/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.90542459e-01f, 4.55143452e-01f, 1.91393182e-01f, -7.41124228e-02f, -1.24518871e-01f, -1.02029800e-01f, -7.15566380e-03f, 4.42135371e-02f, -1.43404782e-01f, 8.01463872e-02f,
  1.02518324e-03f, -5.39161079e-02f, -1.38886303e-01f, 1.06018269e-02f, 6.26994446e-02f, 1.19151799e-02f, 9.75471511e-02f, -3.12684886e-02f, -2.47770116e-01f, -3.07729453e-01f,
  -1.22182168e-01f, -1.53533608e-01f, -7.60212317e-02f, 1.01995384e-02f, 3.88343893e-02f, -1.40686631e-01f, 1.86825022e-01f, 1.13065019e-01f, 7.94053450e-02f, 1.92528278e-01f,
  -2.34929398e-01f, 2.58527070e-01f, -7.26689771e-02f, 3.03423237e-02f, 1.75582156e-01f, 8.20835233e-02f, -3.93573791e-02f, 4.90822308e-02f, 4.84220125e-02f, 3.91449295e-02f,
  -7.00067030e-03f, 1.06535025e-01f, -3.81155945e-02f, 7.53605664e-02f, 1.69032086e-02f, 7.30650574e-02f, 9.50213820e-02f, 9.38363075e-02f, 1.22415438e-01f, -1.48158288e-02f,
  1.48809657e-01f, 7.85772949e-02f, 5.24310470e-02f, 8.96989480e-02f, 9.70502943e-02f, 7.75237083e-02f, 7.89487511e-02f, 1.06321193e-01f, 9.81389172e-03f, 4.02830467e-02f,
  -1.49178624e-01f, 2.76642721e-02f, 2.66816150e-02f, 4.50905673e-02f, -4.74866852e-03f, -3.51878107e-02f, -3.88590470e-02f, -6.67205155e-02f, -5.08366674e-02f, -1.61986873e-02f,
  -1.69034582e-02f, 3.80674587e-03f, 1.93509068e-02f, 2.76124734e-03f, -4.16255137e-03f, -1.42834708e-02f, -1.19213343e-01f, 9.62637141e-02f, 4.97166626e-02f, -3.84905376e-02f,
  5.74786551e-02f, -4.89429832e-02f, -2.69914810e-02f, -6.69329334e-03f, 4.47917245e-02f, 5.62831834e-02f, -3.72199006e-02f, 1.05445264e-02f, 5.20849377e-02f, 7.69920275e-02f,
  -2.19447464e-01f, 1.93864554e-01f, -6.03823997e-02f, 3.29322694e-03f, 4.36750203e-02f, 2.51392797e-02f, 1.19552359e-01f, 1.42436355e-01f, 1.00080833e-01f, 8.75047520e-02f,
  2.24507097e-02f, -2.69120801e-02f, 1.50914639e-01f, 3.33005749e-03f, 1.22956242e-02f, -7.38139302e-02f, 5.39183728e-02f, -7.50721619e-02f, -3.69611047e-02f, -1.88157172e-03f,
  -8.88797455e-03f, -3.19160335e-02f, -1.37206718e-01f, -9.45686246e-04f, -5.65089770e-02f, -1.29398838e-01f, 1.52983656e-02f, -4.31639701e-02f, -1.98930994e-01f, -1.66938916e-01f,
  7.81909406e-01f, -4.90595065e-02f, -1.47323892e-01f, 2.12465882e-01f, -2.98735023e-01f, -3.00930977e-01f, -2.77807862e-01f, -5.03799692e-02f, 2.64325645e-03f, -5.24402782e-02f,
  -2.15423182e-01f, -3.16343643e-02f, -8.54479447e-02f, -1.45983174e-01f, -1.95176467e-01f, -1.46691516e-01f, -2.01581150e-01f, 3.15532163e-02f, -8.30065832e-02f, -2.35113114e-01f,
  -6.66384622e-02f, 1.21452607e-01f, 3.50207001e-01f, 5.19083114e-03f, 5.40465154e-02f, -1.51496679e-01f, -1.17581360e-01f, 9.28444043e-02f, -7.61677101e-02f, 1.16666183e-02f,
  -1.75475910e-01f, 1.44561008e-01f, -2.07042918e-01f, -4.57081981e-02f, -1.18197247e-01f, 1.84291916e-03f, -5.36598936e-02f, -2.52956040e-02f, -1.40924215e-01f, -4.07752395e-02f,
  -5.65134063e-02f, -7.37390965e-02f, 7.65760103e-03f, 1.60714204e-03f, -6.37009814e-02f, 4.65196781e-02f, -4.90127094e-02f, 1.44177387e-02f, -2.33922936e-02f, -1.41382381e-01f,
  -1.98943019e-01f, -7.33043179e-02f, -3.74221392e-02f, -1.84674054e-01f, -1.02455579e-01f, -9.66454819e-02f, -1.76975206e-01f, 7.28431251e-03f, -9.78071764e-02f, 1.19534105e-01f,
  2.00055197e-01f, 1.67662024e-01f, 8.57352689e-02f, 5.68980128e-02f, 6.57169744e-02f, 1.66199170e-02f, 4.23428342e-02f, 9.73001346e-02f, 6.52441084e-02f, 2.25542918e-01f,
  7.28349015e-02f, 2.73350943e-02f, 1.09195836e-01f, 2.14803800e-01f, 3.82175073e-02f, 1.10437870e-01f, 5.96979037e-02f, 1.41315177e-01f, 7.47565255e-02f, 1.55267179e-01f,
  1.21832572e-01f, 1.00646652e-01f, 1.48198828e-01f, 1.25264689e-01f, 4.48467061e-02f, 1.07081272e-01f, 1.21426597e-01f, 4.71023880e-02f, 1.09362751e-01f, 8.92735124e-02f,
  -1.21472597e-01f, -2.58619249e-01f, -9.60636884e-02f, -1.83265597e-01f, -1.24271981e-01f, -9.17974859e-02f, -1.51260510e-01f, -1.35337248e-01f, -1.67131454e-01f, -1.85587451e-01f,
  -1.31389812e-01f, -8.96341130e-02f, -9.38821360e-02f, -1.36112630e-01f, -1.37621403e-01f, -1.41448110e-01f, -1.86411306e-01f, -1.82941005e-01f, -1.93235412e-01f, -1.37412578e-01f,
  -5.81129231e-02f, -1.44830614e-01f, -1.13155425e-01f, -1.98791966e-01f, -1.29676476e-01f, -1.97629139e-01f, -2.27316096e-01f, -1.64118454e-01f, -1.96461007e-01f, -1.75679550e-01f,
  -5.02188981e-01f, 2.36632854e-01f, 1.51502900e-02f, -1.20888881e-01f, 1.90565780e-01f, -3.47604677e-02f, 6.74357414e-02f, -1.37327507e-01f, 6.96571842e-02f, 2.71915078e-01f,
  4.26536761e-02f, -4.44574878e-02f, -3.94286737e-02f, -6.20495118e-02f, -2.44621590e-01f, 1.84445471e-01f, 6.87902123e-02f, -2.15218008e-01f, -3.35721582e-01f, -9.46415067e-02f,
  1.13696925e-01f, 3.52468789e-02f, -1.60926938e-01f, -1.34445205e-01f, 1.51636511e-01f, 7.55739445e-03f, 1.22155517e-01f, 2.43823398e-02f, 6.23217225e-03f, 2.77422935e-01f,
  -5.33587076e-02f, -2.65610427e-01f, -1.64514408e-01f, 6.42736908e-03f, -1.38173290e-02f, -9.67990234e-02f, -2.31748112e-02f, -4.36509028e-02f, -3.78370471e-02f, -8.07421003e-03f,
  -7.51808584e-02f, -9.87450872e-03f, -1.47390559e-01f, -3.86668779e-02f, -6.61708489e-02f, 2.56296229e-02f, -3.55973057e-02f, -1.38440669e-01f, -8.97940621e-02f, -3.11476700e-02f,
  3.97355780e-02f, -4.15737592e-02f, -8.60624537e-02f, -4.94687967e-02f, -1.05259694e-01f, -2.13010192e-01f, -1.72883198e-01f, -1.12049267e-01f, -1.85317174e-01f, 1.29455417e-01f,
  5.03316708e-02f, 7.89171159e-02f, -1.49781574e-02f, 6.97215423e-02f, 4.73482013e-02f, 4.22046855e-02f, 7.81944692e-02f, 1.06636643e-01f, -1.94328325e-03f, 2.63489056e-02f,
  -2.88948114e-03f, 4.66312356e-02f, 4.94625000e-03f, -5.22106402e-02f, 1.00117281e-01f, 1.47035411e-02f, 3.10489498e-02f, 4.25128043e-02f, -4.18722630e-02f, 1.97383165e-02f,
  -5.79428859e-02f, -2.36023553e-02f, 1.98633038e-02f, -3.64769585e-02f, -2.41379179e-02f, 6.22489443e-03f, -2.98385732e-02f, -6.95779920e-02f, -4.67685685e-02f, -4.96196933e-03f,
  4.89492528e-02f, -3.23363543e-01f, -2.08020844e-02f, -1.22518763e-01f, -2.51723789e-02f, -1.23254627e-01f, -1.09253556e-01f, -8.77491906e-02f, -1.73983129e-03f, 6.55138120e-03f,
  -5.87606654e-02f, -2.00429574e-01f, -1.05907731e-01f, -3.78241427e-02f, -5.45294695e-02f, 2.02865861e-02f, -2.05432940e-02f, -1.03193492e-01f, -1.26768991e-01f, 3.80182825e-02f,
  -3.26069146e-02f, -7.04624951e-02f, -5.58373556e-02f, 4.58811410e-02f, -3.34053300e-02f, -1.18824214e-01f, 2.40272824e-02f, 7.85914212e-02f, -1.90911159e-01f, 1.70486182e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.44653738e-01f, 3.96623999e-01f, 4.02708709e-01f, -4.81689006e-01f, 2.32927620e-01f, 2.85960495e-01f, 3.70640457e-01f, -3.48313362e-03f, -1.16959848e-01f, 6.55782521e-02f,
  1.05302118e-01f, -2.01810330e-01f, -2.18724951e-01f, -5.51405139e-02f, 1.05111979e-01f, 3.20833027e-01f, -1.60410732e-03f, -1.18947439e-01f, -1.53981179e-01f, 6.25641942e-02f,
  -3.29046510e-02f, -1.75715849e-01f, -2.18606174e-01f, -4.84816991e-02f, -1.74304008e-01f, -3.90399992e-01f, -3.57780680e-02f, -1.40674964e-01f, 1.70533031e-01f, -1.78978398e-01f,
  -7.68968165e-02f, -3.92388627e-02f, -7.08590299e-02f, -2.80639082e-01f, 2.17338465e-03f, -2.10431322e-01f, 6.50435388e-02f, -1.57878324e-01f, 1.16584681e-01f, 9.88226756e-03f,
  -2.29290519e-02f, 5.97857200e-02f, 2.93600699e-03f, -2.39972189e-01f, -7.20645711e-02f, -1.89999208e-01f, -1.28746137e-01f, -7.43959993e-02f, -8.07214826e-02f, 7.71420300e-02f,
  7.00158551e-02f, 1.58490524e-01f, 5.38686104e-02f, 1.56001598e-01f, 2.64319330e-01f, -7.90201128e-02f, 2.05080345e-01f, -7.19427094e-02f, 1.62995413e-01f, -2.13209614e-01f,
  -9.33364257e-02f, 2.08736919e-02f, 5.42195737e-02f, -7.30349571e-02f, -1.32703513e-01f, -2.11672578e-02f, 1.58539880e-02f, -1.84877887e-01f, 5.16713150e-02f, -1.55888766e-01f,
  -3.74936848e-03f, 6.98260888e-02f, -3.20809148e-02f, 5.20954467e-02f, -2.64988933e-02f, -1.25107795e-01f, 3.41199711e-02f, -2.46877298e-02f, 1.48231648e-02f, 3.39913592e-02f,
  -2.70082653e-02f, -3.88477296e-02f, 6.77510921e-04f, -4.63252142e-02f, 1.12842940e-01f, -4.48272675e-02f, -1.67037698e-03f, 6.19016476e-02f, 7.67592639e-02f, 3.80964316e-02f,
  -5.98534584e-01f, 3.66672009e-01f, -1.75850138e-01f, -1.78026348e-01f, 5.34259423e-04f, -8.83565620e-02f, 7.06904605e-02f, 1.56915486e-01f, 3.15673985e-02f, -9.60189924e-02f,
  2.46272068e-02f, -1.61772221e-01f, 1.26223966e-01f, -2.95132827e-02f, -5.91921099e-02f, -7.68088549e-02f, -1.56800866e-01f, -1.14984818e-01f, 4.43017147e-02f, -5.45047550e-03f,
  -6.03133142e-02f, -6.98468760e-02f, -2.65782863e-01f, -1.93529874e-02f, 5.59937768e-02f, -1.90087393e-01f, -2.74349183e-01f, -3.57508570e-01f, 6.66033104e-02f, -3.53054494e-01f,
  -1.50918484e-01f, 1.01832323e-01f, -1.00377269e-01f, 3.37488115e-01f, 2.82150149e-01f, -1.85340017e-01f, -3.23167443e-01f, -3.60584974e-01f, 2.44445372e-02f, 1.31024271e-01f,
  4.26869303e-01f, 4.55615520e-01f, 2.56561697e-01f, -2.84222458e-02f, -2.15755656e-01f, -6.37623742e-02f, 5.98008409e-02f, -1.75625056e-01f, -2.23484427e-01f, -1.04035117e-01f,
  2.65696377e-01f, 1.87218979e-01f, -2.31760070e-02f, -1.71655864e-01f, 2.48530596e-01f, 1.34993225e-01f, 2.12303251e-02f, 1.34145960e-01f, -5.04915952e-04f, 3.19182396e-01f,
  2.66922355e-01f, 3.69939953e-02f, -3.51715907e-02f, 1.51987940e-01f, 7.68132135e-02f, -2.36700922e-02f, 1.19776754e-02f, 1.24347687e-01f, 4.09391671e-02f, 3.30617838e-02f,
  4.13842112e-01f, 1.57092288e-01f, 1.77708164e-01f, 5.99190518e-02f, -8.63399059e-02f, -1.10045306e-01f, -2.14845896e-01f, -7.07877427e-02f, -1.83693737e-01f, 1.34892136e-01f,
  3.72638851e-01f, 3.28697473e-01f, -4.93725166e-02f, -2.48957649e-01f, -2.33863518e-01f, -3.83065827e-02f, -2.24173740e-01f, -1.56337902e-01f, -4.88935173e-01f, -1.34231150e-01f,
  -5.00279516e-02f, -1.60205200e-01f, -6.60972074e-02f, 1.27732465e-02f, -5.32528944e-03f, 1.26116825e-02f, -4.15634736e-02f, -3.52761969e-02f, -1.53987423e-01f, 2.27332804e-02f,
  -1.07475355e-01f, -8.39115679e-02f, 1.78538449e-02f, -1.04285106e-02f, 5.76734450e-03f, 1.32109523e-02f, -1.39607787e-01f, -1.12181500e-01f, -2.20764540e-02f, 9.85503793e-02f,
  6.80161193e-02f, 1.36311064e-02f, 1.53566077e-01f, -1.88605845e-01f, -8.17736238e-03f, -1.62044168e-01f, -5.82360923e-02f, -7.90266097e-02f, 3.76630835e-02f, 1.93694338e-01f,
  1.96069218e-02f, -2.48098508e-01f, 1.70810252e-01f, -2.27298245e-01f, -1.97093666e-01f, 5.67475371e-02f, 5.71372062e-02f, -9.18236002e-02f, -2.42529977e-02f, -2.47376025e-01f,
  8.14791173e-02f, -1.26796290e-01f, 8.57566297e-02f, -8.67749229e-02f, -1.72445942e-02f, -1.01391621e-01f, -4.54509519e-02f, 9.54413339e-02f, -6.95349798e-02f, 7.70980073e-03f,
  -1.85433507e-01f, -2.26957902e-01f, -8.10361579e-02f, -1.99172616e-01f, 8.19056556e-02f, -1.17591187e-01f, -1.63779065e-01f, -2.52515525e-01f, -2.48961344e-01f, -3.39980394e-01f,
  4.17988956e-01f, 2.51342058e-01f, 3.33156474e-02f, 2.69200027e-01f, 1.87648833e-02f, 3.12868893e-01f, 2.14192733e-01f, 2.43806124e-01f, 3.31492871e-01f, 2.45345101e-01f,
  2.97956556e-01f, 3.66442621e-01f, 2.65524060e-01f, 3.54694426e-01f, 3.25165987e-01f, 2.30155021e-01f, 2.17844173e-01f, 1.31988034e-01f, 6.46409169e-02f, 7.05153346e-02f,
  6.33523464e-02f, -7.72785321e-02f, -6.31824955e-02f, -1.40294479e-02f, 2.41611991e-02f, 2.38589182e-01f, 1.35103941e-01f, -6.94970712e-02f, -2.02435628e-02f, 3.62924971e-02f,
  1.53173804e-02f, 2.62868367e-02f, 1.74835965e-01f, -2.52546114e-03f, 1.27707729e-02f, 5.46346195e-02f, -3.37442383e-02f, -2.60549635e-02f, 3.03196292e-02f, 8.70602727e-02f,
  -6.99397773e-02f, -1.91799372e-01f, -1.78916141e-01f, -3.08689903e-02f, -1.63686126e-01f, -5.12252674e-02f, 4.16680463e-02f, 2.27696046e-01f, 2.19552651e-01f, 1.35613576e-01f,
  -3.83710191e-02f, 1.14551478e-03f, 5.80647513e-02f, 2.11159006e-01f, 1.53984427e-01f, 6.70820326e-02f, 8.64320323e-02f, 1.21712893e-01f, 8.60378742e-02f, 2.43339732e-01f,
  1.54930487e-01f, 1.31682113e-01f, -2.61647347e-02f, -1.06655411e-01f, -6.57995120e-02f, -6.08784668e-02f, -1.05320536e-01f, 5.97844496e-02f, -2.38030814e-02f, -3.01320881e-01f,
  8.44589714e-03f, 6.11560047e-02f, 1.15680635e-01f, -7.66152591e-02f, -3.74540538e-02f, 1.19913006e-02f, 1.25935137e-01f, -4.57010753e-02f, -1.00670017e-01f, -4.29974683e-02f,
  -7.06994906e-02f, 1.09633602e-01f, -1.40117332e-01f, -9.31002083e-04f, 3.58506222e-04f, 1.32376537e-01f, -1.04029067e-02f, 5.18596284e-02f, 7.51759708e-02f, 9.39032249e-03f,
  7.75016770e-02f, -1.76453948e-01f, 3.15174414e-03f, -1.03315987e-01f, -2.17613235e-01f, -2.14648008e-01f, -7.25679100e-02f, -1.54119626e-01f, -1.08371191e-01f, 1.21268056e-01f,
  -9.29926708e-02f, -7.73075446e-02f, -1.68609783e-01f, -1.08589664e-01f, -1.21923082e-01f, -1.61325172e-01f, -1.03787631e-01f, 4.99359295e-02f, 1.29543811e-01f, -4.52483352e-03f,
  -9.88906324e-02f, 1.11735709e-01f, 1.62369028e-01f, -5.38361184e-02f, -3.70971896e-02f, 1.13189369e-02f, -1.53199732e-01f, -9.82428566e-02f, -7.99658522e-03f, -6.96628019e-02f,
  1.26623228e-01f, -4.76577014e-01f, -1.01127252e-01f, 1.11360408e-01f, 1.83308482e-01f, -9.15381163e-02f, -5.33003807e-01f, -4.58032191e-02f, 2.07204416e-01f, -2.41501287e-01f,
  3.85362506e-01f, 4.66625124e-01f, 1.10990055e-01f, 1.03498518e-01f, 3.32811251e-02f, -5.17734766e-01f, -4.09743547e-01f, 4.38630953e-02f, 4.29587513e-01f, 3.47127467e-01f,
  1.48305833e-01f, 1.52944028e-01f, 4.23113346e-01f, 2.07168043e-01f, -1.64407760e-01f, 7.48323575e-02f, -2.47175992e-01f, -1.27398714e-01f, -1.38248384e-01f, -4.90743905e-01f,
  2.41698474e-02f, -3.81501675e-01f, 1.12212531e-01f, 2.15197504e-01f, 1.34605080e-01f, -6.40383884e-02f, -5.78075834e-02f, -8.63516703e-02f, -7.05521777e-02f, -6.69578016e-02f,
  -4.42904048e-02f, 1.48129404e-01f, 1.69290192e-02f, 4.34335954e-02f, -1.64482649e-02f, -1.07962163e-02f, 3.22035477e-02f, -8.71010125e-02f, -6.10493869e-02f, -1.92530509e-02f,
  -2.54602522e-01f, -1.92291573e-01f, -1.12550184e-01f, -1.29473478e-01f, -8.32831338e-02f, 1.57303736e-01f, -3.10519524e-02f, -1.93249628e-01f, -2.74769723e-01f, -5.62831283e-01f,
  -3.60376835e-02f, -7.12652877e-02f, 1.56733692e-02f, -7.12929070e-02f, 6.59623444e-02f, -3.03607751e-02f, -1.28405690e-01f, 2.20924914e-02f, 6.45851493e-02f, -1.27241284e-01f,
  -5.75812869e-02f, 1.01866268e-01f, 6.91854507e-02f, -1.35287330e-01f, 9.84129906e-02f, -7.66224638e-02f, -1.33751854e-01f, -9.13239717e-02f, 9.30424556e-02f, -2.70909294e-02f,
  8.46585259e-02f, -9.26464573e-02f, 4.99648489e-02f, 6.65519908e-02f, 4.43130098e-02f, 5.00977635e-02f, 3.67917493e-02f, 1.20402597e-01f, 1.25650121e-02f, 5.00215031e-02f,
  1.46221340e-01f, 4.20787223e-02f, -1.19021289e-01f, 4.00590375e-02f, -2.40572169e-02f, 2.45827679e-02f, -2.21538007e-01f, 1.10065974e-01f, 1.00388348e-01f, 7.76800439e-02f,
  -2.80144271e-02f, -1.26863234e-02f, -3.50192711e-02f, -7.17591420e-02f, 1.20734721e-01f, -3.98000628e-02f, 7.57505372e-02f, -4.89569753e-02f, -6.76356852e-02f, 4.33985591e-02f,
  -1.26825258e-01f, -2.80402631e-01f, -7.00375140e-02f, -2.28959993e-01f, -8.13344792e-02f, 7.25590959e-02f, -1.42527372e-01f, -1.30298257e-01f, -1.41975760e-01f, -3.48981053e-01f,
  -2.61649638e-01f, -2.47749984e-01f, -1.64548740e-01f, 1.87760949e-01f, 1.90901365e-02f, -2.63865322e-01f, -5.04327357e-01f, -4.18294251e-01f, 4.39491756e-02f, 2.69332225e-03f,
  1.38847500e-01f, 1.87982440e-01f, 3.33886370e-02f, 4.12756950e-02f, -3.04938644e-01f, -2.27664858e-01f, -2.40463112e-02f, -6.29519150e-02f, -4.70426790e-02f, 9.43192616e-02f,
  2.03600973e-01f, 3.46144140e-01f, 1.73577100e-01f, -8.54785834e-03f, 2.39023477e-01f, 2.75650620e-01f, 2.98799872e-01f, 3.40174526e-01f, 1.84324488e-01f, 2.38342032e-01f,
  8.79359394e-02f, -1.78136438e-01f, 5.48877381e-02f, 8.60448480e-02f, 1.92406476e-01f, -6.57892646e-03f, -1.68186814e-01f, -2.51502395e-01f, -1.82665721e-01f, -1.15938984e-01f,
  -4.91512269e-02f, -1.60143837e-01f, 1.83031056e-02f, 1.47512637e-03f, -6.18296005e-02f, -1.15199380e-01f, -2.80113723e-02f, -8.89702737e-02f, 4.53840233e-02f, -1.78099066e-01f,
  3.64550978e-01f, 1.26914680e-01f, -7.26242289e-02f, -1.25172764e-01f, -2.41045505e-01f, 1.76745966e-01f, -2.18654469e-01f, -9.27010775e-02f, -1.46374643e-01f, -9.25140083e-02f,
  7.35169090e-03f, 3.54087236e-03f, 3.18014100e-02f, 4.71529774e-02f, -2.13816874e-02f, 1.04842216e-01f, -6.02379069e-02f, -1.65667281e-01f, -9.46036801e-02f, 5.14978617e-02f,
  -1.91739365e-01f, 6.86818212e-02f, 4.87471232e-03f, 1.23188034e-01f, 1.12015434e-01f, 4.74760216e-03f, 3.68264243e-02f, 8.15150291e-02f, 7.35219866e-02f, -1.34448558e-01f,
  -6.70105545e-03f, -7.80297741e-02f, 9.23441350e-02f, -8.62269104e-02f, 4.32186499e-02f, -7.02846423e-02f, -1.53670162e-02f, -8.82178545e-02f, 9.05294903e-03f, -1.65191125e-02f,
  2.24893376e-01f, 3.87878232e-02f, 1.68036580e-01f, -1.37304395e-01f, 1.30442381e-01f, 1.07806705e-01f, 1.35254949e-01f, -2.02485412e-01f, -9.48064402e-02f, -2.17792779e-01f,
  -2.24875078e-01f, -2.14079484e-01f, 4.34845798e-02f, -1.73838362e-01f, -1.21456206e-01f, 1.87273417e-03f, 1.69778854e-01f, -4.32284927e-04f, 1.19369961e-01f, -1.06121629e-01f,
  4.42559533e-02f, 5.56860045e-02f, 1.32147238e-01f, -1.43732816e-01f, 9.63819623e-02f, 1.17401488e-01f, -2.79559698e-02f, -1.33827880e-01f, -7.53351897e-02f, -5.90887628e-02f,
  -7.52947748e-01f, 2.17246637e-01f, -1.38331056e-01f, -5.01470327e-01f, 1.44082591e-01f, 7.29628801e-02f, 3.53160053e-01f, 9.39403195e-03f, 1.00983270e-01f, 4.01803017e-01f,
  2.38476634e-01f, -6.83422685e-02f, 1.72045738e-01f, 1.13973543e-01f, 5.50182760e-02f, 1.82618573e-01f, 6.60744607e-02f, -1.97205454e-01f, -2.52942592e-01f, -6.25822991e-02f,
  1.55506358e-01f, -7.10617676e-02f, -3.98610026e-01f, -1.02443218e-01f, -2.31420733e-02f, -9.08366367e-02f, 1.04917027e-01f, -1.86628997e-01f, 1.26662910e-01f, -2.39423923e-02f,
  -2.15765730e-01f, -4.19230670e-01f, 1.44601271e-01f, 9.77256596e-02f, -1.20432407e-01f, -1.86106429e-01f, -6.01688623e-02f, -1.73491895e-01f, 9.85712260e-02f, 8.95455778e-02f,
  -4.93432060e-02f, 1.37181327e-01f, -5.83735406e-02f, 2.58179195e-02f, -3.11455190e-01f, -2.79870570e-01f, -3.82896401e-02f, -4.07205135e-01f, -2.57400721e-01f, -4.60992843e-01f,
  5.86654581e-02f, -8.21323097e-02f, -3.86438727e-01f, -1.57086000e-01f, -1.36808366e-01f, -2.15717405e-01f, -1.77237198e-01f, -2.58382142e-01f, -3.73164296e-01f, -3.54419768e-01f,
  1.34010419e-01f, -1.93997268e-02f, -4.36673835e-02f, 1.06136370e-02f, 3.76860553e-04f, 2.09431276e-02f, -4.23190035e-02f, 5.37305884e-02f, -3.90382633e-02f, -5.81622822e-03f,
  -3.86841712e-03f, 6.00066110e-02f, -4.84085875e-03f, -1.30929649e-01f, -8.14751461e-02f, 1.41211301e-02f, 1.33849218e-01f, 6.38591349e-02f, -5.39930426e-02f, -2.26918142e-02f,
  -1.63933150e-02f, -1.98777001e-02f, 1.45889848e-01f, 4.11026664e-02f, 1.38021573e-01f, 7.06629157e-02f, 2.74827302e-01f, 1.84864588e-02f, -6.31640628e-02f, 1.91359505e-01f,
  -2.04708189e-01f, 2.53731400e-01f, 4.69267629e-02f, 1.26945689e-01f, 6.14505373e-02f, -4.39250702e-03f, -1.03258295e-02f, 1.11745253e-01f, 1.09874621e-01f, -1.70991160e-02f,
  -7.96867087e-02f, -6.77177981e-02f, 3.38871442e-02f, -6.52605621e-03f, -8.07657465e-03f, -4.63531390e-02f, 2.02388376e-01f, -1.69633552e-01f, -4.70542684e-02f, -2.67300248e-01f,
  -7.75172785e-02f, 4.24321629e-02f, -2.93968678e-01f, -1.52713105e-01f, -9.17418525e-02f, -3.93222123e-02f, 2.78594512e-02f, -1.19939521e-01f, -9.16998386e-02f, -3.68706137e-02f,
  -1.04723871e-01f, -4.87828463e-01f, -3.32222939e-01f, -3.51487428e-01f, -5.15736341e-01f, -1.45012081e-01f, -3.94419819e-01f, -3.93882804e-02f, -4.23718616e-02f, -4.66331303e-01f,
  -2.22262710e-01f, 1.50353342e-01f, -5.54183759e-02f, 2.13058125e-02f, 1.06680550e-01f, -5.12641728e-01f, -3.86188358e-01f, -7.76448026e-02f, 1.81751013e-01f, -4.60852720e-02f,
  -3.35470796e-01f, -3.86523306e-01f, 3.52741182e-02f, -8.89207423e-02f, -3.67997915e-01f, -1.24059185e-01f, -2.18520105e-01f, -5.23699075e-02f, 5.40034333e-03f, -5.14968693e-01f,
  -1.39964640e-01f, 7.45893642e-02f, 2.15311140e-01f, 1.63137242e-01f, -5.15152812e-02f, 1.79086104e-01f, 4.30767126e-02f, 7.77490139e-02f, 5.24567552e-02f, 4.62168567e-02f,
  2.85158567e-02f, 2.32145116e-02f, 1.34365723e-01f, 1.30698502e-01f, 3.01007628e-02f, 3.85845639e-02f, 7.87062347e-02f, 6.99344948e-02f, -2.24870108e-02f, -1.53516054e-01f,
  9.63642169e-03f, 1.45651788e-01f, 2.04826906e-01f, 1.95571363e-01f, 2.56346703e-01f, 1.76921964e-01f, 1.39521822e-01f, 3.29480737e-01f, 2.69413114e-01f, 2.26126701e-01f,
  3.09288241e-02f, -2.03289352e-02f, 1.61215588e-02f, 1.20823562e-01f, 1.20135516e-01f, 8.95828474e-03f, 7.46906642e-03f, -3.52026671e-02f, 3.47062461e-02f, 5.22165149e-02f,
  -7.50552639e-02f, -1.19755901e-02f, 5.95283322e-02f, -2.40550488e-02f, 4.57058251e-02f, 1.67317148e-02f, 1.55592291e-02f, 3.87804583e-02f, 1.84355155e-01f, 9.44346189e-02f,
  5.90301640e-02f, 1.27774507e-01f, -9.81528461e-02f, 5.91252930e-02f, -8.28640908e-02f, 3.56861129e-02f, 1.37705607e-02f, 1.19102322e-01f, 3.77885513e-02f, -1.19501851e-01f,
  -4.91009280e-02f, 2.34242737e-01f, -1.91573232e-01f, -2.42109299e-02f, -4.09700349e-02f, -3.21114101e-02f, -8.03672224e-02f, 4.03594002e-02f, -5.58550954e-02f, -1.44696221e-01f,
  -1.24469623e-02f, -1.13915019e-01f, 5.15450351e-02f, -3.02147325e-02f, -4.75330800e-02f, 1.28671810e-01f, 4.39737961e-02f, -1.67188779e-01f, 4.64540124e-02f, -1.08936369e-01f,
  4.97581959e-02f, 4.43050601e-02f, 1.56031579e-01f, 1.08175866e-01f, 6.96230158e-02f, 7.89053589e-02f, -1.29827052e-01f, 1.60082638e-01f, 1.35575637e-01f, -6.91417977e-03f,
  3.82265568e-01f, -5.10592341e-01f, 2.45185405e-01f, 1.39856726e-01f, 3.38591188e-01f, 4.46315557e-01f, 3.54882270e-01f, 1.05017744e-01f, -5.24502806e-02f, -4.77598011e-02f,
  -2.88496763e-01f, -5.22136092e-01f, -3.68783146e-01f, -3.14241022e-01f, -2.53178984e-01f, 1.26389030e-03f, 2.00711921e-01f, 9.38465148e-02f, 2.98028797e-01f, 2.27537781e-01f,
  -2.38715690e-02f, 1.83776006e-01f, 7.81367570e-02f, -1.59442738e-01f, -1.60996467e-01f, 3.05617098e-02f, -1.29122272e-01f, 1.40819907e-01f, -1.34932294e-01f, -2.98576534e-01f,
  -2.98548549e-01f, -2.07247958e-02f, 4.87899743e-02f, -3.16815853e-01f, 2.96889432e-02f, 2.99750529e-02f, 6.39039874e-02f, -1.01303849e-02f, 2.39827763e-02f, -8.23967531e-03f,
  -1.08802654e-01f, -3.58926505e-02f, -5.34272604e-02f, -1.18368126e-01f, 1.13534071e-01f, -3.96171920e-02f, -7.59702548e-02f, -1.00308023e-02f, -1.86333627e-01f, -1.94191590e-01f,
  -2.68397838e-01f, 6.49942234e-02f, 1.84319019e-01f, 5.72204441e-02f, -1.56606257e-01f, 6.08748384e-02f, -2.03537233e-02f, -8.88110697e-02f, -1.57587044e-02f, 1.04313809e-02f,
  4.17640433e-02f, -7.24571720e-02f, -4.42047529e-02f, -6.71801642e-02f, -5.62391579e-02f, 2.46324465e-02f, 7.68856481e-02f, -5.52897863e-02f, -3.54794562e-02f, -7.45707331e-03f,
  7.88112953e-02f, -1.23216450e-01f, -1.10748716e-01f, 5.21415100e-02f, -1.91998273e-01f, -1.37869313e-01f, -3.58208232e-02f, -1.87433735e-01f, -1.15643822e-01f, -3.24589610e-02f,
  -1.09986454e-01f, -4.86745127e-02f, -6.74159229e-02f, -3.87852937e-02f, -1.09285757e-01f, -1.56504944e-01f, -7.10039511e-02f, -1.11633874e-01f, -5.03856689e-02f, 1.67954434e-02f,
  -3.08573276e-01f, 1.11504294e-01f, 9.67439935e-02f, -1.74315184e-01f, -5.74033009e-03f, -1.18562773e-01f, -1.59222543e-01f, -4.40465659e-02f, 7.09725870e-03f, 5.16436882e-02f,
  -1.59399286e-02f, -1.43223405e-01f, -7.90972486e-02f, -4.43798341e-02f, 1.22671925e-01f, 4.12008017e-02f, -1.10947937e-01f, 7.12992996e-02f, -6.60223439e-02f, -3.21766324e-02f,
  -2.52046317e-01f, 1.59762338e-01f, 1.79537192e-01f, 9.55774635e-03f, 1.09098949e-01f, 1.97013229e-01f, 9.24571976e-02f, 8.25115517e-02f, 2.92566240e-01f, 3.26625943e-01f,
  -8.13693941e-01f, -9.89927948e-02f, 4.23567832e-01f, -1.55197412e-01f, 1.40804216e-01f, 1.97631091e-01f, 3.40292484e-01f, -4.97932211e-02f, -1.70500308e-01f, 2.02448726e-01f,
  -5.94387352e-02f, -3.44846040e-01f, -2.77373046e-01f, -2.13652924e-01f, -1.73305646e-01f, 3.89627248e-01f, 2.95722961e-01f, -7.20492676e-02f, -1.55147791e-01f, -9.39401463e-02f,
  -1.42142296e-01f, -1.67138010e-01f, -2.98029900e-01f, -2.45803326e-01f, -3.41111538e-03f, -1.73404709e-01f, 1.63159564e-01f, -7.21414611e-02f, -1.27753168e-01f, -6.96884170e-02f,
  3.63565207e-01f, 5.27980961e-02f, 8.27163979e-02f, -2.42146298e-01f, 2.21042875e-02f, -1.05627559e-01f, -5.43793254e-02f, 9.40618068e-02f, -1.88587740e-01f, -1.14024788e-01f,
  -1.00551032e-01f, -6.35278672e-02f, -1.18983738e-01f, 5.61311841e-02f, 4.42462973e-02f, -1.66949034e-01f, -1.21907882e-01f, -5.65904379e-02f, -4.85497303e-02f, -9.96864289e-02f,
  -2.05566451e-01f, -1.76772520e-01f, 9.35090408e-02f, -3.21326405e-02f, -4.88761887e-02f, -1.04835689e-01f, -3.89252566e-02f, -1.20000221e-01f, -1.22141398e-01f, 4.27846722e-02f,
  -6.16847575e-02f, -9.13679525e-02f, 6.35842457e-02f, 1.05452649e-01f, -1.34030625e-01f, 4.22038734e-02f, 4.99101393e-02f, 1.86535940e-02f, 2.06195028e-03f, -1.12163328e-01f,
  -2.81374287e-02f, 6.53984472e-02f, 5.08835986e-02f, 2.75145359e-02f, 1.11214846e-01f, 6.91173424e-04f, 3.04422658e-02f, 6.29551336e-02f, 4.76367809e-02f, 7.96577632e-02f,
  -9.53797549e-02f, 1.31376386e-01f, 9.78213623e-02f, 5.93990237e-02f, 9.87459533e-03f, 1.25449104e-03f, 2.45300308e-02f, -1.09261043e-01f, -4.21212092e-02f, -2.02930849e-02f,
  1.68948814e-01f, 5.18393442e-02f, 2.39847228e-01f, -7.85618126e-02f, 5.51350936e-02f, -4.13790122e-02f, -1.73179023e-02f, 2.17712577e-02f, -5.04929088e-02f, 2.22479142e-02f,
  -1.88993335e-01f, -3.12444996e-02f, 6.94352016e-02f, 3.85597683e-02f, 2.52050050e-02f, 1.67178921e-02f, -7.35715264e-03f, 3.61768762e-03f, 6.48652762e-02f, 3.13441046e-02f,
  -7.52780512e-02f, 8.86757672e-02f, 1.12379879e-01f, 1.18628643e-01f, 3.54460441e-02f, 1.33946970e-01f, 2.07670525e-01f, 1.09889060e-01f, 7.39820525e-02f, 3.70628566e-01f,
  4.19941843e-02f, -9.03604850e-02f, 3.38596404e-01f, 3.35128546e-01f, -3.14918697e-01f, -8.39023069e-02f, -4.97855693e-02f, 2.45723292e-01f, 2.28496015e-01f, 1.12933964e-01f,
  -3.44341576e-01f, 1.51982866e-02f, 2.13839650e-01f, 2.97652334e-01f, 2.56583959e-01f, 9.96903032e-02f, 3.28127474e-01f, 4.20295358e-01f, 3.50850254e-01f, -1.24865281e-03f,
  -2.28936225e-03f, 1.56991541e-01f, 3.17524314e-01f, 2.19476223e-01f, -1.92429386e-02f, 4.00995649e-02f, 1.01680182e-01f, -1.46878406e-01f, -3.39936838e-02f, 2.75625229e-01f,
  -2.71281183e-01f, 8.49226415e-02f, -1.72288403e-01f, -2.71970570e-01f, -2.54049748e-01f, 2.37007052e-01f, -1.00408562e-01f, -2.22558066e-01f, -1.02314822e-01f, 1.35266408e-01f,
  -9.07104611e-02f, -1.47069748e-02f, -6.59368485e-02f, -2.67557538e-04f, -4.15746979e-02f, -2.68245675e-03f, 3.01114507e-02f, 9.88864154e-02f, 2.82450408e-01f, -3.89821120e-02f,
  -2.48494938e-01f, -5.29871762e-01f, -4.07014787e-01f, -1.25828505e-01f, 4.58368361e-02f, -1.25761956e-01f, -9.32758898e-02f, -1.59661010e-01f, 7.34219775e-02f, -7.36858323e-03f,
  -1.19381323e-01f, -2.00605333e-01f, -2.12232560e-01f, 6.60667419e-02f, 4.14881296e-02f, -1.07769843e-03f, 3.05682886e-02f, -3.09383124e-02f, -1.98203735e-02f, -2.39664108e-01f,
  1.37307569e-01f, -9.24339984e-03f, 7.91718438e-03f, -3.90530787e-02f, 9.48492717e-03f, -3.65848211e-03f, -2.47517992e-02f, -1.18108112e-02f, -5.69753721e-02f, 8.79548192e-02f,
  -9.47402295e-05f, -5.11944592e-02f, 7.10012913e-02f, 1.11263514e-01f, 1.08233638e-01f, 5.24928309e-02f, -1.16197973e-01f, 7.07425922e-02f, -3.20506692e-02f, -9.91133749e-02f,
  1.22722678e-01f, -4.55449708e-02f, -1.17359474e-01f, -7.73738176e-02f, -1.67751253e-01f, 3.61920185e-02f, -8.29829499e-02f, -1.24225050e-01f, 3.53017859e-02f, 7.89374933e-02f,
  5.38012795e-02f, -4.76521254e-02f, -1.30691808e-02f, -5.29839955e-02f, 2.37062462e-02f, 5.97011782e-02f, -8.52017477e-02f, -1.43709928e-01f, -3.90408821e-02f, -2.49520853e-01f,
  8.20602253e-02f, -2.15904340e-01f, -2.38837764e-01f, -1.09733284e-01f, -3.13183218e-01f, -2.35510156e-01f, -1.65170416e-01f, -2.85339653e-01f, -1.15906321e-01f, 6.61521219e-03f,
  -3.10625173e-02f, -5.10888636e-01f, -2.14121863e-01f, -1.11388303e-01f, -1.51571378e-01f, -5.43230847e-02f, -4.39594001e-01f, -1.88660890e-01f, 6.72975034e-02f, -5.93886614e-01f,
  -2.28995547e-01f, 3.83684002e-02f, -1.51552305e-01f, -8.15203637e-02f, 1.65223271e-01f, -3.45989525e-01f, -3.34356010e-01f, 1.07939377e-01f, 4.41204995e-01f, 2.15429589e-01f,
  -8.17792024e-03f, 1.19711105e-02f, 2.73334593e-01f, 1.40914127e-01f, -4.02045995e-01f, -5.63304611e-02f, -3.50105226e-01f, -6.36583865e-02f, -1.32110730e-01f, -5.43120086e-01f,
  -2.14244723e-01f, -1.61004558e-01f, 1.60136685e-01f, 1.44892447e-02f, -2.43990764e-01f, 5.73561266e-02f, 1.20015115e-01f, -7.29815364e-02f, -7.30248019e-02f, -4.27564047e-02f,
  -6.34939447e-02f, -1.25290360e-02f, -8.07692260e-02f, 6.71524853e-02f, 8.95631388e-02f, -3.55159044e-02f, -1.07502170e-01f, 2.27987126e-01f, 1.84452966e-01f, -3.98975238e-03f,
  -1.46602437e-01f, -4.84721661e-02f, 1.43855736e-01f, 1.54676512e-01f, 1.28582016e-01f, 8.50190222e-02f, -1.48053512e-01f, 1.26769736e-01f, -3.32782939e-02f, -5.30165493e-01f,
  -7.30588809e-02f, -7.17079043e-02f, 3.04910680e-03f, -9.72662400e-03f, -2.14024149e-02f, -6.83677047e-02f, 9.54913944e-02f, -3.63507196e-02f, -1.30714132e-02f, -9.77469608e-03f,
  -1.78440772e-02f, -1.28896102e-01f, 8.16285685e-02f, -1.62670352e-02f, -1.19949384e-02f, 9.11188498e-02f, -2.97154672e-02f, -7.49053210e-02f, -1.02793537e-02f, 9.48378642e-04f,
  1.08058780e-01f, 1.03895798e-01f, -5.25970720e-02f, 9.75983664e-02f, -1.73509985e-01f, -1.23311266e-01f, -3.38509455e-02f, -2.52358541e-02f, -9.36410949e-02f, 7.49241859e-02f,
  5.38440347e-02f, 3.18684429e-01f, -1.68077916e-01f, -2.40288209e-02f, -1.67938828e-01f, -1.41895711e-01f, 6.35992177e-03f, 9.06751864e-03f, -4.32543419e-02f, -2.77928948e-01f,
  1.44840181e-02f, -5.35332523e-02f, 1.33060559e-03f, 4.28277999e-02f, 1.01179304e-02f, 6.75820336e-02f, -9.37029496e-02f, 4.02265936e-02f, 8.65465626e-02f, -4.68205884e-02f,
  -5.04106879e-02f, -5.26605286e-02f, 4.73986119e-02f, -4.65476289e-02f, -1.47568733e-01f, -3.49713303e-02f, -2.31551006e-01f, -9.77476314e-02f, -9.52188894e-02f, -5.09900928e-01f,
  -5.08447051e-01f, -2.89231896e-01f, -3.21397185e-01f, -7.21407592e-01f, -2.90279686e-01f, 1.23294093e-01f, 1.90355405e-01f, 2.48514917e-02f, -2.06599087e-01f, -1.94452688e-01f,
  1.09607704e-01f, 2.65214890e-01f, 1.20285138e-01f, 1.66611254e-01f, 4.65871364e-01f, -6.39614612e-02f, -1.82456642e-01f, 3.42835821e-02f, 3.14020813e-01f, 3.57213378e-01f,
  2.95897853e-02f, -2.17825964e-01f, -2.63683021e-01f, -5.57570299e-03f, -3.04261833e-01f, -1.56714991e-01f, -3.57816696e-01f, -2.98216760e-01f, 2.03725725e-01f, -2.72867650e-01f,
  3.58816087e-02f, -1.53474838e-01f, 1.84700087e-01f, -4.72657336e-03f, -2.06610918e-01f, -3.88189368e-02f, -2.04660669e-02f, -3.24099362e-01f, -1.06630981e-01f, -1.21480018e-01f,
  -1.50567293e-01f, -6.57672882e-02f, -1.20746501e-01f, -3.48111130e-02f, -3.23900491e-01f, -2.46320851e-02f, -2.29051888e-01f, -2.04603430e-02f, 6.08398505e-02f, 1.62339449e-01f,
  3.42785642e-02f, 4.53638211e-02f, -4.62342612e-02f, 3.06877550e-02f, 2.77765002e-02f, 8.76025930e-02f, 3.45263332e-02f, 1.42151892e-01f, 2.60423779e-01f, -4.62151803e-02f,
  -8.81915987e-02f, -1.90599337e-02f, -4.42815013e-03f, 7.49748945e-02f, 1.06917821e-01f, 1.69481728e-02f, -5.07913046e-02f, -1.12505421e-01f, -3.72440107e-02f, -8.81442875e-02f,
  4.39006537e-02f, 6.86734915e-02f, 3.07150092e-02f, -2.89579462e-02f, 9.77719426e-02f, -4.40756641e-02f, 1.03859894e-01f, -4.38497998e-02f, 1.96678191e-02f, -7.36730918e-02f,
  -6.88189408e-03f, 5.99525357e-03f, -1.51592314e-01f, 3.99798118e-02f, 1.52626289e-02f, 2.85711102e-02f, 6.21210076e-02f, 1.29675910e-01f, -6.42619282e-02f, 8.73665661e-02f,
  -3.98134261e-01f, 2.64519602e-01f, -1.12963974e-01f, 6.16198480e-02f, -6.58864677e-02f, -6.74841404e-02f, -1.33533940e-01f, -1.41600534e-01f, -6.71334639e-02f, -5.11743799e-02f,
  -2.29618810e-02f, -2.71836091e-02f, -2.08694339e-01f, -7.25624189e-02f, 1.98034775e-02f, 8.21708217e-02f, 7.77635723e-02f, -2.27554869e-02f, 1.28156841e-01f, 5.98523440e-03f,
  3.80616933e-02f, 1.54188648e-01f, 4.98552211e-02f, 8.85300562e-02f, 9.48566943e-02f, 2.05364436e-01f, 1.32699504e-01f, 1.35708436e-01f, 2.38096535e-01f, -1.37126401e-01f,
  -2.09718332e-01f, 2.00757727e-01f, 3.39716524e-01f, -3.66617471e-01f, 2.19197839e-01f, 3.12906832e-01f, 4.48799610e-01f, 2.28158325e-01f, -1.49285212e-01f, -7.74451792e-02f,
  2.78012574e-01f, -8.00881013e-02f, -3.50773156e-01f, -9.75209381e-03f, -1.46901663e-02f, -5.66965491e-02f, -2.51372904e-01f, -2.14007214e-01f, 8.26516822e-02f, 2.44147748e-01f,
  -3.92548330e-02f, -1.60919368e-01f, -4.43499088e-02f, -1.46485552e-01f, -2.70520329e-01f, -4.21194732e-01f, -1.50528714e-01f, -1.34525046e-01f, 1.24223195e-01f, -5.53506315e-01f,
  9.48044881e-02f, 2.37383798e-01f, 1.82367601e-02f, -1.10890575e-01f, 5.15217707e-02f, -1.15044259e-01f, -5.57643026e-02f, -1.82207555e-01f, 6.64066300e-02f, -5.27220890e-02f,
  3.63501720e-02f, 7.35351890e-02f, -9.22496095e-02f, 1.31677091e-02f, 1.89287931e-01f, 4.25383747e-02f, 6.52901828e-02f, -2.57334579e-02f, -8.10586959e-02f, 1.31057665e-01f,
  -1.36630014e-01f, 1.40422896e-01f, 1.00596383e-01f, 1.88768297e-01f, 3.82540189e-03f, -1.13124378e-01f, 2.80289680e-01f, 1.22852385e-01f, 7.85651952e-02f, -3.16623598e-01f,
  -5.03420904e-02f, -8.42881054e-02f, 5.33253476e-02f, -1.11371372e-02f, 8.08811411e-02f, -4.22474090e-03f, -3.85997593e-02f, -1.45230293e-02f, -6.95279911e-02f, 4.83338609e-02f,
  1.44412354e-01f, 1.52428625e-02f, 4.46872525e-02f, -8.83695185e-02f, -1.39002120e-02f, 1.71278808e-02f, -3.44197229e-02f, 3.02708279e-02f, 3.51400748e-02f, -1.54278139e-02f,
  -1.32935373e-02f, 1.09129231e-02f, -5.07363910e-03f, -9.75057483e-02f, -2.46162750e-02f, -1.05913850e-02f, 1.33255180e-02f, -1.32891415e-02f, 9.16610733e-02f, 1.40187472e-01f,
  -2.85952210e-01f, 2.11748660e-01f, -2.77318686e-01f, 1.39044032e-01f, 6.79839104e-02f, 9.49999131e-03f, -7.38485381e-02f, 4.41314913e-02f, -3.00984327e-02f, 7.00109527e-02f,
  9.41393524e-02f, 1.13149531e-01f, -4.61511798e-02f, 1.50553688e-01f, 2.45933328e-02f, 4.78575639e-02f, 7.22907782e-02f, -9.35465172e-02f, -3.78353111e-02f, 4.86855693e-02f,
  -1.00101620e-01f, -1.51021272e-01f, -7.68111497e-02f, -1.16360418e-01f, -1.86080366e-01f, -1.87977403e-01f, -2.42371857e-01f, -2.17293113e-01f, -1.69466406e-01f, -3.98272365e-01f,
  4.17754650e-01f, 3.20550323e-01f, 3.45090330e-01f, 7.01919720e-02f, 2.82740742e-01f, 1.53448852e-02f, 1.08136004e-02f, -5.56445830e-02f, -1.67031944e-01f, 1.86835960e-01f,
  2.75328517e-01f, 2.72547770e-02f, -8.36998224e-02f, -9.22391042e-02f, -1.28850639e-01f, -2.10662648e-01f, -1.05579905e-01f, -4.01968993e-02f, -4.10337001e-02f, 2.99111716e-02f,
  -7.76966512e-02f, 5.22835888e-02f, 1.43172100e-01f, -4.32077162e-02f, 2.77998328e-01f, 7.04666302e-02f, 1.54463679e-01f, 3.74461621e-01f, 1.76783517e-01f, 1.81313232e-01f,
  3.13377619e-01f, 3.21765989e-01f, -3.20210367e-01f, 1.37926787e-01f, 2.12262660e-01f, -7.18304962e-02f, 6.50025904e-02f, -8.36645290e-02f, 8.09134021e-02f, -1.02447793e-02f,
  2.28683069e-01f, 2.11238384e-01f, 1.73463583e-01f, 1.06605530e-01f, 9.60214064e-02f, 5.54551370e-02f, 8.16162974e-02f, -3.86569872e-02f, -1.68812811e-01f, 9.55955833e-02f,
  5.75091280e-02f, 1.89079672e-01f, 1.15875967e-01f, -4.00912203e-02f, 1.89947747e-02f, 1.55196816e-01f, 2.24852741e-01f, 2.21335679e-01f, 2.16616496e-01f, 6.45862073e-02f,
  -1.21357679e-01f, -6.93545640e-02f, 1.11211918e-01f, 4.18171585e-02f, -1.39991064e-02f, -1.52169630e-01f, -7.57046118e-02f, 2.07208376e-02f, 2.77361460e-02f, 1.38447523e-01f,
  -5.06281704e-02f, -1.22526623e-02f, -3.05522494e-02f, -8.99961442e-02f, 1.86831728e-01f, 2.12516949e-01f, 2.44178355e-01f, 1.15459464e-01f, 1.76672325e-01f, 9.97008458e-02f,
  1.37806028e-01f, 5.01748286e-02f, 1.14037402e-01f, 7.81467780e-02f, 7.31831789e-02f, 1.37485847e-01f, 1.82105437e-01f, 1.33544907e-01f, 1.26263052e-01f, -2.84908600e-02f,
  -8.62849951e-02f, 1.30013511e-01f, -1.24040261e-01f, -5.80831431e-02f, -3.82448211e-02f, 7.71249831e-02f, 1.11424908e-01f, -1.19321190e-01f, 9.66178700e-02f, -5.18240519e-02f,
  2.06832178e-02f, -8.97075534e-02f, -1.16637968e-01f, -1.51858171e-02f, -7.73973912e-02f, 6.67067692e-02f, -2.34754737e-02f, -1.56800434e-01f, -1.63847402e-01f, 3.52326632e-02f,
  -2.06927523e-01f, -1.70330331e-01f, -1.85654297e-01f, -2.66005635e-01f, -1.66892648e-01f, -6.49286285e-02f, -1.77865326e-02f, -8.02952424e-02f, -4.57846895e-02f, -1.40798330e-01f,
  -2.74816185e-01f, 5.26235759e-01f, -7.99918771e-02f, 8.28065202e-02f, 3.69460523e-01f, 2.40895897e-01f, 3.49787623e-01f, -4.42257375e-02f, -2.34742522e-01f, 1.38056427e-01f,
  7.34883845e-02f, -1.16846882e-01f, -3.88702266e-02f, -7.66061321e-02f, 5.73303960e-02f, 2.13946208e-01f, 2.16160864e-01f, -5.96992075e-02f, -2.96979189e-01f, -5.19711673e-02f,
  1.10982142e-01f, -1.27495959e-01f, -4.08679128e-01f, -8.71883705e-02f, 2.66346961e-01f, -7.93354884e-02f, -8.32125098e-02f, 1.44945353e-01f, 3.38072270e-01f, 4.79581416e-01f,
  4.42693792e-02f, 1.26751453e-01f, -1.76321775e-01f, 2.35363409e-01f, 1.96646735e-01f, -1.01805381e-01f, -1.58923373e-01f, -5.00907674e-02f, -8.42891484e-02f, -2.01386645e-01f,
  1.49148747e-01f, 1.23603351e-01f, 2.75004417e-01f, -2.31010243e-02f, -1.71976805e-01f, -1.45825997e-01f, -2.28269324e-01f, -3.28473747e-01f, -2.45330900e-01f, -2.66377389e-01f,
  4.93309319e-01f, 2.07551092e-01f, 4.26740013e-02f, -7.27738217e-02f, -1.79246202e-01f, -2.96199501e-01f, -1.36254534e-01f, -4.91235070e-02f, -3.55946571e-01f, -1.39145181e-01f,
  2.13515908e-02f, 9.14756432e-02f, -1.91949178e-02f, 2.94667054e-02f, -4.01259912e-03f, 1.45297512e-01f, 2.30894819e-01f, 9.29599777e-02f, 2.84334999e-02f, 8.99295434e-02f,
  9.77190584e-03f, -1.67538092e-01f, -5.17978407e-02f, -3.84428091e-02f, 4.90551479e-02f, 6.84357136e-02f, -6.64369166e-02f, -2.55034696e-02f, 6.52543316e-03f, -1.02135554e-01f,
  -1.62751749e-01f, -4.59829122e-02f, -1.33855000e-01f, -5.60955284e-03f, 7.66132623e-02f, 6.35868683e-02f, -1.47757098e-01f, -2.13900402e-01f, -1.28701320e-02f, 6.08978458e-02f,
  -4.21748936e-01f, 1.15010990e-02f, -2.42769390e-01f, -9.50338840e-02f, 1.56505242e-01f, -1.31292418e-01f, 5.86460009e-02f, -5.99863678e-02f, 3.62031125e-02f, -2.16488410e-02f,
  2.49192920e-02f, -7.91390333e-03f, -1.58258989e-01f, -1.24007724e-01f, -2.35909998e-01f, -1.45665884e-01f, 3.09720542e-02f, -1.25015840e-01f, -7.23656192e-02f, -1.48032159e-01f,
  -9.64061767e-02f, -2.62474746e-01f, -2.66000867e-01f, -2.09727138e-02f, -1.08055525e-01f, -2.78417647e-01f, -2.68070608e-01f, -2.18651146e-01f, -3.32853317e-01f, -3.31850380e-01f,
  2.37351164e-01f, 1.10534072e-01f, 2.07997337e-01f, -5.86565658e-02f, -3.22999746e-01f, -3.99133921e-01f, -4.91102785e-01f, -1.59911767e-01f, -7.20933154e-02f, -7.02068880e-02f,
  -2.71341175e-01f, -2.82994449e-01f, -9.77059901e-02f, -9.79361590e-03f, -9.87083241e-02f, 9.19815898e-02f, 1.74188837e-01f, 2.88204581e-01f, -2.09252879e-01f, -3.85135323e-01f,
  -7.08512813e-02f, 7.37970918e-02f, 1.85172543e-01f, 5.71559630e-02f, 1.03417099e-01f, 2.66496800e-02f, 1.63202345e-01f, 1.21979125e-01f, 1.14285797e-01f, 5.48119128e-01f,
  3.18786263e-01f, 1.88422352e-02f, -1.44127784e-02f, -1.16265558e-01f, 1.18553959e-01f, 1.15608864e-01f, 6.26225770e-02f, 1.87138498e-01f, -1.23008892e-01f, 1.92555785e-02f,
  6.81254789e-02f, 3.70141654e-03f, -7.30252564e-02f, 7.97533542e-02f, -1.36418939e-01f, -4.49149609e-02f, 1.90628827e-01f, 2.07934320e-01f, 1.46227449e-01f, 1.06347753e-02f,
  -1.71686098e-01f, -2.33466744e-01f, -3.04621726e-01f, -9.84070301e-02f, 4.20894995e-02f, -1.03179216e-01f, -8.20720494e-02f, 3.73369306e-02f, -6.44147098e-02f, 2.01755971e-01f,
  -2.46790066e-01f, -5.07206619e-02f, 3.61950062e-02f, 2.38813777e-02f, -5.92632405e-02f, -6.73540756e-02f, 6.59851730e-02f, -5.57321757e-02f, -5.09051047e-02f, 3.42075974e-02f,
  -1.38219502e-02f, 3.11999414e-02f, -3.10021831e-04f, 8.01696852e-02f, -1.32898428e-02f, 3.49185169e-02f, 3.26497946e-04f, 4.40611541e-02f, -7.38930181e-02f, -2.18950473e-02f,
  -1.00544825e-01f, 7.23747760e-02f, 9.47067887e-02f, 4.28704210e-02f, 1.71597898e-02f, 5.42682931e-02f, 6.76039681e-02f, -8.06053430e-02f, -6.49890900e-02f, -5.26566841e-02f,
  4.53201160e-02f, -1.68653637e-01f, 1.54167637e-01f, 1.32332504e-01f, 1.28729746e-01f, 3.29129770e-02f, 1.29573531e-02f, 8.53430629e-02f, -2.64846627e-02f, -4.98446971e-02f,
  -1.91246793e-01f, -2.25514751e-02f, 5.72587252e-02f, -3.42050567e-02f, -7.84457177e-02f, -5.63912503e-02f, 1.02866841e-02f, -1.21093228e-01f, -5.90181239e-02f, -4.05087434e-02f,
  -2.71140113e-02f, -2.55260438e-01f, -4.59799409e-01f, -1.11668885e-01f, -9.73884016e-02f, -1.79145798e-01f, -1.42917871e-01f, -5.43968156e-02f, -1.08985633e-01f, -1.16590552e-01f,
  -4.11261529e-01f, -2.53198534e-01f, -1.90604582e-01f, 3.32486331e-01f, 3.34589601e-01f, 1.84155107e-01f, 3.17977309e-01f, 1.69743687e-01f, 8.19446445e-02f, -8.19593575e-03f,
  -4.01838899e-01f, -2.42725641e-01f, -2.21371770e-01f, -2.05431774e-01f, 1.97967762e-04f, 3.87384832e-01f, 3.27658385e-01f, -9.82391909e-02f, 1.19209863e-01f, 2.23910883e-01f,
  3.41062784e-01f, 7.82364085e-02f, -1.22005902e-01f, 6.30665421e-02f, 1.19120508e-01f, 1.89746141e-01f, 5.53573370e-02f, 2.26461273e-02f, -1.21494465e-01f, 2.32426286e-01f,
  -2.76181310e-01f, -5.48012018e-01f, 4.99396920e-02f, -7.93583021e-02f, -2.82279789e-01f, -3.13041598e-01f, -1.26056001e-01f, -2.92370558e-01f, -2.54482150e-01f, -1.95304230e-02f,
  -1.51702404e-01f, -1.27394199e-01f, 1.10119628e-03f, 6.35926649e-02f, 3.03464830e-02f, -5.11548147e-02f, -5.66064455e-02f, -1.52649626e-01f, -1.87536760e-03f, -6.94894195e-02f,
  1.01375073e-01f, 5.66085204e-02f, -1.14556417e-01f, -9.51120537e-03f, -9.88617390e-02f, -1.24720879e-01f, -1.75926447e-01f, -2.26443172e-01f, -2.40903750e-01f, -6.25709072e-02f,
  -1.20182268e-01f, 3.74662429e-02f, 4.00261357e-02f, 2.84684040e-02f, 1.31760919e-02f, 1.74403727e-01f, 1.92956105e-01f, -7.22339526e-02f, 2.50866413e-01f, 7.72043467e-02f,
  1.01487927e-01f, 2.35415511e-02f, -8.58792961e-02f, 1.24828238e-02f, -2.14636102e-02f, -3.16811688e-02f, 1.09099500e-01f, -7.70062767e-03f, -1.45866811e-01f, -9.32935551e-02f,
  -2.18758453e-02f, 9.63849202e-02f, 4.91204709e-02f, -2.55009457e-02f, -2.95832362e-02f, -1.58684313e-01f, 7.50026181e-02f, 1.58120599e-02f, 1.69525445e-01f, 3.15923728e-02f,
  4.53679293e-01f, -2.90665239e-01f, 2.05438957e-01f, 1.47429081e-02f, 8.84101912e-02f, -2.63691813e-01f, -1.52503222e-01f, -2.75757816e-02f, 3.68205123e-02f, 5.72453663e-02f,
  -1.21429048e-01f, -9.82964560e-02f, 9.68940265e-04f, 9.18616280e-02f, 2.80141056e-01f, 1.57716766e-01f, 1.48452688e-02f, 2.02344194e-01f, 1.49409827e-02f, 5.05966023e-02f,
  1.89303309e-01f, 9.51812491e-02f, 2.08963275e-01f, 1.30389407e-01f, 1.01287052e-01f, 1.96444914e-01f, 1.42934605e-01f, 4.74709719e-02f, 1.57508235e-02f, 2.84646422e-01f,
  -2.25602582e-01f, -1.42723545e-01f, -4.98068660e-01f, -3.26861829e-01f, -4.87268507e-01f, -3.87975842e-01f, -1.81955770e-01f, -2.09659725e-01f, -2.90327430e-01f, -4.46767241e-01f,
  8.07028636e-02f, 5.07021785e-01f, 1.86508745e-01f, 4.37334403e-02f, 1.26027182e-01f, -3.81565958e-01f, -6.85094833e-01f, -2.90271312e-01f, 1.17693938e-01f, 1.84184209e-01f,
  -1.25356406e-01f, -1.75852165e-01f, -1.83875293e-01f, -2.45143496e-03f, 4.98734154e-02f, 1.73531383e-01f, -2.76130706e-01f, -2.45716736e-01f, -1.26907259e-01f, -2.45720878e-01f,
  4.34487551e-01f, -2.20519155e-01f, -4.83145416e-02f, -9.57967117e-02f, -7.31713325e-02f, -7.14681298e-03f, 1.79774016e-01f, -2.05397040e-01f, -1.24326900e-01f, -2.20267668e-01f,
  -2.95281619e-01f, -8.43844488e-02f, 1.24248851e-03f, 3.34477015e-02f, -3.18010226e-02f, -1.16859078e-01f, -1.72017470e-01f, -1.06760882e-01f, -8.89597908e-02f, -5.22871083e-03f,
  -1.19022548e-01f, -3.02850604e-01f, 1.93163201e-01f, 3.64854671e-02f, 1.20509431e-01f, -1.81240253e-02f, 1.67500565e-03f, 6.24647513e-02f, -4.37304052e-03f, -1.64527223e-02f,
  -4.79789004e-02f, 1.13496445e-01f, 9.65247527e-02f, -3.95778343e-02f, -6.87383115e-02f, 4.64213692e-04f, 4.23426256e-02f, 4.59386110e-02f, -6.84865266e-02f, 1.32316366e-01f,
  1.24329329e-02f, -1.99496597e-02f, 1.84968598e-02f, -1.86703224e-02f, -1.00663990e-01f, -2.69827209e-02f, -2.87006404e-02f, -5.21522388e-02f, -3.25451083e-02f, 4.68402989e-02f,
  -6.04398698e-02f, -2.11449519e-01f, -2.72712540e-02f, 1.30531311e-01f, -1.56243473e-01f, 2.23265886e-02f, -3.31296511e-02f, 3.73116359e-02f, 4.18192223e-02f, -2.26440832e-01f,
  6.28278792e-01f, -2.04771966e-01f, -8.39045793e-02f, 1.79987252e-01f, -4.59662750e-02f, -9.01430324e-02f, -1.49387404e-01f, -7.05548748e-02f, -1.64115131e-01f, -1.24951109e-01f,
  -1.07195027e-01f, 3.12799700e-02f, 8.33586529e-02f, 1.94820508e-01f, -4.06159610e-02f, -1.05170742e-01f, -3.54281850e-02f, 1.28051862e-01f, 2.40924093e-03f, -5.31133153e-02f,
  -2.24902809e-01f, -1.32735223e-01f, 3.27996761e-01f, 9.48503017e-02f, 9.43308994e-02f, 1.09797962e-01f, 1.96219981e-01f, -1.38588264e-04f, 2.55049139e-01f, 5.92796393e-02f,
  -1.02706993e+00f, 2.84310788e-01f, 2.14445502e-01f, -4.00312364e-01f, -1.58276469e-01f, -2.59461880e-01f, 1.20468013e-01f, -1.56219304e-01f, -3.43357146e-01f, 2.97881693e-01f,
  1.44344434e-01f, -7.12032765e-02f, 1.95948984e-02f, 3.82018238e-02f, -2.10941479e-01f, 1.12540260e-01f, -5.14896140e-02f, -4.65677619e-01f, -5.71520329e-01f, -3.72329682e-01f,
  -1.12116724e-01f, -4.41477418e-01f, -5.82099915e-01f, -2.46902525e-01f, 4.26710397e-02f, -1.28607541e-01f, 1.67451367e-01f, -2.35419229e-01f, 4.36717831e-02f, 1.13587655e-01f,
  2.67979890e-01f, -1.61240593e-01f, -1.21717863e-01f, -2.80938417e-01f, 6.84343427e-02f, -1.04359426e-01f, -1.34840935e-01f, 6.16710773e-03f, -1.17871903e-01f, -4.41767834e-02f,
  -1.34103313e-01f, 4.16374542e-02f, -1.29582062e-01f, 4.36993279e-02f, -1.05046168e-01f, 2.09052507e-02f, 8.38058367e-02f, -1.31029680e-01f, 5.39498217e-02f, 2.82596111e-01f,
  1.78173065e-01f, 2.22215597e-02f, 1.76505316e-02f, 8.76802281e-02f, -3.34058292e-02f, -3.78361866e-02f, 1.71625555e-01f, -1.05447277e-01f, 7.41498247e-02f, 1.32707596e-01f,
  3.47624868e-02f, 1.12515353e-01f, -2.21314002e-02f, -2.65985653e-02f, 2.18486693e-02f, -4.85963421e-03f, 5.51414378e-02f, 5.92881516e-02f, -5.53456917e-02f, -1.65278316e-02f,
  1.26844749e-01f, -5.59070194e-03f, -3.33418548e-02f, 2.51597092e-02f, -1.02692284e-02f, -5.08078821e-02f, -1.21148601e-01f, 7.91993737e-02f, 6.55107945e-02f, -5.53903393e-02f,
  -1.92548960e-01f, -2.50187013e-02f, 1.14296079e-02f, -4.13207477e-03f, 2.58530192e-02f, -1.13604851e-02f, -4.44220789e-02f, 4.13487852e-02f, -4.07177731e-02f, -5.28318398e-02f,
  1.03202894e-01f, -1.96045160e-01f, 6.01363629e-02f, -4.57547940e-02f, 8.97924323e-03f, 7.36332759e-02f, -1.38267493e-02f, 5.28260367e-03f, -2.75899353e-03f, -1.30234659e-02f,
  -8.51403514e-04f, 1.72401778e-02f, 2.35501826e-02f, 2.77454238e-02f, 1.74361467e-03f, -1.21549681e-01f, 7.70595595e-02f, 1.39761968e-02f, -1.72914676e-02f, 1.76893726e-01f,
  1.38762504e-01f, 7.07832724e-02f, -2.15704422e-02f, 2.12008506e-01f, 8.17453787e-02f, -9.68383029e-02f, 2.41671354e-01f, 5.00201583e-02f, 3.21698301e-02f, 3.50098491e-01f,
  7.44211853e-01f, -4.54745889e-01f, 3.47810686e-01f, 2.72651285e-01f, 3.80583078e-01f, 4.28452462e-01f, 1.99031770e-01f, 1.65935263e-01f, 7.58156627e-02f, -6.98794750e-03f,
  6.77083433e-02f, -4.76991525e-03f, -1.34139052e-02f, -2.09642708e-01f, -5.05010895e-02f, 1.09063134e-01f, -6.75403047e-03f, 2.71340132e-01f, 3.93632263e-01f, 2.11202323e-01f,
  1.47501631e-02f, -5.34904525e-02f, 8.82953405e-02f, -4.21149768e-02f, -3.45724635e-02f, 4.73356955e-02f, -4.25112024e-02f, -2.56150067e-02f, -8.86715204e-02f, -2.43543759e-01f,
  -2.13606656e-02f, 9.07967146e-03f, 1.59666479e-01f, -2.02556044e-01f, -1.58609912e-01f, -1.08920150e-01f, 1.12936817e-01f, -9.44058299e-02f, 1.44175189e-02f, -1.96275294e-01f,
  -6.99988976e-02f, -8.56906325e-02f, 1.39893042e-02f, -5.89493774e-02f, 1.37349203e-01f, -4.21813354e-02f, 2.09270623e-02f, -4.17951457e-02f, 1.87382642e-02f, -6.30243868e-02f,
  -8.89513120e-02f, 1.86352003e-02f, 9.47650075e-02f, 3.25538367e-02f, 1.59598991e-01f, 1.13260448e-01f, -2.28504594e-02f, 9.15164277e-02f, -2.67569255e-02f, -3.25806439e-02f,
  2.54530668e-01f, 1.59078136e-01f, 1.10290349e-01f, 1.44542411e-01f, 9.29545462e-02f, 4.86945733e-02f, 4.95335013e-02f, -7.62634852e-04f, 1.49921402e-01f, 1.22746058e-01f,
  -9.53082889e-02f, -5.86880930e-03f, 2.57686879e-02f, 5.35637252e-02f, 8.56870189e-02f, -5.31437621e-02f, -1.14517331e-01f, -7.10824281e-02f, 5.14089456e-03f, 7.05515519e-02f,
  1.00565329e-01f, -5.89108244e-02f, 4.27880846e-02f, -1.05299741e-01f, 3.81460437e-03f, 6.12695627e-02f, 1.49806440e-01f, -1.49778882e-02f, -6.58205226e-02f, 4.99642715e-02f,
  -3.31994593e-01f, 1.35413483e-01f, 6.98802844e-02f, -2.32962236e-01f, -8.91025886e-02f, -1.52440034e-02f, 4.86627519e-02f, -4.08328958e-02f, -1.91102013e-01f, -1.12538882e-01f,
  -5.58567643e-02f, -2.47957390e-02f, -6.28016442e-02f, 3.96551117e-02f, 9.44641083e-02f, 1.42591789e-01f, -4.95569594e-02f, 2.37517059e-02f, -1.69707164e-01f, -1.84204429e-01f,
  -1.76287413e-01f, 9.18062553e-02f, 9.20275003e-02f, 1.36205390e-01f, 1.03258230e-01f, 1.65069401e-01f, 5.75779863e-02f, 1.69538841e-01f, 1.88222393e-01f, 7.58272409e-02f,
  1.45091951e-01f, 5.40735535e-02f, 3.33581895e-01f, 1.04692191e-01f, 4.72331613e-01f, 3.31786394e-01f, 5.07965446e-01f, 1.36405528e-01f, -4.81316634e-02f, 8.23395997e-02f,
  -2.71283872e-02f, -2.58415580e-01f, -2.99024045e-01f, -1.66133821e-01f, -8.24583992e-02f, 1.90926403e-01f, 1.94756076e-01f, 4.97833192e-02f, 2.05946118e-02f, 2.19811752e-01f,
  3.32181342e-02f, -4.83454876e-02f, -1.26071438e-01f, -7.54016265e-02f, 1.06539875e-01f, -1.91252962e-01f, 9.39273089e-02f, 2.31499836e-01f, 1.26875386e-01f, -2.02183556e-02f,
  7.41425529e-02f, 1.54678673e-01f, -2.27708489e-01f, -2.66658336e-01f, 1.23984054e-01f, -3.33750576e-01f, -1.70091972e-01f, -1.26284480e-01f, -1.57330915e-01f, -1.50256127e-01f,
  6.90998808e-02f, -8.42023268e-02f, 7.24817216e-02f, 9.26589295e-02f, 1.23045184e-01f, 7.45036826e-02f, 3.59238242e-03f, -1.49545252e-01f, -3.62761654e-02f, -1.12845182e-01f,
  -4.68122363e-02f, 1.74062878e-01f, 2.27086067e-01f, 8.62317607e-02f, 6.74897879e-02f, -1.48680359e-01f, -5.48098683e-02f, 4.12147455e-02f, -5.56938462e-02f, -1.17105670e-01f,
  -3.48531544e-01f, -7.03166649e-02f, 1.00513257e-01f, -1.70844987e-01f, -1.99199133e-02f, -9.97742116e-02f, 2.18191408e-02f, -3.19849104e-02f, 1.07720748e-01f, 2.40336433e-02f,
  -1.98183581e-02f, 6.85693249e-02f, -7.75817707e-02f, -9.61468667e-02f, -7.99905285e-02f, -3.26837599e-02f, 1.23357087e-01f, -5.14479056e-02f, 3.76774035e-02f, 1.10936500e-02f,
  5.12143187e-02f, -4.32277359e-02f, 2.18329020e-02f, 4.25978042e-02f, -4.10757400e-02f, -9.13568139e-02f, -1.68403059e-01f, -1.40550584e-01f, -1.84558615e-01f, -7.84881860e-02f,
  -1.47265896e-01f, 1.19347408e-01f, -2.18653575e-01f, -5.06009199e-02f, 8.72676745e-02f, -1.02409393e-01f, -2.36053485e-02f, -6.64732754e-02f, -4.67181168e-02f, -2.39601895e-01f,
  5.24883792e-02f, -9.65470523e-02f, 3.82559374e-02f, -1.40044883e-01f, -7.35010281e-02f, -9.04809460e-02f, -4.10499126e-02f, -2.26758830e-02f, -5.93277300e-03f, 2.97155585e-02f,
  -1.15329763e-02f, 1.00687020e-01f, 1.69375390e-02f, -5.74225932e-02f, -2.88946986e-01f, -2.25130975e-01f, -7.61592239e-02f, -1.27570465e-01f, 4.66036201e-02f, -1.67631388e-01f,
  6.06044412e-01f, 2.02746853e-01f, 3.55735570e-01f, 4.03111607e-01f, 2.29416922e-01f, 3.00170660e-01f, 3.31641108e-01f, 9.38978568e-02f, 8.87420997e-02f, 1.24831565e-01f,
  2.01762915e-02f, 4.75815199e-02f, 8.56263414e-02f, 2.38201814e-03f, 4.35091369e-02f, 4.71384004e-02f, 1.18104398e-01f, 1.55503035e-01f, 1.49818510e-02f, 7.93109089e-02f,
  5.31642400e-02f, -1.17221855e-01f, -8.01809947e-04f, 6.97707906e-02f, -1.80235878e-02f, 4.53916676e-02f, 7.58356601e-03f, 1.34192571e-01f, 2.99620954e-03f, -1.20549738e-01f,
  -5.91710061e-02f, 2.21534163e-01f, -1.74314214e-03f, -9.82114077e-02f, -1.14894688e-01f, -1.34935573e-01f, -7.80801997e-02f, -1.38091698e-01f, -7.44109675e-02f, -1.29062265e-01f,
  -1.90670431e-01f, -1.72585309e-01f, -1.51250255e-03f, -9.24756601e-02f, -1.04339153e-01f, -1.96268663e-01f, -6.50527254e-02f, -5.59183434e-02f, -1.35092616e-01f, 5.98014938e-03f,
  -2.30364595e-03f, 1.09526485e-01f, 1.06713355e-01f, -3.96321267e-02f, 3.92119810e-02f, 5.50510711e-04f, -7.90787116e-02f, 4.11311723e-02f, 5.34896217e-02f, 3.13801877e-02f,
  -2.16631535e-02f, -4.57165614e-02f, 1.39390260e-01f, 4.93548363e-02f, -2.55079218e-03f, 4.26667184e-02f, -9.13562998e-03f, 4.54136170e-02f, -4.99489391e-03f, 5.10293655e-02f,
  -1.40684135e-02f, 1.12541452e-01f, 4.56572734e-02f, 1.37687624e-01f, 9.90115851e-02f, 1.16317727e-01f, 1.76769830e-02f, 4.72113043e-02f, 6.11576661e-02f, 8.01578835e-02f,
  -6.42622486e-02f, 3.50548588e-02f, 4.17029411e-02f, -6.06465228e-02f, -8.07069317e-02f, 1.56042159e-01f, -4.20610830e-02f, -5.90676256e-02f, 4.73705027e-03f, -1.05285965e-01f,
  -4.28284019e-01f, 7.73986131e-02f, -7.33351707e-02f, -5.28886123e-03f, 5.85807711e-02f, -1.03186406e-01f, 1.22687601e-01f, -1.37745216e-01f, -1.29423440e-01f, -4.07293662e-02f,
  -7.44238421e-02f, 1.44506663e-01f, -5.40472046e-02f, -1.95729569e-01f, -4.36183102e-02f, -1.22335687e-01f, -5.27493767e-02f, -7.96151534e-02f, -1.30609080e-01f, -1.70742109e-01f,
  -5.34551311e-03f, -4.14319336e-03f, 7.22260922e-02f, 4.49842401e-02f, -2.92602517e-02f, -8.17472637e-02f, -2.95130592e-02f, -1.13494992e-01f, 4.86076102e-02f, -1.40835151e-01f,
  1.08354712e+00f, 1.52613772e-02f, -7.16277838e-01f, 3.35399717e-01f, -3.70367557e-01f, -2.81716794e-01f, -2.57643491e-01f, 3.07466984e-02f, 3.54950815e-01f, -4.15884219e-02f,
  -2.61188656e-01f, -2.43891440e-02f, 1.18939042e-01f, -1.45091787e-01f, -3.37003559e-01f, -4.15863127e-01f, -2.28608593e-01f, -2.22364724e-01f, -2.53923297e-01f, -4.73333836e-01f,
  -2.24473521e-01f, 1.64261729e-01f, 1.51731998e-01f, -1.42439023e-01f, -2.10513756e-01f, -1.74104914e-01f, -2.99658597e-01f, -2.98078835e-01f, -3.94052386e-01f, -2.50406265e-01f,
  -6.22616887e-01f, -1.05513103e-01f, -2.63452351e-01f, 9.17656124e-02f, -1.44874558e-01f, 1.03797466e-01f, -9.28070024e-02f, -1.23633705e-01f, 4.94723581e-02f, -1.62798464e-02f,
  -2.57671863e-01f, -1.77832291e-01f, -1.06866606e-01f, -1.07388087e-01f, 3.01088183e-03f, -3.90953645e-02f, -7.09959343e-02f, -1.53305024e-01f, -7.62044787e-02f, -1.27183527e-01f,
  -5.91505393e-02f, -2.40520731e-01f, 5.59335155e-03f, -9.65873823e-02f, -1.85378298e-01f, -7.11670294e-02f, -2.98582137e-01f, -3.83128405e-01f, -3.37644786e-01f, -5.68619184e-03f,
  9.76125337e-03f, -2.88395416e-02f, -3.03262249e-02f, 6.99240193e-02f, 2.22682148e-01f, -4.60054073e-03f, 6.78832754e-02f, -6.18317127e-02f, -1.27772447e-02f, 3.13607752e-02f,
  7.65393162e-03f, -5.32289743e-02f, 1.81427933e-02f, 9.13276225e-02f, -9.23860818e-02f, -8.45361799e-02f, 9.55678374e-02f, -6.04152568e-02f, -1.09425306e-01f, 1.09303251e-01f,
  4.39962968e-02f, -1.49911493e-01f, 8.65089819e-02f, 3.28594930e-02f, -1.18869066e-01f, 4.48333584e-02f, -5.96816912e-02f, -9.65712685e-03f, 5.01620322e-02f, 1.06818296e-01f,
  4.36221331e-01f, -6.39287159e-02f, 1.83613092e-01f, -1.47234812e-01f, 5.84762469e-02f, 4.10146080e-02f, -7.34613568e-04f, 1.78286787e-02f, 1.28013879e-01f, -1.53400260e-03f,
  -2.84125388e-01f, 1.40364328e-02f, -1.08303083e-02f, -1.60245582e-01f, -1.98718570e-02f, 6.84335381e-02f, 3.37106287e-02f, 2.39181519e-02f, 3.64760403e-03f, 9.57661346e-02f,
  1.36158437e-01f, 1.59235984e-01f, 3.90659630e-01f, 1.60919949e-01f, 1.59565266e-02f, 2.18639299e-01f, -2.66348030e-02f, 1.06357247e-01f, 4.36722152e-02f, 4.61007386e-01f,
  3.95737439e-02f, 5.85168265e-02f, -2.69944090e-02f, 8.14008489e-02f, -8.40095580e-02f, 1.61558613e-01f, 2.45960817e-01f, 2.34141052e-01f, 8.94862264e-02f, -1.13786841e-02f,
  -3.29871997e-02f, -3.10433563e-02f, 8.63803178e-02f, 7.56442994e-02f, 2.95823663e-01f, 1.85962200e-01f, 2.12129414e-01f, 2.96029240e-01f, 1.96677014e-01f, 1.01721667e-01f,
  1.90253258e-01f, 1.70910954e-01f, 9.73203704e-02f, 2.27867618e-01f, 1.80444419e-01f, 1.11604139e-01f, 7.81834200e-02f, 1.29883379e-01f, 2.61144996e-01f, 3.66324931e-01f,
  -1.29389137e-01f, 1.83607265e-01f, 2.19471809e-02f, -1.70532703e-01f, -2.29722366e-01f, 2.24045478e-02f, -4.40405086e-02f, -1.20436624e-01f, -1.44801155e-01f, 7.77194500e-02f,
  -3.58223952e-02f, -1.15700047e-02f, 4.46111970e-02f, 8.44736472e-02f, -1.76756997e-02f, -7.61249987e-03f, 7.41868541e-02f, 2.71675974e-01f, 1.27540827e-01f, 9.36749652e-02f,
  1.41179219e-01f, -9.53989848e-02f, -2.48283222e-02f, 1.43648013e-01f, 2.47915491e-01f, -6.91935122e-02f, 4.19142544e-02f, 3.59075442e-02f, 6.88674673e-03f, 2.19961330e-01f,
  1.73488617e-01f, 1.84240058e-01f, 1.39826953e-01f, 1.18995257e-01f, 2.59324789e-01f, 2.61372387e-01f, 2.22012907e-01f, 1.31005883e-01f, 2.72249788e-01f, 1.07520148e-01f,
  -8.01283792e-02f, 5.05306460e-02f, 2.59091761e-02f, -2.10078945e-03f, 6.33344650e-02f, -5.77587960e-03f, -1.15236267e-01f, -8.85087326e-02f, 4.69017308e-03f, -5.61336018e-02f,
  3.76930721e-02f, 6.23089522e-02f, -1.36696309e-01f, -6.68771379e-03f, -6.67842329e-02f, -1.27815470e-01f, -5.92868328e-02f, -1.54051498e-01f, -1.07798122e-01f, 6.49453774e-02f,
  -3.36431921e-01f, -1.60533916e-02f, 2.23072642e-03f, 3.28199863e-02f, -5.64324148e-02f, -3.03482320e-02f, -6.23009820e-03f, -1.85834318e-01f, -1.20475061e-01f, -1.11625358e-01f,
  -1.52821779e-01f, -5.99464625e-02f, 8.55490863e-02f, -4.27421778e-02f, -1.25864461e-01f, -1.48835167e-01f, -7.51407966e-02f, 1.33439514e-03f, -6.70242608e-02f, -1.38184831e-01f,
  -5.10559604e-02f, -1.45602986e-01f, -3.96040916e-01f, -4.25766855e-02f, -1.44947954e-02f, -1.31525144e-01f, -2.71543026e-01f, -1.38942078e-01f, -2.15715304e-01f, -2.50973374e-01f,
  -1.96630880e-01f, -3.86768371e-01f, -1.12497399e-03f, 9.63689536e-02f, 1.24378912e-01f, -1.76892862e-01f, -7.73666501e-01f, -3.83785307e-01f, 1.12152025e-01f, -2.55631089e-01f,
  1.80321589e-01f, 3.02297980e-01f, 5.39536308e-03f, -3.64789739e-02f, -6.04642868e-01f, -6.45510435e-01f, -4.98665959e-01f, -2.18252197e-01f, -2.04276249e-01f, 2.66233496e-02f,
  -4.30864692e-02f, -4.56078351e-02f, 1.15577504e-01f, 8.26268643e-02f, 1.14344291e-01f, 5.48628792e-02f, 1.19951092e-01f, 1.48245811e-01f, -2.35159672e-03f, 6.16400130e-02f,
  -1.17678307e-01f, -1.70853361e-01f, 1.63119808e-01f, -3.48358159e-03f, 1.64446086e-01f, -3.39615010e-02f, -1.34514078e-01f, -6.20237105e-02f, 9.11084265e-02f, -5.82560562e-02f,
  9.09205154e-02f, 1.70531586e-01f, 6.14504665e-02f, -4.29192595e-02f, -1.15166202e-01f, -8.22644159e-02f, -7.88899586e-02f, -1.18909933e-01f, -2.41304692e-02f, 1.26879867e-02f,
  2.61631720e-02f, 1.02778368e-01f, -2.60391086e-01f, -1.72683716e-01f, 7.68437088e-02f, 1.44541711e-01f, -4.04400229e-02f, 1.46703765e-01f, -1.51348904e-01f, -1.84122624e-03f,
  1.03086784e-01f, 4.35487069e-02f, 4.68578115e-02f, -3.02283838e-02f, 6.80873320e-02f, 5.90294525e-02f, -2.16973945e-02f, 2.29203212e-03f, 6.63883612e-02f, 8.94331858e-02f,
  -3.71037722e-02f, 6.55755848e-02f, 5.01867291e-03f, 2.20113490e-02f, 1.68145187e-02f, -4.84332293e-02f, 1.34193748e-01f, -2.05515474e-01f, -2.49060988e-01f, -6.97862217e-03f,
  -2.76352130e-02f, 1.25226676e-01f, 8.31778422e-02f, 3.00650299e-02f, -6.12741224e-02f, -1.40116233e-02f, 8.43332261e-02f, -1.08874679e-01f, -3.98642123e-02f, 6.36841776e-03f,
  -1.98924467e-02f, -4.07456085e-02f, -8.76288414e-02f, -1.27101928e-01f, -1.13523174e-02f, -4.36989963e-02f, 1.02903582e-01f, -7.13727325e-02f, 2.11858526e-01f, -1.19565986e-01f,
  -8.20000470e-03f, -1.81238100e-01f, -4.46365066e-02f, 1.16401277e-01f, 4.73681092e-02f, -1.58809334e-01f, -3.16895396e-01f, -7.00544491e-02f, -2.40614265e-01f, 8.39963369e-03f,
  -1.71825677e-01f, -1.87531397e-01f, -3.67144376e-01f, -2.66419232e-01f, -1.13389000e-01f, -2.38594249e-01f, -1.43077224e-01f, -8.29740018e-02f, -3.76441091e-01f, -4.57905650e-01f,
  1.58037469e-01f, -9.03238654e-02f, 4.18933362e-01f, 7.94302598e-02f, -2.55552799e-01f, -4.45923388e-01f, -6.26557052e-01f, -2.71675229e-01f, -1.68425053e-01f, -1.60769656e-01f,
  -8.89922008e-02f, -1.56193405e-01f, -9.50380787e-02f, 4.19475362e-02f, 6.79418445e-02f, -3.43956128e-02f, 2.28637800e-01f, 5.45074582e-01f, 2.63651550e-01f, -1.15751743e-01f,
  -6.55096546e-02f, 2.83549100e-01f, 3.23703647e-01f, 1.27565876e-01f, -8.18593502e-02f, -1.43004775e-01f, 9.80117172e-02f, 1.67605907e-01f, 5.73796816e-02f, 1.55424312e-01f,
  1.77594647e-01f, 2.23912373e-02f, 3.13401408e-02f, 1.19257043e-03f, 6.38853610e-02f, -5.58556691e-02f, -1.10383421e-01f, 1.09049574e-01f, -8.60320479e-02f, -3.43609899e-02f,
  9.90387350e-02f, 1.50247306e-01f, -1.22214220e-01f, -2.01272573e-02f, 9.03154016e-02f, -5.43296151e-03f, 1.12305328e-01f, 1.59453377e-01f, 1.08518124e-01f, -4.65455428e-02f,
  -3.10293492e-02f, 4.37329784e-02f, 7.31114671e-03f, -2.21183196e-01f, -7.13754594e-02f, 1.32070675e-01f, -8.72112438e-02f, -1.84671637e-02f, 2.86486391e-02f, -6.35827258e-02f,
  1.01491973e-01f, 1.79560393e-01f, 4.87799011e-02f, -2.47389041e-02f, -2.20147166e-02f, 2.05615796e-02f, 9.68624800e-02f, -1.96759533e-02f, 1.27495732e-02f, 7.74009377e-02f,
  -1.93380415e-02f, -5.13792634e-02f, 4.23151404e-02f, -1.12093329e-01f, 1.10071059e-02f, 1.27860203e-01f, 2.38410123e-02f, 1.08636528e-01f, 1.46303996e-01f, 4.52156588e-02f,
  6.65194094e-02f, -7.24227279e-02f, 6.86206892e-02f, -1.71227399e-02f, -6.87019958e-04f, 2.23923519e-01f, -1.57485735e-02f, -1.42092556e-01f, 4.91161682e-02f, 6.93875477e-02f,
  -1.63758814e-01f, -6.14691665e-03f, -7.80032203e-02f, 1.01903118e-01f, 4.59032990e-02f, -1.36241093e-01f, -1.05734684e-01f, 4.74072881e-02f, 1.38799906e-01f, -1.16936065e-01f,
  -2.44604215e-01f, -2.06251573e-02f, -6.68571005e-03f, 1.68293357e-01f, -6.88712224e-02f, -6.43499121e-02f, -5.57060130e-02f, -1.15923502e-01f, 2.02558953e-02f, -1.68423384e-01f,
  1.44914147e-02f, -2.07250133e-01f, -3.29013079e-01f, -2.21123338e-01f, -1.93195000e-01f, -2.24350944e-01f, 3.45374481e-03f, -2.45571211e-01f, -2.97528058e-01f, -5.46075106e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  3.54681641e-01f, 6.33700341e-02f, -4.34121266e-02f, 2.67754734e-01f, 7.95173422e-02f, 3.22498202e-01f, -7.15172812e-02f, 2.52068609e-01f, 3.01752746e-01f, 2.97843963e-01f,
  2.82865047e-01f, 2.20834792e-01f, 1.99974284e-01f, 2.36778244e-01f, 1.53541073e-01f, 3.36227387e-01f, 3.42460066e-01f, 4.19173777e-01f, 4.17426497e-01f, 2.90453762e-01f,
  2.51483172e-01f, 3.04753721e-01f, 4.87393796e-01f, 2.47959048e-01f, 1.04102297e-02f, 1.16994552e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.18699828e-02f, 2.99354997e-02f, 1.24883316e-02f, 2.03723058e-01f, 1.40615717e-01f, 4.73620445e-02f, 9.01482329e-02f, -7.33929127e-02f, -5.96093833e-02f, -3.42691541e-01f,
  -2.24816874e-01f, 4.74194288e-02f, -3.29755247e-02f, 1.59725770e-01f, 1.50267944e-01f, -2.60609776e-01f, -9.66977552e-02f, -4.09046650e-01f, 9.92572308e-02f, 1.38197793e-02f,
  -3.24409492e-02f, -4.65473160e-02f, 1.11438885e-01f, -1.27842426e-01f, -1.28215075e-01f, 1.27041593e-01f, 3.60135525e-01f, 1.18416399e-01f, 9.82395485e-02f, 1.72786951e-01f,
  -1.99665502e-01f, -1.11198463e-01f, -7.67070726e-02f, 3.41156237e-02f, -1.23213224e-01f, -2.10349828e-01f, 9.27162319e-02f, -3.16073000e-01f, -2.31794104e-01f, -3.46125960e-01f,
  1.86312109e-01f, 3.33852082e-01f, -2.38184690e-01f, -1.94981858e-01f, -2.68712007e-02f, 1.02115152e-02f, -1.24771386e-01f, -2.94602942e-02f, 4.13139045e-01f, -4.15735915e-02f,
  1.46412566e-01f, 4.79741022e-02f, -6.87926635e-02f, -2.43309483e-01f, -6.39737025e-02f, 1.82212323e-01f, -4.93002832e-01f, 6.17993101e-02f, 1.33271888e-01f, 1.14833459e-01f,
  -3.13897207e-02f, -2.05018923e-01f, 4.70023006e-02f, 6.11277521e-02f, 2.36695614e-02f, 3.94980423e-02f, 2.24647503e-02f, 1.37178162e-02f, 1.67357866e-02f, -8.43174383e-02f,
  -2.01929465e-01f, 3.09380144e-01f, 1.81262910e-01f, -1.32716939e-01f, -1.58050314e-01f, -1.00082345e-01f, 1.28993481e-01f, -1.40116289e-01f, 7.33684702e-03f, 4.72447500e-02f,
  -6.22954592e-02f, -7.76891261e-02f, -3.03902149e-01f, -4.20663618e-02f, 2.20018804e-01f, -8.66729617e-02f, -3.10147498e-02f, 7.51663670e-02f, -2.66906261e-01f, 9.76229459e-02f,
  3.22234452e-01f, 1.37886524e-01f, 2.88899571e-01f, 1.86970143e-03f, -2.95398921e-01f, 9.29070264e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -1.51492609e-02f, 1.63345367e-01f, 1.33649245e-01f, 2.32864559e-01f, -2.89773215e-02f, 1.35435052e-02f, 3.54004085e-01f, 2.24362001e-01f, 1.58419058e-01f, 1.47121444e-01f,
  3.74087423e-01f, 3.30602348e-01f, 1.26415908e-01f, -2.40334824e-01f, 1.97160468e-01f, 1.36512835e-02f, -1.87404558e-01f, 9.48361605e-02f, 1.55157521e-01f, 1.34034410e-01f,
  -1.86491106e-02f, 1.62976421e-03f, 2.93401182e-02f, 3.36179972e-01f, 5.46110392e-01f, -1.67792112e-01f, -2.18500078e-01f, 1.31184652e-01f, -2.07670197e-01f, -2.77507007e-01f,
  2.62244552e-01f, -3.03529590e-01f, 3.48978005e-02f, -4.13067313e-03f, -1.66186243e-02f, 3.05142164e-01f, -1.12749070e-01f, -8.38290229e-02f, 9.29071680e-02f, -5.74150530e-04f,
  2.85850223e-02f, 5.01366891e-03f, -4.10223156e-01f, 1.45013496e-01f, 1.82785437e-01f, -9.68797654e-02f, 1.09774031e-01f, 1.06961727e-01f, 5.54030947e-02f, 3.72497916e-01f,
  3.51487130e-01f, 5.80641665e-02f, 1.25296175e-01f, -4.80969727e-01f, 1.69500858e-01f, 1.41591281e-01f, -5.50800078e-02f, 3.63716871e-01f, 4.61731285e-01f, 3.90407771e-01f,
  8.16984773e-02f, 4.87699091e-01f, -3.33849758e-01f, -4.24629927e-01f, 1.68474838e-01f, 3.94314140e-01f, 1.11294746e-01f, 3.66524495e-02f, 3.53120148e-01f, -2.29872137e-01f,
  3.75955701e-01f, 2.10178196e-01f, -1.22170702e-01f, 4.55968678e-01f, -6.87518902e-03f, -6.24925159e-02f, 3.11376691e-01f, 4.34007421e-02f, -4.16236743e-02f, -8.57099816e-02f,
  4.46049064e-01f, 2.47484490e-01f, 6.13698244e-01f, 4.41695035e-01f, 2.55658209e-01f, 3.26909572e-01f, -3.86679918e-01f, -2.01866925e-01f, -8.75000879e-02f, -3.68674099e-02f,
  3.35283548e-01f, 2.42232699e-02f, -1.20751202e-01f, 2.19939221e-02f, 5.35009265e-01f, 6.01150751e-01f, -4.24378477e-02f, 1.67191029e-01f, -4.87783365e-02f, -3.47657830e-01f,
  8.00498873e-02f, -2.77484089e-01f, -6.96807578e-02f, 2.85542607e-01f, -1.14943527e-01f, 5.78956068e-01f, 2.31647193e-01f, 4.12646076e-03f, -3.98532264e-02f, -1.02713220e-01f,
  -4.02110457e-01f, 5.60529064e-03f, 1.63841143e-01f, 2.08290711e-01f, 3.48869562e-02f, 2.19136733e-03f, 1.17337279e-01f, -7.40497559e-02f, -6.43677413e-02f, 2.16816515e-01f,
  -3.81098092e-01f, -5.13083637e-02f, -1.30023062e-01f, -7.10940659e-02f, 2.30518013e-01f, -6.66476414e-02f, 3.29092324e-01f, 2.45283544e-03f, 2.59482175e-01f, 1.71804667e-01f,
  -2.31459290e-02f, -1.02228850e-01f, -1.43161610e-01f, -2.64085233e-02f, 1.33360699e-01f, -2.55257674e-02f, -4.26122509e-02f, -1.43150818e-02f, 1.39187902e-01f, 3.72166276e-01f,
  -2.68194079e-01f, 2.78340161e-01f, 3.81935954e-01f, 7.07367808e-02f, -1.08161122e-01f, 4.19016004e-01f, -1.07139289e-01f, -3.91167887e-02f, 2.04513237e-01f, -2.22732469e-01f,
  4.85834390e-01f, 4.52537596e-01f, 1.58372477e-01f, 4.97502208e-01f, 1.15943685e-01f, -4.71136533e-03f, 4.21858616e-02f, 5.20722121e-02f, -1.55107975e-01f, -4.34405833e-01f,
  7.09641799e-02f, 3.00717317e-02f, 1.66511476e-01f, 1.01636454e-01f, 2.48484343e-01f, 3.15398782e-01f, -1.08908318e-01f, 6.02008998e-01f, -2.18849629e-01f, 1.93899512e-01f,
  5.10022640e-01f, -1.71531588e-02f, -1.59020647e-01f, -2.30698749e-01f, 1.90765277e-01f, -2.92384215e-02f, -1.33889109e-01f, -2.72823036e-01f, -8.14734921e-02f, 7.46728331e-02f,
  1.54925855e-02f, 5.18365979e-01f, 8.40550810e-02f, 7.30155557e-02f, 4.80691671e-01f, -1.18291430e-01f, -2.69162893e-01f, -3.02512795e-01f, 2.38801986e-01f, 3.45900282e-02f,
  3.04606289e-01f, 3.00325692e-01f, 2.15204269e-01f, 1.13506943e-01f, 2.33283594e-01f, 3.37858289e-01f, 3.17544699e-01f, 1.17808573e-01f, 2.00932756e-01f, 3.06779951e-01f,
  -4.01750416e-01f, -1.82880104e-01f, 2.98613340e-01f, 1.77757204e-01f, 1.89205725e-02f, 1.52150378e-01f, 7.46944547e-02f, -2.03234211e-01f, -1.83003768e-01f, -9.07566845e-02f,
  2.42080852e-01f, 1.93395764e-01f, 5.12407422e-01f, 2.24895015e-01f, -1.12209253e-01f, -3.51989359e-01f, 2.01841608e-01f, -1.37422690e-02f, 2.35739902e-01f, 2.14683250e-01f,
  1.56704322e-01f, 1.15516603e-01f, 2.58848757e-01f, 1.47736922e-01f, 1.16872922e-01f, -4.45632860e-02f, 8.78799930e-02f, -1.10906132e-01f, -8.64218026e-02f, -3.22499722e-01f,
  1.35812670e-01f, -1.62881106e-01f, -6.59258142e-02f, -6.56917840e-02f, -3.04275751e-01f, -7.93123618e-02f, -4.74645533e-02f, 7.20265955e-02f, -4.79313470e-02f, 2.20497876e-01f,
  3.55541885e-01f, 5.50788581e-01f, -2.06665903e-01f, -7.41067529e-02f, 2.04164386e-01f, 6.26103627e-03f, 1.07116103e-01f, 1.62387282e-01f, -3.19683343e-01f, 3.44516993e-01f,
  2.23800123e-01f, 3.79506707e-01f, 3.52739662e-01f, 3.45874220e-01f, -5.03119409e-01f, -8.56080130e-02f, 6.88799098e-02f, 3.50909263e-01f, 8.95350352e-02f, -5.21181561e-02f,
  2.58356869e-01f, -1.58096358e-01f, -1.23909891e-01f, 2.39130810e-01f, 1.23628452e-01f, 3.83425772e-01f, 2.89993912e-01f, 9.38102901e-02f, 3.74857664e-01f, 4.78910804e-01f,
  -5.22851288e-01f, 1.63623169e-01f, 3.40131044e-01f, -1.64389908e-01f, -6.74813837e-02f, -3.31899434e-01f, -3.82229418e-01f, -6.49417788e-02f, -1.03767239e-01f, 1.79413348e-01f,
  -3.82337719e-01f, 9.40241292e-02f, -1.78546067e-02f, 3.39991450e-01f, 7.24120975e-01f, -2.31102228e-01f, 1.57467753e-01f, -6.75806776e-02f, 1.48282591e-02f, 1.16949029e-01f,
  3.86060141e-02f, -8.53799954e-02f, -2.20352739e-01f, -2.51612633e-01f, -2.39984497e-01f, -2.39248902e-01f, -2.50178784e-01f, 1.84187129e-01f, -4.40717749e-02f, -2.34967172e-01f,
  2.54936635e-01f, 1.44311935e-01f, -5.08242726e-01f, 5.82124114e-01f, 3.77850950e-01f, 4.49336827e-01f, -7.65269250e-02f, -4.04714823e-01f, -1.92855909e-01f, 1.08805165e-01f,
  -6.41017318e-01f, 4.20193002e-03f, -3.86637449e-01f, 6.69505075e-02f, -2.61705279e-01f, 9.28759053e-02f, 3.82036641e-02f, 2.93850660e-01f, 2.99682003e-02f, 2.79271245e-01f,
  2.34082922e-01f, 1.39088864e-02f, 1.49271458e-01f, 7.45423064e-02f, -1.54421434e-01f, 7.89448991e-02f, -1.52490661e-01f, -3.88583797e-03f, 1.53802708e-01f, -3.04413382e-02f,
  -9.77881327e-02f, -5.18013127e-02f, -1.48045003e-01f, -1.82885304e-01f, -9.06214342e-02f, 3.58245939e-01f, 1.18062347e-01f, -6.64596912e-03f, -3.43342125e-01f, 1.46776199e-01f,
  -1.00972004e-01f, 5.43525934e-01f, 7.73069039e-02f, 5.37095107e-02f, 2.45454222e-01f, -5.55800274e-02f, -2.39093959e-01f, 3.04403663e-01f, 3.65134507e-01f, 3.47854316e-01f,
  -2.99152434e-01f, 3.55850071e-01f, 2.44256169e-01f, 2.13537231e-01f, 1.58705845e-01f, -1.98602438e-01f, -1.83047816e-01f, -1.59330085e-01f, -1.99531898e-01f, 3.50256599e-02f,
  -1.65583059e-01f, -5.63871339e-02f, 2.59896874e-01f, 1.59001693e-01f, -1.67479694e-01f, 3.58750522e-01f, 4.43215370e-01f, 1.96923405e-01f, -3.28416288e-01f, 1.49888471e-01f,
  -5.92597961e-01f, -4.65033352e-01f, 1.33390039e-01f, -1.88803345e-01f, 5.51263094e-01f, 2.63392091e-01f, 2.96529859e-01f, 8.36828351e-02f, 1.03676066e-01f, -9.76727605e-02f,
  1.42096013e-01f, 1.10762566e-01f, -4.67549622e-01f, -3.58225226e-01f, 4.35801409e-02f, 1.94254637e-01f, -1.18992925e-01f, -1.17478386e-01f, 3.80752049e-02f, -1.37920663e-01f,
  -4.26912904e-02f, 1.89292565e-01f, 2.86183625e-01f, 9.32004899e-02f, -1.94927603e-01f, -1.47726750e-02f, -2.62786988e-02f, -2.15733320e-01f, 3.10929473e-02f, 2.64295042e-01f,
  1.54497817e-01f, 1.77436426e-01f, -3.63307148e-01f, -1.69887200e-01f, 1.46573871e-01f, -9.15661752e-02f, 3.12388778e-01f, 1.23357438e-01f, -3.32353681e-01f, -7.11765736e-02f,
  -2.33517945e-01f, 2.92474516e-02f, 4.78607029e-01f, 4.19365078e-01f, -2.67608047e-01f, -2.04204962e-01f, 4.03252840e-02f, 9.49304402e-02f, 7.16932416e-02f, -3.50792408e-01f,
  -8.59818086e-02f, 2.17170820e-01f, -3.93576056e-01f, 5.04934192e-01f, -3.11257154e-01f, -2.16398295e-02f, 5.09017587e-01f, 2.22306579e-01f, -2.89250672e-01f, 3.74355137e-01f,
  4.15648788e-01f, -2.01841220e-02f, -2.36114874e-01f, -1.77460060e-01f, -2.08476052e-01f, 2.21043363e-01f, 1.36201575e-01f, -1.30043387e-01f, 2.70280957e-01f, 7.10300580e-02f,
  3.34796935e-01f, 2.31704265e-01f, 2.08404921e-02f, -1.42674655e-01f, 3.21727931e-01f, -1.73417285e-01f, 6.86830804e-02f, 1.19528249e-02f, 1.83771059e-01f, 2.02256277e-01f,
  3.23355161e-02f, 1.61426663e-01f, -2.18950808e-01f, 7.94296488e-02f, 1.33787632e-01f, 1.61236584e-01f, 1.12234280e-01f, 3.92106265e-01f, -5.01300097e-02f, 2.40862191e-01f,
  1.97770402e-01f, 5.39767258e-02f, 2.99879998e-01f, -9.73579437e-02f, 1.06230029e-03f, 5.86914420e-01f, 2.15582460e-01f, 2.26857275e-01f, 1.48271188e-01f, -3.85741949e-01f,
  2.12268576e-01f, 4.08567578e-01f, 1.64081365e-01f, 5.88991404e-01f, 2.33416095e-01f, 1.37362003e-01f, -1.42446533e-01f, 1.27953723e-01f, 1.68504685e-01f, -3.32445860e-01f,
  2.85963416e-01f, 7.96580762e-02f, 2.32767999e-01f, -1.30399123e-01f, -8.33459853e-05f, 4.58578616e-01f, 1.29300669e-01f, 4.94078487e-01f, -2.81423688e-01f, -3.44161868e-01f,
  9.20042992e-02f, 2.82012850e-01f, -2.61582762e-01f, 2.70540863e-01f, 7.10571170e-01f, -9.34365243e-02f, -3.64735365e-01f, 1.35403387e-02f, 3.78114246e-02f, -1.87446430e-01f,
  5.53591192e-01f, 5.79245724e-02f, 4.13096517e-01f, 5.37354797e-02f, 3.23738307e-01f, 1.24602959e-01f, 3.09020787e-01f, -2.81086639e-02f, 2.94837318e-02f, -3.60546000e-02f,
  4.50567901e-02f, 3.36353813e-04f, 1.86948001e-01f, 2.58552134e-01f, -4.39504832e-02f, -3.26207802e-02f, -1.84450895e-01f, -1.57890663e-01f, 3.23871195e-01f, -2.67629355e-01f,
  -4.48049635e-01f, 2.82152176e-01f, 1.84736222e-01f, 1.77946895e-01f, 1.93397850e-01f, 1.53970689e-01f, -1.29765704e-01f, 3.12252462e-01f, 4.21765715e-01f, 2.70464748e-01f,
  3.49120557e-01f, -6.07040107e-01f, -3.60424727e-01f, 9.00033712e-02f, -1.47617295e-01f, -7.63029158e-02f, 1.08051404e-01f, 1.24579348e-01f, -3.49888414e-01f, -1.58140868e-01f,
  -1.02138877e-01f, -1.11152455e-01f, 3.33577842e-01f, 6.35986269e-01f, 1.86837196e-01f, 1.29248545e-01f, 1.95075721e-01f, 2.15103813e-02f, 2.65347123e-01f, -7.84121305e-02f,
  -4.59585823e-02f, -7.43272677e-02f, -7.65617564e-02f, 1.42637566e-01f, 8.20630044e-03f, -1.54349610e-01f, 3.85928839e-01f, -6.40763566e-02f, -3.58832657e-01f, 4.47449118e-01f,
  1.03211433e-01f, -4.01911944e-01f, -3.46037686e-01f, 4.68252264e-02f, -1.76374450e-01f, 3.67343426e-01f, -1.48660719e-01f, -7.56106004e-02f, 8.98934156e-02f, -3.86352092e-02f,
  -1.58312872e-01f, -2.08130628e-02f, 7.17382610e-01f, 2.54071169e-02f, 2.36262977e-01f, 4.20941651e-01f, 3.04839581e-01f, 3.76762412e-02f, 2.34402716e-01f, -1.51020348e-01f,
  -1.81891367e-01f, -1.86649722e-03f, -2.54977465e-01f, 3.17113250e-01f, 7.95107111e-02f, -2.54864126e-01f, 2.98075914e-01f, 2.86661446e-01f, -1.70887932e-01f, 6.06711954e-02f,
  1.39029041e-01f, 3.72940570e-01f, -1.39992520e-01f, -6.75328970e-02f, -3.96422595e-01f, -3.04840863e-01f, -1.61094964e-02f, 4.18112069e-01f, 3.54942411e-01f, -6.63717315e-02f,
  8.83593224e-03f, -2.81161636e-01f, -7.39251450e-02f, -2.70920604e-01f, 2.98374504e-01f, 1.93957865e-01f, 4.10110168e-02f, 4.90462959e-01f, 7.15675950e-02f, -3.99984628e-01f,
  2.87932336e-01f, 3.36141437e-01f, 2.03436911e-01f, 9.12836492e-02f, -1.95433460e-02f, 1.83099091e-01f, -3.65278907e-02f, -4.15867865e-01f, 1.62625521e-01f, 4.46041599e-02f,
  -4.35559422e-01f, -4.14221853e-01f, -8.02130252e-02f, 3.06094825e-01f, -1.47637337e-01f, -2.08120763e-01f, -2.66305745e-01f, -7.27982149e-02f, 4.25062209e-01f, 2.74724841e-01f,
  1.67329371e-01f, -6.79670051e-02f, -4.05965298e-01f, -2.25600243e-01f, 1.03192739e-01f, -4.34811134e-03f, -1.31394669e-01f, 1.12542041e-01f, 2.35702634e-01f, 2.95967877e-01f,
  6.62191510e-02f, 2.15499490e-01f, 2.65297927e-02f, 3.51259381e-01f, -3.58070880e-02f, -7.98814520e-02f, 6.10059202e-01f, -3.69737655e-01f, -3.38893123e-02f, 8.70120078e-02f,
  -6.71212077e-02f, 3.88497323e-01f, 7.78761134e-02f, 1.92755070e-02f, 1.13577783e-01f, 1.36980116e-01f, 4.18618172e-01f, 2.58479834e-01f, 5.90647578e-01f, -5.15216142e-02f,
  1.89089760e-01f, -1.54789507e-01f, 8.71213302e-02f, -1.81533232e-01f, 2.74489582e-01f, -3.88132453e-01f, 4.13244128e-01f, -1.06673818e-02f, -5.17759383e-01f, 1.51687503e-01f,
  2.13310927e-01f, -9.88015626e-03f, 1.35069266e-01f, 1.44915402e-01f, 7.33161494e-02f, 1.66347951e-01f, 6.76229820e-02f, -4.73511703e-02f, 1.93086788e-01f, 6.45322129e-02f,
  -1.91457465e-01f, 3.70929658e-01f, 2.44947746e-01f, 3.66374850e-01f, 4.67222363e-01f, -3.24318737e-01f, -3.46451759e-01f, 1.77914470e-01f, 1.49705842e-01f, 4.01755631e-01f,
  3.23477894e-01f, -1.46037340e-01f, -1.79400876e-01f, -1.67632792e-02f, 5.86529059e-05f, 5.57835281e-01f, 2.24403366e-01f, -4.96751592e-02f, -2.52278060e-01f, 2.52254367e-01f,
  5.91054678e-01f, 4.66968790e-02f, 3.00977319e-01f, -3.82240742e-01f, 9.35204178e-02f, 2.88879335e-01f, 2.61135697e-01f, 1.34037122e-01f, -1.18903041e-01f, 1.54602855e-01f,
  1.37677729e-01f, 2.09855646e-01f, 5.77328615e-02f, -2.84085125e-01f, -1.29774287e-01f, 1.26087338e-01f, -2.20821172e-01f, -2.41590470e-01f, 3.51871103e-01f, 2.46937662e-01f,
  -2.19961092e-01f, -1.61676988e-01f, -2.38006189e-01f, 1.33550942e-01f, 1.76978894e-02f, 5.54414749e-01f, 2.03990921e-01f, -4.73815091e-02f, 3.80783170e-01f, -2.36080647e-01f,
  -1.17761074e-02f, -2.29715094e-01f, 2.17807949e-01f, 8.47919062e-02f, 6.76177517e-02f, 2.68430173e-01f, 4.27995808e-02f, 1.29011244e-01f, 2.31890455e-01f, -2.05208305e-02f,
  2.64883079e-02f, 4.40226495e-02f, 1.47548273e-01f, -1.53655455e-01f, -1.57339290e-01f, 6.36447310e-01f, 4.25546587e-01f, 4.22208816e-01f, 3.22154820e-01f, -3.05189878e-01f,
  -3.82938012e-02f, 1.33283675e-01f, 3.94091249e-01f, 3.93052489e-01f, 3.29542339e-01f, 8.46636742e-02f, -2.69822896e-01f, -1.43076777e-02f, 1.42444044e-01f, 5.37853420e-01f,
  2.38795266e-01f, -2.58196563e-01f, -2.68266559e-01f, 5.74150821e-03f, 1.16270363e-01f, -8.12333450e-02f, 9.08000860e-03f, -6.94237649e-02f, 7.22310087e-03f, 3.57939392e-01f,
  1.15037598e-01f, 1.86258003e-01f, -2.65414506e-01f, -2.57347507e-04f, 4.55900937e-01f, -1.24136060e-01f, -1.90975040e-01f, 8.90280902e-02f, 2.34433144e-01f, 2.33539373e-01f,
  -4.54221964e-02f, 1.68381974e-01f, 2.05006495e-01f, -6.89363033e-02f, 1.83034122e-01f, 2.35410631e-01f, 3.90874982e-01f, 7.45958388e-02f, 3.42808336e-01f, 1.40211374e-01f,
  -2.20980957e-01f, -2.37265378e-01f, 1.83714539e-01f, 1.62881184e-02f, 3.52053583e-01f, 5.62754273e-03f, -2.92411715e-01f, 9.39487815e-02f, 1.66460633e-01f, 4.44902420e-01f,
  -4.81013395e-02f, 2.77294725e-01f, 2.34513760e-01f, -1.19799286e-01f, 1.97677761e-01f, 3.78850661e-02f, -3.19207400e-01f, 4.41371322e-01f, -2.45591909e-01f, 4.59860057e-01f,
  3.72053236e-01f, -1.25122204e-01f, 1.03670843e-01f, 5.74875474e-01f, 2.13014320e-01f, -8.96898061e-02f, 2.70412266e-01f, -2.50053316e-01f, -9.46391970e-02f, 3.24954540e-01f,
  -4.06164490e-02f, -1.27916977e-01f, 1.98975746e-02f, -7.93254077e-02f, -2.48493955e-01f, 4.72515315e-01f, 2.47904733e-01f, 3.35729808e-01f, 4.61459816e-01f, 4.99570649e-03f,
  1.50611565e-01f, 2.48259023e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.55145720e-01f, -1.01419449e-01f, -3.60768586e-02f, -1.34222865e-01f, -1.89330205e-02f, 3.58631879e-01f, 3.25370848e-01f, 8.92339870e-02f, 1.09406285e-01f, -4.45065647e-02f,
  3.07522476e-01f, 1.66153476e-01f, 2.61345897e-02f, 6.91421423e-03f, -2.40257978e-02f, 1.22736111e-01f, -1.18707880e-01f, 5.09589553e-01f, 4.45356399e-01f, 1.12273633e-01f,
  4.21416014e-02f, 1.40915737e-01f, 3.31785738e-01f, 1.67594910e-01f, 1.21430337e-01f, 1.87672198e-01f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  2.95378029e-01f, 2.06505537e-01f, -1.81509957e-01f, -2.45019928e-01f, -2.95668304e-01f, -2.63116002e-01f, 1.23970225e-01f, -2.08680481e-01f, 1.74617618e-02f, -1.55424118e-01f,
  3.70674245e-02f, 2.78558969e-01f, -7.73271024e-02f, -1.28772318e-01f, -9.71305072e-02f, 1.12947665e-01f, 2.37185434e-02f, -1.20123453e-01f, 6.32106140e-02f, 2.78830677e-02f,
  -1.36023387e-01f, 4.23011407e-02f, -2.75097601e-02f, 5.26267737e-02f, 2.26565331e-01f, 7.41822124e-02f, 1.93134382e-01f, -1.57485902e-01f, 1.78625464e-01f, 1.85330719e-01f,
  1.02821067e-01f, -2.91351050e-01f, 1.30401611e-01f, -6.00190945e-02f, -3.79391275e-02f, -2.13295057e-01f, 1.86509057e-03f, -2.47037206e-02f, -2.77374517e-02f, 7.93694425e-03f,
  -1.35115355e-01f, 2.04201192e-01f, -5.67624308e-02f, 3.05965841e-02f, -3.68797705e-02f, -1.12371534e-01f, 2.06737414e-01f, 1.90779775e-01f, -8.21468830e-02f, 1.49483636e-01f,
  -6.73318282e-02f, 1.14562288e-01f, 1.18463740e-01f, -3.13302130e-01f, -2.92202353e-01f, 2.11591154e-01f, -2.64941659e-02f, -2.99725070e-04f, -3.15788388e-01f, 6.72452673e-02f,
  -2.46024057e-01f, -4.89607230e-02f, -1.27655417e-01f, 3.76716375e-01f, 3.99016023e-01f, 1.10926062e-01f, -1.88173645e-03f, 9.38897878e-02f, 2.87294835e-01f, 5.17729461e-01f,
  -1.18115462e-01f, -2.61425730e-02f, -1.48128569e-01f, 6.13462850e-02f, -6.29673526e-02f, 7.60980099e-02f, 5.00451997e-02f, 1.65655956e-01f, 1.22641042e-01f, -3.06829333e-01f,
  -1.11156590e-01f, 1.92470685e-01f, 7.72482157e-02f, 2.60801241e-02f, -1.25040144e-01f, 3.60804014e-02f, -1.39784262e-01f, 1.01601198e-01f, 2.23245293e-01f, 1.22037150e-01f,
  -7.64745846e-02f, -1.27608314e-01f, -1.80591661e-02f, -1.59396301e-03f, -8.22548270e-02f, 1.17451787e-01f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  2.13149607e-01f, 1.15821436e-01f, 2.75033057e-01f, -9.62627009e-02f, 5.64652860e-01f, 4.23616588e-01f, 6.18223893e-03f, -8.12924653e-02f, 3.28049928e-01f, 1.85014401e-02f,
  5.34389950e-02f, 3.56851667e-02f, 3.23205680e-01f, -3.43552381e-02f, -4.93417591e-01f, 1.96624130e-01f, 1.04327433e-01f, 1.33733258e-01f, -2.88014058e-02f, -1.92846343e-01f,
  7.14090243e-02f, 3.75884652e-01f, 2.51756627e-02f, 2.99865399e-02f, 2.90269941e-01f, 5.76593459e-01f, -1.52324028e-02f, -5.78927875e-01f, 2.78702825e-01f, -3.05834025e-01f,
  3.37530583e-01f, 1.47197589e-01f, -5.19094467e-01f, 5.65448776e-02f, -2.86056846e-01f, -6.76947981e-02f, 4.96957988e-01f, -3.95928055e-01f, 5.26185706e-02f, -9.98475924e-02f,
  -4.70426008e-02f, 4.31873322e-01f, -5.54880649e-02f, 2.37619057e-01f, -4.25180346e-01f, 1.25598945e-02f, 4.12718713e-01f, -8.75403918e-03f, -3.30107175e-02f, -3.38413358e-01f,
  1.36001026e-02f, -1.37773633e-01f, 3.47831286e-02f, -3.89989078e-01f, 5.38345464e-02f, 2.29948059e-01f, -3.44203487e-02f, -2.57022381e-01f, 7.03232288e-02f, 2.03900054e-01f,
  -4.50515598e-01f, 2.98881531e-01f, -3.17376591e-02f, 4.02979106e-02f, 1.98637202e-01f, 2.62279689e-01f, 4.18168098e-01f, -2.26666243e-03f, -2.59109437e-01f, 4.45584834e-01f,
  -4.47580852e-02f, -5.57333268e-02f, -3.97726476e-01f, -3.49435173e-02f, 5.20753205e-01f, 1.28405076e-02f, -4.41858083e-01f, 3.98417234e-01f, 3.20005387e-01f, 4.08737659e-01f,
  6.46749511e-02f, 9.12309945e-01f, -1.67969596e-02f, 3.98817152e-01f, -1.16154905e-02f, 3.57516795e-01f, -5.07613242e-01f, 1.72406465e-01f, 4.44861770e-01f, 1.80687591e-01f,
  -2.89117008e-01f, 5.73520176e-02f, -9.86356810e-02f, 2.13987216e-01f, -3.09131622e-01f, 2.24431723e-01f, 2.29962677e-01f, 3.66747946e-01f, 5.90818077e-02f, -1.14811957e-01f,
  4.79356170e-01f, 6.87184870e-01f, -3.77453230e-02f, 4.97436561e-02f, 1.91167086e-01f, 3.48445289e-02f, -2.54628956e-01f, -9.01774019e-02f, -1.88167039e-02f, 2.53262073e-01f,
  4.61743116e-01f, 9.27733839e-01f, 3.88720274e-01f, -2.62699723e-01f, -6.93907142e-02f, -2.11920455e-01f, -2.38245383e-01f, -2.89377242e-01f, 3.69648159e-01f, 4.67075795e-01f,
  2.75696069e-01f, 9.78890136e-02f, -4.48706895e-02f, 1.16888605e-01f, 1.08567782e-01f, 2.15347305e-01f, 1.23114705e-01f, 2.38797903e-01f, 3.31586063e-01f, -2.30501872e-02f,
  2.01139793e-01f, -2.15562522e-01f, -7.95436859e-01f, -9.32060480e-02f, 2.16903567e-01f, 7.38122463e-02f, -1.39228165e-01f, -4.86884154e-02f, 2.10557029e-01f, 3.31433833e-01f,
  3.04691762e-01f, -2.21492752e-01f, -1.18562944e-01f, -2.87238419e-01f, 1.59775108e-01f, 5.22993028e-01f, 2.27759391e-01f, 5.14455199e-01f, 1.31766170e-01f, 5.42308867e-01f,
  -1.61238477e-01f, -2.39416853e-01f, 2.22239956e-01f, 2.04302266e-01f, -1.43045306e-01f, -7.56423315e-03f, 2.67274618e-01f, -1.12329073e-01f, 6.95348009e-02f, -8.44978616e-02f,
  4.92330305e-02f, 4.52076972e-01f, 3.06433231e-01f, 2.80828565e-01f, -1.61459863e-01f, -2.57242650e-01f, 1.49400542e-02f, 3.85804884e-02f, 1.36557654e-01f, 5.08322060e-01f,
  -6.54394478e-02f, 4.47420739e-02f, 2.96029270e-01f, -2.67930090e-01f, 2.70288080e-01f, -6.60441458e-01f, -2.35435218e-01f, 1.08480506e-01f, -3.79770994e-03f, 5.27047336e-01f,
  -5.37278540e-02f, 2.03286801e-02f, -2.46619493e-01f, 2.18128845e-01f, -4.46227081e-02f, 9.65909958e-02f, -3.30086857e-01f, 2.65398055e-01f, -1.40116513e-01f, 6.81474432e-03f,
  -1.67903930e-01f, 2.87479699e-01f, 3.38836223e-01f, 4.28612977e-02f, 3.83737296e-01f, 2.07984120e-01f, -1.66413307e-01f, 3.46294582e-01f, -1.30283698e-01f, 1.04428187e-01f,
  1.96292311e-01f, -1.17079832e-01f, -1.96254000e-01f, 3.94029915e-01f, 3.63184452e-01f, -1.21716633e-01f, -4.61367965e-01f, -3.31026286e-01f, 1.81719467e-01f, -1.10124134e-01f,
  2.82814026e-01f, -8.31009448e-02f, -7.25959986e-02f, 3.28286201e-01f, -2.16688707e-01f, 3.00984323e-01f, 6.92555755e-02f, 4.17580158e-01f, 3.49349231e-02f, -3.73638630e-01f,
  3.27252090e-01f, -4.39537108e-01f, 1.37092948e-01f, 1.64605416e-02f, -2.40245268e-01f, 2.23137811e-01f, 2.27802381e-01f, 1.27943531e-02f, -1.09859288e-01f, -4.67595398e-01f,
  1.92198321e-01f, 9.70586762e-02f, 1.48254916e-01f, 3.72707605e-01f, 9.13762823e-02f, 1.55187994e-01f, 1.38295844e-01f, -3.34407240e-01f, -2.46870145e-01f, -3.40689778e-01f,
  -1.87152237e-01f, -1.85511664e-01f, 9.46967378e-02f, 3.22357148e-01f, 2.11840585e-01f, 3.83886188e-01f, 2.67013133e-01f, -2.96105534e-01f, 7.23496303e-02f, 5.84630966e-02f,
  2.96317339e-01f, 2.63745457e-01f, -1.10686265e-01f, 3.68740559e-01f, 3.72788370e-01f, -1.96495026e-01f, -6.74895421e-02f, 3.38646680e-01f, 4.00424570e-01f, 3.99974555e-01f,
  -2.61251628e-02f, -1.33246547e-02f, -4.61439602e-02f, 2.39538644e-02f, 3.25062394e-01f, -2.71096438e-01f, -1.81189939e-01f, 1.29300535e-01f, 3.22787017e-01f, -9.51569825e-02f,
  2.39824951e-01f, -4.66106124e-02f, -9.57066342e-02f, 1.10536367e-01f, -3.05712968e-01f, 4.37789440e-01f, -1.69065893e-01f, 1.29542708e-01f, 3.67026627e-02f, 3.95602733e-01f,
  3.13149452e-01f, 8.57680514e-02f, 1.33159846e-01f, -3.06240439e-01f, -9.22208279e-02f, -2.38350015e-02f, 3.01227987e-01f, 4.57056463e-01f, -5.56879193e-02f, 3.59722465e-01f,
  2.11587152e-03f, -1.39931023e-01f, -5.42445838e-01f, -5.91221273e-01f, 2.75605582e-02f, -7.79348537e-02f, 2.98314393e-01f, 2.37827286e-01f, -1.98106572e-01f, 4.59325582e-01f,
  4.01845843e-01f, -3.03841233e-01f, -7.14413747e-02f, -3.56012195e-01f, 1.97584197e-01f, -3.84604156e-01f, -1.62260354e-01f, 1.68356746e-01f, -1.78153500e-01f, 1.04200758e-01f,
  1.83511898e-02f, 5.97718731e-02f, 1.21200114e-01f, -9.38941911e-03f, -2.61120409e-01f, 6.80643693e-02f, 1.83729991e-01f, -7.68553093e-02f, -7.59456456e-02f, 1.84946194e-01f,
  4.56744432e-02f, -1.82801053e-01f, -5.11133783e-02f, 1.11221485e-01f, -1.32242246e-02f, 8.91223624e-02f, -7.98832327e-02f, 7.95745999e-02f, 8.58223590e-04f, -2.97554165e-01f,
  1.10887483e-01f, 7.15986937e-02f, 5.30298799e-02f, 4.74535003e-02f, -6.14096038e-02f, 1.08242594e-02f, 7.88959116e-02f, 1.51220679e-01f, -9.37286988e-02f, -4.45837714e-02f,
  -2.05169931e-01f, 4.25046943e-02f, -2.55451292e-01f, -8.65677968e-02f, -2.65595820e-02f, -7.26891309e-02f, -1.46283269e-01f, 1.17641784e-01f, 1.91317812e-01f, 2.89503127e-01f,
  -1.28475334e-02f, -1.42655998e-01f, -2.56890774e-01f, 1.19759202e-01f, -1.55176222e-01f, 1.45468175e-01f, 1.66901469e-01f, -1.66063964e-01f, -9.84398052e-02f, 1.73176944e-01f,
  1.57198742e-01f, -8.31529573e-02f, 6.05093837e-02f, -1.15632899e-01f, 5.59659839e-01f, 1.74461529e-02f, -8.28650519e-02f, 1.95463330e-01f, -3.09963912e-01f, 2.96605267e-02f,
  -2.91912585e-01f, 3.08014899e-01f, 2.03546539e-01f, 4.34198529e-01f, 4.04526412e-01f, -3.00649434e-01f, -6.14023320e-02f, -3.54063436e-02f, 3.62517893e-01f, -2.60937624e-02f,
  9.04130414e-02f, -1.04947709e-01f, 5.26205480e-01f, -2.21045949e-02f, 3.81390810e-01f, 5.36065400e-01f, 6.04769647e-01f, -1.21681251e-01f, -6.87389553e-01f, -2.53851384e-01f,
  -2.16962233e-01f, -2.16826022e-01f, 1.87093560e-02f, -2.31960207e-01f, -4.64513078e-02f, 5.80400169e-01f, 3.14333290e-01f, -1.56020254e-01f, 1.81459635e-01f, -2.25430071e-01f,
  2.70566507e-03f, -7.84581974e-02f, -1.39447585e-01f, 2.19534367e-01f, -2.90219635e-01f, 2.32000127e-02f, 1.45486325e-01f, 5.57480276e-01f, 1.27294108e-01f, 1.40292808e-01f,
  -7.74843544e-02f, 3.49965282e-02f, 4.31303144e-01f, -1.12840973e-01f, -6.90796301e-02f, 1.79447636e-01f, -5.03308363e-02f, 1.37493268e-01f, 3.35515626e-02f, -4.51726913e-02f,
  -4.94530350e-01f, -4.74708527e-01f, 5.05519211e-01f, 1.64844453e-01f, 2.31967837e-01f, -2.81990081e-01f, 1.82229638e-01f, 2.07056552e-01f, 2.54886806e-01f, -2.92868733e-01f,
  -3.97988409e-01f, -3.27414989e-01f, 2.89376713e-02f, -2.34223641e-02f, -2.67447352e-01f, 3.15827131e-01f, 3.36273849e-01f, 3.77579778e-01f, 4.19819444e-01f, -2.44783700e-01f,
  -1.44572169e-01f, -1.86473161e-01f, 5.60244143e-01f, 3.43143702e-01f, 2.45643064e-01f, 3.65417808e-01f, 6.59420788e-01f, -1.44566670e-01f, -8.25610682e-02f, 1.37940913e-01f,
  1.82355344e-01f, 3.77866924e-01f, 7.92532980e-01f, 2.53716409e-01f, -2.44715899e-01f, 4.22793120e-01f, 3.13075572e-01f, 6.05714321e-01f, 1.95538878e-01f, -4.06489223e-01f,
  -6.97423220e-02f, 4.50301021e-01f, 1.67604730e-01f, 5.98769844e-01f, 1.93994224e-01f, -5.50922100e-03f, 6.47984147e-02f, 1.50060043e-01f, 3.59593868e-01f, 2.61836275e-02f,
  -1.36826336e-02f, 4.14227657e-02f, -4.42253239e-02f, 1.06084421e-01f, -1.32082803e-02f, -1.42104521e-01f, -3.20951164e-01f, -2.66886503e-01f, -1.86437488e-01f, 5.67864478e-01f,
  3.18224169e-02f, 1.23458549e-01f, 1.95571423e-01f, -1.31962538e-01f, -5.01139998e-01f, -6.17466681e-02f, 9.84857753e-02f, 8.19774643e-02f, -2.19254509e-01f, 4.98320878e-01f,
  2.44781733e-01f, 3.94350439e-01f, -1.79051265e-01f, -2.34655961e-02f, 3.66850078e-01f, -1.94769099e-01f, -5.65068983e-02f, 2.67534137e-01f, 7.95101002e-02f, 6.89512074e-01f,
  3.09355617e-01f, 2.07331598e-01f, -3.25451434e-01f, 5.79206832e-02f, 2.87653524e-02f, -1.80266321e-01f, -3.69766414e-01f, 4.36927348e-01f, 1.62962332e-01f, 3.13912392e-01f,
  -4.86353815e-01f, 4.90546048e-01f, 4.36106920e-01f, 1.41102165e-01f, 4.89461958e-01f, -3.05254370e-01f, -7.89605618e-01f, 1.85488418e-01f, 2.34071925e-01f, -3.17286909e-01f,
  1.08924275e-02f, -1.68781355e-01f, -1.87728360e-01f, 5.93952119e-01f, -1.47004286e-02f, -1.54834017e-01f, -8.82462785e-02f, -2.97812253e-01f, 4.04958963e-01f, 1.27831534e-01f,
  -8.98809880e-02f, 3.79491180e-01f, -1.02816232e-01f, 2.32864842e-01f, -4.78493646e-02f, 1.88182622e-01f, 3.17777604e-01f, -6.28629997e-02f, -1.55982420e-01f, -1.15268238e-01f,
  4.04855788e-01f, 7.05552474e-02f, 1.21915318e-01f, 1.95320517e-01f, -3.64844427e-02f, -6.78307712e-02f, -4.33839262e-02f, 3.68916430e-02f, 9.08588916e-02f, -1.50542036e-01f,
  -2.38729939e-02f, -1.92489102e-01f, 3.96137796e-02f, -1.30153000e-01f, 7.45270774e-02f, -1.60690024e-01f, 4.06823400e-03f, 2.73818187e-02f, -1.65585518e-01f, 5.79020567e-02f,
  -8.81410763e-02f, -1.09857038e-01f, 9.71931368e-02f, -1.52684689e-01f, -1.22746944e-01f, -1.07122913e-01f, 1.17086940e-01f, -1.54886767e-01f, -1.52952969e-01f, 2.39028577e-02f,
  -1.64969280e-01f, 3.41437117e-04f, 1.04376927e-01f, -1.06025979e-01f, 2.01169606e-02f, 1.57644171e-02f, 4.60832603e-02f, 1.99323907e-01f, -1.15782265e-02f, 5.23331523e-01f,
  2.83289161e-02f, 6.61976159e-01f, -2.69933313e-01f, 9.84941274e-02f, -1.74171269e-01f, 3.20230760e-02f, -4.19435836e-03f, -1.56814560e-01f, 3.98094386e-01f, 1.58201709e-01f,
  4.01513100e-01f, -5.56107461e-02f, 8.17948803e-02f, 1.01852030e-01f, 2.63581246e-01f, 1.31573156e-01f, -1.16715200e-01f, 2.01296210e-01f, -4.67622548e-01f, 3.62931669e-01f,
  1.24215133e-01f, 3.21122199e-01f, 1.64364427e-01f, 1.38119549e-01f, 3.07158828e-02f, -1.86550301e-02f, -4.00343746e-01f, 2.04318598e-01f, 4.77130443e-01f, 3.15885544e-01f,
  3.07045221e-01f, -3.38560790e-01f, 1.43333346e-01f, 3.41198027e-01f, -2.61929184e-01f, -3.01877022e-01f, 2.21846864e-01f, -1.39178932e-01f, -4.42625195e-01f, 2.65300512e-01f,
  2.30757222e-01f, -2.96371188e-02f, 7.20558837e-02f, 6.09010398e-01f, 2.42824391e-01f, -1.12332039e-01f, -6.83355182e-02f, -3.88241917e-01f, -2.52941519e-01f, 4.97874022e-02f,
  2.27400362e-01f, 3.95171523e-01f, 3.04037809e-01f, 4.13705885e-01f, -1.15963720e-01f, -4.04807895e-01f, 2.48255849e-01f, -8.47946480e-02f, 2.46661991e-01f, 9.51506197e-02f,
  2.39386722e-01f, -2.43483335e-01f, 8.98630768e-02f, 1.50643829e-02f, 1.87050328e-01f, 6.03417099e-01f, 5.72715253e-02f, 2.58972228e-01f, 1.21840030e-01f, -4.91385162e-01f,
  -1.02456063e-01f, -2.37891272e-01f, 1.24194268e-02f, 3.83499354e-01f, 4.35637832e-02f, 6.56330645e-01f, 3.42359394e-01f, -5.09429052e-02f, 4.11029041e-01f, -4.99781609e-01f,
  -5.14138006e-02f, -8.08280259e-02f, 9.27396864e-02f, 2.29500383e-01f, 3.29958111e-01f, 2.95513183e-01f, 2.53678411e-01f, 1.21288337e-01f, 4.54799801e-01f, -1.47567913e-01f,
  -2.68099811e-02f, -2.79566258e-01f, 6.79689348e-02f, 5.40903248e-02f, 5.15729934e-02f, 9.92393270e-02f, -5.87603271e-01f, 1.77790493e-01f, 1.32073358e-01f, 4.50794250e-01f,
  -8.58064070e-02f, -2.19918594e-01f, 5.34163535e-01f, 1.01743117e-01f, 3.56218427e-01f, 4.02828068e-01f, -5.09703577e-01f, -1.36530502e-02f, 1.77136928e-01f, 4.88995224e-01f,
  3.15694250e-02f, 2.00959280e-01f, 2.41884366e-01f, 5.10291755e-01f, -2.24116594e-01f, -4.86889243e-01f, -1.59852535e-01f, -1.79729328e-01f, 1.80848569e-01f, 2.27342263e-01f,
  4.05964911e-01f, 1.41091868e-01f, 2.68805355e-01f, -4.07767892e-01f, -2.90143102e-01f, 4.11988467e-01f, 4.24879462e-01f, 4.55835849e-01f, -6.93550659e-03f, 6.91841096e-02f,
  -1.89138055e-01f, -1.82153225e-01f, 2.30333194e-01f, -1.72016740e-01f, 1.59948006e-01f, 2.44007707e-02f, 5.38340747e-01f, 8.86762813e-02f, 1.03297032e-01f, -2.01415300e-01f,
  -2.87275404e-01f, 2.98134625e-01f, -3.46793681e-01f, 4.63219613e-01f, 1.73066538e-02f, 4.55961525e-01f, -1.85260177e-01f, -1.98498257e-02f, -1.15671307e-01f, -6.83373064e-02f,
  1.49822906e-01f, -2.28719801e-01f, -1.91060066e-01f, -3.75391155e-01f, 2.69269109e-01f, 4.83013958e-01f, 2.33464941e-01f, -1.94334075e-01f, -3.03164870e-01f, -1.47562474e-01f,
  -7.45125785e-02f, -2.20005646e-01f, 3.31589013e-01f, 2.83552390e-02f, 1.91246390e-01f, 2.62997240e-01f, 1.75836012e-01f, 5.18757738e-02f, -2.46372148e-01f, 2.11374536e-01f,
  3.56410712e-01f, 5.41588306e-01f, 3.02579790e-01f, -2.08443012e-02f, 2.10037366e-01f, -5.67818046e-01f, 2.73017406e-01f, -3.16783965e-01f, 5.20867288e-01f, 2.24930212e-01f,
  -4.95924018e-02f, -7.31525570e-02f, 1.47948697e-01f, 4.88167971e-01f, -1.78440418e-02f, 2.21750319e-01f, -2.05434382e-01f, -2.43192673e-01f, 6.02972209e-01f, 2.55585492e-01f,
  1.52516380e-01f, 1.77761003e-01f, -4.69772547e-01f, 3.78445834e-01f, 1.75357416e-01f, -1.05801541e-02f, -1.34143457e-01f, -1.60169601e-01f, -1.99773479e-02f, 1.11164168e-01f,
  2.65968323e-01f, 4.76082414e-02f, 9.17951763e-02f, -3.93749028e-01f, 2.60670602e-01f, -1.17954407e-02f, 4.01508689e-01f, -8.16770084e-03f, -1.46725506e-01f, 8.36740509e-02f,
  -7.07668006e-01f, 4.31178540e-01f, 1.84018984e-01f, 4.23577391e-02f, -6.96779117e-02f, 1.10918656e-01f, 3.93295765e-01f, -2.79247505e-03f, -1.38692662e-01f, -2.19867334e-01f,
  -2.85754260e-02f, 2.14036554e-01f, -1.24633782e-01f, -1.53125927e-01f, 3.22324157e-01f, -3.85034561e-01f, 3.42621505e-02f, 1.03789419e-01f, 4.82276887e-01f, 7.06830680e-01f,
  -7.54180104e-02f, 3.70134935e-02f, -8.99920762e-02f, -3.33060101e-02f, 6.41938567e-01f, 3.29158902e-01f, 1.95133071e-02f, -3.67020607e-01f, 5.44169508e-02f, -2.51008391e-01f,
  9.57527489e-04f, -3.20178896e-01f, 5.58495402e-01f, 3.08561504e-01f, -1.55147687e-01f, -2.15038106e-01f, 3.15309942e-01f, 1.99978814e-01f, -2.51448095e-01f, 3.54984432e-01f,
  2.92179763e-01f, 4.38544929e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  1.64969876e-01f, -1.50597587e-01f, 2.06210881e-01f, 2.09556982e-01f, 2.07307339e-01f, 1.35769427e-01f, 3.53764862e-01f, -1.35272950e-01f, 2.77641535e-01f, -3.52625251e-02f,
  -1.40920971e-02f, -9.23715159e-02f, 2.38505617e-01f, -4.96856049e-02f, 3.58898342e-02f, -7.07321092e-02f, 1.01059206e-01f, 4.49780235e-03f, 2.97735304e-01f, 3.04914147e-01f,
  2.47333631e-01f, 2.57313289e-02f, 6.67178407e-02f, -1.43864617e-01f, 2.84908921e-01f, -1.43357813e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  2.95121491e-01f, -1.84854031e-01f, 2.18078084e-02f, -2.16170430e-01f, 1.52396515e-01f, -1.38948306e-01f, -2.96680391e-01f, 4.57221091e-01f, -5.28984547e-01f, -1.02868401e-01f,
  -6.04489446e-01f, 8.35004598e-02f, -2.15963766e-01f, 2.27093160e-01f, -1.39463350e-01f, -3.23836948e-03f, -3.31288800e-02f, -2.53096581e-01f, -4.73154813e-01f, 3.93124744e-02f,
  -8.63848196e-04f, -4.97184061e-02f, -5.87437034e-01f, -1.47538468e-01f, -1.92651734e-01f, -5.37116826e-01f, -2.94389606e-01f, -3.33537877e-01f, -4.43737179e-01f, 2.64829755e-01f,
  1.16332151e-01f, 2.43658990e-01f, -5.69547415e-02f, 8.32939595e-02f, 8.22530165e-02f, -3.89260322e-01f, 4.67958413e-02f, -1.11137435e-01f, 3.91050577e-02f, 7.70023316e-02f,
  1.81062460e-01f, 1.17398493e-01f, -1.16263166e-01f, -3.62502426e-01f, -1.80749327e-01f, -6.23790979e-01f, -4.47306693e-01f, -5.54623723e-01f, -1.10440284e-01f, -4.47722554e-01f,
  -4.61659789e-01f, -5.54959476e-01f, 3.60870123e-01f, 1.66575462e-01f, -4.96921271e-01f, 1.43832117e-01f, 4.44141515e-02f, -3.10779303e-01f, 1.36563167e-01f, -2.32395455e-02f,
  -5.08548260e-01f, 3.11028540e-01f, -2.38734052e-01f, 1.54695675e-01f, -9.16330963e-02f, -8.55313323e-04f, 2.16604665e-01f, 8.58029053e-02f, 2.29333997e-01f, -5.27778924e-01f,
  2.56104439e-01f, -8.25582519e-02f, -1.33901432e-01f, 3.01484287e-01f, -3.58390301e-01f, -6.79391325e-01f, -3.38216349e-02f, -1.91682160e-01f, 2.47731403e-01f, -5.40051498e-02f,
  -8.08670893e-02f, -1.58416748e-01f, 2.15592310e-01f, -1.57213174e-02f, 2.14801505e-02f, -3.77101809e-01f, 1.91814899e-01f, -4.71857339e-02f, -3.31248224e-01f, 1.66949749e-01f,
  3.12416051e-02f, -6.07839346e-01f, -2.00498417e-01f, 5.62938005e-02f, -8.66919756e-01f, 2.67583430e-01f, -3.72039884e-01f, 1.35678619e-01f, -1.00423940e-01f, -1.54020086e-01f,
  -4.24645931e-01f, -1.27954125e-01f, 1.41836498e-02f, -2.80881882e-01f, -3.72126013e-01f, -7.13635743e-01f, 8.13953876e-02f, -9.26349461e-01f, -5.04671454e-01f, 2.81471312e-01f,
  -4.87399668e-01f, -2.11965129e-01f, -2.99463309e-02f, 3.35923851e-01f, -5.54523706e-01f, 3.10387939e-01f, -3.54604095e-01f, -2.45337456e-01f, -2.82922059e-01f, 1.44910857e-01f,
  -6.06091857e-01f, -3.75588477e-01f, -8.45732018e-02f, 3.08290273e-01f, -1.64205208e-01f, 1.43293485e-01f, -8.50989640e-01f, 4.55144383e-02f, -2.54029006e-01f, 1.85133979e-01f,
  -4.28804636e-01f, 4.43852544e-01f, 1.55071527e-01f, -1.50516227e-01f, -4.01925325e-01f, -8.65082592e-02f, -6.99496031e-01f, -4.25613731e-01f, 1.06737070e-01f, -7.34296367e-02f,
  -1.27851907e-02f, 4.16336767e-02f, -9.27774161e-02f, 4.68271762e-01f, -4.56228890e-02f, -9.72445905e-02f, 3.07315499e-01f, 1.72841504e-01f, -3.09207529e-01f, 3.39387245e-02f,
  2.03869924e-01f, 2.45255399e-02f, -2.62064308e-01f, -4.32792068e-01f, -1.74199238e-01f, -7.22154826e-02f, -8.36633071e-02f, 1.67740807e-01f, 2.07038611e-01f, 7.49499351e-02f,
  4.46506619e-01f, -5.77114336e-02f, 4.02790308e-02f, -2.64824420e-01f, 3.93538326e-01f, 6.38819784e-02f, -4.87838864e-01f, -3.39381129e-01f, 1.48553014e-01f, -7.34429583e-02f,
  1.23415686e-01f, 3.18528742e-01f, -4.53061551e-01f, -3.18027526e-01f, 1.18296467e-01f, -3.87013018e-01f, 1.79620028e-01f, -7.17721701e-01f, 3.05411011e-01f, -2.34540120e-01f,
  -2.40828127e-01f, 2.35242680e-01f, 3.10004532e-01f, 1.20796345e-01f, 3.00593257e-01f, -4.39020365e-01f, 1.42668299e-02f, -1.05468243e-01f, -9.51769054e-02f, -4.48494181e-02f,
  2.64569223e-01f, -1.57080013e-02f, -5.46974642e-03f, -3.07835285e-02f, 5.45249134e-03f, 2.64290959e-01f, -2.18999684e-01f, 6.41272068e-01f, 2.60898590e-01f, -3.97869170e-01f,
  2.08981894e-02f, 4.22385603e-01f, -9.73900631e-02f, -4.65706855e-01f, 2.81388998e-01f, -6.00555837e-01f, 5.60069270e-02f, 1.10545360e-01f, -2.66089104e-02f, -5.21884263e-01f,
  2.02148393e-01f, -5.64264059e-01f, -1.34067401e-01f, -7.22018361e-01f, 2.37468302e-01f, 6.17514588e-02f, 5.68456063e-03f, 4.86151814e-01f, 3.25982213e-01f, -3.36709291e-01f,
  -1.58419341e-01f, -2.67097801e-01f, 4.16277587e-01f, -5.48246205e-01f, 1.18335873e-01f, -2.69469827e-01f, -2.66130924e-01f, 1.89776123e-01f, -2.94425309e-01f, -9.89476964e-02f,
  2.33458355e-01f, -6.45735383e-01f, 1.02381587e-01f, -6.27856910e-01f, 3.22872370e-01f, -4.67770785e-01f, 2.36911774e-01f, 6.59905653e-03f, -7.39892200e-02f, -4.66084421e-01f,
  -3.11873741e-02f, -1.04610818e-02f, -5.32669663e-01f, 8.65115151e-02f, 4.00933102e-02f, -2.99358845e-01f, -1.66597158e-01f, 1.16429634e-01f, 1.24862090e-01f, -3.79561216e-01f,
  2.24538073e-01f, 1.48109064e-01f, -5.71934469e-02f, 2.53798091e-03f, 2.14864552e-01f, -6.29347682e-01f, -4.71124232e-01f, -1.23543762e-01f, -1.99225947e-01f, -9.86089483e-02f,
  3.56377661e-01f, 2.59526312e-01f, -1.15730196e-01f, -6.35141015e-01f, 3.44468564e-01f, -5.31695664e-01f, 1.27756774e-01f, 7.81693310e-02f, -5.36341727e-01f, -4.65059072e-01f,
  2.49139905e-01f, -3.92106414e-01f, 6.52643340e-03f, 2.28171989e-01f, -4.38025355e-01f, -3.03742200e-01f, 3.20885152e-01f, 1.76123828e-01f, -3.18092585e-01f, -1.18278265e-02f,
  6.29160032e-02f, -1.79320782e-01f, -5.91877043e-01f, 2.96453219e-02f, 6.01892114e-01f, -5.29700160e-01f, -6.45450771e-01f, -3.28513324e-01f, 3.40966880e-01f, 9.94710922e-02f,
  2.65595704e-01f, 1.38990283e-01f, 1.93238109e-01f, 3.93601239e-01f, 2.68663526e-01f, -6.38720512e-01f, 3.80268246e-02f, -2.06106678e-01f, 2.49390602e-01f, 4.43336010e-01f,
  1.60148293e-01f, 8.51490051e-02f, 1.50303930e-01f, 2.72523046e-01f, -2.82848716e-01f, -3.36706102e-01f, 2.33538911e-01f, -2.66335458e-01f, 3.67209874e-02f, -4.34057228e-02f,
  2.74637818e-01f, -1.52847245e-01f, -8.12000036e-02f, 1.42680749e-01f, -3.80684465e-01f, -3.03270698e-01f, 1.99045151e-01f, -5.94124138e-01f, -2.08403990e-01f, -7.27297589e-02f,
  -8.32315534e-03f, -6.67357966e-02f, -1.17751338e-01f, 1.04900137e-01f, 2.05128685e-01f, -3.37706745e-01f, -4.59442198e-01f, -3.74854922e-01f, 2.22688898e-01f, -1.14680195e+00f,
  2.58719087e-01f, -2.61312395e-01f, -5.46929657e-01f, 5.16368002e-02f, -5.97307563e-01f, -1.68471515e-01f, 2.60283500e-01f, -4.02379364e-01f, -3.08302611e-01f, 2.49075025e-01f,
  -5.99469662e-01f, 3.57672453e-01f, 3.02178413e-01f, -1.82764634e-01f, -6.53346896e-01f, -2.12718621e-01f, -6.67297602e-01f, 3.78768712e-01f, -2.93385834e-01f, -1.86034665e-01f,
  -2.23263636e-01f, -5.59420824e-01f, 4.94629368e-02f, 8.44016224e-02f, 3.91884685e-01f, -3.44896853e-01f, -6.56484604e-01f, -1.34438381e-01f, 2.22894445e-01f, -4.86309379e-01f,
  -4.73694950e-01f, 2.03324836e-02f, -2.63425261e-01f, 1.53840512e-01f, 1.19290851e-01f, -9.57337394e-02f, 2.49823123e-01f, -1.45213127e-01f, -1.44634455e-01f, 4.18976665e-01f,
  -4.83691156e-01f, 5.26695848e-02f, 3.02859068e-01f, -6.41089559e-01f, -7.20806897e-01f, -8.49833637e-02f, 4.31125797e-02f, -2.28413880e-01f, 5.14358282e-02f, 2.17687208e-02f,
  3.92473608e-01f, -4.84613508e-01f, -6.39741600e-01f, 1.40652493e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -7.85148665e-02f, 4.12737206e-02f, -1.08505413e-01f, -1.41713873e-01f, 1.32120624e-01f, 1.91756489e-03f, 1.63892865e-01f, 4.81498018e-02f, -5.19196056e-02f, 1.58008009e-01f,
  8.30224250e-03f, -1.31747827e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    