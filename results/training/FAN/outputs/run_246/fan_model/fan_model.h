/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.89160019e-01f, 3.15292150e-01f, 9.73177981e-03f, 5.53077795e-02f, -3.27724852e-02f, -4.35699135e-01f, -4.05775487e-01f, 1.20129682e-01f, 1.76573411e-01f, -1.36906616e-02f,
  -1.03485271e-01f, 1.31101772e-01f, -5.75344674e-02f, -6.72898516e-02f, -4.75064814e-01f, -1.31018579e-01f, -1.68647185e-01f, -7.35591725e-02f, 1.40639067e-01f, 1.01463199e-01f,
  2.45027877e-02f, -6.01205602e-02f, -1.83801964e-01f, 1.54690221e-01f, -7.40743726e-02f, 2.19850808e-01f, -8.60752463e-02f, 7.47283772e-02f, 2.21532434e-02f, -5.77198453e-02f,
  -1.31165668e-01f, 1.17665768e-01f, 6.66729137e-02f, 4.70482223e-02f, -8.12940672e-02f, -5.32347113e-02f, -6.33210391e-02f, -7.30331913e-02f, 5.06697735e-03f, 1.22289197e-03f,
  -7.74762034e-03f, 6.81569874e-02f, 5.59462421e-02f, 1.29762432e-02f, 2.84190923e-02f, 8.47372115e-02f, 1.35222729e-02f, -5.05129546e-02f, 5.28693125e-02f, -3.84229496e-02f,
  -1.60983857e-02f, -7.69250840e-02f, 1.79566927e-02f, -1.07917702e-02f, 6.96754875e-03f, 1.97017379e-02f, -7.40239397e-02f, -4.53099981e-02f, 3.66838686e-02f, 1.87845621e-02f,
  -5.31406607e-03f, 1.36387674e-02f, -2.03926321e-02f, -4.41253297e-02f, 7.09840748e-03f, -2.16104314e-02f, 4.45166528e-02f, -2.77477000e-02f, 3.11942063e-02f, -5.63294291e-02f,
  -1.71293505e-02f, -1.19856549e-02f, 4.02361080e-02f, -7.44851604e-02f, -2.56567243e-02f, -1.09863514e-02f, -2.08098534e-02f, 3.96520682e-02f, -2.18695290e-02f, -5.76114766e-02f,
  1.91911552e-02f, -1.44503806e-02f, 2.93558538e-02f, -5.36392853e-02f, -3.42913009e-02f, -1.76502559e-02f, 5.03306016e-02f, 5.04539302e-03f, 1.39996018e-02f, -8.22919384e-02f,
  -6.32742839e-03f, 2.91155785e-01f, 3.19362655e-02f, 3.61939818e-02f, 4.00726162e-02f, 2.35898718e-02f, 3.17797884e-02f, 2.64545046e-02f, 4.16169763e-02f, 5.24715660e-03f,
  2.05694716e-02f, -6.09566942e-02f, -2.60268245e-02f, -9.93576180e-03f, 4.63677337e-03f, -8.00600573e-02f, -2.00570505e-02f, 1.82172414e-02f, -5.30189201e-02f, 5.75576387e-02f,
  -2.11256072e-02f, 6.07632287e-03f, -5.46255037e-02f, 3.05770561e-02f, -1.86884366e-02f, -4.11348492e-02f, 3.99971344e-02f, 1.82729792e-02f, -3.07971258e-02f, -8.71347729e-03f,
  -3.83770764e-01f, 6.65403083e-02f, 2.55410403e-01f, -2.74397373e-01f, -2.80903608e-01f, 1.90336972e-01f, -8.80315751e-02f, -1.46399751e-01f, -2.88108826e-01f, 9.16996598e-02f,
  -1.81507051e-01f, 1.18633382e-01f, 6.80203959e-02f, 9.73771214e-02f, -6.64383397e-02f, 2.24865809e-01f, -3.77981924e-02f, 2.66229063e-02f, -3.30195129e-02f, -2.54067272e-01f,
  -1.09056897e-01f, -1.84695795e-01f, 2.29000121e-01f, -1.04407214e-01f, -1.03920951e-01f, -5.12910523e-02f, -1.89565226e-01f, -1.81378890e-03f, 1.87587693e-01f, 4.25532013e-02f,
  7.67453760e-02f, -1.72557861e-01f, 6.15140647e-02f, 4.76420820e-02f, -9.94184613e-02f, 9.04280134e-03f, 3.20073068e-02f, 6.79176003e-02f, 2.25303452e-02f, 2.96222023e-03f,
  6.18823338e-03f, 2.21055280e-02f, 3.29312868e-02f, 7.36230868e-04f, -3.33137028e-02f, 6.94880113e-02f, 8.73748958e-02f, 6.57679215e-02f, 2.94568483e-02f, 6.98853433e-02f,
  8.25392231e-02f, 7.79187605e-02f, -5.17994985e-02f, 1.31098097e-02f, -5.53452037e-02f, -3.03676515e-03f, 5.38756698e-02f, 4.14492935e-02f, -1.70443891e-04f, -3.22263055e-02f,
  -1.07717523e-02f, -1.93308631e-03f, 3.63774002e-02f, 4.63487692e-02f, -5.11833690e-02f, 4.11583371e-02f, -2.54549761e-03f, 2.94787921e-02f, -2.10570954e-02f, -2.46232077e-02f,
  -3.19431163e-02f, -2.73646414e-02f, -2.59849504e-02f, 5.14082797e-02f, -3.13001052e-02f, -3.69489118e-02f, -1.98338064e-03f, 1.93803273e-02f, -2.27089357e-02f, 1.99791286e-02f,
  -3.44979763e-02f, -2.28496958e-02f, -1.26804896e-02f, -7.82189239e-03f, -5.94405364e-03f, 3.35367542e-04f, -6.86828932e-03f, 1.34056667e-02f, 1.50145330e-02f, -5.75677790e-02f,
  -2.70029843e-01f, -4.33275461e-01f, -2.29366496e-02f, -2.18217224e-02f, 3.74756008e-02f, 4.06779684e-02f, 1.99678801e-02f, -7.91381579e-03f, 1.58865366e-03f, -4.93470952e-02f,
  3.21674743e-04f, -6.27077669e-02f, -2.53199525e-02f, -7.40235858e-03f, -1.20178200e-02f, -2.40696762e-02f, -3.71763967e-02f, -6.01836257e-02f, -8.95387307e-02f, -3.49127464e-02f,
  -2.94066351e-02f, -6.50411993e-02f, 4.84290980e-02f, -9.22403261e-02f, 2.93270703e-02f, -5.54884747e-02f, -9.40822214e-02f, 1.22193191e-02f, -2.45801150e-03f, 6.17435351e-02f,
  1.96873143e-01f, -1.94743976e-01f, 2.75539279e-01f, 5.01702130e-02f, -2.75262833e-01f, -1.63420945e-01f, 8.81600752e-02f, -2.48196527e-01f, -1.24321403e-02f, -1.40307516e-01f,
  -1.84865296e-01f, 5.63124418e-02f, 5.73841147e-02f, -9.76185054e-02f, -2.69500352e-02f, 1.34366855e-01f, -1.99071988e-01f, -3.92311532e-03f, 1.08848913e-02f, -2.78460771e-01f,
  1.58376582e-02f, -3.39521378e-01f, 2.13204831e-01f, -3.59515041e-01f, -8.25149342e-02f, -3.04742274e-03f, -1.41188771e-01f, 5.98313734e-02f, -5.20898141e-02f, -2.59913527e-03f,
  1.56471312e-01f, 6.03210963e-02f, 3.63441892e-02f, 1.29633188e-01f, 1.83058635e-03f, 6.09224625e-02f, 5.23213260e-02f, 7.11297542e-02f, 1.09249111e-02f, 2.36606393e-02f,
  6.71292171e-02f, 8.42621364e-03f, -2.07322203e-02f, -2.66387165e-02f, -7.78494775e-02f, -7.93004874e-03f, 1.43482639e-02f, 7.98555277e-03f, 9.99215641e-04f, 4.47244868e-02f,
  2.99566183e-02f, 4.56970409e-02f, -2.99188159e-02f, 1.05449539e-02f, 7.63715198e-03f, -3.30746435e-02f, 5.45040984e-03f, 4.74899709e-02f, -7.21287951e-02f, -4.05369736e-02f,
  -7.65524656e-02f, -1.36532001e-02f, -1.72669850e-02f, -8.90932139e-03f, -3.21208909e-02f, -6.71092654e-03f, -5.96594922e-02f, 2.96534207e-02f, 1.67608373e-02f, -5.68765122e-03f,
  2.25674408e-03f, -1.41595975e-02f, -2.77133435e-02f, 2.88045518e-02f, -3.35053541e-02f, 1.09927095e-02f, 5.94439693e-02f, 1.08450297e-02f, 7.32608605e-03f, 6.92364434e-03f,
  1.93886720e-02f, -3.69235799e-02f, -1.30349053e-02f, 4.08363305e-02f, -1.84387490e-02f, 2.94828527e-02f, -4.01074551e-02f, 7.35863997e-03f, 2.93617528e-02f, 4.14880132e-03f,
  -2.94080347e-01f, -3.46679986e-01f, -7.57068349e-03f, -6.19055592e-02f, 2.11279606e-03f, -6.38417006e-02f, -3.63896452e-02f, -2.37405989e-02f, -3.93846147e-02f, -3.51427458e-02f,
  -2.22558789e-02f, 2.60468591e-02f, -4.55042906e-02f, -5.74033931e-02f, -2.34527560e-03f, -6.27473220e-02f, 1.25281699e-02f, -1.74382105e-02f, -7.52943382e-02f, -5.49207404e-02f,
  -4.38546250e-03f, -3.59439664e-02f, 6.84553385e-03f, -4.66020741e-02f, -6.06131628e-02f, 2.28602458e-02f, -6.99693263e-02f, 2.16323286e-02f, 5.88014871e-02f, -3.29085160e-03f,
  -4.94463265e-01f, 2.63195693e-01f, -1.10784687e-01f, -3.36837322e-01f, 1.08779460e-01f, 4.02355194e-01f, 4.37035644e-03f, 1.48466319e-01f, -6.32465398e-03f, 2.11727753e-01f,
  6.20832294e-02f, -1.49179548e-01f, 5.02469800e-02f, 1.71438426e-01f, -3.18561941e-02f, 2.08779171e-01f, 1.66737363e-01f, 1.43975457e-02f, 1.38716668e-01f, -1.15417778e-01f,
  -9.43947211e-02f, 6.84713349e-02f, -1.87377166e-02f, 2.39179581e-01f, -5.50879501e-02f, -1.94078624e-01f, -1.82813525e-01f, 7.13403290e-03f, 6.66229650e-02f, 1.33893609e-01f,
  4.73101251e-03f, 3.81580479e-02f, -7.21940398e-02f, 7.82340169e-02f, -3.34443599e-02f, -1.62965059e-02f, -8.17191601e-02f, -2.80824006e-02f, -8.11332241e-02f, 5.32468818e-02f,
  -5.02686314e-02f, -1.09152012e-02f, 3.07998732e-02f, 5.24421073e-02f, 2.30330434e-02f, -1.81156155e-02f, -2.75730137e-02f, -2.96830311e-02f, 6.63897535e-03f, -2.14165132e-02f,
  -1.11357849e-02f, 1.57810412e-02f, -6.90329075e-02f, 1.68313626e-02f, -1.78158600e-02f, -4.13472690e-02f, -4.00148816e-02f, -7.86860436e-02f, 2.76366882e-02f, 3.79166976e-02f,
  -2.09819246e-02f, 2.08787862e-02f, -9.90183372e-03f, -1.33474199e-02f, 4.01599519e-02f, -2.35204175e-02f, -7.08537549e-03f, 2.12523509e-02f, -2.64119543e-02f, -5.91619546e-03f,
  -8.85708258e-04f, -7.23157525e-02f, -3.70212627e-04f, -3.96192856e-02f, -3.92237641e-02f, -4.77917939e-02f, -5.26347086e-02f, 2.52151079e-02f, -1.48905888e-02f, -1.24948490e-02f,
  4.33671139e-02f, 1.39841232e-02f, 2.26745084e-02f, -3.78217064e-02f, 7.24420398e-02f, -2.72414498e-02f, 2.11751889e-02f, -1.17071681e-02f, -7.14936713e-03f, -5.12330420e-02f,
  1.37446299e-01f, 9.21673328e-02f, 3.52639221e-02f, 3.68406549e-02f, 8.97196233e-02f, 5.81475198e-02f, 6.76569343e-02f, 2.17949990e-02f, 4.72673178e-02f, 1.47693940e-02f,
  -3.27168107e-02f, -5.89650217e-03f, -7.17270374e-02f, -6.65901825e-02f, -3.68610360e-02f, 4.71605100e-02f, -4.49992828e-02f, -1.63313956e-03f, -2.26421058e-02f, 3.10313553e-02f,
  -5.57503328e-02f, -3.66595425e-02f, -4.97514121e-02f, 5.91857545e-02f, 3.46471593e-02f, -2.29579508e-02f, 2.14770082e-02f, 7.18564242e-02f, 1.79674607e-02f, 2.85659544e-03f,
  -3.07897478e-01f, 1.34238601e-01f, -1.40009254e-01f, -3.15700501e-01f, 1.06351897e-01f, -3.28969240e-01f, -5.01666725e-01f, 1.31254584e-01f, -1.96202353e-01f, 1.20007068e-01f,
  1.87597200e-01f, -2.07243130e-01f, 1.98168665e-01f, -9.79599878e-02f, -1.08645387e-01f, 4.75302478e-03f, -1.51039168e-01f, -1.50677800e-01f, -1.95496045e-02f, 6.34063706e-02f,
  -1.19572682e-02f, 1.35887519e-01f, -3.79683748e-02f, 1.91820025e-01f, -1.23292550e-01f, 3.91439721e-03f, 2.78586984e-01f, 2.27534156e-02f, 9.25884247e-02f, 6.09300938e-03f,
  -1.08464547e-01f, 8.78975168e-02f, -4.65297922e-02f, -7.35464767e-02f, -1.62573643e-02f, 2.14722883e-02f, -5.80575652e-02f, -4.73910160e-02f, -4.16856632e-02f, 1.64377782e-02f,
  1.46390358e-02f, 1.02071548e-02f, -3.12879384e-02f, -1.19898496e-02f, -4.51318175e-02f, -9.82087385e-03f, -7.98244029e-04f, -1.42458628e-03f, -2.74163447e-02f, -6.87171414e-04f,
  -2.97274124e-02f, 1.09181423e-02f, -3.87463858e-03f, -1.91643573e-02f, -3.59663479e-02f, 8.68045783e-04f, -8.34257901e-02f, -9.84650478e-03f, 3.23834009e-02f, -4.01911214e-02f,
  6.23544417e-02f, 1.97598636e-02f, 1.25698536e-03f, -1.13826096e-02f, 8.88330804e-04f, 2.78173238e-02f, -7.77819939e-03f, 6.74574971e-02f, -4.59087454e-02f, 3.94904725e-02f,
  -2.15166509e-02f, 3.49751748e-02f, -3.06215603e-03f, 3.25460620e-02f, -1.64329540e-02f, 1.80737898e-02f, -1.93317551e-02f, 7.23807961e-02f, -5.34026921e-02f, -2.88668496e-04f,
  1.27162524e-02f, 2.36909706e-02f, -1.38732716e-02f, -4.00175294e-03f, 7.02575687e-03f, 2.89002825e-02f, 7.27983117e-02f, 2.97881179e-02f, -1.15056848e-02f, -2.03451887e-02f,
  3.27780209e-02f, 2.81118929e-01f, -3.01134940e-02f, -9.33504477e-03f, 9.95548628e-03f, 3.55689824e-02f, -5.74037731e-02f, 5.25088720e-02f, 1.31798778e-02f, 4.66828048e-02f,
  1.74196977e-02f, -7.34216198e-02f, 2.02299692e-02f, -5.23910001e-02f, -2.23164205e-02f, 8.54485258e-02f, 6.25984222e-02f, -3.77758257e-02f, 1.29107200e-02f, 3.70317996e-02f,
  5.03034145e-02f, 1.40173463e-02f, -1.79124642e-02f, -5.35272397e-02f, 2.54014768e-02f, -4.67450805e-02f, 1.70842502e-02f, -1.23052243e-02f, 7.28170276e-02f, 4.70996555e-03f,
  4.77563478e-02f, -1.09351642e-01f, -1.14898138e-01f, -2.02349424e-02f, 1.18725471e-01f, 1.89713269e-01f, -1.00803316e-01f, 9.22763050e-02f, -9.67553556e-02f, 1.01931661e-01f,
  -3.98346819e-02f, 2.53925510e-02f, -4.39639837e-01f, 1.24366418e-01f, -1.87033210e-02f, -2.57362306e-01f, 2.22122654e-01f, 7.94629455e-02f, -6.68343753e-02f, 3.30071338e-02f,
  2.64149792e-02f, 1.93442687e-01f, -1.49595946e-01f, 1.87043339e-01f, 6.94899186e-02f, 3.07727922e-02f, 9.09272432e-02f, -1.50979578e-01f, 2.88628042e-01f, 8.51471052e-02f,
  -5.59691014e-03f, -1.31519929e-01f, -1.59783121e-02f, 3.25038061e-02f, 2.36589671e-03f, 7.77259767e-02f, 1.68556292e-02f, -3.53575759e-02f, -3.20121087e-03f, -5.73912486e-02f,
  -1.95953920e-02f, 3.97435715e-03f, 7.92505220e-02f, -1.60346255e-02f, 3.78362834e-02f, 3.88663933e-02f, -5.05316220e-02f, -5.92228398e-02f, -5.23509644e-02f, -4.26871665e-02f,
  -6.16662912e-02f, 5.55465333e-02f, 1.00218551e-02f, 1.38934106e-02f, -4.46091443e-02f, 2.17845300e-05f, -9.64714959e-03f, -3.08577344e-02f, 3.15442197e-02f, 7.85856172e-02f,
  1.28430324e-02f, 3.60071659e-02f, -6.63479567e-02f, -2.62619611e-02f, -3.74409109e-02f, -2.95943599e-02f, -7.32685206e-03f, -3.91667001e-02f, -2.79976465e-02f, -6.07654899e-02f,
  3.33527848e-02f, 4.30944259e-04f, 4.16390672e-02f, 1.82561390e-02f, 5.36483340e-03f, -3.32606919e-02f, 4.81761759e-03f, 1.39363576e-04f, -4.19469405e-04f, 1.71066599e-03f,
  -2.48036180e-02f, 4.02867831e-02f, -2.92373914e-02f, 1.03011113e-02f, -3.18237906e-03f, 1.01997526e-02f, 2.01673973e-02f, -1.16648674e-02f, -1.65639706e-02f, -5.33952052e-03f,
  6.60740137e-02f, 4.38233465e-02f, -2.13183276e-02f, 1.17830187e-02f, -2.17633345e-03f, 7.57410482e-04f, 2.18146667e-02f, 4.21151854e-02f, 4.25888896e-02f, 4.02913950e-02f,
  7.26810321e-02f, 6.75433427e-02f, 2.81388834e-02f, 2.30755098e-02f, 3.79788540e-02f, -1.72699466e-02f, 2.37183496e-02f, 1.08959690e-01f, 1.07686013e-01f, -1.17706172e-02f,
  -1.44528374e-02f, -3.37447785e-02f, 2.89396886e-02f, 5.14248759e-02f, 8.65432918e-02f, -1.92966557e-03f, 6.70047551e-02f, -1.98540278e-02f, 2.56241038e-02f, -3.38456780e-02f,
  3.89233306e-02f, 2.40304127e-01f, -3.38212729e-01f, 2.03990906e-01f, -8.59079063e-02f, -3.60722356e-02f, -1.43287733e-01f, 1.60718217e-01f, -5.20300791e-02f, 3.12657386e-01f,
  1.05021343e-01f, -1.93210449e-02f, -2.55150944e-01f, 4.25124019e-01f, -1.91024870e-01f, -6.08547404e-02f, 3.60808045e-01f, 2.03533947e-01f, -1.03599168e-01f, -9.17410944e-03f,
  -4.47866693e-02f, 2.89891303e-01f, 3.52615118e-02f, 8.81491229e-02f, 1.47142127e-01f, -6.96076900e-02f, 7.63132498e-02f, -3.19555670e-01f, 1.13213316e-01f, 2.35225726e-02f,
  1.15805872e-01f, 1.16931915e-01f, -1.70940552e-02f, 4.18618917e-02f, 8.05094391e-02f, -1.65843945e-02f, -3.98700237e-02f, -1.09554574e-01f, -2.41460986e-02f, 1.20881107e-03f,
  -1.85808297e-02f, 1.55505519e-02f, 8.06639716e-02f, 6.57062326e-03f, 5.04528992e-02f, 2.28484143e-02f, 9.63786524e-03f, 4.17202718e-05f, -1.47616016e-02f, 1.87386351e-03f,
  -3.97373401e-02f, 6.27794350e-03f, 7.50272023e-03f, 1.39383804e-02f, -1.18444532e-01f, -6.56929240e-02f, -5.55379875e-02f, -3.40912417e-02f, 2.97763851e-02f, 2.66872719e-02f,
  -7.22787082e-02f, -3.12818624e-02f, -1.34570068e-02f, 4.64371443e-02f, -3.12465103e-03f, 1.38343554e-02f, 2.04611123e-02f, -7.70611968e-03f, 8.94658547e-03f, 3.66637930e-02f,
  4.54647727e-02f, 3.13052870e-02f, 2.76134443e-02f, 1.57614984e-02f, 2.40700524e-02f, 4.34602834e-02f, -2.61689443e-02f, 6.37721494e-02f, 3.26480460e-03f, 1.35782966e-02f,
  -2.20051687e-02f, -5.67792468e-02f, 6.38651922e-02f, 7.22448248e-03f, 2.19399277e-02f, -3.15747857e-02f, 1.35366227e-02f, -7.96593633e-03f, -3.68093662e-02f, -3.16486396e-02f,
  2.51369029e-01f, 1.40795112e-01f, 4.13920321e-02f, 3.25925760e-02f, 6.43669367e-02f, -2.64927302e-03f, -1.73539817e-02f, 2.56758537e-02f, -3.54809165e-02f, -1.41291879e-02f,
  -1.38448402e-02f, 2.50632577e-02f, -4.52366248e-02f, 3.19510736e-02f, -4.94439267e-02f, 1.37653798e-02f, -7.51763806e-02f, -6.75412547e-03f, 6.44946694e-02f, 4.88095768e-02f,
  -3.01902667e-02f, -2.82349065e-02f, -5.22398390e-02f, 2.92996177e-03f, 5.53988554e-02f, 2.73159761e-02f, 9.03866813e-03f, 1.81274198e-03f, 7.28335045e-03f, 1.08128972e-02f,
  7.11485922e-01f, -2.35348955e-01f, 4.95662354e-02f, 2.08034381e-01f, 5.48188761e-02f, -1.61166504e-01f, 7.29742125e-02f, -1.41227767e-01f, 4.64232534e-01f, -3.38423163e-01f,
  -1.31665424e-01f, 2.81213462e-01f, -9.90777910e-02f, -6.03834279e-02f, 1.43583834e-01f, -5.97506054e-02f, -9.59197953e-02f, -4.38813418e-02f, 1.82583630e-01f, -9.34971347e-02f,
  9.29972250e-03f, -5.97832575e-02f, -1.14247993e-01f, -1.24670923e-01f, 4.31583598e-02f, 6.04445441e-03f, -2.70128667e-01f, -8.68157484e-03f, -1.52791962e-01f, 6.87469244e-02f,
  4.75197248e-02f, 1.04843475e-01f, -1.01104006e-02f, 2.66041905e-02f, -1.16634287e-01f, -1.04154930e-01f, -3.16110924e-02f, 7.33792409e-02f, 5.11212498e-02f, 2.97704414e-02f,
  2.23347079e-02f, 1.03697591e-02f, 6.65406063e-02f, 6.68165386e-02f, 5.57909235e-02f, 4.87115458e-02f, 2.86287311e-02f, -1.31023386e-02f, 5.62137477e-02f, 4.64866683e-03f,
  2.59885681e-03f, -7.13097677e-02f, -9.09478515e-02f, -3.39839570e-02f, 2.15176456e-02f, 2.14248449e-02f, -1.53814061e-02f, -3.56830694e-02f, -7.36405188e-03f, 1.65981054e-02f,
  2.67612934e-02f, -1.23807965e-02f, 3.26602161e-02f, 2.66391262e-02f, 3.38083580e-02f, -2.41288939e-03f, 5.14998958e-02f, -3.45532894e-02f, 9.19598266e-02f, -5.32636344e-02f,
  3.98865789e-02f, 4.85808291e-02f, 1.94297172e-02f, 4.87797149e-03f, 1.74348038e-02f, 3.00304908e-02f, -8.52065347e-03f, -2.70686094e-02f, -7.25509180e-03f, 1.23687061e-02f,
  9.76528879e-03f, -1.02625340e-02f, 2.32359394e-02f, -4.16830815e-02f, -1.15960427e-02f, 4.49016877e-02f, -4.08223607e-02f, 9.97587666e-03f, 5.93779888e-03f, -4.36966754e-02f,
  -2.94291824e-01f, -1.92405239e-01f, 1.39892744e-02f, 6.02343492e-02f, -1.57580841e-02f, -2.51070075e-02f, 1.04052238e-02f, -1.30917076e-02f, -2.34899931e-02f, -1.75395347e-02f,
  -9.60182548e-02f, 2.06423588e-02f, -1.04269244e-01f, 1.77428778e-02f, 1.21561969e-02f, -6.49522245e-02f, -4.21765372e-02f, -2.03015935e-02f, -8.83639827e-02f, -5.94123127e-03f,
  -5.04314415e-02f, 4.96239960e-02f, 5.91851659e-02f, 4.00700159e-02f, -5.38249724e-02f, -5.16059063e-02f, -1.38140109e-03f, 4.86682802e-02f, -4.41493429e-02f, -2.00275797e-02f,
  -6.29613036e-03f, 1.02101021e-01f, 2.28879694e-02f, -4.84545112e-01f, -2.07706485e-02f, -7.78773576e-02f, -2.76804958e-02f, -9.89991575e-02f, -1.78445503e-01f, -9.09092254e-04f,
  -1.48936257e-01f, 1.48486704e-01f, 1.86073035e-01f, -3.63009423e-01f, -2.60284543e-01f, 3.58720012e-02f, -2.87313282e-01f, -5.29060662e-02f, -6.82189316e-03f, -6.73085079e-02f,
  -1.76458254e-01f, -2.82283217e-01f, -1.83037996e-01f, -6.06255643e-02f, -1.07572012e-01f, -3.71265002e-02f, -1.11402079e-01f, 2.13105738e-01f, -2.00716808e-01f, 8.31706002e-02f,
  1.14603546e-02f, 6.11962080e-02f, 9.27430112e-03f, -2.92418012e-03f, -2.84280796e-02f, -3.31668295e-02f, -2.59564668e-02f, 6.79800808e-02f, 2.51347385e-02f, 4.52572182e-02f,
  7.62390345e-02f, 2.52134949e-02f, -2.67129838e-02f, 1.65655650e-02f, 1.67540424e-02f, -2.29994319e-02f, 2.75418162e-02f, 1.06487172e-02f, 7.56442100e-02f, 1.18733294e-01f,
  4.92022373e-02f, 8.19136668e-03f, -5.86344413e-02f, -1.12672253e-02f, 2.69738268e-02f, -3.00833862e-02f, 1.33790793e-02f, 8.73838514e-02f, 6.81586273e-04f, -3.12169846e-02f,
  8.29778537e-02f, -2.65074223e-02f, 2.63106935e-02f, 1.45925507e-02f, 4.28140908e-03f, -1.00047756e-02f, 6.91395777e-04f, -5.19094169e-02f, 1.80509370e-02f, 6.61387667e-03f,
  -5.40997535e-02f, -2.95356084e-02f, -4.05131727e-02f, -1.60106942e-02f, -4.14760113e-02f, -3.04164365e-02f, 4.21385802e-02f, 1.33218048e-02f, -5.31828851e-02f, -2.23257281e-02f,
  9.61824227e-03f, -5.18108383e-02f, 5.84332040e-03f, 7.38940155e-03f, -1.96553282e-02f, -3.45045552e-02f, -4.44573686e-02f, 2.59954669e-02f, -1.04676215e-02f, 1.60884894e-02f,
  -9.36332569e-02f, -7.27959648e-02f, 1.99268144e-02f, 7.50100836e-02f, 2.96048587e-03f, -2.32445244e-02f, -5.09654637e-03f, -4.35317568e-02f, -5.86615037e-03f, -4.65612002e-02f,
  -4.69098166e-02f, -2.64423899e-03f, -3.70508507e-02f, -1.30316522e-02f, -3.62510979e-02f, -1.77788809e-02f, -9.28362366e-03f, -5.79929501e-02f, -8.60310569e-02f, -1.44284833e-02f,
  -1.01767918e-02f, -1.84180625e-02f, 5.28766178e-02f, 2.88267736e-03f, 3.15517597e-02f, 4.74908622e-03f, -5.71926474e-04f, -1.99096613e-02f, 8.74614269e-02f, -5.98216318e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.72699445e-01f, 3.32259983e-01f, -1.21189598e-02f, 2.38044076e-02f, -2.74438202e-01f, 8.95555466e-02f, 2.68795639e-01f, 4.27753851e-02f, 5.25001297e-03f, 2.21309483e-01f,
  1.36134923e-01f, 1.38194049e-02f, 3.07818621e-01f, 3.04969221e-01f, 3.16656828e-01f, 3.86982709e-01f, 4.00886595e-01f, 2.74886876e-01f, -3.97446267e-02f, 2.17270017e-01f,
  3.91380005e-02f, 2.76454926e-01f, 1.98274717e-01f, -3.86575870e-02f, 9.72565785e-02f, -1.27387762e-01f, 1.07343227e-01f, -5.89931160e-02f, -7.68785691e-03f, 7.64179453e-02f,
  -3.07070017e-02f, -2.83808969e-02f, -7.86833558e-03f, -1.21027999e-01f, 1.67669554e-03f, -1.55352250e-01f, -4.54528518e-02f, -1.83931701e-02f, -5.90625070e-02f, -9.22763273e-02f,
  -1.48140099e-02f, -7.26188496e-02f, -1.07914759e-02f, -1.85575541e-02f, -1.73914596e-01f, -3.91380787e-02f, -3.91218401e-02f, 4.30081859e-02f, 3.79519202e-02f, -2.89177634e-02f,
  4.45110388e-02f, 2.58168150e-02f, -6.85903952e-02f, 8.06307048e-02f, -2.99263056e-02f, 1.27751017e-02f, 9.11876850e-05f, -1.88497175e-02f, -2.34550908e-02f, 6.47809962e-03f,
  -1.86560303e-02f, 2.98522469e-02f, 4.92087193e-03f, -5.67392446e-02f, -5.54906689e-02f, -6.06760159e-02f, 9.34773311e-03f, 1.95702799e-02f, 2.91304216e-02f, -3.18120904e-02f,
  5.25878510e-04f, -1.02462815e-02f, -1.96423549e-02f, -1.11565748e-02f, -3.81051600e-02f, -1.51152816e-02f, -1.52628133e-02f, -1.97148174e-02f, 6.14158763e-03f, -4.74561751e-02f,
  7.14666443e-03f, -1.83632541e-02f, 1.21228825e-02f, -1.28392931e-02f, -1.91899408e-02f, 7.76340961e-02f, -2.08619144e-02f, 6.81642145e-02f, -2.25472562e-02f, -8.09619296e-03f,
  2.29426578e-01f, 3.22117746e-01f, 6.51700869e-02f, -8.13958943e-02f, 3.81440390e-03f, 1.35432277e-02f, 5.79180680e-02f, -9.28016659e-03f, 1.22733444e-01f, 4.07133251e-02f,
  -3.90100181e-02f, -6.33838063e-04f, 2.78319865e-02f, 1.05601577e-02f, 3.65910791e-02f, 4.16816358e-04f, 2.74137110e-02f, -1.89967006e-02f, 7.51325786e-02f, 4.75505218e-02f,
  -1.56583004e-02f, 2.65126359e-02f, -4.96466598e-03f, 8.43734108e-03f, -5.36834411e-02f, -7.42618218e-02f, -1.93529297e-02f, -7.34085590e-03f, 4.34536897e-02f, 6.92850500e-02f,
  -6.67698085e-02f, 1.46112502e-01f, -1.43331334e-01f, -8.22513998e-02f, -1.38648227e-03f, 3.82699370e-02f, 2.23585535e-02f, -5.01860827e-02f, -1.62263408e-01f, 4.17457312e-01f,
  3.84658463e-02f, -2.00600526e-03f, 8.90570730e-02f, -1.25454202e-01f, -5.76659262e-01f, -2.31146067e-01f, -1.05412662e-01f, 3.42756161e-04f, -5.97872511e-02f, 6.63625821e-02f,
  -1.39897436e-01f, -1.28582433e-01f, -9.94016379e-02f, 1.35103822e-01f, 1.01254314e-01f, 1.58136994e-01f, 1.12938270e-01f, -2.35479767e-03f, 1.23958595e-01f, -1.29989013e-01f,
  -1.12282578e-02f, 1.79148633e-02f, 7.92052671e-02f, 3.98903713e-02f, 4.70904633e-02f, 7.82306343e-02f, 1.14909776e-01f, -7.37531260e-02f, -2.18569441e-03f, -2.43917983e-02f,
  1.17896214e-01f, 2.42536515e-02f, 3.52919586e-02f, -2.18170341e-02f, 1.77081767e-02f, 6.77085742e-02f, 5.03164642e-02f, 1.12028513e-02f, 1.59184225e-02f, -9.26447660e-02f,
  5.01354262e-02f, 2.75336113e-02f, 3.50456755e-03f, 8.01089033e-02f, -7.78432190e-02f, -2.30556563e-03f, 1.85750499e-02f, 1.70833841e-02f, 7.93823525e-02f, -4.67681605e-03f,
  -1.39348339e-02f, 1.02646276e-02f, 4.48933728e-02f, -9.83650908e-02f, -6.30986169e-02f, 8.73244703e-02f, 1.06876856e-03f, -4.17214669e-02f, -4.03325856e-02f, -4.29846765e-03f,
  2.29262244e-02f, 2.42555439e-02f, -6.02913424e-02f, 1.71787422e-02f, 2.62942165e-02f, 1.79620851e-02f, 8.17977265e-03f, 2.90852450e-02f, 2.16806792e-02f, -7.61052817e-02f,
  -2.57564932e-02f, 5.93276732e-02f, 2.53540501e-02f, 7.67537281e-02f, -8.36308021e-03f, 1.91232655e-02f, -5.88948987e-02f, -2.90571392e-04f, 5.73713146e-02f, 5.21796793e-02f,
  9.27375481e-02f, 1.85813218e-01f, -7.71588320e-03f, 5.97360097e-02f, 6.47502858e-03f, 1.79997850e-02f, 2.97726169e-02f, -7.10074743e-03f, 1.89761985e-02f, -7.17415810e-02f,
  1.19638495e-01f, -1.33963348e-02f, 1.78067461e-02f, 1.31726954e-02f, -7.58916587e-02f, -4.67417315e-02f, 4.96865995e-02f, 5.50669208e-02f, 4.03136872e-02f, 1.11290887e-01f,
  1.36265950e-02f, 3.26950252e-02f, -3.98417674e-02f, 8.65523219e-02f, 7.69228488e-02f, 8.81186053e-02f, 1.24218948e-02f, 7.71370530e-02f, 3.41426283e-02f, -2.57352809e-03f,
  5.40128276e-02f, 7.21681356e-01f, 1.57312468e-01f, 3.00395548e-01f, -1.81391031e-01f, 2.96175957e-01f, 3.03414315e-01f, 8.49661529e-02f, 4.22425658e-01f, 3.03965598e-01f,
  -2.87979275e-01f, 5.15422463e-01f, -1.21710323e-01f, 1.55108333e-01f, -5.30802235e-02f, 8.52244422e-02f, 3.94582123e-01f, 2.38212004e-01f, 4.37717699e-02f, 1.65453345e-01f,
  -6.08496703e-02f, -1.25628427e-01f, -2.01281697e-01f, -2.18387902e-01f, -8.57469514e-02f, -3.97993028e-02f, -3.97364706e-01f, -2.25222245e-01f, -2.89421789e-02f, -1.13734297e-01f,
  -7.30916038e-02f, 2.41102017e-02f, -5.99911846e-02f, -8.71175143e-04f, -1.44898817e-02f, 3.79816047e-03f, 3.22693735e-02f, -2.38730330e-02f, -8.82677883e-02f, 4.96645272e-02f,
  1.40714094e-01f, -2.65310239e-02f, 4.53174822e-02f, -2.13158298e-02f, -3.19818710e-03f, 1.44392503e-02f, 1.60756148e-02f, -7.10653588e-02f, 6.39638538e-03f, -2.48486698e-02f,
  -3.42157930e-02f, 2.13216376e-02f, -7.19631789e-03f, 4.12824489e-02f, -4.24331352e-02f, 1.10202534e-02f, 5.18331937e-02f, 2.65446084e-04f, 9.48492438e-02f, 1.09393798e-01f,
  5.02893962e-02f, 9.70688760e-02f, -1.62883829e-02f, -5.86806461e-02f, 4.15092893e-03f, -8.89953524e-02f, -1.41221238e-02f, -7.31142312e-02f, -4.82610986e-02f, 1.14818355e-02f,
  1.92426611e-02f, 5.94826136e-03f, 3.62896267e-03f, 7.82370567e-02f, 6.62700981e-02f, 9.79524925e-02f, -6.57996489e-03f, -1.73904225e-02f, 1.63339265e-02f, 1.63910370e-02f,
  -6.88712820e-02f, 3.10284104e-02f, -4.08109240e-02f, -9.78298113e-02f, 2.50625610e-02f, -7.28825107e-02f, -1.54881170e-02f, 4.42215763e-02f, -5.53444363e-02f, -5.41774854e-02f,
  2.33798787e-01f, 4.55438197e-01f, 8.03868193e-03f, 1.30706904e-02f, 5.69481254e-02f, -1.36909615e-02f, 7.84428567e-02f, 4.21192907e-02f, 1.31158084e-01f, 7.55923092e-02f,
  8.30666441e-03f, -1.02038858e-02f, 1.70452893e-02f, -4.41280380e-02f, 6.78758323e-02f, 2.08812393e-02f, 5.27060777e-03f, 5.49748018e-02f, 7.04710037e-02f, -3.38254236e-02f,
  3.36926244e-02f, 6.21056035e-02f, 4.90301289e-02f, -7.34145492e-02f, -9.31403413e-03f, 8.89278948e-03f, 9.15561244e-02f, -1.01554878e-02f, -1.21776434e-02f, 9.34208259e-02f,
  1.56902179e-01f, -1.47012755e-01f, -1.58288002e-01f, 6.24374710e-02f, -2.00122446e-01f, -2.39119172e-01f, -2.57707775e-01f, -3.26183736e-02f, 3.99662107e-02f, -1.28389314e-01f,
  -4.41306308e-02f, -2.51225866e-02f, 2.46654600e-02f, -1.20765917e-01f, 2.37330243e-01f, 1.19827554e-01f, 3.44892070e-02f, -1.03272222e-01f, 2.03782623e-03f, -9.19911191e-02f,
  6.78239763e-02f, -1.37954339e-01f, -7.42328987e-02f, -9.65719745e-02f, -1.74479038e-01f, 2.41502654e-02f, 1.85619235e-01f, -7.50032142e-02f, -1.51580855e-01f, -1.80555075e-01f,
  -1.43759549e-01f, -6.69962466e-02f, -1.05186172e-01f, 2.25794725e-02f, 7.48675913e-02f, -4.45065647e-02f, -2.24018805e-02f, -1.24834422e-02f, -2.38223672e-02f, -4.46931422e-02f,
  3.70460302e-02f, -4.25771475e-02f, -5.48707470e-02f, 9.42470357e-02f, -9.49412435e-02f, 3.34375463e-02f, 2.37797629e-02f, 5.23863994e-02f, -2.10247934e-02f, -8.94818455e-02f,
  -1.05644815e-01f, -5.37111238e-02f, 3.49604413e-02f, 1.74626354e-02f, 1.17439121e-01f, -7.06185326e-02f, 2.86673810e-02f, -4.36564982e-02f, 3.18452045e-02f, -6.26851022e-02f,
  6.45191446e-02f, 4.39402349e-02f, -7.51902387e-02f, -4.18220423e-02f, -6.56637698e-02f, -1.99769791e-02f, -6.19248860e-02f, 1.06832907e-01f, 5.38317896e-02f, -6.31565154e-02f,
  7.77053833e-02f, -1.57786149e-03f, -8.77324045e-02f, -2.48481128e-02f, 7.95614719e-02f, 2.92852055e-02f, 5.52257523e-03f, 3.64749692e-02f, 4.55387942e-02f, -3.47912125e-02f,
  4.51096625e-04f, -3.69164255e-03f, -2.68026814e-02f, -4.14431579e-02f, 4.73937578e-02f, -5.63473813e-02f, 6.44261092e-02f, 5.55645004e-02f, 7.56409904e-03f, 4.53365631e-02f,
  9.56921428e-02f, 1.22378245e-01f, -7.74801970e-02f, -4.23292816e-03f, -5.59381805e-02f, 2.12844461e-02f, 2.89529730e-02f, -3.18386294e-02f, 4.63420376e-02f, 7.35226553e-03f,
  1.09563783e-01f, -5.90478815e-02f, 2.81768702e-02f, 3.86227779e-02f, 3.17950323e-02f, -3.94120738e-02f, 1.09185405e-01f, 7.54745081e-02f, 3.20481844e-02f, 8.57929327e-03f,
  4.31350060e-02f, 4.43627238e-02f, 4.18627821e-02f, 8.51266608e-02f, -7.31531754e-02f, 5.99287711e-02f, 7.62466807e-04f, -1.14294142e-03f, -3.39680910e-03f, 1.08357720e-01f,
  4.82904799e-02f, -1.64651517e-02f, -1.46162271e-01f, -1.39847964e-01f, -1.69421464e-01f, -1.73235297e-01f, -2.45405853e-01f, -1.21898532e-01f, 1.37656063e-01f, 2.85776705e-02f,
  -2.33323529e-01f, 2.20850930e-01f, 1.39094368e-01f, -2.84261376e-01f, 2.29131907e-01f, 2.62769312e-01f, -2.39521384e-01f, 1.77267268e-02f, 1.32068321e-02f, -8.89367163e-02f,
  -3.28747705e-02f, -2.39717305e-01f, -1.10358797e-01f, -2.06316680e-01f, -3.00083309e-01f, -2.10424289e-01f, -1.20181821e-01f, -2.64875531e-01f, -3.20476294e-01f, -1.17587090e-01f,
  -1.84485182e-01f, 4.79696766e-02f, -1.78445168e-02f, 3.92100541e-03f, -3.51729095e-02f, -6.68267079e-04f, 2.02187393e-02f, -1.13694645e-01f, 5.71874576e-03f, -7.74233649e-03f,
  6.29456192e-02f, 9.31877177e-03f, 1.83215830e-02f, 5.48103899e-02f, -4.39194217e-02f, -4.42309082e-02f, -4.89630140e-02f, -5.12409471e-02f, 6.56062737e-02f, -8.34218487e-02f,
  -5.21666892e-02f, 6.75215200e-02f, -1.05248414e-01f, -8.93292204e-03f, 2.41459664e-02f, -5.73079288e-02f, 1.22748785e-01f, 3.66203417e-03f, -6.82986453e-02f, -4.47173044e-03f,
  -2.03184206e-02f, -2.33378392e-02f, -5.94187118e-02f, -4.73189577e-02f, -7.03517273e-02f, 2.12255307e-02f, -4.88985442e-02f, 4.28033434e-02f, 5.45984618e-02f, -4.62519787e-02f,
  3.10047343e-02f, 4.26729722e-03f, -1.66413579e-02f, 7.84343109e-02f, -2.46380288e-02f, 2.84200218e-02f, -9.19615757e-03f, 2.13325466e-03f, -5.14425114e-02f, 4.38943878e-02f,
  2.57880241e-02f, 7.34330062e-03f, -3.35495137e-02f, -2.71480214e-02f, -2.71692835e-02f, 3.87300774e-02f, -1.40999118e-02f, -4.39768396e-02f, 3.52672338e-02f, -3.38791832e-02f,
  3.37180379e-03f, 6.41629249e-02f, 1.06058128e-01f, 1.02623269e-01f, 9.88891572e-02f, -3.92841399e-02f, -6.96027502e-02f, 4.94108573e-02f, -9.75497067e-03f, 3.94990630e-02f,
  3.57644111e-02f, -2.42697112e-02f, 2.62709111e-02f, -6.62587807e-02f, 2.03111395e-02f, 2.88215727e-02f, 2.23052297e-02f, 1.35115534e-01f, 8.44230596e-03f, -4.89160307e-02f,
  1.11582782e-02f, 6.02202788e-02f, 1.21025480e-01f, 4.76226322e-02f, 1.03675321e-01f, -8.52337033e-02f, 4.41527218e-02f, 1.79071433e-03f, 5.38380705e-02f, 2.96414085e-02f,
  3.57675850e-01f, 3.68761420e-01f, 1.00766726e-01f, -9.94393136e-04f, 8.91746138e-04f, -1.72783166e-01f, -1.72756359e-01f, 3.80898342e-02f, -2.05502048e-01f, 2.01367453e-01f,
  -2.61445856e-03f, 3.91618222e-01f, -2.14656636e-01f, -1.21590428e-01f, -6.38843417e-01f, -4.46457744e-01f, -9.00259912e-02f, 4.57953513e-02f, -1.45386979e-01f, 8.40876773e-02f,
  -1.76869422e-01f, -2.81318426e-01f, -1.35949761e-01f, 4.54732478e-02f, 2.82642245e-01f, 2.76670754e-01f, -2.71170288e-02f, 5.14157899e-02f, 2.65708208e-01f, -4.04150486e-02f,
  -3.59893665e-02f, -8.37628245e-02f, 1.42921254e-01f, 4.51122090e-04f, 3.69784087e-02f, 1.76631048e-01f, 9.13461372e-02f, -3.75515111e-02f, -7.38694146e-02f, -1.62563995e-02f,
  1.56234667e-01f, -6.65751398e-02f, -1.81211699e-02f, -6.33390993e-02f, 1.07112050e-01f, -2.02495847e-02f, 1.92201808e-02f, 7.20428601e-02f, 7.22633228e-02f, 1.06201269e-01f,
  7.15488791e-02f, 9.27114040e-02f, 5.88093959e-02f, -2.63110306e-02f, -9.10910144e-02f, 1.61072034e-02f, 2.56223381e-02f, 4.96869683e-02f, 6.47344440e-02f, -2.36992212e-03f,
  5.12636527e-02f, -6.04649365e-04f, 1.79083794e-02f, 2.12434866e-02f, -2.12125871e-02f, -2.76935901e-02f, 1.33992080e-02f, 1.97646506e-02f, 2.21355446e-02f, -4.13002819e-02f,
  6.49183914e-02f, -1.11521129e-03f, -1.63559783e-02f, -9.33870766e-03f, 5.36884321e-03f, -2.34653521e-02f, 3.39837633e-02f, -2.50580534e-03f, -2.69976556e-02f, -6.69659376e-02f,
  -4.48456313e-03f, -2.68257018e-02f, 2.60617808e-02f, 9.75605994e-02f, -1.05395488e-01f, -5.53522445e-03f, 4.01814096e-02f, 5.13996780e-02f, -3.18210386e-02f, 2.54127644e-02f,
  -2.41740625e-02f, -1.24899531e-02f, -6.87909126e-02f, -7.08647147e-02f, -4.16840911e-02f, -2.14433344e-03f, -8.71718377e-02f, 5.55495592e-03f, -8.35545808e-02f, -8.23034644e-02f,
  9.98240709e-02f, 8.12880993e-02f, 4.16718647e-02f, 1.02662537e-02f, -4.62946063e-03f, 2.47053355e-02f, -5.93370311e-02f, 6.31667897e-02f, 6.50083134e-03f, 1.18717119e-01f,
  1.10553622e-01f, 1.04988456e-01f, 2.57763062e-02f, 2.06841771e-02f, -2.62930170e-02f, 8.21577236e-02f, 6.12484626e-02f, -8.57386622e-04f, 5.25877904e-03f, 1.97929703e-02f,
  5.24888262e-02f, -3.39445204e-01f, 3.36889736e-02f, 3.57576549e-01f, 7.80887008e-02f, -6.71313107e-02f, -1.71877742e-02f, 1.49487957e-01f, 2.22935438e-01f, -2.19984934e-01f,
  2.88349800e-02f, -1.37684479e-01f, -1.73591435e-01f, 1.30313724e-01f, -6.40517008e-03f, -3.48576792e-02f, 1.28410801e-01f, 3.29152052e-03f, 1.22356504e-01f, 6.04489483e-02f,
  2.53753096e-01f, -3.06405351e-02f, 5.06415889e-02f, -5.22137694e-02f, 1.40600696e-01f, 1.34007499e-01f, 6.13343529e-02f, -9.05198753e-02f, -5.80991767e-02f, -8.99721682e-02f,
  4.29393649e-02f, 3.60401184e-03f, 1.04643535e-02f, -1.38166204e-01f, 5.93499243e-02f, 7.21334219e-02f, -2.42010318e-02f, 2.45414022e-02f, 2.33120099e-02f, 2.64991708e-02f,
  -5.43761812e-02f, 7.71011934e-02f, 5.73000200e-02f, -2.98776273e-02f, 1.67470204e-03f, 4.26036455e-02f, 3.31684016e-02f, -2.06273459e-02f, -4.09243889e-02f, 2.79531516e-02f,
  9.92846787e-02f, -4.03818749e-02f, 1.76320642e-01f, -7.27231428e-02f, 1.39535263e-01f, -1.46863819e-03f, 3.96864973e-02f, -1.11230224e-01f, -2.39903443e-02f, 3.59650031e-02f,
  4.64427173e-02f, -3.81734669e-02f, 5.44078983e-02f, 3.91536132e-02f, -2.08960157e-02f, 9.60764438e-02f, -4.85671237e-02f, -4.86803008e-03f, -9.98357385e-02f, -6.71959221e-02f,
  5.29219061e-02f, 4.35518213e-02f, 4.37626652e-02f, 5.86808138e-02f, 5.70601188e-02f, 8.13384578e-02f, -4.65534721e-03f, -1.27061066e-04f, 4.67735855e-03f, 6.14415519e-02f,
  -4.28575054e-02f, 1.53763089e-02f, 3.75060402e-02f, -1.77461151e-02f, -9.48128179e-02f, -4.82943766e-02f, -7.45172128e-02f, 3.35941240e-02f, 6.35545030e-02f, -7.30638951e-02f,
  -2.22013339e-01f, -7.43242353e-02f, -2.11617183e-02f, -5.09894937e-02f, -1.07477650e-01f, 3.46204489e-02f, -4.70524356e-02f, -1.78736169e-02f, -6.23598360e-02f, 1.81254279e-02f,
  -1.55990617e-02f, 2.20104214e-02f, 5.74740618e-02f, -9.00697857e-02f, -2.02595573e-02f, 3.24061550e-02f, -2.71115848e-03f, -9.73499417e-02f, -9.90800653e-03f, -2.42845882e-02f,
  -7.81553760e-02f, -6.02196380e-02f, 1.69609804e-02f, 8.00302848e-02f, -9.43408813e-03f, 3.57369296e-02f, -6.53455704e-02f, 3.24574038e-02f, -2.67592520e-02f, -1.09961532e-01f,
  4.58558723e-02f, 2.59293765e-02f, -1.53836235e-01f, -1.84994951e-01f, 8.23825449e-02f, -1.52304515e-01f, -3.29192102e-01f, -2.01362278e-02f, 8.66334811e-02f, -1.95001259e-01f,
  -1.88102156e-01f, -3.15552913e-02f, -3.16591635e-02f, -2.11391062e-01f, 3.41175906e-02f, 1.21533662e-01f, -8.79326761e-02f, -1.21583134e-01f, 2.14381546e-01f, -1.83223307e-01f,
  1.52955234e-01f, -8.77783820e-02f, 5.87434135e-02f, 9.47054699e-02f, -2.29293387e-02f, -2.20832210e-02f, 5.53154647e-02f, -2.35868394e-02f, -1.14971042e-01f, 1.18365020e-01f,
  2.32793558e-02f, -1.64300665e-01f, -1.16683878e-02f, -8.01735595e-02f, -1.62814200e-01f, -3.07904426e-02f, -1.01554558e-01f, 4.20466475e-02f, -5.39604865e-04f, 1.03329020e-02f,
  6.80572353e-03f, 7.56927067e-03f, 7.12104589e-02f, 2.89068557e-03f, 4.54357900e-02f, -7.16707762e-03f, 1.75620764e-02f, 1.68090686e-02f, -7.19155967e-02f, 9.21801105e-02f,
  3.90783213e-02f, 3.39753628e-02f, -2.73080841e-02f, 1.01435341e-01f, -3.05645559e-02f, -1.50882266e-02f, 2.17872001e-02f, 1.26127778e-02f, -2.48516854e-02f, 5.51273897e-02f,
  -4.11016829e-02f, 5.83265536e-02f, -5.40606538e-03f, 2.28907522e-02f, -1.95128955e-02f, 2.56791916e-02f, -7.31423555e-04f, 3.12465876e-02f, -6.20318688e-02f, -2.07809228e-02f,
  -2.22049970e-02f, -9.13423374e-02f, 6.94815740e-02f, -1.13841616e-01f, -2.66725961e-02f, -7.28992149e-02f, 5.51346429e-02f, -7.98136145e-02f, 1.95083916e-02f, -3.00385579e-02f,
  2.19692457e-02f, 1.19753731e-02f, -5.75681450e-03f, -1.72583666e-02f, 2.57048737e-02f, 5.65869827e-03f, 1.16909423e-03f, 9.76561606e-02f, 6.43515810e-02f, 3.95334996e-02f,
  -1.54794604e-01f, -1.90606177e-01f, -4.54590209e-02f, -2.38902513e-02f, -1.30770162e-01f, -7.55896643e-02f, -4.02971059e-02f, 7.79347867e-02f, -7.75411353e-02f, -4.14622761e-02f,
  -7.69465417e-02f, -6.72907829e-02f, -1.80744790e-02f, 7.38392919e-02f, 4.76104692e-02f, 1.07046845e-03f, -9.05375928e-02f, 3.44216228e-02f, -1.10702194e-01f, -7.75551125e-02f,
  -4.54630069e-02f, -2.49122009e-02f, -1.33205196e-02f, 1.02912955e-01f, 1.54250546e-03f, -8.98926035e-02f, -2.44079512e-02f, -5.98505810e-02f, -2.61164960e-02f, -1.05629779e-01f,
  4.96685475e-01f, 1.49663895e-01f, -5.06633520e-01f, -1.12443611e-01f, -5.77264093e-02f, 2.54382372e-01f, 9.98205692e-02f, -2.71252003e-02f, 2.36885566e-02f, 2.82096714e-01f,
  2.75126040e-01f, 3.84259634e-02f, 1.06220201e-01f, 3.44685405e-01f, 1.82782233e-01f, 2.14120045e-01f, 3.54565680e-01f, 1.99885115e-01f, 2.71971244e-02f, 1.70415550e-01f,
  -1.33796958e-02f, 3.85041505e-01f, -3.09410185e-01f, -6.33843616e-02f, 7.23258732e-03f, -2.74925292e-01f, -1.18558928e-01f, -3.69036466e-01f, 2.18047425e-02f, -7.50287203e-03f,
  1.87946290e-01f, 1.71974406e-01f, -7.39072710e-02f, -8.83805081e-02f, 7.20216855e-02f, 6.82612881e-03f, -9.75848585e-02f, -9.85707492e-02f, -1.69328392e-01f, 6.98398948e-02f,
  4.41961810e-02f, -5.15037477e-02f, 4.16514389e-02f, -5.04520163e-02f, 1.82843991e-02f, -6.41591176e-02f, -2.44427510e-02f, -4.55527157e-02f, -1.22589551e-01f, 4.08408530e-02f,
  -1.32281885e-01f, -6.69954205e-03f, 1.01060560e-02f, 2.75027864e-02f, -3.41260806e-02f, -1.37976576e-02f, -2.31071338e-02f, -4.04718071e-02f, 7.35036954e-02f, 5.08702882e-02f,
  7.17807040e-02f, 4.87313978e-02f, 8.05903748e-02f, -4.83656069e-03f, 6.49521202e-02f, 4.36379481e-03f, -1.55961129e-03f, -6.98320344e-02f, -3.77201177e-02f, 4.48171310e-02f,
  -2.90304068e-02f, -1.25868559e-01f, 1.25381127e-02f, 1.90153364e-02f, 6.58978596e-02f, 2.23091580e-02f, -1.78422648e-02f, 6.37703389e-03f, -4.51251380e-02f, -3.91873531e-02f,
  -6.15099594e-02f, 7.16960877e-02f, -2.53424309e-02f, -1.06860222e-02f, -1.36530902e-02f, -5.27890027e-02f, 8.36819932e-02f, -3.79457064e-02f, -4.13321033e-02f, -3.17823775e-02f,
  6.51754066e-02f, 5.24079762e-02f, -2.41870917e-02f, 1.69221871e-02f, -7.34139010e-02f, 1.41579002e-01f, 5.10978922e-02f, 4.19439189e-02f, -2.67776158e-02f, 1.86514445e-02f,
  2.06596591e-02f, -7.50876516e-02f, 1.00296244e-01f, -1.94965228e-02f, -7.27290362e-02f, 1.17500827e-01f, 5.09411544e-02f, -9.71424356e-02f, -7.90384263e-02f, 5.85011905e-03f,
  3.17643071e-03f, 2.88002621e-02f, 1.41084602e-03f, -1.83716565e-02f, -1.18507268e-02f, 2.07729228e-02f, 1.10630849e-02f, -1.06532127e-01f, -3.07372399e-02f, -5.66382408e-02f,
  2.84433395e-01f, -4.03253496e-01f, -8.70747417e-02f, -4.50827032e-02f, 2.07602993e-01f, 3.58394623e-01f, 1.45909905e-01f, -2.77876675e-01f, -6.70661211e-01f, -4.33222413e-01f,
  6.61445558e-02f, 9.71166492e-02f, -1.62965193e-01f, 2.55024433e-01f, 7.82208204e-01f, -4.04944085e-02f, 2.34065071e-01f, 1.96664229e-01f, -1.77334279e-01f, 6.96307570e-02f,
  6.02717213e-02f, 4.08412248e-01f, 1.78743899e-01f, 2.08247274e-01f, 2.95295358e-01f, -2.24806726e-01f, 2.11293429e-01f, 1.42217144e-01f, 3.40720385e-01f, 3.67891878e-01f,
  7.81226233e-02f, -1.96473062e-01f, -2.33916994e-02f, -1.66971013e-02f, -1.16036266e-01f, 8.60714763e-02f, 1.42289132e-01f, 2.52560824e-01f, -1.84806213e-02f, -1.23199709e-01f,
  5.76598756e-02f, 1.00418523e-01f, 6.13746175e-04f, 1.53702632e-01f, -1.04602419e-01f, -1.96903702e-02f, -1.01600491e-01f, -1.47394449e-01f, -3.48493680e-02f, 1.44719938e-02f,
  -8.21703598e-02f, -5.37674502e-02f, -5.04567660e-02f, -8.69281515e-02f, -7.78055862e-02f, -2.49821600e-02f, -1.85677744e-02f, 8.20576102e-02f, -4.01561372e-02f, -1.96648072e-02f,
  9.84024033e-02f, -2.39196159e-02f, 5.19443229e-02f, -2.11682413e-02f, 4.46983539e-02f, -2.69789509e-02f, 6.35216907e-02f, 1.07455561e-02f, -4.29946259e-02f, -1.44280745e-02f,
  -1.78085193e-02f, -9.67651792e-03f, -3.16855386e-02f, -5.38429171e-02f, 2.73525082e-02f, -6.60367310e-02f, 7.63853341e-02f, 1.13818962e-02f, -1.59871206e-01f, -3.35475989e-02f,
  -5.78561947e-02f, 2.77414471e-02f, -2.15496123e-03f, 2.49094609e-02f, 4.71105203e-02f, -5.47227710e-02f, -1.09879738e-02f, -3.13956514e-02f, -4.09096926e-02f, 5.17808534e-02f,
  -3.13760452e-02f, -5.01252972e-02f, -5.30246831e-02f, -1.44212190e-02f, -3.79782133e-02f, 7.91725740e-02f, -4.75647822e-02f, -2.17319354e-02f, 3.13347168e-02f, 7.43934810e-02f,
  1.51511142e-03f, -1.23241739e-02f, 4.74226698e-02f, 9.56085976e-03f, 8.48334581e-02f, -9.64858234e-02f, -4.50470001e-02f, 1.96437305e-03f, 2.76431330e-02f, 2.58636605e-02f,
  -1.53910033e-02f, 5.54722995e-02f, 3.81717458e-02f, 2.53685610e-03f, 3.31695601e-02f, -1.81091428e-02f, 3.47769670e-02f, -8.99884179e-02f, 7.62399361e-02f, -6.57401532e-02f,
  -7.67178178e-01f, 2.78035492e-01f, -2.92279959e-01f, -4.65090647e-02f, -2.52446443e-01f, -2.86688745e-01f, 1.05610929e-01f, -3.18062641e-02f, 1.11838527e-01f, 5.54882050e-01f,
  3.60639542e-01f, -6.64614737e-02f, 4.68669564e-01f, 2.37124264e-01f, -6.58976853e-01f, 3.00612777e-01f, -8.30243155e-02f, 1.31121114e-01f, 3.41019109e-02f, -2.14719489e-01f,
  -2.46407241e-01f, 1.96524456e-01f, -8.75146613e-02f, 1.84987739e-01f, -2.98259091e-02f, -1.31841570e-01f, -2.28048302e-02f, 1.41748279e-01f, -6.10139668e-02f, -1.03495881e-01f,
  -2.37905428e-01f, 7.35186562e-02f, -5.99155463e-02f, -1.17291603e-02f, -2.16649950e-01f, -4.03532088e-02f, -8.72111991e-02f, -2.78463271e-02f, -4.94104214e-02f, -5.59081845e-02f,
  -3.46846459e-03f, -7.51940086e-02f, -1.43344486e-02f, 1.00688785e-01f, -4.08937968e-02f, -1.50481639e-02f, -8.86976197e-02f, -7.94661790e-02f, 4.05225940e-02f, -1.34058461e-01f,
  -2.89497375e-02f, 9.04627144e-03f, -4.03092848e-03f, 4.14961465e-02f, -8.01376104e-02f, 3.70152779e-02f, -2.70059556e-02f, -1.22551434e-01f, -1.35025457e-01f, -9.86061171e-02f,
  -3.14388797e-02f, -2.26196162e-02f, 8.12705457e-02f, 3.35329883e-02f, 2.20203418e-02f, 5.94137162e-02f, -4.90443176e-03f, 3.53042856e-02f, -4.81735729e-02f, -5.29513322e-02f,
  -5.88025302e-02f, 8.77799094e-03f, -1.51854195e-02f, -1.15848333e-02f, 4.20845440e-03f, 7.41488189e-02f, 3.52934026e-03f, -7.62179792e-02f, -8.81532654e-02f, -4.34677005e-02f,
  1.03238538e-01f, -3.86047699e-02f, 8.55967849e-02f, 2.79165842e-02f, 1.49555532e-02f, -2.63049882e-02f, 7.89666101e-02f, -5.46927229e-02f, 6.22389577e-02f, -3.90536450e-02f,
  -2.30017096e-01f, -6.05746955e-02f, 8.77038389e-02f, 8.61202553e-02f, 9.66576114e-03f, -6.22135438e-02f, 4.73643132e-02f, -7.81464428e-02f, -1.11949675e-01f, -2.68974919e-02f,
  -4.86716181e-02f, 1.70431621e-02f, -7.58858547e-02f, 4.51445058e-02f, 5.00955880e-02f, -7.40749240e-02f, 1.64116416e-02f, 5.24891168e-02f, -2.91703679e-02f, -7.69119635e-02f,
  1.19004482e-02f, 2.55688988e-02f, 8.91374797e-02f, 1.80434119e-02f, -1.65115595e-02f, 5.13484096e-03f, -5.11478707e-02f, -1.01854876e-02f, -1.05257601e-01f, 6.67974306e-03f,
  4.83029336e-02f, -6.87426105e-02f, 2.23144576e-01f, -9.75920260e-02f, 3.03151608e-01f, 3.54315400e-01f, 5.36601134e-02f, 3.19725811e-01f, 1.21782929e-01f, -3.84841889e-01f,
  -6.67136088e-02f, -2.30393037e-01f, -1.14267766e-01f, -7.08550438e-02f, 1.10490084e-01f, 4.44045737e-02f, 1.75473951e-02f, -1.84377104e-01f, 2.35102981e-01f, -3.14225443e-02f,
  1.34025440e-01f, -1.35283023e-01f, 2.77295951e-02f, -4.45982292e-02f, 1.02922251e-03f, -1.26026288e-01f, -3.43761146e-01f, 5.06108664e-02f, -1.46447882e-01f, -1.61392689e-02f,
  1.19756564e-01f, -4.27923426e-02f, 9.26253945e-02f, 9.95641723e-02f, 7.36403167e-02f, 9.45055485e-02f, -1.40430212e-01f, -9.66370925e-02f, 2.73129493e-02f, 6.22349530e-02f,
  -3.52414027e-02f, -1.02936417e-01f, 4.61177044e-02f, 5.86582385e-02f, -2.28944533e-02f, 9.69051421e-02f, 1.15245268e-01f, 9.60420147e-02f, 3.48599106e-02f, 1.57815933e-01f,
  1.08904265e-01f, 1.66677181e-02f, 1.56424083e-02f, -1.65640503e-01f, -3.76016721e-02f, -6.29994199e-02f, -4.92415689e-02f, -5.47671914e-02f, -3.85272950e-02f, 8.85467231e-02f,
  -2.47998592e-02f, 4.94670123e-03f, 6.01160824e-02f, 4.46493085e-03f, -3.45646478e-02f, 9.53076705e-02f, -3.47113647e-02f, -2.09663957e-02f, -1.25472890e-02f, -1.16430789e-01f,
  -1.97679084e-02f, -2.42307447e-02f, 5.05804606e-02f, 1.72745027e-02f, -2.93853041e-02f, 6.13931865e-02f, -6.79292977e-02f, -1.03437148e-01f, 4.03945055e-03f, 5.51009104e-02f,
  -6.56431317e-02f, 8.97275563e-03f, 4.55179438e-02f, -7.52747953e-02f, -3.53246182e-03f, -5.87287620e-02f, -3.89459096e-02f, 2.58213710e-02f, -3.99547219e-02f, -3.95389982e-02f,
  4.26409282e-02f, -2.07053930e-01f, 2.62458250e-02f, -5.83504997e-02f, -5.57345450e-02f, 5.17160818e-02f, 2.47283373e-02f, -5.18324738e-03f, -8.39869231e-02f, 7.44075403e-02f,
  -2.80866423e-03f, -1.18176498e-01f, -6.23034537e-02f, -6.64888173e-02f, -4.87330509e-03f, 8.50085989e-02f, -1.97174326e-01f, -8.56930539e-02f, -1.06011428e-01f, -2.24688593e-02f,
  -1.00820504e-01f, 2.79552508e-02f, -9.29866135e-02f, 2.80190613e-02f, -8.24866146e-02f, -1.26473289e-02f, -2.42597088e-02f, -1.06008254e-01f, -3.22206058e-02f, 2.17999611e-03f,
  -3.55374694e-01f, 3.33808273e-01f, -1.43330947e-01f, -4.21937019e-01f, 1.05180912e-01f, -1.94620669e-01f, -3.35448414e-01f, 1.69864465e-02f, 5.49616292e-02f, 4.11835797e-02f,
  -7.48904273e-02f, 1.40730580e-02f, 2.41489187e-01f, -2.05739975e-01f, -1.45111874e-01f, 2.10971504e-01f, -3.82132173e-01f, -2.54663885e-01f, 1.66213050e-01f, -2.41756186e-01f,
  -1.47060946e-01f, -1.56952202e-01f, -1.16233408e-01f, 1.99042261e-01f, -3.51990908e-01f, -6.92332909e-02f, -3.15155722e-02f, 1.28094763e-01f, -2.82204360e-01f, 1.09743185e-01f,
  -1.58802539e-01f, -1.72861204e-01f, -1.66467398e-01f, -5.65838069e-02f, -1.66097105e-01f, -1.39933363e-01f, -1.43991992e-01f, 3.65537368e-02f, -6.03917539e-02f, -7.62730986e-02f,
  -3.62986401e-02f, 7.17703402e-02f, -1.79531821e-03f, 4.26853970e-02f, -6.92789555e-02f, -3.81231774e-03f, -3.23988311e-02f, 3.07018142e-02f, -4.23580669e-02f, 2.12203041e-02f,
  9.50832665e-03f, 6.29589660e-03f, -8.44494626e-02f, -5.69297895e-02f, -8.29635859e-02f, -3.59765999e-03f, -5.72058447e-02f, -4.19926308e-02f, -4.92064282e-03f, 5.93990460e-02f,
  -2.51674689e-02f, -8.46543089e-02f, -4.92977202e-02f, 2.44593490e-02f, -2.02731136e-02f, 8.55336990e-03f, -1.54221160e-02f, -3.67234275e-02f, 9.67755541e-03f, -7.33234286e-02f,
  6.20351657e-02f, -4.14994285e-02f, 3.40533927e-02f, -5.41349836e-02f, -6.66534156e-02f, -9.85945389e-02f, -3.54897566e-02f, 3.44810225e-02f, 2.32309122e-02f, 1.67446639e-02f,
  5.14226267e-03f, 1.33289434e-02f, 1.93334382e-03f, 3.01148538e-02f, -1.12736635e-02f, 5.97059950e-02f, 3.32874767e-02f, -2.68962998e-02f, -5.61069511e-02f, -2.35040244e-02f,
  -1.44950569e-01f, -2.02344224e-01f, -3.19728837e-03f, 1.36478515e-02f, 3.83830220e-02f, -5.19728996e-02f, -3.95134576e-02f, -1.24362567e-02f, -4.38775010e-02f, 1.90609451e-02f,
  -1.15418337e-01f, -2.30453201e-02f, -8.50702226e-02f, 4.58825417e-02f, 4.90765795e-02f, 4.53038886e-02f, -5.72252721e-02f, -4.80500720e-02f, -9.84229967e-02f, 2.96877790e-02f,
  3.89843956e-02f, 3.25986706e-02f, -3.15546617e-02f, -5.09063937e-02f, -1.19788833e-01f, -5.41402660e-02f, -2.23238524e-02f, -1.09815300e-02f, -4.92272489e-02f, 4.21059392e-02f,
  4.36653979e-02f, 1.79633379e-01f, 2.76418209e-01f, 3.95187497e-01f, -2.38144502e-01f, -5.65722585e-01f, -4.32214230e-01f, -3.44865001e-03f, -6.07566796e-02f, -2.34368607e-01f,
  -2.07726657e-01f, 3.19726795e-01f, -2.16082975e-01f, 2.97516495e-01f, 1.56448483e-01f, -1.15031555e-01f, 2.28019580e-02f, -8.00623149e-02f, 1.44273162e-01f, 1.59050450e-01f,
  2.65850157e-01f, 1.34460822e-01f, 3.53904635e-01f, 1.87402010e-01f, 1.06548272e-01f, 3.23913276e-01f, 2.11022034e-01f, -9.91762355e-02f, 3.85496080e-01f, 1.18534401e-01f,
  -1.63393095e-03f, 1.36092216e-01f, 6.20583110e-02f, 3.15946639e-02f, -5.33801913e-02f, -1.08319797e-01f, -1.29929287e-02f, -7.18584061e-02f, 1.30025307e-02f, 2.91069150e-02f,
  -4.79335152e-02f, 7.93551910e-04f, 6.66740015e-02f, -1.48273362e-02f, 1.13780065e-04f, 8.63663629e-02f, 8.57031941e-02f, 1.40567599e-02f, 2.79312693e-02f, 8.51013511e-02f,
  7.77446255e-02f, 1.05866991e-01f, -1.27495574e-02f, 5.38161285e-02f, 1.62786782e-01f, -4.86448146e-02f, 4.61599268e-02f, 3.79044935e-02f, 1.05635002e-01f, 4.15772758e-02f,
  4.88418601e-02f, -6.92952126e-02f, -7.85246193e-02f, -1.01716993e-02f, 1.48279285e-02f, 5.78646734e-03f, -2.43740273e-03f, -4.37167250e-02f, -1.97475739e-02f, -6.17865920e-02f,
  -4.84988764e-02f, -1.62274181e-03f, -6.80495948e-02f, -3.29595208e-02f, 1.34651400e-02f, -7.43960813e-02f, -1.48848547e-02f, -1.64949484e-02f, 4.93465550e-02f, 6.52526841e-02f,
  -4.01587859e-02f, -3.15060243e-02f, -2.01229062e-02f, -2.45881993e-02f, -6.49069250e-02f, 3.00022829e-02f, 3.66500691e-02f, -1.61031727e-02f, -4.30156291e-02f, 2.65852618e-03f,
  1.42436931e-02f, 2.19608977e-01f, 1.57598276e-02f, 1.53643405e-02f, 3.25877070e-02f, -5.25188483e-02f, 8.60123411e-02f, 3.39748710e-02f, 5.06112911e-02f, -6.31574988e-02f,
  1.80103630e-03f, -4.48725671e-02f, 2.48770826e-02f, 2.65745986e-02f, -1.08272466e-03f, 1.41354185e-02f, 3.95124741e-02f, 2.36192327e-02f, 6.61900938e-02f, 1.49043143e-01f,
  3.01050823e-02f, -1.40921280e-01f, 4.26327363e-02f, 1.19632464e-02f, -2.83427965e-02f, 6.18661307e-02f, -2.44194176e-02f, 7.72675052e-02f, 2.70211622e-02f, 6.75351769e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  4.93845910e-01f, 3.55446935e-01f, 4.44230974e-01f, 1.58371523e-01f, 1.52238294e-01f, 4.54830915e-01f, 1.28799260e-01f, 1.62929267e-01f, 2.46718735e-01f, 4.08271283e-01f,
  2.29720101e-01f, 3.77557993e-01f, 3.06679368e-01f, 2.28904471e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -1.03032671e-01f, -3.59869778e-01f, 5.43865077e-02f, -1.22928679e-01f, 1.33187220e-01f, 1.59103811e-01f, -1.28252223e-01f, -4.57179129e-01f, 5.64215705e-02f, -5.14695108e-01f,
  7.65273452e-01f, 1.12144001e-01f, 3.08291167e-01f, 4.03771130e-03f, -9.17679146e-02f, 6.06946528e-01f, -3.27166140e-01f, -4.04209822e-01f, 6.51234567e-01f, 2.06702426e-01f,
  6.70330673e-02f, -2.20762510e-02f, -3.05770040e-01f, -3.98372173e-01f, 8.76121596e-02f, -8.77789930e-02f, 3.68517220e-01f, -4.71969783e-01f, 9.58782196e-01f, -3.96631062e-01f,
  -2.17856511e-01f, -3.12076807e-01f, -1.60651043e-01f, 5.82987219e-02f, -7.57733464e-01f, -1.41838327e-01f, 6.67426214e-02f, -7.21364692e-02f, -5.43328524e-01f, 2.20113412e-01f,
  -1.03172258e-01f, -2.74566829e-01f, -5.54075241e-01f, -4.44521576e-01f, 3.52208972e-01f, 3.17586780e-01f, 3.63510966e-01f, 4.71868843e-01f, -2.86612332e-01f, -9.85953510e-02f,
  4.95606840e-01f, -9.28415358e-02f, 1.99516982e-01f, -9.07572284e-02f, -4.09518808e-01f, 1.23832464e-01f, -3.11375201e-01f, 6.00115769e-02f, 1.00742424e+00f, 5.90373099e-01f,
  -4.13565308e-01f, 3.69391851e-02f, -3.27640116e-01f, -4.48843569e-01f, 7.95076266e-02f, 2.54817873e-01f, 7.02038333e-02f, -3.80715891e-03f, 9.18161049e-02f, -8.70241880e-01f,
  7.23416582e-02f, 3.03109586e-01f, -4.94432807e-01f, -4.22906876e-01f, -7.67761543e-02f, -3.41877371e-01f, -1.81591846e-02f, -2.46419579e-01f, 6.18441522e-01f, 4.18423325e-01f,
  2.41471961e-01f, -3.83012563e-01f, -3.00247669e-01f, -1.93785116e-01f, -5.60690522e-01f, -4.67996895e-02f, -2.65163690e-01f, -1.33359537e-01f, 4.84519042e-02f, 8.16848949e-02f,
  -2.14944199e-01f, 1.04976571e+00f, -3.86014581e-01f, -1.79887578e-01f, -5.08682579e-02f, 3.75123888e-01f, -6.87049925e-01f, 1.46782890e-01f, 1.49096772e-01f, 9.76996496e-02f,
  -3.09374571e-01f, 5.17320111e-02f, -4.99863597e-03f, 1.64529592e-01f, -2.58724719e-01f, 6.92828715e-01f, 1.47786560e-02f, -2.09370032e-01f, 2.41077527e-01f, 3.66184294e-01f,
  -4.44992244e-01f, -2.36624375e-01f, 5.40227778e-02f, 2.03353837e-01f, -4.81002569e-01f, 3.45813304e-01f, -3.81064862e-01f, -2.39707485e-01f, -9.31223109e-02f, 4.56393361e-02f,
  -1.32136568e-01f, 1.39493853e-01f, -3.11276525e-01f, -1.78257570e-01f, 1.05974734e+00f, -1.75043002e-01f, 6.89563930e-01f, -1.69133231e-01f, 5.99178672e-01f, -3.78561825e-01f,
  2.38954082e-01f, -9.21109132e-03f, 7.02671170e-01f, 3.56493562e-01f, 7.41498023e-02f, 5.60855091e-01f, 3.00702095e-01f, -1.35289684e-01f, 7.06398666e-01f, 1.76296473e-01f,
  7.44085491e-01f, 1.05590425e-01f, -5.02638519e-01f, -6.68380857e-01f, -5.28503120e-01f, 5.37608266e-01f, 1.12249166e-01f, -9.63809267e-02f, -1.58719659e-01f, -1.95783243e-01f,
  -1.16957970e-01f, -3.01441669e-01f, -1.44974887e-01f, 3.09618503e-01f, -3.42392892e-01f, 1.61868900e-01f, -3.70711721e-02f, 6.59494281e-01f, 5.68607330e-01f, -1.66916221e-01f,
  3.05084437e-01f, 1.79411978e-01f, 1.05508901e-01f, 7.12570697e-02f, -1.85801201e-02f, 1.62221760e-01f, 6.28182650e-01f, 4.87364531e-01f, 2.36239985e-01f, 2.06926838e-01f,
  -3.92268598e-01f, -3.04983795e-01f, 4.52885509e-01f, -6.23075783e-01f, 6.09727278e-02f, 3.90677936e-02f, 5.31827807e-01f, -2.63650976e-02f, 3.93010110e-01f, -4.17574123e-02f,
  1.15229845e+00f, 1.11049607e-01f, 3.56342494e-01f, -5.05478799e-01f, -3.68161291e-01f, -2.63442546e-01f, 2.04204425e-01f, -2.78398871e-01f, -2.09527865e-01f, -3.21345292e-02f,
  -7.22296685e-02f, -2.24773839e-01f, 4.10891891e-01f, -7.47997463e-02f, 3.16265941e-01f, 3.38785797e-01f, -2.58739561e-01f, 3.06171268e-01f, 4.43976760e-01f, -3.64237487e-01f,
  2.94080585e-01f, -4.70548630e-01f, -8.98624241e-01f, 1.33299008e-01f, -6.26192093e-01f, -6.02039397e-01f, -4.27547880e-02f, -5.31541884e-01f, 7.02264249e-01f, -6.87483966e-01f,
  -2.72072345e-01f, -2.53159314e-01f, -1.59502998e-01f, 8.66967067e-02f, -2.60079056e-01f, -2.11902604e-01f, 5.87741554e-01f, 1.95608616e-01f, 1.77279830e-01f, -3.94211590e-01f,
  -3.17024976e-01f, 6.66391969e-01f, -3.71595085e-01f, -2.65480667e-01f, 5.83687052e-02f, -1.99979037e-01f, -3.77211988e-01f, -1.44713432e-01f, -2.59085178e-01f, -3.78574461e-01f,
  -2.32312173e-01f, -1.00885049e-01f, -1.05931632e-01f, 3.65955681e-01f, 1.29391283e-01f, 3.50498646e-01f, -5.29602431e-02f, 3.20975542e-01f, -2.68660132e-02f, -8.24311003e-03f,
  2.37925619e-01f, 1.87637568e-01f, 6.55276468e-03f, -1.79938957e-01f, -2.16926306e-01f, 5.90959072e-01f, 7.47883141e-01f, -2.47886062e-01f, 7.10973982e-03f, 5.93806207e-01f,
  8.82497802e-02f, -3.14750731e-01f, -2.49286279e-01f, -6.12669140e-02f, 6.08904898e-01f, 2.04502657e-01f, -1.23053156e-01f, -2.50947565e-01f, -2.02817291e-01f, -2.13285744e-01f,
  -4.34969425e-01f, 1.38509721e-01f, -4.50092927e-02f, -1.11369990e-01f, -5.14487028e-01f, 4.60487515e-01f, -4.35971171e-01f, -2.17537761e-01f, -4.40244973e-01f, 6.07578576e-01f,
  1.76970571e-01f, 2.77048826e-01f, -4.11678821e-01f, -4.45639729e-01f, 5.27537823e-01f, -1.48775820e-02f, -2.40471754e-02f, 3.41288149e-01f, -1.27099261e-01f, -2.49666702e-02f,
  6.51651472e-02f, -4.17207815e-02f, -2.40293711e-01f, 5.51586822e-02f, -1.94661185e-01f, -2.30253398e-01f, -2.33040243e-01f, 1.05323136e+00f, -6.21560216e-01f, 2.84991771e-01f,
  -3.62296671e-01f, 2.91209191e-01f, -1.12767860e-01f, 6.54769130e-03f, -4.30075556e-01f, 2.10651502e-01f, 5.18321157e-01f, -6.55709386e-01f, 3.45329493e-01f, 6.98541164e-01f,
  -5.11079073e-01f, -5.82870662e-01f, -5.99381089e-01f, -7.33417749e-01f, 6.41761005e-01f, 3.24519247e-01f, 1.35008961e-01f, -3.04792643e-01f, -4.71594661e-01f, 5.17721958e-02f,
  1.41574383e-01f, -1.02399565e-01f, -2.05055818e-01f, -9.87726748e-02f, -3.88304412e-01f, 8.70800793e-01f, -2.82915086e-01f, 7.04040900e-02f, -2.01973632e-01f, -3.25374901e-01f,
  3.97883087e-01f, 2.10406035e-01f, 4.01051044e-02f, 4.34635520e-01f, 1.92846619e-02f, 1.24270737e-01f, 2.96972126e-01f, -5.24109662e-01f, 4.47103500e-01f, 6.35468185e-01f,
  -6.28181875e-01f, -5.44688821e-01f, -1.39907435e-01f, 8.65162373e-01f, 4.96087611e-01f, -1.34243339e-01f, -9.19108391e-01f, 3.38640034e-01f, -3.69756132e-01f, 7.31092036e-01f,
  -2.76206344e-01f, 9.71443802e-02f, -2.46370465e-01f, 5.94221115e-01f, -6.88023344e-02f, -2.05182090e-01f, -2.12364927e-01f, -3.58773857e-01f, -1.07891180e-01f, -1.72993213e-01f,
  -7.61879906e-02f, -3.62930119e-01f, -4.59536463e-02f, 1.81717128e-01f, 2.27927472e-02f, 3.76910791e-02f, -4.62023020e-02f, 1.25252036e-02f, 4.57957610e-02f, 3.13768446e-01f,
  4.93723713e-02f, 6.68226123e-01f, 4.01182324e-01f, 4.92354304e-01f, -3.92369896e-01f, -4.25553203e-01f, -4.08484228e-02f, -2.82062460e-02f, 3.92645448e-01f, 2.94499457e-01f,
  -3.58076990e-01f, 3.09106112e-01f, 6.64015353e-01f, -2.42547303e-01f, 4.86961715e-02f, 9.66126978e-01f, -1.54978245e-01f, -1.59953117e-01f, -3.56507301e-01f, -4.43914980e-01f,
  -3.10867816e-01f, -1.55372798e-01f, -3.75327647e-01f, 2.65211821e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  1.73468585e-03f, -8.45530853e-02f, -2.34943759e-02f, -1.32994205e-01f, 1.52466699e-01f, -2.14652732e-01f, 2.91036785e-01f, -1.82681307e-01f, -1.61381349e-01f, 2.22460628e-01f,
  1.22998625e-01f, -8.35931972e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    