/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.13022667e-01f, -5.12130916e-01f, -6.81201667e-02f, -1.27720147e-01f, 1.99325219e-01f, 1.43939883e-01f, -7.77427033e-02f, -3.09089348e-02f, 1.03366494e-01f, -1.14389680e-01f,
  1.06281936e-01f, 2.36882389e-01f, 5.05057424e-02f, 1.49306834e-01f, -6.08123764e-02f, -2.02745095e-01f, -1.23300366e-01f, -2.80687939e-02f, 4.04862523e-01f, 1.54126540e-01f,
  1.07453186e-02f, -1.40032619e-01f, -8.81392062e-02f, 4.82025370e-02f, -7.52484649e-02f, 2.77102888e-01f, -4.74533699e-02f, -2.27389306e-01f, 6.61588311e-02f, -2.62761146e-01f,
  -1.97649449e-02f, -2.73771793e-01f, 3.40122655e-02f, 2.08397699e-03f, 7.50358775e-02f, -1.58954076e-02f, -8.25894065e-03f, -1.53556354e-02f, 5.24738319e-02f, -2.86645666e-02f,
  -4.13492583e-02f, -2.46792026e-02f, -6.19798712e-02f, 1.37753310e-02f, -5.59871681e-02f, -5.17702103e-02f, -4.91381101e-02f, -1.08254366e-01f, -6.10496998e-02f, -9.72829685e-02f,
  -7.21273795e-02f, -5.63642122e-02f, -1.00279480e-01f, 2.99509466e-02f, -1.14475921e-01f, 4.81305271e-02f, -3.56171094e-02f, -8.54471698e-02f, -3.64267081e-02f, -9.68764722e-02f,
  1.20450832e-01f, 3.11084520e-02f, -3.63085046e-02f, -1.21507021e-02f, 6.93944171e-02f, 1.46828722e-02f, -7.98449069e-02f, 1.93546657e-02f, 2.60704942e-02f, -3.55218202e-02f,
  -4.53520566e-02f, 3.72930616e-02f, -3.49190384e-02f, -6.19460344e-02f, 6.61076456e-02f, -5.48166968e-02f, -8.60475004e-03f, -7.03868121e-02f, -7.57640367e-03f, 2.75822077e-02f,
  8.30979738e-03f, -6.19912259e-02f, -3.20491605e-02f, -2.93687601e-02f, -7.18715116e-02f, 7.16335513e-03f, 1.12115080e-02f, -7.74877146e-02f, -2.69437414e-02f, -1.54969484e-01f,
  5.42647503e-02f, 2.95390189e-02f, -6.64052591e-02f, -5.57165705e-02f, -2.36351714e-02f, 4.89804149e-02f, -1.77590605e-02f, -8.16216692e-03f, 4.26301248e-02f, -6.30956739e-02f,
  -6.44031987e-02f, -6.01479560e-02f, -5.61745502e-02f, -2.46880148e-02f, 5.78546934e-02f, 4.79403399e-02f, 4.80741542e-03f, 5.92725202e-02f, 5.07211173e-03f, -3.05666272e-02f,
  -8.12514648e-02f, 8.22253376e-02f, 5.52374944e-02f, 3.83802727e-02f, -9.74949542e-03f, 7.82033205e-02f, 2.04100981e-02f, 4.65964973e-02f, 2.01374501e-01f, 1.63586497e-01f,
  1.69527918e-01f, -1.29489124e-01f, -5.87936901e-02f, -3.99087071e-02f, 1.60482407e-01f, 2.31593341e-01f, 3.86875004e-01f, 6.95171878e-02f, -9.35933320e-04f, 1.98706109e-02f,
  4.31572795e-02f, -1.46452814e-01f, -2.32855484e-01f, -2.50715226e-01f, -2.92586479e-02f, -3.65319587e-02f, -9.61796045e-02f, -1.38404176e-01f, -9.08303186e-02f, 1.12670988e-01f,
  4.78015700e-03f, 1.15638226e-01f, -4.24208455e-02f, -1.99450493e-01f, -1.51948661e-01f, 3.65634114e-02f, 4.09592222e-03f, -6.18976494e-03f, -1.70000911e-01f, -2.92260677e-01f,
  9.09547613e-04f, -1.37149930e-01f, -4.19606790e-02f, -8.39333981e-02f, -1.44681275e-01f, -1.87553778e-01f, -8.96045938e-04f, -1.23679958e-01f, -4.18173000e-02f, -1.15974881e-01f,
  -8.23215581e-03f, -6.89331144e-02f, -5.37491478e-02f, -6.46718815e-02f, -6.48656767e-03f, -7.85635188e-02f, -7.45192692e-02f, -2.26196423e-01f, -1.75352409e-01f, -1.12306848e-01f,
  -3.53454575e-02f, -7.47418702e-02f, -3.35556194e-02f, -5.07767498e-02f, -6.87495768e-02f, -8.30639675e-02f, -1.78575709e-01f, -2.38961041e-01f, -1.13786452e-01f, -2.04020247e-01f,
  -3.98013042e-03f, -1.00616040e-02f, 9.41811651e-02f, 1.00839794e-01f, 1.19030505e-01f, 1.34210691e-01f, 6.31436706e-02f, 1.35437444e-01f, -2.38105729e-02f, 1.58757567e-01f,
  -3.33023146e-02f, 1.22823186e-01f, 3.91117446e-02f, 6.98100477e-02f, 4.76486906e-02f, 5.31698093e-02f, 1.00948177e-01f, -1.88366752e-02f, 3.58142890e-02f, 6.72564730e-02f,
  2.10822411e-02f, 7.42499828e-02f, 1.54154912e-01f, 7.07037821e-02f, 2.21822038e-02f, 2.89912112e-02f, 7.59827495e-02f, 1.29805863e-01f, 7.05384761e-02f, 1.40241563e-01f,
  1.65177718e-01f, 2.63434593e-02f, -3.68244760e-02f, -1.16287313e-01f, -1.05850764e-01f, -2.04327255e-01f, -8.57072622e-02f, -1.33862659e-01f, -1.66869134e-01f, -1.62331343e-01f,
  1.56249758e-02f, -6.69777319e-02f, -8.90824292e-03f, -4.55589294e-02f, 1.23891719e-02f, -8.27717688e-03f, -1.74355023e-02f, -1.64867844e-02f, -9.33747217e-02f, -1.30321264e-01f,
  -1.85642287e-01f, 4.99065593e-02f, 1.82775855e-02f, -4.02941704e-02f, -1.88838951e-02f, 1.04693891e-02f, 2.37710029e-02f, -5.06032780e-02f, -5.35452217e-02f, 1.02759980e-01f,
  3.95438299e-02f, 8.45050663e-02f, 2.30964229e-01f, 1.36481777e-01f, 6.69533294e-03f, -9.94577557e-02f, -1.05031133e-01f, -1.13262229e-01f, 8.60504135e-02f, -5.22370189e-02f,
  1.71342660e-02f, -3.39740738e-02f, -1.13331228e-02f, -1.11008901e-02f, -2.05966756e-01f, -1.20056592e-01f, 1.16286822e-01f, -7.53588155e-02f, -2.55702436e-01f, -1.93131894e-01f,
  -1.85385913e-01f, 2.37765163e-02f, 1.03020623e-01f, -3.55317667e-02f, 5.64612262e-02f, -4.33454812e-02f, 1.25932112e-01f, 2.13968247e-01f, 7.07852617e-02f, 3.29961061e-01f,
  2.82517374e-01f, 2.01856688e-01f, -8.73048007e-02f, -2.38495190e-02f, 1.42299011e-01f, 1.30439401e-02f, 3.06666251e-02f, 2.11302593e-01f, 1.25770390e-01f, 4.66261990e-02f,
  1.73340172e-01f, 1.33966818e-01f, 1.28861427e-01f, 1.47400543e-01f, 8.90262946e-02f, 1.60649735e-02f, 9.88783836e-02f, 8.59904140e-02f, 1.02483511e-01f, 3.67693640e-02f,
  1.12215944e-01f, 2.11336941e-01f, 1.22607894e-01f, 2.86822412e-02f, 7.48492256e-02f, 1.03214227e-01f, 1.22727528e-01f, 7.81401992e-02f, 6.82251155e-02f, 1.51447907e-01f,
  -9.10784956e-03f, 1.99494660e-02f, -1.23414176e-03f, -5.03753126e-02f, -4.68034670e-02f, 4.95057181e-03f, -2.99436506e-02f, -1.13029405e-02f, -6.41746968e-02f, -7.24513382e-02f,
  -2.01265011e-02f, -6.83443397e-02f, -2.60257479e-02f, -2.42587700e-02f, 3.94190885e-02f, -3.04059852e-02f, -5.40461540e-02f, -5.15417866e-02f, 1.03464099e-02f, -6.65600300e-02f,
  -3.56888026e-02f, -4.36785147e-02f, 3.47367092e-03f, -2.55911704e-02f, -1.00766815e-01f, 5.79976989e-03f, -4.31560241e-02f, -8.17551762e-02f, -8.15523509e-03f, -4.37115841e-02f,
  -1.89498469e-01f, -5.85221350e-02f, 6.36816397e-02f, 1.78088732e-02f, 1.35472551e-01f, 5.87881282e-02f, -1.14631169e-02f, 5.96797019e-02f, -4.39396268e-03f, -3.45612094e-02f,
  -8.74158833e-03f, -3.14095058e-02f, 6.47596940e-02f, 1.46606760e-02f, 1.07130036e-02f, 2.24235449e-02f, 1.62721686e-02f, 2.28025783e-02f, 3.42364460e-02f, 1.35941416e-01f,
  -2.14178804e-02f, 1.78526971e-03f, -1.03270732e-01f, -3.92260179e-02f, 1.74933914e-02f, -1.22286923e-01f, -5.91573045e-02f, 1.25975329e-02f, -1.18095666e-01f, -1.51543826e-01f,
  -9.09127474e-01f, -2.82177001e-01f, 1.77744880e-01f, -8.16675350e-02f, 8.09826925e-02f, -9.85345915e-02f, -2.69287974e-01f, -1.52319133e-01f, 3.42624336e-02f, -3.84936817e-02f,
  1.61260366e-01f, 2.14831054e-01f, 1.85298532e-01f, 2.80323118e-01f, 8.47052336e-02f, -7.91361332e-02f, -3.17732058e-02f, -5.08130156e-03f, 7.46086389e-02f, 5.94125167e-02f,
  3.99475545e-02f, -9.89481583e-02f, -1.79235250e-01f, 3.63080651e-02f, 6.59760926e-03f, 1.10314980e-01f, 7.54743218e-02f, 2.59099854e-03f, 2.12305799e-01f, -2.69047655e-02f,
  4.79308143e-02f, -2.32506961e-01f, 1.43019915e-01f, -1.70766003e-02f, 2.14701742e-01f, -7.99912438e-02f, -3.85245197e-02f, 1.27609167e-02f, 2.35310607e-02f, 4.17384729e-02f,
  -8.74827523e-03f, 6.01536594e-02f, 7.60608017e-02f, 4.47356217e-02f, 1.55793782e-02f, -6.45047426e-02f, -4.59548868e-02f, -1.20004984e-02f, 9.12976488e-02f, 3.50448638e-02f,
  4.25293408e-02f, -4.79174852e-02f, -1.35866925e-01f, -7.22883791e-02f, -5.22821620e-02f, 2.26133615e-02f, 6.78596422e-02f, 1.22719547e-02f, 1.02371432e-01f, -6.30819425e-02f,
  -1.20549895e-01f, -3.42450403e-02f, 2.88695786e-02f, -9.18362066e-02f, -9.56996828e-02f, 3.50073911e-02f, 7.50964507e-03f, 3.89644615e-02f, 2.68234853e-02f, 3.03896144e-03f,
  9.79965478e-02f, 8.93021077e-02f, 1.27824038e-01f, -5.07811941e-02f, 3.26321200e-02f, 1.95206900e-03f, 2.18887553e-02f, 3.55714075e-02f, 4.80981246e-02f, 1.04729785e-02f,
  7.38635212e-02f, 7.70959556e-02f, 1.15773492e-01f, 8.93282220e-02f, 4.39583324e-02f, 1.17026288e-02f, -1.59263592e-02f, 1.68922424e-01f, -4.40007634e-02f, -4.90294918e-02f,
  1.55301705e-01f, 1.90195531e-01f, -3.61270905e-02f, -2.09668912e-02f, 1.77104212e-02f, 7.25999624e-02f, 1.04991198e-02f, 1.12432754e-02f, 1.87137760e-02f, -6.45113317e-03f,
  1.69960242e-02f, -2.03655716e-02f, 3.55602279e-02f, 1.01286672e-01f, -6.51932582e-02f, -4.17326950e-02f, 5.59188277e-02f, 1.08617102e-03f, 5.56014031e-02f, -5.22046350e-02f,
  2.20040828e-02f, -6.17530085e-02f, -1.74444243e-01f, 3.04918573e-03f, 5.09902500e-02f, -5.97101673e-02f, 2.93839145e-02f, 2.67375354e-02f, -6.16524331e-02f, -2.10304767e-01f,
  -7.14862943e-01f, 7.08371680e-03f, 3.42044413e-01f, -9.92708206e-02f, 3.14184546e-01f, 3.38849932e-01f, 3.80305588e-01f, 8.41484070e-02f, -1.03898816e-01f, 2.55688429e-02f,
  -3.84162739e-02f, -1.25508398e-01f, -1.84555173e-01f, -7.63811022e-02f, -6.79315329e-02f, 3.89908016e-01f, 2.50982672e-01f, -4.83740717e-02f, -1.69266723e-02f, 7.97424279e-03f,
  -1.16250522e-01f, -2.42133319e-01f, -3.59808356e-01f, -1.49798974e-01f, 3.61482091e-02f, 1.25131473e-01f, 1.18152015e-01f, -4.38057519e-02f, 1.01225309e-01f, -3.15166228e-02f,
  7.58645460e-02f, -2.79368684e-02f, 6.23310171e-02f, 9.92566347e-03f, 3.27019468e-02f, -4.30204161e-02f, -4.55238484e-02f, -5.21992147e-03f, -4.81426790e-02f, 2.13791244e-02f,
  -4.07478586e-02f, -8.80163461e-02f, 8.33092257e-02f, -3.26077528e-02f, -4.42873612e-02f, -3.73950377e-02f, -7.10209832e-02f, -2.79171765e-03f, -1.80419777e-02f, -1.02805449e-02f,
  3.77549604e-02f, 8.56844336e-02f, 7.42186978e-02f, 1.52108088e-01f, 8.43256712e-02f, 3.41812447e-02f, 8.09474289e-02f, 2.25097727e-04f, -6.14734851e-02f, -1.14751264e-01f,
  -4.97007631e-02f, -1.38576888e-02f, 2.53724679e-02f, 1.93643160e-02f, -7.53827095e-02f, 8.89552664e-03f, 1.74418241e-02f, 6.92114010e-02f, -2.03794409e-02f, -7.27009699e-02f,
  5.03620067e-05f, -4.51417565e-02f, -2.56179925e-02f, -6.76711202e-02f, 3.21188867e-02f, -4.71743681e-02f, 8.12335592e-03f, -1.70851555e-02f, -2.71315649e-02f, -4.51736599e-02f,
  -3.12277339e-02f, 3.47043294e-03f, 3.41798067e-02f, -2.08525080e-03f, 1.50749320e-02f, -6.66093547e-03f, 4.00398225e-02f, -4.95517664e-02f, -3.87679948e-03f, -4.10404950e-02f,
  -1.13843776e-01f, 1.06004290e-01f, 2.86136921e-02f, 3.83044928e-02f, 1.95085593e-02f, -1.35511262e-02f, 3.75802107e-02f, -2.55763028e-02f, 1.48105966e-02f, 7.89216906e-02f,
  3.13096605e-02f, 1.71046928e-02f, -2.29686312e-02f, -2.28633918e-02f, 9.97554045e-04f, -1.68688654e-03f, 5.92095517e-02f, 6.63474724e-02f, 2.00630277e-02f, 3.59104946e-02f,
  -2.86330339e-02f, 9.07574445e-02f, 8.05732906e-02f, 1.29783690e-01f, 9.01297927e-02f, 1.00319780e-01f, 1.02583602e-01f, 6.20422103e-02f, 1.92260951e-01f, 2.37943307e-02f,
  4.18461382e-01f, 3.58361095e-01f, 1.20773450e-01f, 1.32323787e-01f, -3.30564678e-01f, -3.07155669e-01f, -9.57193449e-02f, 2.93802507e-02f, 1.21219806e-01f, 8.01814571e-02f,
  4.10303362e-02f, 6.83979457e-03f, 1.09042134e-03f, -3.03764194e-02f, -9.03126150e-02f, -2.93004680e-02f, 6.19882345e-02f, 3.72133553e-02f, -1.88157827e-01f, -1.73207939e-01f,
  -1.60155401e-01f, 2.28117764e-01f, 2.73352951e-01f, 1.17378503e-01f, 2.45159119e-01f, 6.60302863e-02f, 2.86523759e-01f, 2.58400798e-01f, 1.73389316e-01f, 3.70724946e-01f,
  1.92766637e-01f, 2.12170005e-01f, -7.27791414e-02f, 3.59079763e-02f, -1.14705395e-02f, 9.25661810e-03f, -4.55312505e-02f, 1.87936813e-01f, 1.36095390e-03f, 1.29065931e-01f,
  -2.45825294e-02f, 4.16713804e-02f, 6.41179904e-02f, 8.73183645e-03f, 1.13103904e-01f, 9.55973268e-02f, 7.82535672e-02f, 2.18991324e-01f, 8.26203451e-02f, -3.26529853e-02f,
  5.30947521e-02f, 1.07089341e-01f, 4.47499566e-02f, 7.96413571e-02f, 5.24503551e-02f, 7.52111599e-02f, 1.77031949e-01f, 2.11929992e-01f, 1.53210461e-01f, 2.73175716e-01f,
  2.68580876e-02f, 2.49107871e-02f, -6.40130267e-02f, -2.04225276e-02f, -9.02831182e-02f, -2.16515269e-02f, -4.11784090e-02f, -7.28922058e-03f, -8.38914141e-02f, 1.66036580e-02f,
  -6.85545057e-02f, -2.76976861e-02f, -2.96582673e-02f, -4.35961522e-02f, -8.59189332e-02f, 1.57912225e-02f, -9.35231224e-02f, -5.00436872e-02f, 1.22084310e-02f, 4.97838436e-03f,
  -3.19030648e-03f, -7.88488332e-03f, 1.42509239e-02f, -1.07967062e-02f, 5.92022575e-02f, -2.53972933e-02f, -7.10599571e-02f, -5.07791378e-02f, -4.54016663e-02f, 1.20824284e-03f,
  7.10386038e-02f, -1.67746872e-01f, 1.49137631e-01f, 2.20320597e-02f, 4.87371236e-02f, 1.07509032e-01f, 7.44044334e-02f, 3.61093953e-02f, 6.96572587e-02f, 4.35683094e-02f,
  -8.36656615e-03f, 5.64174308e-03f, -7.05893058e-03f, 7.98539668e-02f, -5.42657748e-02f, -1.87790617e-02f, -9.19287559e-04f, 1.02355257e-02f, 5.61728925e-02f, 9.48520154e-02f,
  -3.75994816e-02f, 5.07766604e-02f, -6.78426698e-02f, -1.20812431e-02f, 2.24421211e-02f, -1.05907425e-01f, -6.98661245e-03f, -1.89271141e-02f, -1.84550121e-01f, 6.70646355e-02f,
  -6.05418146e-01f, 1.78743303e-01f, 6.93986341e-02f, -2.18461126e-01f, -9.47425812e-02f, -1.30873686e-02f, 1.53262272e-01f, -2.13513896e-02f, -1.35544300e-01f, -4.27562296e-02f,
  -2.53658980e-01f, -3.47348213e-01f, -1.43920720e-01f, -3.23510319e-02f, -1.62331853e-02f, 1.91926688e-01f, 1.99323118e-01f, -4.01193537e-02f, -1.97923720e-01f, -1.59255788e-02f,
  1.05910927e-01f, 7.96052888e-02f, -1.05916604e-01f, -1.30777648e-02f, 3.36662233e-01f, 6.62979484e-02f, 8.80931094e-02f, 5.05693518e-02f, 1.61054358e-01f, 5.79158604e-01f,
  -2.66366508e-02f, -6.26277179e-02f, -1.22539327e-01f, -7.02547505e-02f, -2.43045911e-02f, -1.09340750e-01f, 1.72190834e-02f, 2.24141795e-02f, -1.65014882e-02f, 4.21041884e-02f,
  -7.85859823e-02f, 4.76014651e-02f, -7.28345662e-02f, 1.08413018e-01f, 4.73737046e-02f, -8.22086409e-02f, 7.52915218e-02f, -1.38789117e-02f, -6.39519021e-02f, 3.04631777e-02f,
  4.73356284e-02f, -2.41491608e-02f, -1.59596559e-02f, 2.18324605e-02f, -2.63012126e-02f, -1.11113131e-01f, 9.77544710e-02f, 9.75985602e-02f, -2.51120925e-02f, 2.40149215e-01f,
  3.45018730e-02f, 4.50380184e-02f, -6.22665510e-02f, 2.69991290e-02f, -2.77560167e-02f, -7.80726820e-02f, -4.73843478e-02f, -3.24058421e-02f, 3.25328298e-02f, 3.16769965e-02f,
  -7.15171397e-02f, 2.98306104e-02f, 6.47762790e-02f, 4.51758765e-02f, 3.71404439e-02f, 3.41018699e-02f, 2.96193492e-02f, -3.18875201e-02f, -2.45446060e-03f, 2.50635482e-02f,
  -4.90576290e-02f, -1.09444007e-01f, -5.10494551e-03f, 3.10342740e-02f, 3.50277163e-02f, -1.12462314e-02f, -4.32856269e-02f, -6.27078861e-02f, -8.62454176e-02f, 5.66910906e-03f,
  -4.34621237e-02f, -1.97816804e-01f, 4.63678800e-02f, 7.01501742e-02f, -2.24238746e-02f, -3.71915698e-02f, -3.82802077e-02f, 5.41902445e-02f, -4.80043925e-02f, 1.78356078e-02f,
  3.41833793e-02f, -6.41392469e-02f, 5.04521318e-02f, -1.06311683e-02f, 8.36257823e-03f, 6.30736649e-02f, -1.97027158e-02f, -5.45666367e-03f, -1.72498566e-03f, 4.80656214e-02f,
  1.89086441e-02f, 4.45221625e-02f, -1.90285698e-01f, -3.40878107e-02f, 7.10539743e-02f, -7.25991949e-02f, 5.33364937e-02f, 5.82145974e-02f, -1.13900818e-01f, -3.88053507e-02f,
  7.24718869e-02f, -3.79062742e-01f, -4.61140387e-02f, 2.14188457e-01f, -1.08813599e-01f, -3.09988886e-01f, -3.75344992e-01f, -1.12039298e-01f, 6.72588125e-02f, -1.75364062e-01f,
  -5.89788519e-02f, 1.77476943e-01f, 1.49073705e-01f, 1.29144192e-01f, 3.45647261e-02f, -2.68908143e-01f, 4.91470695e-02f, 2.91810930e-01f, 1.22762427e-01f, 6.61959276e-02f,
  1.77757636e-01f, 2.54150063e-01f, 3.53835940e-01f, 2.37733945e-01f, -2.97429096e-02f, 8.83052424e-02f, -3.76789831e-02f, 6.21118620e-02f, -2.22639158e-01f, 5.16183525e-02f,
  -1.08353175e-01f, -1.47200301e-01f, 1.00882456e-01f, 9.74258110e-02f, -4.54609953e-02f, -6.60597831e-02f, -3.78018543e-02f, -1.07367691e-02f, 5.40162660e-02f, 7.85988346e-02f,
  1.32735178e-01f, 5.59712946e-02f, -2.80430149e-02f, 4.99616861e-02f, 6.10818490e-02f, 1.93718467e-02f, -2.21965481e-02f, 7.46270418e-02f, -3.22227255e-02f, -4.76558469e-02f,
  4.63621784e-03f, 2.75037121e-02f, 5.33919223e-03f, -8.92329514e-02f, -2.16590744e-02f, 1.15515098e-01f, -6.36060834e-02f, -9.12666097e-02f, -1.15830705e-01f, -8.08943212e-02f,
  2.49856822e-02f, 6.34770989e-02f, -5.47386296e-02f, -7.68938214e-02f, -7.48842657e-02f, -5.31799160e-03f, 6.22605570e-02f, 1.52309611e-02f, -5.03372997e-02f, -4.52727005e-02f,
  6.87128212e-03f, -5.36809824e-02f, -1.05002420e-02f, 1.66267641e-02f, 7.70325363e-02f, -4.34442535e-02f, 2.21683122e-02f, 5.92930838e-02f, 3.60025391e-02f, 5.84886922e-03f,
  1.10086519e-02f, 9.02105793e-02f, -2.88132243e-02f, 3.40499058e-02f, -1.01903297e-01f, 2.63163429e-02f, 4.15778086e-02f, -1.56607330e-02f, -8.46534967e-03f, 8.67490321e-02f,
  -9.22626182e-02f, 1.06765516e-01f, 4.77335416e-02f, 3.95975262e-02f, 4.34840210e-02f, 7.56895095e-02f, -5.73082687e-03f, 3.28034572e-02f, 5.92793189e-02f, -2.66155228e-02f,
  -2.21571270e-02f, 6.73946291e-02f, 4.27707285e-02f, 6.69595078e-02f, -1.06615731e-02f, 4.25134003e-02f, -2.10122690e-02f, 8.66089538e-02f, -1.75331323e-03f, -1.04469135e-01f,
  1.40251510e-03f, -1.26846105e-01f, -4.28186953e-02f, -4.84320633e-02f, -3.42544131e-02f, 1.27731696e-01f, -8.49842951e-02f, -1.24500006e-01f, 4.00187680e-03f, -2.93359727e-01f,
  -6.85102284e-01f, 3.22093099e-01f, 4.47042063e-02f, -8.68775472e-02f, 2.06725020e-02f, -1.67549681e-02f, 1.19569406e-01f, 2.06458747e-01f, 8.66934732e-02f, 1.62466988e-01f,
  2.00951099e-01f, 1.03725769e-01f, -1.41443117e-02f, 1.25088051e-01f, -8.10158551e-02f, 6.48378208e-02f, -2.57742801e-03f, -1.03538200e-01f, -1.26135737e-01f, -1.42453864e-01f,
  1.59443870e-01f, 2.20149532e-01f, 2.14308754e-01f, -1.83050334e-03f, 8.35606754e-02f, 3.29758413e-02f, 2.54418463e-01f, 2.32406750e-01f, 9.96925607e-02f, -1.76018551e-01f,
  -1.75683618e-01f, -7.55618066e-02f, 6.51505366e-02f, 6.27731383e-02f, 1.78610444e-01f, 2.73523442e-02f, -4.33150567e-02f, 1.20380655e-01f, 5.20975403e-02f, 1.07399300e-01f,
  8.53218958e-02f, 4.53378148e-02f, 9.09408368e-03f, 9.28136855e-02f, 6.51100129e-02f, 1.45504260e-02f, 1.99849397e-01f, 1.06981270e-01f, 1.13918237e-01f, 1.39114812e-01f,
  1.26163617e-01f, 7.42360204e-02f, -1.99460499e-02f, 1.71948045e-01f, 1.10628707e-02f, 7.27874751e-04f, 1.41033813e-01f, 5.07553071e-02f, 3.77455465e-02f, 1.15146056e-01f,
  4.76434305e-02f, -2.34631058e-02f, -1.20295770e-02f, 5.38967624e-02f, 5.55808507e-02f, -8.53403937e-03f, -5.50356731e-02f, -9.15948600e-02f, -8.94526616e-02f, 2.17590202e-02f,
  -3.59347314e-02f, -5.48474789e-02f, -4.30773981e-02f, -7.15319738e-02f, -2.07235776e-02f, -2.17088219e-02f, -1.16426244e-01f, 1.34272119e-02f, -6.16185591e-02f, -1.13716079e-02f,
  -6.89422106e-03f, -1.35056272e-01f, -3.78904194e-02f, -1.29685462e-01f, -4.09627967e-02f, -2.55734771e-02f, -1.92968938e-02f, -4.02634591e-02f, -4.64360714e-02f, -9.49206054e-02f,
  2.35441804e-01f, 4.09941375e-02f, -6.16400056e-02f, 1.49072544e-03f, 3.99709530e-02f, 9.62692499e-02f, 3.97041291e-02f, 1.12639144e-01f, 1.41986478e-02f, 6.85161818e-03f,
  8.40952992e-02f, -4.99032140e-02f, 1.69619754e-01f, 4.68551628e-02f, 3.65178287e-02f, 7.69709647e-02f, 1.44869983e-01f, 1.79867428e-02f, 8.02234039e-02f, 1.44206583e-01f,
  2.72511840e-01f, 3.88052203e-02f, 6.00070208e-02f, -4.39960882e-02f, 3.41664217e-02f, -1.14088885e-01f, 3.23804058e-02f, 1.06555387e-01f, 9.41321347e-03f, 1.48100138e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.12559116e-01f, 1.33849472e-01f, -4.39316332e-01f, 3.81445475e-02f, -5.46058379e-02f, 6.52659759e-02f, 2.04669684e-01f, -5.04748896e-03f, -3.98920141e-02f, 8.05884227e-02f,
  -1.82322815e-01f, -1.53598666e-01f, 7.28133991e-02f, 3.14848348e-02f, -8.31805170e-02f, 3.09429288e-01f, 4.08356309e-01f, 4.47478816e-02f, -2.66161740e-01f, -6.45449560e-04f,
  3.53354484e-01f, -3.62490751e-02f, -4.74076331e-01f, -3.74177992e-02f, 3.54268968e-01f, 8.83170664e-02f, -9.70742553e-02f, -4.10212390e-02f, 6.83253107e-04f, 7.10847259e-01f,
  -1.55389607e-01f, -2.21697301e-01f, -1.30588990e-02f, -1.08099289e-01f, 2.91136187e-02f, 1.15272067e-02f, 1.23881251e-01f, -9.03452188e-02f, 1.07140169e-01f, 3.23404521e-02f,
  6.43539950e-02f, -1.06107660e-01f, 2.38545224e-01f, 8.42574388e-02f, -8.83491412e-02f, -3.09914630e-02f, -1.39037058e-01f, -2.03195244e-01f, -1.15875743e-01f, -1.07108995e-01f,
  4.45643932e-01f, -9.06749144e-02f, -4.15400892e-01f, -1.20504096e-01f, -1.66115433e-01f, -1.71781600e-01f, -2.97861904e-01f, -1.06388144e-01f, -3.91069263e-01f, 6.40480369e-02f,
  6.37383088e-02f, -7.95225501e-02f, -1.31291926e-01f, -3.24295275e-02f, 1.90692082e-01f, 8.08644146e-02f, 4.96909022e-02f, 1.24082044e-01f, 3.81301790e-02f, 5.15898340e-04f,
  6.34535775e-02f, -1.02417238e-01f, -3.70769799e-02f, -9.97021273e-02f, -2.85626389e-02f, -1.25282079e-01f, 2.02595577e-01f, 9.67972055e-02f, -2.02536285e-01f, -7.53966644e-02f,
  -9.16052982e-02f, -8.55593756e-03f, 5.80663234e-02f, 1.98862165e-01f, 1.60913565e-04f, 4.01342437e-02f, 1.10503547e-01f, -2.34933328e-02f, -1.40939280e-01f, 2.60926019e-02f,
  -2.22982571e-01f, -1.71206415e-01f, 1.04041591e-01f, -1.32387295e-01f, -1.09548727e-02f, -1.87833622e-01f, -6.86529130e-02f, -2.00565322e-03f, -4.48846370e-02f, -1.62211969e-01f,
  -2.80234724e-01f, -4.05095480e-02f, -3.75621207e-02f, 8.93294811e-02f, 7.95364603e-02f, 1.61493197e-02f, 2.21889205e-02f, 7.39363953e-02f, -9.33145508e-02f, -7.55578578e-02f,
  1.37762368e-01f, -1.45043448e-01f, -2.23104641e-01f, -2.43628100e-02f, -1.14830181e-01f, -3.05120140e-01f, -1.60922393e-01f, -2.06172332e-01f, -4.26154643e-01f, -1.33094907e-01f,
  6.73702776e-01f, 3.22788745e-01f, 2.54180163e-01f, 3.19235802e-01f, 1.14718020e-01f, 2.77802080e-01f, 3.28994542e-01f, 1.77550793e-01f, 2.03499034e-01f, 2.47076139e-01f,
  3.38066727e-01f, 2.15424404e-01f, 2.20754743e-01f, 1.70889199e-01f, 2.61028081e-01f, 2.06062347e-01f, 8.33822414e-03f, -1.32377341e-03f, 5.32874838e-02f, 1.13887884e-01f,
  7.52858892e-02f, -9.36166793e-02f, -1.83969229e-01f, -2.25762296e-02f, -1.57418512e-02f, 2.97372267e-02f, -4.48333025e-02f, -1.32900491e-01f, -5.09829447e-02f, -5.33114076e-02f,
  1.82340443e-01f, 3.92245561e-01f, 9.59318057e-02f, -7.37283528e-02f, -4.56490088e-03f, -5.96556775e-02f, 9.64758359e-03f, -2.03965269e-02f, 8.63285270e-04f, 8.72857943e-02f,
  -1.15485832e-01f, -1.38041452e-01f, -1.29580572e-01f, -1.77977085e-01f, -5.73171452e-02f, 3.01061645e-02f, 1.84570495e-02f, 1.32501781e-01f, 9.40286964e-02f, 5.99643290e-02f,
  2.35853195e-02f, -8.98820814e-03f, 1.94669485e-01f, 1.41370401e-01f, -1.37929153e-02f, 6.96070865e-02f, 7.69858137e-02f, 1.12794563e-02f, 1.27869071e-02f, 1.09833203e-01f,
  1.45287186e-01f, 5.42515777e-02f, 6.21020570e-02f, -5.64778373e-02f, 1.78005248e-02f, -9.66314226e-02f, -1.27382085e-01f, -1.14547834e-01f, 2.18679407e-03f, -1.13016039e-01f,
  5.97534562e-03f, 1.46059185e-01f, 4.33089491e-03f, 1.19781993e-01f, -8.77072010e-03f, -4.16930132e-02f, -2.77846295e-04f, -5.45040816e-02f, -7.73470327e-02f, -1.68025885e-02f,
  1.01965722e-02f, -7.91473500e-03f, -1.28272325e-01f, -6.19894862e-02f, 7.01215863e-02f, 1.12979762e-01f, -9.96420085e-02f, -1.71781909e-02f, -1.50302336e-01f, -1.30815208e-01f,
  -2.35953525e-01f, 1.83194265e-01f, -5.46633871e-03f, -1.07847132e-01f, 1.74448523e-03f, -1.95764244e-01f, 1.31913513e-01f, 5.08049279e-02f, 3.47183123e-02f, 1.35711670e-01f,
  -1.38540333e-02f, -5.76652884e-02f, -4.44706948e-03f, -4.93817627e-02f, -3.03820688e-02f, -1.26516551e-01f, -4.10190709e-02f, 1.18432015e-01f, 5.34175895e-02f, 3.30667235e-02f,
  -5.95324039e-02f, 8.66848882e-03f, 1.98434100e-01f, -1.00531029e-02f, 1.53926713e-02f, -3.49045657e-02f, -6.69968501e-02f, -1.55951511e-02f, -1.80255640e-02f, -8.88178870e-03f,
  8.47776830e-01f, -2.07718968e-01f, -8.20563793e-01f, 2.15265810e-01f, -5.11650145e-01f, -3.52133423e-01f, -5.02250910e-01f, 3.06941699e-02f, 3.48171771e-01f, -3.18861157e-01f,
  -2.53900319e-01f, 3.43546152e-01f, 2.72277683e-01f, -2.19679419e-02f, 6.52179345e-02f, -6.62796617e-01f, -6.99765682e-01f, -2.30075181e-01f, -5.63603081e-02f, -2.38411739e-01f,
  -1.29621148e-01f, 5.02011999e-02f, 2.55502582e-01f, -7.67459720e-03f, -1.97212741e-01f, -1.57880127e-01f, -5.73687017e-01f, -2.14704543e-01f, -2.55993456e-01f, -4.46207523e-01f,
  -4.74133909e-01f, -1.88243926e-01f, -8.71443003e-03f, 2.17936978e-01f, -9.87670496e-02f, 2.83037066e-01f, -7.57285161e-03f, 8.62464830e-02f, 7.59647563e-02f, 4.38917940e-03f,
  -7.17885718e-02f, 7.56775513e-02f, 2.30845019e-01f, -1.35406837e-01f, -2.09119264e-03f, 1.34304008e-02f, -8.28657020e-03f, -3.81772146e-02f, 6.46033883e-02f, -1.24464817e-01f,
  -8.98380280e-02f, -1.58605173e-01f, -1.74429975e-02f, -6.16605878e-02f, -7.81806372e-03f, 1.52130639e-02f, -1.72574669e-01f, -3.32720689e-02f, -1.48453578e-01f, -8.18759352e-02f,
  -9.10880640e-02f, 2.45027840e-02f, -7.25198835e-02f, 6.81488067e-02f, 1.72017664e-01f, 8.08112696e-02f, -6.18824027e-02f, 2.52847676e-03f, -1.01713259e-02f, 3.16763073e-02f,
  4.34036329e-02f, -4.62949798e-02f, -5.55737056e-02f, -2.05782689e-02f, -5.82567453e-02f, 4.01751176e-02f, 1.13465749e-01f, -3.46198119e-02f, 8.84975307e-03f, 1.18674830e-01f,
  8.89794752e-02f, -2.38409843e-02f, -9.47749242e-02f, 4.23140116e-02f, -1.68705821e-01f, -1.11038968e-01f, -4.50674929e-02f, 5.53776212e-02f, 2.39096154e-02f, 2.90549472e-02f,
  3.72073203e-01f, -1.43552572e-01f, 2.83748880e-02f, 4.36078310e-02f, -1.03223711e-01f, -2.88765263e-02f, -7.29100555e-02f, 3.31445336e-02f, 2.81804949e-02f, 2.17314474e-02f,
  -7.20472410e-02f, -1.79283451e-02f, -5.96110635e-02f, -3.94256823e-02f, 2.02197395e-02f, 1.00411261e-02f, -4.21688717e-04f, 5.00383005e-02f, 1.88912693e-02f, -1.55273769e-02f,
  -3.18248123e-02f, 2.69107185e-02f, 2.65883535e-01f, 1.69494569e-01f, 1.39971569e-01f, 8.70666429e-02f, -1.25224411e-01f, 8.36409628e-03f, 4.98192385e-02f, 1.29584223e-01f,
  2.44254887e-01f, 3.85396659e-01f, 2.17849344e-01f, 2.72546053e-01f, 2.97553897e-01f, 9.85409543e-02f, 1.16667161e-02f, -3.33278656e-01f, -2.44128034e-01f, 9.87033248e-02f,
  2.10703850e-01f, 4.35117185e-02f, 1.92327760e-02f, -2.02584952e-01f, -2.90268540e-01f, -1.16569810e-01f, -3.97985168e-02f, -2.48604491e-01f, -4.06728417e-01f, -2.43062466e-01f,
  -9.63172466e-02f, 4.51178774e-02f, -5.35463355e-02f, -2.49112159e-01f, 1.77545354e-01f, -1.22829728e-01f, 9.08237770e-02f, 2.34267175e-01f, -1.50566502e-02f, 3.56164634e-01f,
  2.35625461e-01f, 1.91265091e-01f, -2.56051451e-01f, -3.02082449e-02f, 1.49691612e-01f, -4.06421795e-02f, -1.12765551e-01f, -7.70626441e-02f, -8.13426748e-02f, 1.51000647e-02f,
  2.15365827e-01f, -2.64096037e-02f, 2.23654553e-01f, -7.94425383e-02f, -9.05510932e-02f, -2.44583651e-01f, -1.54971734e-01f, -2.06921473e-01f, -3.03910166e-01f, 1.35039017e-01f,
  3.09910715e-01f, 3.16825628e-01f, 9.45072547e-02f, -2.90228724e-01f, 1.20498575e-01f, 1.08596973e-01f, 8.95350298e-04f, -3.51775065e-03f, -2.19441980e-01f, -1.14037074e-01f,
  -4.67658453e-02f, -2.84958873e-02f, 6.91576526e-02f, -1.09775839e-02f, 1.32937543e-02f, 7.82896951e-02f, 1.04079232e-01f, -4.00836691e-02f, -1.53488010e-01f, 1.31986085e-02f,
  -5.17592207e-02f, 7.04129562e-02f, 6.20327853e-02f, 4.10569981e-02f, 4.52572219e-02f, 7.69413188e-02f, -1.23868972e-01f, -8.06243643e-02f, 2.17742547e-02f, -7.81587362e-02f,
  -3.17598647e-03f, -1.92111805e-02f, 5.73268160e-02f, -1.22841917e-01f, 8.91802907e-02f, -1.30981520e-01f, 1.03959300e-01f, 3.57738361e-02f, -2.43508294e-02f, 5.40696383e-02f,
  -1.35581493e-01f, -8.55971277e-02f, -1.99785307e-02f, -1.41215071e-01f, 1.32590160e-01f, -2.89891660e-02f, 1.41364530e-01f, 7.35789444e-03f, 1.60033569e-01f, -6.97415993e-02f,
  1.35078982e-01f, 5.52536137e-02f, 7.99641460e-02f, -8.34359825e-02f, -1.63339615e-01f, -2.92587299e-02f, 1.83834601e-02f, -1.33236796e-01f, -2.62485445e-01f, -4.54163328e-02f,
  -7.96959996e-02f, -2.26277784e-01f, -1.48839638e-01f, -1.30127952e-01f, 8.11292231e-03f, -1.28020823e-01f, -6.29635453e-02f, -1.46766499e-01f, -2.23536402e-01f, -3.75298291e-01f,
  2.95391411e-01f, -2.61051953e-01f, 4.36924756e-01f, 3.38405877e-01f, 4.91082907e-01f, 4.75294083e-01f, 5.54617524e-01f, 3.16085130e-01f, 2.22251900e-02f, 1.36004895e-01f,
  -1.06625520e-01f, -4.07868266e-01f, -2.86676228e-01f, -3.18039238e-01f, -2.03141600e-01f, 5.83108813e-02f, 7.13992640e-02f, 3.31327245e-02f, 2.34793171e-01f, 2.26704612e-01f,
  3.71423624e-02f, 1.43966779e-01f, 4.55465913e-02f, -6.38008267e-02f, -1.03828251e-01f, -1.25776589e-01f, 7.70032555e-02f, -3.16817686e-02f, -1.86110541e-01f, -1.90352499e-01f,
  -5.51954210e-01f, 6.12873770e-02f, -4.10142494e-03f, -2.26195708e-01f, -3.64746861e-02f, 1.87384635e-02f, -4.12498824e-02f, 5.58139291e-03f, 1.28264695e-01f, -6.06583841e-02f,
  -1.09413072e-01f, -3.99682485e-03f, 8.46751407e-02f, 1.11219883e-01f, 2.25876704e-01f, 8.74143243e-02f, -5.23533523e-02f, 3.19346525e-02f, -1.26523912e-01f, -9.36596543e-02f,
  -1.05076499e-01f, 7.93851465e-02f, 2.99845021e-02f, 1.36116743e-01f, -7.95870461e-03f, -4.97190841e-03f, -3.94312330e-02f, 4.98865843e-02f, -7.54872039e-02f, -1.28459567e-02f,
  -8.48868862e-02f, -2.57768780e-02f, -1.10909782e-01f, 6.71772063e-02f, -2.79874466e-02f, 1.99039876e-02f, -1.81142129e-02f, 3.21706454e-03f, 3.52834584e-03f, 6.41800165e-02f,
  -4.30895435e-03f, -1.06138274e-01f, -8.85969773e-03f, 2.52990834e-02f, -1.00441232e-01f, 1.00932106e-01f, 6.30612597e-02f, -1.36123374e-01f, -1.13360897e-01f, 3.05740684e-02f,
  1.07475787e-01f, 8.60461742e-02f, 1.73529517e-02f, -5.27739525e-02f, 5.60688116e-02f, -1.88490245e-02f, 3.49431857e-02f, -6.33518472e-02f, 2.33715251e-02f, 9.28013120e-03f,
  -3.68779004e-01f, 3.51004079e-02f, -2.14540899e-01f, -1.71412572e-01f, 8.83283988e-02f, -6.99135214e-02f, -1.54968113e-01f, -7.04511777e-02f, -2.86819711e-02f, -4.17060368e-02f,
  -6.61205174e-03f, -1.83933973e-02f, 2.74318643e-02f, 9.33638215e-02f, 2.61821926e-01f, 6.71682805e-02f, -1.13040008e-01f, -5.58645092e-03f, -1.17759049e-01f, -1.04909725e-01f,
  4.18731757e-02f, 7.63450563e-02f, 8.69505107e-02f, 1.16363689e-01f, -6.27184138e-02f, -3.61074433e-02f, 7.69214034e-02f, 1.76819544e-02f, 1.01625770e-01f, 2.48930529e-01f,
  -1.73909649e-01f, 3.50696743e-01f, -2.75918901e-01f, 7.91456103e-02f, -1.77683115e-01f, -1.08710460e-01f, 4.28497732e-01f, 7.64437988e-02f, 2.16041766e-02f, 4.06383932e-01f,
  7.09588379e-02f, -3.28992039e-01f, -1.32073015e-01f, -2.67410874e-01f, -1.93536058e-01f, 4.16534901e-01f, 2.14815680e-02f, -3.45394760e-01f, -5.35970926e-01f, -2.86495984e-01f,
  -1.46042071e-02f, -4.40497510e-02f, -1.81521788e-01f, -2.32148707e-01f, 1.05927385e-01f, -2.38001883e-01f, 1.82283998e-01f, -2.36974984e-01f, -4.13673878e-01f, -1.75085664e-01f,
  1.07738756e-01f, -2.15584204e-01f, -1.75821424e-01f, -1.35971099e-01f, -3.10125761e-02f, -3.16070095e-02f, 2.57373042e-02f, -1.24954090e-01f, 2.06527021e-03f, -2.80694533e-02f,
  -2.76347816e-01f, 3.41019519e-02f, -1.84948340e-01f, -4.25808802e-02f, -5.94347306e-02f, -4.08550836e-02f, -6.72214404e-02f, -2.86382467e-01f, -9.91378501e-02f, -5.35989068e-02f,
  7.78226778e-02f, -1.82660908e-01f, -2.39307120e-01f, -1.69150755e-01f, -2.36750051e-01f, -3.12848359e-01f, -1.78166702e-01f, -2.41885766e-01f, -5.15287220e-01f, 2.09102690e-01f,
  9.73342955e-02f, 8.63476917e-02f, -4.00235914e-02f, -4.05192412e-02f, 1.65536970e-01f, 4.13081087e-02f, 4.69080396e-02f, 1.67497452e-02f, 4.34847511e-02f, -1.48219774e-02f,
  1.75913125e-02f, -9.35267285e-03f, -6.62205368e-02f, -4.23171744e-02f, -3.97090130e-02f, -7.15757981e-02f, 9.20292512e-02f, 1.51781112e-01f, -1.48252755e-01f, -7.10628256e-02f,
  -1.84146166e-02f, 2.96244137e-02f, -1.12237502e-02f, 7.64816850e-02f, -1.63247366e-03f, -5.73626196e-04f, 5.40725254e-02f, -8.52411054e-03f, 3.53627242e-02f, 2.72771157e-02f,
  2.14339778e-01f, -3.53344172e-01f, 2.34991938e-01f, 5.33385091e-02f, -1.04165345e-01f, -9.49846357e-02f, -5.73919192e-02f, -1.76470019e-02f, 7.29251057e-02f, 2.67956760e-02f,
  -1.07583471e-01f, 9.68990773e-02f, -1.29591048e-01f, 2.50570904e-02f, -5.08880690e-02f, -1.47490222e-02f, 9.31824073e-02f, -4.23494168e-03f, -1.04163222e-01f, 1.51497126e-01f,
  2.71870613e-01f, 1.62129715e-01f, -2.13017538e-02f, 1.35178119e-01f, -4.29035798e-02f, -1.00321800e-01f, 1.17397666e-01f, 2.48080432e-01f, -1.60343111e-01f, 5.69483101e-01f,
  -3.19791317e-01f, -5.07858753e-01f, -2.62127779e-02f, 3.47777009e-01f, 3.56668234e-01f, 4.02795255e-01f, 1.62894681e-01f, 2.47420117e-01f, 2.51595199e-01f, 6.50086775e-02f,
  -1.64029017e-01f, -6.86572269e-02f, 6.58998564e-02f, -5.15129417e-03f, -3.01601347e-02f, 2.74720192e-01f, 3.65775079e-01f, 6.78295195e-02f, 2.17922106e-01f, 1.47265568e-01f,
  1.88175946e-01f, -9.62588117e-02f, -4.89232868e-01f, -7.27641061e-02f, 6.20682724e-02f, 1.06183499e-01f, -7.82149285e-02f, -2.08611250e-01f, -1.37637466e-01f, 9.38375667e-02f,
  -8.37340802e-02f, -4.06392604e-01f, 1.70988470e-01f, -1.42709464e-01f, -2.16685981e-01f, -2.06312984e-01f, 1.81638282e-02f, -2.57650435e-01f, -7.53310993e-02f, -3.50962356e-02f,
  -4.22151200e-02f, -1.63715452e-01f, 4.77680229e-02f, -1.54880524e-01f, -2.27175757e-01f, -1.17156617e-01f, -2.22066641e-01f, 1.72379166e-02f, 1.05809227e-01f, 3.08146495e-02f,
  -6.70691803e-02f, -5.85132688e-02f, -2.51964969e-03f, 9.67845395e-02f, 2.14698762e-01f, -5.81959449e-03f, -1.21006377e-01f, -1.76354162e-02f, 6.65344670e-02f, -6.03609979e-02f,
  1.39525682e-01f, -3.11960466e-02f, 5.85907735e-02f, 5.96700013e-02f, 5.67150563e-02f, 8.06331038e-02f, 8.17300454e-02f, 5.28147072e-02f, 1.09057212e-02f, -8.51787403e-02f,
  7.80598894e-02f, 1.69764906e-01f, 3.64662930e-02f, 7.00671459e-03f, -1.37508400e-02f, -7.51884133e-02f, -7.05963075e-02f, -8.33093524e-02f, -6.88855872e-02f, 6.25998229e-02f,
  1.01607153e-03f, 3.06608770e-02f, -1.93309501e-01f, 7.97019079e-02f, 4.00826000e-02f, 6.61597252e-02f, 1.16587020e-01f, -2.00517774e-01f, -7.15448111e-02f, -9.36100781e-02f,
  1.44920409e-01f, 1.56489179e-01f, 1.13423988e-01f, 2.19232049e-02f, -1.10042684e-01f, -1.98267803e-01f, 1.14343785e-01f, 1.02044977e-02f, 2.17824131e-02f, 1.45052209e-01f,
  -7.77298063e-02f, 1.15552731e-03f, -3.07565648e-02f, -9.58167296e-03f, 5.98250553e-02f, -3.10880691e-02f, -6.10871986e-02f, 1.34641811e-01f, 2.53925063e-02f, 4.00150828e-02f,
  4.23755124e-02f, 1.53814092e-01f, 1.33354604e-01f, 2.15778232e-01f, 1.26642168e-01f, 2.24330857e-01f, -8.63242522e-03f, 1.13555275e-01f, 1.11988798e-01f, 1.78533141e-02f,
  4.44401056e-01f, 5.53172469e-01f, 2.70810127e-01f, -1.76707834e-01f, -2.03622237e-01f, -4.25729901e-02f, 3.88931721e-01f, 3.35643709e-01f, -1.25767402e-02f, -1.73188150e-02f,
  -1.44029796e-01f, -2.50515133e-01f, -6.30543381e-02f, -4.92474288e-02f, 2.87727624e-01f, 2.61177003e-01f, 2.30734363e-01f, 2.31655344e-01f, -5.38036674e-02f, -9.22670737e-02f,
  -7.05394987e-03f, -3.98576632e-02f, -2.64522452e-02f, 1.09197259e-01f, 4.36264277e-02f, -1.92212999e-01f, -4.42743255e-03f, 7.38198757e-02f, 5.60722779e-03f, 4.28661078e-01f,
  -1.00229137e-01f, 4.16629910e-01f, -3.67379129e-01f, -2.21823066e-01f, -1.74847066e-01f, 9.29433033e-02f, 1.14136534e-02f, 1.68048125e-02f, -6.52712658e-02f, 1.50534466e-01f,
  -1.43330023e-01f, 6.53702999e-04f, 1.77874640e-01f, 9.68347713e-02f, 1.95362289e-02f, -4.06409428e-02f, 1.73038900e-01f, 3.33727062e-01f, 1.61385849e-01f, -1.08185841e-03f,
  4.02983911e-02f, -3.87107581e-02f, 2.75753010e-02f, 2.35007942e-01f, 2.85185456e-01f, -1.57065675e-01f, 1.35564327e-01f, 1.34181365e-01f, 3.73929068e-02f, 2.59114861e-01f,
  -7.29141757e-03f, -1.46390125e-02f, 6.07476989e-03f, 3.08378451e-02f, 1.09108582e-01f, 9.07886624e-02f, 3.16916257e-02f, -3.42128649e-02f, 1.49713993e-01f, 8.25257078e-02f,
  -6.18446134e-02f, -9.25136171e-03f, -3.14755552e-02f, -1.09406099e-01f, -2.46050492e-01f, 1.63829215e-02f, 1.42340995e-02f, 6.55861497e-02f, -2.12144122e-01f, 3.88284363e-02f,
  5.67632588e-03f, 3.16301845e-02f, 2.44580042e-02f, 1.46572858e-01f, -8.05837885e-02f, -6.46268651e-02f, 2.29260157e-04f, -1.98313389e-02f, -5.51110208e-02f, -1.05174132e-01f,
  -4.11164790e-01f, -2.41153538e-01f, -2.23828200e-02f, 1.04857467e-01f, -6.37914464e-02f, -8.45600478e-03f, -8.17648917e-02f, -3.01199891e-02f, -1.30125463e-01f, -3.55111994e-02f,
  -1.35336563e-01f, 2.75972057e-02f, 1.24952286e-01f, 1.12813748e-01f, -1.85039550e-01f, -1.96878061e-01f, -6.95498660e-02f, 1.34310182e-02f, -6.92467112e-03f, -9.12711695e-02f,
  -1.24710001e-01f, -2.52062678e-01f, -2.52637535e-01f, -2.17318535e-02f, -1.27128378e-01f, -3.66073757e-01f, -1.68924108e-01f, -7.24430010e-02f, -1.94158465e-01f, -1.10375285e-01f,
  -5.80744684e-01f, 2.41291467e-02f, -4.12749983e-02f, -3.02128196e-01f, 1.34648561e-01f, 2.58154958e-01f, 5.40251806e-02f, 2.79823422e-01f, 2.36177996e-01f, -2.23128777e-03f,
  1.14385255e-01f, 2.63770260e-02f, -2.55998850e-01f, 9.98901501e-02f, -3.55554596e-02f, -1.73279524e-01f, -1.80766433e-01f, -2.47706071e-01f, 2.89489746e-01f, 4.09358114e-01f,
  8.29816014e-02f, -1.62171006e-01f, -1.13273092e-01f, -4.07193676e-02f, -1.74898341e-01f, -1.76938251e-01f, -5.00565588e-01f, -2.53150403e-01f, -8.69685486e-02f, -4.61869180e-01f,
  -2.04654083e-01f, 3.53830233e-02f, 1.61552623e-01f, 5.28738983e-02f, -7.23088831e-02f, -5.55239543e-02f, -2.16976041e-03f, -1.98623553e-01f, 4.65008616e-03f, 1.05283707e-01f,
  -8.32838565e-02f, 1.78127006e-01f, -1.74169302e-01f, 1.22868858e-01f, 7.57488012e-02f, 1.11514673e-01f, 7.53108189e-02f, 4.84702475e-02f, -1.45560488e-01f, 6.46663383e-02f,
  -4.72172676e-03f, -9.21310857e-02f, -3.01000476e-02f, 5.73622882e-02f, 1.93483189e-01f, -2.23802887e-02f, -1.17458971e-02f, 6.61714375e-02f, -5.27598485e-02f, -2.61861712e-01f,
  1.48146255e-02f, 1.05619163e-03f, 1.19064385e-02f, 4.17341553e-02f, -1.91811286e-02f, -5.45432121e-02f, -7.28153065e-02f, 1.17499512e-02f, 1.25314789e-02f, -3.01594045e-02f,
  6.65029660e-02f, 3.88378911e-02f, 9.85000134e-02f, -1.78347901e-01f, -6.10805973e-02f, 5.29072210e-02f, -1.33962750e-01f, -5.99211715e-02f, 2.99588125e-02f, 6.77152053e-02f,
  4.11618352e-02f, -1.14702629e-02f, -2.72848196e-02f, 4.25626002e-02f, 1.11408018e-01f, -4.66613993e-02f, -7.62680992e-02f, 9.49840769e-02f, 1.29187293e-02f, -5.45355380e-02f,
  -1.34160638e-01f, -1.17093310e-01f, -1.97362855e-01f, 1.46290332e-01f, 2.40705162e-02f, -3.34737753e-03f, -2.04948798e-01f, 1.82140335e-01f, -6.12507723e-02f, 1.25904411e-01f,
  2.22740665e-01f, -3.59474309e-02f, -1.22614510e-01f, 1.14166476e-01f, 5.11465296e-02f, 8.33704546e-02f, -1.55062154e-02f, -1.09559568e-02f, -4.48375493e-02f, 1.13247566e-01f,
  -4.49100845e-02f, -8.61138627e-02f, -1.31845996e-01f, -4.59856875e-02f, -8.30879882e-02f, -2.19697043e-01f, -2.03074351e-01f, -2.35002875e-01f, -2.79375315e-01f, -4.01037335e-01f,
  -9.30171609e-01f, 2.40060002e-01f, -3.32036018e-02f, -4.90341842e-01f, -1.21597916e-01f, 7.28855841e-03f, 7.75026530e-02f, 5.26609682e-02f, -5.54631725e-02f, -2.85306368e-02f,
  1.44914418e-01f, 3.35263577e-03f, -3.54714431e-02f, -8.09934363e-02f, -2.56899923e-01f, -2.42288321e-01f, -3.61563563e-01f, -5.58555484e-01f, -2.75534064e-01f, -6.38799891e-02f,
  -3.45292389e-01f, -6.51965320e-01f, -6.25254750e-01f, -2.15566069e-01f, -2.65610833e-02f, 8.91495310e-03f, 2.10720696e-03f, -2.30725765e-01f, 5.12394831e-02f, -8.61404389e-02f,
  2.08784759e-01f, 2.34276503e-02f, 8.37749615e-03f, -7.63862506e-02f, -9.75524448e-03f, -7.16739297e-02f, -9.63227302e-02f, 8.93907920e-02f, 6.58530369e-02f, 1.41661555e-01f,
  -1.77740995e-02f, -8.61635953e-02f, -9.51946992e-03f, -4.78511071e-03f, 4.27296059e-03f, 7.16503114e-02f, 4.21861606e-03f, -5.19913770e-02f, 8.91752839e-02f, 2.17452854e-01f,
  1.24330625e-01f, -1.08175231e-02f, 7.94659033e-02f, 2.91544706e-01f, 2.51796484e-01f, 1.17373117e-03f, 1.84462205e-01f, 2.24588633e-01f, 1.08074397e-01f, 2.31077209e-01f,
  -2.65805237e-02f, 2.20488638e-01f, -5.55269129e-04f, -9.94468108e-02f, -1.67477168e-02f, 2.14333594e-01f, 9.24542546e-02f, 7.41949454e-02f, -2.05717776e-02f, -3.09536066e-02f,
  1.21818304e-01f, -6.13770038e-02f, 6.63695037e-02f, -3.33170965e-02f, -4.63785753e-02f, -9.04219747e-02f, -2.39087939e-02f, 8.91828686e-02f, -2.43811039e-04f, -3.72343026e-02f,
  -3.85315716e-02f, 1.40479788e-01f, -1.58659190e-01f, 8.26311260e-02f, -1.29069790e-01f, -3.51375043e-02f, 7.88497087e-03f, -1.10959031e-01f, -3.63924690e-02f, -1.22277074e-01f,
  4.03306745e-02f, -3.23098540e-01f, -4.90700342e-02f, 2.24293154e-02f, 8.50096345e-03f, 6.63795695e-02f, -4.00209762e-02f, -8.45933054e-03f, 6.53922632e-02f, 2.14681178e-02f,
  5.82297109e-02f, -3.25456969e-02f, 2.44446266e-02f, 1.22313358e-01f, -7.92342797e-02f, -6.76001012e-02f, -6.47596503e-03f, -5.76406755e-02f, 6.01675287e-02f, 6.50636330e-02f,
  6.73793927e-02f, -2.92959940e-02f, 4.03144732e-02f, 2.12335140e-01f, 9.33703333e-02f, -1.49792090e-01f, 6.07264340e-02f, 1.15406767e-01f, 9.13457246e-04f, 4.36296128e-02f,
  -3.00841987e-01f, -5.81522048e-01f, -1.15073368e-01f, 1.05895557e-01f, 1.37664545e-02f, -2.04514548e-01f, -6.44847274e-01f, -4.41399038e-01f, 1.90719992e-01f, -4.82279658e-01f,
  -1.23159692e-01f, 3.76654714e-01f, 1.57115817e-01f, -4.70508896e-02f, -4.89971042e-01f, -8.33174586e-01f, -2.89552808e-01f, 3.13351769e-03f, 1.77635774e-01f, 1.17806293e-01f,
  2.26023868e-01f, 3.44528019e-01f, 3.68163735e-01f, 9.34135020e-02f, -1.05434060e-01f, 1.60389587e-01f, 1.96204497e-03f, 1.39259845e-02f, -1.74016312e-01f, -1.23831466e-01f,
  -3.63341510e-01f, -4.96828258e-01f, 1.92369550e-01f, 4.17120717e-02f, 2.62296721e-02f, -1.31424934e-01f, -2.53219962e-01f, -5.60769849e-02f, -1.27064921e-02f, -1.41892537e-01f,
  -6.39186576e-02f, -9.10014510e-02f, 3.07719633e-02f, 8.18040743e-02f, 3.20162773e-02f, -2.50293046e-01f, 8.35608970e-03f, -2.31942348e-02f, -1.39785886e-01f, -2.00914159e-01f,
  1.81222856e-01f, 5.82447350e-02f, -1.02542229e-01f, 1.30618922e-02f, -2.49870867e-01f, 2.27243170e-01f, -2.71918122e-02f, -9.95339006e-02f, -2.41669536e-01f, -2.66907871e-01f,
  1.96045548e-01f, -2.86480342e-03f, -1.17865585e-01f, -6.38495684e-02f, 2.27184384e-03f, 1.20590657e-01f, 4.64405753e-02f, 4.79451641e-02f, 1.37323782e-01f, -8.59938860e-02f,
  8.14617127e-02f, 2.83755595e-03f, 2.63143908e-02f, -1.01751052e-01f, -8.52171928e-02f, -3.61602381e-02f, 3.44194584e-02f, -2.68279165e-02f, -3.90738510e-02f, -7.61130452e-02f,
  7.43731856e-02f, -1.07603502e-02f, 8.13952386e-02f, 9.27438959e-02f, -8.17307383e-02f, -8.93486068e-02f, -8.70444905e-03f, -3.92370895e-02f, -9.32774693e-03f, -2.41308659e-02f,
  3.27674188e-02f, 2.34447613e-01f, -1.91824526e-01f, -9.33175758e-02f, -7.91233778e-02f, 6.41080271e-03f, 1.12313740e-01f, -1.10066526e-01f, 2.67502088e-02f, 3.34171541e-02f,
  -1.93170667e-01f, -8.70325193e-02f, -5.66284992e-02f, 1.65220425e-01f, 7.43139237e-02f, -1.06953010e-01f, -1.76808611e-01f, -4.11553367e-04f, -1.11170523e-02f, 2.64640953e-02f,
  -8.67689475e-02f, -3.66318583e-01f, -2.17883155e-01f, -2.47355327e-01f, 8.36597197e-03f, -2.56649368e-02f, -1.10574454e-01f, -1.27446979e-01f, -2.23745257e-01f, -3.93815696e-01f,
  -9.50401008e-01f, -1.66217759e-01f, 2.07755148e-01f, -3.40976328e-01f, -1.37791306e-01f, -1.57557353e-01f, -2.25235894e-01f, -6.77635446e-02f, -1.97657511e-01f, -1.88691691e-01f,
  -2.01094255e-01f, -2.69715726e-01f, -8.98354277e-02f, -1.21592460e-02f, -1.83492795e-01f, 6.61952943e-02f, 2.50727326e-01f, -4.95369583e-02f, -2.48214319e-01f, -1.77141532e-01f,
  -2.75361538e-01f, -3.06557089e-01f, -2.08499268e-01f, 4.51261550e-02f, -2.36555606e-01f, -7.93920904e-02f, 2.56087333e-01f, -1.72666758e-01f, -7.77723119e-02f, -2.51534104e-01f,
  -1.76280841e-01f, -4.63873893e-02f, -9.85323414e-02f, -1.68459624e-01f, 3.50263752e-02f, 6.57918528e-02f, 1.74429547e-02f, 2.55170047e-01f, 1.69825688e-01f, 9.19057652e-02f,
  1.15171890e-03f, 2.66589612e-01f, -1.01576701e-01f, -9.44537893e-02f, -2.66526103e-01f, -2.16099516e-01f, 1.38409346e-01f, 3.11785080e-02f, -1.13341488e-01f, -6.80421293e-02f,
  -2.42459267e-01f, -1.40655190e-01f, -1.50093690e-01f, 1.00843035e-01f, -1.62738301e-02f, 6.16888329e-02f, -7.93876424e-02f, -5.68060093e-02f, 7.62609392e-02f, -4.68805462e-01f,
  -5.65133207e-02f, -4.21451107e-02f, 2.03715879e-02f, 8.69935006e-02f, -3.32064331e-02f, 9.01776031e-02f, -2.33467296e-03f, -6.64612874e-02f, 8.25710893e-02f, -2.02096224e-01f,
  5.69958687e-02f, 1.93518512e-02f, 6.77980632e-02f, 1.13729514e-01f, -4.46981341e-02f, -5.99393249e-03f, 4.09583449e-02f, 8.89125690e-02f, 2.71052551e-02f, -2.52217520e-02f,
  -1.66257992e-01f, -5.49553521e-03f, 6.20031878e-02f, -5.11401109e-02f, -2.25327518e-02f, -1.80303100e-02f, 7.22352117e-02f, 6.79473812e-03f, 4.11875173e-02f, 1.36811852e-01f,
  -2.51503229e-01f, 1.60095155e-01f, -1.04871280e-01f, -1.60385787e-01f, -1.12411596e-01f, 2.53731627e-02f, -4.86713685e-02f, 6.89356625e-02f, -6.03926219e-02f, -1.18432783e-01f,
  -2.20218360e-01f, -1.05021313e-01f, 1.71965614e-01f, 2.89656483e-02f, -1.58139914e-01f, -9.82412696e-02f, -1.08864076e-01f, -1.92417622e-01f, -3.71054895e-02f, -4.34100777e-02f,
  -1.99931636e-01f, -2.90809184e-01f, -6.52882338e-01f, -2.21611112e-01f, -2.54133135e-01f, -3.58983397e-01f, -1.20421261e-01f, -2.82940537e-01f, -2.19980806e-01f, -4.89949286e-01f,
  -4.24771011e-01f, -2.27446914e-01f, -4.78625536e-01f, -5.38257539e-01f, -2.31913626e-01f, 1.94389656e-01f, 1.22873403e-01f, 1.66846231e-01f, -1.45334944e-01f, -2.92089045e-01f,
  -5.26676849e-02f, 9.60606039e-02f, -2.83474296e-01f, -6.59249350e-02f, 1.56852186e-01f, -2.62740403e-01f, -4.14505482e-01f, -1.86984047e-01f, 2.45815113e-01f, 3.30999941e-01f,
  7.22033083e-02f, -3.42129201e-01f, -2.30766624e-01f, 1.28873497e-01f, -1.67328671e-01f, -1.59389123e-01f, -4.13036615e-01f, -2.99449176e-01f, 4.00244780e-02f, -5.39847136e-01f,
  -3.67796212e-01f, -3.78900357e-02f, -2.20292322e-02f, -2.80264895e-02f, -1.64151862e-01f, -4.08294201e-02f, 2.14111675e-02f, -1.82965696e-01f, 5.59004992e-02f, -1.72655717e-01f,
  -1.47845581e-01f, 1.51944637e-01f, -8.54937285e-02f, -5.20730391e-02f, -1.05268620e-01f, 6.20574467e-02f, -4.43024039e-02f, 9.08126030e-03f, -1.09879281e-02f, 6.10637926e-02f,
  7.10256994e-02f, 4.92648035e-02f, 4.54762094e-02f, 1.88491717e-02f, 6.63283542e-02f, 2.60902780e-05f, 8.18056241e-02f, 2.17217922e-01f, 2.37016216e-01f, -1.66473687e-01f,
  -2.66086664e-02f, -1.56906005e-02f, 5.03444560e-02f, 5.44405095e-02f, -2.19869073e-02f, 1.37559706e-02f, 6.42835163e-03f, -7.63200745e-02f, 7.08649978e-02f, -6.26652464e-02f,
  -5.73138036e-02f, -2.22021528e-02f, -8.34645256e-02f, 4.39669862e-02f, 3.85801867e-03f, -7.00397119e-02f, 5.99576086e-02f, -5.28861992e-02f, 9.07782018e-02f, -3.13404910e-02f,
  7.06997886e-02f, -3.38728679e-03f, -1.51059926e-01f, 3.41250300e-02f, 8.42369720e-02f, -1.34135470e-01f, 4.35516238e-02f, 1.78927436e-01f, -1.10225558e-01f, 1.14237726e-01f,
  -3.66222352e-01f, 2.35876992e-01f, -1.91693619e-01f, 8.75615776e-02f, -3.38461287e-02f, 1.14692217e-02f, -5.98921180e-02f, 1.03922851e-01f, -6.78924024e-02f, -6.29378036e-02f,
  1.68503866e-01f, 2.80840993e-02f, -1.07449755e-01f, 5.57652712e-02f, -1.23757571e-02f, 6.49760440e-02f, -1.00794353e-03f, -5.38952723e-02f, 8.99409428e-02f, 7.52513781e-02f,
  -4.45188060e-02f, 1.45992413e-01f, -2.16843449e-02f, -7.17680231e-02f, 1.18461430e-01f, 7.98432454e-02f, 1.59608915e-01f, 3.36083286e-02f, 1.78010955e-01f, -1.92633018e-01f,
  -3.94875497e-01f, -2.80445397e-01f, -2.08506256e-01f, -4.21000957e-01f, -3.51556271e-01f, -1.17511451e-01f, -1.05705500e-01f, -2.26390347e-01f, -3.52004945e-01f, -8.99501666e-02f,
  2.34621793e-01f, 2.10200623e-01f, 1.30599707e-01f, 2.95616031e-01f, 9.03182849e-02f, -5.08269444e-02f, -1.72268182e-01f, -5.96100949e-02f, 3.54739308e-01f, 1.98151693e-01f,
  -6.83236644e-02f, -2.45423228e-01f, -2.82475054e-01f, -3.84356193e-02f, -1.67555988e-01f, 8.81759042e-04f, -1.88431874e-01f, -2.75961488e-01f, -1.17928743e-01f, -3.38380694e-01f,
  4.04087037e-01f, -1.09549411e-01f, -9.50586274e-02f, -1.73471630e-01f, -1.57339662e-01f, -1.49963766e-01f, -1.61289703e-02f, -1.25975385e-01f, -2.27739047e-02f, -5.62142988e-04f,
  -2.08436355e-01f, -2.15689316e-02f, -5.11270352e-02f, 5.39681921e-03f, 2.95636784e-02f, -8.55539814e-02f, -4.95846197e-02f, -1.29241303e-01f, -8.32297057e-02f, -4.63448875e-02f,
  -4.72457111e-02f, -1.02510452e-01f, 4.61720750e-02f, 3.16418484e-02f, 4.03799340e-02f, 2.97615509e-02f, 1.50578558e-01f, -8.20310637e-02f, 2.81895977e-02f, -1.08561940e-01f,
  -4.34694067e-02f, 5.63665293e-02f, -3.88592780e-02f, 3.12878489e-02f, 1.71565898e-02f, 5.34093343e-02f, 1.27540603e-01f, 8.03090781e-02f, 7.00554997e-02f, -6.37835935e-02f,
  4.33000475e-02f, -3.14929076e-02f, 1.22253217e-01f, -1.39680039e-02f, -1.64021805e-01f, -9.75996330e-02f, 9.88915712e-02f, -1.09697832e-02f, -5.75055182e-02f, -8.83627757e-02f,
  -1.17093526e-01f, -1.02911957e-01f, -8.74719620e-02f, 4.97475639e-02f, -2.03057349e-01f, -7.74586871e-02f, -8.61591771e-02f, 4.26636152e-02f, 3.84093411e-02f, 3.09351087e-02f,
  2.83972323e-01f, -2.90733129e-01f, 7.23848864e-02f, -3.91571783e-02f, 2.04489306e-02f, -1.14260137e-01f, -1.04232438e-01f, -2.57469565e-02f, -9.68247131e-02f, -3.62622552e-03f,
  -1.32149890e-01f, 1.13379406e-02f, 9.38760191e-02f, -8.70218575e-02f, 1.65528476e-01f, 2.41060164e-02f, -3.43568437e-03f, 3.40823084e-02f, -1.13587424e-01f, -5.47824353e-02f,
  -6.70067593e-02f, -2.39558965e-02f, 1.79600641e-01f, 1.41260341e-01f, -1.41352508e-02f, 3.02394271e-01f, 2.35718206e-01f, 6.20170943e-02f, 1.53015465e-01f, 1.24729738e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  6.76096678e-02f, 1.78237915e-01f, 1.78888872e-01f, 2.34840900e-01f, 4.32716668e-01f, 2.27496982e-01f, 2.77713150e-01f, 4.49264385e-02f, -2.92238593e-01f, 1.25169545e-01f,
  2.20523775e-01f, 2.76785076e-01f, 2.73870546e-02f, 2.26569861e-01f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.01137208e-02f, 5.85444272e-02f, -7.41711482e-02f, 3.22961621e-02f, 1.07352473e-02f, 1.02951273e-01f, -1.50081873e-01f, 2.44917616e-01f, 1.05473652e-01f, -2.53006965e-01f,
  -5.06003052e-02f, 2.23564908e-01f, -2.27181688e-01f, 1.64143201e-02f, 1.49113610e-01f, -9.99506786e-02f, 1.88105017e-01f, -1.78188890e-01f, 3.91022056e-01f, 1.27483621e-01f,
  1.76753268e-01f, 3.67826194e-01f, -9.66788605e-02f, -2.31996745e-01f, 1.88999638e-01f, -1.84477746e-01f, -4.36307609e-01f, -1.63109273e-01f, -2.89487451e-01f, 2.69210842e-02f,
  -2.05015644e-01f, 6.37226254e-02f, 4.95473593e-02f, -4.35457379e-02f, 1.16483882e-01f, -6.40260652e-02f, 7.65088573e-02f, -6.04792126e-02f, -3.53608988e-02f, -3.77193689e-02f,
  -9.77571830e-02f, -7.57447332e-02f, 2.62104310e-02f, 8.16649646e-02f, -1.98461577e-01f, 7.89253190e-02f, -1.05175547e-01f, -6.83235899e-02f, -1.13997608e-01f, -1.28854796e-01f,
  -6.80630729e-02f, 2.88064301e-01f, -2.98635066e-01f, 4.61081564e-02f, 2.61262089e-01f, -7.73654878e-02f, 4.12163772e-02f, -6.06130958e-02f, -1.26436025e-01f, -2.31049508e-01f,
  -4.08601373e-01f, 2.08293095e-01f, -1.67381708e-02f, -1.34982929e-01f, -2.53194068e-02f, 5.08700088e-02f, 4.23592925e-02f, -2.20166668e-01f, -1.99552953e-01f, -2.49191280e-02f,
  6.19903207e-02f, 9.44244489e-02f, 2.45018005e-02f, -8.27587470e-02f, 1.83720559e-01f, -5.90026230e-02f, -1.24613017e-01f, 1.44454420e-01f, 6.63535669e-02f, 2.75896996e-01f,
  -9.93413478e-03f, -8.36899132e-02f, 1.94749489e-01f, -2.29723498e-01f, -1.87111527e-01f, 2.67968833e-01f, 1.60360172e-01f, 1.03194743e-01f, -1.86299130e-01f, 2.11018592e-01f,
  -3.45229030e-01f, -1.73776507e-01f, 1.13554545e-01f, -9.17686969e-02f, -2.43844971e-01f, -1.16303332e-01f, -2.48666242e-01f, -1.64908674e-02f, -1.83472186e-01f, -2.07682654e-01f,
  -6.41105175e-02f, -5.83173521e-02f, 2.91957587e-01f, -1.00938864e-01f, 5.34455804e-03f, -2.08069161e-01f, 2.58497857e-02f, 1.99239179e-01f, 1.04551087e-03f, 3.68558884e-01f,
  1.29036099e-01f, 2.16895700e-01f, -1.80946887e-01f, 1.46290898e-01f, -7.81567544e-02f, 3.06946114e-02f, -2.85838664e-01f, 2.16407910e-01f, 1.67385072e-01f, 2.81574875e-01f,
  -4.98423390e-02f, 9.48427618e-02f, -2.17513442e-01f, 1.33294925e-01f, -1.75850824e-01f, 3.11115086e-01f, -3.77493322e-01f, -1.18864506e-01f, 4.98772487e-02f, -2.42432114e-02f,
  3.87571864e-02f, -4.97733764e-02f, 1.12485968e-01f, 1.63671777e-01f, 1.30766764e-01f, -1.43644035e-01f, 1.69441365e-02f, -5.56525681e-03f, -9.25454572e-02f, 3.17745730e-02f,
  3.33004266e-01f, 3.54992151e-01f, -1.02722056e-01f, 9.06291008e-02f, -1.67583019e-01f, 2.08857283e-01f, -7.03268275e-02f, -2.46257573e-01f, -4.22890395e-01f, 1.03796043e-01f,
  -1.35070994e-01f, 1.78401634e-01f, -2.49145925e-01f, -7.47607872e-02f, -1.90410838e-01f, 2.05316529e-01f, 4.09596786e-02f, 2.88871437e-01f, -1.58008754e-01f, 1.84832364e-01f,
  -2.32261904e-02f, 3.93519923e-02f, 7.09297881e-03f, 1.19374424e-01f, 1.10982088e-02f, -3.58956009e-02f, -2.57612765e-01f, 1.61054999e-01f, 1.93881858e-02f, 3.12614590e-02f,
  -1.04842052e-01f, 7.16417283e-02f, -2.18784615e-01f, 9.23202485e-02f, -9.00744721e-02f, 1.15732171e-01f, 1.24997817e-01f, -2.13753283e-01f, 2.44419754e-01f, -1.85835764e-01f,
  -1.38185909e-02f, -1.40962481e-01f, -1.55478686e-01f, -4.63491350e-01f, 1.51837587e-01f, 1.17801949e-01f, 3.92727643e-01f, -2.24956665e-02f, -2.92433858e-01f, 6.59345165e-02f,
  3.49357069e-01f, 2.26115093e-01f, -2.02361181e-01f, 3.68522778e-02f, -1.49554521e-01f, -1.29325697e-02f, 8.88843089e-02f, -9.70331803e-02f, 2.80397646e-02f, -1.73820868e-01f,
  1.33208662e-01f, -1.88624427e-01f, -5.61419278e-02f, 1.01317599e-01f, -5.68664670e-02f, -2.28895202e-01f, -8.46531987e-03f, -1.45293593e-01f, -5.64055927e-02f, -2.55694270e-01f,
  -2.67774343e-01f, 1.26282841e-01f, 2.16686100e-01f, 3.01417977e-01f, -2.90428728e-01f, -2.76439786e-01f, -2.08579421e-01f, 4.09396142e-01f, 1.38108864e-01f, -6.07934743e-02f,
  1.41632318e-01f, -1.63195699e-01f, 2.30268136e-01f, -2.81309932e-01f, -1.71678588e-01f, 4.68883999e-02f, -2.03241277e-02f, -5.49995378e-02f, -1.35767519e-01f, -1.51254103e-01f,
  -1.20433956e-01f, 1.20012416e-02f, -1.40667260e-01f, -3.22053909e-01f, 5.52568864e-03f, 2.12272599e-01f, -1.10163487e-01f, -4.58257228e-01f, 2.08301008e-01f, 9.86336148e-04f,
  2.29790643e-01f, -3.04228608e-02f, -3.10063630e-01f, 1.44627631e-01f, 4.79483604e-01f, 1.32352486e-01f, -2.14674212e-02f, 2.14856878e-01f, -7.46032372e-02f, 3.57082456e-01f,
  -1.11798504e-02f, -5.15761897e-02f, 2.25644723e-01f, 7.40942806e-02f, -2.61019170e-01f, -2.98611790e-01f, 2.03525037e-01f, 1.57383196e-02f, 1.81624562e-01f, 6.90771490e-02f,
  2.06988141e-01f, 1.27470747e-01f, 7.53170848e-02f, 2.42044609e-02f, 4.22089547e-02f, 8.80387649e-02f, -1.86324436e-02f, -2.01437831e-01f, -1.50081575e-01f, -1.77470297e-01f,
  -1.27354920e-01f, -2.10904572e-02f, 1.76467046e-01f, 1.28407851e-01f, 4.43881452e-02f, -1.01955064e-01f, 9.44724604e-02f, -1.42285720e-01f, 1.82857633e-01f, -1.28064200e-01f,
  1.59238115e-01f, -1.74565509e-01f, -1.28016070e-01f, -3.46966088e-01f, 3.51702832e-02f, 1.05324164e-02f, 1.96526185e-01f, -1.79925114e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.26097062e-01f, -5.63686574e-03f, 1.09632917e-01f, -7.57411420e-02f, 1.30252719e-01f, 1.20300606e-01f, 4.36401188e-01f, 5.14157750e-02f, 7.92551190e-02f, -1.66518122e-01f,
  3.74689288e-02f, -2.42164537e-01f, -3.49088013e-02f, -6.93113804e-01f, 3.09671104e-01f, -2.58729935e-01f, 6.75177621e-03f, 6.44084334e-01f, 9.22914147e-02f, -1.79772437e-01f,
  2.50752270e-01f, -7.56470382e-01f, 9.09469500e-02f, 6.02250516e-01f, 6.69702739e-02f, -3.28436732e-01f, -1.47414312e-01f, -1.86741471e-01f, 1.73257347e-02f, -4.84907590e-02f,
  -1.44563764e-01f, -2.38560587e-01f, 1.90920651e-01f, 8.97182003e-02f, -2.33257264e-02f, 2.14581668e-01f, 1.62234709e-01f, 1.96597829e-01f, -4.65098917e-01f, 2.64588781e-02f,
  -3.16841993e-03f, 2.50285208e-01f, 5.50608933e-02f, 5.56715094e-02f, 2.45731309e-01f, -4.05607492e-01f, -6.04867190e-02f, -4.72129971e-01f, 2.86089450e-01f, -2.60328520e-02f,
  2.10893550e-03f, 4.52383369e-01f, 5.88119030e-01f, 5.44240475e-02f, -1.06879510e-01f, -3.64342272e-01f, -7.30880499e-02f, -1.58271994e-02f, 2.79533416e-01f, 1.02049932e-01f,
  5.34348488e-01f, 1.50333727e-02f, 3.63439292e-01f, -8.48507881e-02f, 8.70239437e-02f, 2.72221118e-01f, -5.17371818e-02f, 8.09758082e-02f, 2.43501246e-01f, 1.46707043e-01f,
  1.85870707e-01f, 3.16473603e-01f, 1.59185767e-01f, -5.34500033e-02f, 1.24287121e-01f, -9.51158032e-02f, -5.77910542e-02f, 3.45738739e-01f, -1.22624906e-02f, -2.38704547e-01f,
  -3.43693256e-01f, -1.83563694e-01f, -3.28027546e-01f, -1.12102509e-01f, 5.13035536e-01f, 3.48071218e-01f, 7.35379517e-01f, 4.11600143e-01f, 1.82508573e-01f, -8.87477100e-02f,
  -4.42432046e-01f, -8.29584617e-03f, -3.04300100e-01f, -1.49278492e-01f, -4.35774364e-02f, 4.51132208e-01f, 1.50466830e-01f, 6.18108325e-02f, 2.05379739e-01f, 1.09956019e-01f,
  -5.07470854e-02f, 1.01249285e-01f, -1.36826560e-01f, 6.17757924e-02f, 1.41950205e-01f, 3.65687460e-01f, 7.42748678e-02f, -2.57302105e-01f, 4.55048867e-03f, 6.39475435e-02f,
  -2.79181391e-01f, -1.89936027e-01f, -3.82488631e-02f, -8.80490150e-03f, 3.06266338e-01f, 3.71916266e-03f, 3.03047240e-01f, -2.65041769e-01f, 1.88742071e-01f, -1.36050642e-01f,
  6.30842090e-01f, 4.67811599e-02f, 3.51610810e-01f, 3.07998896e-01f, 1.51535958e-01f, 1.82967573e-01f, 6.38694346e-01f, 3.96210670e-01f, 1.30824238e-01f, 1.27864152e-01f,
  1.05591029e-01f, 9.36691314e-02f, -1.19091896e-02f, 2.18994655e-02f, -2.77871080e-02f, 2.37922221e-01f, -5.70173979e-05f, -4.10405062e-02f, -4.97315489e-02f, -1.99656650e-01f,
  2.10241318e-01f, 4.58231270e-01f, -2.93462932e-01f, 2.26450592e-01f, -1.49827421e-01f, 3.75934869e-01f, 6.64141297e-01f, 1.94055110e-01f, -5.98621309e-01f, 1.70525789e-01f,
  -4.27497894e-01f, 4.13792074e-01f, 5.34739077e-01f, -2.07218871e-01f, 2.26482749e-01f, 8.48113596e-02f, -3.28722715e-01f, 3.10683429e-01f, 3.60419214e-01f, -1.18813433e-01f,
  1.29903913e-01f, -1.40558090e-02f, 1.22497827e-01f, 1.64186150e-01f, 1.65590107e-01f, 1.76361591e-01f, 2.32419614e-02f, 2.08860382e-01f, 1.55847684e-01f, 2.38599867e-01f,
  -1.28360325e-02f, -1.15795024e-01f, -8.64245221e-02f, 4.59330529e-01f, -4.55206633e-02f, -2.92820185e-01f, 1.03334241e-01f, 7.12056309e-02f, -3.44724476e-01f, 5.54003865e-02f,
  4.83692944e-01f, 2.35466763e-01f, 6.41342759e-01f, 2.35578030e-01f, 4.17445868e-01f, 5.16034476e-03f, -5.39601684e-01f, 1.24834448e-01f, -3.59572500e-01f, 6.06552474e-02f,
  -1.74621984e-01f, 5.61388433e-01f, 5.82857192e-01f, 9.79582667e-02f, -1.05077244e-01f, 1.10872656e-01f, 3.23560268e-01f, 3.57284397e-01f, -1.81297332e-01f, -1.97062552e-01f,
  2.94055223e-01f, 1.81994528e-01f, -2.54923195e-01f, 1.37457829e-02f, 3.97307724e-01f, -5.81598401e-01f, -7.61045143e-04f, -3.98248196e-01f, 4.87910539e-01f, 1.71962976e-01f,
  3.07758421e-01f, -1.50673047e-01f, 5.97973764e-01f, 4.21174467e-01f, -1.91981718e-01f, -7.13360682e-02f, 7.12934509e-02f, -4.67788935e-01f, -1.66880921e-01f, -3.33292693e-01f,
  6.19019866e-01f, -1.90061375e-01f, 5.25255576e-02f, -1.42434612e-01f, 1.27528816e-01f, 1.29972577e-01f, 1.78537205e-01f, 1.37082577e-01f, 4.33843672e-01f, 3.82615238e-01f,
  7.79081834e-03f, 1.28500843e-02f, 9.41163898e-02f, 1.26968861e-01f, 3.12564597e-02f, 7.37793595e-02f, -8.48478898e-02f, 2.85150588e-01f, -7.37643568e-03f, -2.60464758e-01f,
  -2.85501391e-01f, 1.89423814e-01f, -4.29251879e-01f, 7.99139068e-02f, 2.18106378e-02f, 1.76841140e-01f, 1.15478538e-01f, 4.88536209e-01f, -1.10642090e-01f, 1.17338322e-01f,
  6.02935135e-01f, 5.64799666e-01f, -8.18788633e-02f, 7.01775193e-01f, 3.80015194e-01f, 5.16973257e-01f, 3.54197234e-01f, -5.45077287e-02f, 4.97508757e-02f, 2.41986603e-01f,
  3.81061494e-01f, -1.53348207e-01f, 2.44997010e-01f, 2.11704783e-02f, 2.65801847e-01f, -1.70327380e-01f, -2.46056497e-01f, 3.99111241e-01f, 2.86004990e-01f, -3.78652781e-01f,
  2.37466425e-01f, 1.34157091e-01f, 3.76189053e-01f, 1.83214277e-01f, 4.81726706e-01f, -3.67341518e-01f, -2.14346737e-01f, 1.15134388e-01f, -2.24013194e-01f, 1.87522262e-01f,
  1.54880464e-01f, 1.26953945e-01f, 5.51384151e-01f, 5.31831920e-01f, 6.28796518e-01f, 5.98527908e-01f, 2.33009458e-01f, -3.92596751e-01f, 4.09259170e-01f, 2.75501817e-01f,
  -1.51284069e-01f, -4.93930355e-02f, 5.23069799e-01f, 3.16322595e-01f, 3.58222246e-01f, -3.80277261e-02f, 1.96676105e-01f, 3.10890237e-03f, 1.18261976e-02f, 3.97319138e-01f,
  4.92808908e-01f, -1.20270245e-01f, -4.46503088e-02f, -2.22492352e-01f, 2.26994619e-01f, 1.31706804e-01f, 9.03335214e-02f, -1.85433049e-02f, 1.38090536e-01f, 2.67302394e-01f,
  -2.75447607e-01f, 1.39826670e-01f, -4.22924846e-01f, -1.48167193e-01f, -2.36046642e-01f, -1.25231007e-02f, 3.90409291e-01f, 2.10457087e-01f, -3.79157811e-01f, 8.64758156e-03f,
  1.82390615e-01f, 1.67041555e-01f, 2.40020499e-01f, 1.39999464e-01f, 1.96769640e-01f, 1.19164042e-01f, 7.45083094e-02f, -2.91313648e-01f, 1.33232310e-01f, 2.64491737e-01f,
  -1.97596803e-01f, -1.78969547e-01f, 6.56030104e-02f, -2.11381376e-01f, -2.09427759e-01f, -3.60555232e-01f, 7.89845958e-02f, 8.48359838e-02f, -4.28527534e-01f, 6.22499101e-02f,
  4.34809886e-02f, -4.66975540e-01f, 1.45467430e-01f, 1.00610174e-01f, -3.15932244e-01f, 7.59940520e-02f, 4.52938020e-01f, 1.61426395e-01f, 3.78304362e-01f, 4.23625886e-01f,
  4.74302948e-01f, -8.46228823e-02f, 1.34017959e-01f, 1.74025401e-01f, 5.23379147e-02f, -2.06817284e-01f, 2.46010378e-01f, 1.56382039e-01f, 3.26371849e-01f, 3.25226635e-01f,
  1.91499516e-01f, -1.93196386e-01f, 2.18291715e-01f, -6.62271231e-02f, -2.07727119e-01f, -6.12993864e-03f, 1.06162727e-01f, -3.79702412e-02f, -2.01013342e-01f, 2.75050133e-01f,
  -2.39740640e-01f, 1.65336818e-01f, 2.24881321e-01f, 1.95356548e-01f, 3.10566753e-01f, 6.70430839e-01f, -3.18397909e-01f, -2.13100929e-02f, -4.86731440e-01f, 1.86948597e-01f,
  -6.27669618e-02f, 1.16527654e-01f, -2.85642177e-01f, 7.71003067e-02f, 1.26124825e-02f, 2.01315641e-01f, 1.58186778e-01f, 2.10745379e-01f, -1.95035785e-01f, -2.40673900e-01f,
  3.91162112e-02f, 2.91828871e-01f, 3.95958155e-01f, -4.46229488e-01f, -5.24069741e-02f, 3.16443503e-01f, -1.73961408e-02f, -8.93472657e-02f, 2.13716730e-01f, 1.34468064e-01f,
  -1.39490589e-01f, -1.25212763e-02f, 4.87151355e-01f, 1.59642339e-01f, -2.45536104e-01f, 6.41992629e-01f, -1.43159866e-01f, -4.19848226e-02f, 1.55388758e-01f, 6.10409856e-01f,
  7.55283237e-02f, -5.13170362e-01f, 1.28704965e-01f, -1.95840746e-01f, -3.24211776e-01f, -2.06915215e-01f, 2.22847357e-01f, 2.34764576e-01f, 2.03730538e-01f, 1.80200368e-01f,
  8.38174373e-02f, 1.02194607e-01f, -7.72736222e-02f, 2.49312952e-01f, -1.93559006e-02f, 1.36892544e-02f, -1.20482124e-01f, -2.82447726e-01f, -7.16791004e-02f, -1.17609255e-01f,
  -9.34585333e-02f, -9.59037989e-02f, 1.66030943e-01f, 1.16660316e-02f, 4.11534637e-01f, -4.74640690e-02f, 3.24625373e-01f, 1.00950427e-01f, 4.77688879e-01f, -8.20210874e-02f,
  3.19205403e-01f, 6.11486852e-01f, 6.87867925e-02f, -3.26472223e-01f, 5.77949546e-02f, -1.55667961e-01f, 5.55044532e-01f, 1.89006284e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  -1.80918947e-02f, -1.51728047e-02f, 5.69475330e-02f, -1.51024625e-01f, -1.14258856e-01f, 2.62699693e-01f, 2.78262258e-01f, 1.03930689e-01f, 1.52374342e-01f, 2.78856337e-01f,
  -1.06504768e-01f, 1.65745780e-01f, 2.51142889e-01f, 2.83621132e-01f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  1.24842934e-01f, -5.17106414e-01f, -3.18629332e-02f, 2.86512494e-01f, -2.60077626e-01f, -5.33648990e-02f, -4.47978944e-01f, -3.53308409e-01f, -2.07033202e-01f, 5.72275370e-02f,
  3.14541936e-01f, 1.49533957e-01f, 7.21579045e-02f, -4.42588925e-01f, -1.81625798e-01f, -1.72893599e-01f, 3.61807607e-02f, 1.64417312e-01f, 2.63116330e-01f, -9.24791768e-02f,
  -2.59823352e-02f, -1.00431293e-01f, 2.72643007e-02f, 1.04338035e-01f, -3.60683262e-01f, 1.55511964e-02f, -3.81444991e-02f, -8.90027077e-05f, -8.53055716e-02f, 1.95434928e-01f,
  -1.84319422e-01f, -2.14058161e-01f, -7.38592148e-01f, 1.46987345e-02f, 5.15405834e-02f, -2.96574354e-01f, -1.64482847e-01f, 1.72462612e-01f, -4.29949444e-03f, -2.32392147e-01f,
  2.74964012e-02f, 8.97648484e-02f, -1.29866421e-01f, -1.53633550e-01f, -1.41334444e-01f, 3.05695713e-01f, 5.77953458e-01f, 9.26203132e-02f, -1.35952190e-01f, -1.76343992e-01f,
  -6.00736618e-01f, 2.34415397e-01f, 8.75081494e-02f, 1.93163127e-01f, 3.08988929e-01f, -1.19356669e-01f, 5.06019667e-02f, -4.11223210e-02f, 1.14704788e-01f, -4.86353450e-02f,
  -2.39383988e-02f, -1.67831317e-01f, 8.85010585e-02f, -3.34357858e-01f, 4.26537216e-01f, 2.87210010e-02f, 3.43052601e-03f, 3.57222855e-01f, -1.17448598e-01f, -1.62916839e-01f,
  1.38299391e-01f, -1.51945949e-01f, 1.45479694e-01f, 3.84651460e-02f, -4.89013821e-01f, -5.25279976e-02f, -2.46489257e-01f, 6.66698664e-02f, -1.63727120e-01f, 2.59639651e-01f,
  5.44070415e-02f, -6.54100999e-02f, -1.94106728e-01f, 2.47298107e-02f, -3.02873731e-01f, -2.21481428e-01f, 4.85624939e-01f, -1.03336237e-01f, 4.30306457e-02f, 1.42320737e-01f,
  -4.46221866e-02f, 3.14583927e-01f, -4.44718786e-02f, 2.25956172e-01f, 1.50463372e-01f, -3.37591511e-03f, -1.19256906e-01f, 2.23523304e-01f, 3.62030596e-01f, -2.67045319e-01f,
  7.42751434e-02f, 4.36926633e-02f, -1.27001926e-01f, -2.00783476e-01f, 2.93688029e-02f, -1.70169398e-01f, -4.33828793e-02f, 6.94242656e-01f, 2.00658843e-01f, -8.81161615e-02f,
  3.93801659e-01f, -4.41505015e-02f, -3.42694730e-01f, 7.17076898e-01f, 2.78040737e-01f, -2.76769161e-01f, 1.34006545e-01f, 2.67157536e-02f, -2.78916270e-01f, -1.28153577e-01f,
  -1.60638258e-01f, -6.75617531e-02f, 9.26062167e-02f, 1.11919023e-01f, 3.26131821e-01f, -2.99051970e-01f, 9.46857780e-02f, 3.04998338e-01f, -9.37518384e-03f, 1.91733260e-02f,
  -8.63233954e-02f, 2.41390154e-01f, -2.75045097e-01f, -2.23453328e-01f, -3.39110419e-02f, 1.15416512e-01f, -1.68002576e-01f, -1.60424903e-01f, -4.73222613e-01f, -3.19749057e-01f,
  -2.12586373e-01f, 1.88692719e-01f, -8.29370543e-02f, 1.73575357e-01f, -1.34542271e-01f, -1.42970309e-01f, 1.35545954e-01f, -7.92550445e-02f, -1.35601927e-02f, -1.10248111e-01f,
  1.04668319e-01f, -2.31137350e-01f, -1.87857106e-01f, 1.94553390e-01f, 1.46158665e-01f, 1.10598080e-01f, 1.58380896e-01f, 4.49686721e-02f, -2.58486688e-01f, -1.63638398e-01f,
  2.17798010e-01f, 1.17183663e-01f, 2.07974464e-01f, 2.76264876e-01f, 3.09526265e-01f, 6.52855113e-02f, 1.09199630e-02f, 1.16434827e-01f, 2.79252201e-01f, -4.12727207e-01f,
  -3.14091861e-01f, 3.31024140e-01f, -2.61674821e-01f, 3.87246668e-01f, -4.09404486e-01f, 1.83314919e-01f, 4.06201094e-01f, 4.22208905e-02f, 2.15368718e-01f, -1.22505538e-01f,
  3.41338143e-02f, -2.32513741e-01f, -2.20874339e-01f, -1.48071572e-01f, 7.31937215e-02f, -8.84931460e-02f, 2.75377840e-01f, 9.18637440e-02f, -3.62963527e-02f, 1.99950859e-01f,
  -3.89721356e-02f, 2.85525024e-02f, -3.32855210e-02f, -1.00179970e-01f, -4.26055282e-01f, 2.63734519e-01f, -3.43030095e-01f, 3.43344510e-01f, 5.40113375e-02f, -1.05684638e-01f,
  -1.41863137e-01f, -4.22746353e-02f, -3.28431427e-01f, -6.03198946e-01f, 1.58356071e-01f, 2.53986686e-01f, -4.37757857e-02f, 1.08856492e-01f, -4.93965484e-02f, -3.17393780e-01f,
  -4.71475422e-01f, -1.44395707e-02f, -1.40969783e-01f, 1.23150550e-01f, -1.05009556e-01f, 3.32284309e-02f, 1.46245686e-02f, 1.65602818e-01f, 1.78789452e-01f, -3.44559141e-02f,
  -5.30555360e-02f, -2.11041361e-01f, -1.77083969e-01f, -2.65874207e-01f, 1.37889221e-01f, -1.35216609e-01f, -8.53244141e-02f, 4.49918956e-03f, -2.30964959e-01f, 7.93209374e-02f,
  -3.67240518e-01f, -9.01499987e-02f, 2.47022167e-01f, -1.18264832e-01f, 1.71134025e-01f, -4.99913305e-01f, -2.53137350e-01f, -5.06962061e-01f, -5.09762764e-02f, -2.77605712e-01f,
  -3.60851958e-02f, -2.65767097e-01f, 3.48521650e-01f, -1.93736330e-01f, 2.39843920e-01f, 6.11049943e-02f, -3.99220556e-01f, 1.41492292e-01f, -1.93146870e-01f, -4.29939143e-02f,
  1.41200513e-01f, -2.46898040e-01f, -3.43171149e-01f, 1.74021572e-01f, -1.17713772e-01f, 1.42665848e-01f, -4.05953974e-01f, -6.44401312e-02f, -3.92778590e-02f, -5.23098767e-01f,
  -1.43863191e-03f, 1.87360585e-01f, -5.28488085e-02f, -1.52503237e-01f, 1.48951113e-01f, 2.92479157e-01f, 5.85523427e-01f, 4.04338151e-01f, 2.72168845e-01f, -3.40099931e-02f,
  6.31914556e-01f, 9.40766633e-02f, -1.40255868e-01f, 1.45693524e-02f, -1.01112835e-01f, 8.43670666e-02f, -9.51490626e-02f, 7.64733776e-02f, 3.25615518e-02f, 1.14730336e-01f,
  7.47253362e-04f, -2.82363091e-02f, -1.79827362e-01f, -1.93810120e-01f, -2.25627366e-02f, -1.75135493e-01f, 6.16607964e-02f, 1.54021889e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  3.78294587e-02f, 1.39905781e-01f, 1.68533459e-01f, 4.66703057e-01f, 3.31565917e-01f, 5.17965019e-01f, 7.31864199e-02f, 3.58426541e-01f, 3.04673731e-01f, 2.65271366e-01f,
  8.58318031e-01f, 1.32400289e-01f, 3.63546014e-01f, -6.99465692e-01f, 7.75582120e-02f, 1.95466489e-01f, -2.44286641e-01f, 1.27965897e-01f, -3.31496030e-01f, -1.50338978e-01f,
  6.22145608e-02f, 1.92630932e-01f, 8.47944692e-02f, 1.85136721e-01f, 7.89239630e-02f, -2.93598920e-01f, -1.16052285e-01f, -1.12418421e-01f, -1.89818531e-01f, -7.83678889e-02f,
  3.55374217e-01f, 2.54614294e-01f, 5.12522943e-02f, 5.48179924e-01f, 3.09196889e-01f, 7.38981128e-01f, 2.41846114e-01f, 1.47171542e-01f, -1.58081442e-01f, -3.33862126e-01f,
  6.45741284e-01f, 7.64943182e-01f, 3.98573846e-01f, 6.02543175e-01f, 1.86038315e-01f, -5.44749439e-01f, 5.68997085e-01f, 4.30919826e-01f, 3.70769709e-01f, -8.20550770e-02f,
  9.59563479e-02f, -1.73248664e-01f, -8.40617061e-01f, -5.41606992e-02f, 4.21243727e-01f, -3.28838736e-01f, 1.39286056e-01f, -8.12438309e-01f, 1.87141359e-01f, -5.78246824e-02f,
  -4.16998357e-01f, -2.75207996e-01f, 4.17472810e-01f, 4.05910194e-01f, -1.39662415e-01f, -9.24153775e-02f, 2.50988722e-01f, -6.64894879e-01f, 2.23183617e-01f, 6.46687578e-03f,
  -1.12211898e-01f, 5.70478290e-03f, 3.38903107e-02f, -5.83641864e-02f, 2.51058042e-01f, 2.42122442e-01f, 5.22869349e-01f, -1.55498102e-01f, -3.68775070e-01f, -4.38029170e-01f,
  -2.62771368e-01f, 3.48806024e-01f, 5.09830475e-01f, -3.15616429e-02f, 7.82506704e-01f, 4.95683908e-01f, -3.90535206e-01f, 5.31374037e-01f, 1.46549061e-01f, 3.58667850e-01f,
  -3.22212934e-01f, -2.53312793e-02f, 8.99581760e-02f, 1.76806465e-01f, -2.25314140e-01f, 5.10867596e-01f, -2.43365809e-01f, 4.55367379e-03f, -3.55097979e-01f, -5.43762743e-01f,
  -3.41051757e-01f, -1.45928591e-01f, 2.06231833e-01f, 3.71508300e-02f, 3.00419062e-01f, 5.58228970e-01f, 2.21840553e-02f, -2.97319293e-01f, 1.62160486e-01f, -6.26815250e-03f,
  7.36833334e-01f, 3.27257574e-01f, 2.02348977e-01f, 1.60595983e-01f, -2.49703184e-01f, 3.54626924e-01f, -3.03346157e-01f, 4.68853116e-01f, 4.04324234e-01f, 1.26344536e-03f,
  -4.40813825e-02f, 1.58830762e-01f, -4.45060506e-02f, -1.02913991e-01f, 2.44030252e-01f, -4.27288592e-01f, 3.23865592e-01f, 2.89560467e-01f, -2.41227195e-01f, -7.17452392e-02f,
  1.05668366e-01f, 1.06028605e+00f, -2.42338434e-01f, 4.31188881e-01f, -5.31229675e-01f, -3.21969599e-01f, 1.42020777e-01f, -3.30764085e-01f, 1.90620407e-01f, 1.11507475e-01f,
  -1.07715651e-01f, 1.23969920e-01f, 5.69580793e-01f, -8.04165542e-01f, -7.07610190e-01f, -2.65444309e-01f, -1.82550281e-01f, -1.71109617e-01f, 2.61928350e-01f, 2.41641447e-01f,
  5.93780041e-01f, 2.33473659e-01f, -7.66451538e-01f, 2.64467925e-01f, 4.98977482e-01f, -3.13441269e-02f, -1.32138446e-01f, -4.97124391e-03f, -2.85086483e-01f, 1.45632297e-01f,
  -7.03574046e-02f, -3.43631953e-01f, -4.26871553e-02f, 4.47523564e-01f, -2.43985638e-01f, 2.63170242e-01f, 1.58975303e-01f, -3.10551599e-02f, -4.20617796e-02f, -6.97776377e-01f,
  -3.96104693e-01f, -5.01073420e-01f, -2.76647657e-01f, 6.57022476e-01f, 3.08292925e-01f, -3.91978770e-01f, -4.68698680e-01f, -3.79890740e-01f, -1.97091207e-01f, 4.56077792e-02f,
  -8.64822716e-02f, 1.62200749e-01f, -9.78689343e-02f, 1.73274517e-01f, -1.80025399e-01f, 5.06543756e-01f, 6.57055438e-01f, 3.94996494e-01f, 4.48897332e-01f, 1.81766659e-01f,
  -2.72369951e-01f, -3.23971182e-01f, 3.09277654e-01f, -1.67956874e-01f, 1.07665665e-01f, 1.72982141e-02f, 1.21324927e-01f, 6.38684988e-01f, -1.27143815e-01f, -5.80390822e-03f,
  3.03894192e-01f, -2.55628285e-04f, 5.81056356e-01f, 1.33932233e-01f, 5.48766613e-01f, -3.04122597e-01f, 1.39189795e-01f, 7.24255800e-01f, 1.83570787e-01f, -1.28175363e-01f,
  -5.50299406e-01f, 2.24681973e-01f, -5.20124510e-02f, -7.37845078e-02f, -5.60543120e-01f, 6.99982122e-02f, 4.36135055e-03f, 2.09004343e-01f, 2.20163137e-01f, 1.48280516e-01f,
  1.39039114e-01f, -4.90203574e-02f, 2.28260919e-01f, 7.46159330e-02f, 3.43088843e-02f, -3.27689946e-02f, -1.48401454e-01f, -4.21902388e-01f, 3.57198417e-01f, -1.39807761e-01f,
  6.97785974e-01f, 6.42729580e-01f, 1.28130585e-01f, 3.26198459e-01f, -5.23502707e-01f, -4.09533054e-01f, -4.74112421e-01f, -1.36454806e-01f, -8.45066309e-02f, -1.17625576e-02f,
  1.36687070e-01f, 5.31061709e-01f, 5.84677041e-01f, 5.26812077e-01f, -4.54197824e-02f, 1.76951036e-01f, 1.23908810e-01f, -6.76144511e-02f, 1.25015163e+00f, -2.90950891e-02f,
  4.93450105e-01f, 3.52999985e-01f, 1.07509300e-01f, -1.94385678e-01f, -6.08064933e-03f, 1.28640249e-01f, -2.95281298e-02f, 8.56463909e-02f, -2.06773847e-01f, -5.69531798e-01f,
  5.09409010e-02f, -5.02062850e-02f, 1.54478535e-01f, 1.62434131e-01f, 5.39526232e-02f, 2.59210944e-01f, 1.33726299e-01f, -3.63584667e-01f, 1.73125848e-01f, -1.48513824e-01f,
  6.29969612e-02f, -3.10820699e-01f, -1.27290383e-01f, 5.95187485e-01f, -3.67606767e-02f, -1.05182745e-01f, 5.05712807e-01f, 5.30899048e-01f, 3.08693588e-01f, 4.27854836e-01f,
  2.93220639e-01f, 1.98845699e-01f, -4.52733070e-01f, -1.70142606e-01f, -7.13831782e-02f, -2.12539375e-01f, 1.09784901e-01f, 5.04372895e-01f, -1.63960278e-01f, 1.95201784e-01f,
  -1.22269973e-01f, -2.83392906e-01f, -9.09203887e-02f, -1.67503521e-01f, 1.94315165e-01f, 9.12163481e-02f, -3.18387538e-01f, -3.52154434e-01f, -4.21187133e-01f, -6.63930118e-01f,
  -6.20149314e-01f, 2.48364180e-01f, 1.88212708e-01f, -4.98522967e-01f, -2.10947260e-01f, 3.07871461e-01f, 1.05417526e+00f, 3.58139426e-01f, 1.82960927e-01f, 2.59792000e-01f,
  1.56498551e-01f, 2.58658081e-01f, 1.32859245e-01f, 1.36215582e-01f, 1.68179721e-01f, -7.86757618e-02f, 3.99914473e-01f, 2.98871458e-01f, -3.68335307e-01f, 2.22797841e-01f,
  5.69163322e-01f, 3.84658873e-01f, 1.41565889e-01f, 4.66184944e-01f, 6.97966397e-01f, 1.27715200e-01f, 3.79425436e-01f, 1.30705774e-01f, 4.15640511e-02f, 1.63949311e-01f,
  2.02742890e-01f, 1.44026533e-01f, 1.40910983e-01f, -4.32457358e-01f, -9.14278388e-01f, 3.87079507e-01f, 7.96058595e-01f, -1.03433609e-01f, 7.77323425e-01f, 1.57737762e-01f,
  4.41642851e-01f, -2.59551108e-01f, -3.26324344e-01f, 2.82218784e-01f, 6.08594060e-01f, -1.04770266e-01f, 1.94529355e-01f, 3.80312264e-01f, 9.50547382e-02f, 5.91208518e-01f,
  9.38015953e-02f, 3.53017375e-02f, 3.15119117e-01f, 1.88700613e-02f, -2.09555626e-01f, 3.86538178e-01f, 2.09195465e-01f, 2.11253107e-01f, 5.14848471e-01f, 5.65794468e-01f,
  5.34242112e-03f, 9.39013734e-02f, -4.16296989e-01f, 2.14518681e-02f, 4.76907082e-02f, 4.37513590e-01f, 4.13455553e-02f, 4.45503354e-01f, 5.08591950e-01f, 2.83183098e-01f,
  -6.74546242e-01f, 4.13369536e-01f, -1.45814165e-01f, -9.41165462e-02f, 2.92069465e-01f, -4.39395122e-02f, 4.94107157e-01f, -1.87696129e-01f, 3.63357484e-01f, 5.21315038e-01f,
  -3.49828079e-02f, -3.36399227e-01f, 4.57711220e-01f, 3.46001029e-01f, 5.73607266e-01f, 3.57454382e-02f, 6.11071140e-02f, 4.07782972e-01f, 2.60037065e-01f, 4.46557134e-01f,
  1.69210777e-01f, -6.35957345e-02f, -7.07905665e-02f, -2.09757332e-02f, -4.12695676e-01f, -1.89570814e-01f, 1.04849599e-01f, 3.14374864e-01f, -8.02370071e-01f, 3.71202320e-01f,
  6.34959877e-01f, -6.09548688e-01f, 3.18296075e-01f, 2.57824570e-01f, 4.65300471e-01f, -1.56975597e-01f, -2.95831501e-01f, 4.24408138e-01f, 3.01019132e-01f, 1.26387268e-01f,
  -1.62928417e-01f, 4.61858690e-01f, -2.73341596e-01f, 5.35074472e-01f, 3.27735424e-01f, 4.69332971e-02f, -2.90287226e-01f, 1.09564468e-01f, 4.90548223e-01f, 6.92424774e-02f,
  2.31614202e-01f, 3.15515809e-02f, 2.09651127e-01f, -3.02229792e-01f, 4.55561161e-01f, -1.34098232e-01f, 4.18353975e-01f, 5.62362432e-01f, 3.29359621e-01f, -7.86662772e-02f,
  2.91919112e-01f, 2.91981220e-01f, 4.28705633e-01f, -2.20609933e-01f, 1.34537771e-01f, 4.30847183e-02f, -1.42511114e-01f, 1.36711076e-01f, -1.60967689e-02f, -2.41149023e-01f,
  -4.48999465e-01f, 3.79579216e-01f, 4.90838617e-01f, 3.11635602e-02f, 2.89695024e-01f, 2.47411653e-01f, 2.67454594e-01f, 1.97778288e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  3.68119121e-01f, 4.88619447e-01f, -1.85379870e-02f, 1.83618739e-02f, 2.67017543e-01f, -6.52376413e-02f, 2.99647927e-01f, 1.39348924e-01f, 1.83139995e-01f, -2.23660499e-01f,
  4.69333202e-01f, 2.20135197e-01f, 4.11142707e-01f, 1.36857927e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  2.10239053e-01f, -4.69976902e-01f, 1.74290299e-01f, 1.25867769e-01f, 1.01285602e-03f, 3.54574323e-02f, 1.62169054e-01f, -2.75939137e-01f, 4.65885758e-01f, 4.82030243e-01f,
  3.44777614e-01f, -7.11865008e-01f, 2.45317519e-01f, 4.45998639e-01f, 1.08659707e-01f, 3.23829561e-01f, 1.23108737e-01f, 4.98232432e-02f, -7.37532020e-01f, -1.56359255e-01f,
  1.97784260e-01f, 2.14141145e-01f, -4.54559684e-01f, 8.47898424e-02f, 1.25244811e-01f, 3.49942178e-01f, -4.41812165e-03f, 1.24386929e-01f, -3.99701834e-01f, -2.28619501e-01f,
  -4.11801040e-01f, 2.59552211e-01f, -3.45734119e-01f, 8.31995308e-01f, 2.58321110e-02f, -1.14944972e-01f, -2.65309334e-01f, -4.11227733e-01f, 5.68472803e-01f, 2.76434034e-01f,
  4.04336691e-01f, -3.38269658e-02f, -1.99186414e-01f, -1.49248779e-01f, -5.30444086e-01f, -3.10649037e-01f, -6.11088812e-01f, -5.58995605e-01f, -6.32616226e-03f, 7.37888813e-01f,
  -3.07623297e-02f, -3.02223980e-01f, 9.87428501e-02f, 2.81953871e-01f, -6.17642462e-01f, -2.93956518e-01f, -1.37117818e-01f, 1.83389962e-01f, 3.61095250e-01f, 1.11773811e-01f,
  -7.41027519e-02f, 8.03134218e-02f, 1.74481243e-01f, -4.87860501e-01f, -1.40457198e-01f, 3.77063602e-01f, -1.77906364e-01f, 2.19387144e-01f, 4.86468852e-01f, -5.92881501e-01f,
  6.55932784e-01f, -6.83087468e-01f, -1.69536233e-01f, 3.04448128e-01f, -3.04675281e-01f, 4.75938261e-01f, 1.11291659e+00f, 6.37549758e-01f, 7.25049898e-02f, 2.71657646e-01f,
  -5.73459387e-01f, -1.93369076e-01f, -5.76285720e-01f, -1.04054570e+00f, -4.98371482e-01f, -3.06619912e-01f, -9.12905693e-01f, 2.16964424e-01f, -1.31224692e-01f, 2.31229067e-01f,
  -2.90160030e-01f, 4.82308231e-02f, 1.35076821e-01f, 4.38201517e-01f, 1.72387913e-01f, -2.85487231e-02f, -3.30996096e-01f, -1.03733219e-01f, 1.23886298e-02f, 1.73296615e-01f,
  -1.49149746e-01f, -2.55608231e-01f, 9.85263139e-02f, -2.59119030e-02f, 1.15717582e-01f, -1.20161831e-01f, -5.30213751e-02f, 4.50050980e-02f, 1.00200661e-01f, -1.88096657e-01f,
  -4.76198226e-01f, 1.62447587e-01f, -1.76820680e-01f, -2.04192057e-01f, -3.81636590e-01f, -8.71996284e-01f, -2.25813717e-01f, 9.80833322e-02f, 5.61588109e-01f, 2.69129008e-01f,
  -6.97500587e-01f, 4.52874713e-02f, 2.24095453e-02f, 1.97231725e-01f, -9.30052936e-01f, -3.49300772e-01f, -1.00193870e+00f, 1.92168608e-01f, -1.45578235e-01f, -4.27944474e-02f,
  2.44006008e-01f, -4.69513208e-01f, -8.90996456e-01f, 4.42534029e-01f, -7.86316395e-01f, 3.05056334e-01f, -7.17292070e-01f, 2.88546714e-03f, 4.21525806e-01f, 3.27427506e-01f,
  -5.54300249e-01f, 3.76857251e-01f, 9.62042868e-01f, 2.92615891e-01f, -2.45565593e-01f, -4.98003811e-01f, 1.70371518e-01f, -4.69080538e-01f, -2.13080779e-01f, -8.44696090e-02f,
  7.31262490e-02f, 3.41650218e-01f, 1.13619357e-01f, 4.82533835e-02f, -2.48421624e-01f, 7.57855922e-02f, -8.16004872e-02f, 5.62113747e-02f, 1.55024201e-01f, 3.71396020e-02f,
  4.69878584e-01f, -6.88213468e-01f, 3.60910207e-01f, -2.40793616e-01f, 4.33712751e-01f, 2.56337821e-01f, -2.03545049e-01f, -2.11255908e-01f, -4.54714090e-01f, -1.88933238e-01f,
  4.78031300e-02f, 5.61108030e-02f, -2.13706732e-01f, -5.47836721e-02f, 5.80670238e-01f, -3.46910417e-01f, 5.83284974e-01f, -7.21592665e-01f, -3.86229038e-01f, -9.49849635e-02f,
  1.35582104e-01f, -4.16225731e-01f, -3.57774109e-01f, -1.37071922e-01f, -4.58803147e-01f, 1.31689832e-01f, 4.52466831e-02f, 2.76930392e-01f, 3.62787753e-01f, -3.71419013e-01f,
  2.89285451e-01f, -9.49803963e-02f, 4.96177763e-01f, -1.32793069e-01f, 5.08216617e-04f, -4.56569940e-01f, 2.09149607e-02f, 3.23806703e-01f, 5.93633652e-02f, 2.69463599e-01f,
  1.16531469e-01f, -2.82185823e-01f, -2.19362289e-01f, 3.74568313e-01f, 1.52495131e-01f, -1.96906745e-01f, 3.99829775e-01f, -4.87317234e-01f, 2.10106388e-01f, 5.51609457e-01f,
  3.97193491e-01f, 6.17382586e-01f, -7.48184800e-01f, 8.67686048e-02f, -1.73378840e-01f, -9.64579582e-02f, 4.05144244e-01f, -7.26947010e-01f, -6.54206514e-01f, -4.17894870e-02f,
  1.04433410e-01f, 7.14549273e-02f, 1.32750273e-01f, 4.17110980e-01f, -8.17238390e-02f, -2.36945257e-01f, -1.03330307e-01f, -2.84911335e-01f, -3.22630167e-01f, 2.84291264e-02f,
  -2.36085579e-01f, -4.10037011e-01f, -2.69992977e-01f, -8.80158618e-02f, 5.99421747e-02f, -7.87283294e-03f, 4.04848039e-01f, -7.69672617e-02f, -5.05015731e-01f, 3.84255886e-01f,
  -1.22426070e-01f, 3.24268728e-01f, 1.89900041e-01f, 3.97032589e-01f, -6.65589124e-02f, 3.58421117e-01f, 2.16970161e-01f, -4.04904604e-01f, -4.09540236e-01f, -2.64607463e-02f,
  2.08964303e-01f, -2.39598349e-01f, -4.13457304e-01f, 1.82715997e-01f, -2.34678641e-01f, 1.05722390e-01f, 1.41142398e-01f, -7.22300857e-02f, -4.77849096e-01f, 1.20621413e-01f,
  -1.49337992e-01f, -6.08044155e-02f, 1.18612252e-01f, -3.96393359e-01f, 3.23683709e-01f, 4.53625977e-01f, -2.89774507e-01f, -5.78305483e-01f, 4.13469166e-01f, -2.57761091e-01f,
  -5.53265452e-01f, -9.14184824e-02f, 2.41807073e-01f, 2.23823264e-01f, 3.91642928e-01f, -3.78766239e-01f, 3.75591964e-01f, -4.14058834e-01f, 4.23750550e-01f, -3.88183564e-01f,
  -1.24486759e-01f, -4.98466402e-01f, 3.32064927e-01f, -1.02716245e-01f, 2.57947072e-02f, -3.84627521e-01f, -7.66716748e-02f, -6.72722638e-01f, -4.18734610e-01f, 1.84532300e-01f,
  -3.47956955e-01f, 5.02929270e-01f, 1.87541902e-01f, -1.32525429e-01f, 4.22597468e-01f, -3.54141742e-01f, 2.34323770e-01f, 1.21872209e-01f, 6.86898530e-02f, -3.15927975e-02f,
  2.28187039e-01f, -3.49333853e-01f, 1.20644398e-01f, -3.29139054e-01f, -4.86495823e-01f, -8.38123202e-01f, 1.74072281e-01f, 1.77087292e-01f, -7.35077381e-01f, -2.32346982e-01f,
  -6.58461928e-01f, -6.22134864e-01f, 5.04065529e-02f, 4.55288947e-01f, -3.06726873e-01f, -9.44254696e-01f, 3.51031840e-01f, 3.15826625e-01f, 2.56529659e-01f, -1.18488364e-01f,
  3.82052869e-01f, 3.36208284e-01f, 2.46724218e-01f, -2.84800708e-01f, 2.70406634e-01f, -4.54515405e-02f, 4.08815257e-02f, -7.77600973e-04f, 1.50627747e-01f, 4.20367002e-01f,
  6.59135133e-02f, 3.08412194e-01f, -4.51745450e-01f, 5.41779220e-01f, -2.86456347e-01f, 5.99297166e-01f, 6.26482308e-01f, -5.08180976e-01f, -6.46424353e-01f, -4.00563627e-02f,
  2.26713821e-01f, -7.26549327e-01f, 7.69146442e-01f, 4.07513052e-01f, -5.56018293e-01f, -7.00785935e-01f, 8.28352496e-02f, -6.19130544e-02f, -5.34108460e-01f, -7.34741271e-01f,
  2.69409180e-01f, -4.93972957e-01f, 2.93785244e-01f, -1.50734857e-01f, 4.10053641e-01f, 5.20318031e-01f, -4.24627602e-01f, 4.57342476e-01f, -4.03815448e-01f, 2.13922828e-01f,
  2.19535097e-01f, -2.56970882e-01f, -4.73202467e-01f, -1.72995642e-01f, -4.16370839e-01f, -2.72079736e-01f, 4.94226158e-01f, 1.58373356e-01f, 7.84892365e-02f, 4.46018130e-01f,
  5.62723055e-02f, -6.80650473e-01f, 2.98243940e-01f, -5.17623186e-01f, -6.78866923e-01f, -1.81351125e-01f, 3.02958071e-01f, -9.87977147e-01f, 6.34560063e-02f, -7.96643078e-01f,
  3.86171103e-01f, -1.43810824e-01f, 4.13734347e-01f, 3.22131008e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.12212189e-01f, -1.61176860e-01f, 2.57605523e-01f, 3.52449939e-02f, -1.33438021e-01f, 6.22335896e-02f, 2.38795638e-01f, -7.91894272e-02f, 8.15961435e-02f, 9.58216339e-02f,
  9.98544693e-02f, -1.61631568e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    