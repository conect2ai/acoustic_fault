/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  7.87702948e-02f, 2.25462709e-02f, 6.60341680e-02f, 2.88253069e-01f, 2.42428884e-01f, 1.79908741e-02f, 4.06103246e-02f, 1.86732203e-01f, 2.94263601e-01f, -3.24555449e-02f,
  1.77037597e-01f, 4.06949334e-02f, -1.78850934e-01f, 1.94562018e-01f, 1.08439587e-01f, -8.88206437e-02f, 8.04904029e-02f, 1.87501106e-02f, -4.04454395e-02f, 7.08548054e-02f,
  1.04916826e-01f, 7.01953247e-02f, -8.56413543e-02f, 1.34036317e-01f, 4.19146307e-02f, 4.89866622e-02f, -3.92775098e-03f, 1.29272183e-03f, 1.47473082e-01f, -3.52149922e-03f,
  -7.29827732e-02f, -9.75409970e-02f, 1.15725078e-01f, -9.73502100e-02f, 5.84120005e-02f, 1.72937312e-03f, -4.85227779e-02f, -9.90004241e-02f, 1.07651725e-02f, 3.49814408e-02f,
  8.62438604e-03f, -2.59785703e-03f, 5.53057119e-02f, -1.29288249e-02f, 4.44081016e-02f, 3.92254777e-02f, -1.08819176e-02f, 5.80730401e-02f, -2.07052473e-02f, -4.93982770e-02f,
  -1.36895059e-03f, 4.15996835e-02f, 8.82320181e-02f, -2.97141969e-02f, 8.39926377e-02f, -1.99943408e-02f, 5.81178209e-03f, -3.22406664e-02f, 7.72645772e-02f, 6.68304563e-02f,
  2.42526480e-03f, -5.54714762e-02f, -2.82030925e-02f, 2.58259904e-02f, 2.37418748e-02f, 2.28221007e-02f, 5.97382784e-02f, -3.12750079e-02f, 6.51842579e-02f, 4.68234569e-02f,
  -2.61043124e-02f, -1.21167116e-02f, 3.17507349e-02f, 1.71812996e-02f, 2.11071707e-02f, -1.77003182e-02f, 2.21493952e-02f, -1.04785822e-02f, -3.59120890e-02f, 9.77186337e-02f,
  -8.32036417e-03f, 9.53038316e-03f, -1.72471795e-02f, 5.81059493e-02f, 2.04392336e-03f, 2.80038081e-02f, 1.39002670e-02f, 1.03765972e-01f, 4.25007120e-02f, -2.33303048e-02f,
  1.33511975e-01f, 2.00813740e-01f, 1.46905025e-02f, -1.52829022e-03f, 3.76889259e-02f, -3.49749662e-02f, 3.61310616e-02f, 3.81591283e-02f, -9.83374193e-03f, -1.71738688e-03f,
  -5.57872765e-02f, 1.46729378e-02f, 1.05183972e-02f, 3.12314555e-02f, -3.81802805e-02f, -8.93006660e-03f, 1.15791783e-02f, 3.25827152e-02f, 5.50932065e-02f, -2.14558430e-02f,
  -6.18743245e-03f, -3.33432853e-02f, -1.22273536e-02f, 7.29220584e-02f, 5.46904802e-02f, -6.15850510e-03f, 5.98257706e-02f, 4.51014191e-02f, 3.44484784e-02f, 5.22767566e-02f,
  6.43318057e-01f, 1.20432906e-01f, -2.42693767e-01f, -6.35852590e-02f, 1.14052445e-01f, 5.41349165e-02f, -5.00214100e-02f, 1.05784632e-01f, 2.57294863e-01f, 2.64946278e-02f,
  1.19952343e-01f, -1.36594057e-01f, 4.71521169e-02f, -2.17682193e-03f, -5.06493673e-02f, -5.79273179e-02f, 1.35603532e-01f, 8.77425000e-02f, 1.11805961e-01f, 5.12126461e-02f,
  1.15268650e-02f, 1.92721188e-01f, -2.76199967e-01f, 7.08172619e-02f, -1.73501913e-02f, 2.00793426e-03f, -7.60621801e-02f, -1.21960565e-01f, -8.26039985e-02f, 5.92393950e-02f,
  -3.99019383e-02f, 5.54646328e-02f, 1.51301529e-02f, 2.71877702e-02f, -2.59359460e-02f, -3.96075146e-03f, -5.16574048e-02f, -2.51119900e-02f, -2.51526479e-02f, -3.75712663e-02f,
  -5.21099716e-02f, -9.02109407e-03f, 8.20462778e-02f, -9.99043286e-02f, 5.46048470e-02f, -1.50492098e-02f, 3.94847132e-02f, -3.69793512e-02f, -9.04028863e-03f, -6.87446371e-02f,
  -3.86213921e-02f, -6.35483721e-03f, -7.38214478e-02f, 7.15052942e-03f, -5.06754555e-02f, 4.21527997e-02f, -3.15376706e-02f, -6.96443915e-02f, 1.17768804e-02f, 4.97488156e-02f,
  4.64826711e-02f, -1.24051888e-02f, 2.61532981e-02f, 5.82072278e-03f, 8.70531276e-02f, -8.52021109e-03f, -7.56947622e-02f, -1.81002934e-02f, -7.75945513e-03f, 1.86481071e-03f,
  -1.36675471e-02f, -5.10515869e-02f, 4.95850928e-02f, -6.52924553e-03f, 2.09045336e-02f, 7.13980570e-02f, -3.14216018e-02f, -5.63822277e-02f, 1.03410520e-02f, -4.40355763e-02f,
  -7.07740942e-03f, 5.42095117e-02f, -7.77789578e-02f, -2.17481442e-02f, -4.67639416e-03f, -5.49889766e-02f, 3.48878801e-02f, -7.28931800e-02f, 3.57653163e-02f, -6.16437336e-03f,
  2.62020137e-02f, -1.32945374e-01f, -2.27286518e-02f, 3.99409309e-02f, -1.02853570e-02f, -2.02510059e-02f, 2.12738477e-02f, 9.89374369e-02f, 2.86256359e-03f, 2.13630572e-02f,
  6.71225563e-02f, 2.39963550e-02f, -6.05928451e-02f, 2.47030109e-02f, -4.29503433e-02f, -1.66699700e-02f, -3.55703123e-02f, 2.02441402e-02f, 7.70918652e-03f, 1.42013263e-02f,
  9.62947868e-03f, 4.21207622e-02f, 6.15412332e-02f, -1.22456104e-02f, 3.98555174e-02f, 1.33870486e-02f, 2.43945187e-03f, -2.48496793e-02f, -6.44766465e-02f, -8.08533356e-02f,
  1.32279024e-01f, -1.50761344e-02f, -3.02371234e-01f, -6.10506833e-02f, -8.20248723e-02f, 1.29481152e-01f, 1.02814510e-01f, -8.24698433e-02f, 2.11841673e-01f, 2.48285055e-01f,
  9.20004323e-02f, 6.78170845e-02f, 7.69419298e-02f, 1.94312826e-01f, 1.13680154e-01f, 2.13865057e-01f, 2.90902138e-01f, 2.15248987e-01f, 1.27695939e-02f, 4.10003727e-03f,
  -3.39320898e-02f, 5.85015416e-02f, -1.20715976e-01f, -8.49104226e-02f, -1.48753479e-01f, -2.05605090e-01f, -1.50505677e-01f, -1.43449187e-01f, 1.15775550e-02f, -7.06195310e-02f,
  -2.66317334e-02f, 5.31110801e-02f, 1.88263541e-04f, -4.61917892e-02f, -2.14548446e-02f, -7.89452437e-03f, 2.02588364e-02f, -6.22375198e-02f, -1.15170619e-02f, 1.19966147e-02f,
  2.85808053e-02f, -4.76231333e-03f, -3.34473252e-02f, 1.78097971e-02f, 4.57713641e-02f, 5.17309047e-02f, -1.84783377e-02f, -5.53333536e-02f, -2.70088222e-02f, -1.19266836e-02f,
  4.75394838e-02f, -2.98347436e-02f, 4.74832067e-03f, -1.10073639e-02f, -3.54999453e-02f, 5.51472120e-02f, -5.46447635e-02f, 6.51757279e-03f, 1.18506039e-02f, 1.58905089e-02f,
  1.02973152e-02f, -9.87372175e-03f, -7.98444897e-02f, 4.75560268e-03f, -1.00330606e-01f, -3.17857675e-02f, 4.80498150e-02f, 1.83031578e-02f, -3.26894857e-02f, 2.71329805e-02f,
  2.44273189e-02f, -2.65660007e-02f, -4.26576808e-02f, 2.12694686e-02f, -2.99962573e-02f, 1.25589892e-02f, -1.44670438e-02f, 4.47193235e-02f, 5.53205311e-02f, 4.53387238e-02f,
  1.50354113e-02f, -3.56324166e-02f, 2.70204842e-02f, 3.08814668e-03f, 5.43232709e-02f, -7.35059846e-03f, -3.36589059e-03f, 2.18817461e-02f, -5.93703315e-02f, -3.42648961e-02f,
  1.47794157e-01f, 8.09182003e-02f, 5.08290669e-03f, 1.17565105e-02f, -9.72663797e-03f, 5.52317984e-02f, 2.06019934e-02f, -2.06105281e-02f, 3.43132615e-02f, -1.17851868e-02f,
  -2.78737750e-02f, -5.47355674e-02f, -3.01904720e-03f, 5.36959618e-02f, -4.43887860e-02f, -3.40554281e-03f, 8.13097972e-03f, -2.65918318e-02f, -1.92042254e-02f, 4.05344255e-02f,
  -1.70976892e-02f, 3.96781303e-02f, -7.05491379e-02f, -7.46039376e-02f, -1.82910834e-03f, 5.66348713e-03f, -3.56282368e-02f, -1.05544347e-02f, -1.01033160e-02f, 5.46114519e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.50971515e-02f, -6.17755614e-02f, -5.74742816e-02f, 1.53652638e-01f, 1.58147618e-01f, -7.27251125e-03f, 1.30323142e-01f, 1.00451745e-02f, -1.30045101e-01f, -1.60021409e-02f,
  2.39858311e-02f, -5.95828965e-02f, -6.30884916e-02f, 7.38114258e-03f, -4.83727921e-03f, 4.65850905e-03f, -5.88955320e-02f, 9.66220573e-02f, -9.56785008e-02f, -9.87015590e-02f,
  -1.10588536e-01f, -9.29632597e-03f, 2.94974968e-02f, 4.14500386e-02f, 1.63655981e-01f, 1.50065929e-01f, 7.88773820e-02f, 1.67038232e-01f, 1.77333469e-03f, 7.56618828e-02f,
  7.90248215e-02f, -4.02958319e-02f, 4.86744978e-02f, 8.71427916e-03f, -1.06034681e-01f, -4.38582636e-02f, -2.34500822e-02f, 3.89152206e-02f, 6.56638353e-04f, -1.88686862e-03f,
  -1.02944843e-01f, -5.20275272e-02f, -5.96736558e-02f, 2.41932422e-02f, 2.47619320e-02f, -5.10923080e-02f, 6.94741532e-02f, 1.32911205e-01f, 2.55772229e-02f, -4.66258228e-02f,
  -3.41512971e-02f, -1.78901292e-02f, -6.88397288e-02f, 7.63475224e-02f, 9.81227867e-03f, -4.91170026e-02f, -4.90969829e-02f, 8.13677981e-02f, 3.62030715e-02f, -2.58801319e-02f,
  8.79845843e-02f, 5.55055179e-02f, -8.47073421e-02f, -2.40948237e-02f, -5.59507497e-02f, 1.56701822e-02f, -2.27124169e-02f, 3.10260728e-02f, 1.65632647e-02f, 5.65024354e-02f,
  1.48048311e-01f, 4.53893282e-02f, 4.16444205e-02f, -2.25266796e-02f, -2.73845829e-02f, -2.30168011e-02f, -3.37772183e-02f, 5.85252345e-02f, 2.22173370e-02f, 6.82568029e-02f,
  1.27524570e-01f, -7.96120428e-03f, 3.18480209e-02f, -2.16210391e-02f, 2.14197692e-02f, 2.57400554e-02f, -3.68217453e-02f, -4.38149981e-02f, -7.18308389e-02f, -3.73923779e-02f,
  -9.61528495e-02f, -4.16941904e-02f, 6.41547740e-02f, -2.44281869e-02f, 2.35968549e-02f, 8.28503445e-02f, 4.08360036e-03f, -5.10069393e-02f, 5.38994372e-02f, 7.69098625e-02f,
  2.89704539e-02f, -7.89085682e-03f, 3.02651012e-03f, -9.17831734e-02f, 3.25613841e-02f, 4.30793837e-02f, -1.05408177e-01f, 1.29139507e-02f, 2.96458299e-03f, 3.74208130e-02f,
  -3.39259878e-02f, -3.40789696e-03f, -3.69615778e-02f, 1.12135641e-01f, -2.45037340e-02f, -2.14819275e-02f, -5.89987300e-02f, -4.01453599e-02f, -1.02849066e-01f, -4.28858697e-02f,
  8.32874626e-02f, -1.20581537e-01f, -1.94008097e-01f, -1.16342336e-01f, -8.77213702e-02f, -3.67135108e-01f, -3.62645775e-01f, -1.78800046e-01f, 2.11126599e-02f, -3.97546813e-02f,
  -1.65449291e-01f, 7.13714436e-02f, -6.51205406e-02f, -2.54811555e-01f, 1.79539695e-01f, 7.37832859e-02f, -2.99470484e-01f, -1.47654444e-01f, 3.13680544e-02f, -2.36991346e-01f,
  -7.29667693e-02f, -2.27289826e-01f, 4.42993417e-02f, -1.27716899e-01f, -1.56045511e-01f, -9.07455757e-02f, 1.48972183e-01f, -6.48581758e-02f, -1.03890069e-01f, -5.33259995e-02f,
  -7.69580528e-02f, 6.53970093e-02f, 4.98217382e-02f, -3.78435470e-05f, -9.60065275e-02f, -6.07838109e-02f, -4.70144153e-02f, -7.95684662e-03f, 5.27459010e-02f, -6.81941910e-03f,
  -8.61261860e-02f, 2.46135406e-02f, 5.90141751e-02f, -3.20133218e-03f, 2.34711003e-02f, -3.74868326e-02f, 1.14798977e-03f, 4.71667685e-02f, 4.51319851e-03f, -2.86135310e-03f,
  -5.34151234e-02f, -7.42420414e-03f, -5.86826466e-02f, -1.46188494e-02f, 2.82960921e-03f, -1.00393064e-01f, 3.21149230e-02f, 7.73383770e-03f, -3.39055471e-02f, 1.12566603e-02f,
  6.05938658e-02f, -5.52095510e-02f, 4.84483540e-02f, 1.99110657e-02f, -4.45379317e-02f, -8.28080103e-02f, 2.43981518e-02f, 5.72771877e-02f, 9.53581277e-03f, 9.13174674e-02f,
  1.21375425e-02f, 2.65973490e-02f, -4.80148830e-02f, -1.84815675e-02f, -1.47341168e-03f, -1.51015241e-02f, 1.47114415e-03f, 3.72819230e-02f, 8.96209572e-03f, 6.58781752e-02f,
  1.05381217e-02f, 5.41798538e-03f, -2.21149083e-02f, -9.72323492e-02f, 3.20138223e-02f, -2.18763109e-02f, -5.16677015e-02f, -8.47546756e-02f, 2.56538633e-02f, -2.07149666e-02f,
  -1.29604682e-01f, -1.21094339e-01f, -9.74210072e-03f, 3.82546969e-02f, 1.45404497e-02f, 4.08842647e-03f, -4.13991958e-02f, 4.05151993e-02f, -7.52169490e-02f, -1.28646102e-02f,
  1.78748965e-02f, -2.37770583e-02f, -2.62571070e-02f, -1.21654160e-02f, -1.83078945e-02f, 1.48231455e-03f, -4.49525490e-02f, 3.71316001e-02f, 1.36297347e-03f, -7.73648322e-02f,
  4.41685086e-03f, -3.03883422e-02f, 6.64604008e-02f, 2.57790666e-02f, -2.05088705e-02f, 5.69943851e-03f, 4.14940342e-02f, 3.97757702e-02f, -1.82277337e-02f, -6.37298003e-02f,
  2.23251864e-01f, -1.97457056e-02f, -1.07268743e-01f, 1.55424133e-01f, 3.38497870e-02f, -2.81070590e-01f, -2.37655595e-01f, 1.08281337e-01f, -1.83596745e-01f, 1.77556083e-01f,
  1.02474906e-01f, -1.15015887e-01f, -8.33170786e-02f, 4.04504277e-02f, 1.42867580e-01f, -3.12157869e-01f, 2.28777975e-01f, -5.59480302e-02f, -1.81375250e-01f, 1.92690417e-01f,
  6.42403886e-02f, 2.76140481e-01f, -4.72122105e-03f, 2.92315423e-01f, 1.59900054e-01f, 1.85954288e-01f, 4.92135882e-01f, -4.84047346e-02f, 3.15243065e-01f, 2.18400639e-03f,
  -9.94394124e-02f, -6.71372861e-02f, 1.60251949e-02f, -4.12298180e-02f, 1.22987099e-01f, 7.79405534e-02f, 5.66242374e-02f, 4.05142680e-02f, -7.60354474e-03f, -3.55731584e-02f,
  -2.26863939e-02f, 1.70727796e-03f, -1.54885780e-02f, 4.08624560e-02f, 9.90752596e-04f, -4.05809321e-02f, -6.06135391e-02f, -7.79629573e-02f, -4.65835445e-02f, -7.13385688e-03f,
  -3.47016305e-02f, 4.32515889e-02f, 1.65676568e-02f, -2.02786960e-02f, -4.66015823e-02f, -6.20771432e-03f, 2.29047034e-02f, -5.00276051e-02f, -5.74288890e-02f, -1.02952924e-02f,
  1.17288604e-01f, -2.65731141e-02f, 3.61628011e-02f, -6.40922263e-02f, 4.49735671e-02f, -4.84323129e-02f, -4.69330922e-02f, 1.94498245e-03f, -5.63298874e-02f, 3.90213281e-02f,
  4.31062691e-02f, 3.71996090e-02f, -2.92480066e-02f, 1.31110922e-02f, 5.13614938e-02f, -5.18657193e-02f, 1.96529627e-02f, 3.70235443e-02f, 7.53192045e-03f, -7.29076713e-02f,
  -5.83961867e-02f, 4.61139828e-02f, 5.79187227e-03f, -7.03181373e-03f, 5.85363209e-02f, -2.59428397e-02f, 5.04086912e-02f, -3.58738005e-02f, -5.43305688e-02f, 5.12724891e-02f,
  -1.54346637e-02f, 2.59393394e-01f, -5.61783575e-02f, -7.12212268e-03f, -6.91536069e-02f, 4.06627096e-02f, -7.13609830e-02f, 3.68818268e-02f, 7.73680881e-02f, 1.69950500e-02f,
  1.50462419e-01f, -1.01227630e-02f, 3.88908908e-02f, 2.52983216e-02f, 5.63058965e-02f, 7.60134906e-02f, 3.15234773e-02f, 2.57321000e-02f, 5.86350262e-02f, 4.55441251e-02f,
  7.74432272e-02f, 6.14204630e-03f, -1.90375820e-02f, -4.60556671e-02f, 2.41976958e-02f, 1.95312093e-03f, 2.56623160e-02f, 3.43674682e-02f, 6.56600967e-02f, -2.09592320e-02f,
  3.38307947e-01f, 1.80095300e-01f, 1.62308484e-01f, 3.43175828e-02f, 9.93973538e-02f, 9.61996317e-02f, 7.74768530e-04f, 6.32166639e-02f, 1.29260570e-01f, 8.23087692e-02f,
  1.54993311e-02f, 2.37221286e-01f, -2.16206938e-01f, 8.96853235e-05f, -2.15572402e-01f, -2.88244456e-01f, -2.50196978e-02f, 1.60133317e-01f, -1.53946042e-01f, 6.59649819e-02f,
  -9.64950994e-02f, -8.24995115e-02f, -2.51572937e-01f, -9.77311879e-02f, 8.68389383e-02f, 1.75211921e-01f, -4.66701686e-02f, -7.69902989e-02f, 2.01705351e-01f, -4.05894220e-03f,
  6.65956065e-02f, 2.78536063e-02f, 1.57322928e-01f, 1.06375344e-01f, -1.10061402e-02f, 1.18103683e-01f, -6.31592125e-02f, 1.24838017e-02f, 4.52870131e-02f, 3.54035501e-03f,
  4.54615541e-02f, 3.66669567e-03f, 8.22152942e-02f, -6.12462908e-02f, 8.84339362e-02f, 5.04132435e-02f, 1.05559956e-02f, 7.52892643e-02f, 4.39134650e-02f, -2.87118312e-02f,
  3.68421376e-02f, -4.22496013e-02f, -4.11114655e-02f, -2.99940594e-02f, 3.12619098e-02f, 5.37019186e-02f, 6.64962679e-02f, 6.33568168e-02f, 5.03846556e-02f, 4.95586134e-02f,
  -9.74749215e-03f, -8.81016254e-02f, 4.68734801e-02f, -5.82866706e-02f, 4.44341898e-02f, -3.56315896e-02f, 2.22615562e-02f, -4.64515351e-02f, -2.19068285e-02f, 4.74506468e-02f,
  -5.63990651e-03f, -4.29671519e-02f, -7.80858845e-02f, -5.34353741e-02f, 3.75450365e-02f, 6.29975125e-02f, -5.78415766e-02f, 5.84611632e-02f, 7.88765103e-02f, 2.43599084e-03f,
  -3.07278950e-02f, 5.24706841e-02f, -1.47687132e-02f, 4.63440232e-02f, 6.70371056e-02f, -4.33566459e-02f, 1.97940841e-02f, -2.71791834e-02f, -3.19942236e-02f, -9.36338603e-02f,
  -1.27322882e-01f, 1.35364890e-01f, 4.46279980e-02f, -3.52512263e-02f, -4.27942164e-03f, -2.89892741e-02f, 2.74008531e-02f, 1.91036202e-02f, 1.88215617e-02f, -4.34419438e-02f,
  6.10794462e-02f, 1.09152235e-02f, 7.57549554e-02f, 4.98011522e-02f, -7.22479150e-02f, 6.17157370e-02f, -7.04618683e-03f, 2.45251823e-02f, -9.94180888e-03f, 9.85086989e-03f,
  -8.87742341e-02f, 4.67723273e-02f, 6.92501292e-02f, 5.14746606e-02f, -1.09740384e-02f, 3.69960777e-02f, 1.60166144e-01f, 1.37817049e-02f, -3.20264734e-02f, -2.33551413e-02f,
  2.90725619e-01f, -6.53656900e-01f, 1.38491660e-01f, 2.10596502e-01f, 3.16303730e-01f, 1.86019778e-01f, 2.85213321e-01f, -1.10663988e-01f, -5.57382815e-02f, -4.31960881e-01f,
  -5.58336824e-02f, -3.09555568e-02f, -2.50275046e-01f, 4.20945324e-02f, 2.26321161e-01f, -2.07565293e-01f, -4.95627783e-02f, -4.94062491e-02f, -6.23272732e-03f, -5.62842861e-02f,
  6.21114224e-02f, 4.87448275e-02f, 7.54472166e-02f, -1.33749783e-01f, 3.93716246e-02f, -8.37715790e-02f, -3.92154828e-02f, -5.67685999e-02f, 1.36961648e-02f, 4.95213047e-02f,
  1.24232069e-01f, 6.50084205e-03f, 3.48333530e-02f, -6.62445277e-02f, -9.28350464e-02f, -2.57087429e-03f, 3.50001156e-02f, 5.04989624e-02f, 3.21941525e-02f, -6.99294880e-02f,
  -7.31665874e-03f, 1.67868491e-02f, 2.62333825e-02f, 6.07125945e-02f, 5.45458607e-02f, -9.75540839e-03f, -8.60849582e-03f, 9.47476458e-03f, 4.43199947e-02f, 3.77716832e-02f,
  -1.49222827e-02f, -1.11235706e-02f, 2.04987898e-02f, -4.61985618e-02f, 2.73805726e-02f, 3.79139483e-02f, 4.33621667e-02f, 3.85922156e-02f, -2.14598216e-02f, 2.45896820e-02f,
  -1.07851744e-01f, 2.42268797e-02f, 3.24853472e-02f, 3.56648974e-02f, -8.72857589e-03f, 4.71632145e-02f, 1.48253664e-02f, 4.08776198e-03f, 6.17216248e-03f, -4.07238603e-02f,
  2.23772284e-02f, -2.27972772e-03f, -7.74037046e-03f, 2.59154849e-02f, 3.20218988e-02f, 1.28051881e-02f, 5.28289191e-02f, 2.86736190e-02f, -2.05965340e-02f, -1.54074244e-02f,
  -1.41733289e-02f, -2.68592667e-02f, -1.70703586e-02f, -1.67365477e-03f, 1.22767193e-02f, -1.20600630e-02f, 3.05482075e-02f, -3.78705040e-02f, 2.17575412e-02f, -4.25342135e-02f,
  -2.79218227e-01f, -4.74321485e-01f, -2.27115769e-03f, 1.99968498e-02f, -4.39434797e-02f, -8.21742564e-02f, -2.99386755e-02f, -1.89572703e-02f, -1.20653711e-01f, -2.84865983e-02f,
  -2.43638381e-02f, 7.66051188e-02f, -1.76585559e-02f, -6.08098134e-03f, 1.15545976e-04f, -4.26884033e-02f, -1.78797469e-02f, -5.50766438e-02f, -5.86295947e-02f, -4.82031628e-02f,
  -3.15059274e-02f, 1.26037246e-03f, 5.64156435e-02f, 1.45600010e-02f, -1.24070216e-02f, 1.95731763e-02f, 1.26421591e-02f, 2.26503350e-02f, -1.87617149e-02f, -6.30572587e-02f,
  8.91784877e-02f, 6.03702441e-02f, 2.22110957e-01f, 4.26453948e-02f, -3.54836397e-02f, 1.09349862e-01f, 5.34274392e-02f, 2.40861718e-02f, 1.25003625e-02f, 1.79415066e-02f,
  -8.50134790e-02f, 2.21679896e-01f, -6.82065561e-02f, 6.75117299e-02f, -6.27716407e-02f, -1.36821106e-01f, -1.20563149e-01f, -3.92563269e-02f, 1.23769157e-02f, -4.26849863e-03f,
  5.93306646e-02f, -1.15897566e-01f, -3.50161077e-04f, -4.18842770e-02f, 1.37553811e-01f, -3.74770463e-02f, -7.83398077e-02f, -4.11984995e-02f, -4.16762047e-02f, -7.97648355e-02f,
  4.61938009e-02f, -8.84777904e-02f, 1.86163448e-02f, 1.45720512e-01f, 1.33064939e-02f, -3.84639502e-02f, 8.28349963e-02f, 1.16036803e-01f, 1.27839781e-02f, -4.76720789e-03f,
  -1.27504498e-01f, 8.98565799e-02f, 2.40797363e-02f, -3.97711508e-02f, 4.03095484e-02f, -5.39397448e-02f, 9.48594511e-02f, 1.36669531e-01f, 1.20370589e-01f, 1.72949672e-01f,
  1.68204814e-01f, 4.88987938e-02f, 4.52093706e-02f, -6.30578622e-02f, 3.80609445e-02f, -1.65719632e-02f, -5.80728538e-02f, 1.21915594e-01f, -2.50484627e-02f, 1.19422814e-02f,
  1.09542221e-01f, -2.10808422e-02f, 1.08693894e-02f, 1.22670876e-03f, 2.89245676e-02f, -4.74635176e-02f, -3.96322198e-02f, -4.18435745e-02f, 1.45935472e-02f, 2.90248338e-02f,
  5.54619655e-02f, -1.10311538e-01f, -4.53810804e-02f, 4.82452326e-02f, 2.52118092e-02f, 6.51872754e-02f, 1.25181332e-01f, -4.69630361e-02f, -6.66576624e-02f, -1.42886932e-03f,
  -7.17987493e-02f, -5.41841052e-02f, 2.68593393e-02f, -1.06870972e-01f, -1.00584231e-01f, -2.98584625e-02f, 2.61536147e-02f, 9.03400481e-02f, 3.95730361e-02f, -6.16083294e-02f,
  -4.56177294e-02f, -1.68683261e-01f, 7.28666186e-02f, 1.16850110e-02f, 2.99884267e-02f, -2.46314760e-02f, -3.79702523e-02f, 3.72012146e-02f, -6.25561327e-02f, -3.76238003e-02f,
  2.29679048e-02f, 4.65145968e-02f, 8.55002403e-02f, -6.58937469e-02f, 7.27334619e-02f, 5.87620810e-02f, -1.04747061e-02f, -4.19079773e-02f, -6.89878985e-02f, -6.52865320e-02f,
  8.02147388e-02f, 4.08849157e-02f, 1.18809910e-02f, 6.94992719e-03f, -6.43383041e-02f, -9.18221921e-02f, -4.48290184e-02f, 1.26632884e-01f, -9.74015426e-03f, 1.62145402e-02f,
  5.94211966e-02f, 1.51057065e-01f, 1.02952048e-01f, -5.60326241e-02f, -6.19303547e-02f, -9.51384678e-02f, -1.50951847e-01f, -8.34273547e-02f, -1.24462985e-01f, 8.60092565e-02f,
  -1.39103487e-01f, 1.00713305e-01f, 3.88290137e-02f, -1.09352030e-01f, -1.35499045e-01f, -7.53653347e-02f, -1.23922274e-01f, -1.44215003e-02f, -1.98452938e-02f, -3.61517817e-02f,
  4.10177000e-03f, -1.43696964e-01f, 3.79254594e-02f, 1.70106608e-02f, 1.28096994e-02f, -1.84533615e-02f, 6.80459738e-02f, 3.44239920e-02f, 2.45040599e-02f, -8.63805562e-02f,
  -5.62465042e-02f, -1.14047833e-01f, -9.73419938e-03f, -9.99714211e-02f, -9.24512977e-04f, -9.13420394e-02f, -4.39431489e-04f, -1.01139836e-01f, -8.14103857e-02f, 2.32879147e-02f,
  -2.16742530e-02f, 8.06391239e-02f, -1.50218368e-01f, -5.86679205e-02f, -1.75872408e-02f, -4.62327944e-03f, -6.32956177e-02f, 1.39048407e-02f, 1.29610732e-01f, 1.43080652e-01f,
  6.07038289e-02f, -3.73770343e-03f, 2.67634410e-02f, 3.33059318e-02f, -6.42332584e-02f, 3.63236703e-02f, -5.15212752e-02f, -5.56605980e-02f, -5.03748991e-02f, -1.05457515e-01f,
  -9.35459584e-02f, 5.99397160e-02f, -6.49452955e-02f, -7.83952996e-02f, -8.11404362e-02f, 4.34805453e-02f, -2.35061087e-02f, -8.42060968e-02f, 8.84978548e-02f, -5.62770963e-02f,
  -9.35750306e-02f, -3.10618356e-02f, 1.10019222e-01f, 7.49733075e-02f, -4.70952094e-02f, -6.64222538e-02f, 8.91456902e-02f, 3.66960429e-02f, -6.75736219e-02f, 7.44878799e-02f,
  1.70780513e-02f, 3.06589436e-02f, 4.38308008e-02f, 3.58163263e-03f, 6.44191215e-03f, 1.37432031e-02f, 2.23838687e-02f, 8.76475573e-02f, -1.11205138e-01f, 8.32897499e-02f,
  -1.96189821e-01f, -1.95821360e-01f, -1.02028297e-02f, 3.28020528e-02f, 1.01002418e-01f, 1.14013022e-03f, -2.72806529e-02f, 7.16901869e-02f, -8.97975266e-02f, -4.14685272e-02f,
  6.16286509e-02f, 5.15387692e-02f, -5.63157909e-02f, 4.61177016e-03f, 3.49037759e-02f, -6.51329607e-02f, 2.05579642e-02f, 5.63341938e-03f, -4.78116609e-02f, 1.04372799e-02f,
  -8.17845401e-04f, -1.78479943e-02f, -3.79373468e-02f, 5.02114445e-02f, 6.53351247e-02f, 6.07578531e-02f, -4.35949750e-02f, 3.73309813e-02f, 3.06007322e-02f, -4.76651639e-02f,
  -7.84517825e-01f, 1.53562501e-01f, -1.57910511e-01f, -1.81191847e-01f, 2.27106526e-01f, -2.71118581e-01f, -1.95427760e-01f, 2.56007791e-01f, 3.42635699e-02f, 1.22590929e-01f,
  -2.15888247e-02f, -1.45585924e-01f, -8.71746428e-03f, -2.52297789e-01f, -4.68929857e-01f, -2.76958346e-01f, -4.24011439e-01f, -3.21077853e-02f, -2.11341828e-01f, 1.11414284e-01f,
  -1.36967972e-01f, 1.15706669e-02f, -3.61627340e-01f, 1.70265555e-01f, 5.86182289e-02f, 1.37751445e-01f, 1.94319889e-01f, 1.58277780e-01f, -9.93553922e-02f, -1.68227069e-02f,
  3.08642164e-02f, 1.73482552e-01f, 1.00346074e-01f, 4.25967835e-02f, -7.94090144e-03f, 9.48455371e-03f, -3.82362530e-02f, 1.73523016e-02f, 1.03737591e-02f, 7.21439137e-04f,
  -3.61342691e-02f, 3.22848670e-02f, -5.08637866e-03f, -4.49193157e-02f, 9.57421511e-02f, 2.70934328e-02f, 1.52667928e-02f, 6.23580515e-02f, -1.39159868e-02f, -8.45607519e-02f,
  -6.55369088e-02f, -8.17384273e-02f, -7.67716998e-03f, -4.57279943e-02f, -7.17122704e-02f, 2.91164164e-02f, -5.98132052e-02f, -2.89949821e-03f, 4.97712307e-02f, -9.45782661e-03f,
  -1.35210017e-02f, -4.09747474e-03f, 1.88745260e-02f, 1.28867896e-02f, -2.85629369e-02f, 2.48589516e-02f, -6.83327541e-02f, 4.42608930e-02f, -5.84998429e-02f, 2.30851434e-02f,
  -3.82667743e-02f, 1.02477232e-02f, 3.64082009e-02f, -2.92848423e-03f, -7.61287287e-03f, -2.11803969e-02f, -2.71951109e-02f, 8.55111480e-02f, 2.89553381e-03f, -6.99267082e-04f,
  7.77555183e-02f, 5.06006517e-02f, -1.28617166e-02f, 4.28704778e-03f, 9.62191895e-02f, -4.44987752e-02f, -1.19504668e-02f, 7.52056297e-03f, 3.33120562e-02f, -4.28702682e-02f,
  1.37979656e-01f, 2.34295771e-01f, 2.05648858e-02f, -7.66731286e-03f, 7.87325948e-03f, -6.48042560e-02f, 1.80558190e-02f, 1.83610115e-02f, 2.50673052e-02f, -2.42671035e-02f,
  6.57961816e-02f, 7.15638837e-03f, 2.16502808e-02f, -3.67445797e-02f, -6.43075556e-02f, 7.88329076e-03f, 2.44033448e-02f, -2.91600265e-02f, 4.08417620e-02f, 3.14057693e-02f,
  5.00321239e-02f, 5.55748641e-02f, 2.11022254e-02f, 9.78360511e-03f, -1.02042453e-02f, -3.52789722e-02f, 4.87125805e-03f, 1.01444768e-02f, -3.75152798e-03f, 1.75502207e-02f,
  -1.10151625e+00f, 7.81749785e-02f, -2.10796252e-01f, 1.23998798e-01f, -2.34317422e-01f, -1.04769953e-01f, 6.27910271e-02f, -1.52994245e-02f, 3.18800174e-02f, 1.32654667e-01f,
  9.77547374e-03f, -6.47909418e-02f, -4.51077195e-03f, 1.78585082e-01f, -4.15416032e-01f, 9.56182107e-02f, 6.34593796e-03f, -3.42088006e-02f, -3.61839570e-02f, -9.81480852e-02f,
  -8.94457549e-02f, 4.56135608e-02f, -1.01538695e-01f, 4.71206605e-02f, -1.51199363e-02f, 1.53572969e-02f, -9.20564085e-02f, -6.76364899e-02f, 4.11614887e-02f, -6.31983653e-02f,
  -2.19038147e-02f, -1.24757206e-02f, 4.19817232e-02f, -1.65635496e-02f, -8.89481679e-02f, -5.41283712e-02f, -1.91272367e-02f, -2.79941354e-02f, -2.95741092e-02f, -8.91824365e-02f,
  -7.66989496e-03f, -2.93221558e-03f, 3.08807241e-03f, 3.10174208e-02f, 4.55558207e-03f, -3.68327573e-02f, 6.71617594e-03f, 3.74270678e-02f, 1.65299643e-02f, 2.11820584e-02f,
  5.06960452e-02f, 6.85527474e-02f, -3.84701937e-02f, 1.08757941e-02f, -1.95645913e-02f, 5.93040586e-02f, 4.77928855e-02f, -5.00073209e-02f, -3.97516638e-02f, 4.40999214e-03f,
  -1.09412819e-02f, -5.28683998e-02f, 2.01523378e-02f, -1.04262540e-02f, 3.14922929e-02f, 3.13938526e-03f, -2.57944986e-02f, -2.66008750e-02f, 2.66170390e-02f, 8.11997335e-04f,
  1.72465127e-02f, -4.10394631e-02f, 1.08653996e-02f, 4.42165062e-02f, 1.76261831e-03f, 3.77849042e-02f, 2.06859168e-02f, -2.11943705e-02f, -1.01802945e-02f, -2.70951297e-02f,
  1.13212585e-03f, 4.02452871e-02f, -1.99663471e-02f, -3.09444242e-03f, 7.87514448e-03f, -2.52121291e-03f, 3.00150141e-02f, 2.78918967e-02f, -1.37949176e-02f, -4.31211814e-02f,
  -2.54134208e-01f, -2.77761996e-01f, -1.33872952e-03f, -2.64693126e-02f, 3.20026800e-02f, -2.11358964e-02f, 2.17438955e-02f, -1.16496878e-02f, -3.01146191e-02f, 3.94078307e-02f,
  -4.58451509e-02f, 4.41649780e-02f, -3.49059179e-02f, -1.11149419e-02f, 3.82979624e-02f, 1.05414195e-02f, -2.24510077e-02f, -3.45038660e-02f, -5.55163585e-02f, -3.49230804e-02f,
  -2.21890770e-02f, -4.28934470e-02f, -5.50079020e-03f, 5.24002910e-02f, 3.84730622e-02f, -1.49744274e-02f, -2.35482827e-02f, 5.31861000e-02f, -1.56486891e-02f, -6.73897192e-02f,
  3.37439179e-01f, 1.50108144e-01f, 4.14132267e-01f, 4.20233816e-01f, 1.82407349e-01f, 1.60928145e-01f, 1.56580523e-01f, 2.14684501e-01f, 5.83704770e-01f, -2.30899546e-02f,
  -2.25403771e-01f, 1.23227447e-01f, -2.33095720e-01f, 5.16971052e-02f, -1.26638502e-01f, -1.00686312e-01f, 1.14669070e-01f, 1.17473472e-02f, 1.75648391e-01f, 5.03447745e-03f,
  8.31882879e-02f, -1.93210199e-01f, -6.76892102e-02f, -1.40889689e-01f, 1.53748810e-01f, 9.64111611e-02f, -2.35024706e-01f, -8.64610076e-03f, -7.88301229e-02f, -8.00432172e-03f,
  1.00505866e-01f, 4.12389822e-02f, -9.95910726e-03f, -2.43174769e-02f, -2.27025747e-02f, 4.95321788e-02f, -4.21224069e-03f, -1.27779633e-01f, 2.82825474e-02f, 7.89418668e-02f,
  -1.33087076e-02f, -5.67552969e-02f, 2.24394463e-02f, 7.93262050e-02f, 9.16150734e-02f, 4.05853149e-03f, 5.25732227e-02f, 1.57489516e-02f, 2.02442091e-02f, 2.37839762e-02f,
  -2.81263180e-02f, 5.51031902e-02f, 1.01525582e-01f, 1.42962942e-02f, -5.22397906e-02f, 4.21957187e-02f, 5.11976816e-02f, -2.17800681e-02f, 8.14363509e-02f, 2.36712508e-02f,
  -1.37462571e-01f, -3.59303541e-02f, -1.99046638e-02f, -1.00761810e-02f, -4.62939814e-02f, -4.12276387e-02f, -1.10644110e-01f, 4.19213437e-02f, 2.49711592e-02f, -6.03192039e-02f,
  5.81817143e-02f, 5.88106103e-02f, 6.08284697e-02f, 5.45099489e-02f, -4.84295040e-02f, -4.49872538e-02f, -5.60591407e-02f, 2.84388866e-02f, 5.06296987e-03f, 1.00748409e-02f,
  1.34108709e-02f, 3.25189792e-02f, -1.79943983e-02f, 3.74337845e-02f, 2.65214313e-03f, -1.24448203e-02f, -5.35186976e-02f, 2.97342446e-02f, -2.41030157e-02f, 2.40256172e-03f,
  -3.96719426e-02f, -1.23469487e-01f, -4.22238894e-02f, -5.36808074e-02f, -2.84181745e-03f, -1.03990629e-01f, -1.17745111e-02f, 8.89435876e-03f, 1.18121319e-03f, 2.32778699e-03f,
  -2.65533216e-02f, 4.60922942e-02f, -8.46838504e-02f, -1.82275437e-02f, -6.73776632e-03f, -6.19494691e-02f, -9.95752662e-02f, -3.89547907e-02f, -3.23762372e-02f, -5.19913919e-02f,
  3.10077390e-04f, -1.23304397e-01f, -5.17480671e-02f, -1.70184150e-02f, 5.27577586e-02f, -9.39630643e-02f, -1.35321831e-02f, -1.23265022e-02f, -3.06472685e-02f, -4.65206709e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  3.78895402e-02f, -9.39764977e-02f, 1.42847300e-01f, 2.46395186e-01f, 2.48996675e-01f, 7.01867789e-02f, 2.31156453e-01f, -1.10443413e-01f, 4.74014925e-03f, 2.01675668e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.03830621e-01f, 2.31978431e-01f, -1.61781833e-01f, 1.14752628e-01f, -4.93029982e-01f, -5.07857323e-01f, 2.57701259e-02f, -4.26277936e-01f, 2.06229135e-01f, -4.40970629e-01f,
  4.65591401e-01f, -9.73407030e-02f, -3.00862223e-01f, 7.03006089e-01f, 4.03450191e-01f, -4.90475923e-01f, -1.51368547e-02f, 4.95575555e-02f, 1.42172024e-01f, 1.41338110e-01f,
  6.22249655e-02f, -2.24897742e-01f, -1.79995522e-01f, -3.30132663e-01f, -9.38520767e-03f, 1.91950828e-01f, -1.66429460e-01f, 1.65834919e-01f, 6.65555000e-02f, -1.49880409e-01f,
  -5.19622147e-01f, 5.63973367e-01f, -2.30552211e-01f, -1.41804680e-01f, -6.89169839e-02f, 2.11584210e-01f, 1.97884455e-01f, -3.05266734e-02f, 2.28788719e-01f, -2.00300857e-01f,
  4.39622432e-01f, -1.25162914e-01f, 2.24863738e-02f, 5.18380143e-02f, 1.34278640e-01f, -3.93394560e-01f, -3.80595714e-01f, -4.83981073e-02f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  2.77129203e-01f, -1.28754869e-01f, -3.77222933e-02f, -2.50884682e-01f, 2.77362883e-01f, 2.61878252e-01f, -1.38245812e-02f, 3.26851189e-01f, 1.44845536e-02f, -1.17408149e-01f,
  -2.62554407e-01f, -1.15000136e-01f, 1.49642512e-01f, 7.71229807e-03f, 5.77652812e-01f, -9.33850706e-02f, -4.05317619e-02f, 2.93954343e-01f, -4.72782366e-02f, 3.03217679e-01f,
  -2.17376277e-01f, -3.23398679e-01f, -1.01262838e-01f, -1.76460549e-01f, 4.22585577e-01f, 5.87504916e-02f, -3.23071986e-01f, -2.00674295e-01f, -1.14161544e-01f, 5.16061842e-01f,
  4.67724726e-02f, -2.03137487e-01f, -2.47097626e-01f, -3.74234319e-02f, 1.97577223e-01f, -1.34004593e-01f, 1.59344926e-01f, 3.83569626e-03f, -9.38789099e-02f, 3.68342310e-01f,
  -2.83342183e-01f, 2.04613999e-01f, -1.59133777e-01f, 1.09171629e-01f, 2.04689309e-01f, -6.75745606e-02f, -4.90942672e-02f, -9.28494260e-02f, 2.00995337e-03f, 2.52739847e-01f,
  -6.10316657e-02f, 2.09457532e-01f, 1.50867589e-02f, 6.30387887e-02f, -1.01581603e-01f, 1.44769520e-01f, 3.81410062e-01f, 3.64986569e-01f, -3.36326957e-01f, 2.44968653e-01f,
  1.46562397e-01f, -7.41997510e-02f, -2.50346094e-01f, 7.11410567e-02f, 1.23414226e-01f, 2.03038037e-01f, 3.91702503e-01f, -2.64854521e-01f, -8.88306424e-02f, -8.98380354e-02f,
  2.18465447e-01f, -7.55025372e-02f, -2.51065910e-01f, -8.75427127e-02f, -1.22028962e-01f, -1.52116627e-01f, 3.27602237e-01f, -2.07461730e-01f, -1.87020004e-01f, 2.84409702e-01f,
  2.56615251e-01f, 2.07297534e-01f, 5.21269262e-01f, -1.39399037e-01f, -6.49248362e-01f, -5.09856939e-01f, -1.45755693e-01f, -2.93132186e-01f, 1.07518457e-01f, -8.67761821e-02f,
  -1.15534859e-02f, 5.14271716e-03f, 1.22840226e-01f, 8.59667540e-01f, 6.17442906e-01f, -2.74642229e-01f, -2.12250173e-01f, -5.14604598e-02f, -2.44679660e-01f, -1.86581597e-01f,
  -4.28178534e-02f, -1.34788379e-01f, -1.20936930e-02f, -1.11532524e-01f, -1.35298699e-01f, -1.51185608e-02f, 4.72934805e-02f, -1.69526577e-01f, -1.44085750e-01f, -2.04752520e-01f,
  -2.03531166e-03f, -1.45702183e-01f, 6.14506125e-01f, 4.28245217e-01f, 4.23296630e-01f, -4.69114721e-01f, -5.40966034e-01f, -2.61716932e-01f, -1.74080834e-01f, 1.09135248e-01f,
  -4.99720663e-01f, 5.28134823e-01f, -8.83545503e-02f, 4.29375410e-01f, 2.77214170e-01f, -1.26060275e-02f, 4.09293652e-01f, 3.82592231e-01f, 2.99307019e-01f, 2.12579966e-01f,
  5.21642506e-01f, -3.04492097e-02f, -2.50592679e-02f, -5.43475211e-01f, 2.64703453e-01f, -1.34579420e-01f, 2.19428465e-01f, 2.76142478e-01f, 1.04568303e+00f, 3.62728775e-01f,
  1.38531104e-01f, -2.58406270e-02f, -2.23832890e-01f, 5.69914758e-01f, -1.99696988e-01f, 3.62760946e-02f, -1.27192542e-01f, -5.66340834e-02f, -1.87033173e-02f, -2.50096500e-01f,
  1.70274630e-01f, 1.40428454e-01f, -7.76876807e-02f, -1.41765103e-02f, -2.88305115e-02f, 1.32587194e-01f, 1.69595212e-01f, 4.21392024e-02f, 8.67816210e-02f, -1.58348829e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  7.85117745e-02f, 4.25553113e-01f, 6.72250660e-03f, 5.17889023e-01f, -2.15808246e-02f, 4.40833718e-01f, -2.08766580e-01f, 4.95857239e-01f, 4.26502049e-01f, -1.54499859e-01f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -2.80367613e-01f, 6.82480931e-02f, -4.25464451e-01f, 6.34931087e-01f, 2.39952609e-01f, 1.50904447e-01f, -3.34529102e-01f, 1.34649023e-01f, 3.55790332e-02f, -3.56214762e-01f,
  6.66665882e-02f, 3.29317689e-01f, 8.24708641e-02f, -1.58634156e-01f, 4.49896425e-01f, -1.27160214e-02f, -4.95597273e-01f, -6.71440959e-01f, -1.56658813e-01f, -2.18335435e-01f,
  9.67620984e-02f, -6.25849485e-01f, -1.76244006e-01f, -3.16496551e-01f, 2.92746216e-01f, -3.10105115e-01f, 3.15416127e-01f, -1.30997837e-01f, 6.58698976e-02f, 2.56979853e-01f,
  4.34895903e-02f, -1.48522779e-01f, 2.39811271e-01f, -8.96729231e-02f, 2.24435061e-01f, -5.61890975e-02f, 5.89552701e-01f, 7.30855882e-01f, -1.29052266e-01f, 1.74070776e-01f,
  -1.21331483e-01f, -7.73269385e-02f, -2.07100660e-01f, -3.47041011e-01f, -5.56032024e-02f, -5.40523589e-01f, 1.82636142e-01f, -2.29391437e-02f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  2.52977312e-01f, 4.97205257e-02f, -1.99853629e-01f, 3.92594188e-01f, 7.25769997e-02f, -2.40290269e-01f, 2.86041290e-01f, 4.07168828e-02f, 1.19631156e-01f, -3.05918325e-02f,
  -2.79668272e-02f, 2.05757678e-01f, -2.34755144e-01f, 1.89979553e-01f, -3.10967267e-01f, 8.72844830e-02f, 3.37298550e-02f, -2.23087311e-01f, -2.02207357e-01f, 1.75818175e-01f,
  2.26144850e-01f, 7.10603073e-02f, 4.56910990e-02f, -8.71479660e-02f, -1.77357301e-01f, 1.63800791e-01f, 1.17631748e-01f, -1.03651561e-01f, -2.31812999e-01f, 4.88081351e-02f,
  1.94031715e-01f, -2.09681969e-02f, 5.77503741e-01f, 2.11831957e-01f, 7.72769570e-01f, -4.83638465e-01f, 7.14015067e-01f, -2.88345724e-01f, -4.27482992e-01f, -1.67656429e-02f,
  -3.07279080e-01f, 8.14950243e-02f, 3.60434562e-01f, -7.49123916e-02f, -2.45169997e-01f, 6.50952935e-01f, 7.63599873e-01f, -1.87576130e-01f, 2.07282409e-01f, 1.85626969e-02f,
  -2.75987506e-01f, 1.13751996e+00f, -2.50559282e-02f, -6.18425190e-01f, -9.98124331e-02f, 4.81677294e-01f, -1.18638039e-01f, -1.67794034e-01f, 8.09102580e-02f, 1.15971851e+00f,
  3.89567912e-02f, 6.54333234e-01f, 1.64736539e-01f, 7.31940344e-02f, -2.33768001e-01f, -2.60174513e-01f, 1.53935933e-03f, 7.67279789e-02f, -2.05954179e-01f, 1.81442574e-01f,
  -1.64479658e-01f, -1.57384910e-02f, 1.64654270e-01f, -8.43235627e-02f, 2.24029586e-01f, 1.69704989e-01f, 2.35761166e-01f, -8.04551765e-02f, -1.21233135e-01f, -2.11302459e-01f,
  -7.25630531e-03f, -9.01073292e-02f, 3.57678831e-01f, -6.74614966e-01f, 2.63853699e-01f, -3.11664551e-01f, 2.23624796e-01f, 6.16169069e-04f, 2.70361722e-01f, 4.88359451e-01f,
  2.34844685e-01f, -2.56238878e-01f, -1.44120812e-01f, 6.38537943e-01f, 2.19498187e-01f, 8.97735953e-02f, -1.46407917e-01f, 6.06163323e-01f, 2.62596846e-01f, 4.25798863e-01f,
  1.49406334e-02f, 3.39637518e-01f, -3.88886392e-01f, 7.05024123e-01f, -2.00542822e-01f, 3.03454340e-01f, -3.04615200e-01f, 4.22188282e-01f, -4.85623851e-02f, -4.78127569e-01f,
  3.38722944e-01f, 2.03005537e-01f, -3.92049372e-01f, 2.28200138e-01f, -2.39000052e-01f, 6.47866726e-02f, -4.35055435e-01f, -1.62211597e-01f, 2.48344287e-01f, 1.40217230e-01f,
  2.93815017e-01f, -4.37679663e-02f, 5.52775338e-02f, 5.29847741e-01f, 1.58519015e-01f, 1.73187703e-01f, -2.42068097e-01f, 2.11138338e-01f, 3.41662690e-02f, 5.89811265e-01f,
  2.51242965e-01f, 2.01237902e-01f, -7.90868625e-02f, 3.90120864e-01f, -3.27195749e-02f, 2.99823191e-02f, -9.62765515e-02f, -2.20174029e-01f, -1.23099782e-01f, -2.10639074e-01f,
  -2.22819850e-01f, -6.75619721e-01f, 8.49716127e-01f, -1.10286154e-01f, 1.81188375e-01f, 1.32820398e-01f, 6.05002999e-01f, 4.33406159e-02f, 3.15945558e-02f, 3.11228573e-01f,
  -7.26497695e-02f, -2.66769916e-01f, -2.32459176e-02f, 9.34967846e-02f, 1.96532398e-01f, 8.73206481e-02f, -1.37144476e-01f, 1.74604177e-01f, 8.83973897e-01f, -7.02858567e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  1.08883142e-01f, -4.58736159e-02f, 3.60849679e-01f, 1.10914938e-01f, -1.00426480e-01f, 2.87912488e-01f, 3.27587426e-01f, 2.73028463e-01f, 4.29783553e-01f, 4.85937625e-01f
};

// L3_fan_Wp (Shape: 3 x 16)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  1.57929733e-02f, 1.27590507e-01f, 3.42545301e-01f, -4.26022172e-01f, -6.47916794e-01f, 9.01188552e-01f, 6.69441279e-03f, 2.35949140e-02f, 4.56039682e-02f, -4.44276482e-01f,
  3.02439388e-02f, -1.75826009e-02f, 1.01286218e-01f, 9.27467495e-02f, 4.44991261e-01f, 5.75201102e-02f, 1.52565494e-01f, -2.26705089e-01f, 1.54240355e-01f, 2.61401594e-01f,
  -2.53834307e-01f, 3.11932892e-01f, 2.51774769e-02f, 5.42872995e-02f, 2.96457857e-01f, -2.91537702e-01f, -1.59409661e-02f, -1.09716475e-01f, 3.68130773e-01f, -3.71490896e-01f,
  4.63981479e-02f, 2.63634205e-01f, 5.37720263e-01f, -3.90223235e-01f, -3.40526812e-02f, -3.09729964e-01f, -2.78575987e-01f, -7.89775789e-01f, 8.96774009e-02f, 9.41892639e-02f,
  2.35343054e-01f, 2.57989615e-01f, 5.36050424e-02f, 1.15480311e-01f, 4.82450068e-01f, -4.62717593e-01f, -6.06416583e-01f, -2.33188897e-01f
};

// L3_fan_Wp_bar (Shape: 10 x 16)
const int L3_fan_Wp_bar_rows = 10;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  4.18348461e-01f, -1.65637672e-01f, 6.71000361e-01f, 2.79982179e-01f, -7.09364772e-01f, 3.96840334e-01f, 2.03594267e-02f, -1.51987448e-01f, 6.69923842e-01f, -1.42308384e-01f,
  -1.46488711e-01f, 1.37652174e-01f, 5.21561086e-01f, -3.71959597e-01f, 7.18188345e-01f, 5.21712899e-01f, -2.69939661e-01f, -2.43132059e-02f, 4.20940548e-01f, 4.75844055e-01f,
  -4.42315996e-01f, 4.83703732e-01f, -1.03124045e-01f, 2.49881968e-01f, 2.64056653e-01f, -2.29217067e-01f, -1.16902761e-01f, -1.09441146e-01f, 5.63283324e-01f, -2.12218806e-01f,
  5.99609494e-01f, 6.37990117e-01f, 2.93778270e-01f, 4.71372217e-01f, -1.80310503e-01f, -1.53250307e-01f, -1.00761935e-01f, -2.13895023e-01f, 4.30961281e-01f, -1.68804705e-01f,
  -1.44513115e-01f, 6.35970056e-01f, 1.04353711e-01f, -9.92288962e-02f, -3.91646355e-01f, 1.52144939e-01f, -2.13185355e-01f, -2.81627536e-01f, 3.02036703e-01f, 1.93957403e-01f,
  -4.46976870e-01f, -2.87531376e-01f, 2.28145033e-01f, -7.86294341e-01f, 1.78985432e-01f, 1.10175356e-01f, 2.55264968e-01f, 2.28049204e-01f, -1.01853304e-01f, 3.39723647e-01f,
  -4.17997509e-01f, -1.16619337e-02f, -2.42773637e-01f, 2.96052545e-01f, 7.10509941e-02f, 2.43065357e-01f, 8.66333395e-02f, -4.47193325e-01f, -3.99748832e-01f, -5.51907979e-02f,
  -5.75282797e-02f, -2.56284058e-01f, 1.06474936e-01f, -2.64634520e-01f, 1.20333269e-01f, 6.95272395e-03f, 1.41380830e-02f, 5.32448106e-02f, 3.15332562e-01f, 2.32670099e-01f,
  2.93971181e-01f, 2.88294464e-01f, -6.03809953e-01f, 8.71574044e-01f, -6.92416877e-02f, -6.24492705e-01f, 2.53325313e-01f, 1.05411746e-01f, 2.73098171e-01f, 1.57647276e+00f,
  1.55398557e-02f, -3.90678495e-01f, 3.09016973e-01f, 3.14312756e-01f, 1.23396479e-01f, 1.64529309e-01f, 5.32714665e-01f, 3.41618061e-01f, 2.34142870e-01f, 5.48758321e-02f,
  2.88058043e-01f, -3.33318889e-01f, -1.09983616e-01f, -1.40775159e-01f, 1.18372679e+00f, -2.09934115e-01f, 1.19158506e-01f, 6.70536399e-01f, -5.09703934e-01f, -4.36266243e-01f,
  -3.44980150e-01f, 1.39224187e-01f, -9.87557843e-02f, -1.72682449e-01f, 1.68844834e-01f, 2.29451925e-01f, 9.84676369e-03f, -2.94527203e-01f, -3.83619964e-01f, 2.07049400e-01f,
  4.32201326e-01f, 1.13102160e-01f, 9.44807529e-02f, 1.76440030e-01f, 4.22874063e-01f, 6.50005490e-02f, -1.59122422e-01f, 4.51866686e-01f, 7.05380797e-01f, 7.05175519e-01f,
  -3.69278193e-02f, -8.59009027e-01f, 5.20328045e-01f, -3.60586613e-01f, -4.15776111e-02f, -2.38269776e-01f, 7.49985099e-01f, -1.86161876e-01f, -1.09937422e-01f, 9.07236338e-01f,
  -4.77199197e-01f, 5.70516177e-02f, -3.35632473e-01f, 4.80743110e-01f, -2.90403783e-01f, -1.97584614e-01f, 8.50591883e-02f, 4.94776666e-01f, -4.58737686e-02f, 6.09443665e-01f,
  2.73007333e-01f, -1.16667308e-01f, -5.01513898e-01f, 6.98127925e-01f, -2.04316322e-02f, -1.65430933e-01f, 2.95987487e-01f, 4.79702979e-01f, 3.24207693e-01f, -2.17830494e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 10)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 10;
const float L3_fan_Bp_bar_data[] = {
  3.29221219e-01f, 1.30098835e-01f, 1.98360980e-01f, 4.56057936e-01f, 4.52932715e-01f, -3.87789197e-02f, 9.93731059e-03f, -2.00338677e-01f, 5.26217461e-01f, 3.05464089e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -5.33493236e-02f, -2.31343791e-01f, -4.47734475e-01f, -9.49793577e-01f, -3.37774932e-01f, 2.19763324e-01f, -6.58643425e-01f, -3.23011070e-01f, 7.94714808e-01f, 5.80836058e-01f,
  1.48962334e-01f, 6.19966686e-01f, -4.63776767e-01f, -6.84206486e-01f, 4.16515656e-02f, -1.47855461e-01f, -3.68170619e-01f, -4.22649264e-01f, 8.97532403e-01f, 7.88613975e-01f,
  4.96160150e-01f, 1.88819900e-01f, 9.80426311e-01f, 3.06979150e-01f, -2.29783356e-01f, -4.27787066e-01f, 4.39526141e-01f, -1.03380203e+00f, -2.27429703e-01f, -1.94267891e-02f,
  4.54202667e-02f, -3.09956640e-01f, -9.05726030e-02f, -1.84474871e-01f, -7.44148642e-02f, 4.17191893e-01f, 2.61623979e-01f, -1.10122395e+00f, 5.68559110e-01f, 9.18892443e-01f,
  -3.04322839e-01f, -2.79967368e-01f, 2.41202369e-01f, -3.41467351e-01f, -6.94176435e-01f, -6.50248826e-02f, -7.27085948e-01f, 2.01565757e-01f, -3.68344039e-01f, -8.18261147e-01f,
  3.04805279e-01f, -4.75543678e-01f, -3.64431351e-01f, -9.46265552e-03f, -4.13062751e-01f, -3.06014657e-01f, 4.69659925e-01f, -5.68859875e-01f, -2.03461811e-01f, 4.53817278e-01f,
  -3.46283913e-02f, -3.05993944e-01f, -7.73009002e-01f, 9.99082267e-01f, -1.80370629e-01f, 3.41246486e-01f, -2.77824283e-01f, -5.03559828e-01f, 3.60012613e-02f, 5.43886304e-01f,
  -2.01696366e-01f, -3.54378015e-01f, 6.98832422e-02f, 3.95637900e-01f, -3.10780048e-01f, 7.45921135e-01f, 4.73756880e-01f, -8.39370117e-02f, 8.86642560e-03f, -4.75841641e-01f,
  5.56688070e-01f, 3.55859607e-01f, 4.35748920e-02f, 7.67680347e-01f, 4.38128352e-01f, 7.85685778e-01f, 9.72909927e-02f, -3.14965338e-01f, -3.04756686e-02f, -1.94678567e-02f,
  2.46969998e-01f, -8.20378602e-01f, 8.90057266e-01f, -1.79792002e-01f, 6.50721788e-01f, -5.10458164e-02f, -4.96039093e-01f, -7.67428875e-02f, -5.19158483e-01f, 6.11096084e-01f,
  -6.87060207e-02f, -1.01209211e+00f, 2.88974881e-01f, 3.76215011e-01f, -1.89862605e-02f, -9.33659598e-02f, 5.71298972e-02f, -3.43004674e-01f, 4.49472666e-01f, -6.63232664e-03f,
  3.62732589e-01f, -3.37508887e-01f, 5.62725008e-01f, 3.77342254e-01f, 3.00764471e-01f, -4.69593704e-02f, -7.91391790e-01f, -1.91035513e-02f, -8.47022533e-01f, -4.18302208e-01f,
  1.08365774e-01f, 6.50184035e-01f, 1.93547741e-01f, -7.41498053e-01f, 2.14833096e-01f, -1.26346782e-01f, 1.04454029e+00f, -1.43395960e-01f, 6.63737953e-01f, -2.87488550e-01f,
  5.10323830e-02f, 8.63607287e-01f, 3.74959826e-01f, 5.11820495e-01f, 2.73141026e-01f, 5.77096045e-01f, -1.68320477e-01f, -2.80574977e-01f, -3.57209444e-01f, 2.52700299e-01f,
  -3.91072631e-01f, 1.40717542e-02f, -7.09089279e-01f, 5.65298736e-01f, 8.19807768e-01f, -2.19381914e-01f, 6.13249660e-01f, 1.10128924e-01f, 4.78092581e-01f, 5.49292304e-02f,
  2.14553580e-01f, 1.37200445e-01f, -3.13480765e-01f, 9.92470384e-02f, 1.46884352e-01f, 3.55349630e-01f, 9.43201706e-02f, 2.13819131e-01f, 8.07038099e-02f, -3.15549433e-01f,
  -5.26855350e-01f, 1.38192192e-01f, -5.11066377e-01f, -5.50383747e-01f, -2.64405459e-01f, -1.56029642e-01f, -6.41434044e-02f, -1.43982366e-01f, -3.12036663e-01f, -1.48529887e-01f,
  -1.37521282e-01f, 8.34523380e-01f, -5.90179980e-01f, 4.24974084e-01f, -7.99466133e-01f, 8.04914013e-02f, -4.09533054e-01f, 1.00528382e-01f, -6.85278893e-01f, -5.51679373e-01f,
  1.35563925e-01f, -5.47945723e-02f, -2.58985996e-01f, -3.04435253e-01f, -2.19421953e-01f, 3.97059649e-01f, -4.05090153e-01f, -1.99393883e-01f, 8.02647471e-01f, 2.89746583e-01f,
  4.73742723e-01f, -3.09123009e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  8.67279023e-02f, 1.35778040e-01f, 1.80590451e-02f, -4.66392845e-01f, -1.10902481e-01f, -4.71773185e-02f, -2.24389300e-01f, 2.08250821e-01f, 2.52857327e-01f, -1.04184292e-01f,
  2.08652735e-01f, -4.41203326e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    