/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.36214465e-02f, -1.82721466e-01f, -1.23928823e-01f, -2.40067001e-02f, -1.35760948e-01f, 1.95410803e-01f, 1.78718492e-01f, -1.49229154e-01f, 1.36924759e-01f, -9.01859179e-02f,
  2.02204183e-01f, -4.98531796e-02f, 2.66671121e-01f, 1.05522290e-01f, 3.56108099e-01f, 3.15829962e-01f, 2.21467748e-01f, 9.38143954e-02f, 9.87157822e-02f, -1.26096323e-01f,
  -1.93932429e-02f, 6.84000254e-02f, -2.79879011e-02f, -1.63360119e-01f, -1.78239703e-01f, -2.51569122e-01f, -6.61435872e-02f, -2.72486638e-02f, -1.60171509e-01f, 1.88129973e-02f,
  1.48580387e-01f, 3.29395127e-03f, -9.74264294e-02f, 4.16624174e-02f, -7.21760467e-02f, 1.13872224e-02f, 4.98972088e-03f, 5.47081791e-02f, 6.86063021e-02f, -7.28741195e-03f,
  -7.31646456e-03f, 4.61487137e-02f, -9.17940494e-03f, -2.65639909e-02f, 3.00480817e-02f, 8.10909048e-02f, -7.45399371e-02f, 1.75980590e-02f, 4.30060056e-04f, -1.20373992e-02f,
  6.77393079e-02f, 9.73428972e-03f, 3.83932628e-02f, 2.28660870e-02f, -1.77644864e-02f, 7.22393841e-02f, -6.69337017e-03f, -1.12828195e-01f, 4.33517508e-02f, -5.64716710e-03f,
  -1.02910936e-01f, -2.00952180e-02f, 4.02432634e-04f, 1.37960007e-02f, 6.14839494e-02f, 2.12142020e-02f, 5.13887145e-02f, 3.96552868e-02f, -3.54248732e-02f, 3.72759923e-02f,
  -2.54559573e-02f, -9.87413432e-03f, 1.90963224e-02f, -4.73248260e-03f, 1.35093136e-02f, -3.26674245e-02f, 2.21644789e-02f, 4.58941087e-02f, -6.39541373e-02f, -5.49581535e-02f,
  1.02069415e-02f, 4.99132872e-02f, -5.15276641e-02f, 4.20926921e-02f, 9.85127091e-02f, -9.03708115e-02f, 4.48924154e-02f, -4.93909754e-02f, 3.15283686e-02f, 1.89926829e-02f,
  9.16917995e-02f, -2.64396816e-01f, -4.98696417e-02f, -2.36012470e-02f, 4.87486944e-02f, 2.14477386e-02f, 1.10604195e-02f, -3.27834263e-02f, -1.82200372e-02f, 5.55246770e-02f,
  -7.44137401e-03f, -4.76101041e-02f, -4.50918451e-02f, 7.34980628e-02f, -6.02281727e-02f, 1.88247208e-02f, 4.18356247e-02f, -1.00677377e-02f, -6.81009889e-02f, -1.31448895e-01f,
  -1.09537043e-01f, 5.66595048e-02f, -1.35961883e-02f, -6.62290528e-02f, -4.38598394e-02f, -8.20631236e-02f, -6.86188713e-02f, -2.59613083e-03f, -2.62265559e-02f, 5.55161983e-02f,
  -5.27381361e-01f, -2.37204820e-01f, -4.49280232e-01f, -1.86129555e-01f, 4.44553047e-02f, 5.44265881e-02f, -1.65158629e-01f, -1.01294592e-01f, -2.53330022e-01f, 2.13615075e-01f,
  1.48192033e-01f, -1.93698585e-01f, -6.09465763e-02f, 9.19937640e-02f, -2.05921918e-01f, 9.71242636e-02f, 7.28889629e-02f, 2.96234097e-02f, 7.69124180e-02f, -1.34572476e-01f,
  -4.74879630e-02f, 3.40122759e-01f, -1.22713260e-01f, 2.67204762e-01f, -7.90255964e-02f, -5.56922778e-02f, 2.81768460e-02f, -3.04927584e-02f, 1.46071911e-01f, 1.22354673e-02f,
  2.82779448e-02f, -1.28058881e-01f, -3.13222967e-02f, -6.57060668e-02f, -8.68330002e-02f, -2.92256270e-02f, -8.19702521e-02f, 3.71754616e-02f, 1.71185993e-02f, -1.39754657e-02f,
  -3.42635363e-02f, -4.74902830e-04f, 1.69776864e-02f, 3.83704789e-02f, -9.49034118e-04f, 2.09485199e-02f, 6.31856099e-02f, 4.11464460e-02f, -2.10504998e-02f, 2.91799959e-02f,
  -2.95111611e-02f, -1.92640591e-02f, -6.32055104e-03f, 2.84076072e-02f, -6.43030461e-03f, 5.02856486e-02f, 9.76647437e-03f, 3.13665979e-02f, -9.66777802e-02f, 8.43356401e-02f,
  5.28138690e-02f, -7.10740406e-03f, 6.33696169e-02f, -2.83407699e-02f, 5.99314310e-02f, 2.68379692e-02f, 2.74873599e-02f, 5.31137362e-02f, -2.01978330e-02f, 1.17905634e-02f,
  3.23456675e-02f, -6.12418242e-02f, 5.44005446e-02f, -4.80574742e-03f, 9.22528952e-02f, -3.16508450e-02f, 1.79851465e-02f, 1.11786276e-02f, -8.66549909e-02f, 9.55945477e-02f,
  -1.92529596e-02f, -5.56938574e-02f, -2.38609258e-02f, 2.36924216e-02f, 1.51743647e-02f, -1.34705920e-02f, 5.50751984e-02f, -2.19098609e-02f, -4.19261605e-02f, -5.20749129e-02f,
  -4.76804450e-02f, -8.99933875e-02f, -1.19963372e-02f, -3.32670175e-02f, 4.82953414e-02f, 8.59125257e-02f, -2.20163609e-03f, 3.02316062e-02f, 2.48547504e-03f, -5.99731877e-02f,
  -6.68186769e-02f, 2.03858428e-02f, -4.04615998e-02f, 9.82329063e-03f, 4.35160063e-02f, 7.85886683e-03f, -3.63805406e-02f, 3.34274918e-02f, -3.29107326e-03f, -3.97910811e-02f,
  1.88339059e-03f, 2.95957197e-02f, 1.11718047e-02f, 8.85862634e-02f, 4.18702997e-02f, -2.65880078e-02f, -4.00285088e-02f, -4.29986827e-02f, 8.58955458e-02f, -5.47806323e-02f,
  2.98822910e-01f, -7.62634128e-02f, 3.17182243e-02f, 4.04093862e-01f, -7.68406019e-02f, -2.34516144e-01f, 1.64288804e-01f, -2.17398759e-02f, 6.25604838e-02f, 7.09692389e-02f,
  3.63318175e-01f, -6.82655908e-03f, -1.53235584e-01f, 3.34274322e-01f, 2.31999345e-02f, 1.91037785e-02f, 3.41136932e-01f, 1.23821519e-01f, -1.55497119e-01f, 5.60205139e-04f,
  7.75854960e-02f, 2.80614734e-01f, 1.13376729e-01f, -7.76238218e-02f, 6.93225414e-02f, 3.25875566e-03f, 6.53239191e-02f, -6.23358637e-02f, 1.42713636e-01f, -8.87821317e-02f,
  4.45675105e-02f, 4.40691747e-02f, 8.63216445e-02f, -1.42422272e-02f, -4.17929180e-02f, 6.52015358e-02f, 6.56997180e-03f, 3.37199913e-03f, 5.61692379e-02f, -1.87378703e-03f,
  1.62354559e-02f, 2.62765680e-02f, 4.83048484e-02f, -1.39712235e-02f, 1.27264031e-03f, -2.50252392e-02f, -1.32449018e-02f, -1.43754957e-02f, -5.66894859e-02f, 3.13141979e-02f,
  1.08384918e-02f, 3.67278829e-02f, 1.69811714e-02f, -5.39430827e-02f, -1.04900837e-01f, -4.37367999e-04f, -3.13571654e-02f, -1.29879758e-01f, 7.58293970e-03f, -6.29161717e-03f,
  -2.49948055e-02f, 3.13379206e-02f, 6.23064637e-02f, 6.03344887e-02f, -1.45942969e-02f, -5.87474927e-02f, 4.15996835e-02f, 6.03139736e-02f, 2.06627343e-02f, 3.11046257e-03f,
  4.64724042e-02f, 3.49478498e-02f, 7.88369253e-02f, 9.32560638e-02f, 5.06358370e-02f, 5.18221594e-02f, -3.38218510e-02f, -4.70872931e-02f, 2.70550493e-02f, -1.95136499e-02f,
  2.90052462e-02f, 1.92521773e-02f, 9.15215071e-03f, 1.43648069e-02f, 5.42038120e-02f, 6.93353266e-03f, 2.77589131e-02f, -6.20758496e-02f, -6.31141476e-04f, 9.31183994e-02f,
  -8.73831287e-02f, -2.44206607e-01f, 9.48433857e-03f, -7.12137250e-03f, -1.51326852e-02f, -5.41930906e-02f, 3.54913920e-02f, -3.93431932e-02f, -6.75736517e-02f, 5.20978756e-02f,
  -2.45656576e-02f, 1.99394394e-02f, 7.11668422e-03f, 2.89088599e-02f, 5.76580316e-02f, -2.47229971e-02f, 6.93455562e-02f, 2.47500185e-02f, 1.07447952e-02f, -6.52840585e-02f,
  2.10351571e-02f, -4.49565090e-02f, -9.38168075e-03f, -2.98579806e-03f, -3.70102413e-02f, -3.20627429e-02f, -5.29755838e-02f, 2.80026626e-02f, 3.54561172e-02f, 6.03358597e-02f,
  2.29062200e-01f, -2.90501148e-01f, -8.49691033e-02f, -9.08913240e-02f, 1.90993488e-01f, 4.73726332e-01f, 2.26011127e-01f, 6.53618723e-02f, 4.12876392e-03f, -1.62114814e-01f,
  8.62479061e-02f, -2.58516103e-01f, -1.36206388e-01f, 7.57848620e-02f, 4.04559225e-01f, -3.78654972e-02f, 7.96531886e-02f, -3.92743051e-02f, 5.13473526e-02f, -1.03596337e-01f,
  5.24816699e-02f, 1.55555367e-01f, 1.44266784e-02f, -2.27626469e-02f, -3.88174201e-03f, -1.42692477e-01f, -1.63654149e-01f, -3.57986167e-02f, -8.83618966e-02f, 4.26704846e-02f,
  1.89177498e-01f, 2.75222771e-02f, 4.06117477e-02f, -1.01264371e-02f, -4.12916020e-02f, -6.86335787e-02f, -4.05757427e-02f, -4.73731719e-02f, 6.88537806e-02f, -8.22339132e-02f,
  -9.58995074e-02f, 5.23236580e-02f, 2.28605568e-02f, 3.55783366e-02f, 1.07056260e-01f, 1.29018829e-03f, 6.15125112e-02f, 6.24222308e-02f, -9.31560621e-02f, 3.06003708e-02f,
  3.39589291e-03f, 5.59607707e-03f, -1.35562988e-02f, -9.12488624e-02f, -6.25039414e-02f, 1.58922803e-02f, -6.07214943e-02f, -4.87352349e-02f, 1.91472080e-02f, -3.34176682e-02f,
  -3.72471213e-02f, -2.15528253e-02f, 2.55578905e-02f, -4.40011472e-02f, 4.93185148e-02f, 1.02849342e-02f, -2.04835590e-02f, -2.86993794e-02f, 1.05994195e-02f, -1.95204914e-02f,
  -4.35670279e-03f, 3.57970744e-02f, 2.98786797e-02f, 4.22978625e-02f, 5.42072281e-02f, 1.06257964e-02f, 5.40323381e-04f, -6.08105995e-02f, -3.36478986e-02f, 4.81305309e-02f,
  -2.98036430e-02f, 1.77781973e-02f, -7.54841417e-02f, -4.53993045e-02f, 3.50549375e-03f, 2.53902245e-02f, -2.30656695e-02f, -1.49415592e-02f, -2.54980382e-02f, -5.25347190e-03f,
  -1.24462835e-01f, -3.29781353e-01f, -8.25064555e-02f, -4.80332412e-03f, -5.84343299e-02f, -1.92322675e-02f, 5.07114939e-02f, 4.84691821e-02f, -1.19269915e-01f, 6.97180554e-02f,
  -7.90168811e-03f, -1.39872283e-02f, 3.01708858e-02f, 5.86023815e-02f, -2.01851372e-02f, -5.38786314e-02f, -9.90835354e-02f, -4.28854190e-02f, -4.76635359e-02f, -1.32369567e-02f,
  -6.12408444e-02f, -1.10929143e-02f, 4.37164791e-02f, 9.75824147e-02f, -6.35105092e-03f, -1.55811133e-02f, 3.30361091e-02f, 1.84704363e-02f, 1.25441421e-02f, -7.07162023e-02f,
  5.07710040e-01f, -2.40467235e-01f, -9.02315304e-02f, 1.63090736e-01f, 1.96376815e-01f, 1.63091291e-02f, -2.26521939e-01f, -2.51535252e-02f, 1.26296341e-01f, -2.70523548e-01f,
  -4.86070551e-02f, -1.09164655e-01f, -1.10288940e-01f, -8.78790319e-02f, 3.62252712e-01f, -4.05425094e-02f, 1.96153089e-01f, -4.99382094e-02f, 1.04595125e-01f, 9.48410928e-02f,
  1.82620481e-01f, 1.65010169e-01f, -1.50217693e-02f, 1.10151149e-01f, -8.06186721e-02f, -4.57706628e-05f, 1.14749465e-02f, -1.49098426e-01f, 4.40227687e-02f, -4.57076281e-02f,
  -1.57273099e-01f, -1.00011900e-01f, -8.94321129e-02f, -5.88499494e-02f, 5.66647016e-02f, -1.90212633e-02f, -4.25928459e-02f, -1.31778931e-02f, 3.21327448e-02f, -9.64912819e-04f,
  -8.78633000e-03f, 4.90957126e-02f, 1.63135142e-03f, 4.71684039e-02f, 2.76392531e-02f, -4.16170657e-02f, -5.15981205e-02f, -3.53669301e-02f, -4.27313410e-02f, -1.32926451e-02f,
  -2.78817266e-02f, 8.51015002e-03f, 7.04592317e-02f, -3.14731970e-02f, -3.34636010e-02f, 3.17319087e-03f, -6.40863478e-02f, -1.55936088e-02f, 1.36011532e-02f, 7.10042100e-03f,
  9.70392078e-02f, 5.54828420e-02f, 1.91171691e-02f, -2.64720209e-02f, 3.13575044e-02f, 2.71511320e-02f, 7.33480081e-02f, -1.10607306e-02f, 1.49441119e-02f, 3.41375656e-02f,
  4.81167696e-02f, 3.87896821e-02f, -3.22038569e-02f, 5.91271892e-02f, -1.55615248e-02f, 3.54362931e-03f, 2.82932501e-02f, -6.70620101e-03f, 5.88736944e-02f, 3.48911923e-03f,
  3.92312407e-02f, 5.43371476e-02f, -8.18977952e-02f, -2.94981580e-02f, 6.30783066e-02f, 1.17601575e-02f, -1.63396634e-02f, -5.83055131e-02f, -5.64164892e-02f, 2.42923610e-02f,
  7.81780630e-02f, -3.27913538e-02f, -4.16188985e-02f, -2.80240141e-02f, -4.02436368e-02f, 7.81323016e-02f, 7.03776181e-02f, 6.06590249e-02f, -1.91002116e-02f, 6.22860081e-02f,
  1.83486156e-02f, -1.58562250e-02f, 2.07768772e-02f, 2.44965609e-02f, 7.44758695e-02f, -3.63201252e-03f, -4.03255858e-02f, 2.50673238e-02f, -1.14673711e-02f, 3.06727495e-02f,
  1.60379540e-02f, -9.48646478e-03f, -5.51984981e-02f, 2.75249314e-02f, 1.07565530e-01f, -4.63505201e-02f, 4.45837826e-02f, -4.01452892e-02f, 1.95381194e-02f, 2.64832564e-02f,
  -1.26623645e-01f, 5.70925809e-02f, -2.66713291e-01f, 6.52305409e-02f, -2.97173802e-02f, -3.04829389e-01f, 9.21151415e-02f, 3.05928420e-02f, -1.32534340e-01f, 2.84608543e-01f,
  7.84237087e-02f, -4.93569076e-02f, 2.46477887e-01f, -2.72764862e-02f, -1.90983355e-01f, -1.29887797e-02f, -4.61529605e-02f, -1.01393228e-02f, -7.49798566e-02f, 1.65182561e-01f,
  -1.75663352e-01f, 1.61121845e-01f, -1.59078807e-01f, 5.81176020e-02f, -1.48322374e-01f, -1.35242701e-01f, 1.29768223e-01f, -5.31128934e-03f, 1.68211514e-03f, -2.80968659e-02f,
  -3.41627263e-02f, 1.78779274e-01f, -9.96881649e-02f, -5.48887253e-02f, -2.36626491e-02f, -3.34156156e-02f, -5.41470982e-02f, -1.75119508e-02f, -6.01429343e-02f, -6.08307980e-02f,
  -9.70291197e-02f, -4.05831560e-02f, 5.33934645e-02f, 1.24595324e-02f, -4.61380258e-02f, -5.53811714e-03f, -3.59316953e-02f, -9.46463645e-02f, 2.03276146e-02f, -8.38396028e-02f,
  -3.09923813e-02f, -1.06844783e-01f, -4.29590568e-02f, -2.33589448e-02f, -9.47905704e-02f, -1.37842679e-02f, -7.58752897e-02f, -5.55909127e-02f, -1.40275508e-02f, -8.51781741e-02f,
  -3.20461914e-02f, 3.86973135e-02f, 4.36287597e-02f, 3.43613401e-02f, 1.09748587e-01f, -2.88642757e-02f, 7.20101073e-02f, 4.51225340e-02f, 9.41688847e-03f, 5.95954023e-02f,
  3.00190300e-02f, -1.02034574e-02f, 3.06346994e-02f, -7.44024515e-02f, 3.87090184e-02f, -2.28132959e-02f, -1.68783721e-02f, 6.81246221e-02f, -8.24768096e-02f, -3.48904245e-02f,
  7.70243332e-02f, 1.56787299e-02f, 5.73847294e-02f, -6.06728978e-02f, 9.33483839e-02f, -1.72024835e-02f, -8.10984001e-02f, -1.59296617e-02f, 4.86947186e-02f, -3.00831366e-02f,
  1.69861332e-01f, 3.00647259e-01f, 4.64001596e-02f, -4.23734542e-03f, 3.58814076e-02f, -1.40426727e-02f, -2.99892481e-02f, -6.82222024e-02f, 7.06421137e-02f, 6.58154637e-02f,
  7.21807359e-03f, 3.91729437e-02f, -1.20315691e-02f, 1.94858275e-02f, -2.24782433e-02f, -6.53150529e-02f, 4.94116582e-02f, 2.10455935e-02f, 6.71572844e-03f, 5.46761975e-02f,
  1.93873290e-02f, 6.63414896e-02f, -9.07011388e-04f, 3.78674851e-03f, 6.86153816e-03f, 3.95295210e-02f, -1.42558413e-02f, -3.58319916e-02f, 1.89596806e-02f, -5.41193364e-03f,
  3.69823068e-01f, 2.69588351e-01f, -2.99653113e-02f, 1.75997362e-01f, 1.11766398e-01f, -1.99715421e-01f, 3.41342203e-02f, 6.46893382e-02f, 5.10928892e-02f, -7.88012445e-02f,
  -7.20554516e-02f, -1.66269287e-01f, 5.64420968e-02f, -7.95443058e-02f, -1.24115080e-01f, -7.61822015e-02f, -5.47851399e-02f, -4.75251153e-02f, 1.05787210e-01f, 3.52064371e-02f,
  7.74395764e-02f, 5.29376715e-02f, -4.96754199e-02f, 8.83064233e-03f, 6.79267645e-02f, 1.68994188e-01f, -3.97306830e-02f, 3.93578187e-02f, -1.31177887e-01f, -2.65167058e-02f,
  1.07750587e-01f, 2.11690553e-02f, 9.90322903e-02f, -3.86133976e-03f, 4.12931181e-02f, 5.00728600e-02f, -6.75833970e-03f, 8.88579059e-03f, 3.11673936e-02f, 1.69347804e-02f,
  -7.85084814e-03f, 2.61590518e-02f, -1.45165352e-02f, 2.85380986e-02f, 9.92523786e-03f, -4.15398128e-04f, 1.45710902e-02f, 6.48293868e-02f, -4.07690890e-02f, -1.88803151e-02f,
  -3.79485488e-02f, 1.79018974e-02f, 1.09862536e-01f, -8.16414176e-05f, 4.06566337e-02f, -3.07406345e-03f, -5.66135943e-02f, -6.07534237e-02f, -8.21307302e-02f, -3.85055169e-02f,
  4.39588875e-02f, -1.64201390e-02f, 2.08503846e-02f, 2.35873833e-03f, 3.26746963e-02f, 5.81496730e-02f, -2.37957761e-02f, -2.47688387e-02f, -2.73888651e-02f, -2.27248352e-02f,
  -7.70831928e-02f, 5.44077195e-02f, -4.78481166e-02f, -2.34058965e-02f, 4.78212861e-03f, 1.66239943e-02f, 1.06249638e-01f, -5.63907847e-02f, 2.70154923e-02f, -7.21602216e-02f,
  4.89920340e-02f, -6.96549052e-03f, -1.06661864e-01f, 4.63184454e-02f, -3.98561209e-02f, 7.57865161e-02f, 1.21143259e-01f, -1.18907083e-04f, -5.76893352e-02f, 4.23465483e-03f,
  2.64157206e-01f, 1.60073504e-01f, 3.06776725e-02f, -2.34182328e-02f, -1.13997333e-01f, -3.71488594e-02f, 4.14801985e-02f, 4.20633517e-03f, -3.24599352e-03f, 8.62867311e-02f,
  2.93960124e-02f, -2.76490413e-02f, -1.62375327e-05f, 1.47546371e-02f, -8.63923598e-03f, 4.45537604e-02f, -8.69142637e-02f, 5.45160770e-02f, 6.63195876e-03f, 5.78058138e-02f,
  3.21011432e-02f, 1.50770769e-02f, -1.39688477e-01f, 1.14007212e-01f, -7.29509769e-03f, -8.22955444e-02f, 6.30373880e-02f, -6.83587939e-02f, -5.41794002e-02f, 1.11067742e-02f,
  1.45646214e-01f, 8.03739019e-03f, 2.50174552e-01f, 1.00168683e-01f, 8.45069811e-02f, 1.38121650e-01f, 2.79793084e-01f, -2.89344899e-02f, 4.67389315e-01f, -2.54904985e-01f,
  -1.56966999e-01f, -8.95736441e-02f, 6.26312643e-02f, -2.77885139e-01f, 5.23928367e-02f, 1.92700967e-01f, -1.06204547e-01f, -7.37179667e-02f, 1.89458877e-01f, -8.86208415e-02f,
  7.06660450e-02f, -1.85392290e-01f, 1.94082707e-02f, -1.44829422e-01f, -1.68419197e-01f, -3.88275832e-02f, -3.53608787e-01f, 1.31736472e-01f, -3.27907920e-01f, -3.68072577e-02f,
  9.65541601e-02f, 5.55407703e-02f, 2.84716915e-02f, -2.06064172e-02f, -4.04356271e-02f, 2.22364049e-02f, -3.83280963e-02f, 1.02246322e-01f, 8.94413218e-02f, 6.43841922e-02f,
  -5.97133227e-02f, -2.20359322e-02f, -1.19044222e-02f, 5.57482429e-03f, 6.88950196e-02f, -2.75679436e-02f, 1.97611097e-02f, -1.31795965e-02f, -3.87444571e-02f, -1.62457884e-03f,
  9.79445949e-02f, 7.36157317e-03f, 9.00329370e-03f, -3.27749699e-02f, 2.05590320e-03f, 5.02465516e-02f, 1.15887979e-02f, 7.37565756e-03f, -4.25298028e-02f, 7.34159872e-02f,
  4.06443048e-03f, 7.31687769e-02f, 1.51939671e-02f, -3.78051749e-03f, -4.29502912e-02f, -1.73988156e-02f, -5.65460324e-02f, -2.79479772e-02f, 1.06702270e-02f, -3.21272053e-02f,
  -2.55893264e-02f, 1.13174261e-03f, 2.16399916e-02f, 5.81440479e-02f, -1.85419731e-02f, -1.84952710e-02f, 3.86168389e-03f, 6.14814600e-03f, 3.01550869e-02f, 5.19055547e-03f,
  -2.25479435e-02f, 4.58955616e-02f, 1.75341610e-02f, -1.54427777e-03f, 1.25806322e-02f, 8.11266154e-02f, -7.71198794e-02f, 7.73443235e-03f, 6.25539869e-02f, -2.85483263e-02f,
  -8.46613273e-02f, -4.13644202e-02f, -4.65266034e-02f, 1.16605600e-02f, 4.67654131e-02f, -1.03651464e-01f, 7.35080391e-02f, -8.89313594e-02f, 1.67521648e-02f, -5.25424853e-02f,
  -6.27056733e-02f, -5.68045340e-02f, -1.72413308e-02f, -8.30635894e-03f, 2.10296810e-02f, 4.58155908e-02f, -4.28616907e-03f, -5.88206016e-02f, 1.92017816e-02f, -7.33133331e-02f,
  -1.26552626e-01f, 2.24394654e-03f, -1.08158868e-02f, -5.88202886e-02f, -6.90875798e-02f, -1.03579216e-01f, -1.18623879e-02f, -9.73239262e-03f, 9.45672207e-03f, -6.39372412e-03f,
  -9.10123345e-03f, -2.61337340e-01f, 1.00555634e-02f, -1.73116148e-01f, -1.13902867e-01f, -5.22468865e-01f, -3.84534061e-01f, -1.67335253e-02f, -2.07108244e-01f, -1.69568539e-01f,
  -6.79975823e-02f, -1.69040635e-01f, -3.79740298e-02f, -1.67082042e-01f, -7.22799823e-02f, -1.28481135e-01f, -1.15739390e-01f, -1.44918367e-01f, 6.25715824e-03f, 1.70458425e-02f,
  2.01796964e-02f, -1.15308978e-01f, 2.62190029e-02f, 7.19195530e-02f, -5.42809069e-02f, 1.52501449e-01f, 2.53417611e-01f, 4.57651950e-02f, 5.87042980e-02f, -1.04009835e-02f,
  -6.72881305e-02f, -2.16651000e-02f, -6.75139055e-02f, 1.50725609e-02f, -4.18869182e-02f, -2.02642698e-02f, 1.58144459e-02f, 1.52176926e-02f, 6.67699128e-02f, -2.19820198e-02f,
  3.91510837e-02f, 1.52049037e-02f, -2.64007989e-02f, -2.20550895e-02f, -3.90669480e-02f, -2.91189365e-02f, -3.08762789e-02f, -3.02247033e-02f, -2.71028597e-02f, -6.95392722e-03f,
  5.94462492e-02f, 3.24912556e-02f, 3.61745385e-03f, -7.94465318e-02f, 5.57513386e-02f, -1.59408879e-02f, -9.02671739e-03f, 2.09358279e-02f, 3.28933224e-02f, -1.82814784e-02f,
  3.29275504e-02f, 3.77119929e-02f, -1.30610531e-02f, 8.85392874e-02f, -6.26721680e-02f, 2.36963369e-02f, 1.76216681e-02f, -3.87804583e-02f, 6.66777641e-02f, -5.67624047e-02f,
  3.16416146e-04f, -1.61826313e-02f, 5.26279286e-02f, 5.81926815e-02f, 6.98138550e-02f, 8.58286470e-02f, 3.17590646e-02f, 4.42289263e-02f, -4.37819660e-02f, -3.39817256e-02f,
  1.33678280e-02f, 1.36025632e-02f, -1.07561231e-01f, 1.98148806e-02f, -1.29270609e-02f, 3.34891230e-02f, -5.19135222e-02f, 2.24895347e-02f, -7.13347085e-03f, 2.90788338e-02f,
  -1.11763425e-01f, -1.50159612e-01f, -2.69485340e-02f, 4.10773791e-02f, 1.11303264e-02f, 4.98415157e-02f, 1.60823446e-02f, -1.54876001e-02f, 2.26561595e-02f, -7.94033930e-02f,
  4.36593518e-02f, 1.09537849e-02f, 5.90023622e-02f, -7.29381992e-03f, 4.02711518e-02f, -6.94920123e-02f, 5.48521131e-02f, 1.24255689e-02f, -7.67184934e-03f, 2.50393115e-02f,
  1.60587188e-02f, -2.63440143e-02f, 7.58264505e-05f, -5.20017371e-02f, -6.63911998e-02f, -3.56315784e-02f, -4.39585112e-02f, 7.30215833e-02f, 4.83726487e-02f, -1.23481248e-02f,
  -4.37550336e-01f, -2.33895898e-01f, -2.47349828e-01f, -4.94292527e-01f, 2.97486177e-03f, 3.19610417e-01f, 3.89007665e-02f, -6.98117092e-02f, -4.04433310e-01f, 7.51716942e-02f,
  5.57465293e-02f, -1.93057880e-01f, -1.77340657e-02f, -6.58119321e-02f, 4.22252938e-02f, 1.18670508e-01f, -1.04120262e-01f, -1.79898068e-01f, -8.90348777e-02f, -1.42751321e-01f,
  -6.83179051e-02f, 1.01052620e-01f, -4.56046984e-02f, 1.25237461e-02f, -4.12491895e-02f, -8.48524496e-02f, 5.91562502e-02f, -6.46443223e-04f, 1.20983116e-01f, 1.22665189e-01f,
  1.28773332e-01f, -8.87449011e-02f, -3.20932977e-02f, 2.65888236e-02f, -6.12427443e-02f, 4.15661633e-02f, 9.43874493e-02f, 1.22378290e-01f, -3.95108126e-02f, -3.19024920e-02f,
  9.57626663e-03f, 6.00697063e-02f, -1.97980050e-02f, -6.91756681e-02f, -3.63338776e-02f, -4.78230156e-02f, -9.47684795e-03f, -1.97892613e-03f, -7.16771558e-02f, 1.52365232e-04f,
  -4.34110872e-02f, 4.59583960e-02f, -1.83651969e-02f, 6.92201704e-02f, -2.44692601e-02f, 6.53532101e-03f, 3.55825499e-02f, 5.47467843e-02f, 4.97770831e-02f, -8.36419407e-03f,
  7.04353862e-03f, -2.50477344e-02f, -4.88415919e-02f, -8.55944902e-02f, -4.26346138e-02f, 3.17633175e-03f, -4.95148301e-02f, 5.16025908e-02f, -6.69443905e-02f, 2.50336081e-02f,
  -1.60501227e-02f, -1.53250312e-02f, -6.11130036e-02f, -3.69148590e-02f, -4.20385897e-02f, -1.29427081e-02f, -6.45995606e-03f, 1.54802797e-03f, -3.37619297e-02f, -1.19711742e-01f,
  6.35386854e-02f, 6.36592209e-02f, -6.06003813e-02f, 3.88553813e-02f, 7.66703039e-02f, -5.21296337e-02f, -6.49593771e-03f, -5.00100665e-03f, -4.96579967e-02f, -1.07604740e-02f,
  6.88057542e-02f, -7.41445869e-02f, -8.78060050e-03f, 4.70013730e-02f, 1.41967530e-03f, 1.50810913e-04f, -5.14836535e-02f, -9.39982310e-02f, -2.31565386e-02f, 2.25306954e-02f,
  6.15659691e-02f, -1.98672861e-02f, 7.85512701e-02f, 1.60773825e-02f, 2.13120356e-02f, 5.06926700e-02f, -4.67257723e-02f, -2.18564812e-02f, -3.55513431e-02f, 1.23503963e-02f,
  6.76130992e-04f, 3.22560477e-03f, -1.38923516e-02f, 4.97499306e-04f, 6.12909123e-02f, -3.05833537e-02f, -5.78730367e-02f, -2.88528670e-02f, 5.92478923e-02f, 3.31652770e-03f,
  -1.63107291e-01f, 2.85055697e-01f, 6.58735186e-02f, 2.24964470e-01f, -3.91456217e-01f, -2.15128928e-01f, -2.83872746e-02f, -1.30566619e-02f, 1.59647286e-01f, 7.17043281e-02f,
  -2.32564554e-01f, 6.83362857e-02f, -3.12676583e-03f, 9.69374999e-02f, -3.21350485e-01f, 2.89059699e-01f, -9.43378583e-02f, -2.12020993e-01f, 1.63320720e-01f, -1.75149113e-01f,
  2.02836152e-02f, -2.09684387e-01f, -6.45357519e-02f, -1.51412055e-01f, -2.44635537e-01f, -9.82715003e-03f, -1.73700973e-01f, 3.94384414e-02f, -2.39833087e-01f, -1.36173204e-01f,
  -5.23524210e-02f, 1.15247495e-01f, -3.22182886e-02f, 5.72982430e-02f, -2.51840532e-01f, -1.67889819e-02f, -1.14962034e-01f, 4.40055132e-02f, -3.06143016e-02f, -2.85093430e-02f,
  1.50369611e-02f, -5.64932376e-02f, -6.67778999e-02f, 7.11153895e-02f, 2.95901019e-02f, 1.28252441e-02f, 1.18388413e-02f, 4.44148779e-02f, 3.50121707e-02f, 3.46418470e-02f,
  4.85922545e-02f, 3.61025557e-02f, 9.65387300e-02f, 4.29226793e-02f, 2.79810466e-02f, 5.32229468e-02f, 3.14564928e-02f, -8.34428668e-02f, 2.22857185e-02f, -8.35375860e-02f,
  4.96808290e-02f, -2.61485595e-02f, -6.17187805e-02f, -3.38782580e-03f, -4.63468730e-02f, 5.31514932e-04f, 1.16500415e-01f, -2.45722886e-02f, -1.76953932e-03f, 2.66811587e-02f,
  -1.54662412e-02f, 5.54890111e-02f, 4.10694405e-02f, 1.18727431e-01f, -4.11996208e-02f, 9.47912708e-02f, -2.86918376e-02f, -4.05074693e-02f, -1.72408298e-02f, -3.58365439e-02f,
  1.30295172e-01f, 7.17837885e-02f, -5.64129800e-02f, 4.89192009e-02f, 4.63710092e-02f, 2.66783908e-02f, 7.04072788e-02f, 7.38490000e-02f, -7.54298717e-02f, -4.34208885e-02f,
  -1.96845740e-01f, -7.30003342e-02f, -2.58590020e-02f, -1.06707253e-01f, 5.14615253e-02f, 3.41456756e-02f, 1.36794493e-01f, -2.72643901e-02f, 2.28358954e-02f, -6.11656196e-02f,
  -1.43097326e-01f, -8.06118920e-02f, 6.30587563e-02f, 5.52491343e-04f, -3.54762487e-02f, 7.99732283e-03f, 1.35410298e-02f, -4.33830582e-02f, -4.84519713e-02f, -8.26021060e-02f,
  -4.59128469e-02f, -1.14533983e-01f, -7.69881904e-03f, -7.96781406e-02f, -3.82981673e-02f, -5.45143969e-02f, -2.62446981e-02f, -1.36095425e-02f, -3.85945514e-02f, 5.63017167e-02f,
  -3.94705355e-01f, 1.71657149e-02f, 1.57454208e-01f, -4.40245032e-01f, -6.23646788e-02f, 3.26397605e-02f, -4.08486463e-03f, -7.59096146e-02f, -2.05904052e-01f, 8.44449773e-02f,
  5.87428883e-02f, -5.49351983e-02f, 2.57055551e-01f, -3.34708005e-01f, -2.58737832e-01f, -1.04404278e-02f, -2.25760251e-01f, -3.95053849e-02f, -9.29665118e-02f, -1.47597909e-01f,
  -1.22406915e-01f, -3.37293535e-01f, -1.58137009e-02f, -7.23827556e-02f, -1.30926341e-01f, 4.64467220e-02f, -1.10170849e-01f, 1.71524003e-01f, -2.27333922e-02f, -9.71901864e-02f,
  7.85484314e-02f, -9.89783481e-02f, 3.80514376e-02f, -5.06664021e-03f, -5.41153625e-02f, 6.43201992e-02f, 3.20330188e-02f, -5.48265781e-03f, 1.97686628e-02f, -7.39078177e-03f,
  4.23542224e-02f, -6.43112063e-02f, -5.88255450e-02f, -2.87216213e-02f, -4.21198979e-02f, -4.77922559e-02f, -1.10835368e-02f, 2.54207477e-02f, -5.41387424e-02f, 6.29438013e-02f,
  8.06268230e-02f, 4.86799628e-02f, -3.08502279e-02f, 7.21474551e-03f, 3.26596126e-02f, -1.09774508e-01f, -6.85162097e-03f, 1.57294087e-02f, -4.12367322e-02f, -7.76030272e-02f,
  -3.03486884e-02f, 2.71997489e-02f, 3.91052105e-02f, -8.59763473e-03f, -4.28179204e-02f, -7.09477961e-02f, -2.17445344e-02f, 2.96344161e-02f, -2.11572442e-02f, -5.20651229e-02f,
  -4.07957472e-02f, 7.24790990e-02f, -6.37532352e-03f, -1.70747470e-03f, -7.93457311e-03f, -4.29105423e-02f, 7.48372748e-02f, -4.07888852e-02f, 3.48530523e-02f, -2.43256204e-02f,
  -1.04257499e-03f, -5.73052391e-02f, 1.02021977e-01f, 8.02085400e-02f, 1.11887082e-01f, -9.96404793e-04f, -3.92734669e-02f, -6.58418164e-02f, 4.92255948e-02f, 7.81582892e-02f,
  -6.36166483e-02f, -1.10385515e-01f, 3.49476896e-02f, -2.69868225e-02f, 4.54761609e-02f, -8.94992705e-03f, 3.95083288e-03f, -2.39966270e-02f, -1.17494702e-01f, -8.08152705e-02f,
  -6.89233094e-02f, 1.11019164e-02f, 2.64573153e-02f, 6.33633317e-05f, 8.37744027e-02f, 6.70259446e-02f, 3.04866321e-02f, -1.44557552e-02f, -1.06809987e-02f, -5.00937328e-02f,
  -3.67533900e-02f, -1.55027360e-02f, -9.66914557e-03f, -3.36664058e-02f, 2.06654649e-02f, 1.31392153e-02f, -6.15580976e-02f, -1.04536079e-02f, 6.52963594e-02f, 2.91186795e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.10242736e-01f, 9.78277400e-02f, -1.81776837e-01f, -8.45193714e-02f, -1.52128384e-01f, 6.86467052e-01f, 6.79772139e-01f, -1.93092927e-01f, 1.44754956e-02f, 2.25516021e-01f,
  2.35156640e-02f, 2.23363861e-01f, 2.31087536e-01f, 1.79057643e-01f, 3.21708918e-01f, 3.83887678e-01f, 1.87703654e-01f, 2.23375186e-01f, -5.34756444e-02f, 1.63881272e-01f,
  -8.82143970e-04f, 2.88378954e-01f, -1.82304457e-01f, -2.71715760e-01f, 1.09672263e-01f, -2.73675948e-01f, -2.74082392e-01f, 3.76374200e-02f, -1.57738626e-01f, 1.39596030e-01f,
  -4.64849807e-02f, -6.60325401e-03f, -1.58591047e-01f, 6.63294420e-02f, 4.71999794e-02f, 1.63133088e-02f, 9.08287615e-02f, 1.24277525e-01f, -1.17358595e-01f, 1.40962526e-02f,
  1.61244601e-01f, 1.83544215e-02f, 9.43566635e-02f, 3.57852615e-02f, -7.04104546e-03f, -1.47609100e-01f, -1.25568405e-01f, -1.87515140e-01f, -8.54958743e-02f, 1.14236344e-02f,
  2.45811809e-02f, -8.95348564e-02f, -4.48338017e-02f, 2.10301057e-02f, -1.10858053e-01f, -2.73629203e-02f, 1.24379158e-01f, -1.88407842e-02f, 3.13345753e-02f, 5.22471592e-02f,
  6.11108541e-02f, 1.32347703e-01f, 9.87116992e-02f, -4.07881700e-02f, 9.10848565e-03f, -8.29143897e-02f, -3.56146274e-03f, -1.01856580e-02f, 2.57555265e-02f, -2.43636705e-02f,
  -3.47725302e-02f, -1.36667937e-02f, 1.55076766e-02f, -1.30435852e-02f, 8.95109698e-02f, 4.26688530e-02f, 1.78971682e-02f, 1.78703330e-02f, -8.46582949e-02f, -1.40673310e-01f,
  1.97802018e-03f, 6.20533749e-02f, -5.96577711e-02f, 6.61267415e-02f, -2.52060574e-02f, -1.47489710e-02f, -1.22091302e-03f, -3.90696339e-02f, -8.46491680e-02f, 6.92897141e-02f,
  1.35289639e-01f, 3.55484575e-01f, -2.61778086e-02f, -4.11241055e-02f, -7.28140101e-02f, -3.37387845e-02f, 9.25495625e-02f, 2.50909869e-02f, 3.52192745e-02f, 1.12768576e-01f,
  -3.14375013e-02f, -1.25340344e-02f, 5.76029234e-02f, -1.18354693e-01f, -2.92873923e-02f, 6.50597140e-02f, 1.04646571e-01f, -7.18340464e-03f, 5.05212843e-02f, -6.84252158e-02f,
  -8.65363330e-02f, 1.00001350e-01f, 6.73724934e-02f, -6.62118942e-02f, -3.62602919e-02f, 3.59596349e-02f, -1.09963842e-01f, -7.03589916e-02f, 6.92057908e-02f, 1.41248861e-02f,
  -1.87028602e-01f, 1.84149116e-01f, -2.08683342e-01f, -1.84416428e-01f, 5.20775281e-03f, -1.16807424e-01f, -2.83064932e-01f, -1.03247024e-01f, 1.12801075e-01f, 3.34428966e-01f,
  -1.93834364e-01f, 4.79709208e-01f, -2.50258476e-01f, -3.25109005e-01f, -6.00150704e-01f, -3.71307313e-01f, -3.29234421e-01f, -2.19721049e-02f, -3.74784134e-02f, -5.48345074e-02f,
  -2.25268990e-01f, -4.93374646e-01f, -4.74703580e-01f, -1.58567995e-01f, -9.32395309e-02f, 2.25784212e-01f, -1.21892966e-01f, 2.21386161e-02f, 7.96778575e-02f, -1.32236674e-01f,
  -1.86203361e-01f, 8.18392485e-02f, 2.71165539e-02f, 1.32482070e-02f, -1.42328858e-01f, 1.49867997e-01f, 3.93753313e-02f, -4.64977464e-03f, -4.22523879e-02f, 1.33614421e-01f,
  1.12603836e-01f, -1.53673701e-02f, 3.26891840e-02f, -5.28314002e-02f, 1.21299669e-01f, 8.57911333e-02f, 2.76753027e-02f, 1.06959969e-01f, 9.38526466e-02f, -1.23471558e-01f,
  -1.57706022e-01f, 6.39430508e-02f, 1.54524744e-02f, 4.12701294e-02f, -1.41285926e-01f, -7.58909388e-03f, 8.23984146e-02f, -2.02513691e-02f, 1.61597162e-01f, 6.80634528e-02f,
  -2.63917800e-02f, 9.96648446e-02f, -4.97835092e-02f, -7.93080106e-02f, 3.21900360e-02f, 2.59206165e-03f, -4.36477847e-02f, -5.51937800e-03f, 5.07112928e-02f, 1.99176930e-02f,
  4.67725508e-02f, 6.96788579e-02f, -7.95190856e-02f, 9.31536257e-02f, -2.28597634e-02f, -7.17693754e-03f, -4.85073626e-02f, 7.19382241e-02f, -1.20672761e-02f, -7.94006512e-03f,
  2.39290390e-03f, -1.68877281e-02f, -5.64433001e-02f, -2.87232921e-02f, -8.36251080e-02f, -2.16784365e-02f, 3.83112766e-02f, 1.54236872e-02f, -1.11758806e-01f, 5.21232672e-02f,
  8.86821449e-02f, 1.99815437e-01f, 3.09133995e-02f, -1.70647781e-02f, 4.32943925e-02f, 9.24825482e-03f, -8.61668736e-02f, -7.06702322e-02f, 3.51327248e-02f, -7.40943989e-03f,
  4.92665358e-02f, 8.42033047e-03f, 1.00110583e-01f, -7.50434920e-02f, -6.39501140e-02f, 5.47934091e-04f, 1.20630758e-02f, 1.69394076e-01f, 2.62594242e-02f, 6.23302236e-02f,
  1.40744433e-01f, 1.17213102e-02f, -2.28032768e-02f, -5.67533560e-02f, 5.84795736e-02f, 6.97981715e-02f, 1.45049214e-01f, 9.40065235e-02f, 8.54076538e-03f, 1.07494984e-02f,
  5.11465728e-01f, -6.52473688e-01f, 1.88458592e-01f, 4.86908436e-01f, 3.20071191e-01f, 7.94685557e-02f, 3.02653730e-01f, -1.08553879e-01f, -1.29963756e-01f, -6.39339089e-01f,
  -9.83852595e-02f, 3.49426985e-01f, -3.32165062e-01f, -6.25083745e-02f, 1.59782380e-01f, -3.36687088e-01f, -9.24443677e-02f, -4.93191108e-02f, -2.81782169e-02f, -1.02815730e-02f,
  2.25957945e-01f, -1.81408629e-01f, 1.41508073e-01f, -3.69793326e-01f, 2.07947820e-01f, 1.88215561e-02f, -2.03576043e-01f, 7.63105080e-02f, 2.82858647e-02f, 1.60833180e-01f,
  -2.02878565e-02f, -5.07914983e-02f, 1.32603288e-01f, -9.59628969e-02f, -6.79703429e-02f, 6.72976598e-02f, 1.16359547e-01f, 1.68167233e-01f, 2.29113564e-01f, 4.57803309e-02f,
  4.75966819e-02f, 6.19503707e-02f, 7.91368857e-02f, 8.38371515e-02f, 4.57307845e-02f, 4.59326021e-02f, 6.41232505e-02f, 3.22644114e-02f, 4.02436927e-02f, 9.56043527e-02f,
  2.63911672e-02f, 9.18429345e-02f, 4.08766046e-02f, 5.85655216e-03f, 4.63121347e-02f, 8.05955380e-02f, 5.06456830e-02f, 9.70919803e-02f, 1.22932382e-02f, -1.06260795e-02f,
  -1.05847664e-01f, -1.00502536e-01f, 7.82401022e-03f, -2.03394033e-02f, 4.93243076e-02f, 8.33901316e-02f, -3.67102884e-02f, 5.71865141e-02f, 1.05984155e-02f, -3.37171921e-04f,
  5.79442037e-03f, 9.13514346e-02f, -8.47417861e-02f, -3.40594575e-02f, -1.06844500e-01f, 1.96805801e-02f, 1.08857386e-01f, 4.10997085e-02f, -9.03746113e-02f, 6.12141825e-02f,
  -1.60730211e-03f, 2.29330324e-02f, -5.31819984e-02f, 9.73027423e-02f, -6.76801577e-02f, 7.31431842e-02f, -4.65226872e-03f, -1.88093621e-03f, 6.52728043e-03f, 3.66290435e-02f,
  -5.89255512e-01f, -6.72600448e-01f, -1.49154425e-01f, 5.84987514e-02f, -9.75564644e-02f, -3.14357504e-02f, -2.30502225e-02f, -3.79338227e-02f, -1.95450023e-01f, -4.81613986e-02f,
  5.76980934e-02f, 1.55265421e-01f, -1.19508564e-01f, 7.89701119e-02f, -9.32116583e-02f, -4.32734713e-02f, -3.32499482e-03f, -1.05112001e-01f, 6.13141991e-03f, -7.51116052e-02f,
  2.94443108e-02f, -8.98863748e-02f, 1.06046781e-01f, 8.27023908e-02f, 8.94648675e-03f, -2.86881290e-02f, -1.39720067e-02f, -1.04835846e-01f, -1.15177054e-02f, -7.33536929e-02f,
  -7.30219245e-01f, 6.54653490e-01f, 3.00668448e-01f, -4.34556663e-01f, 2.72746831e-01f, 4.06459868e-02f, -2.15340331e-01f, 1.67725891e-01f, -1.04748897e-01f, -7.50887617e-02f,
  -1.33646682e-01f, 1.38972610e-01f, 1.77335963e-01f, -6.67330921e-02f, -2.62138814e-01f, 7.24454746e-02f, -3.07361603e-01f, -1.69106945e-01f, 1.43102646e-01f, -1.13903902e-01f,
  -1.43619105e-01f, -1.42336428e-01f, -2.55324468e-02f, 3.84962589e-01f, 3.38949375e-02f, -3.86978835e-02f, -4.49152559e-01f, 1.92559168e-01f, -1.11644477e-01f, 1.30107284e-01f,
  -1.40101030e-01f, -2.14546770e-01f, 3.06948088e-02f, 1.08187273e-01f, -3.42705287e-02f, -1.04976326e-01f, -1.16386034e-01f, 1.14624515e-01f, 4.25352342e-02f, 1.11157402e-01f,
  2.53900737e-02f, 1.00559287e-01f, 9.10432488e-02f, 1.80717215e-01f, -1.74101703e-02f, 3.89291979e-02f, 1.26812145e-01f, 5.70473932e-02f, 1.01013035e-01f, 1.52466938e-01f,
  1.92600876e-01f, 5.80544770e-02f, -1.31744772e-01f, -1.38419375e-01f, 2.36160327e-02f, 1.16004609e-02f, -7.44853020e-02f, 6.72589391e-02f, -1.66355371e-02f, -5.59949577e-02f,
  -8.15144628e-02f, 5.03897294e-03f, 2.75648572e-02f, 8.38355049e-02f, 4.62826565e-02f, 4.26581204e-02f, 3.08999028e-02f, -3.74152623e-02f, 1.52037675e-02f, -5.35811856e-02f,
  -1.23826295e-01f, -1.39462259e-02f, -2.81566195e-02f, -9.53804702e-02f, -9.21329111e-02f, -8.03489089e-02f, -2.84438990e-02f, 1.13110170e-02f, 1.70382373e-02f, -2.40793992e-02f,
  -4.45903093e-02f, -6.96397796e-02f, 6.25423118e-02f, -1.61519460e-02f, -3.92251238e-02f, 1.30744707e-02f, 7.16802105e-02f, -1.92288086e-02f, -5.34051843e-03f, -3.90921719e-02f,
  -5.01362622e-01f, -6.19187713e-01f, -3.85229588e-02f, 3.33011076e-02f, -6.50815200e-03f, 2.23053787e-02f, 1.71735100e-02f, -1.45908690e-03f, -3.83913182e-02f, 4.90165204e-02f,
  -1.51229938e-02f, -4.56083417e-02f, -1.21519983e-01f, -7.32696131e-02f, -5.42269722e-02f, -8.60399231e-02f, -1.65313095e-01f, -9.81063768e-02f, -1.57621875e-01f, 6.02770597e-03f,
  2.24114303e-02f, 3.12029049e-02f, -2.56618783e-02f, 5.80809787e-02f, -1.20616220e-01f, -1.39148697e-01f, -6.77324533e-02f, 5.40271541e-03f, 1.74165494e-03f, 3.89003158e-02f,
  -1.76651865e-01f, -3.44570093e-02f, -2.92356014e-01f, -2.16792926e-01f, -8.30744281e-02f, -5.51370382e-01f, -3.83239180e-01f, -2.24701986e-01f, 1.38704047e-01f, 1.53151572e-01f,
  -5.20447306e-02f, 1.05085500e-01f, 3.20427656e-01f, -3.42422068e-01f, -1.43721297e-01f, 2.18965843e-01f, -5.88407516e-01f, -2.23097250e-01f, 1.48346767e-01f, -3.11304510e-01f,
  -6.36737868e-02f, -1.66457877e-01f, -2.02271983e-01f, -6.25223368e-02f, -3.92484993e-01f, -3.79084237e-02f, 4.21916321e-02f, 1.12597376e-01f, -3.58619064e-01f, 8.33263993e-02f,
  -5.78045892e-03f, 2.82857507e-01f, -6.71541542e-02f, 7.73575436e-03f, -2.04838693e-01f, -8.67399648e-02f, -1.21337317e-01f, 7.92231634e-02f, 3.98290195e-02f, -3.31548825e-02f,
  1.49812438e-02f, 1.14298180e-01f, -7.99157768e-02f, 1.63569495e-01f, -7.46201202e-02f, 2.53404072e-03f, 5.06589711e-02f, -1.56848326e-01f, 1.64302550e-02f, -8.10077116e-02f,
  -7.33299404e-02f, -8.21020901e-02f, -1.21481307e-01f, 7.23138871e-03f, -7.82797188e-02f, -3.86039377e-03f, -6.57740831e-02f, -3.03776339e-02f, -7.97530934e-02f, -5.76482527e-02f,
  -4.26565111e-03f, -8.21524635e-02f, -5.13860732e-02f, -9.53318644e-03f, 1.27772894e-02f, -1.13189425e-02f, 4.91694771e-02f, 5.73326088e-02f, 1.41510309e-03f, 4.03052978e-02f,
  -2.33394187e-02f, 6.24681562e-02f, 2.09069662e-02f, -1.48834884e-01f, -4.54675891e-02f, 1.08757846e-01f, 1.42673301e-02f, 9.82073620e-02f, -1.44980893e-01f, -3.89153212e-02f,
  9.38583240e-02f, 2.30307877e-02f, 3.30575854e-02f, -5.42889088e-02f, -2.48179492e-02f, 9.62868854e-02f, -4.65194173e-02f, -1.20874522e-02f, 5.57444133e-02f, 1.83269642e-02f,
  -2.13602811e-01f, -7.12339506e-02f, 1.70070399e-02f, 8.96291882e-02f, -2.47310125e-03f, -6.91835806e-02f, -7.47081265e-02f, -1.13791965e-01f, -1.51739836e-01f, -2.20891442e-02f,
  -2.09644940e-02f, -2.55764872e-02f, -1.17877997e-01f, 3.54783540e-03f, 6.42229058e-03f, -1.00922212e-01f, -2.06444580e-02f, 6.02143966e-02f, -1.48728892e-01f, -5.60523607e-02f,
  -4.53266576e-02f, 2.79117003e-02f, 1.07285865e-01f, 1.10030239e-02f, -1.05194151e-02f, -5.13444878e-02f, -1.00624055e-01f, 6.55471012e-02f, -6.63291365e-02f, -9.68702137e-02f,
  2.17394516e-01f, -1.27325375e-02f, -4.72675040e-02f, -1.39735686e-02f, -1.67620987e-01f, -2.85046726e-01f, -4.02416497e-01f, -2.31927663e-01f, -1.21894134e-02f, -7.90755227e-02f,
  -3.58089298e-01f, 4.70663220e-01f, 2.01842621e-01f, -3.44186157e-01f, 3.85934234e-01f, 2.28689089e-01f, -1.47201821e-01f, 4.78864349e-02f, 1.62859857e-02f, -1.94895893e-01f,
  -2.33859420e-01f, -4.47094858e-01f, -1.02826394e-01f, -3.88419092e-01f, -3.36480021e-01f, -1.27333030e-01f, -1.62457556e-01f, -2.03963786e-01f, -2.39714622e-01f, -9.42741036e-02f,
  -1.40348017e-01f, -1.71452329e-01f, -6.93782046e-02f, 1.36651903e-01f, -6.96569830e-02f, 1.29163072e-01f, -6.14224076e-02f, 2.77492255e-02f, 8.02643523e-02f, 2.73209885e-02f,
  1.92500204e-01f, 7.47668967e-02f, -7.31866732e-02f, 6.23661838e-02f, -9.25793052e-02f, -1.09996498e-01f, 5.82965538e-02f, 5.01765124e-02f, 1.18899897e-01f, 8.27294141e-02f,
  1.36893123e-01f, 6.67697638e-02f, -1.71516150e-01f, 7.84940273e-02f, 2.06315611e-03f, -1.35230631e-01f, 7.90156275e-02f, 9.11433771e-02f, 1.03960894e-02f, 6.00873260e-03f,
  -2.32487102e-03f, 5.78902401e-02f, -4.96831797e-02f, -1.05205923e-01f, 1.94736682e-02f, -1.42599538e-01f, 7.06560463e-02f, -2.22329125e-02f, 1.11929856e-01f, 3.94848362e-02f,
  -6.10481538e-02f, -3.97675894e-02f, -1.38178514e-02f, 4.76099104e-02f, -3.73497345e-02f, 1.94344483e-02f, -3.44973318e-02f, 4.64940108e-02f, 5.32822199e-02f, 5.66096418e-02f,
  2.28367113e-02f, -2.15737410e-02f, 1.19289368e-01f, -4.17076200e-02f, -7.41324276e-02f, 8.93035308e-02f, -2.62317099e-02f, 1.02073010e-02f, -4.73634861e-02f, -2.39071418e-02f,
  3.64944749e-02f, -5.22248149e-02f, 1.68241430e-02f, -1.21174231e-02f, 7.28695020e-02f, -5.66026615e-03f, -6.60955086e-02f, 5.38126938e-02f, 6.03120625e-02f, -8.64478201e-02f,
  -8.59317631e-02f, 6.95491135e-02f, 2.68142559e-02f, -2.76482273e-02f, 1.12953112e-01f, -7.36653432e-03f, 6.46598041e-02f, 2.43561845e-02f, -4.02666479e-02f, -5.16222343e-02f,
  1.25269681e-01f, 7.99911469e-03f, 1.02001339e-01f, 1.66079272e-02f, 4.55512926e-02f, 3.33325677e-02f, 1.22745961e-01f, 7.06574023e-02f, 7.41026700e-02f, 9.20179486e-02f,
  -4.48453993e-01f, 3.79072547e-01f, 1.58631563e-01f, 2.39682302e-01f, -6.23579681e-01f, 1.02761291e-01f, 2.55167425e-01f, -2.00874746e-01f, 2.11093202e-01f, 4.88859773e-01f,
  -2.49602292e-02f, 2.99650252e-01f, 1.47878909e-02f, 3.50435853e-01f, -6.06610835e-01f, 2.14420229e-01f, 2.90558219e-01f, 2.89939493e-01f, -4.23487425e-02f, -5.87781034e-02f,
  -1.09240577e-01f, -1.65058538e-01f, 1.17355146e-01f, -1.65499315e-01f, -5.78145459e-02f, -8.24992880e-02f, -2.40734175e-01f, -2.97230422e-01f, 7.70128444e-02f, -1.68389261e-01f,
  -1.70594081e-01f, 6.58714771e-02f, 5.74900880e-02f, 8.87794197e-02f, -6.29729778e-02f, 2.81949826e-02f, -4.26804572e-02f, -9.43099558e-02f, -5.89966914e-03f, 2.83049531e-02f,
  1.17480837e-01f, -3.07411682e-02f, 4.59116884e-02f, -2.39271801e-02f, -5.92388734e-02f, -2.76923086e-02f, 3.57429050e-02f, 1.04889371e-01f, -2.33743880e-02f, 4.40252461e-02f,
  1.52627841e-01f, 9.30504575e-02f, 6.55090287e-02f, 1.11921795e-01f, -7.25167021e-02f, 6.62644580e-02f, 1.43906638e-01f, -4.95252684e-02f, 3.76081504e-02f, -6.61705658e-02f,
  5.04334010e-02f, -3.79111543e-02f, 5.34573235e-02f, -3.27612162e-02f, 3.79382484e-02f, -1.58209086e-03f, 1.27986491e-01f, -1.03893407e-01f, 8.59570131e-02f, -6.09603114e-02f,
  1.87933259e-02f, 4.72913776e-03f, -1.05250277e-01f, 1.01101108e-01f, 5.92442937e-02f, 8.70030820e-02f, 8.13202262e-02f, 1.14483247e-02f, 5.05957305e-02f, -7.51516894e-02f,
  1.33492565e-02f, -3.68507695e-03f, 2.23459862e-03f, -2.80781835e-02f, -1.54356789e-02f, -7.82909319e-02f, -1.04768407e-02f, 7.51656443e-02f, -4.06462885e-03f, -1.65133700e-01f,
  -3.49133730e-01f, -2.36059651e-01f, -2.73253024e-03f, 7.56106153e-02f, 5.78648001e-02f, -1.09510817e-01f, 2.48803981e-02f, -8.77184644e-02f, -1.64390668e-01f, -4.02464569e-02f,
  -8.60318728e-03f, 9.17573348e-02f, -6.35802671e-02f, -1.07019236e-02f, 8.21956620e-02f, 1.84607748e-02f, -2.61252802e-02f, 2.21175794e-02f, -6.68134540e-02f, -8.26941803e-02f,
  -1.23044336e-02f, -3.46608832e-02f, 4.61854087e-03f, 2.67128702e-02f, 1.01891950e-01f, 2.01601116e-03f, -1.13400102e-01f, 4.77346256e-02f, -1.05350763e-01f, 2.80687343e-02f,
  -3.35264862e-01f, -3.21503609e-01f, 9.13827270e-02f, -2.36347705e-01f, -1.08337045e-01f, 1.27070457e-01f, 5.45102119e-01f, -4.57148969e-01f, -5.26510537e-01f, -2.30798610e-02f,
  5.75032383e-02f, 6.35192767e-02f, 4.94557440e-01f, -9.37785953e-02f, 3.46077114e-01f, 2.66704679e-01f, -1.67578131e-01f, 2.03539766e-02f, -1.61440164e-01f, -1.50256008e-01f,
  -1.35165423e-01f, -5.15990667e-02f, 4.28989977e-01f, -2.73238331e-01f, -4.24810499e-02f, -2.15266645e-01f, 2.31841207e-01f, 1.87325433e-01f, -7.45145008e-02f, 9.19304937e-02f,
  -9.36245844e-02f, -4.03798997e-01f, -8.75314474e-02f, -1.09106667e-01f, -2.80553853e-04f, 1.60109811e-02f, 1.40734553e-01f, 2.85948575e-01f, -3.05256201e-03f, 3.46785970e-02f,
  6.11695927e-03f, -6.79120868e-02f, -2.08094388e-01f, 8.64428952e-02f, -7.69835636e-02f, -1.61890998e-01f, -9.23213437e-02f, -1.38052389e-01f, -4.90876958e-02f, 1.22862197e-01f,
  1.30217494e-02f, -8.60069320e-02f, -2.65509784e-02f, 3.53716351e-02f, 4.47067060e-02f, -1.40588447e-01f, 3.37791070e-02f, 1.66668713e-01f, -8.87466297e-02f, -8.56236964e-02f,
  -3.94764468e-02f, 6.29322156e-02f, 1.01708639e-02f, -2.01995298e-02f, 3.27991992e-02f, -3.83288860e-02f, 6.24650829e-02f, 2.75042243e-02f, 5.98314181e-02f, 9.06598195e-03f,
  -1.18877493e-01f, -4.42913324e-02f, -5.15224747e-02f, 2.04635188e-02f, 3.03895473e-02f, -7.15500638e-02f, 1.33603945e-01f, -2.62422729e-02f, -3.98679860e-02f, 5.30150272e-02f,
  4.48143706e-02f, -3.37649807e-02f, 2.39603017e-02f, -3.27319875e-02f, -6.40250444e-02f, 2.17452690e-01f, -1.12478144e-01f, 1.20749502e-02f, 7.89111573e-03f, 1.97517008e-01f,
  -7.06014708e-02f, -3.51518065e-01f, -9.45475399e-02f, -6.84375986e-02f, 4.42017391e-02f, -9.00394097e-02f, -6.48105964e-02f, -1.65195510e-01f, -3.26596349e-02f, -2.64969915e-02f,
  -5.75232320e-03f, -6.33161217e-02f, -5.47640882e-02f, 2.27942131e-02f, -4.89924550e-02f, -9.14024264e-02f, 4.00101990e-02f, 1.03575559e-02f, 1.78188011e-02f, -6.93441853e-02f,
  -1.81572679e-02f, 1.97106935e-02f, 4.01943810e-02f, -9.20262709e-02f, -5.81620708e-02f, 3.70603092e-02f, -1.61576971e-01f, -7.91131109e-02f, -5.35618365e-02f, -2.45567914e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  5.74393094e-01f, 7.25322187e-01f, 6.20147586e-01f, 4.16236132e-01f, -3.26384455e-02f, 2.57165313e-01f, 2.82619715e-01f, 2.36868113e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  6.72186539e-02f, 8.15375149e-02f, -2.37578228e-01f, -1.84812427e-01f, -1.95034370e-01f, -3.67232077e-02f, -3.06568504e-03f, 6.60270303e-02f, 3.77471268e-01f, -6.13225289e-02f,
  -2.12074012e-01f, -1.39270112e-01f, -2.68539302e-02f, 1.89411864e-01f, 9.40543264e-02f, 2.24420711e-01f, 3.80173981e-01f, -1.85015976e-01f, -1.38122588e-01f, 5.32947257e-02f,
  2.70455509e-01f, -1.35877609e-01f, 1.58032358e-01f, -2.88052827e-01f, -2.67721802e-01f, -1.38591051e-01f, 1.16299674e-01f, 4.10276145e-01f, 3.85140657e-01f, -9.12925601e-02f,
  -2.13498488e-01f, -2.14862362e-01f, -1.39881372e-01f, -3.03030796e-02f, 1.42111093e-01f, 9.41270441e-02f, 2.18948543e-01f, 1.09849833e-01f, 1.06002658e-03f, -1.21452540e-01f,
  -1.35451674e-01f, -6.27145171e-02f, 2.30655327e-01f, 1.17450841e-01f, 2.20587045e-01f, -3.95232618e-01f, 2.31396750e-01f, -2.11647693e-02f, 1.54463708e-01f, -1.88144147e-02f,
  3.74788009e-02f, 1.80385992e-01f, -2.69244075e-01f, -3.09756726e-01f, -4.95721549e-02f, -1.36968881e-01f, 2.69221127e-01f, -8.82353559e-02f, 1.94117665e-01f, -2.15590268e-01f,
  1.99397956e-03f, 3.17381233e-01f, 2.95860469e-01f, 8.38254094e-02f, 7.13775977e-02f, 2.44564325e-01f, 5.24925329e-02f, 1.33684352e-01f, 2.71744192e-01f, 1.60393238e-01f,
  9.18735638e-02f, -2.02755004e-01f, -4.83400643e-01f, 1.31894976e-01f, -9.66723561e-02f, -1.25275999e-01f, 1.23843908e-01f, 1.92831635e-01f, -1.23918958e-01f, -3.93510424e-02f,
  2.16528177e-02f, 3.91741276e-01f, 2.13063449e-01f, -3.74110281e-01f, -1.73258558e-02f, 2.39883482e-01f, -3.54872912e-01f, -2.30772376e-01f, 2.82065928e-01f, 7.91887417e-02f,
  -3.29437256e-01f, -2.91377574e-01f, -1.60237104e-02f, 1.58165976e-01f, -1.70807049e-01f, 2.12125340e-03f, -2.26880655e-01f, -1.80800602e-01f, 8.34252760e-02f, 9.35053602e-02f,
  2.82224249e-02f, 1.86328869e-02f, -1.92571282e-02f, 9.15690735e-02f, 1.95342466e-01f, 1.26145422e-01f, -3.27027477e-02f, 2.58890927e-01f, 7.68169761e-02f, -3.47366661e-01f,
  1.26842082e-01f, 1.04439870e-01f, -2.78062016e-01f, -3.37832391e-01f, -2.19835326e-01f, 2.36642644e-01f, -3.24920535e-01f, 7.64172077e-02f, 1.44898698e-01f, 2.79487431e-01f,
  -1.82057847e-03f, -2.42004335e-01f, 2.23271564e-01f, -1.33527890e-01f, -2.49458641e-01f, 7.69656850e-03f, 4.27289605e-01f, 2.22959206e-01f, -3.85800987e-01f, -2.74429291e-01f,
  -6.64670311e-04f, 1.69722289e-02f, -1.71252847e-01f, -7.11089149e-02f, 2.07974613e-02f, 3.27349544e-01f, 2.92720824e-01f, -4.50528152e-02f, -1.05130710e-01f, -7.81719685e-02f,
  -3.18151176e-01f, 2.38247856e-01f, 5.00084162e-01f, -1.21192209e-01f, -2.27484792e-01f, 7.63745084e-02f, -9.83351693e-02f, -4.69290853e-01f, 1.85622782e-01f, -5.70117198e-02f,
  2.30565056e-01f, -1.13002851e-03f, -1.95116028e-01f, 9.82914269e-02f, 1.50743529e-01f, 5.55275306e-02f, 6.69276342e-02f, -2.15710253e-01f, 2.67247766e-01f, -8.38879645e-02f,
  1.98850915e-01f, 2.57151455e-01f, 2.62151212e-02f, -4.58449982e-02f, 1.39297679e-01f, 1.05890349e-01f, -4.66503762e-02f, -3.60831529e-01f, -2.12277502e-01f, 1.38877898e-01f,
  -2.32508387e-02f, 8.22000429e-02f, 2.59034604e-01f, -2.97212332e-01f, -6.54490218e-02f, 3.50762844e-01f, 2.26408556e-01f, 1.54133037e-01f, 1.48928374e-01f, 3.96957278e-01f,
  -2.19851106e-01f, -8.41963217e-02f, -3.50270629e-01f, -2.16642439e-01f, 2.75370389e-01f, -9.15398896e-02f, -3.89927924e-02f, -8.94315168e-02f, -2.80401289e-01f, 4.60684262e-02f,
  -2.02987775e-01f, -7.48872012e-02f, -2.10020781e-01f, -1.81418672e-01f, 7.44593283e-03f, 1.01237804e-01f, -1.36391269e-02f, -1.60811469e-01f, 6.46460801e-02f, 2.06110597e-01f,
  1.64083362e-01f, -1.00294106e-01f, -8.53836611e-02f, -4.26839404e-02f, -3.05689663e-01f, 1.64144740e-01f, 1.30926818e-01f, -4.03151423e-01f, -3.27153265e-01f, 2.40212113e-01f,
  1.52220041e-01f, -3.61503333e-01f, 2.61005133e-01f, 1.36262596e-01f, 7.97147229e-02f, 2.25111559e-01f, -1.43299684e-01f, 1.91061199e-01f, -1.55564444e-02f, 5.02851047e-03f,
  -5.86310737e-02f, -2.03412920e-01f, 1.48938194e-01f, 1.27994314e-01f, 4.31252629e-01f, 9.33548659e-02f, -7.48514608e-02f, 8.11861679e-02f, -1.30514324e-01f, -6.69335073e-04f,
  -2.27997862e-02f, -3.87364924e-02f, -3.70685011e-01f, 9.23226848e-02f, -5.50573915e-02f, -1.75503809e-02f, 2.18516842e-01f, 2.27374047e-01f, -4.05898720e-01f, 2.54498333e-01f,
  2.16260567e-01f, -2.38224104e-01f, -1.71366587e-01f, 1.59757137e-01f, -9.63533744e-02f, 1.18277594e-01f, 5.76334000e-02f, -1.97344944e-01f, 2.04048827e-01f, -5.30971847e-02f,
  -4.08223897e-01f, 1.07118540e-01f, 2.02326477e-01f, 1.88120872e-01f, -2.47044399e-01f, -1.47788465e-01f, -1.51535600e-01f, 1.86151505e-01f, -2.20079303e-01f, -1.59833282e-01f,
  -1.14026606e-01f, 8.03475901e-02f, -3.74264531e-02f, -7.30234161e-02f, -1.15216756e-02f, 1.58500612e-01f, -1.92828909e-01f, -2.12910920e-01f, -2.23145097e-01f, 3.78889650e-01f,
  1.37227818e-01f, -5.31551167e-02f, 7.18757510e-02f, 4.99252528e-01f, 1.18302010e-01f, -5.88857114e-01f, 2.61132270e-01f, 2.43799850e-01f, -3.03455114e-01f, -2.50730097e-01f,
  6.47553056e-02f, -2.86486577e-02f, 3.96449752e-02f, -2.06248581e-01f, -3.08464080e-01f, -1.81403711e-01f, -2.48025119e-01f, -6.93482012e-02f, -2.49852642e-01f, -1.66344330e-01f,
  -4.35592681e-02f, -4.71547432e-02f, -1.34674702e-02f, 1.47631168e-01f, -5.71046434e-02f, 1.85631402e-02f, 2.62489200e-01f, -9.18823406e-02f, -5.16473055e-02f, -1.05607351e-02f,
  -3.40731069e-03f, -7.90176988e-02f, 3.94376993e-01f, 2.41577253e-02f, 1.84968650e-01f, -1.44560203e-01f, -1.51233450e-01f, -1.53704524e-01f, -5.00491522e-02f, -1.73632801e-01f,
  5.96674755e-02f, -3.19443941e-01f, -3.30000788e-01f, -2.11974874e-01f, 2.48352841e-01f, -8.49060789e-02f, 1.43364310e-01f, 2.43539840e-01f, 3.74461174e-01f, -1.77938312e-01f,
  1.13636374e-01f, 1.42788008e-01f, 1.65005699e-01f, 2.13125721e-01f, 1.98724031e-01f, 1.88939989e-01f, 3.71886194e-02f, -2.20925272e-01f, -1.93763137e-01f, 4.17935848e-02f,
  2.14460522e-01f, 2.38640770e-01f, 3.95558745e-01f, -3.80197138e-01f, -2.55761296e-01f, 2.35363692e-01f, -2.86028162e-02f, -2.09316030e-01f, -1.05937570e-01f, 3.74928027e-01f,
  -3.67279500e-01f, 1.31680742e-01f, -7.66635016e-02f, 8.57408270e-02f, 2.25419551e-01f, -7.04971924e-02f, -1.06516391e-01f, -1.97150156e-01f, -8.95076916e-02f, 2.27796659e-01f,
  -5.64177427e-03f, 2.34635875e-01f, -5.54696657e-02f, 6.80109262e-02f, 7.09342882e-02f, 2.26437256e-01f, 2.54608970e-02f, 1.98499411e-01f, 4.94409464e-02f, -4.70585637e-02f,
  2.19033346e-01f, -5.42038446e-03f, 1.54086754e-01f, 1.23938709e-01f, 2.75157928e-01f, -3.27313036e-01f, -2.69017756e-01f, 3.52287322e-01f, 1.10737488e-01f, -4.61266130e-01f,
  -4.73298073e-01f, 5.69877803e-01f, -8.74169245e-02f, 1.47489682e-01f, 6.27376437e-02f, 3.89826983e-01f, -1.42195791e-01f, -3.86846252e-02f, 2.29622364e-01f, -5.84578216e-02f,
  -3.31499316e-02f, 2.48855546e-01f, -1.07288480e-01f, 1.90403700e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.48567536e-01f, 4.30287808e-01f, -8.65802169e-02f, 3.39624852e-01f, 2.24574804e-01f, 4.59817439e-01f, 3.22530359e-01f, 2.43870646e-01f, 1.00573108e-01f, 5.35483479e-01f,
  -4.34635162e-01f, -2.56616790e-02f, 2.19339058e-02f, 9.56866682e-01f, -3.50135952e-01f, 7.70333886e-01f, 4.45377469e-01f, 2.29088038e-01f, -3.67802143e-01f, -9.75289166e-01f,
  3.62914294e-01f, 1.13993120e+00f, -9.37639713e-01f, -9.24352184e-03f, 1.63464531e-01f, 3.36442858e-01f, 4.95950133e-01f, -1.11735007e-02f, 2.79756248e-01f, 3.05475622e-01f,
  -8.23454678e-01f, 2.85621941e-01f, 4.11329120e-01f, 7.24650398e-02f, 1.16959944e-01f, 1.57169715e-01f, 1.24576636e-01f, 1.67955473e-01f, 3.43392581e-01f, 2.38654986e-01f,
  7.01262355e-01f, 1.32170364e-01f, 2.38789454e-01f, 3.75523031e-01f, -3.95572394e-01f, -4.61795837e-01f, -5.79138756e-01f, 4.25938815e-01f, -2.04104319e-01f, -7.53773391e-01f,
  -1.98700607e-01f, 6.46862864e-01f, 7.24943802e-02f, -7.01363571e-03f, 8.28261971e-02f, 5.20410120e-01f, -2.96069264e-01f, 6.99125946e-01f, 9.80384648e-01f, 1.00007486e+00f,
  -1.19639844e-01f, -2.99734697e-02f, -3.97406742e-02f, -7.93218464e-02f, 3.01878393e-01f, 6.38494968e-01f, 5.63769817e-01f, 6.06321767e-02f, 7.16359794e-01f, 4.76959795e-01f,
  2.71194994e-01f, -2.36688599e-01f, -2.56263971e-01f, -6.08509332e-02f, 6.01197839e-01f, 1.71995044e-01f, -3.95122260e-01f, -8.52653623e-01f, 2.08230749e-01f, -5.26559055e-01f,
  5.47429144e-01f, 2.75347739e-01f, 7.99707770e-01f, 5.46760559e-01f, -1.05338663e-01f, -1.04945278e+00f, 1.51596934e-01f, -6.69701219e-01f, 4.23192263e-01f, 6.03370488e-01f,
  1.37063026e-01f, -6.52938634e-02f, 5.98250143e-02f, 5.11774480e-01f, 1.81814909e-01f, -8.92276645e-01f, 4.72700357e-01f, 3.29341650e-01f, 2.54379183e-01f, 4.20391142e-01f,
  8.73884186e-02f, 1.04342304e-01f, 4.09995615e-01f, 2.87801445e-01f, -2.92517692e-01f, 4.76877898e-01f, 2.65454091e-02f, 9.46347937e-02f, 7.02686965e-01f, 2.85565287e-01f,
  -3.58342975e-01f, -6.28293231e-02f, 2.25793019e-01f, -1.11467846e-01f, -3.55160177e-01f, 4.91570979e-01f, -4.24100995e-01f, 1.05722733e-01f, 7.40228355e-01f, -3.05482000e-01f,
  6.38374090e-01f, 5.08829281e-02f, -8.20162296e-01f, 8.04558516e-01f, 8.64703596e-01f, 7.66926259e-02f, 2.60774791e-01f, 3.84059139e-02f, 2.74150409e-02f, 4.53632981e-01f,
  3.13833922e-01f, -3.24936509e-01f, 1.46476209e-01f, 3.20306331e-01f, 2.01670960e-01f, -2.32082427e-01f, 5.06866932e-01f, 4.74883676e-01f, 1.62158906e-01f, 4.70815040e-02f,
  1.32415374e-03f, -3.94498050e-01f, 8.32903028e-01f, 6.21167123e-01f, 7.06975460e-01f, 5.25822490e-02f, -3.01631689e-02f, 3.07067540e-02f, 2.19754636e-01f, -3.79258305e-01f,
  -6.10410213e-01f, -7.84563780e-01f, 4.41988051e-01f, -6.26618385e-01f, 9.57182705e-01f, -4.88910168e-01f, -4.91377972e-02f, 1.33898258e-01f, -4.26661670e-01f, -6.26454409e-03f,
  -1.69429567e-03f, 1.82022780e-01f, 3.88623387e-01f, 5.07178545e-01f, 5.52836657e-01f, 5.18605351e-01f, 1.55909911e-01f, 2.59789437e-01f, 2.43502289e-01f, 3.32874298e-01f,
  2.49834821e-01f, 5.80606818e-01f, 3.86977524e-01f, -4.91323262e-01f, -1.22635670e-01f, 2.48733699e-01f, -6.14639580e-01f, -3.34082514e-01f, -3.76451731e-01f, 2.56113946e-01f,
  -4.20847178e-01f, 3.37785721e-01f, -5.12547754e-02f, 4.91618186e-01f, 6.04389787e-01f, 4.79727872e-02f, 3.25360954e-01f, -1.37244398e-02f, -6.70594513e-01f, 3.67288262e-01f,
  8.77959549e-01f, 7.45472074e-01f, 5.50450683e-01f, 1.04505628e-01f, 4.08820897e-01f, 4.87267524e-01f, 2.17663378e-01f, 6.65493608e-02f, 3.22297931e-01f, 3.76937479e-01f,
  2.50482839e-03f, 6.78473651e-01f, 2.28074580e-01f, 2.48487607e-01f, 3.86479765e-01f, 4.91201341e-01f, 2.00800877e-02f, -1.28721297e-01f, -3.64819556e-01f, 3.57437581e-01f,
  -2.42938459e-01f, -3.31791610e-01f, -2.83204019e-01f, 6.76826537e-01f, 1.26725003e-01f, 2.47597530e-01f, 7.99951077e-01f, 3.68227065e-01f, -2.57534236e-01f, 6.09877825e-01f,
  5.16251206e-01f, -3.03330291e-02f, 4.52860326e-01f, 8.17976415e-01f, -2.04956517e-01f, 4.44544554e-01f, 3.18368316e-01f, -4.80787642e-02f, 6.27066195e-01f, 2.48627156e-01f,
  5.56838930e-01f, 2.39990994e-01f, 6.00703321e-02f, -3.92357446e-02f, 3.37508976e-01f, -2.41197441e-02f, -2.56107181e-01f, -3.00487101e-01f, -2.81810224e-01f, -8.25767159e-01f,
  1.01130642e-01f, 8.32830593e-02f, 2.72375822e-01f, -4.87174578e-02f, 5.43167949e-01f, -3.10446709e-01f, -1.11863986e-01f, 4.84200865e-01f, 1.96237549e-01f, 8.60123217e-01f,
  1.55372947e-01f, -8.04522336e-02f, 4.00932044e-01f, 8.73079419e-01f, -3.22251827e-01f, 7.63726950e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  5.06303191e-01f, 4.81393039e-01f, 6.28307283e-01f, 2.69329399e-01f, 7.48680532e-01f, 4.41512346e-01f, 3.82306188e-01f, 2.26853624e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -2.53576189e-01f, -2.01277673e-01f, 3.68832827e-01f, -5.10659516e-01f, 7.87451416e-02f, 3.85396749e-01f, 1.33919761e-01f, 3.28891516e-01f, 2.49383286e-01f, 2.98156023e-01f,
  -1.42961472e-01f, 2.02502280e-01f, -2.45389655e-01f, 2.75324076e-01f, 7.23239556e-02f, 1.86841622e-01f, 7.57378757e-01f, -3.87729138e-01f, 3.49402130e-01f, -4.19266880e-01f,
  -2.75231391e-01f, 4.57186908e-01f, 2.96697378e-01f, 6.96371794e-02f, -7.79141903e-01f, -7.33627081e-01f, -8.77996206e-01f, 2.58539498e-01f, -4.72742677e-01f, 6.23472631e-01f,
  5.52486956e-01f, -9.05881286e-01f, 3.93384129e-01f, 1.33270591e-01f, -6.81023955e-01f, 3.10171634e-01f, 2.31519207e-01f, -7.26680309e-02f, 3.25084440e-02f, -8.57372805e-02f,
  2.78937757e-01f, 2.94751883e-01f, 1.99208379e-01f, 3.78897607e-01f, -3.72102410e-01f, 4.74662304e-01f, 5.75176895e-01f, -2.99995422e-01f, -5.08147538e-01f, 5.66051662e-01f,
  -4.71152365e-01f, 6.13168776e-01f, 6.52747810e-01f, -1.96603239e-01f, 5.54282606e-01f, -7.85557151e-01f, 6.70050204e-01f, -9.16731000e-01f, -2.37068444e-01f, 1.06692262e-01f,
  1.36472076e-01f, -1.57409415e-01f, 4.30258960e-01f, -8.32206964e-01f, -2.69463181e-01f, 2.81383544e-01f, 4.23363239e-01f, 2.02144176e-01f, -2.58314963e-02f, 3.06840092e-01f,
  2.23676860e-01f, 8.45850930e-02f, -1.58379346e-01f, -2.39399076e-01f, 1.20050117e-01f, 2.91194588e-01f, 6.40640259e-01f, -1.04763590e-01f, -2.59506792e-01f, 5.77213541e-02f,
  7.17801869e-01f, 2.99413465e-02f, -2.15792075e-01f, -1.13737352e-01f, 5.58147430e-01f, 3.58015805e-01f, -4.04566884e-01f, 5.43211937e-01f, 9.16848063e-01f, -1.16784394e-01f,
  -8.99141133e-01f, -6.63729191e-01f, 5.84227920e-01f, -1.72843471e-01f, -7.27757692e-01f, -6.57427549e-01f, -2.98900772e-02f, -2.28050098e-01f, 3.46166402e-01f, -2.00076431e-01f,
  -2.29811534e-01f, -4.87686932e-01f, -3.85954440e-01f, 3.59249026e-01f, 1.55010253e-01f, -3.55977565e-02f, -3.47212970e-01f, 1.07309893e-01f, 5.39464235e-01f, -5.86439192e-01f,
  -5.79945564e-01f, -3.95475775e-01f, 5.88832617e-01f, -9.75658149e-02f, 4.81713802e-01f, 2.09061161e-01f, -6.23567522e-01f, -5.36602736e-01f, -6.56332791e-01f, -5.65435767e-01f,
  -4.15641665e-01f, 2.69494116e-01f, -5.39490432e-02f, 6.10618532e-01f, -3.07091266e-01f, -1.23944652e+00f, 4.97805625e-01f, 2.10936423e-02f, 2.89096773e-01f, 6.25613153e-01f,
  1.47597596e-01f, 5.25886595e-01f, 2.93196708e-01f, 5.33890605e-01f, 2.89994359e-01f, 2.14668617e-01f, -1.96123719e-01f, 5.18007092e-02f, 2.09482402e-01f, -4.97974426e-01f,
  4.21192646e-01f, -5.63601732e-01f, -5.79360545e-01f, 5.26869595e-01f, -4.65488732e-01f, -2.83651620e-01f, -1.03319190e-01f, 5.82594156e-01f, -3.18753839e-01f, -3.09652448e-01f,
  3.00032943e-01f, 6.37604117e-01f, 1.74418494e-01f, 6.58569634e-01f, -7.12583542e-01f, 2.93205410e-01f, -7.15139568e-01f, 1.37685895e-01f, 1.21471137e-01f, -4.74669904e-01f,
  -3.14064473e-01f, -4.42130804e-01f, 5.49311228e-02f, 1.63280204e-01f, -2.19773427e-01f, -1.15792297e-01f, -2.18927205e-01f, 9.45354179e-02f, 2.27453951e-02f, 4.38770391e-02f,
  -7.30980098e-01f, -1.21957203e-02f, -3.75584990e-01f, 1.29961520e-01f, 6.04043543e-01f, 3.55823845e-01f, -6.42807961e-01f, 5.20714521e-01f, -5.15066147e-01f, 3.70434999e-01f,
  -5.42040408e-01f, -2.26042956e-01f, 7.78000802e-03f, 5.21281362e-01f, -1.14270186e+00f, -5.54472923e-01f, 8.00531924e-01f, 5.51156282e-01f, -2.92172253e-01f, 2.76784241e-01f,
  -7.78642893e-02f, -4.91442718e-02f, -1.89200360e-02f, -1.78516060e-01f, -2.15850547e-01f, 1.33632466e-01f, 2.91865736e-01f, -3.37004364e-01f, -2.51994938e-01f, -2.14768783e-03f,
  2.62722880e-01f, -3.26589346e-01f, 2.20795855e-01f, -2.37560406e-01f, 4.18759108e-01f, 3.24725620e-02f, -5.63129783e-01f, 3.11929375e-01f, -3.86342764e-01f, 5.30321360e-01f,
  -3.98455441e-01f, -3.93953502e-01f, -6.27258658e-01f, 4.44967777e-01f, 3.99754524e-01f, 5.10011256e-01f, -6.03093684e-01f, 4.30901110e-01f, 5.11364639e-01f, -4.64071959e-01f,
  6.08456433e-01f, -8.02387223e-02f, -1.21937633e+00f, -9.71984923e-01f, -5.57375886e-02f, -2.14452609e-01f, -2.39288304e-02f, -2.85834372e-01f, -7.95036629e-02f, -1.32692009e-01f,
  -7.12453621e-03f, -5.82278848e-01f, -3.68498057e-01f, -3.10356505e-02f, 7.69602582e-02f, -2.05594927e-01f, 3.11601311e-01f, 5.02571106e-01f, 1.69357330e-01f, -2.76600301e-01f,
  -5.76730311e-01f, -3.43020976e-01f, -6.74956918e-01f, 2.87742078e-01f, 1.50988549e-01f, 3.90825212e-01f, 3.32993269e-01f, 4.88019258e-01f, 3.48600298e-01f, -2.62326390e-01f,
  1.41047716e-01f, 3.15781772e-01f, -5.86198747e-01f, -7.32756138e-01f, 1.43071031e-02f, 6.05930388e-01f, 3.73098642e-01f, 3.30322385e-01f, 2.38303334e-01f, 1.04053885e-01f,
  1.86373577e-01f, 2.89534181e-01f, 4.08262789e-01f, -1.75053179e-01f, 6.37189895e-02f, 1.39835894e-01f, 4.85178642e-02f, -2.99841613e-01f, 2.91143715e-01f, 1.43958569e-01f,
  3.32233608e-01f, -5.82686782e-01f, 3.45592976e-01f, 1.00782648e-01f, 5.28708518e-01f, -4.87648576e-01f, 4.46258873e-01f, 2.32087210e-01f, -6.98367834e-01f, -6.05311811e-01f,
  -5.84751308e-01f, -7.49713719e-01f, 8.46385598e-01f, -4.67706978e-01f, 4.37458396e-01f, -7.27204144e-01f, -5.96933365e-01f, 3.85470688e-01f, 3.10090836e-02f, -5.09234905e-01f,
  1.38475195e-01f, -4.67070222e-01f, -1.89705223e-01f, 5.08724675e-02f, 1.89313553e-02f, -1.31433621e-01f, 7.58318901e-02f, 1.50528133e-01f, -5.54983079e-01f, -4.55659717e-01f,
  -3.38936180e-01f, 1.66674420e-01f, -3.87103766e-01f, 2.39305533e-02f, -3.17438334e-01f, 2.90500820e-01f, -1.72809631e-01f, -2.88027376e-01f, -1.55117616e-01f, -1.14345156e-01f,
  -8.57388601e-02f, -2.60695755e-01f, 9.43330973e-02f, 1.09514140e-01f, -8.35680783e-01f, -8.09601784e-01f, 2.56034881e-01f, 4.69101965e-01f, -2.33628396e-02f, 4.79473174e-01f,
  -5.34443781e-02f, 1.00533359e-01f, -1.73330531e-01f, -1.01392195e-01f, 2.09080562e-01f, 2.31269434e-01f, -5.77708066e-01f, 1.16220310e-01f, 2.97118247e-01f, -2.42696449e-01f,
  3.24186742e-01f, 2.40451753e-01f, -6.14337385e-01f, -6.74266577e-01f, 6.06112778e-01f, -4.54704851e-01f, 2.70053715e-01f, -4.60683137e-01f, 3.94666821e-01f, -4.40581024e-01f,
  7.36764193e-01f, -6.90726519e-01f, -4.17374521e-01f, -3.24736416e-01f, 8.34337950e-01f, 6.90478161e-02f, -6.39102161e-02f, -9.46587920e-01f, -9.21280742e-01f, -2.36580119e-01f,
  1.39115930e-01f, 4.22163963e-01f, -9.28187966e-02f, 1.07026892e-02f, -2.40593225e-01f, 3.93893793e-02f, -4.25405413e-01f, -3.81413311e-01f, -1.20626681e-01f, -2.62558430e-01f,
  -3.54000151e-01f, 5.45839258e-02f, 2.82154351e-01f, 2.40079179e-01f, -2.17837989e-01f, 4.32825774e-01f, -3.81598115e-01f, 2.80319989e-01f, 5.44555485e-01f, -3.84138793e-01f,
  5.33159018e-01f, -2.95742035e-01f, -1.28233641e-01f, 4.60061789e-01f, -3.43270063e-01f, 2.88050592e-01f, -7.53061354e-01f, 5.86275399e-01f, 3.90817523e-01f, -6.14092886e-01f,
  -8.19787383e-01f, 3.27624679e-01f, -2.32333526e-01f, 3.27490538e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  2.00826019e-01f, 2.49110103e-01f, 1.25182480e-01f, 5.02126105e-02f, 3.93567309e-02f, -2.36056238e-01f, 1.96639970e-02f, -1.94252685e-01f, 3.01752895e-01f, -1.77319422e-01f,
  1.59165695e-01f, -1.11845359e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    