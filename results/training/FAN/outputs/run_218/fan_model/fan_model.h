/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.30844331e-01f, -2.38612384e-01f, -2.65160412e-01f, -3.26270372e-01f, 4.73632589e-02f, 6.02315627e-02f, -1.39754891e-01f, -3.52463163e-02f, -2.97158778e-01f, -4.20971774e-02f,
  1.34451658e-01f, -1.61163673e-01f, 1.09957755e-02f, -7.50868469e-02f, -1.73193410e-01f, -5.95594533e-02f, -1.37570918e-01f, -1.24212079e-01f, -9.90852043e-02f, -9.21461508e-02f,
  -1.86614081e-01f, 1.66239858e-01f, -1.26537085e-01f, 1.16791666e-01f, -5.98385409e-02f, -1.13773897e-01f, 9.57885683e-02f, 2.81295367e-02f, 1.05686724e-01f, 1.04058214e-01f,
  5.88673800e-02f, -8.49823281e-02f, -1.30047798e-02f, 1.09002758e-02f, -8.21020082e-03f, -5.06730145e-03f, 9.22252759e-02f, -8.05047806e-03f, 7.70028541e-03f, -5.95313534e-02f,
  9.57204215e-03f, -2.27554534e-02f, 2.61311978e-02f, 4.67438856e-03f, -5.50571305e-04f, -7.66258338e-04f, 2.51722662e-03f, -6.00690469e-02f, 1.76347084e-02f, 7.04881828e-03f,
  1.01205846e-02f, -2.60911938e-02f, -1.16932867e-02f, 1.65000819e-02f, -4.58028540e-03f, -2.71004438e-02f, -9.53150317e-02f, -3.67764682e-02f, 2.07536221e-02f, -9.18182917e-03f,
  9.10664350e-02f, -8.49374533e-02f, 1.50304129e-02f, -4.75330232e-03f, -6.13859147e-02f, 9.42023471e-02f, 2.38789991e-03f, 5.73298931e-02f, -6.78159669e-02f, -5.76607650e-03f,
  -6.16412461e-02f, 8.36878829e-03f, 1.53243132e-02f, -1.59824789e-02f, -4.73405607e-02f, -1.30171906e-02f, -8.52138475e-02f, 4.13465723e-02f, -7.83906691e-03f, 2.08859704e-02f,
  1.00407954e-02f, -6.72239531e-03f, -2.04537548e-02f, 6.26455322e-02f, 1.61116589e-02f, -4.37546037e-02f, -8.04794766e-03f, -3.03639341e-02f, 9.62916005e-04f, 3.04469969e-02f,
  6.50777295e-02f, -5.39659988e-03f, 6.15127338e-03f, 1.75770111e-02f, -4.56223637e-02f, 1.81388501e-02f, -1.47100249e-02f, -7.12465215e-03f, 4.49183956e-02f, 3.41497213e-02f,
  -8.56535695e-03f, 3.50678153e-03f, 2.73705088e-02f, -1.87880583e-02f, 4.20721620e-03f, -1.89521001e-04f, 3.25056934e-03f, 1.57234408e-02f, 6.19354025e-02f, -2.73362771e-02f,
  2.55402718e-02f, 4.39499319e-02f, -2.26895511e-02f, 3.59982997e-03f, 6.48555681e-02f, 1.78198516e-02f, 4.20770086e-02f, -1.81824807e-02f, 3.81541178e-02f, -4.84884419e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.53679353e-01f, -5.76658607e-01f, 1.02163315e-01f, 4.89011668e-02f, 3.22324842e-01f, 1.52722612e-01f, 3.56553853e-01f, -1.07197225e-01f, -1.08299211e-01f, -4.67505187e-01f,
  3.06625962e-02f, -2.03394324e-01f, 1.66308388e-01f, -2.80705929e-01f, 4.54632819e-01f, 4.89988662e-02f, -1.40661048e-02f, -5.03983386e-02f, 1.39721736e-01f, -4.15021777e-02f,
  1.74977154e-01f, 1.09056924e-02f, 1.33978829e-01f, -3.14086318e-01f, -9.23586786e-02f, -1.86005846e-01f, -2.39809640e-02f, 8.51017535e-02f, -2.12726578e-01f, 5.99888116e-02f,
  -2.51397118e-02f, -1.35195702e-01f, 1.25179188e-02f, -7.41342679e-02f, -3.22238728e-02f, -5.96947111e-02f, 4.25230786e-02f, 1.94529351e-02f, 6.67499527e-02f, -6.46427050e-02f,
  -9.67780575e-02f, 3.89054939e-02f, -1.00076988e-01f, -2.10991018e-02f, 3.38038206e-02f, 4.11049686e-02f, 3.17566693e-02f, -8.72183368e-02f, -4.38189171e-02f, -3.39910649e-02f,
  2.12158561e-02f, -2.83033941e-02f, 1.47560118e-02f, -9.84583199e-02f, -5.16019911e-02f, 1.31952493e-02f, -4.70405109e-02f, 8.21837112e-02f, -8.36520642e-03f, 2.73399223e-02f,
  4.13989052e-02f, -2.26944517e-02f, 2.01369859e-02f, 4.05247547e-02f, 2.91803088e-02f, 9.17994231e-02f, -4.50693443e-02f, 7.43537694e-02f, 5.29703349e-02f, 2.39279289e-02f,
  7.39835650e-02f, -5.27659617e-02f, -2.56504603e-02f, 2.46007740e-02f, -1.76473130e-02f, 2.24795975e-02f, -1.18268738e-02f, -8.32901895e-02f, -7.32422099e-02f, -2.49880813e-02f,
  -7.93972909e-02f, -3.03489547e-02f, -7.15247020e-02f, 9.39110965e-02f, -3.95821733e-03f, 1.88699588e-02f, -4.99615110e-02f, -3.08438148e-02f, 1.07173733e-01f, 9.27824900e-02f,
  -1.45047888e-01f, -4.24312383e-01f, -4.56862710e-02f, -1.89070124e-02f, -8.71693641e-02f, -1.16208754e-01f, -4.65476476e-02f, -3.18528600e-02f, -8.07061642e-02f, 4.56771478e-02f,
  -4.44399565e-02f, 1.98089033e-02f, -4.01026458e-02f, -9.66797769e-03f, -6.53044283e-02f, -7.39457980e-02f, -9.09062698e-02f, -8.75042304e-02f, -9.66636185e-03f, 2.36451663e-02f,
  -1.28159314e-01f, 6.11116085e-03f, 7.21363584e-03f, 2.04411354e-02f, -3.49899828e-02f, -3.88222784e-02f, -8.33045617e-02f, -7.61359558e-02f, -8.83217826e-02f, -1.85459778e-02f,
  -1.98426440e-01f, -7.18609393e-02f, 8.75281543e-02f, -2.10893497e-01f, -1.19103948e-02f, 2.23890275e-01f, 2.56449342e-01f, -1.64474040e-01f, -4.50139970e-01f, -1.14611089e-01f,
  6.79132938e-02f, -7.62435654e-03f, 2.06429854e-01f, -1.18310012e-01f, 1.48528963e-01f, 1.36388615e-01f, 5.93726784e-02f, 1.03468433e-01f, -1.72292441e-01f, -3.16509865e-02f,
  3.76984067e-02f, -1.89064801e-01f, 2.55728275e-01f, -4.92566973e-02f, -4.76725213e-03f, -1.39875608e-02f, -2.83469707e-02f, 1.17742009e-01f, 8.43257308e-02f, 2.25964421e-03f,
  -3.15192975e-02f, -1.50130600e-01f, 1.07454546e-02f, -3.65015492e-02f, 1.68083593e-01f, 2.77897846e-02f, 1.06860973e-01f, 1.02994755e-01f, 9.88510717e-03f, 5.05383536e-02f,
  -2.32123006e-02f, -1.04368508e-01f, -7.96560049e-02f, 3.91667560e-02f, -1.63507387e-01f, -8.42928961e-02f, 1.37861436e-02f, -1.93546992e-03f, -2.30432935e-02f, -2.41068602e-02f,
  5.23008518e-02f, -7.22515881e-02f, -8.56451243e-02f, -6.08704693e-04f, 3.46005633e-02f, -3.38233798e-03f, -4.44895998e-02f, 9.55805033e-02f, 5.04338508e-03f, -1.21738121e-01f,
  -5.41080199e-02f, 3.52944769e-02f, 3.30061391e-02f, 1.30056608e-02f, -4.21909317e-02f, -4.92421500e-02f, 5.46233281e-02f, 1.35413576e-02f, -5.10360189e-02f, 1.84212085e-02f,
  -4.79195006e-02f, -2.69353632e-02f, 4.03851345e-02f, -4.39134240e-02f, -5.27009070e-02f, 3.23895328e-02f, 2.51043029e-02f, 9.66305658e-02f, 3.86440344e-02f, 1.27596490e-03f,
  -9.49707534e-03f, -7.62078539e-02f, -6.24331906e-02f, 3.26969773e-02f, -2.44069956e-02f, -1.68012083e-02f, -2.86507402e-02f, -4.02870402e-02f, 4.77032959e-02f, 2.85906289e-02f,
  6.77362978e-02f, -1.07457653e-01f, 2.37443987e-02f, 4.06958610e-02f, 2.23868899e-02f, 1.19657703e-01f, -1.16323261e-02f, -7.29831755e-02f, -4.82804105e-02f, 2.87215170e-02f,
  2.52968743e-02f, 9.77047235e-02f, 1.56736113e-02f, -9.19887945e-02f, 5.42940907e-02f, -7.85103161e-03f, 8.16613734e-02f, -8.36562365e-02f, 9.84736905e-03f, -1.67925395e-02f,
  -8.41344893e-02f, -4.01022062e-02f, 1.82549693e-02f, -6.81106597e-02f, -9.69389454e-02f, -6.53713048e-02f, 7.69733638e-02f, -5.31877056e-02f, -9.84377041e-03f, -7.19312280e-02f,
  4.58095044e-01f, -4.19267893e-01f, -1.81326255e-01f, 1.20338872e-02f, 1.52574822e-01f, 1.97637782e-01f, 1.22186631e-01f, 1.36999441e-02f, -3.20062898e-02f, -1.09997712e-01f,
  -2.49832794e-02f, -3.26967314e-02f, -2.60372460e-01f, 2.49786116e-02f, 1.58363521e-01f, -7.91907981e-02f, 3.34751070e-03f, 1.26618519e-02f, -5.97476102e-02f, -1.34106293e-01f,
  1.33820713e-01f, 1.00528985e-01f, -7.87313748e-03f, 5.87000288e-02f, 4.09238860e-02f, -4.71053272e-02f, 8.80907252e-02f, -2.98249051e-02f, -2.61300895e-02f, 1.18921191e-01f,
  8.31958055e-02f, -2.64401734e-02f, -1.07402571e-01f, -5.76314963e-02f, -9.81158670e-03f, 2.03709081e-02f, 3.45629714e-02f, 1.04072556e-01f, 6.22105971e-03f, 2.11282969e-02f,
  -9.91224404e-03f, -6.33342192e-02f, 2.17457265e-02f, 1.85694024e-02f, -2.30237339e-02f, 2.31977794e-02f, -5.60192727e-02f, -2.99723074e-02f, -1.08492732e-01f, -5.20858727e-02f,
  -8.49882737e-02f, -1.03833199e-01f, -1.00632899e-01f, -7.20728487e-02f, -7.32623637e-02f, -8.43881369e-02f, -2.56602536e-03f, -6.63253712e-03f, 7.97982290e-02f, -5.63821234e-02f,
  -8.65747221e-04f, 1.16239097e-02f, 1.91317108e-02f, 7.13775679e-02f, -1.58683192e-02f, -6.61728391e-03f, 6.37214556e-02f, -4.76636328e-02f, 2.96025965e-02f, -5.77579997e-02f,
  -1.00304671e-02f, -1.57015622e-02f, 7.68811926e-02f, 1.63230263e-02f, -2.29430641e-03f, 3.30306701e-02f, 4.56421115e-02f, -5.18801296e-03f, -3.71062644e-02f, -4.79563065e-02f,
  7.55446181e-02f, 1.54411783e-02f, -7.40152523e-02f, 5.82769066e-02f, -3.75261642e-02f, 1.14227548e-01f, 5.73599488e-02f, -1.02393907e-02f, -3.91960368e-02f, -4.78211865e-02f,
  -1.63048938e-01f, -2.36190110e-01f, 3.40874717e-02f, 3.59054580e-02f, -3.38803083e-02f, -3.65729816e-02f, -3.47192623e-02f, 1.87050756e-02f, -6.89227832e-03f, 1.95719805e-02f,
  -4.85891774e-02f, 1.89824775e-02f, -9.17110313e-03f, 8.01492110e-02f, 3.72233801e-03f, -2.88706124e-02f, 3.23387943e-02f, 7.17372745e-02f, -1.43123623e-02f, -5.77678606e-02f,
  -2.88388375e-02f, 6.50040507e-02f, 6.28575459e-02f, -8.96311626e-02f, -4.06813109e-03f, -5.21985665e-02f, -5.77829778e-02f, 7.63952285e-02f, -4.01009284e-02f, 3.07366606e-02f,
  -1.08301431e-01f, -6.76299095e-01f, -2.49425635e-01f, -4.31851983e-01f, -5.70696853e-02f, -4.98880148e-01f, -5.03167868e-01f, -2.22642422e-01f, 4.38423753e-02f, -5.88727072e-02f,
  -1.83884531e-01f, 4.97968756e-02f, 1.43293202e-01f, -5.83518267e-01f, 7.96142370e-02f, 1.01906270e-01f, -4.76259649e-01f, -1.93244219e-01f, 1.54968575e-01f, -2.47842297e-01f,
  -5.51265553e-02f, -3.06352675e-01f, -3.10839981e-01f, -1.61556467e-01f, -3.93534273e-01f, 5.07158674e-02f, 2.95738131e-01f, 5.97962216e-02f, -1.58858329e-01f, -9.45474729e-02f,
  -1.30791426e-01f, 5.44813201e-02f, 6.34960532e-02f, 6.75385967e-02f, -9.30053070e-02f, 2.09397413e-02f, -1.87875833e-02f, 1.21776581e-01f, 2.87382938e-02f, -3.51166502e-02f,
  4.38953489e-02f, -1.13412486e-02f, -6.23489730e-02f, 3.10777174e-03f, -5.89926578e-02f, -1.28389765e-02f, 8.15985538e-03f, -4.74894419e-03f, -1.10541418e-01f, 4.35893482e-04f,
  -6.80840313e-02f, -4.84950505e-02f, -4.78316024e-02f, 2.15631202e-02f, -8.56601000e-02f, -3.52308415e-02f, -7.19923228e-02f, -2.13752985e-02f, -3.34350243e-02f, 2.53870003e-02f,
  -2.06198543e-02f, 1.22595564e-01f, -5.54506704e-02f, 6.93203807e-02f, -3.86216640e-02f, 7.55014317e-03f, -9.19582322e-03f, 1.49516631e-02f, 4.84150164e-02f, -9.56199970e-03f,
  -3.15278582e-02f, 1.64286774e-02f, 9.84993484e-03f, -3.32566686e-02f, -8.95480514e-02f, 2.77318433e-02f, -1.21382009e-02f, 7.62058049e-03f, -1.06739938e-01f, 4.28560488e-02f,
  8.79071951e-02f, 3.50371972e-02f, -4.25472744e-02f, 3.21258605e-02f, -2.22517159e-02f, 3.63302156e-02f, 3.12581770e-02f, 1.07794385e-02f, -2.51418017e-02f, -2.42698956e-02f,
  -2.66589820e-01f, -9.66770481e-03f, -3.17984484e-02f, -4.56962734e-03f, 3.56437080e-02f, 8.10012128e-03f, -5.52896559e-02f, -8.18025023e-02f, 1.95942745e-02f, -1.94500983e-02f,
  -4.07986119e-02f, 2.73515340e-02f, 1.40158506e-02f, 1.35339461e-02f, 1.21408869e-02f, -6.56051636e-02f, -1.67955656e-03f, -5.38597628e-03f, -3.78310308e-02f, -3.87021266e-02f,
  -1.40609145e-02f, 7.92307258e-02f, 1.31536806e-02f, -2.98654791e-02f, 1.02091292e-02f, 2.06639115e-02f, -7.91812688e-03f, -9.82323382e-03f, 1.33841839e-02f, -5.06742252e-03f,
  2.51832813e-01f, -3.45342234e-02f, 2.37254545e-01f, 2.17323273e-01f, -3.38844173e-02f, -2.87824925e-02f, 7.09673837e-02f, -1.30790055e-01f, -7.48684853e-02f, -9.96057037e-03f,
  -1.50347382e-01f, 3.47693682e-01f, -6.26826957e-02f, -6.00162372e-02f, 4.44671772e-02f, -1.47197515e-01f, -9.68024060e-02f, -2.63445005e-02f, -5.78501634e-02f, 1.45599600e-02f,
  -1.20681740e-01f, -1.40260428e-01f, 1.05656669e-01f, -1.10366233e-01f, 3.09817810e-02f, 8.08571279e-02f, -5.27491421e-02f, -3.32987420e-02f, 1.15790047e-01f, 1.69861522e-02f,
  -1.19389251e-01f, -6.01022132e-02f, 9.85852107e-02f, 1.06036656e-01f, -4.79759686e-02f, 1.42829612e-01f, 2.65996177e-02f, 9.03378054e-02f, 5.29967342e-03f, 4.31500748e-02f,
  9.52571109e-02f, 8.49027634e-02f, 6.87533990e-02f, -1.28449593e-03f, 1.37693603e-02f, -2.18643285e-02f, 4.04927135e-02f, 1.35274902e-01f, 3.74931246e-02f, 1.44172981e-01f,
  8.43276381e-02f, 1.15145288e-01f, 6.20780922e-02f, 4.72137518e-02f, 4.81542610e-02f, 9.57425311e-02f, 1.72462668e-02f, 3.99592854e-02f, 1.37702733e-01f, 2.17312984e-02f,
  1.00323580e-01f, -9.09302849e-03f, -7.51720592e-02f, -1.29784361e-01f, -4.61706929e-02f, 1.99407097e-02f, -2.01608776e-03f, -2.44015036e-03f, 2.96045803e-02f, -9.88480356e-03f,
  3.82830501e-02f, 2.46299896e-02f, 3.92224602e-02f, -2.03733798e-02f, 4.63807918e-02f, -6.96431771e-02f, 2.87482217e-02f, -3.02950349e-02f, -1.47244073e-02f, 9.90330204e-02f,
  -3.40315141e-02f, 9.80205163e-02f, -4.97208014e-02f, -9.90932807e-02f, -5.31684048e-02f, 8.17583222e-03f, 5.65659394e-03f, -3.21495309e-02f, -2.57999748e-02f, 1.11250751e-01f,
  -9.38781798e-02f, -2.25434214e-01f, -8.51835236e-02f, 6.89040497e-02f, 2.99354247e-03f, -1.62701346e-02f, -1.76843498e-02f, 1.90236717e-02f, -1.42395452e-01f, -2.20521521e-02f,
  7.08530322e-02f, 4.84725870e-02f, 4.45063971e-02f, 6.46044686e-02f, 3.07896361e-02f, -3.33653651e-02f, -2.82998085e-02f, 4.23991717e-02f, 5.82782514e-02f, 4.08284478e-02f,
  1.06462978e-01f, -3.19735729e-03f, 3.87383103e-02f, 9.39166453e-03f, 9.16081364e-04f, 1.62028726e-02f, 5.18559664e-02f, -1.19113978e-02f, 5.78627437e-02f, 1.75515413e-02f,
  5.46073854e-01f, -5.02368331e-01f, -1.09191030e-01f, 2.52783716e-01f, 3.09589744e-01f, 1.23919539e-01f, 1.98887333e-01f, -1.33103162e-01f, 1.19615689e-01f, -3.52390975e-01f,
  -6.39733626e-03f, -5.41354977e-02f, -1.13955915e-01f, 1.24672577e-01f, 3.81641179e-01f, -9.59210023e-02f, 1.60851330e-01f, 9.35840532e-02f, -6.19982593e-02f, -5.55232838e-02f,
  -5.65117039e-03f, 1.06259093e-01f, -8.37459788e-03f, -5.40873967e-02f, 1.16352335e-01f, -1.34051695e-01f, 7.77995959e-02f, -3.01377159e-02f, -1.16791278e-01f, 1.03181712e-01f,
  7.91762546e-02f, -8.22260380e-02f, -4.48151939e-02f, 6.93470379e-03f, -9.71815512e-02f, -4.81098481e-02f, 2.05848995e-03f, 4.28710580e-02f, 5.09708039e-02f, 1.30712218e-03f,
  -5.58039024e-02f, 3.05574816e-02f, -3.91461188e-03f, 1.09680921e-01f, 3.90816443e-02f, -8.51588324e-02f, -6.81879446e-02f, 9.28665549e-02f, -5.03256842e-02f, -1.13328606e-01f,
  -7.56104067e-02f, -1.00830533e-01f, 9.71745700e-02f, -3.52125466e-02f, 9.10345316e-02f, 5.77816926e-02f, 8.69567227e-03f, -8.76985192e-02f, -1.18394263e-01f, 4.29558903e-02f,
  3.21193086e-03f, 2.85204444e-02f, -1.41356243e-02f, 6.51241466e-02f, 6.40059933e-02f, 3.61090619e-03f, 5.79998828e-04f, -4.37951013e-02f, 2.16879696e-03f, 3.40036191e-02f,
  -3.13424505e-02f, 3.76146547e-02f, -1.62571799e-02f, 2.55869236e-02f, 1.19001390e-02f, -3.07647940e-02f, -5.15559986e-02f, 2.96642520e-02f, 4.68395017e-02f, 1.23194642e-02f,
  6.85497979e-03f, 4.19818722e-02f, 4.70767918e-05f, -4.15929332e-02f, 6.75100461e-02f, 4.07592356e-02f, -1.67034753e-02f, 5.53885289e-02f, 1.01869563e-02f, -5.63728362e-02f,
  -1.10970825e-01f, -1.63963601e-01f, -6.24180697e-02f, 8.45747218e-02f, 1.16468770e-02f, 4.12247516e-02f, 1.38796791e-01f, -6.51626661e-02f, -3.35506047e-04f, -6.78861793e-03f,
  -5.25537729e-02f, 6.81641772e-02f, -1.74242351e-02f, 8.32858309e-02f, 1.81026421e-02f, -3.94488499e-03f, 2.31886059e-02f, -5.13953622e-03f, -6.78052753e-02f, -1.31912500e-01f,
  7.00455233e-02f, 3.90757769e-02f, 7.83733502e-02f, 2.92972811e-02f, -2.15242747e-02f, -2.04745363e-02f, 7.82295242e-02f, 1.45819755e-02f, -4.05637994e-02f, 5.39590791e-03f,
  2.62564391e-01f, -1.02842949e-01f, -8.30966681e-02f, 3.25297832e-01f, 4.88784686e-02f, -3.12891960e-01f, -3.40088010e-01f, 2.57805586e-01f, 1.93177506e-01f, -2.42729008e-01f,
  2.03890339e-01f, -7.33862221e-02f, -1.09905064e-01f, 3.97883713e-01f, 3.86766464e-01f, -5.62891513e-02f, 3.08100373e-01f, 2.56569013e-02f, 1.69039130e-01f, 1.79629877e-01f,
  3.36907417e-01f, 3.17554265e-01f, 1.81287676e-01f, 1.08091690e-01f, -6.34321123e-02f, 1.01435028e-01f, 1.17845170e-01f, -2.99851686e-01f, 2.08256707e-01f, -9.20995399e-02f,
  -8.80010724e-02f, 1.55649662e-01f, 3.80946323e-02f, 2.94857491e-02f, -1.27045259e-01f, -2.05017626e-01f, -1.15112990e-01f, -1.45336732e-01f, 2.67759413e-02f, 2.91989576e-02f,
  -7.89036974e-02f, 2.57547423e-02f, -3.78034962e-03f, 7.07731470e-02f, -1.57111418e-02f, -4.85882759e-02f, 7.44611397e-02f, -1.00006439e-01f, 3.38304266e-02f, 9.30484012e-02f,
  1.15379607e-02f, -1.85478455e-03f, -1.30619723e-02f, -9.14805606e-02f, 3.27418000e-02f, 5.91771305e-02f, -9.71277654e-02f, -1.04990289e-01f, 2.79340777e-03f, 8.65885094e-02f,
  3.71023603e-02f, -1.49852529e-01f, -7.35437497e-02f, 7.03030601e-02f, -3.52815539e-02f, 7.45270476e-02f, -3.77052161e-03f, -3.60352620e-02f, -2.53707077e-02f, -2.03991719e-02f,
  -3.52840349e-02f, 8.14437959e-03f, 9.11957249e-02f, -8.60356912e-02f, -7.11964518e-02f, -5.86394183e-02f, -2.35849544e-02f, 1.73187964e-02f, 5.10922596e-02f, 1.28698170e-01f,
  -8.45649764e-02f, 6.50309259e-03f, -6.35560751e-02f, 2.34487746e-02f, -3.34861949e-02f, 5.69815375e-02f, 7.31468350e-02f, -1.83709431e-02f, 8.38009082e-03f, -2.47885031e-03f,
  3.91281359e-02f, 5.95410317e-02f, 5.51908463e-02f, -1.67765766e-02f, -6.45105839e-02f, -1.17356665e-01f, -9.64284688e-02f, 1.01488993e-01f, -6.98836967e-02f, 3.72144952e-02f,
  4.34063338e-02f, 1.66146234e-02f, -3.46962996e-02f, 3.63329835e-02f, 2.39848229e-03f, 3.04795969e-02f, 8.41407804e-04f, -8.36342759e-03f, 3.67729440e-02f, 6.82888478e-02f,
  -1.21199243e-01f, -1.34733409e-01f, -7.89925009e-02f, -5.33307418e-02f, 2.72106398e-02f, -9.49114412e-02f, 5.27397878e-02f, 9.85998288e-03f, -3.48968506e-02f, 1.96506474e-02f,
  -8.49780381e-01f, -3.97678502e-02f, -3.11484873e-01f, -3.06492418e-01f, -1.61775246e-01f, -3.27607810e-01f, -8.63810405e-02f, -1.98753297e-01f, -1.59596518e-01f, -1.86810661e-02f,
  -6.11410514e-02f, -1.73450261e-01f, 3.16833198e-01f, 7.36910701e-02f, -7.68998936e-02f, 2.54977852e-01f, -2.36463770e-01f, -1.54285863e-01f, 1.34813696e-01f, -2.28625953e-01f,
  -4.70915176e-02f, -1.50664181e-01f, 9.95670557e-02f, 8.04966614e-02f, -2.33508095e-01f, -5.76570742e-02f, -1.97170656e-02f, 8.23866576e-02f, -1.10352136e-01f, -3.24157625e-02f,
  -2.47950464e-01f, -3.54495466e-01f, -2.20425159e-01f, -5.15481941e-02f, -1.79955512e-01f, -1.80071350e-02f, -7.55086616e-02f, 5.89912347e-02f, -2.86670756e-02f, -5.27223721e-02f,
  -4.63107303e-02f, 3.95435374e-03f, -3.04152705e-02f, 1.54587952e-03f, -7.22436160e-02f, -6.35096133e-02f, -4.26803641e-02f, 8.83034780e-04f, 1.52543271e-02f, 4.97734845e-02f,
  1.24812638e-02f, -3.39460187e-02f, -6.95440844e-02f, -7.49819959e-03f, 3.40966210e-02f, -3.61977257e-02f, 1.43502350e-03f, 1.16696700e-01f, -9.13503543e-02f, -8.00082758e-02f,
  -3.83889936e-02f, -1.85791086e-02f, -9.69906803e-03f, -3.03900111e-02f, 2.48088930e-02f, 1.64316706e-02f, -6.11483641e-02f, -3.23189273e-02f, -1.83859915e-02f, 1.07996883e-02f,
  -5.05923703e-02f, -5.95875047e-02f, -5.49139753e-02f, -5.15908375e-02f, -1.94684323e-02f, -9.72818956e-03f, 3.52091640e-02f, -6.66990280e-02f, 3.80717590e-02f, -7.78549584e-03f,
  -4.86940257e-02f, -1.29642140e-03f, 6.72997311e-02f, 7.50176935e-03f, -3.80041413e-02f, 1.38180718e-01f, 2.43874285e-02f, 8.38244110e-02f, 2.47317478e-02f, -2.23769713e-02f,
  -5.28315485e-01f, -4.87984955e-01f, 1.52018601e-02f, -1.36264324e-01f, -2.48943828e-02f, -1.20195247e-01f, 1.04856929e-02f, -7.99455270e-02f, -5.93553334e-02f, -3.74188647e-02f,
  -1.15419254e-01f, -3.65209505e-02f, -1.14300691e-01f, 3.19142714e-02f, 7.52770379e-02f, 8.09802953e-03f, -3.07090133e-02f, -4.14915830e-02f, -1.16542414e-01f, -9.11089312e-03f,
  -5.64332260e-03f, -2.08658930e-02f, 9.33672264e-02f, 1.21207181e-02f, -1.19689666e-02f, -1.00288717e-02f, -7.96758756e-02f, -3.74268144e-02f, -1.09378174e-01f, 3.12972963e-02f,
  1.31530598e-01f, -3.61252055e-02f, -4.96543229e-01f, 4.28425819e-02f, 1.51097387e-01f, 3.57132614e-01f, 1.92480668e-01f, -1.22849785e-01f, -2.68328577e-01f, 3.44982654e-01f,
  2.24205136e-01f, -9.20097306e-02f, -3.57364938e-02f, 4.53716218e-01f, 1.85508281e-01f, 4.91201207e-02f, 4.20069456e-01f, 2.86211789e-01f, -1.28467456e-01f, 8.19716379e-02f,
  -2.89017856e-02f, 5.47882199e-01f, -1.36542052e-01f, 7.70287067e-02f, 1.75537795e-01f, -2.68237680e-01f, 1.48564905e-01f, -2.14797437e-01f, 1.71145633e-01f, 7.94462562e-02f,
  1.19957037e-01f, 1.07549429e-02f, -1.85404401e-02f, -3.67257111e-02f, 3.29894088e-02f, 1.07304677e-01f, -2.83061173e-02f, -4.57457751e-02f, -1.68956995e-01f, -9.93313827e-03f,
  -3.20913307e-02f, 4.28888053e-02f, -8.31510592e-03f, -3.43064815e-02f, -4.40862216e-02f, -6.41167015e-02f, 4.23365971e-03f, 2.88344314e-03f, -4.80752140e-02f, -1.98173281e-02f,
  -7.75607526e-02f, -2.38510687e-02f, 2.46915147e-02f, 4.03806418e-02f, -1.05366968e-01f, 1.17972791e-01f, 8.38736296e-02f, 1.21148769e-02f, -7.37955421e-03f, 8.34669471e-02f,
  2.64859963e-02f, 2.06845310e-02f, 4.74245995e-02f, 2.92638168e-02f, 2.45496966e-02f, -6.09072708e-02f, 3.78321558e-02f, -2.61329301e-02f, -3.35162468e-02f, 1.39593899e-01f,
  2.81990729e-02f, -8.13863985e-03f, 2.26409175e-02f, 1.06123246e-01f, 5.92152663e-02f, 1.05064116e-01f, 4.76306528e-02f, 3.15969922e-02f, -5.12372218e-02f, -2.96050254e-02f,
  5.07428832e-02f, -3.98023613e-02f, -3.16598406e-03f, -4.32085842e-02f, 4.39332649e-02f, -4.90173176e-02f, 6.75807670e-02f, -9.31303799e-02f, -6.81928247e-02f, 2.68942472e-02f,
  4.10137698e-03f, 3.41599695e-02f, -6.79921880e-02f, -7.38369226e-02f, 3.36101241e-02f, 1.76580846e-01f, 2.57698400e-03f, -1.95585880e-02f, -9.63390023e-02f, 2.08511166e-02f,
  7.93696120e-02f, -1.98544171e-02f, 3.23371142e-02f, -4.23472077e-02f, -7.95438886e-02f, 1.09785311e-01f, 5.90160638e-02f, 2.05705035e-02f, 6.02089353e-02f, 2.40186807e-02f,
  6.12269603e-02f, 8.77733168e-04f, 3.08094919e-02f, 7.63383112e-04f, -4.22152970e-03f, -5.52120842e-02f, -5.64160272e-02f, -9.79645103e-02f, -2.22595427e-02f, -8.15549269e-02f,
  2.10010201e-01f, -2.31130645e-01f, -2.97545254e-01f, 9.50921997e-02f, 2.45181218e-01f, 2.60826468e-01f, 4.86152247e-02f, 3.93533185e-02f, 3.97492163e-02f, -2.19811097e-01f,
  7.96079561e-02f, -2.35419899e-01f, -2.51041591e-01f, 8.72294605e-02f, 2.87779450e-01f, -1.71384156e-01f, 1.70658514e-01f, -5.37591502e-02f, -8.92388374e-02f, -1.27377421e-01f,
  5.03919683e-02f, 1.25373989e-01f, -1.71459377e-01f, 4.72031571e-02f, 6.24467321e-02f, -5.28571010e-02f, 1.01055682e-01f, -8.85522515e-02f, 1.03754960e-01f, 6.03296980e-02f,
  5.94379380e-02f, -1.05235003e-01f, -4.77849282e-02f, -1.22236378e-01f, 5.98561019e-02f, 1.10964164e-01f, -5.58795519e-02f, 9.71988589e-03f, 8.21347013e-02f, -3.90755236e-02f,
  -1.21859892e-03f, 1.30694462e-02f, 3.87685113e-02f, 3.90245356e-02f, 8.60540122e-02f, 2.18604431e-02f, -3.55656230e-04f, -5.36526963e-02f, 2.13953927e-02f, 5.66434227e-02f,
  -6.97702318e-02f, -2.39634863e-03f, 1.93472877e-02f, 2.97485571e-02f, -1.26989216e-01f, 6.16802797e-02f, -8.00698176e-02f, -5.43839224e-02f, 6.98238909e-02f, -4.18318436e-02f,
  -5.36074899e-02f, 3.08110509e-02f, -9.71202999e-02f, -2.99066640e-02f, 9.30297151e-02f, 8.17865804e-02f, 7.06812888e-02f, -9.31088254e-02f, -5.34439795e-02f, -4.34556417e-02f,
  2.04411112e-02f, 5.67946509e-02f, -2.12234352e-02f, -3.08140796e-02f, -2.24031303e-02f, 9.35170949e-02f, 3.97174731e-02f, -1.07213929e-01f, -8.33744854e-02f, 1.20360613e-01f,
  6.25523273e-03f, 7.37135559e-02f, 4.80849034e-04f, 4.09876816e-02f, 3.08962800e-02f, -2.95338351e-02f, -2.29762588e-02f, -2.20713932e-02f, -8.06334913e-02f, 2.07418520e-02f,
  1.16474796e-02f, -1.56598717e-01f, -9.51419547e-02f, 1.90638006e-02f, 7.06946850e-02f, 6.06271178e-02f, 1.05488338e-02f, 2.36380193e-02f, 3.38075566e-03f, 6.28742129e-02f,
  8.70191213e-03f, 3.87857556e-02f, 2.39699101e-03f, -5.60908131e-02f, 7.96526074e-02f, -1.19658925e-01f, -1.27351671e-01f, -8.57656077e-02f, 5.77261730e-04f, 1.37916915e-02f,
  -6.23401888e-02f, 2.29410343e-02f, -7.97916576e-02f, 4.00238205e-03f, 2.46718954e-02f, -3.17257233e-02f, 6.48472682e-02f, -1.43517643e-01f, 6.64979294e-02f, -7.97024369e-02f,
  -1.85890287e-01f, 1.34480640e-01f, -9.14077163e-02f, 6.49865121e-02f, -1.82043552e-01f, 2.72204608e-01f, 3.75337034e-01f, -6.21482125e-03f, 2.61065274e-01f, 2.71329671e-01f,
  1.87242225e-01f, 4.87120226e-02f, 2.14800090e-01f, 3.38296205e-01f, 2.15491816e-01f, 3.73276353e-01f, 2.67809868e-01f, 2.07383215e-01f, -5.67409359e-02f, -7.59370625e-02f,
  -4.25837561e-02f, 1.95536688e-01f, 6.26091212e-02f, -1.42402500e-01f, -4.31947894e-02f, -1.52633786e-01f, 4.59154882e-02f, -8.71241316e-02f, -3.12658139e-02f, 2.26644780e-02f,
  -3.60559449e-02f, -4.29688282e-02f, -1.05064392e-01f, -8.83473456e-02f, -2.80252174e-02f, -9.36260968e-02f, 4.11179066e-02f, -9.91550181e-03f, -4.98087294e-02f, -3.91026363e-02f,
  3.30031291e-02f, -1.47724245e-02f, 4.26733606e-02f, 4.20920514e-02f, -1.80975609e-02f, -4.80087548e-02f, -7.60044828e-02f, -1.42103713e-02f, 2.02458464e-02f, -1.22367926e-01f,
  3.57134230e-02f, 1.29605848e-02f, -3.36564369e-02f, 2.92453095e-02f, 2.86421198e-02f, 9.22410749e-03f, 6.19410239e-02f, -7.11569861e-02f, -9.64663252e-02f, 4.02294361e-04f,
  -7.07821250e-02f, 7.96239227e-02f, -5.88057609e-03f, -1.11379690e-01f, -8.29803292e-03f, -2.26716809e-02f, -7.33128656e-03f, -9.76414457e-02f, 2.54188478e-02f, -4.26451601e-02f,
  -4.83484156e-02f, 1.12877116e-02f, -1.68320052e-02f, -1.94595847e-02f, 2.15817839e-02f, -2.26066932e-02f, -3.06266192e-02f, 3.89932655e-02f, 6.18639961e-02f, 5.51114008e-02f,
  1.36658028e-02f, 6.96628466e-02f, 7.99322724e-02f, 5.09238541e-02f, -9.33184195e-03f, 6.94743767e-02f, -3.32685374e-02f, -3.70821767e-02f, 5.72282523e-02f, 3.81065905e-02f,
  -3.28747816e-02f, -2.95175258e-02f, -9.34010148e-02f, -4.07897867e-02f, 4.28505018e-02f, -7.58468956e-02f, 2.79871933e-02f, -4.35742103e-02f, 1.22354090e-01f, -7.39713982e-02f,
  -2.54371073e-02f, 4.23199274e-02f, -1.62489377e-02f, 5.46366945e-02f, -3.95963602e-02f, -2.67152060e-02f, 2.92044450e-02f, 6.48420155e-02f, 2.37696862e-04f, -3.26502398e-02f,
  -4.99712192e-02f, -1.05055533e-02f, 1.06310114e-01f, -7.70960599e-02f, 5.40510826e-02f, 5.74430339e-02f, -7.13375304e-03f, -3.04465201e-02f, -7.82581568e-02f, 9.53412428e-03f,
  3.05892974e-01f, -4.52514179e-02f, 1.06859095e-01f, 4.23301935e-01f, 1.05168685e-01f, -2.16699228e-01f, -1.16825633e-01f, 2.64269024e-01f, 1.56650156e-01f, -6.70778602e-02f,
  1.01967461e-01f, -1.97552219e-01f, -5.51315434e-02f, 1.25562206e-01f, 1.98913038e-01f, -9.84404683e-02f, 8.58712271e-02f, -5.25958650e-02f, 6.64424524e-02f, 2.31848329e-01f,
  2.43488953e-01f, 1.04852311e-01f, 1.19247414e-01f, 6.17659055e-02f, 4.78044748e-02f, 1.48010731e-01f, 1.68923765e-01f, -1.24979028e-02f, 1.03173345e-01f, -1.67589054e-01f,
  -1.98421627e-01f, -8.39190278e-03f, 2.71769594e-02f, -7.17273653e-02f, 1.26709655e-01f, 7.17420951e-02f, -6.68547750e-02f, -1.14386372e-01f, -4.35249247e-02f, -1.00080833e-01f,
  -3.98422480e-02f, -5.05028032e-02f, 1.06041633e-01f, 3.45756784e-02f, -2.91161016e-02f, -2.00019907e-02f, 1.34390481e-02f, 1.60526738e-01f, -6.32663316e-04f, -2.93997694e-02f,
  3.60587388e-02f, -7.37872049e-02f, 3.02655604e-02f, -8.57531801e-02f, 5.23773469e-02f, -5.09001352e-02f, -9.75297093e-02f, 3.47445160e-02f, 2.23125499e-02f, -1.54671464e-02f,
  -4.53781299e-02f, 1.20361699e-02f, -1.19398758e-01f, -5.71177900e-02f, -5.53760342e-02f, 1.14298966e-02f, 2.29811650e-02f, -1.58370510e-02f, -3.56895775e-02f, 5.13321906e-02f,
  4.82226387e-02f, 6.04445636e-02f, 4.68014814e-02f, -1.85278170e-02f, 2.01474987e-02f, 4.64383792e-03f, -3.29087377e-02f, 2.12215707e-02f, 8.36764798e-02f, -1.86794363e-02f,
  -1.90256331e-02f, 3.59417945e-02f, 1.60136092e-02f, -1.08414769e-01f, -9.09827184e-03f, -8.01549628e-02f, 7.99737573e-02f, 6.47313055e-03f, -3.59917022e-02f, -8.98515433e-02f,
  -6.85619563e-03f, 1.49224773e-01f, 1.03890756e-02f, -1.26203194e-01f, 9.66208354e-02f, 1.32748310e-03f, -7.08238930e-02f, -4.88036908e-02f, -2.30321437e-02f, -6.46197572e-02f,
  -3.80136748e-03f, 3.60774659e-02f, -5.87327555e-02f, -1.64729860e-02f, -8.28525499e-02f, -2.29220837e-03f, 5.28423637e-02f, -3.71260457e-02f, 1.18165150e-01f, 6.50685206e-02f,
  6.70574903e-02f, -6.20851144e-02f, 1.61956623e-02f, 1.25926482e-02f, 2.36619767e-02f, -9.84962564e-03f, -2.73559019e-02f, 2.49242373e-02f, 2.72216387e-02f, -8.88117105e-02f,
  9.44883600e-02f, 1.35444060e-01f, -2.95658976e-01f, 8.17026757e-03f, -6.54777363e-02f, 1.94454864e-01f, 3.84442925e-01f, 1.38085871e-03f, 2.36769646e-01f, 2.76053011e-01f,
  1.99389219e-01f, 3.12157311e-02f, 1.53878152e-01f, 2.67238766e-01f, 1.50508225e-01f, 3.17052752e-01f, 3.31871331e-01f, 2.14479327e-01f, 5.07695936e-02f, 8.41032192e-02f,
  5.45143075e-02f, 1.33060068e-01f, -1.21632770e-01f, -1.44716576e-01f, -1.75610423e-01f, -2.70507872e-01f, -1.48362070e-01f, -1.56774968e-01f, -9.94223878e-02f, -5.13277352e-02f,
  -1.41938003e-02f, 5.05045950e-02f, -6.51729330e-02f, -2.33525690e-02f, -4.04216275e-02f, -6.58156574e-02f, -2.19467748e-02f, -1.23930201e-01f, -8.84797703e-03f, 4.88194190e-02f,
  -2.32413355e-02f, -1.05733283e-01f, 5.11365337e-03f, -9.68088508e-02f, -8.73295814e-02f, -4.55497652e-02f, 4.50264923e-02f, -6.87081292e-02f, -4.49396558e-02f, 1.34291453e-02f,
  -6.98870122e-02f, 6.47447212e-03f, 8.23314581e-03f, 5.87433800e-02f, -1.81643162e-02f, 3.03238183e-02f, 4.74041849e-02f, -8.47169608e-02f, 3.51776965e-02f, 7.99307004e-02f,
  8.87854472e-02f, 2.41587497e-02f, 5.18436246e-02f, 2.10674088e-02f, -5.35132247e-04f, -2.21135393e-02f, 4.46187779e-02f, 8.68354167e-04f, 2.37552896e-02f, 4.44397070e-02f,
  -4.04271036e-02f, -3.70837301e-02f, 3.56377102e-02f, -5.58664463e-02f, 1.03195846e-01f, -8.13279534e-04f, -2.86110844e-02f, -9.14302766e-02f, 3.42609175e-02f, 5.00414381e-03f,
  1.89243630e-02f, 2.36892290e-02f, -7.75173381e-02f, 5.92171121e-03f, 1.41523601e-02f, -1.07603967e-01f, 4.01500612e-02f, 2.41451804e-02f, 2.13858150e-02f, -1.08334068e-02f,
  1.08143866e-01f, 1.76493749e-01f, 5.66538870e-02f, 3.49927880e-02f, -5.48525434e-03f, 1.97025924e-03f, 4.26977873e-02f, 6.93312064e-02f, 8.07933584e-02f, 1.25728518e-01f,
  3.63110341e-02f, 4.51523066e-02f, -9.58497822e-02f, 9.05838888e-03f, 3.74740995e-02f, 1.32138789e-01f, -1.56340413e-02f, -1.06925014e-02f, 1.80031117e-02f, -9.92069319e-02f,
  -7.84270912e-02f, 3.96304484e-03f, -5.54366969e-03f, 1.23724993e-02f, -1.59911998e-02f, 7.11079091e-02f, -5.06209806e-02f, -6.24161102e-02f, 5.50750922e-03f, 6.66712373e-02f,
  -2.09880307e-01f, -2.41260841e-01f, -3.30711842e-01f, 1.15487516e-01f, 2.63504386e-01f, -2.26652861e-01f, -2.67540306e-01f, 1.17327377e-01f, -4.45250571e-01f, -5.57076782e-02f,
  9.16661471e-02f, -3.06526452e-01f, -2.25921825e-01f, -1.97614864e-01f, 2.99968105e-02f, -5.84631383e-01f, 9.90803391e-02f, -2.96010040e-02f, -2.51427442e-01f, 1.93770990e-01f,
  -2.69258637e-02f, 1.71141207e-01f, -2.56303931e-04f, 4.48067993e-01f, 1.06011793e-01f, 3.88352752e-01f, 6.25844300e-01f, 1.58651844e-01f, 2.69866914e-01f, 1.62547663e-01f,
  -2.75356144e-01f, -2.87569553e-01f, -4.26912587e-03f, -6.09731898e-02f, 1.44818276e-01f, 1.60655633e-01f, 6.03829473e-02f, -5.98739320e-03f, -2.47657038e-02f, -7.56789148e-02f,
  -3.93800139e-02f, -4.21512909e-02f, 3.80052365e-02f, -4.44695130e-02f, -3.37220095e-02f, 6.56403229e-03f, -1.17331736e-01f, -7.21102348e-03f, -6.10797256e-02f, -1.79201528e-01f,
  -5.61786704e-02f, -2.24727411e-02f, 7.48958960e-02f, 3.38537768e-02f, 3.89589220e-02f, 3.52824628e-02f, 1.04231231e-01f, 1.46874972e-02f, 6.53182119e-02f, 4.49097715e-02f,
  3.01135965e-02f, 1.07305914e-01f, 4.01286185e-02f, -5.87311275e-02f, 5.01355492e-02f, -4.27449755e-02f, -5.75800985e-02f, 2.82402188e-02f, -4.35044952e-02f, -1.48894945e-02f,
  9.13019702e-02f, -5.76504283e-02f, -1.37651637e-02f, -3.88741232e-02f, 8.73081852e-03f, -1.36500383e-02f, 1.11123748e-01f, -4.75678639e-03f, 5.44393435e-02f, -2.51509771e-02f,
  -4.35562767e-02f, 2.17580739e-02f, -3.23855318e-02f, 8.05714279e-02f, 2.05023829e-02f, 4.56263609e-02f, -6.20707823e-03f, -5.44395037e-02f, 3.16736437e-02f, 9.87405181e-02f,
  1.20106883e-01f, 2.16483459e-01f, -5.87639660e-02f, 5.56678884e-02f, -5.30153401e-02f, 7.21870363e-02f, 3.91769335e-02f, -9.85518750e-03f, 2.18961034e-02f, -1.26223136e-02f,
  1.27182722e-01f, 1.45182773e-01f, 4.71728295e-02f, 5.99292219e-02f, 7.10339621e-02f, 6.77512512e-02f, 1.00828921e-02f, 1.53006986e-01f, 1.65649474e-01f, 2.78824791e-02f,
  1.43358648e-01f, 3.61734815e-02f, 1.09955914e-01f, 1.00676209e-01f, 8.15762579e-02f, 1.05572388e-01f, 8.83345157e-02f, 2.08362639e-02f, 5.41011952e-02f, -8.54301080e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  6.42639637e-01f, 3.90850276e-01f, 1.17393829e-01f, 1.57116763e-02f, 1.75684378e-01f, 4.33677256e-01f, 1.22430682e-01f, 4.79113281e-01f, 4.34307307e-01f, 1.71254545e-01f,
  3.44528854e-01f, 1.84853300e-01f, 2.39333376e-01f, 2.94661969e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.19944420e-02f, -8.72532129e-02f, 3.53228837e-01f, -8.36058632e-02f, 2.79250205e-01f, -4.41254228e-01f, -9.15042534e-02f, 4.78852481e-01f, -1.27432134e-03f, -2.13921681e-01f,
  2.73711860e-01f, 3.00879955e-01f, 4.55630094e-01f, -8.94427896e-02f, 2.56314993e-01f, -3.23154658e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  1.79022193e-01f, 7.73772657e-01f, -1.29572064e-01f, 2.05129117e-01f, 2.32756108e-01f, 8.30715537e-01f, 9.26726684e-03f, -9.80952531e-02f, -9.38372388e-02f, 5.93263507e-01f,
  5.99389136e-01f, 5.38575798e-02f, 6.41652942e-02f, -1.23714637e-02f, -1.21230133e-01f, 3.96298766e-01f, -8.22563767e-02f, 3.38262498e-01f, -1.24121316e-01f, -1.32779449e-01f,
  6.64922455e-03f, 6.58483133e-02f, -7.94230029e-02f, 4.20251131e-01f, 4.11374420e-01f, -2.63325453e-01f, 2.45978042e-01f, 3.29334527e-01f, -1.83444712e-02f, 2.69342750e-01f,
  -2.25173622e-01f, 7.81504691e-01f, 5.61219752e-02f, 7.83412680e-02f, -1.02920957e-01f, 2.83617646e-01f, -1.79448083e-01f, -1.14377759e-01f, -2.11696163e-01f, 2.78151870e-01f,
  -2.17203259e-01f, 3.36304128e-01f, 8.73098746e-02f, -1.92816883e-01f, 3.36883873e-01f, -1.26501312e-02f, 3.09336215e-01f, -2.09490627e-01f, 1.38243651e-02f, 2.45868087e-01f,
  -1.36232883e-01f, 2.66248673e-01f, -5.58025651e-02f, -1.96240097e-01f, 2.74126709e-01f, -9.44566578e-02f, -2.66295940e-01f, -2.51493812e-01f, -2.48279166e-03f, -1.90802753e-01f,
  -9.15165767e-02f, 1.45805150e-01f, -2.03106463e-01f, 3.85938197e-01f, -1.13459691e-01f, 1.05428845e-01f, 1.21357128e-01f, -2.17824772e-01f, 2.76929259e-01f, 7.58838236e-01f,
  -1.60111845e-01f, 3.00391167e-01f, 3.57004106e-01f, -2.65861005e-02f, 6.62349164e-01f, 9.94641781e-02f, 9.50896665e-02f, 6.94525614e-02f, 4.15461987e-01f, 5.49528711e-02f,
  8.12101841e-01f, -5.62906563e-01f, 6.76059783e-01f, 6.17350698e-01f, 2.14758903e-01f, -1.00870401e-01f, 4.70752388e-01f, 4.25991088e-01f, -5.02785325e-01f, 3.25925201e-01f,
  8.57155621e-02f, -5.30371703e-02f, 6.16298735e-01f, -2.55254898e-02f, 1.98875606e-01f, -5.35997391e-01f, 3.05364877e-01f, -1.43267021e-01f, -4.78420705e-01f, 1.12506181e-01f,
  -2.62100905e-01f, -1.61722839e-01f, -3.33274126e-01f, 4.08058278e-02f, 3.26494813e-01f, -1.13103241e-01f, 7.34931946e-01f, 8.29879716e-02f, 5.64946651e-01f, 2.05425233e-01f,
  7.49668181e-01f, 1.32180676e-01f, 2.18168482e-01f, 6.97633505e-01f, 4.73439217e-01f, 5.42904794e-01f, -2.29677737e-01f, 3.58715296e-01f, -1.36847660e-01f, -8.06894749e-02f,
  -2.25729078e-01f, 6.66866243e-01f, -2.88176276e-02f, 4.01648618e-02f, -1.56635210e-01f, -1.49915993e-01f, -5.24163172e-02f, 2.12144896e-01f, -1.83838024e-03f, -5.56633830e-01f,
  3.07269484e-01f, -7.24479258e-02f, -3.80071431e-01f, -1.32243335e-01f, 7.40937293e-02f, 1.88534185e-01f, 7.99491942e-01f, -3.73963982e-01f, -9.38235670e-02f, -3.46376240e-01f,
  -2.59245932e-01f, 6.18514895e-01f, -2.38409504e-01f, 5.57574570e-01f, 2.56805897e-01f, -3.74261700e-02f, -6.03089631e-02f, -2.06702530e-01f, 3.54544702e-03f, -8.01749304e-02f,
  -2.24620864e-01f, -2.51964152e-01f, 3.67970049e-01f, 1.11778013e-01f, -1.45687222e-01f, 8.26796815e-02f, 1.17138043e-01f, 3.29276204e-01f, 1.32753298e-01f, 1.02163665e-01f,
  2.78179228e-01f, 5.30206561e-01f, 5.81779107e-02f, 1.78305954e-01f, 8.75817612e-02f, 8.30030859e-01f, -1.57621279e-01f, 1.06539577e-01f, 2.07293808e-01f, 5.49325645e-01f,
  6.51044786e-01f, 1.62265658e-01f, -2.74626166e-02f, -8.37810636e-02f, -2.09644753e-02f, 3.00739743e-02f, -2.12446451e-01f, 3.02869231e-01f, -2.38951534e-01f, -1.40788183e-01f,
  -1.05362246e-03f, 4.20455597e-02f, -5.23574185e-03f, -1.28139079e-01f, 1.61632404e-01f, -1.37862593e-01f, 8.25035423e-02f, -5.79075553e-02f, -1.32304296e-01f, -1.92259789e-01f,
  1.39994264e-01f, -1.80794522e-01f, 3.78147095e-01f, 5.91499031e-01f, -2.34968036e-01f, -9.96784866e-03f, -2.80588597e-01f, 3.56795549e-01f, -3.13987166e-01f, -2.72978395e-01f,
  2.84164455e-02f, 8.23320925e-01f, -2.14134693e-01f, -2.56572664e-01f, 2.66290605e-01f, -1.54431671e-01f, -1.14089184e-01f, -1.73559487e-01f, 1.85891569e-01f, 1.87585905e-01f,
  1.02753496e+00f, 1.14415735e-01f, 5.53384960e-01f, -4.78581190e-02f, 3.31826322e-02f, 9.00769591e-01f, 3.76241624e-01f, -3.51673841e-01f, 3.57356131e-01f, 7.09779501e-01f,
  1.00872949e-01f, 5.05007505e-01f, 1.46345332e-01f, 8.34600031e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  3.94340456e-01f, -1.65432394e-01f, -7.84101114e-02f, 3.05766702e-01f, -7.31583908e-02f, 9.85075235e-01f, 1.47341892e-01f, 5.15690744e-01f, 1.38419211e-01f, 1.28336266e-01f,
  1.08613551e-01f, -2.06394121e-01f, 4.96290356e-01f, 4.21411008e-01f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  9.29344222e-02f, -1.29165053e-01f, 1.44944206e-01f, -1.94165289e-01f, 1.50179043e-01f, 2.58942783e-01f, 3.58218282e-01f, -9.53077301e-02f, 1.12992570e-01f, -1.16894683e-02f,
  -4.41227585e-01f, 9.59678069e-02f, 1.66912273e-01f, -8.31492990e-02f, 1.01499893e-01f, -2.48884588e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  5.17486870e-01f, -1.06461734e-01f, 6.50226712e-01f, -4.21931893e-01f, 2.57062048e-01f, -2.11595267e-01f, -1.32054135e-01f, 8.84059891e-02f, 2.19657242e-01f, 6.05196655e-01f,
  -4.06511188e-01f, 1.38144508e-01f, 4.99726892e-01f, -1.42596826e-01f, 1.13606930e+00f, -3.67761016e-01f, 1.18909478e-01f, 2.91944474e-01f, -2.66132802e-01f, 3.45210344e-01f,
  8.77905935e-02f, -1.33931264e-01f, 7.74398521e-02f, -7.83200487e-02f, -4.29366171e-01f, -1.33385181e-01f, -1.84506848e-01f, -3.42767745e-01f, -1.14089698e-01f, 1.73097908e-01f,
  -2.07662713e-02f, 7.93994188e-01f, -1.44887567e-01f, -4.03660312e-02f, 3.28393668e-01f, 2.10861921e-01f, 2.15210646e-01f, -4.53281738e-02f, -2.13774666e-01f, 5.32583110e-02f,
  -1.95395663e-01f, 4.04982083e-02f, 1.50039792e-01f, -1.77906513e-01f, -1.82694852e-01f, -4.98039722e-02f, 4.49426658e-02f, -2.38486737e-01f, -1.70043148e-02f, -1.55353144e-01f,
  -1.57103956e-01f, -1.36127099e-01f, 1.43031310e-02f, -4.44313325e-02f, -1.63873985e-01f, 1.52838930e-01f, -1.70654655e-01f, -1.57984763e-01f, 1.91885531e-01f, -9.23080742e-02f,
  -2.63268709e-01f, -2.78053820e-01f, -2.62661994e-01f, 3.27059716e-01f, -1.83899850e-01f, 9.77215767e-01f, -5.78548610e-02f, -4.60646659e-01f, 4.87750083e-01f, -2.66066432e-01f,
  2.06069544e-01f, 1.14676893e+00f, 2.65304357e-01f, 1.00389093e-01f, -4.51768816e-01f, -1.58921376e-01f, 2.92545021e-01f, -2.18003258e-01f, -2.45582893e-01f, 7.58347750e-01f,
  -1.07215606e-01f, -4.58985716e-01f, 6.72350168e-01f, 4.65416089e-02f, 1.03033014e-01f, 1.10798307e-01f, -2.87327856e-01f, 3.00489426e-01f, -5.39424658e-01f, 8.53956997e-01f,
  1.23326495e-01f, -6.96368469e-03f, 5.04879832e-01f, -1.91820160e-01f, 1.42539397e-01f, 4.57325131e-01f, 6.24622822e-01f, 4.36617881e-02f, -9.99367163e-02f, -7.58976340e-02f,
  2.13003963e-01f, 2.21625045e-01f, -9.91256312e-02f, 5.62480032e-01f, 3.22979361e-01f, -1.08661689e-01f, -9.26853344e-02f, 1.76545888e-01f, 1.40836090e-02f, -2.41333440e-01f,
  -3.96361090e-02f, -2.44802341e-01f, -3.07830006e-01f, -2.45160516e-02f, 7.57850528e-01f, 3.60473007e-01f, 1.15313485e-01f, -1.54230475e-01f, 6.53136969e-01f, -3.11676204e-01f,
  5.19962847e-01f, -6.71796640e-03f, -3.27904463e-01f, -2.26524975e-02f, 8.92600358e-01f, 8.10797662e-02f, 2.35923797e-01f, 1.77349463e-01f, 2.56358087e-01f, -1.58832014e-01f,
  -1.60463214e-01f, -3.05380434e-01f, -2.79335141e-01f, 1.31923288e-01f, -2.97136337e-01f, 7.46433139e-01f, -3.69964838e-01f, -4.67021726e-02f, -8.85833725e-02f, -2.63375163e-01f,
  -2.51812667e-01f, -3.39506328e-01f, -2.33502775e-01f, -8.20439830e-02f, 2.24359766e-01f, -2.48290241e-01f, -4.93113101e-01f, 1.58227280e-01f, -1.26980171e-01f, 1.67411968e-01f,
  -2.99390167e-01f, 3.24523687e-01f, -2.20787808e-01f, -2.05799937e-01f, 1.00127029e+00f, 2.06218854e-01f, -1.87132239e-01f, -1.16014391e-01f, 1.33736745e-01f, 4.51730877e-01f,
  1.00519201e-02f, 5.62826037e-01f, -3.89543027e-01f, 7.60806054e-02f, -1.53319821e-01f, -4.35134441e-01f, 5.07511854e-01f, 9.54761878e-02f, 5.16001403e-01f, -4.01135951e-01f,
  2.36129999e-01f, 2.73060322e-01f, -2.60716408e-01f, -1.92134470e-01f, -3.96727443e-01f, 7.79032886e-01f, 1.07733592e-01f, -5.53435147e-01f, 1.69545650e-01f, 2.13355452e-01f,
  -1.95898086e-01f, 7.52569735e-02f, -1.09944500e-01f, -3.27214062e-01f, 5.18980682e-01f, 3.92896056e-01f, 4.60818678e-01f, 8.26900452e-02f, -2.96454746e-02f, -8.59568566e-02f,
  -6.77077100e-02f, 3.71755026e-02f, 8.29801261e-02f, -1.00928172e-01f, 2.84500271e-01f, 7.15223670e-01f, -1.20819651e-01f, 3.17837864e-01f, 4.60750133e-01f, -6.50247574e-01f,
  -6.39912114e-02f, 2.07526550e-01f, 1.07243910e-01f, -8.25432613e-02f, 4.42253739e-01f, -1.83737710e-01f, -3.40787977e-01f, 1.20015383e+00f, 8.09099555e-01f, 1.46388292e-01f,
  -1.95728969e-02f, -3.79490703e-01f, -2.70569861e-01f, 1.77280888e-01f, 4.08732854e-02f, 8.51656139e-01f, -3.84280473e-01f, 3.28552544e-01f, 2.57107820e-02f, -8.36365372e-02f,
  7.28535801e-02f, -1.59329996e-01f, -1.06424920e-01f, 6.02035113e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  1.85991034e-01f, -2.95706481e-01f, -6.73618093e-02f, 4.06157553e-01f, 3.42383623e-01f, 2.84589063e-02f, 4.82444316e-01f, -5.12449861e-01f, 6.25676155e-01f, 3.19911152e-01f,
  3.96006852e-02f, -2.13040020e-02f, -4.81243692e-02f, 6.65164292e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -2.79969901e-01f, 6.17626369e-01f, 5.47783136e-01f, -3.47160369e-01f, -6.10702895e-02f, 1.06077552e-01f, 6.18096948e-01f, -3.54202986e-01f, 1.41429886e-01f, 4.07214761e-01f,
  -2.14602411e-01f, -7.58241862e-02f, -4.01045471e-01f, -1.54963836e-01f, -4.82737213e-01f, -1.64275795e-01f, 4.41522896e-02f, -1.25643432e-01f, -3.46014857e-01f, -1.06256679e-01f,
  -2.25028098e-01f, -2.39195928e-01f, 2.40644574e-01f, -4.01883006e-01f, -1.31314069e-01f, 6.71954453e-01f, -2.20118493e-01f, -7.00314701e-01f, 4.20257300e-01f, -1.08700417e-01f,
  4.32839513e-01f, -1.22748971e-01f, -8.63772750e-01f, -6.16078019e-01f, -4.10348505e-01f, 8.37912142e-01f, 1.44908309e-01f, 4.45447043e-02f, -2.94838369e-01f, -2.20207363e-01f,
  8.21863636e-02f, 2.55443305e-01f, -2.41213441e-02f, -1.86595637e-02f, 3.95682782e-01f, -2.66638041e-01f, 6.89679861e-01f, -6.16215169e-01f, -6.90843105e-01f, 1.14288270e+00f,
  1.09429646e+00f, -8.03528726e-02f, 1.80348441e-01f, -3.23126733e-01f, -8.60936880e-01f, 3.64847988e-01f, -2.95136690e-01f, -1.12093752e-02f, -5.01376092e-01f, -4.24865574e-01f,
  -1.21857256e-01f, 2.13420480e-01f, -5.63627481e-01f, -4.61245000e-01f, 4.00061876e-01f, 7.27998972e-01f, 7.15757787e-01f, -1.12701192e-01f, -2.73621589e-01f, -1.77233920e-01f,
  1.04700975e-01f, 3.00884843e-01f, 2.25172937e-01f, -8.06064963e-01f, -1.45447165e-01f, 5.35504967e-02f, -5.68650901e-01f, -6.05092011e-02f, -1.13152318e-01f, 7.51659214e-01f,
  8.41569245e-01f, 2.35701445e-02f, -1.87241167e-01f, -1.14003137e-01f, 1.31349750e-02f, -8.62941146e-02f, 9.85042095e-01f, -8.43008518e-01f, 4.30383891e-01f, -4.37991202e-01f,
  -1.07058585e-01f, -1.36113703e-01f, 5.40328085e-01f, -3.03460777e-01f, -6.26970112e-01f, -2.57754792e-02f, -1.96013317e-01f, -5.44365585e-01f, -3.66359532e-01f, 4.33972806e-01f,
  -2.53214300e-01f, 4.27704990e-01f, 2.39760280e-01f, -2.98735738e-01f, -3.52606624e-01f, -6.98232234e-01f, -1.69879869e-01f, 4.94902313e-01f, 5.84712505e-01f, -3.42218280e-01f,
  2.99708128e-01f, -1.63586855e-01f, -3.57642621e-01f, -3.01124781e-01f, 3.57176781e-01f, -6.93969205e-02f, -1.42268941e-01f, -3.27306725e-02f, -2.41153583e-01f, 1.98492885e-01f,
  -4.56273049e-01f, 7.91222394e-01f, -2.13883191e-01f, 5.89374118e-02f, -6.03762716e-02f, -2.81371832e-01f, 3.44837792e-02f, 1.09436132e-01f, -1.07373667e+00f, -4.49428201e-01f,
  -3.55523109e-01f, -2.85375178e-01f, -1.77731812e-01f, -1.41073629e-01f, -5.84170699e-01f, -1.17084526e-01f, 7.79042989e-02f, 7.43398294e-02f, -1.98886514e-01f, 8.04463685e-01f,
  5.40833831e-01f, 6.39694333e-01f, 3.16264033e-01f, -5.56725919e-01f, 1.14413106e-03f, -3.43957365e-01f, -6.36497021e-01f, 1.68430179e-01f, 1.68042377e-01f, -1.10892549e-01f,
  7.34923959e-01f, 4.98454273e-01f, -2.13469639e-01f, -2.79964685e-01f, 4.57428247e-01f, 2.78490949e-02f, -2.50264823e-01f, -1.99593127e-01f, -3.19025993e-01f, 1.52565166e-01f,
  1.81429565e-01f, 1.56618118e-01f, -1.83715865e-01f, -9.81769115e-02f, 1.04063870e-02f, -1.94180533e-02f, -6.80037618e-01f, 4.94528174e-01f, -2.00853780e-01f, 2.21285179e-01f,
  -3.37438852e-01f, -3.78150851e-01f, -4.82220173e-01f, 4.11153585e-01f, 8.30716491e-01f, -9.28860754e-02f, 1.18861020e+00f, 9.59538892e-02f, -2.72434056e-01f, -3.76545578e-01f,
  -9.15528238e-02f, 3.84586513e-01f, -2.01625064e-01f, -3.99104595e-01f, 5.46770692e-01f, -3.74952346e-01f, 9.09604490e-01f, 5.47970712e-01f, -4.55239981e-01f, -1.24183550e-01f,
  -6.31145060e-01f, 8.03074777e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.49307558e-02f, -2.28497013e-01f, -6.49222732e-01f, -7.27953985e-02f, 2.85987973e-01f, 7.90159285e-01f, 1.03782393e-01f, -8.57015610e-01f, -1.96216106e-01f, -1.82294443e-01f,
  9.50963572e-02f, 7.46236444e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    