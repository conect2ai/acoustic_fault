/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.66620031e-01f, -6.18936308e-02f, -2.98050851e-01f, -2.73999409e-03f, -4.51211594e-02f, -7.41806105e-02f, -1.19632058e-01f, 7.98106268e-02f, 4.58279252e-02f, -2.45172344e-02f,
  -5.07935882e-02f, 5.12510613e-02f, 4.73718271e-02f, -4.26301211e-02f, 4.55468632e-02f, -7.82162249e-02f, 8.87863114e-02f, -2.27385666e-02f, -1.54406559e-02f, 1.56721458e-01f,
  4.88788523e-02f, 5.41659966e-02f, 1.05804950e-01f, 8.12379643e-02f, 3.22902785e-03f, 6.72570542e-02f, -8.58062971e-03f, -1.01048328e-01f, -3.37505713e-02f, -9.73474607e-03f,
  -2.97233373e-01f, -3.92038636e-02f, -1.04575738e-01f, -4.57672663e-02f, -7.65481740e-02f, -1.15214653e-01f, -3.66598479e-02f, 2.81939022e-02f, -1.54206455e-02f, -8.88290256e-02f,
  -2.14201547e-02f, 2.66045611e-02f, 7.44742854e-03f, 7.66364560e-02f, 2.31471751e-02f, 2.05437280e-02f, 6.82475045e-02f, 8.82098526e-02f, -7.44566619e-02f, -9.85058695e-02f,
  -3.36088389e-02f, -1.55485302e-01f, -1.51798755e-01f, 3.34214494e-02f, -1.47482147e-02f, -4.11623567e-02f, -4.60483283e-02f, -5.89741468e-02f, -1.54091910e-01f, -1.37919381e-01f,
  6.22081980e-02f, -1.11305997e-01f, -1.57383829e-01f, -6.17831536e-02f, 3.53639610e-02f, -3.66540477e-02f, 1.86526328e-02f, 2.88462862e-02f, 2.21858844e-02f, -8.95491168e-02f,
  6.13190793e-02f, 4.45300080e-02f, 4.28740261e-03f, -8.22619870e-02f, -8.06839988e-02f, -1.01129733e-01f, 9.66688991e-03f, -1.93380341e-02f, -1.65560357e-02f, 4.77292649e-02f,
  -3.62211540e-02f, -9.13425088e-02f, -2.30672657e-02f, 2.95404755e-02f, 6.58998825e-03f, -1.03301927e-02f, -7.21229911e-02f, -9.98886600e-02f, -6.58322722e-02f, -5.28360903e-02f,
  -1.29173458e-01f, -1.17850546e-02f, -5.70969004e-03f, 6.51430339e-02f, -6.40798286e-02f, -1.86097529e-02f, -5.28866425e-02f, -8.70167315e-02f, 3.86434495e-02f, 5.84818795e-02f,
  -8.91551971e-02f, -1.53253032e-02f, -4.92161773e-02f, 3.75419408e-02f, -9.04392218e-04f, -6.00422360e-02f, -3.33433822e-02f, 3.43019292e-02f, 3.24110128e-03f, 2.71274243e-02f,
  -5.28355092e-02f, -7.62375593e-02f, -2.05901191e-01f, -1.77695543e-01f, -1.01245172e-01f, -1.53058022e-01f, -7.53288195e-02f, -1.05700240e-01f, -1.39871791e-01f, -1.29997164e-01f,
  1.41040415e-01f, -1.87768601e-02f, 1.04332127e-01f, -1.52131766e-01f, -1.22080579e-01f, 5.89740351e-02f, 1.06003113e-01f, 1.45568311e-01f, 3.20651382e-02f, -5.72611876e-02f,
  6.58227084e-03f, -1.20647505e-01f, 7.74006499e-03f, -1.13243796e-01f, 7.17739835e-02f, 4.81869355e-02f, -1.92675978e-01f, -1.08988546e-01f, -2.73418333e-02f, 1.56046003e-02f,
  -1.34885386e-01f, -1.19500481e-01f, -1.00440994e-01f, -3.23377736e-02f, -1.16260327e-01f, 3.26558910e-02f, 4.33741920e-02f, -1.21574573e-01f, -4.71973978e-02f, -9.38178524e-02f,
  1.39907733e-01f, 1.82782188e-01f, 1.04256079e-01f, -3.55263986e-02f, -1.47939334e-02f, 8.55729803e-02f, 3.65765840e-02f, -6.45649210e-02f, 5.37549406e-02f, 9.69590396e-02f,
  -2.30210666e-02f, 1.71101242e-02f, -3.30528393e-02f, 2.27273945e-02f, 2.58503892e-02f, 1.15704291e-01f, -3.94300297e-02f, -3.90167981e-02f, -4.36890423e-02f, 6.05972596e-02f,
  -1.18006699e-01f, -7.37672672e-02f, -1.57959666e-02f, 6.76963553e-02f, -4.82290657e-03f, -8.66777599e-02f, 8.78807157e-02f, -1.46564236e-02f, 1.19784042e-01f, 1.02037832e-01f,
  6.10635839e-02f, 2.86670774e-02f, -1.69644952e-02f, 4.04526526e-03f, 2.60297004e-02f, 2.76421327e-02f, -2.38397121e-02f, -1.81062352e-02f, -2.90322490e-03f, -9.41036865e-02f,
  1.14052378e-01f, 6.22811466e-02f, 6.78461418e-02f, 1.08232182e-02f, -5.54954745e-02f, -6.12238459e-02f, -9.85666737e-02f, 2.06547324e-02f, 2.60676467e-03f, -4.27096225e-02f,
  2.90127154e-02f, 7.01551558e-03f, -1.23113869e-02f, -3.19597125e-02f, 1.11909276e-02f, 5.30933216e-02f, -4.30571064e-02f, 1.39367357e-02f, 8.76828432e-02f, 2.64551882e-02f,
  -8.21405128e-02f, 1.16936471e-02f, 7.06540197e-02f, 3.62363309e-02f, 8.16281810e-02f, 2.53655408e-02f, -9.96092241e-03f, -6.31033210e-03f, 3.10351513e-03f, 6.93136752e-02f,
  1.05236791e-01f, 6.81912377e-02f, -1.79893877e-02f, -7.05747977e-02f, 8.41845721e-02f, 1.35060921e-01f, 3.97186801e-02f, -6.19809097e-03f, -1.59266498e-02f, 1.79365221e-02f,
  -1.63612198e-02f, 1.56448409e-02f, 9.60943922e-02f, 1.53692635e-02f, 6.40277714e-02f, 3.40101905e-02f, 1.49616614e-01f, 1.46186933e-01f, 1.68042734e-01f, 5.59751019e-02f,
  -2.64271051e-01f, -3.23218375e-01f, -4.12721671e-02f, 6.21350529e-03f, 1.71755627e-01f, 1.84268206e-01f, -9.77390409e-02f, -3.77183184e-02f, 2.29259860e-02f, -2.46571600e-01f,
  -1.41250134e-01f, 5.19675910e-02f, 5.37971631e-02f, 1.38850197e-01f, 5.02026640e-02f, -2.27223352e-01f, -1.44683570e-01f, 1.62054524e-01f, 2.39760518e-01f, 1.24159008e-01f,
  5.16623855e-02f, 6.63459077e-02f, -9.57034379e-02f, -9.12909582e-02f, -9.04771164e-02f, 1.71749517e-01f, -1.85864732e-01f, -1.13901936e-01f, -1.05474673e-01f, -1.96144283e-01f,
  -9.78084207e-02f, -3.76469254e-01f, 8.34598616e-02f, -6.84655458e-02f, -1.64203063e-01f, -5.61200306e-02f, 3.61845680e-02f, -5.54697029e-02f, -8.27708170e-02f, -1.03884272e-01f,
  -1.10004880e-01f, -1.73148569e-02f, 2.66214530e-03f, -4.81982976e-02f, -6.14196248e-02f, -9.73779783e-02f, -1.80290043e-01f, -1.94238350e-01f, -1.53617427e-01f, -1.64630637e-01f,
  -7.24122452e-04f, -1.61386076e-02f, -1.46828666e-01f, -5.68492943e-03f, -7.58856684e-02f, 1.20058149e-01f, -9.46016088e-02f, -1.89099938e-01f, -8.36263150e-02f, -2.49200538e-01f,
  9.22933966e-02f, 7.25608915e-02f, 1.00183263e-01f, 3.64510864e-02f, 1.12082399e-01f, 6.93132877e-02f, 9.05191600e-02f, 6.71694577e-02f, 1.02132626e-01f, -1.34899141e-03f,
  4.73480113e-02f, 8.88990611e-02f, 3.37839536e-02f, 3.36041525e-02f, 1.84008390e-01f, 1.62082759e-03f, 6.46041259e-02f, 2.57641186e-05f, 1.42762926e-03f, -1.67747401e-02f,
  1.30427703e-01f, 3.33207613e-03f, 4.53194976e-02f, 4.28826474e-02f, 8.11112449e-02f, 8.32513198e-02f, 1.04909420e-01f, 8.01239833e-02f, 9.54054818e-02f, -1.69990771e-02f,
  1.51617974e-01f, 6.03696220e-02f, -4.62491671e-03f, -3.33730914e-02f, -9.43626389e-02f, -1.63796410e-01f, -5.24952747e-02f, 2.97795273e-02f, -9.78555679e-02f, -1.36483787e-02f,
  -7.96764120e-02f, -1.34113297e-01f, -1.52119443e-01f, -5.62764481e-02f, -3.05050686e-02f, -1.00359090e-01f, -1.15442067e-01f, 5.80197293e-03f, 3.92011628e-02f, -4.29883376e-02f,
  -1.04472078e-01f, 7.37955570e-02f, 7.37356991e-02f, 6.75999448e-02f, -8.03333148e-03f, 7.39657059e-02f, 5.60594499e-02f, 9.74860340e-02f, 3.00200898e-02f, -2.77945492e-02f,
  -3.51048678e-01f, 2.25463942e-01f, 1.02802329e-02f, 1.58130266e-02f, 1.73015699e-01f, 2.46289760e-01f, 2.57726789e-01f, 9.46756750e-02f, 1.11996725e-01f, 8.93410370e-02f,
  1.23007253e-01f, 7.04983771e-02f, -2.37329006e-02f, 3.19083482e-02f, -4.26521488e-02f, 5.14273532e-02f, 7.28686824e-02f, -2.26900578e-01f, -6.44663721e-02f, 7.17744604e-02f,
  3.05871908e-02f, -5.78303747e-02f, -1.63723975e-01f, -2.99420822e-02f, -1.26503212e-02f, -1.23514310e-01f, -6.53769523e-02f, 1.62389204e-02f, -1.01089329e-02f, -1.69266000e-01f,
  8.27427655e-02f, 1.54892176e-01f, 8.88151750e-02f, 1.29428416e-01f, 7.87883401e-02f, 1.48750797e-01f, 4.19619679e-02f, 8.03481862e-02f, 1.40362605e-01f, 9.34241116e-02f,
  2.14867070e-01f, 2.40178835e-02f, 2.01042026e-01f, 1.21130042e-01f, 1.17275134e-01f, 1.72649994e-01f, 3.79080288e-02f, 6.70541599e-02f, 1.42133564e-01f, 1.87143460e-01f,
  1.56091988e-01f, 5.37782498e-02f, 3.66881490e-02f, 8.71670544e-02f, 1.07082203e-01f, 5.17827980e-02f, 1.40747741e-01f, 8.83921981e-02f, -1.80004034e-02f, 8.55777320e-03f,
  -1.42235562e-01f, -1.51576726e-02f, -3.26790921e-02f, -8.30527171e-02f, -9.87424478e-02f, -3.28299515e-02f, -2.62396000e-02f, -7.59017095e-02f, 3.71506140e-02f, -6.60942122e-02f,
  -4.23071496e-02f, -6.97991326e-02f, 1.60183571e-02f, -2.33955011e-02f, -2.16801967e-02f, 4.13980484e-02f, 2.23976318e-02f, -7.55340159e-02f, -6.86711147e-02f, -3.63875628e-02f,
  -8.46347138e-02f, 1.74341369e-02f, -3.52152996e-02f, -2.71776076e-02f, 3.87340076e-02f, -8.21620822e-02f, -8.35341495e-03f, -4.21357602e-02f, -4.53382032e-03f, 9.02344957e-02f,
  3.76429409e-02f, 1.29912078e-01f, 1.22971229e-01f, 1.75639521e-02f, 1.07746385e-01f, 7.51166418e-02f, 1.44594133e-01f, 1.10523522e-01f, 1.26266122e-01f, 8.25119391e-02f,
  2.25733399e-01f, 1.66867107e-01f, 9.08970088e-02f, 1.83744460e-01f, 7.09401742e-02f, 6.81971237e-02f, 9.68781039e-02f, -2.55606938e-02f, 9.85635445e-02f, 1.16535991e-01f,
  1.82429537e-01f, 8.38312879e-02f, -7.45956376e-02f, 5.65456785e-02f, 2.83964127e-02f, -4.54501212e-02f, 3.19291316e-02f, 9.80594545e-04f, -4.71750051e-02f, -3.73316705e-02f,
  -2.21102744e-01f, -3.23001742e-01f, 1.31958937e-02f, -6.29183426e-02f, -1.69426858e-01f, -9.34297740e-02f, -1.26905173e-01f, 2.72202436e-02f, 4.14297357e-03f, -7.10973293e-02f,
  -1.90966669e-02f, -4.63503525e-02f, 1.27044274e-03f, 1.54398784e-01f, 1.68510973e-01f, -1.90836042e-01f, -1.28971785e-01f, 1.32292062e-01f, 1.94703534e-01f, -1.23666815e-01f,
  -1.20113775e-01f, -1.87468201e-01f, 1.08530648e-01f, 4.91174087e-02f, -1.63783625e-01f, -3.49829234e-02f, 6.73481748e-02f, -1.65485479e-02f, 2.09193435e-02f, -2.66281724e-01f,
  -8.85148719e-02f, 4.91739176e-02f, 3.51898372e-02f, 9.49204043e-02f, -8.70053715e-04f, 5.08015715e-02f, -2.07587592e-02f, 4.00222465e-02f, -6.28412515e-02f, 1.84697553e-03f,
  -7.04127327e-02f, -6.63559930e-03f, -1.59788691e-02f, 1.76536962e-02f, -1.03654645e-01f, -3.20342705e-02f, 3.32987644e-02f, 1.79997906e-01f, 8.93387347e-02f, 1.77503303e-02f,
  -2.24924367e-02f, -1.30801678e-01f, -5.64351156e-02f, 9.13962629e-03f, 1.26235962e-01f, 4.87520620e-02f, 9.91693512e-02f, 1.35544419e-01f, 1.51452526e-01f, -1.23402491e-01f,
  -6.26415759e-02f, 1.15102334e-02f, 4.36017811e-02f, -1.50722871e-02f, 4.92377058e-02f, -3.70029099e-02f, -1.91041101e-02f, -5.69809638e-02f, -7.05127791e-02f, 3.87777053e-02f,
  5.15038334e-02f, 7.68548846e-02f, -7.22667724e-02f, 2.78302301e-02f, -1.32719092e-02f, -6.48382753e-02f, -4.14413773e-02f, 4.05088365e-02f, 6.82362961e-03f, 5.59347123e-02f,
  6.78175986e-02f, 7.76050240e-02f, -4.12867405e-02f, 1.10072913e-02f, -4.42895433e-03f, -3.37610114e-03f, 3.73099186e-02f, 6.57934248e-02f, -9.76550430e-02f, 1.08540542e-02f,
  -2.48864621e-01f, 2.68562645e-01f, -1.31667450e-01f, 4.14803475e-02f, 3.35543565e-02f, 7.22828433e-02f, -9.89722908e-02f, 5.21188565e-02f, 5.57005368e-02f, -1.25790490e-02f,
  5.64703010e-02f, 5.41149154e-02f, -5.33066988e-02f, 7.38131478e-02f, -1.88627429e-02f, 3.86530198e-02f, -1.08284391e-01f, 3.59992199e-02f, -5.97606227e-03f, 4.49136496e-02f,
  -2.41309572e-02f, 2.89802030e-02f, -5.89872114e-02f, 2.56116465e-02f, -5.50345965e-02f, 1.68768130e-02f, -8.77882689e-02f, 1.06748566e-03f, 4.02534902e-02f, -1.86180502e-01f,
  1.31551504e-01f, -3.59962694e-02f, 1.00388102e-01f, 2.18694180e-01f, 1.38698980e-01f, -9.66318846e-02f, -1.07590944e-01f, -1.84866890e-01f, 1.56261888e-03f, -1.41103312e-01f,
  -3.08228470e-02f, -2.74358898e-01f, -1.96185455e-01f, -2.45032176e-01f, -2.01036036e-01f, -1.68945193e-02f, 6.50139153e-02f, 1.68570615e-02f, -1.17796995e-01f, -1.92011669e-01f,
  -2.24998482e-02f, 5.66638634e-02f, 1.52110592e-01f, 2.26318855e-02f, 1.44429520e-01f, 2.34425850e-02f, 1.36731297e-01f, 1.14228018e-01f, -2.60816999e-02f, 1.32729262e-01f,
  8.81678537e-02f, 1.61732763e-01f, -1.48528248e-01f, -7.28755072e-02f, 7.10303187e-02f, -4.14909422e-02f, -4.22218479e-02f, 9.80415791e-02f, -1.73373204e-02f, -1.10293999e-02f,
  6.32965267e-02f, -9.79349166e-02f, -5.07594571e-02f, 6.94815516e-02f, -6.44047570e-04f, -8.20964426e-02f, -8.18999205e-03f, 1.12898909e-02f, 5.60469646e-03f, -8.51295590e-02f,
  1.45919882e-02f, -3.35260369e-02f, -3.28011401e-02f, -1.13563187e-01f, -5.88805936e-02f, 1.86967906e-02f, -1.49815315e-02f, -2.12005824e-02f, -5.88221736e-02f, 1.79045722e-02f,
  -9.09540355e-02f, -1.24419034e-01f, -8.40654448e-02f, 2.28055473e-03f, -1.00778349e-01f, -7.09808171e-02f, 6.43491894e-02f, 1.47660514e-02f, -5.62434196e-02f, -3.05563603e-02f,
  -1.98492669e-02f, 8.46934319e-02f, 5.86700179e-02f, 4.90055233e-02f, 4.63977398e-04f, 3.81683968e-02f, -1.37371030e-02f, -4.75954451e-02f, 1.77401062e-02f, 1.33924102e-02f,
  9.21368152e-02f, -2.16510445e-02f, 9.50939953e-02f, 3.37535702e-02f, 8.23729560e-02f, -3.41429445e-03f, 1.29636694e-02f, 1.98005028e-02f, 3.28297378e-03f, 5.18423356e-02f,
  -1.17523633e-01f, -9.06817690e-02f, -7.40068555e-02f, 2.91624777e-02f, 8.59645158e-02f, -2.54357997e-02f, 7.50009390e-03f, 4.94652838e-02f, 9.97072980e-02f, -3.53438035e-02f,
  1.08856857e-02f, -4.65605222e-03f, -2.35177949e-02f, -7.42314681e-02f, 2.99014691e-02f, -5.24255037e-02f, 3.08593158e-02f, 1.63490400e-02f, -4.00933772e-02f, 6.92667291e-02f,
  -7.05703944e-02f, -1.24171197e-01f, -9.80297253e-02f, -7.12545365e-02f, 3.12263127e-02f, -5.92668168e-02f, 2.52118818e-02f, -8.49298462e-02f, -5.17871156e-02f, -7.25916773e-02f,
  4.53242302e-01f, 2.17157796e-01f, 1.58599779e-01f, 3.29894692e-01f, -1.37221262e-01f, -2.01176777e-01f, -2.59742469e-01f, -4.56127524e-02f, 6.09146766e-02f, 1.88486546e-01f,
  3.85805555e-02f, 2.46850178e-01f, 3.55745971e-01f, 2.79772103e-01f, 3.30394208e-01f, 1.30116969e-01f, 3.08523387e-01f, 3.88847619e-01f, 2.46352870e-02f, -7.59442747e-02f,
  7.75968954e-02f, 2.29330525e-01f, 3.27290446e-01f, 2.05645099e-01f, 1.74840450e-01f, 2.33130574e-01f, 1.89689919e-01f, 6.35735318e-02f, 1.77104622e-01f, 3.34399194e-01f,
  8.27551447e-03f, 1.87810466e-01f, 9.68758017e-02f, 2.78145015e-01f, 8.12391490e-02f, 2.34565601e-01f, 9.97027829e-02f, 1.49474382e-01f, 1.79319859e-01f, 9.47042629e-02f,
  2.12678120e-01f, 1.76588997e-01f, 1.65227488e-01f, 5.90246059e-02f, 4.26600799e-02f, 1.02665737e-01f, 2.02797458e-01f, 3.44805360e-01f, 2.43623435e-01f, 1.10556036e-01f,
  2.23405153e-01f, 1.08182192e-01f, 7.27665722e-02f, 1.29072368e-01f, 1.12329975e-01f, 1.69847190e-01f, 5.39385378e-02f, 7.45896921e-02f, 2.10538760e-01f, 1.76658303e-01f,
  -1.30438611e-01f, -1.50389299e-01f, -1.10465690e-01f, -1.18208446e-01f, -1.35324001e-01f, -1.40172079e-01f, -8.05019960e-02f, -1.27257049e-01f, -1.37991086e-01f, -1.71172217e-01f,
  -1.30509481e-01f, -1.47656888e-01f, -8.68753642e-02f, -1.44093394e-01f, -1.20306030e-01f, -1.34099618e-01f, -1.11812964e-01f, -1.95271507e-01f, -1.68878138e-01f, -1.19711123e-01f,
  -9.62959155e-02f, -1.89341649e-01f, -1.47383302e-01f, -1.89671412e-01f, -1.26262441e-01f, -1.22181751e-01f, -2.05085799e-01f, -1.23821616e-01f, -1.94269881e-01f, -2.15336949e-01f,
  3.18912379e-02f, 1.28414601e-01f, 1.21345356e-01f, 1.95985079e-01f, 1.61553726e-01f, 1.61235943e-01f, 1.06505066e-01f, 1.88275576e-01f, 1.66625515e-01f, 4.21647392e-02f,
  1.64058767e-02f, 1.03504680e-01f, 1.03070848e-01f, 1.54368609e-01f, 9.43159536e-02f, 3.53236496e-02f, 2.39982903e-01f, 1.15661204e-01f, 1.17898256e-01f, 9.02697816e-02f,
  1.81839049e-01f, -7.47462409e-03f, 4.83090729e-02f, 1.20075479e-01f, 1.10087760e-01f, 1.23753540e-01f, 5.62549531e-02f, -2.98243910e-02f, 4.07080948e-02f, 1.01160277e-02f,
  -9.95002761e-02f, -1.88600854e-03f, -1.38517067e-01f, -1.99228525e-01f, -1.59535259e-01f, -1.13051243e-01f, -1.11754768e-01f, -6.56405836e-02f, -1.36705965e-01f, 2.07428690e-02f,
  4.41513471e-02f, 7.06409812e-02f, 3.31324637e-02f, -9.55958068e-02f, -4.45207581e-03f, -1.58685341e-01f, -2.28726536e-01f, -1.72282875e-01f, -1.72571540e-01f, -4.04351428e-02f,
  -1.15200644e-02f, -1.76282108e-01f, -1.92109510e-01f, -2.13421389e-01f, -2.50554562e-01f, -1.83410153e-01f, -2.01651901e-01f, -1.49536327e-01f, -1.56412631e-01f, -2.97742188e-01f,
  -4.49375957e-02f, -2.52650082e-02f, -1.89237624e-01f, -2.27387458e-01f, -1.16664566e-01f, -1.40913635e-01f, -1.36209503e-01f, -1.15393192e-01f, -1.11652054e-01f, -8.38476792e-02f,
  -2.56405547e-02f, -4.13780548e-02f, -7.31605962e-02f, -1.06285818e-01f, -1.33991033e-01f, -8.94791707e-02f, -1.55044436e-01f, -1.34818509e-01f, -1.87121943e-01f, -7.62502998e-02f,
  -2.16847569e-01f, -1.99568316e-01f, -2.80081958e-01f, -7.23413005e-02f, -1.16852351e-01f, -1.70239985e-01f, -1.14190772e-01f, -1.90218970e-01f, -2.56942332e-01f, -2.20362365e-01f,
  -5.25088497e-02f, 1.35710955e-01f, 1.34486884e-01f, 1.63293943e-01f, 1.99636653e-01f, 2.17067212e-01f, 1.51089698e-01f, 9.55507681e-02f, 8.97874087e-02f, 6.25617579e-02f,
  1.69996783e-01f, 6.38374314e-02f, 1.37611121e-01f, 1.09254263e-01f, 7.67417252e-02f, -2.05152249e-03f, 9.88111123e-02f, 6.22681379e-02f, 1.36930928e-01f, 1.52564049e-01f,
  1.43283591e-01f, 1.32218495e-01f, 7.93704540e-02f, 1.90082893e-01f, 1.72003761e-01f, 1.31877348e-01f, 1.38744608e-01f, 1.64999560e-01f, 1.64427429e-01f, 1.86823457e-01f,
  -1.30721211e-01f, -6.61217943e-02f, -1.29785225e-01f, -1.24602325e-01f, -1.21286668e-01f, -1.16940401e-01f, -4.82528135e-02f, -9.44492593e-02f, 1.39518026e-02f, -1.48826584e-01f,
  -3.10584232e-02f, -1.36710301e-01f, -3.49208526e-02f, -1.03659302e-01f, -6.48205951e-02f, -2.88034161e-03f, -1.95308421e-02f, -5.45077771e-02f, -5.57864532e-02f, -6.58873767e-02f,
  -1.30256459e-01f, -1.85695127e-01f, -1.70862734e-01f, -1.74062818e-01f, -1.65057719e-01f, -1.04045793e-01f, -7.03581348e-02f, -2.20166266e-01f, -1.64450705e-01f, -2.72286326e-01f,
  -7.56616518e-02f, -4.07752767e-03f, -2.46875197e-01f, -2.39385545e-01f, -1.84360415e-01f, -8.81173462e-02f, -8.99672508e-02f, -6.77212316e-04f, 2.82411929e-02f, -1.25362193e-02f,
  3.35586518e-02f, 4.45831493e-02f, 3.34906355e-02f, -1.03979088e-01f, -1.12160727e-01f, -1.71156347e-01f, -8.88907760e-02f, -8.77860412e-02f, -1.70616850e-01f, -1.58548132e-01f,
  -6.01114780e-02f, -1.55345455e-01f, -1.80765897e-01f, -7.83226416e-02f, -1.37704583e-02f, -4.34128493e-02f, -1.28552794e-01f, -1.12292066e-01f, 2.31998488e-02f, -1.56996682e-01f,
  -1.84536278e-01f, 5.16599566e-02f, 1.65477972e-02f, 1.31932229e-01f, -6.36670366e-02f, 1.48050293e-01f, 7.65701458e-02f, 1.09832004e-01f, 1.46981239e-01f, 1.78235173e-02f,
  8.94733667e-02f, 2.50763167e-02f, 4.24289219e-02f, -3.09800077e-02f, 5.14963269e-03f, 8.94858167e-02f, 1.40431270e-01f, -1.33756269e-02f, -2.92705605e-03f, 1.33605361e-01f,
  2.95242984e-02f, 5.54745607e-02f, -1.05778202e-02f, 8.25419351e-02f, 2.26446035e-04f, 7.15940148e-02f, 1.90326828e-03f, -2.17728559e-02f, 8.02351534e-02f, 6.22027293e-02f,
  -1.18019968e-01f, -2.12703994e-03f, 2.85060368e-02f, 1.59997325e-02f, 7.23221630e-04f, 1.51569219e-02f, -4.59864177e-02f, -1.17982626e-01f, -2.23249439e-02f, -6.43495917e-02f,
  2.08080262e-02f, -5.15081957e-02f, -1.41896559e-02f, -1.56242788e-01f, -4.51984927e-02f, -9.21736881e-02f, 3.44790407e-02f, -8.47459286e-02f, -1.04065491e-02f, -3.69426049e-02f,
  1.29415952e-02f, -1.32426142e-03f, -4.82531413e-02f, -6.41617626e-02f, -5.05494326e-02f, -1.41338095e-01f, -1.04568243e-01f, 1.70477852e-02f, -3.73815820e-02f, -1.19761871e-02f,
  -2.72601545e-02f, 1.64226264e-01f, 1.05801135e-01f, 7.83541352e-02f, -1.40203014e-02f, 5.78549504e-02f, 2.29001474e-02f, 1.12794042e-01f, 1.56420127e-01f, -9.79031995e-03f,
  3.51995863e-02f, 1.77452073e-03f, 2.33573187e-02f, 3.61013301e-02f, -1.08191492e-02f, 2.36743689e-02f, 1.07325420e-01f, 7.75669366e-02f, 1.33821279e-01f, 2.52892748e-02f,
  8.56553838e-02f, 8.73700529e-02f, 1.26107514e-01f, 1.27051935e-01f, 5.76687381e-02f, 9.67445448e-02f, 1.24970384e-01f, 1.53272063e-01f, 1.13994494e-01f, 9.22301337e-02f,
  -2.43974254e-01f, -2.00451940e-01f, -2.27350190e-01f, -1.72050521e-01f, -3.77511196e-02f, 2.52803508e-02f, -1.58720285e-01f, -1.21910423e-02f, -1.22960079e-02f, -1.68191671e-01f,
  -4.93844859e-02f, 2.05189615e-01f, 4.74555343e-02f, 9.05036032e-02f, -2.03265380e-02f, -8.67399201e-02f, -1.62505060e-01f, -3.60427983e-02f, 1.27695873e-01f, 4.01640162e-02f,
  -8.57417211e-02f, -1.77766338e-01f, -1.85440525e-01f, -1.10180236e-01f, -5.33095784e-02f, 5.08862883e-02f, -1.85701668e-01f, -2.20570982e-01f, -7.91090950e-02f, -2.90049642e-01f,
  6.15926087e-02f, -6.46450222e-02f, 1.14151604e-01f, 9.32523757e-02f, 3.72410752e-02f, 5.91563620e-02f, -3.27935591e-02f, 6.89121485e-02f, 3.11066303e-02f, -1.50356637e-02f,
  2.62093730e-02f, -2.67290380e-02f, 3.18988226e-02f, -2.99747549e-02f, 3.15083750e-02f, -9.06962156e-03f, 6.38432382e-03f, -5.62238209e-02f, 8.98623168e-02f, 4.79686912e-03f,
  2.13675182e-02f, -1.21265762e-01f, -1.25501111e-01f, -1.36772105e-02f, 4.79174629e-02f, 7.93555230e-02f, 4.75838706e-02f, 7.28167742e-02f, -1.34387678e-02f, -1.46826863e-01f,
  5.42705394e-02f, 3.96591090e-02f, -1.08665355e-01f, -1.04060650e-01f, -8.77829716e-02f, 6.81994250e-03f, -9.90341678e-02f, -1.24109514e-01f, -9.45556313e-02f, -3.17569748e-02f,
  -6.50333613e-02f, -4.09920663e-02f, 1.48428902e-02f, -4.86387238e-02f, -3.87889966e-02f, -5.34003899e-02f, -1.23943418e-01f, -7.38952756e-02f, 5.59968501e-02f, 1.94975995e-02f,
  -4.03441079e-02f, -3.65408361e-02f, -1.11222863e-01f, 2.46902648e-02f, -4.59473729e-02f, -7.13462830e-02f, 1.06058847e-02f, 2.25657467e-02f, 2.12497078e-03f, 7.04229474e-02f,
  4.53803949e-02f, 6.46852478e-02f, 1.12509936e-01f, 1.57422289e-01f, -1.11515420e-02f, 5.38898893e-02f, 5.39025366e-02f, 3.01406346e-02f, 1.32035855e-02f, -3.77886333e-02f,
  3.31641063e-02f, 4.32410836e-02f, -4.72557032e-03f, -2.17268635e-02f, 7.95312077e-02f, 1.32489592e-01f, -3.71103399e-02f, 5.37694693e-02f, 9.83029082e-02f, 1.78859476e-02f,
  3.33361067e-02f, 1.98041946e-02f, 9.58798528e-02f, 7.88669661e-02f, 9.38992575e-02f, 7.14021251e-02f, 9.84941423e-02f, 4.39060889e-02f, 8.52441788e-02f, -2.80341040e-03f,
  -1.99921459e-01f, -2.08164796e-01f, 1.12582810e-01f, -8.68329406e-02f, 1.56111419e-01f, 2.19593570e-01f, 1.59512773e-01f, -1.00909770e-02f, -1.60100028e-01f, -3.80487032e-02f,
  8.74201506e-02f, 5.48778586e-02f, 6.37365803e-02f, 1.88160852e-01f, 6.55652210e-02f, 6.64745644e-02f, -1.14392079e-02f, 2.72368908e-01f, 3.29088002e-01f, 4.79532629e-02f,
  -6.52305186e-02f, 1.83597058e-02f, 6.59641400e-02f, -3.41623612e-02f, -1.59598246e-01f, -8.29045847e-02f, -1.21492893e-01f, -4.13697995e-02f, -9.78045836e-02f, -2.09971502e-01f,
  2.04719231e-01f, -2.62654692e-01f, 2.46609896e-01f, 3.40521708e-02f, 4.45016846e-02f, 6.70400541e-03f, -7.82518275e-03f, -4.58570383e-02f, 2.70436499e-02f, -5.30417785e-02f,
  3.21864747e-02f, 2.81490549e-03f, -7.26849139e-02f, -8.07922930e-02f, -1.04901798e-01f, 2.75591128e-02f, -1.40910745e-01f, -4.32556048e-02f, -2.63120122e-02f, -7.62721151e-02f,
  -8.40113908e-02f, 7.44119380e-03f, 1.41411379e-01f, 4.17468213e-02f, 5.05127907e-02f, 1.39610499e-01f, -1.69018302e-02f, -9.96163487e-02f, -8.28282628e-03f, -8.68461803e-02f,
  7.67935365e-02f, 3.35404277e-02f, 7.53738871e-03f, -1.06031694e-01f, -2.82418951e-02f, -1.88365486e-02f, 3.85662317e-02f, 5.88587113e-02f, -5.94417155e-02f, -2.22310866e-03f,
  2.74670236e-02f, 1.83875915e-02f, -2.68937945e-02f, -4.43234816e-02f, 3.16825509e-02f, -6.76670820e-02f, -3.50725129e-02f, 3.53652611e-02f, -6.38873652e-02f, -3.55511606e-02f,
  -6.60194755e-02f, -2.42567919e-02f, -7.61147439e-02f, -1.53067648e-01f, -9.42864865e-02f, 1.02177840e-02f, -5.35687469e-02f, 3.86131778e-02f, -5.26237860e-02f, -9.54238251e-02f,
  7.99675880e-04f, 2.82734394e-01f, 1.02133248e-02f, -5.70422597e-02f, 6.60451176e-03f, 1.68776680e-02f, 7.92516097e-02f, 5.84857576e-02f, 1.49563495e-02f, 3.14625278e-02f,
  1.62839163e-02f, 7.90487602e-02f, 7.23626837e-02f, 9.76069830e-03f, 1.12311311e-01f, -3.96734178e-02f, 6.53496757e-02f, 4.28145900e-02f, 5.45466244e-02f, -1.08621709e-01f,
  -4.98994254e-02f, 6.81893378e-02f, 1.95272207e-01f, 2.00427026e-01f, -9.85143520e-03f, 2.34853163e-01f, 2.07873985e-01f, 1.49963692e-01f, 2.78488725e-01f, 1.06262550e-01f,
  -1.97170898e-01f, 1.35830581e-01f, 2.65822440e-01f, -2.27470800e-01f, -1.11956775e-01f, -2.40815263e-02f, 5.86139932e-02f, -1.11927450e-01f, -1.60057738e-01f, 1.25030994e-01f,
  8.76611397e-02f, 1.83874741e-02f, 2.89375167e-02f, 4.77469377e-02f, 1.07565606e-02f, 1.51554823e-01f, 7.09037632e-02f, 2.58554220e-02f, -9.32551399e-02f, -3.79867181e-02f,
  -5.52015826e-02f, -2.28469640e-01f, -2.33844489e-01f, -5.71454614e-02f, 4.72196005e-02f, 3.96150723e-02f, 2.83240788e-02f, 6.87567070e-02f, 6.32872432e-02f, 2.18808621e-01f,
  2.77057469e-01f, 4.56917286e-02f, -3.86175215e-02f, -6.71065897e-02f, 5.20586036e-03f, -6.49098083e-02f, 6.60458114e-03f, -5.67890555e-02f, 1.49010802e-02f, -4.70318422e-02f,
  -3.30813192e-02f, -8.76217615e-03f, -7.49524534e-02f, -2.42313240e-02f, -7.42102638e-02f, 2.11137775e-02f, -9.40525681e-02f, -1.44266943e-02f, -8.70273355e-03f, 7.25666136e-02f,
  -7.23155169e-03f, 7.02780411e-02f, 1.29477587e-02f, -1.63266975e-02f, 4.45635170e-02f, -4.94669005e-02f, 8.51922110e-02f, 1.85635760e-02f, -6.97743893e-02f, 9.16290842e-03f,
  -5.62769882e-02f, 8.66708979e-02f, -5.67644946e-02f, 3.42782736e-02f, -1.63065195e-02f, 1.17898859e-01f, -1.83752347e-02f, -4.85369610e-03f, -6.93215355e-02f, -4.18606475e-02f,
  -5.47213154e-03f, 1.17424957e-01f, -2.36352403e-02f, 2.21321676e-02f, -5.54100759e-02f, -7.37003423e-03f, 5.65133467e-02f, 2.56900955e-02f, 5.14562987e-02f, 9.99448672e-02f,
  9.72857792e-03f, 7.84841308e-04f, -1.30468700e-02f, -2.80565396e-02f, 8.85975957e-02f, 4.05353718e-02f, -7.55944476e-02f, 6.36839867e-02f, 4.06111917e-03f, -5.07978424e-02f,
  -1.59409881e-01f, -1.84498996e-01f, 1.07221007e-01f, -3.50616537e-02f, -5.04807085e-02f, -5.46217002e-02f, -1.32383898e-01f, -1.07593238e-01f, -2.35331990e-03f, 4.18621190e-02f,
  -4.39732708e-02f, -1.15462139e-01f, 5.80707658e-03f, -1.02083623e-01f, -9.92165357e-02f, -7.67940804e-02f, -1.91824943e-01f, -5.45650944e-02f, -4.72234115e-02f, -5.98001815e-02f,
  -1.55835107e-01f, -1.14531144e-01f, -1.11218326e-01f, -6.80464208e-02f, 7.34927366e-03f, -1.51036233e-01f, 1.21177342e-02f, -5.95418587e-02f, -1.15293980e-01f, -1.74810916e-01f,
  1.57582745e-01f, 1.59408495e-01f, -6.04762845e-02f, 1.13993004e-01f, 5.66502213e-02f, 7.29836673e-02f, 2.32814983e-01f, -3.95015515e-02f, -7.03707337e-02f, 1.04990184e-01f,
  8.34739208e-02f, 4.24120314e-02f, -1.02497198e-01f, -8.13828874e-03f, -4.49160896e-02f, -7.81871285e-03f, 1.17524579e-01f, -1.35040075e-01f, -3.89727093e-02f, 1.05795048e-01f,
  1.73325747e-01f, 1.21807583e-01f, -6.44222870e-02f, -1.38772987e-02f, 5.22988997e-02f, 1.15432516e-02f, -7.94786289e-02f, -7.77093694e-02f, -2.65472010e-02f, 1.36976257e-01f,
  4.28093672e-02f, -3.41578089e-02f, -3.71704362e-02f, 4.76589128e-02f, -7.94175416e-02f, -5.64536899e-02f, -4.53852303e-03f, -1.04657598e-01f, -1.05262332e-01f, -3.18570674e-04f,
  -5.36662564e-02f, -3.43678817e-02f, -1.14960916e-01f, 2.61618979e-02f, 8.73368524e-04f, -4.64479886e-02f, -3.75123806e-02f, -1.35867774e-01f, -1.55282691e-01f, -5.56416512e-02f,
  1.10809594e-01f, 4.66342904e-02f, -7.30943605e-02f, -1.21714827e-03f, -6.42728731e-02f, -1.50958709e-02f, -1.47041246e-01f, -1.64657701e-02f, -6.45212308e-02f, -5.11476994e-02f,
  -1.11496318e-02f, 9.45363287e-03f, 6.71726838e-02f, 6.49545118e-02f, 4.49628346e-02f, -1.72804464e-02f, 6.12105653e-02f, 1.00241795e-01f, 7.65783265e-02f, -2.98627969e-02f,
  7.96448588e-02f, -3.69330123e-02f, -1.47645725e-02f, 1.68979098e-03f, 4.60302428e-04f, 4.09324095e-02f, -1.85975106e-03f, 9.90219042e-03f, -2.41101272e-02f, -5.07376753e-02f,
  7.40403533e-02f, -3.15846093e-02f, 4.49360199e-02f, -7.84815997e-02f, -4.55696285e-02f, -3.10967639e-02f, 2.93593202e-02f, 5.35201393e-02f, 1.22504085e-01f, 2.31445450e-02f,
  -2.84282807e-02f, -1.12300217e-01f, -3.97909395e-02f, -6.89257905e-02f, 9.24028754e-02f, -4.12065163e-02f, -5.59266545e-02f, -2.46420950e-02f, 2.37685703e-02f, 4.42161299e-02f,
  2.32984498e-02f, 2.30619274e-02f, 2.56806780e-02f, -1.25691555e-02f, 2.70029008e-02f, 2.19154004e-02f, 6.55332282e-02f, 9.21492428e-02f, -4.79462221e-02f, 2.52776127e-02f,
  -3.49838007e-03f, 1.41172305e-01f, 6.00414090e-02f, -5.27514964e-02f, -1.28240690e-01f, 9.21287164e-02f, 1.71266887e-02f, -5.09908125e-02f, 8.40636566e-02f, 1.50102109e-01f,
  1.89343810e-01f, 1.03374057e-01f, -6.45218939e-02f, -1.59927323e-01f, -1.17584355e-01f, -1.10101208e-01f, -3.20705064e-02f, 5.89718558e-02f, 4.10927050e-02f, -4.56388332e-02f,
  4.55763973e-02f, 1.27147272e-01f, 6.68370053e-02f, 1.12053387e-01f, 2.01297075e-01f, -2.01984897e-01f, -2.35062242e-01f, -5.04545048e-02f, -4.29699272e-02f, -4.00073640e-02f,
  -8.04493427e-02f, -8.94927308e-02f, -2.88960934e-02f, 6.07685335e-02f, -2.90524304e-01f, -1.50416911e-01f, -2.11379841e-01f, -1.51301295e-01f, -1.44009620e-01f, -3.09729010e-01f,
  -1.84975415e-01f, 1.40541494e-01f, 3.61625180e-02f, 9.65804160e-02f, -7.56288394e-02f, 1.28525216e-02f, -3.93780656e-02f, 5.17710671e-03f, -1.02139665e-02f, -1.78739224e-02f,
  7.81246927e-03f, -1.53250741e-02f, -3.68951894e-02f, -2.85990071e-02f, 4.08612452e-02f, 6.93446472e-02f, 1.31676137e-01f, 2.22864151e-02f, 3.89282173e-03f, -5.19770160e-02f,
  -7.39063174e-02f, -2.38749862e-01f, -1.95961535e-01f, 2.32541896e-02f, 5.83047532e-02f, -6.14502467e-02f, -1.55020624e-01f, -1.59043059e-01f, 1.86414924e-02f, -1.58260196e-01f,
  -9.07499343e-02f, -1.03348620e-01f, 1.14888608e-01f, 8.66033509e-02f, 2.54555400e-02f, -5.40517410e-03f, -5.73828518e-02f, 1.46914227e-03f, 8.52564257e-03f, 1.32247610e-02f,
  2.66829077e-02f, 5.51773459e-02f, 1.61274299e-02f, -8.13994557e-02f, 1.34834358e-02f, 3.35789435e-02f, -2.60004234e-02f, -1.70543827e-02f, -3.26222666e-02f, 2.72881929e-02f,
  3.16264741e-02f, 2.89034355e-03f, -7.75964037e-02f, 4.57843579e-02f, -4.22699414e-02f, 8.75584707e-02f, -2.64643002e-02f, 1.32064357e-01f, 1.22139573e-01f, -4.54549119e-02f,
  3.94899882e-02f, 1.23053938e-01f, -9.86130685e-02f, 9.20181870e-02f, -8.17374364e-02f, -8.19100365e-02f, -8.22354481e-02f, -3.62627059e-02f, -2.08789688e-02f, -5.81728183e-02f,
  6.82798726e-03f, -1.91468727e-02f, 9.60749574e-03f, 1.05249723e-02f, -6.90976903e-02f, -3.95681486e-02f, -4.09102328e-02f, -1.20210730e-01f, -6.47744238e-02f, -7.05288202e-02f,
  -5.31916991e-02f, -1.28179774e-01f, -8.91548991e-02f, -1.76986665e-01f, -1.67471886e-01f, -2.89713275e-02f, -1.68724537e-01f, -1.59172863e-01f, -1.71168998e-01f, -2.73601174e-01f,
  5.02489924e-01f, -2.45726496e-01f, -1.40643984e-01f, 1.76763624e-01f, 4.59606061e-03f, 2.30514184e-02f, -1.49498209e-02f, 1.23537794e-01f, 1.49570972e-01f, 1.82519592e-02f,
  4.30900529e-02f, 2.38806814e-01f, 1.53993860e-01f, 1.23146966e-01f, 7.95165002e-02f, -1.04434174e-02f, -4.90344316e-03f, 2.57328779e-01f, 3.32286805e-01f, 2.17157453e-01f,
  1.72248157e-03f, 8.58953521e-02f, 1.12212382e-01f, 8.65870342e-02f, -1.44760489e-01f, 1.22546978e-01f, -1.20860219e-01f, -3.38149257e-02f, -1.49908185e-01f, -2.51054168e-01f,
  9.23305005e-02f, -1.13031253e-01f, 1.73217848e-01f, 1.71537593e-01f, 7.87641406e-02f, 1.69432759e-01f, 1.04290552e-01f, 9.57640857e-02f, 7.89168999e-02f, 2.95454934e-02f,
  5.13816625e-02f, 1.38659209e-01f, 1.01599107e-02f, 5.85014932e-02f, 5.68327010e-02f, 9.17904824e-02f, -4.07010242e-02f, 1.36056617e-01f, 1.27953678e-01f, -2.55430043e-02f,
  -6.60692602e-02f, -4.95579652e-02f, 1.46582425e-01f, 8.66423026e-02f, 9.71771404e-02f, 2.38590911e-01f, -3.28422748e-02f, 3.30964997e-02f, 1.60454497e-01f, 1.43710569e-01f,
  1.81664392e-01f, -3.64658103e-04f, -1.37959003e-01f, 2.00683214e-02f, -2.58208979e-02f, -1.30013421e-01f, -1.00384697e-01f, 1.58377159e-02f, 5.38618490e-02f, 7.83107337e-03f,
  -1.29474908e-01f, -9.89734754e-02f, -4.44360673e-02f, 2.61019059e-02f, -9.19968709e-02f, -9.69348475e-02f, -8.46371204e-02f, -1.12694331e-01f, -1.17489673e-01f, -8.06769058e-02f,
  -4.74602208e-02f, -1.72618091e-01f, -7.94034526e-02f, -3.06668822e-02f, -1.85266644e-01f, -4.66309525e-02f, -8.94321129e-02f, -9.03886110e-02f, 1.71633121e-02f, -9.92758721e-02f,
  2.70410568e-01f, 1.92998841e-01f, 1.35224819e-01f, 1.01527967e-01f, 5.23508452e-02f, 1.21954000e-02f, 6.57165423e-02f, 7.81985596e-02f, 1.07792616e-01f, 9.90108177e-02f,
  1.05084389e-01f, 2.01536044e-01f, 7.40388408e-02f, 1.35351643e-01f, 2.12030664e-01f, 7.53223002e-02f, 5.85951731e-02f, 1.49028167e-01f, 5.22607230e-02f, -9.15507227e-03f,
  1.63395420e-01f, 1.40039504e-01f, 2.96075076e-01f, 2.72333682e-01f, 1.99816674e-01f, 3.28169644e-01f, 1.45755038e-01f, 2.32180431e-01f, 2.34136403e-01f, 2.93629020e-01f,
  6.19142413e-01f, 9.02763903e-02f, -3.45943838e-01f, 2.22078770e-01f, -2.67683119e-01f, -3.87794226e-01f, -4.28262949e-01f, -2.11384594e-01f, 1.40009761e-01f, -6.86010569e-02f,
  -5.59142642e-02f, 1.06849395e-01f, 1.03222430e-01f, 1.01202399e-01f, -4.44994904e-02f, -2.62121290e-01f, -1.74434543e-01f, -3.02928220e-03f, -1.82824582e-01f, -7.27868900e-02f,
  1.16225397e-02f, 7.21492544e-02f, 1.04171038e-01f, -1.35101452e-02f, 9.99481082e-02f, -2.88298149e-02f, -1.86303899e-01f, -3.83866169e-02f, -2.09725618e-01f, 1.51904523e-01f,
  -4.87542786e-02f, -8.64870660e-03f, -1.77441284e-01f, -8.73519294e-03f, -1.38649181e-01f, -8.29655975e-02f, -8.17523599e-02f, -1.23477697e-01f, -7.05629438e-02f, -7.95922056e-02f,
  -1.12090483e-01f, 2.09569577e-02f, -9.02245864e-02f, -8.45333040e-02f, -2.07192749e-01f, -7.87827671e-02f, -4.27284054e-02f, -2.21172702e-02f, -9.89511535e-02f, -3.48489988e-03f,
  -2.25749891e-02f, -2.12665513e-01f, -1.79665074e-01f, -2.73890078e-01f, -1.20924383e-01f, -1.22832239e-01f, -1.37265190e-01f, -6.66966066e-02f, -1.24234147e-01f, -2.54869275e-02f,
  -3.16700414e-02f, 8.98606628e-02f, -3.62801105e-02f, 3.54544148e-02f, 9.49589759e-02f, -3.02726775e-02f, -8.97140801e-03f, -5.96625544e-02f, 6.63448721e-02f, 7.58880749e-03f,
  6.40148446e-02f, -2.50709634e-02f, 2.41475496e-02f, -7.58632645e-03f, 6.20672815e-02f, -6.70972764e-02f, -2.86756419e-02f, 7.39691183e-02f, -1.36356344e-02f, 1.19952708e-01f,
  4.07172889e-02f, -4.23140712e-02f, 1.38324006e-02f, -2.51800045e-02f, -5.06645776e-02f, -4.23182994e-02f, 9.78293195e-02f, -9.07683652e-03f, 5.52335680e-02f, 5.60815409e-02f,
  5.36996983e-02f, -2.11692870e-01f, 9.33769867e-02f, -5.15819341e-02f, -4.77677137e-02f, -2.84934398e-02f, 8.35700892e-03f, -6.71926439e-02f, -2.29832195e-02f, 2.47362200e-02f,
  -9.75986198e-02f, -8.06238875e-02f, -7.27920383e-02f, 1.61913000e-02f, -1.38037279e-01f, -1.46957353e-01f, 2.53054360e-03f, -8.79153796e-03f, -1.51252106e-01f, -6.50379732e-02f,
  -2.63575315e-02f, -4.03382294e-02f, 2.10825521e-02f, -8.65962356e-02f, -1.54519379e-01f, -2.36875638e-02f, -1.01811655e-01f, -1.69993341e-01f, -1.93897203e-01f, -9.01556909e-02f,
  -1.20210819e-01f, 3.97681504e-01f, 3.06217015e-01f, -1.35689855e-01f, -2.27286443e-01f, -3.78598049e-02f, 2.46091917e-01f, 3.27534825e-02f, -2.15818211e-01f, 1.16313040e-01f,
  1.47071123e-01f, -3.02829593e-01f, -1.30495399e-01f, -5.38487360e-02f, 4.39340211e-02f, 3.13007146e-01f, 1.43809929e-01f, -1.29682958e-01f, -2.53147364e-01f, -1.71096787e-01f,
  -7.73140565e-02f, -7.71888644e-02f, 2.00123414e-02f, -5.09840362e-02f, -4.60100211e-02f, -2.64903337e-01f, 2.28944764e-01f, 6.28299639e-02f, 1.98188588e-01f, 7.98624456e-02f,
  1.75562367e-01f, 2.00826660e-01f, -1.43586248e-01f, -9.02724490e-02f, -5.58835268e-02f, -5.69316596e-02f, -7.76105300e-02f, 4.03555967e-02f, -7.14085475e-02f, -4.78033349e-02f,
  9.72387660e-03f, -2.30248086e-02f, -5.40530719e-02f, 6.53519258e-02f, 4.01691906e-02f, -4.19639461e-02f, 5.89029863e-02f, 1.02977797e-01f, -3.30595039e-02f, 8.36973265e-02f,
  -4.33767587e-02f, 2.24168245e-02f, 1.34096548e-01f, -1.85718276e-02f, 1.85166448e-02f, -1.79789841e-01f, 4.51503089e-03f, -1.65077690e-02f, 4.30762023e-02f, 6.98636621e-02f,
  9.64396913e-03f, 5.80685064e-02f, 3.83053981e-02f, 8.47002044e-02f, 6.15516193e-02f, 1.43006481e-02f, 4.16166410e-02f, 3.12212203e-02f, 2.15632431e-02f, 8.02582577e-02f,
  6.22978397e-02f, 1.19206943e-01f, 7.79129416e-02f, 6.99842721e-02f, 3.93509585e-03f, 1.92108732e-02f, 1.78374238e-02f, 7.68579617e-02f, 6.31720647e-02f, 5.93053214e-02f,
  3.64522561e-02f, 2.48786155e-02f, -3.57008129e-02f, 3.96933742e-02f, 2.96383128e-02f, -2.01982912e-02f, -7.23017529e-02f, 5.17000481e-02f, -2.75254752e-02f, 1.75741762e-02f,
  -1.61831677e-02f, -7.28896335e-02f, -6.75459728e-02f, 4.09378037e-02f, -1.87886432e-02f, 2.72167511e-02f, 1.16601558e-02f, -6.38864487e-02f, -5.82360569e-03f, -3.92850414e-02f,
  -5.88640943e-02f, 8.81731734e-02f, 7.53060803e-02f, 6.47102520e-02f, -1.06620140e-01f, -7.30688348e-02f, 5.23955487e-02f, -6.43463805e-02f, -5.34702204e-02f, -8.64750445e-02f,
  8.42624158e-02f, -2.59449575e-02f, 3.83306071e-02f, 9.11910906e-02f, 1.60928909e-02f, -9.47726965e-02f, 8.07036310e-02f, -9.66591295e-03f, -8.23662896e-03f, 7.28469342e-02f,
  1.18104748e-01f, 2.98019916e-01f, 1.87286139e-01f, -3.76229957e-02f, -1.88525617e-01f, -5.49966767e-02f, 1.39068142e-01f, 6.88930601e-02f, -1.66078478e-01f, 1.43946871e-01f,
  -8.54280666e-02f, -3.00275445e-01f, -5.69256656e-02f, -1.11749195e-01f, -1.19515643e-01f, 1.98853359e-01f, 6.75569847e-02f, -2.40991071e-01f, -3.13101679e-01f, -2.82581747e-01f,
  -2.48923823e-01f, -1.13956779e-01f, 6.22507483e-02f, -8.99414048e-02f, -1.19056553e-01f, -3.24799240e-01f, 1.88980564e-01f, 1.29758322e-03f, -6.81328680e-03f, -7.32594505e-02f,
  -5.80127016e-02f, 2.37934873e-01f, -2.07102373e-01f, -8.13872218e-02f, 9.06783715e-02f, 2.58021131e-02f, 3.72376107e-02f, 3.48011851e-02f, 1.02439620e-01f, 6.94343746e-02f,
  -3.77655700e-02f, -4.87628300e-03f, 6.22394048e-02f, -2.58797146e-02f, 9.11988840e-02f, -4.05915529e-02f, 6.82461411e-02f, 5.04980162e-02f, 5.94853535e-02f, 1.08990990e-01f,
  -1.62423640e-01f, -8.85210037e-02f, -3.77145186e-02f, -4.84612444e-03f, 2.75686570e-02f, -1.67808846e-01f, 9.13543254e-03f, -1.04006037e-01f, 4.92565893e-02f, 1.22211412e-01f,
  -5.55047467e-02f, 1.41955409e-02f, -3.85567956e-02f, -4.16218378e-02f, 4.29017358e-02f, 4.57761735e-02f, 1.38328932e-02f, -8.04546326e-02f, -5.83587028e-02f, 5.77034205e-02f,
  -7.46987388e-03f, -1.26744136e-02f, -1.73677411e-02f, -1.47668854e-03f, -6.12972192e-02f, -8.63351151e-02f, -4.59927656e-02f, 4.22468968e-03f, 5.42466762e-03f, 9.23557803e-02f,
  -4.32409309e-02f, -5.75715415e-02f, 4.97188196e-02f, -1.92514136e-02f, -1.19112814e-02f, -7.91305378e-02f, -6.20201789e-02f, 4.85475129e-03f, -1.29455522e-01f, 2.49800496e-02f,
  5.64364456e-02f, -5.80044873e-02f, 4.09120433e-02f, 2.04949453e-03f, 2.53475476e-02f, -6.95684701e-02f, -9.41370726e-02f, -7.35204667e-02f, -7.08401725e-02f, 1.74281262e-02f,
  -8.47483128e-02f, -7.79257296e-03f, 9.99428853e-02f, -3.02562825e-02f, -3.25408019e-02f, 2.62659471e-02f, -1.98256373e-02f, -6.50767609e-02f, -1.13437794e-01f, -6.52382225e-02f,
  -4.83252034e-02f, -9.65872779e-02f, -1.37534037e-01f, -7.89944977e-02f, -1.29726708e-01f, -2.45758533e-01f, -8.14523920e-02f, -1.69666596e-02f, -1.17032137e-02f, 1.66625634e-01f,
  -2.71441460e-01f, 6.23699836e-02f, 4.17520888e-02f, -9.57689658e-02f, -5.91461286e-02f, -9.98338982e-02f, -1.82569250e-01f, -5.35688624e-02f, 7.07527325e-02f, 1.04218349e-01f,
  1.06604211e-01f, 3.72331211e-04f, 1.56330392e-01f, 1.31709799e-01f, -1.02004604e-02f, 1.15435101e-01f, 1.44110769e-01f, -1.00318685e-01f, -1.60170391e-01f, -1.18214764e-01f,
  9.03751627e-02f, 1.19574346e-01f, 2.11394001e-02f, 3.67886052e-02f, 4.63237613e-02f, 1.58079892e-01f, 1.58966929e-01f, -1.53611042e-02f, -6.29063509e-03f, 1.85803100e-01f,
  1.67383507e-01f, -1.98846847e-01f, 1.28953412e-01f, 1.22240119e-01f, 1.36878088e-01f, 7.97311496e-03f, 1.12064168e-01f, 6.93760514e-02f, 9.92143899e-02f, 1.44861955e-02f,
  1.27026245e-01f, 4.41434421e-02f, -4.49751802e-02f, 7.14472905e-02f, -6.56571463e-02f, 3.93785164e-02f, 7.19674081e-02f, 2.35054586e-02f, -2.67728860e-03f, 2.21715122e-02f,
  1.18447296e-01f, -7.74786100e-02f, -1.00012772e-01f, 1.28977403e-01f, -2.82478575e-02f, 4.58611771e-02f, 2.52665207e-02f, -4.47930507e-02f, 8.80144238e-02f, 4.69945930e-02f,
  7.55142197e-02f, -3.42313163e-02f, -1.43364847e-01f, -5.50849177e-02f, -9.81188715e-02f, -1.16937496e-01f, -9.61763710e-02f, -3.78593355e-02f, -1.82071537e-01f, -9.91636142e-02f,
  -5.33497371e-02f, -1.54840469e-01f, -1.57681629e-01f, -8.31525028e-02f, -6.29348159e-02f, -1.33316249e-01f, -5.73724881e-02f, -3.15160491e-02f, -1.17545858e-01f, -1.26047254e-01f,
  -9.65790227e-02f, -1.22006260e-01f, -1.58009436e-02f, -1.19071104e-01f, -9.37087983e-02f, -1.30990088e-01f, -1.11611329e-01f, -1.66426674e-01f, -9.49330032e-02f, -1.34449840e-01f,
  2.39407659e-01f, -5.82422651e-02f, 9.79544222e-02f, 1.03048738e-02f, 1.22553699e-01f, 1.13361292e-01f, 9.13002342e-02f, 1.50330648e-01f, 1.16839655e-01f, 1.21307202e-01f,
  5.04425615e-02f, 5.93329705e-02f, 6.60783276e-02f, 3.99452820e-02f, 8.95674080e-02f, 8.81854519e-02f, 2.08271697e-01f, 3.99600267e-02f, 1.48266092e-01f, 1.23855174e-01f,
  2.09281102e-01f, -1.79999992e-02f, 8.30583945e-02f, 1.32683173e-01f, 3.69541682e-02f, 4.91675921e-02f, 9.04789567e-02f, 1.69721231e-01f, 1.70271713e-02f, 2.72524804e-01f,
  -6.09307349e-01f, 6.17656931e-02f, 1.64139628e-01f, -8.14134926e-02f, 8.63196850e-02f, 5.99136716e-03f, 3.67634483e-02f, -1.63011342e-01f, -1.60516113e-01f, -2.36898437e-02f,
  -4.25845198e-02f, 1.76385082e-02f, 6.87224120e-02f, -1.83171406e-02f, -1.00147046e-01f, 1.44593760e-01f, 5.56500256e-02f, -9.26933512e-02f, -1.62925929e-01f, -1.69457421e-01f,
  7.51936287e-02f, -1.16827406e-01f, -3.57805997e-01f, -1.57589197e-01f, 6.10852540e-02f, 1.14063270e-01f, 1.33137330e-01f, 1.05059948e-02f, 1.73954383e-01f, 3.28477561e-01f,
  1.32621273e-01f, -5.08524105e-02f, -9.40138176e-02f, 5.52668935e-03f, 2.47640423e-02f, -8.20348561e-02f, -1.43914027e-02f, -6.51809573e-02f, 6.47950917e-02f, 3.32819931e-02f,
  1.80620793e-02f, 2.42523476e-03f, -2.45705936e-02f, -6.02731667e-03f, -9.67611931e-03f, -1.04563206e-01f, -6.62154006e-03f, -1.41849428e-01f, -9.02016908e-02f, -5.68921752e-02f,
  6.83938563e-02f, -2.99051385e-02f, -1.10395946e-01f, 2.43097171e-02f, -1.11362837e-01f, -9.35826376e-02f, -4.24330588e-03f, -5.71187846e-02f, -1.35768101e-01f, -1.13075785e-02f,
  -1.92663297e-02f, -4.33263443e-02f, 3.52486856e-02f, -1.95772480e-02f, -2.41851937e-02f, 2.43245438e-02f, 6.18479475e-02f, 5.62108755e-02f, -7.62070790e-02f, 3.71999410e-03f,
  3.98990512e-02f, -9.97040328e-03f, 1.88314300e-02f, 1.91314798e-02f, 8.98697302e-02f, 1.96268186e-02f, 2.43595615e-02f, 5.79958446e-02f, -7.22380029e-03f, 3.78244817e-02f,
  -6.82378886e-04f, -3.08532082e-02f, 2.02486757e-03f, 3.74540761e-02f, 1.06267691e-01f, 1.65544525e-02f, -1.70159945e-03f, 9.10246279e-03f, -6.10536058e-03f, -2.03951001e-02f,
  -1.27506509e-01f, -1.50242865e-01f, 2.60500666e-02f, -5.42640164e-02f, 3.51948701e-02f, 1.58617657e-03f, 2.62548551e-02f, -4.87340130e-02f, -3.60562652e-02f, 5.31134848e-03f,
  -4.55890372e-02f, -1.54501021e-01f, -1.56476926e-02f, 6.12398461e-02f, -6.57736659e-02f, -4.74301539e-02f, -8.05508345e-02f, -1.73048247e-02f, -7.53773004e-02f, -6.23689294e-02f,
  -7.16494247e-02f, -1.20835878e-01f, -1.33513168e-01f, -7.03795254e-02f, -1.04650341e-01f, -1.80817723e-01f, 5.32169677e-02f, -1.03845797e-01f, -1.44002467e-01f, -1.81969091e-01f,
  9.05148238e-02f, -1.02747954e-01f, -6.85704276e-02f, -1.57762870e-01f, -1.14533022e-01f, -5.94978668e-02f, -2.32961960e-02f, -2.23654378e-02f, -9.20758322e-02f, 9.39178094e-02f,
  3.78266983e-02f, 4.97794487e-02f, -8.28753933e-02f, -5.28014090e-04f, 5.01428125e-03f, -1.18427902e-01f, -2.23837301e-01f, -1.11205123e-01f, -4.46262360e-02f, -1.35008782e-01f,
  -7.18805194e-02f, -1.95658028e-01f, -6.44124448e-02f, -1.76037803e-01f, -9.79939699e-02f, -1.69426631e-02f, -1.24272481e-01f, -1.59212217e-01f, -1.90744847e-01f, -1.41348660e-01f,
  1.26030281e-01f, -6.42469227e-02f, -4.53815125e-02f, -4.61747535e-02f, 8.03936943e-02f, 1.88328866e-02f, -3.60168479e-02f, -1.76754482e-02f, 9.53906924e-02f, -7.70281926e-02f,
  -5.80962561e-02f, -9.02612805e-02f, -2.85964664e-02f, -6.54525831e-02f, -5.81219941e-02f, 4.11202237e-02f, 3.52197886e-02f, -4.94845696e-02f, 2.46140640e-02f, 4.69179377e-02f,
  2.58113220e-02f, -9.47428346e-02f, 4.27835733e-02f, -4.15656157e-02f, -6.11871481e-02f, -5.48652820e-02f, 9.01858658e-02f, 4.03370224e-02f, 7.82380775e-02f, -4.18639183e-03f,
  6.08829781e-02f, 2.85667256e-02f, -9.94782448e-02f, -7.44950697e-02f, -9.71650556e-02f, -3.63297239e-02f, -9.73731279e-02f, -1.16697349e-01f, -1.05905250e-01f, -9.99192744e-02f,
  4.70682830e-02f, 6.37225807e-02f, -1.24952039e-02f, -4.32855412e-02f, 3.40920910e-02f, 1.02606798e-02f, 7.65359262e-03f, -5.19355871e-02f, -5.40567264e-02f, -1.31208319e-02f,
  8.42701178e-03f, 2.45478861e-02f, 1.89832617e-02f, -5.89049719e-02f, 5.96967675e-02f, -1.98953263e-02f, -5.55019341e-02f, -6.84763789e-02f, -3.03664636e-02f, 1.13793276e-02f,
  2.58190125e-01f, 1.48711324e-01f, -1.40985455e-02f, -1.01462945e-01f, -6.82078302e-02f, -3.03500285e-03f, -6.86603971e-03f, -2.17598360e-02f, -1.00072175e-01f, -1.00715287e-01f,
  -5.57248108e-02f, -7.27209076e-02f, -4.99856919e-02f, -6.42574877e-02f, -3.57279438e-03f, -1.61058512e-02f, 5.05522974e-02f, -6.90431073e-02f, -1.89483929e-02f, 7.66023770e-02f,
  -1.41467163e-02f, 3.54133174e-02f, 1.27721876e-01f, 2.88067479e-03f, -3.92942391e-02f, 3.15380134e-02f, -7.04534724e-02f, 5.47797829e-02f, 7.61861131e-02f, 9.48611423e-02f,
  5.01128852e-01f, 2.92640418e-01f, -2.10053660e-02f, 2.00474057e-02f, -1.54784560e-01f, -1.73536241e-02f, 1.65955484e-01f, 1.39069691e-01f, -4.55530994e-02f, -1.55450124e-02f,
  -1.23851135e-01f, -2.73124307e-01f, -2.14703470e-01f, -1.89643472e-01f, 1.32425845e-01f, 1.59538031e-01f, -4.36175168e-02f, 8.32006056e-03f, -1.50421553e-03f, -6.16112053e-02f,
  -1.97162211e-01f, 9.99424160e-02f, 1.99050367e-01f, 1.04003072e-01f, -9.20608491e-02f, -1.29119456e-01f, -2.84200795e-02f, -1.00978259e-02f, 8.61176290e-03f, 4.91324104e-02f,
  -4.75934967e-02f, 1.53459817e-01f, -1.81172505e-01f, -1.22428149e-01f, -1.92060634e-01f, 4.05319408e-02f, -5.81820086e-02f, -5.84963933e-02f, -3.32189016e-02f, 4.85033579e-02f,
  -1.26151904e-01f, 3.59309861e-03f, -1.72989964e-01f, -2.14101076e-02f, 7.73600191e-02f, 1.16744585e-01f, 1.05608717e-01f, 1.39004886e-01f, 3.24076973e-02f, 3.87450345e-02f,
  -9.36109871e-02f, -2.14440618e-02f, 8.41109529e-02f, 1.05809957e-01f, 8.33980814e-02f, -5.65460697e-03f, -4.91411053e-02f, 5.03975153e-02f, 9.91811529e-02f, 1.73801929e-01f,
  1.24809422e-01f, 7.81425983e-02f, 1.49199795e-02f, 1.92737989e-02f, 1.03128813e-01f, 3.93809117e-02f, 8.80166888e-02f, 7.54040778e-02f, -2.30009053e-02f, 7.88151845e-03f,
  -2.45277566e-04f, 1.26339681e-02f, 4.46384326e-02f, -5.44571467e-02f, -3.61621678e-02f, 8.71018246e-02f, -3.19559351e-02f, 4.43750769e-02f, -2.24434361e-02f, -2.13742033e-02f,
  -6.73525184e-02f, 3.12552601e-02f, -6.41374961e-02f, -2.78108511e-02f, -4.77254018e-02f, -3.05683464e-02f, 6.02301918e-02f, 8.54437053e-03f, 1.19031429e-01f, 6.38750345e-02f,
  -1.50561944e-01f, -1.65831327e-01f, -2.32762638e-02f, -4.25067693e-02f, -9.57778543e-02f, -1.35394037e-01f, -6.96861744e-02f, 1.91662572e-02f, -7.98612088e-02f, 1.93705852e-03f,
  -1.77326147e-02f, 1.62394643e-02f, -1.32650629e-01f, 1.56469848e-02f, -1.42981415e-03f, -1.12533092e-01f, 3.72676291e-02f, -3.82080488e-02f, -5.35432957e-02f, -4.10283953e-02f,
  1.87696293e-02f, -9.34036076e-03f, 8.42545405e-02f, -7.77678192e-02f, -1.79419890e-02f, -8.95610731e-03f, 6.42508566e-02f, 2.69162585e-04f, 9.24547464e-02f, 1.62882924e-01f,
  2.38924593e-01f, -2.06536233e-01f, -2.83707052e-01f, 3.67575228e-01f, 2.40907818e-01f, 9.20660049e-02f, -4.08333838e-02f, 1.86632842e-01f, 3.87255788e-01f, 3.20561640e-02f,
  2.05951333e-01f, 3.53159070e-01f, 1.13565035e-01f, -3.07813729e-03f, 2.19246279e-02f, -5.26646078e-02f, -1.41930178e-01f, 2.57329158e-02f, 5.94545789e-02f, 1.62371665e-01f,
  2.20182836e-01f, 1.05646245e-01f, 1.03610039e-01f, 1.44182265e-01f, 1.50816336e-01f, 3.17368984e-01f, 3.61709893e-02f, 3.75912562e-02f, -6.59247413e-02f, -6.62167966e-02f,
  -5.32301962e-02f, -1.37184441e-01f, 1.75736994e-01f, 1.08049460e-01f, -3.73511948e-02f, 1.27926186e-01f, 9.09764878e-03f, 3.97874750e-02f, 1.16141394e-01f, 5.39919995e-02f,
  8.97595137e-02f, 1.63693100e-01f, 4.97905016e-02f, 8.10777992e-02f, 1.49272503e-02f, 1.05871625e-01f, 6.64092600e-02f, -4.53034081e-02f, -6.96402229e-03f, 4.29547280e-02f,
  -3.11493278e-02f, 1.24950685e-01f, 3.28393057e-02f, -4.57307324e-02f, 5.05442405e-03f, 3.73692773e-02f, 7.87111279e-03f, 1.10548459e-01f, -4.39596809e-02f, 6.71847835e-02f,
  -2.24808902e-02f, -4.80210595e-03f, 4.06305753e-02f, 4.12922166e-02f, 2.60519721e-02f, 3.16743217e-02f, 1.81693956e-02f, 1.79195739e-02f, 4.94302996e-02f, -2.21490990e-02f,
  2.01953892e-02f, -1.10824920e-01f, -6.64774179e-02f, -7.87883401e-02f, 3.09236236e-02f, -9.72878933e-02f, -5.84337153e-02f, 1.56606751e-04f, -9.21801403e-02f, 3.12156696e-03f,
  -7.66572356e-02f, -8.33185092e-02f, 2.19352301e-02f, -1.13393836e-01f, -6.94093481e-02f, 4.89526754e-03f, 6.56349352e-03f, 2.56531164e-02f, 6.16738498e-02f, -3.03488951e-02f,
  3.39294314e-01f, -2.04378992e-01f, 7.79197887e-02f, 3.47030796e-02f, 2.77186129e-02f, 3.10527049e-02f, 7.03392401e-02f, 5.92645593e-02f, 1.06481723e-01f, 6.49325922e-02f,
  -2.68917009e-02f, 1.19780079e-01f, 2.59259082e-02f, 7.22801536e-02f, 1.71215862e-01f, 1.57798126e-01f, 1.29348725e-01f, 1.27609417e-01f, 2.65258062e-03f, 1.03730962e-01f,
  2.33759116e-02f, 1.79068908e-01f, 2.71323919e-01f, 1.41618103e-01f, 1.68639332e-01f, 1.86488211e-01f, 1.02348909e-01f, 1.47794157e-01f, 1.04263514e-01f, 2.68209219e-01f,
  -4.08165365e-01f, -4.46188897e-02f, -2.71595210e-01f, 9.98064652e-02f, 2.59402543e-01f, 1.59360498e-01f, 2.39732280e-01f, 1.66394919e-01f, 1.27388462e-01f, -2.43619419e-04f,
  -1.86147243e-01f, -2.03793868e-01f, -2.59738564e-01f, -4.91170436e-02f, -4.14470248e-02f, 8.34496245e-02f, 1.44122839e-01f, -7.42750689e-02f, 5.45584597e-02f, 1.89945504e-01f,
  1.96680069e-01f, 1.19403884e-01f, -1.38876200e-01f, -4.97269556e-02f, 1.59899384e-01f, -1.55135477e-02f, 1.26853678e-03f, -1.45399349e-03f, 1.38318876e-03f, 5.48501126e-02f,
  -1.02492757e-01f, -2.80857176e-01f, 2.00435892e-02f, -5.34120277e-02f, -6.73114508e-02f, -2.55523697e-02f, 1.67118553e-02f, -1.75033718e-01f, -1.41442372e-02f, -4.40263301e-02f,
  -1.48217782e-01f, -9.94405448e-02f, -1.39626727e-01f, -2.41205022e-02f, 2.09234143e-03f, -5.13947532e-02f, -1.41007885e-01f, -1.21357612e-01f, -6.54522032e-02f, -4.15839739e-02f,
  3.98188317e-03f, 5.57257570e-02f, -7.19104931e-02f, 1.42070502e-02f, -1.73305813e-02f, -1.21653333e-01f, 2.16453942e-03f, -3.21437838e-03f, -4.53367047e-02f, 3.72298732e-02f,
  1.21174932e-01f, -3.08528617e-02f, -8.55015591e-03f, -4.25634645e-02f, 2.74374220e-03f, -3.29602659e-02f, 4.67017032e-02f, 4.01812494e-02f, 6.53817952e-02f, -1.72742363e-02f,
  -8.65566656e-02f, -3.53279747e-02f, 1.64202135e-02f, -7.78713748e-02f, 4.59128469e-02f, -3.35014984e-02f, 2.55382843e-02f, 4.48699035e-02f, -9.12843943e-02f, -4.81677614e-02f,
  -6.44388944e-02f, 1.49291614e-03f, -2.27011144e-02f, -4.50605676e-02f, 2.81568263e-02f, -1.38499402e-02f, 7.68010542e-02f, -5.40459938e-02f, -1.30663542e-02f, -8.52246433e-02f,
  4.83970009e-02f, -1.62162557e-01f, -5.60973492e-03f, -1.22283138e-01f, 3.01439054e-02f, -1.13968439e-01f, -5.74767515e-02f, -7.30213448e-02f, -9.03097764e-02f, -6.75700456e-02f,
  -3.10814977e-02f, -1.26442254e-01f, -1.00648627e-01f, -7.01417476e-02f, -8.72825086e-03f, 6.84438273e-02f, 4.55812737e-02f, -3.60615067e-02f, 5.94795868e-02f, 2.37595160e-02f,
  4.30185813e-03f, 3.88141684e-02f, 3.11246365e-02f, 5.22562477e-05f, 9.23393592e-02f, 7.81276301e-02f, -5.39854951e-02f, 1.14319041e-01f, -7.38840103e-02f, 9.23842564e-02f,
  5.78205943e-01f, 4.12926257e-01f, -1.58466250e-02f, 8.38960782e-02f, -3.70060317e-02f, 1.30760312e-01f, 2.80374557e-01f, 1.36235431e-01f, 7.66626596e-02f, 1.27158508e-01f,
  -5.45072220e-02f, -1.43127531e-01f, -1.11223403e-02f, -7.54504353e-02f, 3.25785726e-02f, 2.41342023e-01f, 1.39062583e-01f, -1.36690304e-01f, -3.20059210e-01f, -1.54113680e-01f,
  -1.41385570e-01f, -5.19875064e-03f, -6.90936521e-02f, -5.78865558e-02f, -3.54293012e-03f, -1.70781776e-01f, 1.29702389e-01f, -7.41927838e-03f, -6.96183890e-02f, -1.43233553e-01f,
  -2.07442522e-01f, 1.74448937e-01f, -1.06239147e-01f, -4.18940820e-02f, -5.19322678e-02f, 1.20307587e-01f, 7.24297389e-02f, 4.89632748e-02f, -4.88355756e-03f, 9.60459262e-02f,
  4.40864861e-02f, -3.42596346e-03f, -5.25435572e-03f, 5.92800975e-02f, 7.03366175e-02f, -1.07747549e-02f, 6.72144666e-02f, -9.88342147e-03f, 2.16186848e-02f, -6.20734207e-02f,
  -3.73056643e-02f, 3.53286639e-02f, -5.81570715e-03f, 3.74029353e-02f, 4.18583117e-02f, -9.56016034e-02f, -2.74237688e-03f, 1.49914641e-02f, -3.67030986e-02f, 1.68810815e-01f,
  -7.03988373e-02f, -2.37016603e-02f, -7.48602152e-02f, -4.31371592e-02f, -3.01481574e-03f, -2.04258636e-02f, 6.73420131e-02f, 4.39722128e-02f, -8.19205418e-02f, 6.30592778e-02f,
  -3.80119309e-02f, -4.01530452e-02f, -1.33369807e-02f, 9.88205597e-02f, -4.35071103e-02f, 1.89132895e-02f, -6.48691282e-02f, 3.19221732e-03f, 1.17948633e-02f, 3.93736130e-03f,
  -5.86838974e-03f, -2.18972676e-02f, -4.20677997e-02f, -6.76414669e-02f, -5.55529967e-02f, -1.53304702e-02f, -4.35751164e-04f, -6.68299794e-02f, -3.56439911e-02f, -6.99933525e-03f,
  5.71879782e-02f, 3.87206078e-02f, 1.30620748e-02f, 1.80196837e-02f, 1.15591260e-02f, 1.44905159e-02f, -6.90927505e-02f, -9.30202100e-03f, -7.41071552e-02f, -9.95369628e-04f,
  -7.02935681e-02f, -1.74724106e-02f, 1.24820694e-01f, -9.69804153e-02f, 6.13468280e-03f, -9.09247845e-02f, -2.30331370e-03f, -1.88602338e-04f, -1.60930771e-02f, 3.57143208e-02f,
  1.02299452e-01f, 9.81171727e-02f, 6.80219159e-02f, 7.73932710e-02f, -1.08007245e-01f, -1.28126845e-01f, 4.39980365e-02f, -6.63246214e-02f, -4.16864939e-02f, 1.74976215e-01f,
  -2.74151504e-01f, 4.49983686e-01f, -1.45329595e-01f, -2.73907125e-01f, -1.17261903e-02f, 2.72831887e-01f, 3.27512026e-01f, 2.01777577e-01f, -1.25925979e-02f, -2.42983690e-03f,
  8.53961706e-02f, -1.26022056e-01f, 7.39542721e-03f, -1.32788708e-02f, 1.73576921e-01f, 1.79887623e-01f, -1.55199125e-01f, -1.05205610e-01f, 1.29588796e-02f, 4.66858745e-02f,
  2.13885698e-02f, -1.38840660e-01f, -2.15230882e-01f, -1.49158597e-01f, -3.71057168e-02f, -1.96036011e-01f, -1.46407977e-01f, -1.87430065e-02f, 7.72809908e-02f, -1.88703910e-01f,
  -1.56361625e-01f, 2.40521096e-02f, -5.40563539e-02f, -1.25098675e-01f, -5.94212078e-02f, -5.93029782e-02f, 9.06985104e-02f, -1.39034003e-01f, 9.10356734e-03f, -6.15012571e-02f,
  -1.40087530e-01f, -1.46982428e-02f, 6.50277063e-02f, 2.09934041e-02f, -3.21392827e-02f, 4.51359712e-02f, -8.24039951e-02f, -1.63607777e-03f, -1.06880022e-02f, -4.96805785e-03f,
  5.15315011e-02f, -2.37963218e-02f, 4.58653420e-02f, 1.61462799e-01f, 1.34922832e-01f, -5.02908118e-02f, -1.89457256e-02f, 3.64939831e-02f, -1.83451362e-02f, -2.21588220e-02f,
  7.63756037e-02f, -9.47635621e-02f, 1.54729828e-03f, 7.83345625e-02f, 8.58272538e-02f, -9.51297134e-02f, -3.95174846e-02f, 6.35055527e-02f, 3.67433019e-02f, 1.17594697e-01f,
  2.68083941e-02f, 4.51604603e-03f, -6.32275594e-03f, -2.88545359e-02f, -6.05714954e-02f, -4.67056595e-03f, 8.42328090e-03f, -1.39576793e-02f, 1.27650956e-02f, -4.99105714e-02f,
  6.97051138e-02f, 6.73090667e-02f, -1.12587651e-02f, 5.66432439e-02f, 4.97722216e-02f, -3.16146463e-02f, 6.81332275e-02f, 1.13053374e-01f, 1.14774354e-01f, 1.96284391e-02f,
  -1.61984757e-01f, -2.02858578e-02f, -2.17888594e-01f, 7.39540905e-02f, -2.43789311e-02f, 3.15319486e-02f, -1.97212622e-02f, -4.42050695e-02f, -7.15600178e-02f, -5.01447031e-03f,
  8.04831460e-02f, -1.54376077e-02f, -3.00971493e-02f, 6.94603622e-02f, -4.88942787e-02f, -4.92071211e-02f, 4.62268293e-02f, -1.20420262e-01f, -8.29569995e-02f, 1.11714480e-02f,
  6.43905178e-02f, -4.16269712e-02f, -3.30142453e-02f, -3.05070579e-02f, 7.55398795e-02f, -6.30136877e-02f, 5.11631183e-02f, 2.23087724e-02f, -4.78355773e-02f, -3.22600566e-02f,
  -3.67905617e-01f, -3.19403261e-01f, 4.82869186e-02f, -2.33090445e-01f, 1.29950345e-01f, 2.14100316e-01f, 9.95508805e-02f, 9.13055465e-02f, 9.62002110e-03f, -1.97351903e-01f,
  6.11663647e-02f, 1.75621241e-01f, 9.42870155e-02f, 2.11320892e-01f, 9.39654037e-02f, -1.01052016e-01f, -1.71332359e-01f, 2.61827707e-02f, 1.73733875e-01f, 7.00750649e-02f,
  4.32711951e-02f, -6.97511062e-02f, -1.79857463e-01f, -2.21586339e-02f, -2.08536759e-02f, 5.35726361e-02f, -1.34417057e-01f, -1.05817445e-01f, -1.22665681e-01f, -3.70576411e-01f,
  7.08251894e-02f, -1.10402890e-02f, 9.78777409e-02f, 6.19811490e-02f, 3.91769186e-02f, 1.56259332e-02f, -1.64975375e-02f, 4.61709574e-02f, 1.91252455e-02f, -4.35262993e-02f,
  2.14458443e-02f, 3.48391645e-02f, 9.81915444e-02f, 1.10909440e-01f, 1.08825386e-01f, 6.83293939e-02f, 1.45530095e-02f, 4.28432412e-02f, 1.70349374e-01f, 1.54674560e-01f,
  8.54200870e-02f, 3.54474713e-03f, 1.24600522e-01f, 1.59366220e-01f, 1.98389143e-01f, 6.47784695e-02f, 4.42637913e-02f, 6.85591549e-02f, 9.47078019e-02f, -1.99671641e-01f,
  -5.22228777e-02f, -9.78051499e-02f, -7.54887611e-02f, -6.07037209e-02f, -1.50264427e-01f, -3.35263349e-02f, -1.43916264e-01f, -6.87007010e-02f, -8.22248831e-02f, 2.34527607e-03f,
  -9.37566757e-02f, -1.02039790e-02f, -3.89571786e-02f, -1.04545310e-01f, -8.76491666e-02f, -4.20242362e-02f, -1.22977808e-01f, -8.54723305e-02f, -7.72674289e-03f, -8.84678215e-02f,
  -1.05375141e-01f, -4.22924608e-02f, -1.13130808e-01f, -4.31876965e-02f, -9.03475378e-03f, -3.93698663e-02f, 1.08314501e-02f, -2.63969805e-02f, -1.37882177e-02f, -8.46381485e-02f,
  -5.04117273e-03f, 3.05043191e-01f, -6.36650845e-02f, -1.60989687e-02f, 9.55716744e-02f, 8.96384120e-02f, 1.54117392e-02f, -4.91983965e-02f, -3.13118026e-02f, 3.16267610e-02f,
  2.99537312e-02f, 2.06616782e-02f, 2.81709898e-02f, -1.78770348e-02f, 3.15049365e-02f, 9.21061784e-02f, -4.49691936e-02f, 5.72279021e-02f, 5.90013638e-02f, 4.88390177e-02f,
  1.97665282e-02f, -8.62297714e-02f, -5.02543710e-02f, -3.92947719e-03f, 1.42451838e-01f, 4.68342565e-02f, 1.22104466e-01f, 1.35579392e-01f, 1.26487166e-01f, -1.33820146e-01f,
  -3.20914984e-02f, 1.62642509e-01f, -4.50382739e-01f, 6.86763786e-03f, 1.40479773e-01f, 2.06414633e-03f, 1.04177490e-01f, 6.72112852e-02f, 1.36311769e-01f, 8.17205161e-02f,
  9.49674100e-02f, 1.81102604e-02f, -6.94183558e-02f, 5.83653525e-02f, -1.72872394e-01f, 8.91160890e-02f, 7.50415102e-02f, -8.72064903e-02f, -1.70267209e-01f, 2.42245153e-01f,
  3.44624192e-01f, 2.60198098e-02f, -1.41370118e-01f, 1.31382406e-01f, 2.89973080e-01f, 2.48262316e-01f, -1.30874813e-01f, -7.35667581e-03f, 1.07418120e-01f, 3.93112808e-01f,
  -1.21744797e-01f, -1.30364355e-02f, -3.96079086e-02f, 1.77677274e-01f, -3.41909681e-03f, 7.27634802e-02f, 1.48399502e-01f, -3.30023766e-02f, 6.59028515e-02f, 7.28593394e-02f,
  9.61592942e-02f, 1.61203787e-01f, 4.88177538e-02f, 6.95699751e-02f, 1.45728678e-01f, 8.61991346e-02f, -3.94819379e-02f, 7.91925099e-03f, 5.03720380e-02f, 7.64165521e-02f,
  2.72687197e-01f, 2.38048472e-02f, -1.22725606e-01f, -1.57345701e-02f, 5.60675524e-02f, 9.93199274e-02f, 8.61189049e-03f, 1.05115809e-01f, 4.77732681e-02f, 1.91245630e-01f,
  7.91970268e-02f, -1.15836293e-01f, -2.51923632e-02f, -4.46838997e-02f, 1.16364034e-02f, -2.88579296e-02f, -7.76463421e-03f, -2.00922731e-02f, 9.98606440e-04f, 1.58292502e-02f,
  -1.05648480e-01f, -7.69187436e-02f, -4.75680344e-02f, 3.40452902e-02f, 1.07648991e-01f, 2.79841921e-03f, 6.64029783e-03f, 5.88146970e-02f, 1.90737043e-02f, -1.08186089e-01f,
  -5.89566678e-02f, 5.26230596e-03f, -2.22335923e-02f, -3.85339893e-02f, 7.78133720e-02f, -2.54359525e-02f, 2.84909946e-03f, 9.34499204e-02f, -9.37235653e-02f, -3.35513800e-02f,
  1.51474446e-01f, -1.47248015e-01f, 1.82979897e-01f, 1.15679927e-01f, 5.37845828e-02f, 1.08398244e-01f, 4.76138070e-02f, 2.84404922e-02f, 1.20319240e-02f, 6.86803237e-02f,
  -2.13685799e-02f, 3.46723646e-02f, 4.12807353e-02f, 1.06851183e-01f, 4.29863459e-04f, 8.13773498e-02f, 2.05839679e-01f, -6.06170017e-03f, 1.26732960e-01f, 1.45441750e-02f,
  6.29837066e-02f, 1.49383336e-01f, 7.59146512e-02f, 1.03013784e-01f, -1.39822380e-03f, 7.13575482e-02f, 9.74356160e-02f, 4.71245050e-02f, 6.29237071e-02f, 2.62426049e-01f,
  -3.33020650e-02f, -3.04446489e-01f, -2.98368424e-01f, -1.28349021e-01f, -2.24081665e-01f, -2.57286448e-02f, 8.24090838e-02f, 1.89280733e-01f, -1.38994912e-02f, -6.28014877e-02f,
  -1.70985669e-01f, -1.61442738e-02f, -1.33266216e-02f, 3.92043591e-02f, 8.76050144e-02f, -8.29771161e-02f, -7.24551752e-02f, -1.13588452e-01f, 1.15772439e-02f, 6.39499426e-02f,
  -4.28970940e-02f, -1.02391563e-01f, 5.76178245e-02f, -7.68680200e-02f, -9.73004624e-02f, -3.06498986e-02f, -2.54094582e-02f, -5.72504438e-02f, -4.20499556e-02f, -1.23247683e-01f,
  -2.09268510e-01f, -9.15119126e-02f, 4.87975366e-02f, -1.01078667e-01f, -5.37586622e-02f, -1.04834408e-01f, -1.00756712e-01f, -8.94628242e-02f, -1.07444614e-01f, 5.79237612e-03f,
  -1.23663940e-01f, -1.06135093e-01f, -9.11019444e-02f, -6.13983348e-02f, 2.49579921e-03f, -1.03319459e-01f, -2.10776292e-02f, -1.23180792e-01f, -5.13341241e-02f, -6.19719140e-02f,
  -1.53090283e-01f, -1.85943842e-01f, -1.30323544e-01f, 5.10476083e-02f, -7.93491155e-02f, -1.27964228e-01f, -1.01615176e-01f, -2.98556890e-02f, 6.66318759e-02f, -5.95804341e-02f,
  5.24323015e-03f, -9.52658206e-02f, -6.51262030e-02f, -1.67336091e-02f, 6.77315220e-02f, 2.98989676e-02f, 3.17399465e-02f, 5.80245219e-02f, 1.35638472e-02f, 3.30554843e-02f,
  6.37724623e-02f, -7.97309726e-03f, 3.55428010e-02f, 3.23547125e-02f, -1.88284963e-02f, -5.26534021e-02f, 5.12188338e-02f, 5.22547066e-02f, 1.58417020e-02f, 6.49512792e-03f,
  6.58311248e-02f, 4.46647480e-02f, -2.90573724e-02f, 9.35413390e-02f, 6.29002526e-02f, -4.97724302e-02f, 8.25985223e-02f, 6.70970604e-02f, 2.37446483e-02f, -8.51085931e-02f,
  6.38534576e-02f, 1.65740639e-01f, -5.95440492e-02f, 8.95424411e-02f, -1.30486012e-01f, 2.15076767e-02f, -1.35638222e-01f, 7.52792647e-03f, -6.74230978e-02f, -1.11980870e-01f,
  -4.82352525e-02f, 1.92745049e-02f, -1.48066878e-02f, -1.22349197e-02f, -3.54076512e-02f, -1.48679432e-03f, -1.06905423e-01f, -1.34302095e-01f, 2.48472355e-02f, -5.41169085e-02f,
  4.31709923e-02f, -4.42606732e-02f, -2.54853647e-02f, -6.83544800e-02f, -1.74138285e-02f, -1.92105491e-02f, 7.49189109e-02f, 6.21884456e-03f, 4.32768576e-02f, 8.82901475e-02f,
  -1.32999539e-01f, 2.17334166e-01f, 2.19345346e-01f, 1.54940307e-01f, 2.61238068e-01f, 3.49828809e-01f, 3.14227909e-01f, 9.58172679e-02f, 1.11595258e-01f, 1.92107290e-01f,
  1.88682795e-01f, 1.38628572e-01f, 1.33569911e-01f, 9.98709947e-02f, 9.36079472e-02f, 2.27107227e-01f, 2.05751583e-01f, 2.91297529e-02f, 1.04843579e-01f, 2.06217840e-01f,
  2.83882558e-01f, 1.13908812e-01f, -6.00758642e-02f, 3.92605644e-03f, 8.88798535e-02f, 8.17010701e-02f, 7.88010135e-02f, 1.28733695e-01f, 2.16718927e-01f, 6.92690909e-02f,
  2.68024236e-01f, -3.09566688e-02f, 3.32961902e-02f, 2.75295321e-02f, 9.38059315e-02f, -2.54964014e-03f, 3.41879725e-02f, -5.60139567e-02f, -7.35753030e-02f, 6.12057857e-02f,
  4.61512357e-02f, 5.50758988e-02f, 3.09496019e-02f, 8.98180306e-02f, 6.31165132e-02f, 5.42868413e-02f, -9.77906212e-02f, -8.03039968e-02f, -1.60460435e-02f, 1.21324129e-01f,
  8.66938382e-02f, 1.92302108e-01f, 9.19516459e-02f, -1.20667834e-03f, -5.57873817e-03f, 8.32771659e-02f, -2.22349223e-02f, -1.43892569e-02f, -8.51456299e-02f, -2.82066539e-02f,
  3.61077636e-02f, -5.63970134e-02f, -4.95985262e-02f, -4.61162403e-02f, -7.96515644e-02f, -6.87585846e-02f, 1.06702857e-02f, 7.69447759e-02f, 5.75897917e-02f, -8.68955031e-02f,
  1.73218716e-02f, 4.32536043e-02f, -1.10404259e-02f, 5.13123348e-02f, -4.86666560e-02f, 4.68630381e-02f, -1.58350579e-02f, -1.68127399e-02f, -2.41176561e-02f, -7.53748119e-02f,
  -1.41241252e-02f, -2.10771933e-02f, -7.29570612e-02f, 3.62493470e-02f, 4.66901325e-02f, 2.68095974e-02f, -4.11471687e-02f, -5.55371493e-02f, 2.15429012e-02f, -6.69469237e-02f,
  6.24447428e-02f, 7.85370022e-02f, 3.83589379e-02f, -3.12171262e-02f, 2.62632910e-02f, -3.89092676e-02f, 5.61170056e-02f, -2.16848031e-02f, 1.87463947e-02f, 9.37740058e-02f,
  1.63913101e-01f, 7.94169605e-02f, 9.19397324e-02f, 1.05121486e-01f, 9.69115272e-02f, 1.07840620e-01f, 1.25058115e-01f, 1.05615817e-01f, 2.47354824e-02f, 1.73640940e-02f,
  3.15028876e-02f, 4.32089493e-02f, 5.37148528e-02f, 6.08413247e-03f, 4.87335622e-02f, 1.04428582e-01f, 1.46309612e-02f, 4.59185801e-02f, -4.93327063e-03f, -2.11954117e-02f,
  -1.01926420e-02f, 4.18987393e-01f, -1.31283224e-01f, -3.99471335e-02f, 9.72986966e-03f, -1.03364445e-01f, -9.78541300e-02f, 9.77754127e-03f, -8.11505318e-02f, 1.76646203e-01f,
  4.07499939e-01f, 2.79507339e-01f, 2.15161458e-01f, -2.41100378e-02f, -1.61546156e-01f, -2.38684818e-01f, -3.80586833e-01f, -3.21163297e-01f, -2.63790667e-01f, -1.07205495e-01f,
  2.05780473e-02f, 6.61598472e-03f, -9.43811685e-02f, -1.25713184e-01f, 1.32940978e-01f, 2.06688624e-02f, -1.99179407e-02f, 1.26159474e-01f, 1.16861872e-01f, 2.52101496e-02f,
  2.89254010e-01f, 2.69259751e-01f, 2.15181019e-02f, 1.55430555e-01f, 2.86466293e-02f, 4.53523993e-02f, 1.13452608e-02f, 6.96993098e-02f, 4.87489998e-02f, 4.60287295e-02f,
  2.00016961e-01f, 8.57490078e-02f, -2.12796740e-02f, 6.46719337e-02f, 4.02574353e-02f, 8.64991248e-02f, -2.15733964e-02f, -6.05667531e-02f, 6.45759329e-02f, 1.25413895e-01f,
  1.74041316e-01f, 8.73183385e-02f, 8.58008303e-03f, -1.89067167e-03f, 2.99575943e-02f, 1.02548324e-01f, 4.09645699e-02f, 6.30178452e-02f, 8.18499476e-02f, 3.70213315e-02f,
  -1.17497586e-01f, -1.85163096e-02f, 7.31871277e-02f, 4.66308855e-02f, 8.48888159e-02f, 9.73925516e-02f, 2.94542350e-02f, 9.70398933e-02f, -8.32412690e-02f, 2.10017078e-02f,
  7.58458152e-02f, 3.28292372e-03f, -4.58580554e-02f, 2.08151005e-02f, 1.15987398e-02f, -1.62583422e-02f, 2.84031797e-02f, 3.23778205e-02f, -2.58628447e-02f, 1.20508727e-02f,
  6.81777149e-02f, -2.94210506e-03f, 1.25933054e-03f, 6.16241619e-02f, -2.83986200e-02f, -1.97681636e-02f, 5.15966788e-02f, 1.52193636e-01f, 2.33137701e-02f, 9.11895856e-02f,
  1.10028595e-01f, -3.16367596e-02f, -3.30383442e-02f, -1.57495365e-02f, 9.00084712e-03f, 4.21205312e-02f, 1.31503999e-01f, 4.28547896e-02f, 8.92112330e-02f, -3.34203169e-02f,
  4.36940938e-02f, 4.61776182e-03f, -2.51425989e-02f, -2.18014866e-02f, -1.07164815e-01f, 3.25505808e-02f, -1.26105219e-01f, -8.39684978e-02f, -4.41227667e-02f, 6.89429268e-02f,
  -1.77331008e-02f, -2.03410015e-02f, -1.16021827e-01f, -4.77729999e-02f, -6.82984516e-02f, -1.58718973e-01f, 1.34127177e-02f, -8.20352754e-04f, -2.08191097e-01f, -1.03838600e-01f,
  1.22817889e-01f, 5.90733327e-02f, -4.29786831e-01f, 3.28135192e-01f, 1.24936685e-01f, -1.39500514e-01f, -9.63197574e-02f, 6.79455400e-02f, 2.15037793e-01f, 2.25403041e-01f,
  1.76491916e-01f, 2.52010196e-01f, 9.80420560e-02f, -1.04164772e-01f, -2.08383217e-01f, -7.36124665e-02f, -9.10971835e-02f, -3.14583838e-01f, -3.05958986e-01f, 2.51507778e-02f,
  1.87779903e-01f, 1.98331758e-01f, 1.24584595e-02f, 3.77189112e-03f, 1.43613860e-01f, 1.38457999e-01f, 1.61541432e-01f, -8.31759826e-05f, 3.88820991e-02f, -2.09228061e-02f,
  2.50487197e-02f, 1.76912558e-03f, 1.03970632e-01f, 6.81962892e-02f, 1.47306398e-01f, 4.71826876e-03f, -4.87324689e-03f, 9.65736657e-02f, 2.69667618e-02f, 3.24055739e-02f,
  7.28272945e-02f, 1.09004095e-01f, 2.37549655e-02f, -1.11434022e-02f, 4.30416241e-02f, -5.71355894e-02f, -4.46032323e-02f, -6.33894503e-02f, 2.02930775e-02f, 7.23836124e-02f,
  4.73586284e-02f, 7.34770447e-02f, -6.27507865e-02f, -5.57951704e-02f, -1.15448058e-01f, 2.51469202e-02f, 5.50940596e-02f, 2.29433980e-02f, -1.33358121e-01f, 1.36720434e-01f,
  8.77121910e-02f, 1.90628767e-02f, -9.16929469e-02f, 1.90218184e-02f, 3.10156792e-02f, -2.42682938e-02f, 3.04491515e-03f, -3.72967906e-02f, -7.16538280e-02f, 5.32132871e-02f,
  -1.96484346e-02f, -9.31504592e-02f, -1.85967758e-02f, -2.07132120e-02f, 4.40606065e-02f, -1.31319344e-01f, -1.30509317e-01f, -2.22857785e-03f, -4.37074304e-02f, -3.71619798e-02f,
  2.08662990e-02f, -6.57049716e-02f, 3.49526778e-02f, -9.63414758e-02f, -3.25343646e-02f, -1.12562835e-01f, -8.20671394e-02f, 1.97444335e-02f, -1.62588637e-02f, 5.06500266e-02f,
  4.11499560e-01f, -1.52121959e-02f, 1.07993089e-01f, 6.73129410e-02f, 6.54296996e-03f, 1.69842727e-02f, 5.91651164e-02f, 4.40159664e-02f, 7.30740950e-02f, -6.12414908e-03f,
  2.55585704e-02f, 1.16350558e-02f, 5.32778054e-02f, 7.54151344e-02f, -2.05671997e-03f, 1.18523166e-01f, 1.31129801e-01f, 6.63123727e-02f, 3.44391502e-02f, 6.54454157e-02f,
  1.44731164e-01f, 6.07643165e-02f, 5.39698899e-02f, 7.46300220e-02f, 1.22627884e-01f, -9.85950697e-03f, 5.95997348e-02f, 7.00156540e-02f, -9.41072330e-02f, 1.44967318e-01f,
  -4.69599366e-02f, 8.09334591e-02f, 1.67904466e-01f, 1.39152214e-01f, 1.90432653e-01f, 2.05881134e-01f, 1.33204117e-01f, 8.37389901e-02f, -4.96537387e-02f, 1.21393204e-01f,
  1.47152379e-01f, -2.08299160e-01f, -1.70660213e-01f, -2.47020856e-01f, -1.96690589e-01f, -1.53106645e-01f, 1.48723153e-02f, -2.58195639e-01f, -1.57581806e-01f, -6.15972504e-02f,
  -9.09099951e-02f, -1.16772108e-01f, -1.85242295e-01f, -4.04650047e-02f, 5.68225682e-02f, -5.95762394e-02f, 8.06770101e-02f, 9.52682346e-02f, -5.07836640e-02f, -6.00461960e-02f,
  -1.62191186e-02f, 1.02049604e-01f, -2.34086849e-02f, -4.22231108e-03f, 1.31107613e-01f, -4.23689298e-02f, 1.28241718e-01f, 4.59994003e-02f, 8.65213871e-02f, 1.19923882e-01f,
  3.76890115e-02f, 1.08112320e-01f, 8.76467749e-02f, -1.74420867e-02f, 1.11038812e-01f, 1.23170219e-01f, 1.20408230e-01f, -2.39528157e-02f, 1.39306813e-01f, 6.14341982e-02f,
  1.01250783e-01f, 1.26822263e-01f, 1.64505854e-01f, 1.31454378e-01f, 6.93886504e-02f, -5.33186346e-02f, 1.15104206e-01f, 9.58586559e-02f, 2.09661927e-02f, 1.12797312e-01f,
  -4.65279073e-02f, -1.18546881e-01f, -2.29981169e-02f, 8.40522628e-03f, -6.28153980e-02f, -3.70968617e-02f, -6.45490289e-02f, -9.65144336e-02f, -4.61883917e-02f, -9.35070813e-02f,
  -4.90971096e-02f, -1.62543673e-02f, -9.43769813e-02f, -5.23057096e-02f, -1.09462112e-01f, 5.46388216e-02f, -5.04351072e-02f, -1.27781913e-01f, -8.86576921e-02f, -9.31347907e-02f,
  -9.64857638e-02f, 2.20261589e-02f, 1.80662069e-02f, -7.65313879e-02f, 1.94109473e-02f, 3.63767669e-02f, -4.36994508e-02f, -1.60997473e-02f, -8.55827555e-02f, -3.26847732e-02f,
  1.20293871e-01f, 1.72099900e-02f, -8.13902095e-02f, -4.22591083e-02f, 1.42746478e-01f, 1.38009444e-01f, 1.08994856e-01f, 1.36758730e-01f, 1.01240603e-02f, 2.55842768e-02f,
  9.34920460e-02f, 7.22463243e-03f, 1.16431072e-01f, 9.66449529e-02f, 1.15094960e-01f, 1.03558652e-01f, 7.27992430e-02f, -1.58222150e-02f, 5.89942522e-02f, 5.49267195e-02f,
  5.53508475e-02f, -1.17980735e-02f, 5.42539209e-02f, 7.48088881e-02f, 4.54087742e-03f, 1.34089096e-02f, 1.62213817e-01f, 1.21480353e-01f, 5.55838831e-03f, 1.62665218e-01f,
  -4.09519486e-02f, 2.81630874e-01f, 1.94219247e-01f, -4.07931238e-01f, -2.52833247e-01f, 1.41693726e-01f, 4.04792845e-01f, -6.82464801e-03f, -3.06815952e-01f, 8.86113644e-02f,
  -5.41999638e-02f, -1.48407251e-01f, -1.22038126e-01f, -1.99897047e-02f, 1.71238050e-01f, 8.39309916e-02f, -7.48015288e-03f, -7.34141991e-02f, 1.35002181e-01f, 2.16531649e-01f,
  8.98152217e-03f, -7.13809282e-02f, -6.24076985e-02f, -1.11107752e-01f, -2.83665001e-01f, -3.44910145e-01f, -3.14388275e-01f, -1.69189841e-01f, 8.09910372e-02f, -1.49526909e-01f,
  2.40464911e-01f, 1.78932119e-03f, -5.36462031e-02f, -1.13871045e-01f, -1.73444450e-01f, 9.17607695e-02f, 3.04471962e-02f, -7.23639280e-02f, -1.17303528e-01f, 4.19431087e-03f,
  -1.95372105e-01f, -3.96542847e-02f, -3.31050754e-02f, -4.24304232e-02f, 1.13429306e-02f, -1.00951828e-01f, -1.33747891e-01f, -5.38444594e-02f, -8.50671902e-02f, -4.30559702e-02f,
  -4.91066724e-02f, -8.16710144e-02f, 6.24150634e-05f, 5.73892007e-03f, -6.32668585e-02f, -8.41371492e-02f, -8.59666765e-02f, 2.40397342e-02f, 3.98365445e-02f, 9.77506936e-02f,
  4.70851734e-02f, 3.54333036e-02f, -1.08262030e-02f, 7.12751970e-02f, -5.60142770e-02f, -7.77897462e-02f, -3.24680991e-02f, 4.68642777e-03f, 2.08335891e-02f, 3.50040980e-02f,
  5.87786920e-02f, -5.16092696e-04f, -4.08789935e-03f, 3.36676799e-02f, -1.44463494e-01f, -2.42109895e-02f, -1.58510208e-02f, -1.67217888e-02f, -1.42901521e-02f, -1.34148896e-02f,
  -4.10160311e-02f, -9.81170405e-03f, -1.72832221e-01f, 3.74865346e-02f, -9.60400030e-02f, -1.05398573e-01f, -3.71201113e-02f, -9.19192750e-03f, 1.65066088e-03f, 5.29532656e-02f,
  -1.20789595e-01f, -3.17801759e-02f, 4.47809435e-02f, -3.20514455e-03f, -1.47564128e-01f, -6.11552335e-02f, -4.08290513e-02f, 1.99281033e-02f, -9.58216265e-02f, 2.55956557e-02f,
  -1.87139865e-02f, 6.13111304e-03f, -4.79629673e-02f, -5.73412515e-02f, 3.89749520e-02f, -1.15196832e-01f, -1.16206475e-01f, -1.01999119e-01f, -4.33973186e-02f, 4.04486060e-02f,
  -7.16356039e-02f, 6.89860014e-03f, 7.39141256e-02f, -1.70178879e-02f, 7.55320210e-03f, -1.40932560e-01f, 1.25779763e-01f, -1.63317267e-02f, 6.71991408e-02f, 1.64511964e-01f,
  -1.88513935e-01f, 1.53759480e-01f, 3.63297850e-01f, -2.30383649e-01f, 1.88780352e-01f, 2.41914749e-01f, 2.70019621e-01f, -4.99602444e-02f, -1.37230068e-01f, 3.68065238e-02f,
  -3.45428730e-03f, -2.62187093e-01f, -2.02354327e-01f, -2.22733200e-01f, -5.56943305e-02f, 1.30386382e-01f, -3.57890688e-02f, 2.14863140e-02f, -4.75054756e-02f, -3.16077881e-02f,
  -2.45808169e-01f, -2.02630982e-01f, -2.31506214e-01f, -2.17876703e-01f, -1.31195009e-01f, -7.22049028e-02f, 1.01068303e-01f, 4.28686664e-02f, 1.68864727e-01f, -2.27830391e-02f,
  2.01582462e-01f, 1.20059028e-01f, -6.88136891e-02f, -1.81830630e-01f, -4.04198766e-02f, -2.65105963e-02f, 4.47993912e-02f, -1.21500827e-01f, -1.02352433e-01f, -1.72537509e-02f,
  -3.97219658e-02f, -5.57661019e-02f, -9.11985636e-02f, -7.06254169e-02f, -1.07487716e-01f, -3.67872901e-02f, -9.69696641e-02f, -1.00671172e-01f, 4.05503670e-03f, -6.28461093e-02f,
  -1.44913718e-02f, 7.22130165e-02f, 2.85011418e-02f, -4.97636199e-03f, 8.98892060e-02f, 1.13767786e-02f, 6.25819946e-03f, -5.48545122e-02f, 3.17432880e-02f, -4.89591733e-02f,
  -1.43378098e-02f, -7.62571348e-03f, 2.07063090e-02f, -4.44697514e-02f, -9.34571177e-02f, 2.65035070e-02f, -3.05392817e-02f, 3.66664417e-02f, -3.30107994e-02f, -7.92354569e-02f,
  -3.83379199e-02f, 6.87274039e-02f, -2.71169120e-03f, -6.18059747e-02f, 1.28350016e-02f, 2.36935187e-02f, -2.09065736e-03f, -3.79661396e-02f, 4.46847454e-03f, 6.72636274e-03f,
  -3.55743170e-02f, 7.43528232e-02f, -1.70927681e-02f, -1.08287513e-01f, 6.67693391e-02f, -2.32048631e-02f, 3.11465953e-02f, -9.33515355e-02f, -7.08660632e-02f, 4.02487628e-02f,
  -3.02921474e-01f, 3.25490087e-02f, -2.68457811e-02f, -3.23865674e-02f, 1.29499538e-02f, -1.86622851e-02f, -5.12981117e-02f, -7.06278905e-02f, -2.01175883e-02f, -4.78777923e-02f,
  8.42162035e-03f, -5.85477836e-02f, -3.33693787e-03f, -6.96944892e-02f, 1.41220586e-02f, -1.94819737e-02f, -5.58300875e-02f, -5.71606718e-02f, -9.17176753e-02f, 1.91129595e-02f,
  -4.89811748e-02f, -9.53744724e-02f, -9.34008583e-02f, 4.21084054e-02f, 1.64608322e-02f, 6.24353215e-02f, 3.08895875e-02f, 7.54198581e-02f, 2.63387500e-03f, -1.39195323e-01f,
  2.60271221e-01f, 4.43219952e-02f, -2.25240007e-01f, 2.53684014e-01f, 1.84254244e-01f, 3.27423625e-02f, -3.45025584e-02f, 1.01613598e-02f, 2.14764759e-01f, 2.08037749e-01f,
  6.00486174e-02f, 1.68233961e-01f, 1.10912070e-01f, -1.82253439e-02f, -1.74355015e-01f, 3.22252512e-02f, 1.58397764e-01f, -5.51352687e-02f, -1.20402187e-01f, 7.98522308e-02f,
  7.37020299e-02f, 5.82338348e-02f, -4.46735770e-02f, 3.34084965e-02f, 2.35465541e-01f, 1.96087703e-01f, 3.29225697e-02f, 4.36896570e-02f, 6.82557747e-02f, 2.62194067e-01f,
  -9.35828388e-02f, -2.01856732e-01f, 7.56432191e-02f, 9.88512188e-02f, 3.85965519e-02f, -8.14983770e-02f, 6.10364638e-02f, -2.77647302e-02f, 1.07214088e-02f, 1.05900457e-02f,
  1.98554248e-02f, 6.14306144e-02f, 4.69837822e-02f, 1.35964632e-01f, 8.72648507e-02f, 3.39199454e-02f, -1.01308562e-02f, 3.09647508e-02f, -4.04120162e-02f, -4.24887501e-02f,
  1.57827944e-01f, 5.36041595e-02f, -9.46797282e-02f, 3.46187353e-02f, -6.03436716e-02f, 5.87301962e-02f, -1.72327477e-02f, -3.10737342e-02f, -1.29697463e-02f, 1.38189867e-01f,
  -3.14808451e-02f, 2.58700792e-02f, 2.47113947e-02f, -2.52949493e-03f, 6.52541071e-02f, 1.05997093e-01f, 7.18224868e-02f, 2.97343805e-02f, 1.99977029e-02f, 5.08794701e-03f,
  1.09772580e-02f, 2.36277306e-03f, 4.43004221e-02f, 4.17910740e-02f, 8.90020654e-02f, 7.07140099e-03f, -4.88075726e-02f, 8.71914700e-02f, 1.15937479e-02f, 6.98946789e-02f,
  3.22794579e-02f, 2.80385055e-02f, 5.44742160e-02f, 7.15523735e-02f, -8.69978219e-03f, -5.80783896e-02f, 6.54670522e-02f, -5.30216433e-02f, 2.76008118e-02f, 3.03644314e-03f,
  1.44880652e-01f, -9.52081233e-02f, 2.01040804e-01f, 4.85225357e-02f, 4.22919281e-02f, 3.23971026e-02f, 6.73488081e-02f, 5.92036285e-02f, 9.34833512e-02f, 1.38318660e-02f,
  -6.08980805e-02f, -1.04088066e-02f, 1.79797728e-02f, 8.19053054e-02f, 8.22450891e-02f, 2.40034387e-02f, 8.93775225e-02f, 1.57630473e-01f, 2.02943310e-02f, 1.03740916e-01f,
  3.87715399e-02f, -2.69623660e-02f, 4.74641770e-02f, 6.49135485e-02f, 4.86604571e-02f, 1.56295002e-02f, 5.18224165e-02f, 5.58112152e-02f, -2.71885004e-02f, 1.85547024e-01f,
  1.83502898e-01f, 3.28332663e-01f, 1.11261569e-03f, 1.24554336e-01f, 1.02476656e-01f, 9.47965980e-02f, 1.54451281e-01f, -5.59640117e-02f, -1.21875808e-01f, -6.23183586e-02f,
  -2.23184028e-03f, -1.41552649e-02f, -1.37438074e-01f, -1.95716485e-01f, -1.95608303e-01f, -1.09596983e-01f, -1.07452571e-01f, -1.49380073e-01f, -1.01830401e-01f, 4.55140360e-02f,
  2.88162772e-02f, 2.67988965e-02f, 1.52980175e-03f, 4.99015190e-02f, 1.92547292e-01f, -4.71322574e-02f, 3.89157794e-02f, 1.96820855e-01f, 1.43672839e-01f, 1.43443972e-01f,
  -1.30168840e-01f, 8.22893679e-02f, -1.59119278e-01f, -4.96798865e-02f, 3.94189321e-02f, -1.25164762e-01f, -8.12194422e-02f, 2.00256500e-02f, 3.29833180e-02f, -1.25719393e-02f,
  -3.00816260e-02f, -1.78794693e-02f, -4.41221148e-02f, -1.15889370e-01f, -6.12648912e-02f, -1.21917292e-01f, 1.60347689e-02f, -1.43083423e-01f, -2.00201258e-01f, -9.14146081e-02f,
  3.84249091e-02f, 7.84157738e-02f, 5.63890822e-02f, -1.63109943e-01f, -1.16315670e-02f, -1.65647447e-01f, -5.62977679e-02f, 3.93364877e-02f, -4.06141914e-02f, -7.70967007e-02f,
  1.91025541e-03f, 6.36624768e-02f, 7.89059624e-02f, 1.04360856e-01f, 5.31915501e-02f, -5.45359077e-03f, 5.99696040e-02f, 8.67237300e-02f, 2.72446014e-02f, -1.81846395e-02f,
  -4.89902720e-02f, -3.71946651e-03f, 2.47172043e-02f, 5.25063016e-02f, 1.70288756e-02f, 1.00434482e-01f, 1.22174181e-01f, 7.24053085e-02f, 1.57474186e-02f, -6.50317268e-03f,
  -3.17809582e-02f, 2.40113549e-02f, 8.18307474e-02f, 9.92527902e-02f, 8.28188192e-03f, 1.07248053e-01f, 5.10253422e-02f, 3.05326842e-02f, 2.04568589e-03f, 2.08862647e-02f,
  -2.54254192e-01f, -2.17170164e-01f, -9.43278745e-02f, -1.19762994e-01f, -5.28497212e-02f, -1.24826685e-01f, 1.46436784e-02f, -7.04060793e-02f, 4.18462642e-02f, -1.24324635e-01f,
  -3.61724347e-02f, -5.28836101e-02f, -9.35031548e-02f, -6.21019043e-02f, -1.20881133e-01f, -9.89498943e-02f, 4.61338125e-02f, -7.60407969e-02f, -1.76897272e-01f, -1.30236357e-01f,
  2.04988718e-02f, -1.04209505e-01f, -1.72796533e-01f, -7.24626258e-02f, -5.09655066e-02f, -1.11090302e-01f, -1.71550095e-01f, -1.73456743e-01f, -1.24368548e-01f, -5.38451448e-02f,
  -1.48371130e-01f, 4.08041418e-01f, 5.96705191e-02f, -2.90233225e-01f, -2.16648951e-01f, -4.14063409e-02f, 1.76450357e-01f, -1.19408935e-01f, -2.01910719e-01f, 8.72817189e-02f,
  1.96168497e-01f, -1.72157988e-01f, -9.92329940e-02f, -1.51654720e-01f, -6.06360547e-02f, 5.01517653e-02f, -1.38829216e-01f, -2.14002997e-01f, -2.10142642e-01f, -1.86044306e-01f,
  -1.25308976e-01f, -1.02123767e-01f, -7.47851888e-03f, -9.57923457e-02f, -4.49197255e-02f, -1.03838585e-01f, 1.45906657e-01f, -8.30619875e-03f, 1.07631899e-01f, -3.74262920e-03f,
  8.42361152e-02f, 6.32644743e-02f, -1.16222963e-01f, -7.40412548e-02f, -4.04882897e-03f, -8.14834163e-02f, 7.05030700e-03f, 1.94846150e-02f, -3.93648334e-02f, -1.45059656e-02f,
  -1.12873651e-01f, 5.52922860e-03f, -1.35639027e-01f, 2.55594254e-02f, -8.20582658e-02f, 5.24795614e-03f, 3.38869691e-02f, -1.42885238e-01f, -4.65167649e-02f, -3.42015326e-02f,
  -3.35333832e-02f, -4.81428672e-03f, -1.60794687e-02f, -4.48876247e-02f, -3.16083897e-03f, 1.96007658e-02f, 7.20255002e-02f, 1.98699962e-02f, 1.87617578e-02f, 1.01749770e-01f,
  4.37191166e-02f, 9.22556743e-02f, 6.75656497e-02f, 1.10443220e-01f, 6.79729357e-02f, 4.75805067e-03f, -5.93479946e-02f, 5.78290038e-02f, -2.10145465e-03f, -1.22383544e-02f,
  -5.52841239e-02f, 1.49892241e-01f, 1.29815638e-01f, -3.95495705e-02f, 8.65486264e-02f, 8.87341872e-02f, -1.09576816e-02f, 7.87012130e-02f, 4.08359319e-02f, 9.39221978e-02f,
  5.27414642e-02f, 1.77292060e-02f, -6.84499415e-03f, -5.61616905e-02f, 6.14480861e-02f, -2.53703929e-02f, -2.80595347e-02f, 3.40910908e-03f, 6.18529432e-02f, -4.34838906e-02f,
  7.70531073e-02f, 1.41437337e-01f, -4.56784070e-02f, -1.46247506e-01f, -8.44855979e-03f, 4.72192690e-02f, 1.07153496e-02f, -5.35894074e-02f, -3.22854612e-03f, -2.48106159e-02f,
  -2.50490028e-02f, -1.11554034e-01f, -1.74879301e-02f, -7.95503035e-02f, -1.15683161e-01f, -5.40051684e-02f, -1.98546750e-03f, -5.41290455e-02f, -7.93485343e-02f, -6.16138093e-02f,
  7.74391443e-02f, -6.32593334e-02f, -8.09842944e-02f, 2.54518241e-02f, -7.75962323e-02f, -7.02744722e-02f, 3.82385626e-02f, 6.02771714e-03f, -9.78400037e-02f, 1.50745094e-01f,
  -1.99017048e-01f, -1.69256091e-01f, 3.06148589e-01f, 8.23735818e-03f, 1.90886363e-01f, 2.63604164e-01f, 2.19398469e-01f, 6.69388026e-02f, -4.78288196e-02f, 6.81921393e-02f,
  -3.63620594e-02f, -6.25119582e-02f, 3.10858171e-02f, -6.76376075e-02f, 1.25593677e-01f, 2.80075461e-01f, 2.23704770e-01f, 2.46939152e-01f, 1.55452937e-01f, 1.20828263e-01f,
  -4.57668640e-02f, -1.29681990e-01f, -5.35139665e-02f, 3.55572137e-03f, -2.43318081e-01f, -1.66593641e-02f, 1.13643985e-02f, -1.19364403e-01f, 7.29964077e-02f, -2.18395025e-01f,
  -1.44194458e-02f, -2.88404785e-02f, 1.18447222e-01f, -6.44788221e-02f, 3.37223448e-02f, -8.53860900e-02f, 2.38956865e-02f, 1.87704582e-02f, 4.49082032e-02f, 1.12307286e-02f,
  9.90662426e-02f, 5.17267210e-04f, -5.44040650e-02f, -1.20582633e-01f, 9.41581875e-02f, -5.61674871e-02f, -8.28092266e-03f, 4.47876491e-02f, -1.24488296e-02f, -2.47943103e-02f,
  4.34779152e-02f, 1.70575947e-01f, 1.67251185e-01f, 4.86076623e-02f, -6.52155979e-03f, 7.73031414e-02f, 7.07745329e-02f, -1.99408643e-02f, 1.38052576e-03f, -2.01694474e-01f,
  1.21456221e-01f, 4.14053956e-03f, -8.98806676e-02f, -1.04723215e-01f, -7.18637854e-02f, 1.10328058e-02f, -2.24302113e-02f, 8.74582157e-02f, -1.90642923e-02f, -2.42657270e-02f,
  -5.65281473e-02f, -6.56271633e-03f, 9.21481382e-03f, 1.01884946e-01f, -9.24682319e-02f, 4.31029871e-02f, 2.07621083e-02f, 4.67788801e-02f, -4.85890061e-02f, -2.14291527e-03f,
  -6.40987679e-02f, -3.55071351e-02f, -9.52356011e-02f, -4.31532413e-02f, -8.93172771e-02f, 7.94325322e-02f, -3.72672565e-02f, -8.57739821e-02f, -8.55367072e-03f, 1.22637652e-01f,
  -1.93395153e-01f, 3.39419901e-01f, 9.34752822e-03f, 2.32245382e-02f, 2.28281207e-02f, -6.93067238e-02f, -4.75497209e-02f, -1.29432948e-02f, -2.58956607e-02f, -2.18827687e-02f,
  -8.12365767e-03f, 3.21661085e-02f, -3.63235138e-02f, -8.93679783e-02f, 1.24886081e-01f, -1.69966947e-02f, 1.96141321e-02f, 1.18479682e-02f, 4.64131720e-02f, 2.25027408e-02f,
  -1.38625894e-02f, 1.84017748e-01f, 1.31066203e-01f, 1.64404362e-01f, 4.31500226e-02f, 1.11641549e-01f, 8.25376958e-02f, 4.40794975e-03f, 1.02224879e-01f, 1.24056660e-01f,
  4.98088568e-01f, 2.64905930e-01f, 2.43477449e-01f, 2.38415197e-01f, 1.95551157e-01f, 9.71701636e-04f, 1.39702871e-01f, 1.02768756e-01f, 1.24663882e-01f, 1.71993867e-01f,
  1.51492864e-01f, -4.88273241e-02f, 8.65982566e-03f, -2.44471617e-02f, -3.54655832e-02f, 1.68538481e-01f, 1.34105489e-01f, 1.08961388e-02f, -2.00070843e-01f, -9.91378725e-02f,
  8.59747604e-02f, 1.29776821e-01f, 8.20890889e-02f, 7.44373873e-02f, 1.48562148e-01f, 7.00237751e-02f, 1.81722902e-02f, 6.13886863e-02f, -5.67498803e-02f, 2.85817564e-01f,
  6.67761639e-02f, 1.16113901e-01f, -1.11427911e-01f, -7.54056731e-03f, -3.19182649e-02f, -2.93775629e-02f, 6.12543337e-02f, -7.93766081e-02f, -3.91579755e-02f, 4.30496372e-02f,
  1.09671861e-01f, 2.48342492e-02f, -3.98190767e-02f, -6.85582086e-02f, -5.36168069e-02f, 4.34451215e-02f, -1.47130731e-02f, 7.16646388e-02f, 1.04282774e-01f, 7.69947395e-02f,
  7.28339255e-02f, 2.81619169e-02f, 4.16756347e-02f, -8.44533518e-02f, -1.02079613e-02f, 3.26511487e-02f, 2.19642036e-02f, -5.45548610e-02f, -3.22419293e-02f, 5.81436902e-02f,
  -9.08496827e-02f, -1.08992517e-01f, -4.41864282e-02f, -9.73782092e-02f, -6.91644996e-02f, 8.47334322e-03f, 3.23968828e-02f, -3.49041931e-02f, -1.09078139e-01f, -2.81521939e-02f,
  3.80661129e-03f, 5.35759702e-02f, -2.00474188e-02f, 1.27441093e-01f, 2.97147166e-02f, 2.10330752e-03f, 3.24774496e-02f, 1.69511903e-02f, -2.29715202e-02f, 5.31509668e-02f,
  2.32785139e-02f, -6.48754761e-02f, 8.10868368e-02f, 4.20625247e-02f, -2.02167057e-03f, 1.20359600e-01f, 8.76761228e-03f, 1.38569064e-03f, 3.54284048e-02f, -4.77728155e-03f,
  -1.27952710e-01f, -4.14490551e-02f, 2.52485462e-02f, -2.31266785e-02f, 7.69796073e-02f, -1.20550366e-02f, -9.95415635e-03f, -5.01056425e-02f, 8.07321817e-02f, 8.03745538e-02f,
  6.31918907e-02f, 9.29859653e-02f, 5.29520074e-03f, -5.16677685e-02f, 1.18239569e-02f, -2.42727324e-02f, -5.11279069e-02f, -6.70181355e-03f, -4.65989439e-03f, 9.25508887e-02f,
  -1.34830400e-02f, -1.05680279e-01f, -3.31097618e-02f, -1.70318350e-01f, -6.35966137e-02f, -1.13613538e-01f, -6.27773255e-02f, -1.08225346e-01f, -1.25944987e-01f, -1.10424861e-01f,
  1.54365495e-01f, -5.62022105e-02f, 1.93103731e-01f, 1.26881629e-01f, -1.82761103e-01f, -1.75603986e-01f, -2.29253784e-01f, -1.19097784e-01f, -1.00456521e-01f, 1.40349725e-02f,
  2.13372055e-02f, 7.57162049e-02f, 6.99624494e-02f, 4.60343249e-02f, 3.30052748e-02f, 5.25244512e-02f, 6.22693673e-02f, 1.00054145e-01f, -5.95500283e-02f, -1.57234132e-01f,
  -1.73563093e-01f, 1.11770432e-03f, -3.27584287e-03f, -4.21455875e-02f, -9.63999853e-02f, -2.41136868e-02f, 1.54800937e-01f, -3.99789959e-02f, -1.20876320e-02f, 1.24984823e-01f,
  1.72132179e-01f, -1.38454393e-01f, -8.07148740e-02f, -1.97303474e-01f, -2.56732255e-01f, -8.59945342e-02f, -1.78957179e-01f, -4.54941615e-02f, -1.67659312e-01f, -1.11859120e-01f,
  -1.72043607e-01f, -2.30382144e-01f, -1.62495717e-01f, -2.41842866e-01f, -1.74578741e-01f, -1.49972230e-01f, -1.63130268e-01f, -1.44294649e-01f, -1.13744512e-01f, -1.47654831e-01f,
  -1.75715327e-01f, -2.47952715e-01f, -8.04579034e-02f, -1.94141015e-01f, -9.86327529e-02f, -1.90814987e-01f, -2.03489050e-01f, -1.17949396e-01f, -9.08401087e-02f, -1.00239355e-03f,
  -3.82519513e-02f, 1.93640366e-01f, 3.39358039e-02f, 2.08278567e-01f, 1.30316868e-01f, 1.14437439e-01f, 7.74946436e-02f, 1.00471877e-01f, 6.24371096e-02f, 1.38262749e-01f,
  1.30854949e-01f, 1.69745281e-01f, 1.27665117e-01f, 1.69003382e-01f, 1.57041833e-01f, 1.64061055e-01f, -7.15432735e-03f, 6.31050244e-02f, 5.57115600e-02f, 1.03008956e-01f,
  8.32857415e-02f, 1.58786818e-01f, 1.63678750e-01f, 4.08002287e-02f, 9.87226218e-02f, 1.07583173e-01f, 1.62212431e-01f, 1.21226601e-01f, 1.13584250e-01f, 1.49472997e-01f,
  2.29283422e-01f, -1.77374765e-01f, 5.55337518e-02f, -1.13619454e-01f, -1.66583747e-01f, -9.33950767e-02f, 5.40905073e-03f, -1.36316651e-02f, -1.60728797e-01f, -9.41869691e-02f,
  -8.24739933e-02f, -8.31601024e-02f, -1.04298472e-01f, -5.35395779e-02f, -1.36443928e-01f, -2.04476371e-01f, -1.16680168e-01f, -9.63771120e-02f, -7.28072152e-02f, -1.75958008e-01f,
  -1.44800365e-01f, -3.49450181e-03f, 8.30199942e-02f, 5.52922562e-02f, -8.76173973e-02f, 9.61416662e-02f, 9.14648473e-02f, 1.41084706e-02f, -4.31155153e-02f, 1.27897024e-01f,
  -2.68431772e-02f, -2.07678109e-01f, 3.28380972e-01f, -1.09911829e-01f, -5.43681979e-02f, -1.38418511e-01f, -1.73776940e-01f, -2.41703093e-01f, -1.22825474e-01f, 5.81186637e-02f,
  -2.91681066e-02f, 1.49945885e-01f, 2.61560440e-01f, 2.17377886e-01f, 1.71211138e-01f, 2.62505382e-01f, 3.30806017e-01f, 4.10460591e-01f, 2.49698907e-01f, -8.59850049e-02f,
  9.98819014e-04f, -5.95215559e-02f, 9.26932599e-03f, 2.09304709e-02f, 5.11010997e-02f, 1.97935760e-01f, 6.96769804e-02f, 9.81312320e-02f, 2.04050571e-01f, 2.82654285e-01f,
  3.27601016e-01f, -4.36529852e-02f, 3.78621891e-02f, 2.26021186e-02f, -3.18891890e-02f, -3.35448422e-02f, 4.94592860e-02f, 1.94180477e-02f, -6.86859488e-02f, -2.21465174e-02f,
  2.40282845e-02f, -2.80578043e-02f, 1.15825847e-01f, -3.62453759e-02f, 4.87426482e-02f, -1.76679753e-02f, 9.88270808e-03f, 1.72568157e-01f, 1.13941520e-01f, 5.85021861e-02f,
  -5.76882623e-02f, 5.33182286e-02f, 1.31613985e-01f, -5.13096116e-02f, 8.66324902e-02f, 1.49973795e-01f, 1.18664242e-01f, 1.28724277e-01f, 5.05782627e-02f, 1.16858706e-01f,
  -2.87427064e-02f, -3.02683059e-02f, -5.90990819e-02f, -7.29693752e-03f, -1.00189038e-01f, -7.21297646e-03f, 3.80894286e-03f, -1.51316468e-02f, -5.27684204e-02f, -5.97966537e-02f,
  3.98775563e-02f, -5.86084500e-02f, -3.12757045e-02f, -3.60309891e-02f, 1.53538259e-02f, 2.77233310e-02f, 5.68241067e-02f, -4.47041951e-02f, 5.67181706e-02f, -4.60169315e-02f,
  5.12106046e-02f, 9.62522347e-03f, -7.06763268e-02f, -4.89795431e-02f, 4.07206267e-02f, 1.15651153e-02f, -5.42265102e-02f, -1.60280447e-02f, -4.65274341e-02f, 2.52664052e-02f,
  -4.72420603e-02f, -4.23580129e-03f, 1.23566858e-01f, 8.80842283e-02f, 1.03810228e-01f, -2.64795939e-03f, 9.64141339e-02f, -4.02780212e-02f, 4.38898951e-02f, 7.84197152e-02f,
  4.46275249e-02f, 4.71606143e-02f, -3.76407132e-02f, -2.14323662e-02f, -4.76940870e-02f, 3.57222073e-02f, 2.91007403e-02f, 5.24602234e-02f, 6.46567643e-02f, 1.41603574e-02f,
  -4.54215072e-02f, 5.57645690e-03f, 1.69760436e-01f, -8.56071338e-03f, 3.03314291e-02f, 5.89494742e-02f, 7.60792494e-02f, 7.51958415e-02f, 2.20166057e-01f, 4.59430777e-02f,
  -6.08564578e-02f, -2.40676701e-01f, -1.05692251e-02f, 1.50031582e-01f, 2.35483170e-01f, 3.13325703e-01f, 1.29913568e-01f, 1.50960281e-01f, 1.07616872e-01f, -6.28005192e-02f,
  -1.02982305e-01f, 1.04682378e-01f, 4.03752476e-02f, 1.82442978e-01f, 1.99291915e-01f, 1.22070953e-01f, 2.48438507e-01f, 1.82105824e-01f, 1.89628854e-01f, 2.34660402e-01f,
  9.89411548e-02f, -1.38529554e-01f, -1.14133187e-01f, 5.97007722e-02f, -2.83084717e-02f, 4.07126583e-02f, -1.06306329e-01f, -6.54839501e-02f, -5.21135703e-02f, 4.86300252e-02f,
  -1.20774426e-01f, -1.04870558e-01f, 2.49470532e-01f, 1.42091230e-01f, -1.99510809e-02f, 5.36161661e-02f, 9.37682092e-02f, 8.87536258e-03f, 9.44840536e-02f, 5.50972037e-02f,
  -5.24047539e-02f, -2.52593914e-03f, 8.64026025e-02f, 6.96036220e-02f, 5.88564649e-02f, 4.19853851e-02f, -4.01234664e-02f, 1.07589431e-01f, 1.92928240e-01f, 5.04517518e-02f,
  5.05750701e-02f, 1.17489271e-01f, 3.54500371e-03f, 9.40653458e-02f, 9.98976678e-02f, 8.30485821e-02f, -6.00862168e-02f, -3.79310250e-02f, 5.54010682e-02f, 3.11811436e-02f,
  -1.89401526e-02f, -9.60018039e-02f, -9.56761464e-02f, -1.31961554e-01f, -1.13773771e-01f, -7.44333938e-02f, -2.42159124e-02f, -8.70940089e-02f, 2.50073266e-03f, -2.50936359e-01f,
  -3.42887975e-02f, -1.01840198e-01f, -1.78420674e-02f, -7.48760998e-02f, -1.05381660e-01f, -1.61899954e-01f, -8.67309272e-02f, -1.56727567e-01f, -1.15726940e-01f, -6.83197230e-02f,
  -1.58350736e-01f, -1.12183355e-01f, -2.19644830e-01f, -4.98090871e-02f, -1.14355609e-02f, -1.12404920e-01f, -1.51765808e-01f, -9.09849852e-02f, -1.60082266e-01f, -8.98102745e-02f,
  -1.92021504e-01f, 2.26180837e-01f, 1.28726244e-01f, 3.11440248e-02f, 4.22781818e-02f, 7.54373744e-02f, -2.78520919e-02f, 2.57081166e-02f, 8.54974017e-02f, 1.14366040e-01f,
  9.34330106e-04f, 5.18381894e-02f, -1.60526037e-02f, 8.94443225e-03f, 1.22927710e-01f, 3.49166691e-02f, 1.32980021e-02f, 1.56764597e-01f, 9.98955965e-02f, 9.55772698e-02f,
  6.81100786e-02f, 7.18131512e-02f, 1.59335166e-01f, 1.43275023e-01f, 1.49831131e-01f, 2.92257071e-01f, 5.88492341e-02f, 1.69701785e-01f, 1.69259354e-01f, 1.29277661e-01f,
  -2.46327713e-01f, -2.70397514e-01f, -1.49847060e-01f, -1.39931357e-02f, -9.00196508e-02f, -1.33632123e-01f, -2.36290410e-01f, 2.29901895e-02f, -2.39842180e-02f, -2.59661943e-01f,
  -2.90605605e-01f, 1.72901034e-01f, 6.67293444e-02f, 1.48165241e-01f, 5.21038808e-02f, -2.00347036e-01f, 3.35184596e-02f, 1.34021848e-01f, 3.36114109e-01f, 5.71544021e-02f,
  2.02804670e-01f, 2.23303571e-01f, 8.77646953e-02f, 1.46084100e-01f, -1.37306256e-02f, 1.11645140e-01f, -4.00053337e-02f, -1.06160857e-01f, -1.32735416e-01f, -9.40473378e-02f,
  2.15755720e-02f, -1.37274563e-01f, 1.24361992e-01f, 3.03513575e-02f, -3.28389965e-02f, -2.34680492e-02f, 5.53221218e-02f, 1.82892866e-02f, -2.08876487e-02f, -1.22455675e-02f,
  -2.72293109e-02f, 1.30672250e-02f, 1.38327688e-01f, 6.23779818e-02f, 3.22714038e-02f, 8.89546890e-03f, 6.42607659e-02f, 7.50926509e-02f, 7.94939697e-03f, -8.16093609e-02f,
  4.01555672e-02f, -1.62355140e-01f, -1.09843530e-01f, -2.63247639e-02f, 3.03352848e-02f, -1.59709416e-02f, 3.44539136e-02f, -1.07906861e-02f, -2.13930532e-02f, -6.41561821e-02f,
  7.75656430e-03f, -4.46608216e-02f, 1.41947847e-02f, 7.77333677e-02f, 8.36025178e-02f, -4.68177125e-02f, -2.72185374e-02f, -1.14234779e-02f, 7.42936656e-02f, 9.86912027e-02f,
  3.63563448e-02f, 3.34595442e-02f, 2.33803294e-03f, -2.06251331e-02f, -5.65545820e-03f, -9.81861353e-02f, -2.16215104e-03f, -3.89240757e-02f, -6.09391704e-02f, 9.40499604e-02f,
  9.93529186e-02f, 2.08896324e-02f, -2.54613049e-02f, 2.57297661e-02f, -2.35177707e-02f, 3.97679918e-02f, -1.40168518e-02f, 6.66146502e-02f, -3.74376366e-04f, -9.67733115e-02f,
  2.18254164e-01f, -5.30656055e-02f, 5.25448285e-02f, 1.11971058e-01f, -8.10936019e-02f, 3.15546133e-02f, -3.33410092e-02f, 9.96690840e-02f, 3.47555168e-02f, 8.63498747e-02f,
  1.13206306e-05f, 8.28505829e-02f, -5.12571866e-03f, 6.15362823e-02f, 1.17769852e-01f, 3.05301957e-02f, 7.20314533e-02f, 4.04255502e-02f, -4.31188866e-02f, 3.39036956e-02f,
  -6.41473755e-02f, -3.20964605e-02f, 3.46968994e-02f, 9.45131183e-02f, 5.59331998e-02f, 2.87103076e-02f, 1.16544828e-01f, 7.56648323e-03f, 6.71614334e-02f, 1.23164050e-01f,
  1.32171914e-01f, -7.63385519e-02f, -3.34244519e-01f, -4.61921766e-02f, -1.51783094e-01f, -1.03275508e-01f, -1.03943869e-01f, 5.52874021e-02f, 1.06391534e-01f, -1.42797202e-01f,
  -8.57676864e-02f, -1.48980469e-01f, -1.28698945e-01f, -1.36367932e-01f, -3.46838008e-03f, -1.17038898e-01f, -1.34619266e-01f, -1.49284482e-01f, -8.93175229e-02f, 2.43367162e-02f,
  7.18648406e-03f, -7.15414062e-02f, 1.14552293e-03f, -1.42154447e-03f, -1.78785488e-01f, -1.14676565e-01f, -2.30742693e-01f, -2.81665117e-01f, -2.81988561e-01f, -1.93654999e-01f,
  -4.36706454e-01f, 7.83652887e-02f, 3.13284844e-02f, 2.39995820e-03f, -9.41010378e-03f, 1.05832234e-01f, 7.80389532e-02f, 7.74550214e-02f, 5.84098585e-02f, -5.65094016e-02f,
  9.89257023e-02f, 6.42078649e-03f, -6.70423284e-02f, 4.67637926e-02f, 1.00011043e-01f, -8.26687925e-03f, 6.09392263e-02f, 3.90836373e-02f, 1.02150574e-01f, -2.59084590e-02f,
  -3.36996615e-02f, 5.35430163e-02f, -5.57340942e-02f, -3.20838811e-03f, 1.91478617e-03f, -5.03766537e-02f, -7.79349804e-02f, -4.08668593e-02f, -7.33395442e-02f, -1.14955522e-01f,
  -1.46450743e-01f, -6.42053410e-03f, -5.13750687e-02f, 3.65100871e-03f, 4.20070216e-02f, 6.94863200e-02f, 2.64396109e-02f, -5.91975115e-02f, 6.64345846e-02f, -1.29575497e-02f,
  -2.00764854e-02f, -7.11726174e-02f, 2.08513476e-02f, -2.09944304e-02f, -5.01486510e-02f, 2.69776043e-02f, 9.48837250e-02f, 4.33145650e-02f, -4.28138413e-02f, 8.44068378e-02f,
  -2.23993398e-02f, -2.29142271e-02f, 4.44636419e-02f, 3.59364264e-02f, -2.11797915e-02f, -4.94459122e-02f, 6.50093108e-02f, 1.59606617e-02f, 7.71791562e-02f, 9.11971927e-02f,
  -1.03443898e-01f, 2.04212796e-02f, -8.03941488e-02f, 2.67692492e-03f, -1.29402718e-02f, 4.31281701e-02f, -1.41372662e-02f, -4.32298481e-02f, 2.39485390e-02f, 4.47250381e-02f,
  7.02258274e-02f, -5.64873638e-03f, 1.45097775e-02f, -1.22165702e-01f, -1.31936774e-01f, -1.69968270e-02f, 8.00548121e-02f, -1.11889854e-01f, 3.04832906e-02f, 3.17134857e-02f,
  -1.17909396e-02f, -1.06813855e-01f, -4.17471826e-02f, -2.54434925e-02f, -2.06844229e-03f, -1.35411352e-01f, -1.70399502e-01f, -9.02488008e-02f, -2.98384042e-03f, -4.22341190e-02f,
  -3.33931774e-01f, 1.99607417e-01f, 5.89704923e-02f, -1.38480037e-01f, -3.44385237e-01f, -1.97077706e-01f, -1.64511651e-01f, -8.14466104e-02f, -1.62121758e-01f, 4.26413342e-02f,
  -7.13053048e-02f, 5.49957603e-02f, 1.33808509e-01f, 1.80322349e-01f, 1.80098027e-01f, 1.47653729e-01f, 1.57698333e-01f, 2.49862298e-01f, 6.96584061e-02f, -2.08216578e-01f,
  -1.89023968e-02f, 1.29078805e-01f, 5.66430539e-02f, 8.94222558e-02f, -3.84506136e-02f, 4.07779701e-02f, 1.49461981e-02f, -7.93571845e-02f, 6.84968904e-02f, 2.11328715e-01f,
  1.44116879e-01f, -2.27574587e-01f, -1.25735649e-03f, -5.85715435e-02f, -7.39605399e-03f, -2.15146411e-03f, -5.10552637e-02f, 7.65469968e-02f, -9.05818120e-02f, -8.68096128e-02f,
  -3.92531902e-02f, -1.54472992e-01f, -8.36583972e-03f, -6.73631877e-02f, -1.35760993e-01f, -3.12397871e-02f, 2.44921651e-02f, 1.11988589e-01f, -2.72799283e-02f, -1.18753135e-01f,
  -7.87155796e-03f, -1.29710719e-01f, -1.78789869e-01f, -1.30733877e-01f, -6.61619678e-02f, -1.03973210e-01f, -1.09867789e-02f, -9.90816727e-02f, 1.31161988e-03f, -8.98340344e-02f,
  -9.64122117e-02f, -4.60879803e-02f, -2.85447594e-02f, -4.03079130e-02f, -6.29003718e-02f, 2.29318514e-02f, 5.38588911e-02f, -1.27574261e-02f, -5.94254360e-02f, 5.65048121e-02f,
  9.37690679e-03f, -1.13324514e-02f, -7.56883621e-02f, -5.75193837e-02f, 4.07263227e-02f, -1.96413184e-03f, -2.94497348e-02f, 6.61754087e-02f, 5.46794571e-03f, -4.71516373e-03f,
  -1.17635697e-01f, 3.35013941e-02f, -4.90350015e-02f, 8.74960646e-02f, 9.96253174e-03f, 6.10333402e-03f, -8.71350616e-02f, -1.48641085e-02f, 2.39194208e-03f, -9.98426080e-02f,
  1.82804123e-01f, 3.03438702e-03f, -4.59454097e-02f, 8.66102502e-02f, -8.58630612e-02f, 5.97183034e-02f, -5.57850823e-02f, 1.03549613e-02f, 5.41037647e-03f, -2.05349289e-02f,
  -1.40029028e-01f, 3.87206711e-02f, 7.02231079e-02f, -4.30323407e-02f, -4.28879894e-02f, -1.16413318e-01f, 6.56607226e-02f, -4.27343249e-02f, 2.46075653e-02f, -1.32375816e-03f,
  6.35940805e-02f, -4.20431197e-02f, -4.85554710e-02f, -3.80299017e-02f, -5.08149564e-02f, -6.22279197e-02f, 5.76074608e-02f, -9.96815227e-03f, -1.01033591e-01f, -7.61909410e-02f,
  -3.07915181e-01f, -1.75083220e-01f, -8.38505626e-02f, -1.88875571e-01f, -1.43040031e-01f, 2.35769212e-01f, 2.69559115e-01f, 9.58468467e-02f, -4.53631729e-02f, -1.25766456e-01f,
  -1.30413964e-01f, -2.16311783e-01f, -5.13200276e-03f, 3.22580934e-02f, 2.31800348e-01f, 2.07124025e-01f, 1.18857719e-01f, 1.50861293e-01f, 1.51480019e-01f, 1.27387702e-01f,
  5.69122843e-03f, -6.61550760e-02f, -1.09585151e-01f, 1.35701876e-02f, -1.64939836e-01f, -1.31348163e-01f, -3.38802561e-02f, -2.07231238e-01f, 2.84636598e-02f, -2.97356963e-01f,
  -2.64441043e-01f, -3.84860069e-01f, 2.31133625e-02f, -1.01226673e-01f, -1.08412012e-01f, 1.67804714e-02f, -1.98270939e-02f, -9.73158628e-02f, -1.77074596e-01f, -1.20672770e-01f,
  -1.59583345e-01f, -7.41901621e-02f, -1.52437478e-01f, -5.67977764e-02f, -1.12153113e-01f, -1.69844553e-02f, -9.14978758e-02f, -2.73466278e-02f, 3.58551033e-02f, -8.43764171e-02f,
  -1.41580716e-01f, -1.21035688e-01f, -1.41124099e-01f, 2.91986410e-02f, -8.78683999e-02f, -1.08657867e-01f, -5.26508018e-02f, -3.81731763e-02f, 8.57134312e-02f, -1.65328518e-01f,
  1.42442897e-01f, 9.47930068e-02f, 8.10949951e-02f, 6.69700354e-02f, 1.01339653e-01f, 1.17990866e-01f, 4.49729115e-02f, 1.41826451e-01f, 5.26672341e-02f, 1.26044378e-01f,
  3.03417630e-02f, 1.43799320e-01f, 9.50957164e-02f, 4.29272428e-02f, 3.66473459e-02f, -1.89053025e-02f, 1.02287151e-01f, 1.60813361e-01f, 7.17327371e-02f, 4.45925407e-02f,
  -7.05046766e-03f, 1.07950807e-01f, 1.51370894e-02f, 1.31735936e-01f, 1.39464010e-02f, 9.42806825e-02f, 8.43612775e-02f, 1.25368819e-01f, 5.17056249e-02f, -5.20260911e-03f,
  -7.49184415e-02f, 9.61687416e-02f, -1.47761971e-01f, -8.60181730e-03f, -1.85622111e-01f, -1.39265075e-01f, -8.36990625e-02f, -4.70121689e-02f, -1.59973904e-01f, -3.93863618e-02f,
  -1.11524053e-02f, -1.06410183e-01f, -5.83968535e-02f, -3.39106247e-02f, 2.66369618e-02f, -1.96409058e-02f, -8.67691562e-02f, -2.52331477e-02f, -6.86053839e-03f, -7.98146874e-02f,
  4.95805964e-02f, 8.69706646e-02f, 1.36533320e-01f, 5.30760735e-02f, 8.28240626e-03f, 1.15359770e-02f, 4.01130095e-02f, 5.49996011e-02f, 1.32428691e-01f, 2.39466324e-01f,
  1.54578090e-01f, -1.64034322e-01f, 1.98979542e-01f, -6.53664172e-02f, -2.27893665e-01f, -2.08158121e-01f, -3.18897843e-01f, -8.05148259e-02f, -1.86431214e-01f, -8.83227587e-02f,
  -1.99784786e-01f, -1.48494601e-01f, -2.70574272e-01f, -9.12334174e-02f, -1.64717630e-01f, -2.31758654e-01f, -1.80754885e-01f, 9.79226306e-02f, 1.08982317e-01f, -7.24997697e-03f,
  -1.52677968e-01f, -1.02153152e-01f, 1.62737012e-01f, -5.84276803e-02f, -1.82399154e-01f, -1.10091165e-01f, -1.56620607e-01f, 3.90236303e-02f, -4.31509353e-02f, -3.71376332e-03f,
  -9.40569714e-02f, 1.15213312e-01f, -1.80433601e-01f, -1.21777385e-01f, -1.37582824e-01f, -4.39402312e-02f, -4.09755707e-02f, -2.79215127e-02f, -2.04884067e-01f, -1.45104244e-01f,
  -6.08416870e-02f, -1.51878253e-01f, -1.07129641e-01f, -7.65543804e-02f, -1.45515531e-01f, -9.08945948e-02f, -1.28913850e-01f, -8.77152830e-02f, -1.57671928e-01f, -4.49828543e-02f,
  -2.48981044e-01f, -1.23276412e-02f, -9.73749384e-02f, -2.56244332e-01f, -4.12657261e-02f, -5.33160791e-02f, -1.30665451e-01f, -5.12147173e-02f, -1.24519773e-01f, -8.92292932e-02f,
  9.65122283e-02f, 1.09268248e-01f, 1.50240198e-01f, 1.41349584e-01f, 1.01104975e-01f, 1.04407839e-01f, 6.27533942e-02f, 9.79555994e-02f, 1.09047212e-01f, 1.12429298e-01f,
  1.27682596e-01f, 1.78262934e-01f, 4.33673263e-02f, 2.01614946e-01f, 8.31505582e-02f, 1.57692492e-01f, 1.73619732e-01f, 1.71438068e-01f, 1.26852438e-01f, 1.07232012e-01f,
  2.02822447e-01f, 2.06469700e-01f, 1.85408533e-01f, 5.66877052e-02f, 1.81355387e-01f, 1.90156370e-01f, 1.48152635e-01f, 2.05443874e-01f, 8.93173888e-02f, 2.36029074e-01f,
  -3.66009533e-01f, 7.40495101e-02f, -1.67605504e-01f, -1.03654474e-01f, -6.04624562e-02f, -1.13233902e-01f, -1.55854240e-01f, -7.99007043e-02f, -9.87294912e-02f, -8.14446807e-02f,
  -2.92206667e-02f, -1.66828614e-02f, -1.31935939e-01f, -1.40305609e-01f, -1.63211405e-01f, -1.13078542e-01f, -1.47778004e-01f, -1.51173338e-01f, -7.83586651e-02f, -4.07961197e-02f,
  -1.15579240e-01f, -1.28081769e-01f, -2.13990360e-01f, -2.51343697e-01f, -1.06758408e-01f, -2.48188883e-01f, -2.33917505e-01f, -2.07512021e-01f, -1.49334639e-01f, -3.52708191e-01f,
  -5.33229351e-01f, 2.77093023e-01f, -1.51954919e-01f, -4.24364135e-02f, 1.57118022e-01f, 7.36788735e-02f, 4.75594737e-02f, -6.24772273e-02f, 4.77841571e-02f, 1.18581004e-01f,
  1.62872002e-01f, 6.70532957e-02f, -8.68726149e-02f, -2.10705139e-02f, -2.67049611e-01f, 7.86128938e-02f, 2.80912891e-02f, -3.07583839e-01f, -3.68250251e-01f, -8.47255066e-02f,
  1.47724941e-01f, -9.94532555e-02f, -2.35633895e-01f, -1.81435440e-02f, 2.88634002e-01f, 9.86570939e-02f, 7.81849772e-02f, 1.72385857e-01f, 1.32694334e-01f, 7.93207288e-02f,
  6.65262435e-03f, 2.42016967e-02f, -6.72176294e-03f, 1.00791998e-01f, 8.23278874e-02f, -4.45330143e-02f, -2.48741414e-02f, -3.90695315e-03f, 2.78289542e-02f, 6.79904744e-02f,
  1.13763079e-01f, 5.16697727e-02f, 3.87036316e-02f, 3.91530097e-02f, 2.03117579e-02f, -1.02024490e-03f, 1.02796098e-02f, 1.25274016e-03f, -7.98452124e-02f, 1.24397404e-01f,
  1.48237303e-01f, 9.42047834e-02f, 6.31788298e-02f, 1.69258993e-02f, -8.54219049e-02f, 4.57826480e-02f, -3.61629948e-02f, 3.71469222e-02f, -9.17326063e-02f, 6.32227883e-02f,
  1.36411823e-02f, -5.18704429e-02f, -1.18515506e-01f, -3.48038822e-02f, -3.52533087e-02f, -5.43597117e-02f, -6.54926477e-03f, 2.61434931e-02f, -1.10750504e-01f, -1.93473957e-02f,
  -7.14250430e-02f, -2.92036310e-02f, -1.31733134e-01f, -3.12973037e-02f, -5.60231134e-02f, -2.77691036e-02f, -1.34916186e-01f, 1.00644091e-02f, -5.22721894e-02f, 2.54831202e-02f,
  -1.03891522e-01f, -7.87590742e-02f, -2.64776275e-02f, -5.61112501e-02f, -9.44482014e-02f, -4.26261649e-02f, -4.27198363e-03f, -6.05362421e-03f, 2.08246130e-02f, -5.67599609e-02f,
  8.59278962e-02f, -1.13506302e-01f, -5.47720753e-02f, -2.61364710e-02f, 9.14110616e-02f, 8.88807699e-02f, 5.82746826e-02f, -3.64251807e-02f, 8.26708749e-02f, -5.98060116e-02f,
  -2.79707592e-02f, -7.43077323e-02f, 7.04199588e-03f, 7.69277588e-02f, 4.99429852e-02f, 1.01908660e-02f, 1.02357052e-01f, -6.46590218e-02f, 7.64599396e-03f, 6.71751946e-02f,
  1.71006322e-01f, -5.45567386e-02f, -1.78044975e-01f, -7.63898492e-02f, 9.22783092e-02f, -1.34045616e-01f, 1.78644843e-02f, 2.76274495e-02f, -9.01497453e-02f, 7.72507191e-02f,
  3.62710893e-01f, -2.98152864e-01f, 4.33694646e-02f, -1.09707549e-01f, 4.26840363e-03f, 7.09879324e-02f, 4.43585813e-02f, 1.09141916e-01f, -3.09543703e-02f, -1.17578007e-01f,
  -1.14943951e-01f, 1.38212591e-01f, 7.05096275e-02f, 9.29521248e-02f, 9.48404446e-02f, -6.27173185e-02f, -1.40761048e-01f, 1.30997881e-01f, 2.63932735e-01f, 2.93329328e-01f,
  5.95703162e-02f, -5.46219945e-02f, 8.19357783e-02f, 2.34569814e-02f, 1.53374420e-02f, 4.69509400e-02f, -4.99605797e-02f, -1.18151970e-01f, 9.08212271e-03f, -9.06902477e-02f,
  2.26458564e-01f, 7.36531802e-03f, 1.51109591e-01f, 2.10506078e-02f, -7.08486736e-02f, -6.60241628e-03f, 7.44178072e-02f, 5.35128564e-02f, -1.02507778e-01f, -5.16928136e-02f,
  -1.33640468e-02f, 8.68902802e-02f, -4.79275621e-02f, -5.22975177e-02f, -3.52656431e-02f, 9.30867419e-02f, -9.37277973e-02f, -5.12236394e-02f, 4.67067026e-02f, -4.14513946e-02f,
  -1.06655098e-01f, 3.12568247e-02f, 7.09057450e-02f, 1.83983017e-02f, 2.51359511e-02f, 8.91305320e-03f, -2.44538672e-02f, 1.35511026e-01f, 8.82245898e-02f, 6.59395531e-02f,
  3.31441425e-02f, -4.27510776e-02f, 2.31693424e-02f, -7.87675679e-02f, -1.86242629e-02f, -9.20194760e-02f, -6.55246973e-02f, -1.00733958e-01f, -4.13218513e-02f, 6.47930836e-04f,
  -4.59371507e-02f, 2.94246282e-02f, -9.48600322e-02f, -5.53345457e-02f, -9.69856419e-03f, -3.15706320e-02f, -3.74117196e-02f, -1.16851136e-01f, -7.14281648e-02f, -7.13981837e-02f,
  -7.91463628e-02f, -3.74976806e-02f, -2.47136485e-02f, -1.45730928e-01f, -4.53865565e-02f, -1.08481757e-01f, -7.56804645e-02f, -1.51728699e-02f, 1.99218169e-02f, -3.53060551e-02f,
  -5.42233251e-02f, -3.96576039e-02f, 4.74713780e-02f, 2.26178262e-02f, 2.25487389e-02f, 5.41971922e-02f, -4.87374105e-02f, -6.78166226e-02f, 2.70542107e-03f, 9.94169712e-02f,
  7.70450234e-02f, -1.24441441e-02f, 1.18868677e-02f, 6.93986639e-02f, 1.37339175e-01f, 4.25386690e-02f, 2.66610575e-03f, 5.01154102e-02f, -7.49600902e-02f, 4.41926122e-02f,
  -1.57238096e-01f, 1.18622258e-01f, 1.17480762e-01f, -1.67022627e-02f, -5.87482564e-03f, 2.01447859e-01f, 3.76441106e-02f, 1.82374746e-01f, 1.18106969e-01f, 4.04377989e-02f,
  -9.84543264e-02f, 2.30654240e-01f, 2.85761744e-01f, 1.44834667e-01f, 1.69931054e-01f, 7.92557895e-02f, -3.26056629e-02f, 8.41038078e-02f, 1.09675623e-01f, 4.85561602e-02f,
  1.36180267e-01f, 9.71167088e-02f, 1.98717102e-01f, 1.30038336e-01f, 7.14516416e-02f, 2.54233420e-01f, 2.08836377e-01f, 2.98595816e-01f, 3.74520123e-02f, -9.86338481e-02f,
  6.05692044e-02f, 1.12299877e-03f, 1.01682633e-01f, 1.37340739e-01f, 1.07901201e-01f, 7.79616013e-02f, 2.38676250e-01f, 1.83077157e-01f, 3.09844673e-01f, 2.59596169e-01f,
  4.83337194e-02f, 1.30190015e-01f, 6.07290305e-04f, 2.17153877e-02f, 8.24445263e-02f, 1.21846208e-02f, 2.69287601e-02f, 5.50914630e-02f, 7.65215084e-02f, -8.70600529e-03f,
  1.03722833e-01f, 1.01626724e-01f, 7.29190260e-02f, 8.10094997e-02f, 9.22202319e-02f, 2.78005432e-02f, 1.57654658e-01f, 6.59741610e-02f, 1.45156190e-01f, 8.05175602e-02f,
  4.93142232e-02f, 1.13265708e-01f, 8.56757164e-02f, 1.38873354e-01f, 1.44340456e-01f, 2.43881419e-02f, -7.07069784e-03f, 1.11296937e-01f, 5.40100113e-02f, -1.36185596e-02f,
  -2.06162691e-01f, 3.46529447e-02f, 7.22611919e-02f, -1.07192136e-01f, -6.36330768e-02f, 7.50998408e-02f, -3.41895558e-02f, -3.67746986e-02f, 3.66624594e-02f, 2.89804451e-02f,
  1.85772292e-02f, -5.26060574e-02f, 5.75029217e-02f, -4.39194590e-02f, 3.77462208e-02f, 1.30285874e-01f, 6.19766593e-04f, -4.90583852e-02f, 9.82197896e-02f, -9.47371591e-03f,
  4.43684943e-02f, -5.59036201e-03f, 1.42767563e-01f, -9.71023925e-03f, 3.04689482e-02f, 6.74329698e-02f, -5.50138727e-02f, 4.72094603e-02f, -4.14648987e-02f, -1.12576354e-02f,
  -2.62559354e-01f, 2.37731576e-01f, 8.01424030e-04f, -9.38500371e-03f, 1.53691232e-01f, 4.25542258e-02f, 1.25780851e-01f, 9.53968167e-02f, 1.14736870e-01f, 3.46433930e-02f,
  7.77984932e-02f, -2.93867346e-02f, 9.93501991e-02f, -1.89608578e-02f, -6.72658533e-03f, -4.52660918e-02f, -8.24853126e-03f, 1.25841722e-01f, 1.53471440e-01f, 7.20938435e-03f,
  2.96991654e-02f, -2.53962800e-02f, -1.34322852e-01f, -3.87153635e-03f, -5.15550226e-02f, -3.60251814e-02f, 1.69816259e-02f, -1.02706432e-01f, -1.14923567e-02f, -2.24609375e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.01402956e-01f, -2.70576358e-01f, 1.01810224e-01f, -2.48015106e-01f, -3.68195891e-01f, -1.80329740e-01f, -2.66643316e-01f, 1.13749601e-01f, -2.49545261e-01f, -6.20050311e-01f,
  -4.18616027e-01f, -2.32579947e-01f, -4.20350194e-01f, -9.26717445e-02f, 2.40788385e-01f, -3.15036297e-01f, -1.41975135e-01f, 4.44692343e-01f, 8.08297753e-01f, 4.45162505e-01f,
  -1.07452907e-01f, 1.63128495e-01f, 5.83856285e-01f, 4.53262091e-01f, -2.99915135e-01f, 9.28634871e-03f, -2.42671430e-01f, -1.32555723e-01f, -2.67640129e-02f, -3.66011292e-01f,
  -3.22098523e-01f, 2.26106748e-01f, 1.14741676e-01f, 9.09413323e-02f, -1.55164883e-01f, 1.61821302e-02f, 3.77559923e-02f, 1.18666515e-01f, 5.04150288e-03f, 1.74083803e-02f,
  -3.20284635e-01f, -9.81961144e-04f, -3.09612632e-01f, 3.26506160e-02f, 2.74409372e-02f, 1.99437037e-01f, 2.40963697e-01f, 4.70755309e-01f, 1.58500403e-01f, 4.29188460e-03f,
  -3.48607004e-01f, 1.42498594e-02f, 2.34576501e-02f, 1.45279080e-01f, 1.39892817e-01f, 8.00208673e-02f, 1.28919125e-01f, 3.29977661e-01f, 2.29189798e-01f, -3.44100773e-01f,
  -3.82279046e-02f, -3.12591307e-02f, -1.32659957e-01f, -1.20813116e-01f, -1.07656516e-01f, -9.51503441e-02f, -6.47012610e-04f, -1.02584409e-02f, -2.42862664e-02f, -4.17303741e-02f,
  6.62019178e-02f, -6.36237264e-02f, 1.12579569e-01f, 8.08493514e-03f, -2.30417587e-02f, -8.18687901e-02f, 7.15661794e-03f, 2.05699816e-01f, 4.37132940e-02f, -2.60590948e-02f,
  1.05171748e-01f, -1.12990960e-02f, -2.85735521e-02f, 1.58612505e-01f, 6.64477646e-02f, 1.80339381e-01f, -4.32356223e-02f, 1.28274426e-01f, -8.18701535e-02f, -5.21617383e-02f,
  -2.52000362e-01f, 1.99734241e-01f, -4.22061890e-01f, 1.53484121e-01f, -2.35843956e-01f, 7.75931552e-02f, -7.23521784e-02f, 9.04250816e-02f, 1.37431128e-02f, 6.59994483e-02f,
  9.07396600e-02f, 5.29578477e-02f, -1.58767670e-01f, -5.33010177e-02f, -7.15320334e-02f, -1.50785372e-01f, -2.12645650e-01f, -1.74044311e-01f, 4.61340547e-02f, -1.62276387e-01f,
  -6.62555024e-02f, -5.23058288e-02f, -2.83588409e-01f, -2.24879041e-01f, -1.34487629e-01f, -1.78715274e-01f, -1.62163511e-01f, -1.62750691e-01f, -2.38610014e-01f, -6.18815720e-01f,
  5.23278058e-01f, 6.47987425e-01f, 6.02669045e-02f, 4.15150434e-01f, 1.81426093e-01f, 3.50868016e-01f, 5.26108801e-01f, 3.77731144e-01f, 2.82041043e-01f, 3.83887559e-01f,
  3.45100045e-01f, 3.18352818e-01f, 2.01275438e-01f, 2.57763237e-01f, 2.10833386e-01f, 2.44608194e-01f, 5.99766560e-02f, 6.31867871e-02f, 5.70262223e-02f, 1.98855788e-01f,
  2.15615258e-01f, 2.34784245e-01f, 1.66730955e-01f, 5.88969700e-02f, 1.28900945e-01f, 1.70958087e-01f, 2.46932298e-01f, 2.26578683e-01f, 2.31643662e-01f, 1.34962082e-01f,
  -3.40594858e-01f, 2.44893208e-02f, -1.21000037e-01f, -1.37212753e-01f, -3.05953398e-02f, 9.31313820e-03f, -6.77502677e-02f, -2.29644142e-02f, -9.55698937e-02f, -6.81247860e-02f,
  -1.38284013e-01f, -1.45830601e-01f, -5.32769933e-02f, -3.77390087e-02f, -2.06023723e-01f, -2.22752482e-01f, 5.76831587e-02f, 1.17590949e-02f, -4.42497507e-02f, -6.01330847e-02f,
  1.27947768e-02f, -7.41058439e-02f, 1.39234168e-02f, 7.01645613e-02f, 7.48081207e-02f, -9.11033887e-04f, -1.35014892e-01f, -5.82481883e-02f, -6.18089288e-02f, 7.14000016e-02f,
  1.48992956e-01f, 9.29404944e-02f, -7.00190589e-02f, 6.23571500e-02f, 1.06111448e-02f, -1.25503317e-01f, -1.23154670e-01f, 5.08299023e-02f, 1.05301194e-01f, 5.22632673e-02f,
  -9.60199758e-02f, 4.17910591e-02f, -3.35447188e-03f, -1.37528837e-01f, -3.31859328e-02f, -1.43592656e-01f, -6.81414753e-02f, -1.00861706e-01f, -2.07699537e-01f, -1.18166283e-01f,
  -8.54916521e-04f, -9.33029279e-02f, -1.40020490e-01f, -1.83799982e-01f, -1.61446244e-01f, -1.55876637e-01f, -8.91923308e-02f, -3.66552025e-02f, -3.45888287e-02f, -5.86792864e-02f,
  9.58344936e-02f, -2.43217647e-02f, 8.52641314e-02f, 3.55168208e-02f, -1.02629147e-01f, -1.19505860e-02f, 1.22482322e-01f, -8.06281716e-02f, -8.74110833e-02f, -1.43002614e-01f,
  -1.45437270e-01f, -1.29447892e-01f, 7.82220811e-03f, -9.96047035e-02f, -1.88431263e-01f, -1.25228822e-01f, 7.33614936e-02f, 1.10624403e-01f, -3.85669544e-02f, -4.48344611e-02f,
  6.85764989e-03f, -6.29652813e-02f, -9.22560245e-02f, 2.48532686e-02f, 2.65531670e-02f, -5.85393375e-03f, -8.04765224e-02f, -1.95781235e-02f, -8.19566399e-02f, 8.36852589e-04f,
  2.08946362e-01f, 1.72302902e-01f, -9.20132637e-01f, 2.02044874e-01f, -1.98685244e-01f, -2.03494266e-01f, -6.26221895e-02f, 2.48938680e-01f, 3.28700006e-01f, 2.07767114e-01f,
  -3.95169854e-02f, -2.51066178e-01f, -3.89108717e-01f, -2.73815840e-01f, -4.73486871e-01f, -2.80512869e-01f, -3.77668083e-01f, -7.24489391e-01f, -7.17622519e-01f, -2.41087794e-01f,
  -5.06076366e-02f, -3.22078705e-01f, -2.07913160e-01f, -2.37281799e-01f, 1.33099943e-01f, -1.89243495e-01f, -3.05133730e-01f, -3.84457737e-01f, -1.30520836e-01f, -2.73408949e-01f,
  -6.95997000e-01f, -9.52220485e-02f, 5.15124835e-02f, 1.71206281e-01f, 6.66699409e-02f, 2.61976033e-01f, 5.06476648e-02f, 1.61264047e-01f, 2.15433925e-01f, 8.36715549e-02f,
  -1.20988190e-01f, 1.09224632e-01f, -6.73969314e-02f, -1.64513737e-01f, 2.54097283e-02f, 2.32547894e-02f, 1.33500412e-01f, 4.93608192e-02f, 1.35111511e-01f, 2.63319343e-01f,
  2.22899899e-01f, -1.32161956e-02f, -1.44149028e-02f, 1.59598008e-01f, 7.01353624e-02f, -9.28729773e-02f, 4.72146869e-02f, 1.61911771e-01f, 7.43768662e-02f, 1.75168663e-01f,
  -1.39918867e-02f, 3.39394845e-02f, 1.30781040e-01f, 1.26036897e-01f, 9.73731950e-02f, 1.23861790e-01f, 9.87696182e-03f, 4.77772765e-03f, -1.22699380e-01f, -1.90297235e-02f,
  2.13944972e-01f, 1.68969885e-01f, 5.53589426e-02f, 6.74979761e-02f, -7.00670555e-02f, 7.24258125e-02f, -6.80840749e-04f, 1.27861097e-01f, 6.77207932e-02f, 1.60401285e-01f,
  -2.95530874e-02f, 3.35201994e-02f, 1.89238451e-02f, 6.74179802e-03f, -8.02844856e-03f, 9.66616627e-03f, -9.62200984e-02f, 5.84655516e-02f, 6.86149672e-02f, 3.13046351e-02f,
  -4.72337231e-02f, -2.27397770e-01f, 1.72574222e-02f, 9.00629461e-02f, -1.19486593e-01f, 8.27411488e-02f, -1.30703658e-01f, 6.25629723e-02f, 2.50638481e-02f, -5.85447103e-02f,
  -1.08153380e-01f, -2.99527105e-02f, -8.96642953e-02f, 1.57151178e-01f, -3.18752863e-02f, -2.03017354e-01f, 2.86866128e-01f, -1.34122185e-02f, 1.72787949e-01f, 2.46420205e-01f,
  3.62642497e-01f, 6.57387218e-03f, 1.31209329e-01f, 4.22403887e-02f, 1.56005010e-01f, -7.59683102e-02f, -1.40714854e-01f, 1.14202937e-02f, -2.38095373e-01f, 2.85181731e-01f,
  -8.34784925e-01f, 6.28092706e-01f, 5.57224572e-01f, -2.73329318e-01f, 4.86780167e-01f, 3.19171757e-01f, 3.29612106e-01f, -2.50613570e-01f, -1.94312274e-01f, 3.26212734e-01f,
  4.36123490e-01f, -2.44086772e-01f, 1.91801727e-01f, -1.01584658e-01f, -3.29347789e-01f, 4.26877558e-01f, 4.02917415e-01f, -3.15543562e-01f, -8.46343756e-01f, -6.26055956e-01f,
  -1.84846610e-01f, -3.29266191e-01f, -5.70775568e-01f, -3.23084265e-01f, 2.59448379e-01f, -4.73140068e-02f, 5.35551190e-01f, 1.53380543e-01f, 4.22733039e-01f, 2.89597273e-01f,
  1.67268276e-01f, 4.82509524e-01f, -2.11241990e-01f, -6.62981793e-02f, 2.43432894e-01f, -2.78626323e-01f, -8.87822658e-02f, 6.77352026e-02f, 4.29462194e-02f, -9.78927836e-02f,
  1.88538685e-01f, 3.54760252e-02f, 2.82628864e-01f, 6.45625517e-02f, -1.07817419e-01f, -1.10612959e-01f, -1.06173456e-01f, -3.26843321e-01f, -2.42984980e-01f, -2.05806717e-01f,
  5.89934289e-02f, 5.37339710e-02f, 1.76755413e-01f, 2.93317754e-02f, -8.98157060e-03f, -3.32348436e-01f, -5.49101606e-02f, -3.17061484e-01f, -1.93868816e-01f, -3.87355655e-01f,
  -7.97001421e-02f, 7.15703592e-02f, 8.65100473e-02f, -1.31169762e-02f, -1.54941589e-01f, 8.88981149e-02f, 1.48943469e-01f, -2.18946580e-03f, -2.12435629e-02f, -9.39499140e-02f,
  6.66650236e-02f, 1.19149992e-02f, -7.57264197e-02f, 1.54135823e-01f, -6.80393800e-02f, 1.61616225e-02f, 5.46757318e-03f, -5.62389987e-03f, 9.94560048e-02f, 8.30876175e-03f,
  -9.84571408e-03f, 1.14980988e-01f, -5.32497987e-02f, -1.88888982e-01f, 1.90831050e-01f, 8.40157047e-02f, 8.72100890e-02f, -1.12411872e-01f, -1.23422168e-01f, 5.38747646e-02f,
  -5.46870530e-01f, 1.06740065e-01f, -1.81728050e-01f, -4.72600199e-02f, 2.08302185e-01f, 9.34434384e-02f, 1.85439840e-01f, -1.75849702e-02f, 1.77108735e-01f, -1.73098221e-01f,
  -1.07431016e-03f, 5.69798164e-02f, 3.30958456e-01f, -4.43595909e-02f, -2.11847112e-01f, 6.02180436e-02f, 6.42354190e-02f, -8.59146714e-02f, -1.87356517e-01f, -1.13439105e-01f,
  -6.89241290e-02f, -4.31728482e-01f, -5.45409858e-01f, 1.13621615e-02f, -1.23776354e-01f, -3.91079456e-01f, -1.70288548e-01f, -3.52457970e-01f, -2.48055294e-01f, -5.67006767e-01f,
  -1.32801130e-01f, 1.67374790e-01f, 2.53941447e-01f, 3.83920103e-01f, 6.11961007e-01f, 5.14483869e-01f, 4.35286313e-01f, 3.58958304e-01f, 2.22473666e-01f, 3.76322716e-01f,
  3.59855682e-01f, 1.59982055e-01f, 1.16059057e-01f, 5.17320223e-02f, 1.35016546e-01f, 1.94554701e-01f, 3.10245126e-01f, 4.39702012e-02f, 1.21861100e-01f, 2.27424741e-01f,
  1.44464701e-01f, 2.29531527e-01f, 2.54983790e-02f, 7.36834034e-02f, 1.67273968e-01f, 1.86954319e-01f, 2.64178663e-01f, 3.54228318e-01f, 2.05215827e-01f, -2.62428988e-02f,
  -2.31841981e-01f, -2.75050523e-03f, -1.78290293e-01f, -1.30857393e-01f, -1.53221861e-01f, -1.86979592e-01f, -1.81113440e-03f, 8.59641936e-03f, -9.25390944e-02f, -1.38376191e-01f,
  3.07448115e-02f, -1.02979682e-01f, 1.15763642e-01f, 4.41690162e-02f, 7.32079074e-02f, -5.43307588e-02f, -4.49049957e-02f, 7.89187178e-02f, 1.31146088e-01f, 2.34373100e-02f,
  1.83197036e-02f, 1.59783944e-01f, 8.94383788e-02f, 1.38984337e-01f, 3.07337679e-02f, -1.23562895e-01f, -1.10052153e-02f, -1.02637492e-01f, -4.30337340e-02f, 4.91220690e-03f,
  1.95013598e-01f, 6.69799298e-02f, 2.14123115e-01f, 8.14508647e-02f, 1.57837346e-02f, 7.17752576e-02f, 1.73691809e-01f, 2.52329081e-01f, 2.72872478e-01f, 1.07220478e-01f,
  8.84459242e-02f, 7.01680928e-02f, 1.59826219e-01f, 1.48134619e-01f, 2.95784995e-02f, 2.15705678e-01f, 1.24829069e-01f, 3.12523544e-02f, 8.81667286e-02f, 3.42511609e-02f,
  6.60585612e-02f, 4.44922037e-02f, -1.43700754e-02f, -7.26142228e-02f, -4.44017649e-02f, 8.69112462e-02f, -1.95951648e-02f, 6.23736717e-03f, 5.22297733e-02f, -1.18579447e-01f,
  5.29264033e-01f, -9.84003674e-03f, -8.22675377e-02f, -4.56427187e-02f, -1.16308399e-01f, -1.22397728e-01f, -1.22980043e-01f, -1.74114436e-01f, -1.17450915e-01f, -9.10602584e-02f,
  4.84633446e-02f, -1.33244678e-01f, -7.52637982e-02f, 1.06952645e-01f, 2.83702537e-02f, 2.51560967e-04f, 3.54465656e-02f, 9.79355425e-02f, 3.79994744e-03f, -3.85770807e-03f,
  -2.80961506e-02f, 2.06143841e-01f, 1.75606564e-01f, 1.27142414e-01f, -7.38571882e-02f, 4.52015996e-02f, 4.04693559e-02f, -2.63212658e-02f, -1.44676901e-02f, 1.03307441e-01f,
  6.87883079e-01f, -6.42573535e-01f, -3.94497573e-01f, -3.10749769e-01f, -2.38231316e-01f, -9.04900730e-02f, -3.13883454e-01f, 3.18469740e-02f, 1.45164222e-01f, -3.57740879e-01f,
  5.27402423e-02f, 6.37698233e-01f, 4.14172620e-01f, 3.68589938e-01f, 5.00040829e-01f, -4.69740033e-01f, -3.90244305e-01f, 2.65382677e-01f, 6.96949720e-01f, 2.94282764e-01f,
  -1.93643942e-01f, -1.49357647e-01f, 3.92030865e-01f, 1.16522357e-01f, -5.31657696e-01f, 2.73605324e-02f, -4.56115186e-01f, -2.49437720e-01f, -1.70965418e-01f, -6.07145607e-01f,
  -1.35985970e-01f, 2.34179944e-01f, 2.43568718e-01f, 2.23908827e-01f, -1.21630028e-01f, -7.88819194e-02f, 1.68050844e-02f, -8.66323635e-02f, 7.48793036e-02f, -2.14084998e-01f,
  -3.08559672e-03f, 1.15881048e-01f, 8.55561122e-02f, 1.27417312e-04f, -3.47859338e-02f, -1.88150513e-03f, -7.23366160e-03f, 1.48105413e-01f, 5.49060479e-02f, -7.66930357e-02f,
  -2.08399862e-01f, -6.47560209e-02f, 8.43179151e-02f, -7.65352920e-02f, 1.20177455e-01f, 2.04289928e-01f, -6.71094209e-02f, 1.84028789e-01f, 1.80225521e-01f, -5.18885136e-01f,
  3.18179354e-02f, -9.85660702e-02f, -9.21324492e-02f, 3.57667692e-02f, 2.85241026e-02f, -8.48871619e-02f, -9.10228416e-02f, -5.10269664e-02f, 1.47799835e-01f, -1.11030489e-01f,
  -6.51643723e-02f, 7.54269809e-02f, 1.27178013e-01f, -8.60695764e-02f, -8.39158371e-02f, 3.72682959e-02f, -1.77781209e-01f, -3.43786478e-02f, 1.36795819e-01f, 4.67999578e-02f,
  9.42263901e-02f, 4.91163433e-02f, -1.13395132e-01f, -3.57280262e-02f, -1.01412022e-02f, 6.55140579e-02f, 2.23398712e-02f, 3.01049817e-02f, -3.37577760e-02f, -6.69582114e-02f,
  -2.58782029e-01f, 3.64141852e-01f, -2.12329462e-01f, 1.83268949e-01f, -4.39340770e-02f, 6.00165650e-02f, -6.97830096e-02f, 2.22422346e-03f, 5.86570837e-02f, -3.53593193e-02f,
  1.28038242e-01f, 5.55284955e-02f, -8.87721777e-02f, -7.49830436e-03f, -1.58575475e-02f, 1.74296290e-01f, 3.87629643e-02f, 6.79434836e-02f, 1.03777982e-01f, -1.69055641e-01f,
  -2.26440802e-01f, -1.59178078e-01f, 1.57576367e-01f, 2.40772753e-03f, -5.72990328e-02f, 1.10895522e-01f, -1.71237335e-01f, -1.14748582e-01f, 1.65260822e-01f, -5.75371981e-01f,
  -5.31481445e-01f, -6.50572181e-02f, -6.44741878e-02f, 1.80286452e-01f, -5.02372533e-02f, -1.10426232e-01f, -1.11779094e-01f, 9.57203880e-02f, 1.61140174e-01f, -1.05450191e-01f,
  -2.52611578e-01f, -9.71140862e-02f, 7.65849352e-02f, 1.80504899e-02f, 1.56868815e-01f, 1.98179021e-01f, 4.74444658e-01f, 2.68634468e-01f, 1.00693882e-01f, 2.51428932e-02f,
  2.02788278e-01f, -6.46151677e-02f, -1.45094708e-01f, 2.34569520e-01f, 4.90231723e-01f, 2.67626941e-01f, 1.68800622e-01f, 3.37734655e-03f, -7.92141184e-02f, 6.77483976e-01f,
  -3.39907259e-01f, -2.14972168e-01f, 9.36424211e-02f, -2.34270558e-01f, 3.36268209e-02f, 1.06782310e-01f, 9.02138576e-02f, 3.72997560e-02f, -1.60899252e-01f, 1.02301024e-01f,
  1.10297062e-01f, -4.13232148e-02f, 1.62827631e-03f, 1.69240147e-01f, -1.00506499e-01f, -1.18422702e-01f, 2.06292167e-01f, 1.24306530e-01f, 1.19057603e-01f, -4.80483212e-02f,
  3.12908769e-01f, -1.77348092e-01f, -2.65209109e-01f, 2.06554271e-02f, 1.56770602e-01f, -1.66793227e-01f, -8.63488615e-02f, -1.33586034e-01f, -3.04881334e-01f, 2.61346437e-02f,
  -8.87440983e-03f, 5.13929054e-02f, 6.36839047e-02f, 1.97585434e-01f, 8.96318257e-02f, 1.61673754e-01f, 2.73848742e-01f, 1.51482811e-02f, 7.13878945e-02f, 1.19981855e-01f,
  8.39044452e-02f, -4.24913727e-02f, 1.00243933e-01f, -5.93835562e-02f, -9.13078040e-02f, -5.01149669e-02f, 1.02404384e-02f, -8.51483047e-02f, -1.69925228e-01f, -1.81971431e-01f,
  -2.09859729e-01f, 7.53010511e-02f, 6.98216408e-02f, 3.08598548e-01f, -8.97693336e-02f, 3.82549725e-02f, 9.02909115e-02f, -2.06650421e-01f, -5.89277484e-02f, -1.75227940e-01f,
  -2.40166098e-01f, -2.43732423e-01f, 6.88549951e-02f, 6.93968013e-02f, -3.93688083e-02f, -3.05263340e-01f, -9.07053947e-02f, -1.23757266e-01f, -2.27690950e-01f, -9.46201831e-02f,
  -2.40546122e-01f, -8.37809071e-02f, -8.19891542e-02f, 2.62473822e-01f, 1.35984257e-04f, -1.19380996e-01f, 8.57732669e-02f, 3.36245820e-02f, 7.01299384e-02f, 1.54853776e-01f,
  2.04530224e-01f, -1.16470113e-01f, -2.54982412e-01f, -1.35655567e-01f, 7.56466314e-02f, -3.67279589e-01f, -1.95388705e-01f, -1.28743485e-01f, -5.90571582e-01f, -3.51771384e-01f,
  -8.17669570e-01f, -2.64251411e-01f, -2.73327202e-01f, -5.74552476e-01f, -1.02503069e-01f, 1.72282428e-01f, 1.15391135e-01f, 6.99729100e-02f, -1.90314978e-01f, -2.46860564e-01f,
  2.09109858e-02f, -4.03461838e-03f, -4.96285111e-01f, -1.82233788e-02f, -4.39990349e-02f, -2.89423019e-01f, -4.02360767e-01f, -3.38865638e-01f, 2.57599562e-01f, 5.69362164e-01f,
  2.34506130e-01f, -1.66238219e-01f, -7.13785365e-02f, -4.07048725e-02f, -1.58871070e-01f, -1.14283115e-01f, -4.41627383e-01f, -2.40267470e-01f, 5.53250052e-02f, -3.75366211e-01f,
  -2.66852230e-01f, -1.60812885e-01f, 3.06888252e-01f, 1.02737546e-02f, 7.00109079e-02f, 8.24115425e-02f, 1.68632060e-01f, -9.81923118e-02f, -5.98717667e-02f, -1.28113916e-02f,
  -2.51041334e-02f, 2.03592256e-01f, -5.11888368e-03f, 4.71528210e-02f, 1.28342971e-01f, 8.13232586e-02f, 9.33472626e-03f, -3.39330398e-02f, -2.41366133e-01f, 1.36735797e-01f,
  8.80779848e-02f, -1.76625773e-01f, -4.06992048e-01f, 1.22221299e-01f, 6.63417727e-02f, -1.12925529e-01f, 1.09031960e-01f, 2.38621131e-01f, -5.53625710e-02f, -3.58606815e-01f,
  1.00965105e-01f, -4.43372279e-02f, 2.37220243e-01f, 6.85217371e-03f, -3.72090936e-02f, -1.31019339e-01f, -8.29189718e-02f, 3.56185548e-02f, 1.13498762e-01f, -6.59139305e-02f,
  7.62262866e-02f, -4.37430944e-03f, 8.87931436e-02f, -1.64249614e-01f, -9.97817665e-02f, -1.62687466e-01f, -7.84736201e-02f, -1.28957048e-01f, -6.23625144e-02f, -1.17722377e-02f,
  -5.44021130e-02f, -1.71221662e-02f, -6.05974197e-02f, 9.06621963e-02f, 1.17187090e-01f, -6.24581128e-02f, 6.84605613e-02f, 1.53102711e-01f, 1.54044265e-02f, 7.50192255e-02f,
  -3.14445704e-01f, 2.41080239e-01f, -3.84022444e-01f, 5.64352088e-02f, -1.74091622e-01f, 8.43981057e-02f, -8.93529579e-02f, 1.78133056e-01f, -1.18344218e-01f, 1.41624808e-01f,
  3.00823897e-01f, -6.45323917e-02f, -6.59600794e-02f, 1.72936603e-01f, 2.03536585e-01f, 1.51794270e-01f, 6.08323775e-02f, -1.74747959e-01f, -7.27521107e-02f, 2.24006817e-01f,
  -3.29781137e-02f, -2.72524446e-01f, -4.06895101e-01f, -2.76070863e-01f, 6.18088283e-02f, -2.41246119e-01f, -2.43825495e-01f, 2.30848622e-02f, -1.69257134e-01f, -4.70163822e-01f,
  -9.67800245e-02f, -3.53264481e-01f, -1.70463651e-01f, 1.12426065e-01f, 3.77960682e-01f, -1.65271655e-01f, -9.68981683e-01f, -5.44977784e-01f, 1.03455558e-01f, -1.41404673e-01f,
  3.80138427e-01f, 3.86507511e-01f, 2.50684321e-02f, -1.20745525e-01f, -3.98316503e-01f, -4.36410844e-01f, -2.51532912e-01f, -2.14667380e-01f, -1.37766868e-01f, 8.43096077e-02f,
  1.89430043e-01f, 7.23840147e-02f, -3.31598776e-03f, -5.23352101e-02f, 3.67863238e-01f, 1.54475197e-01f, 1.05469458e-01f, 2.88726568e-01f, -6.35740310e-02f, 2.95343101e-01f,
  2.22769901e-01f, -4.81426604e-02f, -1.47666395e-01f, 3.53010565e-01f, 2.52489924e-01f, -2.34253615e-01f, -1.86286137e-01f, -9.13063958e-02f, -9.67892334e-02f, -1.59411803e-01f,
  2.11627573e-01f, 1.46516219e-01f, 1.50699675e-01f, -2.71838391e-03f, -3.14109027e-02f, -2.42356524e-01f, -1.57350615e-01f, -2.92872310e-01f, -2.24213153e-01f, 4.86067459e-02f,
  2.66993254e-01f, 3.92058641e-01f, 4.55899015e-02f, -2.26227745e-01f, -3.38585436e-01f, -1.40268102e-01f, -2.42638677e-01f, -2.47819964e-02f, -4.36464190e-01f, -1.68181896e-01f,
  1.06255814e-01f, 1.06166221e-01f, -3.55045870e-02f, -5.33476211e-02f, -8.52522925e-02f, -3.48687284e-02f, 9.65545848e-02f, 3.03846244e-02f, 3.22683975e-02f, -4.18848060e-02f,
  -6.81055114e-02f, -2.45643761e-02f, -8.72221601e-04f, -4.21711504e-02f, 1.23048298e-01f, 6.63357601e-03f, 3.35650258e-02f, -9.23819095e-02f, 9.55676883e-02f, -7.77374879e-02f,
  5.50755598e-02f, -1.66506099e-03f, 1.22140795e-01f, -7.28479624e-02f, -1.69703327e-02f, -1.05769128e-01f, -1.64854705e-01f, -4.87856828e-02f, -1.45587072e-01f, -3.65908369e-02f,
  -7.46149048e-02f, -1.29998296e-01f, 8.22519735e-02f, -1.07520960e-01f, -4.72452939e-02f, 3.09711210e-02f, 8.97830501e-02f, -8.95048454e-02f, 4.83460873e-02f, -2.03069061e-01f,
  -4.19962145e-02f, -1.24030262e-01f, -5.09609506e-02f, -1.39663398e-01f, -8.03368539e-02f, 8.19012150e-03f, 5.27085084e-03f, -5.60440198e-02f, -1.22820646e-01f, 1.19666673e-01f,
  -1.00947015e-01f, -1.87466532e-01f, -1.52458072e-01f, -3.70132148e-01f, 7.96161219e-02f, -1.95379004e-01f, -3.60511065e-01f, -1.35683194e-01f, -4.43088531e-01f, -6.48395717e-01f,
  2.44775444e-01f, -8.68115544e-01f, 1.34627581e-01f, 3.35023403e-01f, 1.50211155e-01f, -1.05961449e-01f, -4.13966715e-01f, 1.10016808e-01f, 3.64034116e-01f, 2.87272278e-02f,
  -2.10015416e-01f, 1.32610768e-01f, -5.82745299e-03f, 8.87508467e-02f, -1.17707640e-01f, 8.13174173e-02f, 3.47188920e-01f, 3.27056617e-01f, 1.44488961e-01f, 1.05570056e-01f,
  2.59044766e-02f, 1.29623450e-02f, 1.89854339e-01f, 2.35092193e-01f, 9.71397269e-04f, 2.78539836e-01f, 7.84767419e-02f, -1.00907855e-01f, -2.19462842e-01f, 1.23081937e-01f,
  -2.90918767e-01f, -1.96125194e-01f, 4.38016534e-01f, 6.44573420e-02f, -7.39467964e-02f, 1.18995361e-01f, 5.98698072e-02f, 5.28625678e-03f, 4.75227982e-02f, 9.57347527e-02f,
  9.37189907e-02f, -1.07315503e-01f, -1.67660028e-01f, -4.77493331e-02f, -6.48523420e-02f, -7.47008547e-02f, -6.57258928e-02f, -6.51508048e-02f, -3.81516479e-02f, -5.97110689e-02f,
  -1.61565483e-01f, -3.97826433e-02f, -4.47452627e-03f, -1.36497885e-01f, -6.88921437e-02f, -4.54649627e-02f, -1.70618623e-01f, -1.07250147e-01f, -9.75508429e-03f, -4.00843695e-02f,
  -4.42415057e-03f, 3.80213223e-02f, -2.29177684e-01f, -6.36397451e-02f, -9.80056152e-02f, 1.50052115e-01f, 1.26001656e-01f, -3.99209186e-02f, -1.16409637e-01f, -4.74484041e-02f,
  6.14374727e-02f, -3.02134212e-02f, 1.26375556e-01f, 7.56720752e-02f, 8.18344057e-02f, -1.38553053e-01f, -2.05338791e-01f, -1.63211033e-01f, 1.00818640e-02f, -5.81299141e-02f,
  -1.23758987e-01f, 5.80872819e-02f, 1.30400762e-01f, -1.69796616e-01f, 1.27269560e-02f, 1.83633603e-02f, 1.11257739e-01f, -1.09072112e-01f, 5.42101748e-02f, 1.00199789e-01f,
  -3.40767473e-01f, 1.08625397e-01f, 2.90870816e-01f, -1.34799093e-01f, -1.88598335e-02f, 3.53135988e-02f, -1.15022279e-01f, 1.53904967e-02f, 7.83961192e-02f, 1.54572263e-01f,
  4.48200703e-02f, 1.81297183e-01f, -7.41514713e-02f, 5.37622906e-02f, 3.19510400e-01f, 1.75769418e-01f, -1.02845356e-01f, -5.38765043e-02f, 8.81202295e-02f, 2.37491637e-01f,
  6.63551390e-02f, 2.58301914e-01f, 1.54471233e-01f, 2.18689471e-01f, 1.35175258e-01f, 3.06903481e-01f, 6.96089491e-02f, 4.61632051e-02f, 2.11256757e-01f, 2.68788487e-01f,
  6.78557634e-01f, 1.93977177e-01f, -1.80569232e-01f, 4.74397391e-01f, -2.48889804e-01f, -4.89283681e-01f, -5.64490199e-01f, 2.42426783e-01f, 6.42755270e-01f, 8.16562474e-02f,
  -4.39288676e-01f, -2.27727696e-01f, 1.11264877e-01f, -1.99343503e-01f, -4.66664493e-01f, -2.54031122e-01f, -1.47758901e-01f, -2.53293097e-01f, -4.30755526e-01f, -4.87483978e-01f,
  -3.45328093e-01f, 3.83968428e-02f, 1.02181040e-01f, 1.16977006e-01f, 4.87932980e-01f, 6.10542856e-02f, 2.57589787e-01f, 1.28528982e-01f, -1.56124771e-01f, 2.66030520e-01f,
  5.45835607e-02f, 6.56841338e-01f, -4.03058022e-01f, -4.33413386e-02f, -5.59685193e-02f, 8.45932774e-03f, -8.28290507e-02f, 3.65091056e-01f, -1.14035368e-01f, 1.39330300e-02f,
  -2.25310937e-01f, -2.80281186e-01f, -4.23029512e-02f, -6.94328323e-02f, 1.01409748e-01f, -3.09950188e-02f, 1.83301330e-01f, 2.42146403e-02f, 1.50909990e-01f, -6.08967170e-02f,
  -4.93204594e-01f, -1.87176600e-01f, 9.39651430e-02f, -1.19797401e-01f, 1.33741081e-01f, -3.45615476e-01f, 1.35783628e-01f, 1.68369144e-01f, 7.29020592e-03f, 5.41763842e-01f,
  -1.93839725e-02f, -8.02260041e-02f, -1.66348457e-01f, 8.78765583e-02f, -5.43597341e-02f, -4.43999581e-02f, 3.92027050e-02f, -1.19127393e-01f, -3.40133160e-02f, 1.34837821e-01f,
  -8.56813937e-02f, 2.61858162e-02f, 9.60316285e-02f, 1.00496449e-01f, 2.76526995e-03f, 7.06837401e-02f, -1.52605847e-01f, -2.65097432e-02f, 2.28123665e-02f, 9.81033314e-03f,
  -3.81506123e-02f, -5.54189682e-02f, -5.40815070e-02f, 5.57984486e-02f, -7.09424689e-02f, 1.10792935e-01f, 1.36283606e-01f, 3.50608267e-02f, 6.79951906e-02f, 1.59138024e-01f,
  3.10410649e-01f, -6.41273379e-01f, 1.97383136e-01f, 5.87049499e-03f, -9.95451398e-03f, 4.45156395e-02f, 7.04426840e-02f, -1.96934074e-01f, 1.42302942e-02f, -6.04404546e-02f,
  -2.00833455e-01f, -5.97505085e-02f, 2.03273699e-01f, -7.23870918e-02f, -1.73591286e-01f, -5.45441583e-02f, -3.15701276e-01f, -3.89726818e-01f, -2.52729446e-01f, 9.01338533e-02f,
  -2.69621238e-02f, -2.71155983e-01f, -1.86388656e-01f, -2.21520528e-01f, 1.34501249e-01f, -2.50114799e-01f, -1.60800442e-01f, -3.04119829e-02f, -5.55889428e-01f, -4.21460010e-02f,
  -4.66460794e-01f, 5.84100708e-02f, 6.26988590e-01f, -4.10507709e-01f, 3.46291423e-01f, 1.02535978e-01f, -5.65871656e-01f, -5.28884828e-01f, 2.33724080e-02f, 8.62211585e-02f,
  4.33295876e-01f, 1.56266510e-01f, -5.79712503e-02f, -2.40822762e-01f, -6.47327423e-01f, -4.25412863e-01f, -3.37300003e-01f, -3.41596961e-01f, -3.65884542e-01f, -3.19681346e-01f,
  -1.07679769e-01f, -1.55051321e-01f, -2.27613211e-01f, -2.15884879e-01f, -1.68329805e-01f, -6.98511451e-02f, 1.89532012e-01f, 8.95904824e-02f, 5.05719893e-02f, -3.69598679e-02f,
  -1.03588872e-01f, 2.30730977e-02f, 1.25557989e-01f, 4.01124433e-02f, 3.15455198e-01f, -1.63819343e-01f, -1.04098402e-01f, -7.11243898e-02f, -4.01586741e-02f, 5.42072728e-02f,
  1.39657751e-01f, 9.79050621e-02f, 2.90321000e-02f, 5.06506339e-02f, -1.43269390e-01f, -6.27049357e-02f, 5.32976910e-02f, -1.62235737e-01f, -5.69099411e-02f, 1.90330252e-01f,
  9.53786671e-02f, 1.23443373e-01f, -1.28022045e-01f, -6.59037754e-03f, -1.79722160e-01f, 7.13902898e-03f, 8.35885629e-02f, -7.20995739e-02f, -1.85762033e-01f, -2.75592357e-01f,
  -1.31639630e-01f, -3.36551033e-02f, 1.28155828e-01f, 8.20214972e-02f, -1.20182618e-01f, -7.79331708e-03f, -7.33830407e-02f, -2.26948619e-01f, 8.16288125e-03f, -8.05414915e-02f,
  8.25099573e-02f, 1.56177491e-01f, 2.21543852e-02f, -2.19950378e-01f, -2.49652922e-01f, 3.90270539e-02f, 2.90360916e-02f, -2.06729814e-01f, -2.11982578e-01f, -5.75964786e-02f,
  -1.42855212e-01f, -9.13179386e-03f, 2.16537207e-01f, -1.56330600e-01f, 9.81107131e-02f, 1.53658509e-01f, 8.36153477e-02f, 9.68251303e-02f, 9.29477587e-02f, 1.25699267e-01f,
  -1.16433814e-01f, 3.55979830e-01f, -1.83135942e-01f, -2.85556972e-01f, -1.16344281e-01f, 1.84730172e-01f, 1.96569607e-01f, 1.06649697e-01f, 1.48378804e-01f, -1.00934505e-01f,
  -2.59764977e-02f, -2.94106126e-01f, 3.95860709e-02f, 4.31456864e-02f, -1.02629252e-02f, -1.18376464e-01f, -2.23305941e-01f, 2.08332893e-02f, -8.83002356e-02f, 1.61678359e-01f,
  -4.33375537e-02f, -3.75425041e-01f, -5.36923170e-01f, -2.46300995e-01f, -2.72390693e-01f, -4.93549794e-01f, -2.71110266e-01f, -2.78835326e-01f, -5.18040359e-01f, -7.84630835e-01f,
  6.67885959e-01f, -5.80944836e-01f, 1.52382562e-02f, 3.56377095e-01f, 1.83703661e-01f, -1.27046645e-01f, -9.59314823e-01f, -3.33573431e-01f, 3.51586878e-01f, -5.11035621e-01f,
  7.59346336e-02f, 7.52234697e-01f, 6.02567136e-01f, 1.53508261e-01f, -1.91228896e-01f, -8.46898556e-01f, -7.11141646e-01f, -3.47635732e-03f, 1.95108466e-02f, -3.14184338e-01f,
  -2.08224073e-01f, -1.04246609e-01f, 2.16501765e-02f, -5.90920597e-02f, 3.69195007e-02f, 4.32943374e-01f, -4.83875237e-02f, 1.33731058e-02f, -1.82193011e-01f, -1.51203470e-02f,
  -9.80696604e-02f, -3.14095914e-01f, 8.08001086e-02f, 1.31786913e-01f, 9.65172276e-02f, -9.44223031e-02f, -1.11111350e-01f, -2.74747014e-02f, 7.61486143e-02f, -1.34028703e-01f,
  1.73348591e-01f, 3.69858146e-02f, 2.35835046e-01f, -3.02837091e-03f, -2.98522532e-01f, -4.97112311e-02f, -2.71760941e-01f, -1.68324500e-01f, -7.69127458e-02f, -3.46437633e-01f,
  -1.28726006e-01f, -1.40385535e-02f, -1.20022893e-02f, -2.72652298e-01f, -1.31196827e-01f, 3.92963409e-01f, -1.67846665e-01f, 6.27891794e-02f, 3.17972451e-02f, -4.59118262e-02f,
  -6.51702657e-02f, 1.28193721e-01f, -1.41589260e-02f, -1.26160249e-01f, 9.80133414e-02f, 7.42372647e-02f, -9.72991437e-03f, -1.08142138e-01f, -1.98307633e-02f, -7.47151896e-02f,
  -7.67089501e-02f, 2.69745216e-02f, 3.82569246e-02f, -1.28844559e-01f, 5.47166765e-02f, -3.14797051e-02f, 1.43987248e-02f, -7.56805092e-02f, -4.88126129e-02f, 1.21434536e-02f,
  -3.25964615e-02f, 7.69504979e-02f, 5.18285250e-03f, 3.41675878e-02f, -1.11873798e-01f, -8.73979356e-04f, 9.78997424e-02f, 4.77139726e-02f, 1.31574899e-01f, -3.47926691e-02f,
  2.75078386e-01f, 1.16341673e-01f, 4.04559597e-02f, -2.23500971e-02f, -8.07737634e-02f, 7.37404749e-02f, 9.75925624e-02f, -9.90905315e-02f, 1.71414018e-01f, 1.35520443e-01f,
  -1.41299665e-01f, -3.74786109e-02f, -3.94241102e-02f, 1.09070754e-02f, -1.08709462e-01f, -7.18553662e-02f, -3.04485857e-01f, 5.09953126e-02f, -1.48051456e-01f, -8.80764052e-02f,
  -1.61502674e-01f, -2.59727478e-01f, -1.89187061e-02f, -1.34256892e-02f, -2.40790844e-02f, 1.81304857e-01f, -6.65875375e-02f, 1.08877793e-01f, 2.14443798e-03f, -4.64561701e-01f,
  -6.00010633e-01f, 2.61808544e-01f, 7.20876455e-01f, -5.16119838e-01f, -3.86177868e-01f, -8.72503445e-02f, 1.30508691e-01f, 9.57697108e-02f, -1.04751185e-01f, 7.63036534e-02f,
  -2.80073792e-01f, -4.13869053e-01f, 7.99696073e-02f, 6.35968596e-02f, 2.75525153e-01f, 4.69224840e-01f, 5.04241467e-01f, 2.73033887e-01f, -2.13897884e-01f, -2.97571540e-01f,
  -2.68390775e-01f, -4.28367078e-01f, -2.61326790e-01f, 1.06786706e-01f, 3.82129550e-02f, -1.04044639e-01f, 3.23490173e-01f, -1.80510774e-01f, 1.31208375e-01f, 3.60345483e-01f,
  -2.39499345e-01f, -1.39314651e-01f, 2.08462477e-02f, -2.70983905e-01f, 1.23600662e-01f, 9.69308540e-02f, 1.48455754e-01f, 9.87913013e-02f, 2.77362429e-02f, 1.76182508e-01f,
  -5.31345196e-02f, 1.50692880e-01f, -1.66802868e-01f, -5.70865907e-02f, -2.19852254e-01f, -9.55075696e-02f, 1.54470921e-01f, 2.76980698e-01f, 2.22135022e-01f, 8.81970301e-02f,
  -1.24167606e-01f, -5.41544139e-01f, -3.36368114e-01f, 1.55215561e-01f, 3.17796022e-01f, -1.24938294e-01f, 3.11186612e-02f, -6.40739501e-03f, 2.58025944e-01f, 1.17997795e-01f,
  -5.30812144e-02f, 1.03991166e-01f, 1.68876663e-01f, 2.15959340e-01f, 4.20770273e-02f, 1.65928472e-02f, 1.68015257e-01f, -1.40720576e-01f, 4.19637226e-02f, -1.23500936e-01f,
  4.29688804e-02f, -4.66029644e-02f, 6.23281524e-02f, -8.88976604e-02f, 1.19666331e-01f, -6.96032494e-02f, 1.75474528e-02f, 4.75227833e-03f, -1.17741622e-01f, 2.64648832e-02f,
  5.78757413e-02f, 1.14579909e-01f, 2.74707805e-02f, 5.35288937e-02f, 9.46346521e-02f, 6.94072247e-02f, -7.83209056e-02f, -1.58983871e-01f, -1.17797544e-02f, -1.12605102e-01f,
  -1.98416576e-01f, 3.38599980e-01f, 9.56831407e-03f, 1.08337797e-01f, 2.90788282e-02f, 1.36263549e-01f, 6.61577135e-02f, -2.73198579e-02f, -9.78488028e-02f, -1.71105281e-01f,
  -7.07524270e-02f, -6.84010088e-02f, 9.86069366e-02f, 1.18953474e-01f, -3.46257240e-01f, -1.10566653e-02f, -2.74641365e-01f, -2.54231066e-01f, 4.23850790e-02f, -5.80208236e-03f,
  1.22271605e-01f, -3.87226313e-01f, -7.96649754e-01f, -1.85905546e-01f, -2.50136554e-01f, -3.79644424e-01f, -1.46568775e-01f, -1.24899432e-01f, -1.88410431e-01f, -1.90938488e-01f,
  -1.30707777e+00f, -1.75624430e-01f, 5.70668697e-01f, -5.66863775e-01f, -3.15595359e-01f, -2.17205003e-01f, -2.30373487e-01f, -4.68080580e-01f, -3.13965797e-01f, 7.12833926e-02f,
  -1.09154232e-01f, -2.55755991e-01f, -3.91551927e-02f, -1.33287445e-01f, -4.51328307e-01f, 5.56608029e-02f, -5.57015128e-02f, -3.60899180e-01f, -5.72391808e-01f, -3.82335454e-01f,
  -4.57563728e-01f, -6.95494354e-01f, -7.79506087e-01f, -2.65064776e-01f, 1.04028210e-01f, -1.54657170e-01f, 2.17987463e-01f, -2.62908280e-01f, -9.01870057e-02f, -1.31948888e-01f,
  6.32821083e-01f, -4.70776200e-01f, -1.66475892e-01f, -2.55185902e-01f, 1.06877327e-01f, -1.02601372e-01f, -9.65701118e-02f, -7.18410611e-02f, -1.27016544e-01f, 4.49280106e-02f,
  -5.58862500e-02f, -6.14384888e-03f, -1.03808582e-01f, 9.08233523e-02f, -1.21950805e-01f, -1.55879464e-02f, 5.91344200e-02f, -1.61027357e-01f, 4.03409563e-02f, 3.69837612e-01f,
  1.92199335e-01f, -3.10949180e-02f, 1.01880975e-01f, 1.92718983e-01f, 2.66480204e-02f, -1.91706136e-01f, 1.54792309e-01f, 6.25427067e-02f, 6.98263869e-02f, 7.69144520e-02f,
  2.13791996e-01f, 3.10684711e-01f, -2.80526113e-02f, -2.63981279e-02f, 7.48350844e-02f, 1.29754156e-01f, 6.60855547e-02f, 6.01381883e-02f, -2.94015482e-02f, -4.67205308e-02f,
  2.87232641e-02f, -6.47920296e-02f, -3.12785320e-02f, 4.79584448e-02f, 8.59750509e-02f, -1.02708004e-01f, -9.79436040e-02f, 3.71604748e-02f, 3.95170189e-02f, -1.91477567e-01f,
  -1.86560556e-01f, 2.06190795e-02f, 5.36070839e-02f, -5.19050509e-02f, 1.52133917e-02f, 1.92573462e-02f, -5.81141263e-02f, -4.53790911e-02f, -3.47057804e-02f, -1.57931045e-01f,
  -1.86139606e-02f, -3.13083708e-01f, 1.53908152e-02f, -7.67237097e-02f, 7.40841255e-02f, 6.47896752e-02f, 1.28764436e-01f, -2.18349565e-02f, 3.63061577e-02f, 1.25852659e-01f,
  6.20890968e-02f, 9.65932831e-02f, 1.49445727e-01f, 9.29174274e-02f, 1.89983286e-02f, 8.50457251e-02f, 1.58857871e-02f, -6.79572858e-03f, 1.04313985e-01f, 1.90462232e-01f,
  1.55428171e-01f, -7.37888226e-03f, 4.41533439e-02f, 2.10288510e-01f, 6.25558570e-02f, 8.55275197e-04f, 1.64697871e-01f, 2.05524653e-01f, 1.43045336e-01f, 1.37330011e-01f,
  6.08646095e-01f, 3.71059626e-01f, 4.88885194e-01f, 3.96097720e-01f, 2.66359985e-01f, 4.28737432e-01f, 4.56649244e-01f, 2.13040382e-01f, 1.56037152e-01f, 2.14980632e-01f,
  -4.99239080e-02f, -2.26566434e-01f, -1.94718167e-01f, -3.42295058e-02f, 1.28082007e-01f, 1.28332973e-01f, 1.76946938e-01f, 2.12871671e-01f, 1.93675026e-01f, 1.56421214e-01f,
  -3.93757820e-02f, 1.24478685e-02f, 1.05442986e-01f, 4.44914438e-02f, 9.71620083e-02f, -8.53531510e-02f, -7.05946982e-02f, 1.24693587e-01f, 9.29070413e-02f, 1.14694260e-01f,
  -2.10683882e-01f, 2.02735990e-01f, -2.55465478e-01f, -2.70353705e-01f, -3.13496739e-02f, -6.02120310e-02f, 1.01405025e-01f, -2.24677492e-02f, -1.15410730e-01f, -9.58793517e-03f,
  -1.04594961e-01f, -4.01649550e-02f, 2.68449448e-02f, 2.58467719e-03f, -1.35617834e-02f, -4.26401831e-02f, -8.76848400e-02f, 4.11925763e-02f, -1.05778329e-01f, -2.48890556e-02f,
  -1.13608725e-01f, 9.32595357e-02f, 1.43428832e-01f, 9.36435238e-02f, 4.08172756e-02f, -1.93110868e-01f, -1.30387813e-01f, -1.52566899e-02f, -3.31727392e-03f, 8.17383453e-02f,
  -1.48146346e-01f, 7.19193816e-02f, 2.35421434e-02f, 5.02013303e-02f, -1.38721662e-02f, -1.11738211e-02f, -3.53966840e-02f, -4.26046038e-03f, -4.24437933e-02f, 1.05262414e-01f,
  -3.15084904e-02f, 4.71252315e-02f, 6.27088621e-02f, -1.74367742e-04f, -1.30865976e-01f, 1.06998608e-01f, 6.31305501e-02f, -1.37559950e-01f, -3.96747291e-02f, -1.30420119e-01f,
  1.11693002e-01f, -5.21661527e-02f, -1.32348850e-01f, 1.53036590e-03f, -1.44013032e-01f, -9.28137302e-02f, -5.75138628e-02f, -6.40342236e-02f, -7.72063807e-02f, -8.93593356e-02f,
  -5.93383670e-01f, -1.93394840e-01f, -1.00638472e-01f, -4.56420705e-02f, 7.11731613e-02f, -7.64409378e-02f, 5.49308918e-02f, 3.62768071e-03f, -8.58059973e-02f, -3.29657868e-02f,
  -2.89147086e-02f, 3.19868769e-03f, -7.83840343e-02f, 1.45016415e-02f, -9.72601399e-03f, -1.62211716e-01f, -9.26344618e-02f, -3.64780091e-02f, -9.48978812e-02f, -1.46057263e-01f,
  -7.39507526e-02f, 2.83778738e-02f, 3.66452448e-02f, 5.90388738e-02f, -9.12686512e-02f, -2.83893138e-01f, -1.17413610e-01f, -7.03224316e-02f, -1.02990299e-01f, -1.40631646e-01f,
  -1.28309059e+00f, 2.01442972e-01f, 3.28385502e-01f, -5.25373816e-01f, -1.15723222e-01f, 2.15060860e-01f, 4.38929975e-01f, -7.66376033e-02f, -3.65183711e-01f, 5.58087751e-02f,
  1.48675203e-01f, -2.36756355e-01f, 9.54921357e-03f, 6.36829883e-02f, 1.86990321e-01f, 4.20777500e-01f, 2.76775718e-01f, -9.74067226e-02f, -2.17683196e-01f, -1.57446235e-01f,
  5.37344590e-02f, -1.39125735e-01f, -2.42452025e-01f, -1.39354229e-01f, -8.87664407e-02f, -1.10657908e-01f, 2.20396355e-01f, 8.78528878e-02f, 2.58650452e-01f, -9.81201418e-03f,
  8.32678914e-01f, -2.08316341e-01f, -1.31894767e-01f, -8.08825642e-02f, 1.84877008e-01f, -1.46976992e-01f, -1.41323507e-02f, -1.60306752e-01f, -1.42450303e-01f, 1.60722464e-01f,
  -9.37582646e-03f, 5.63181676e-02f, -2.99680885e-02f, 1.30407378e-01f, 5.49351834e-02f, -4.08779457e-02f, 4.51533496e-02f, -5.76931983e-02f, 2.81841695e-01f, 2.48342261e-01f,
  2.39983916e-01f, 2.83861943e-02f, 2.80606568e-01f, 2.90878415e-01f, 1.04653940e-01f, -5.73851261e-03f, 2.46436119e-01f, 1.29568288e-02f, 8.14477652e-02f, -4.61907424e-02f,
  7.31750429e-02f, -1.66275635e-01f, -2.68062018e-02f, -4.09569852e-02f, 6.89742640e-02f, 8.59328061e-02f, -3.59217748e-02f, 5.48014678e-02f, 9.80515033e-03f, -1.15628913e-01f,
  -4.11131829e-02f, 2.34452665e-01f, 4.60250117e-02f, 3.87146138e-02f, -4.37783077e-02f, -5.08482605e-02f, -2.25454699e-02f, 8.99295211e-02f, 4.13679481e-02f, -5.92106692e-02f,
  -6.00833930e-02f, 4.50895168e-02f, 1.84373669e-02f, 1.35495543e-01f, 1.57575294e-01f, -2.42076013e-02f, 1.18149824e-01f, 1.85559839e-01f, 6.67303205e-02f, -1.32369816e-01f,
  3.80849242e-01f, 2.31726959e-01f, -2.65340731e-02f, -1.79854840e-01f, -1.92910850e-01f, -1.07975371e-01f, -2.45358661e-01f, -2.57569086e-02f, 7.36707002e-02f, 7.53436089e-02f,
  8.65061507e-02f, -7.70440325e-02f, 7.65216127e-02f, 1.66797917e-02f, -2.88278431e-01f, -8.88625085e-02f, -4.76744659e-02f, -2.62280684e-02f, 1.47485197e-01f, 1.60926238e-01f,
  1.15831606e-02f, -1.70402117e-02f, 5.75848594e-02f, -2.63819881e-02f, -8.38867947e-02f, -9.12255123e-02f, 1.18405737e-01f, 1.14492632e-01f, 1.24966063e-01f, -1.55192822e-01f,
  9.88524318e-01f, -2.35130475e-03f, 1.28916621e-01f, 2.59143263e-01f, 1.13793518e-02f, -1.60830673e-02f, 5.81047917e-03f, -1.95152219e-02f, 1.67026594e-01f, 2.35503703e-01f,
  2.64159858e-01f, 3.31581205e-01f, 2.26292774e-01f, 1.33034393e-01f, 1.86302483e-01f, -2.37183701e-02f, -7.46511742e-02f, 2.85910964e-01f, 2.48593390e-01f, 2.49335960e-01f,
  1.32143363e-01f, -6.48994278e-03f, 1.81861848e-01f, 5.28325252e-02f, 5.96127585e-02f, 1.85213298e-01f, -4.79731523e-02f, 8.55463371e-02f, 1.27718329e-01f, 9.79764163e-02f,
  3.51192243e-02f, 3.46598476e-01f, -8.63597356e-03f, -1.87466629e-02f, 9.18520801e-03f, -8.73292387e-02f, 5.36332689e-02f, -2.80630458e-02f, -1.16578706e-01f, -9.19725895e-02f,
  -7.62537196e-02f, 6.56596869e-02f, 5.99319600e-02f, -1.37956575e-01f, -2.35320572e-02f, 2.95497924e-02f, -1.12182675e-02f, -7.16072395e-02f, -4.95326035e-02f, 4.66204733e-02f,
  -7.70255476e-02f, -4.58540842e-02f, 6.74265251e-03f, -1.28145158e-01f, 5.82649857e-02f, 1.74239531e-01f, -3.67967337e-02f, 1.59278423e-01f, 5.34039810e-02f, 4.44707554e-03f,
  3.33515912e-01f, 2.59802669e-01f, 3.50750655e-01f, 3.22211087e-01f, 2.48970956e-01f, 1.68953210e-01f, -8.53426382e-02f, -3.81305367e-02f, 7.56325424e-02f, 1.33098349e-01f,
  7.44635388e-02f, 1.61914244e-01f, 3.54718193e-02f, -6.65684938e-02f, 1.14723751e-02f, 6.15166128e-03f, -6.25701547e-02f, -1.55050114e-01f, 5.64437658e-02f, 8.70777965e-02f,
  8.19162577e-02f, -7.81586468e-02f, 1.28844678e-01f, -8.88403207e-02f, 3.10695712e-02f, 4.28059660e-02f, 1.02502227e-01f, 4.14510444e-03f, -7.59799499e-04f, 6.91766962e-02f,
  -7.01658964e-01f, 2.40825608e-01f, 2.06295013e-01f, -6.84632584e-02f, -1.15844741e-01f, -1.00236885e-01f, 1.02405325e-01f, -8.60237330e-02f, -2.03109697e-01f, -2.52016515e-01f,
  -1.66783571e-01f, -1.00062536e-02f, -7.89153278e-02f, -1.21038586e-01f, -1.38024896e-01f, -9.96394828e-02f, 5.63834831e-02f, -6.32887781e-02f, -1.32319242e-01f, -1.13099076e-01f,
  -1.38901711e-01f, -1.36258855e-01f, -9.85509306e-02f, -1.02907173e-01f, -9.57260653e-02f, 3.99113493e-03f, -1.01494059e-01f, 5.92528060e-02f, -9.19454619e-02f, -7.18202889e-02f,
  4.83354896e-01f, 3.61869812e-01f, 8.58763978e-03f, 2.13204935e-01f, -1.75306693e-01f, -4.97261733e-01f, -7.50911295e-01f, -4.74137455e-01f, 1.83938574e-02f, 6.11747876e-02f,
  -4.59183753e-02f, 2.15803564e-01f, 2.26234086e-02f, -7.92505220e-02f, -2.04043090e-01f, -1.37310848e-01f, 4.14811410e-02f, -9.36806388e-03f, -1.24588445e-01f, -3.31065096e-02f,
  8.81332457e-02f, 3.07164967e-01f, 2.96821743e-01f, 2.20332853e-02f, 4.41945404e-01f, 2.21498042e-01f, 1.65746287e-01f, 4.20775831e-01f, 1.03281677e-01f, 4.89070326e-01f,
  3.88595939e-01f, 9.00782943e-02f, -6.22918069e-01f, 6.15197457e-02f, 2.52120554e-01f, 1.71798319e-01f, 7.72972032e-02f, 2.58955091e-01f, 6.03143014e-02f, -5.55224065e-03f,
  1.29116192e-01f, 2.01092243e-01f, 6.52107745e-02f, 1.80759028e-01f, 6.94601089e-02f, -1.34234980e-01f, 1.15405127e-01f, -8.65897611e-02f, -1.05381534e-01f, 7.13749975e-02f,
  1.15791135e-01f, -1.90542880e-02f, -2.41864637e-01f, -4.62289482e-01f, -2.62747835e-02f, 2.92503163e-02f, -2.23653689e-02f, 9.64887962e-02f, -2.54285514e-01f, 2.73984969e-01f,
  -1.54239208e-01f, 4.48616482e-02f, 1.47155896e-01f, 8.34649727e-02f, -5.44699393e-02f, -1.94370002e-02f, 6.98684230e-02f, 1.27477661e-01f, -5.98159283e-02f, -3.42289880e-02f,
  -8.22095200e-02f, -5.93110956e-02f, 1.06678128e-01f, -6.69136867e-02f, -3.99862491e-02f, 1.07509814e-01f, 1.08097762e-01f, 3.16315703e-02f, -1.46517396e-01f, 1.05119891e-01f,
  -3.94573137e-02f, 6.17833659e-02f, 2.37511978e-01f, 9.48142558e-02f, 7.79286996e-02f, 2.57115886e-02f, 2.13595957e-01f, 7.54489824e-02f, 1.69043437e-01f, 1.74979344e-01f,
  -1.79007083e-01f, -6.71565950e-01f, 3.75162065e-02f, 5.40800095e-02f, 1.73673972e-01f, 5.09998649e-02f, 8.20417479e-02f, 1.19079828e-01f, 1.41946852e-01f, 7.35085865e-04f,
  1.37864128e-01f, 1.50517523e-01f, 5.92420883e-02f, -4.43387702e-02f, -1.40729234e-01f, -1.54330311e-02f, 1.47008106e-01f, -1.73692688e-01f, -1.58774123e-01f, 1.69683710e-01f,
  -5.86837754e-02f, -5.58835328e-01f, -4.37885433e-01f, -4.54567313e-01f, 3.49875763e-02f, -2.70107269e-01f, -1.49001390e-01f, -1.64438739e-01f, -3.30227673e-01f, -2.93281615e-01f,
  -4.03820008e-01f, 4.62581724e-01f, -1.04300368e+00f, 2.95410529e-02f, -9.42193530e-03f, 1.00446627e-01f, 6.80282354e-01f, 3.29531252e-01f, 2.19980597e-01f, 3.53808761e-01f,
  2.84258872e-01f, -6.59224540e-02f, -9.97293666e-02f, -1.45187318e-01f, -7.95705318e-02f, 4.24336195e-01f, 8.27831551e-02f, -7.06503034e-01f, -5.84238648e-01f, 3.95751819e-02f,
  4.26292390e-01f, 2.42274627e-01f, -1.16184473e-01f, 6.17349260e-02f, 1.71117306e-01f, 3.58948708e-02f, 6.94291592e-02f, -2.10621506e-01f, 8.11675936e-02f, -4.41421717e-01f,
  -8.73070657e-01f, -4.11888987e-01f, -1.48772746e-01f, 3.23480517e-02f, -2.94933528e-01f, 1.90084442e-01f, 2.16614068e-01f, -3.27008514e-04f, 2.33626246e-01f, 1.51525319e-01f,
  -1.19648837e-01f, 8.19574967e-02f, 2.02266917e-01f, 8.60581920e-02f, 1.11762375e-01f, 1.93377063e-01f, -8.11895654e-02f, -3.15696597e-01f, -3.68761867e-01f, -4.39762175e-02f,
  2.59579748e-01f, -2.22435638e-01f, -5.58041334e-01f, 1.72197953e-01f, -1.18629739e-01f, -2.05730051e-01f, -3.30023408e-01f, -3.58608574e-01f, -3.25970918e-01f, -4.36453670e-01f,
  9.31731462e-02f, -4.66011427e-02f, -2.88781691e-02f, -3.77423456e-03f, 1.22523099e-01f, -1.07969277e-01f, -9.21647772e-02f, -1.92078546e-01f, -6.24880567e-02f, 1.14784222e-02f,
  4.40983362e-02f, -4.00401354e-02f, -1.69943586e-01f, 1.37252375e-01f, 4.05977182e-02f, -1.03281550e-01f, -6.74431995e-02f, 5.15835956e-02f, -1.57026157e-01f, 1.18565977e-01f,
  -4.48240042e-02f, -1.99821442e-01f, -5.07218204e-02f, -1.36220023e-01f, 8.62379223e-02f, -7.85272047e-02f, 6.69342093e-03f, 5.38105555e-02f, 3.66414636e-02f, 3.86776716e-01f,
  3.38880688e-01f, 2.68609792e-01f, -1.20405249e-01f, -4.31476794e-02f, -4.25652117e-01f, -1.09923191e-01f, 1.89085286e-02f, -1.86579913e-01f, 2.13619843e-02f, -3.38329375e-02f,
  -7.45187998e-02f, -1.70892589e-02f, 2.64458090e-01f, -3.77441896e-03f, -8.15650150e-02f, 2.78622583e-02f, 1.18710294e-01f, -4.06534106e-01f, -2.03050636e-02f, -3.50791737e-02f,
  3.61485511e-01f, 2.38426458e-02f, -2.63169348e-01f, -1.04284592e-01f, 6.76089292e-03f, 1.37822151e-01f, -2.92030364e-01f, -1.35383382e-01f, -1.61792636e-01f, 3.71620059e-01f,
  -9.15344179e-01f, -2.07836740e-02f, -3.22025210e-01f, -5.53814471e-01f, 1.74921721e-01f, 3.49481136e-01f, 4.91732895e-01f, 7.39534870e-02f, -3.70329231e-01f, -2.07448617e-01f,
  8.82886201e-02f, -5.99229746e-02f, -3.88686240e-01f, 4.34972905e-02f, 2.98996001e-01f, 8.90447944e-02f, -6.51121736e-02f, -7.22559765e-02f, 2.90245622e-01f, 6.52846456e-01f,
  4.30804729e-01f, -5.91505803e-02f, -1.60743788e-01f, 8.75820667e-02f, -1.92152768e-01f, -1.09702654e-01f, -2.63349414e-01f, -1.16087466e-01f, 2.37151861e-01f, -2.08899841e-01f,
  -3.23726773e-01f, -3.15897465e-01f, 4.97552268e-02f, 1.74906671e-01f, 1.31605476e-01f, -2.30755791e-01f, 2.24244632e-02f, -4.81848866e-01f, -2.08094306e-02f, -1.93151742e-01f,
  -5.32945469e-02f, -4.43004211e-03f, -6.47077486e-02f, 2.37967893e-02f, -1.62765160e-01f, 1.56258181e-01f, -9.71716642e-02f, -1.70807153e-01f, -1.61429599e-01f, 1.74847737e-01f,
  4.74917591e-01f, 3.65440160e-01f, -1.03594527e-01f, 1.15290977e-01f, -5.01949228e-02f, -1.33658752e-01f, 1.59310818e-01f, 2.59866983e-01f, -4.82845604e-02f, -3.25760782e-01f,
  9.40225199e-02f, 1.28295049e-02f, -6.93921372e-02f, -9.63276327e-02f, 2.16430411e-01f, -1.09234802e-01f, -1.03880785e-01f, 9.75643992e-02f, -9.00465846e-02f, -3.08901761e-02f,
  1.67885069e-02f, -7.71978498e-03f, 3.53879482e-02f, -1.34087160e-01f, 2.99140979e-02f, -9.35589988e-03f, 4.46699150e-02f, 5.88218570e-02f, 7.59917349e-02f, -3.59440409e-02f,
  -1.53725585e-02f, -1.98125653e-02f, -1.59305885e-01f, 5.08571304e-02f, -6.79612309e-02f, 7.67828748e-02f, -8.13307837e-02f, 9.46526974e-02f, -5.82137518e-02f, 1.59381349e-02f,
  -5.10854006e-01f, 2.80766070e-01f, -4.92970079e-01f, 2.04068914e-01f, 1.07554886e-02f, -7.41172656e-02f, 2.25165170e-02f, 1.97826419e-02f, -2.85461754e-01f, -5.59850559e-02f,
  1.91795051e-01f, -1.54547215e-01f, -2.32506096e-01f, 1.84093807e-02f, -3.37797515e-02f, -2.95861244e-01f, -2.07529478e-02f, -1.56215385e-01f, 3.17084268e-02f, 7.76801407e-02f,
  -1.59295782e-01f, 7.71204308e-02f, -3.87259543e-01f, -1.88425213e-01f, -1.43255383e-01f, -1.95413277e-01f, -2.72231728e-01f, -1.43642947e-01f, -2.90652752e-01f, -4.38302785e-01f,
  7.82725513e-01f, 2.05225080e-01f, 2.57970244e-01f, -1.72240496e-01f, -3.37048203e-01f, -2.49072224e-01f, -3.32590878e-01f, -1.28953606e-01f, 2.59656012e-02f, 3.27742733e-02f,
  1.95243850e-01f, 2.78506845e-01f, 1.89534724e-01f, 2.70385861e-01f, 1.70076430e-01f, -1.54802967e-02f, -1.20690390e-01f, 1.81467012e-01f, 2.00539574e-01f, -1.18882522e-01f,
  -6.99889883e-02f, 3.06675453e-02f, 1.76983073e-01f, 1.67153642e-01f, 8.06718245e-02f, -4.72110212e-02f, -4.19351980e-02f, -2.10808501e-01f, -1.73213765e-01f, -5.58939725e-02f,
  3.75444263e-01f, 1.30960137e-01f, 1.77262276e-01f, 2.53542721e-01f, 2.43317500e-01f, 4.06173557e-01f, 1.86326563e-01f, 1.54335752e-01f, -4.20824103e-02f, -1.08654097e-01f,
  8.00954998e-02f, 7.93510899e-02f, 8.35806131e-02f, 4.65918854e-02f, -9.78092849e-02f, 1.27601102e-01f, 1.86161757e-01f, 1.46336379e-02f, 4.96491380e-02f, 1.78870007e-01f,
  1.18635044e-01f, -1.39563650e-01f, -5.91638349e-02f, -9.31784883e-02f, 1.01910934e-01f, 1.06497779e-01f, 6.56813383e-02f, -4.08013538e-02f, 6.06301799e-02f, 1.00521348e-01f,
  8.37734342e-02f, 1.80917487e-01f, 1.16679393e-01f, -2.08650294e-04f, -3.25588733e-02f, -1.61399961e-01f, -2.02398926e-01f, -3.12201791e-02f, 1.30254552e-01f, 2.63540950e-02f,
  -6.45812824e-02f, -4.90099639e-02f, -9.01095103e-03f, -4.93266210e-02f, 2.16786802e-01f, 5.27895689e-02f, -8.47491547e-02f, 1.14633538e-01f, -8.61762557e-03f, 7.71572860e-03f,
  -9.20708105e-02f, -3.32194455e-02f, -9.43949167e-03f, -9.92057472e-02f, -3.56078446e-02f, 5.90367354e-02f, -1.67052895e-02f, 1.29232099e-02f, -1.53273055e-02f, -5.41953109e-02f,
  1.50062665e-01f, 2.09638983e-01f, 6.35807216e-02f, 2.19903067e-01f, -9.40318629e-02f, 2.07494408e-01f, 1.97410062e-01f, -1.20088369e-01f, -1.51795655e-01f, -8.95951912e-02f,
  -9.79378000e-02f, -9.76635702e-03f, -6.45348132e-02f, 5.62617481e-02f, -4.93583865e-02f, -3.07957381e-02f, 6.26122653e-02f, -4.28013597e-03f, 4.54864698e-03f, -4.23957258e-02f,
  -5.20074293e-02f, -1.22630466e-02f, -1.09536350e-01f, -1.13729527e-02f, -1.47764266e-01f, -9.87432227e-02f, -4.24615256e-02f, 2.39916816e-02f, -1.45144805e-01f, -1.00958943e-01f,
  4.05194908e-01f, -2.77433783e-01f, -1.06817365e+00f, -4.96418983e-01f, -7.70292699e-01f, -6.45770252e-01f, -3.10672730e-01f, -1.31957367e-01f, -3.06207716e-01f, -4.29513216e-01f,
  -2.21135691e-02f, 2.03024283e-01f, 6.34904876e-02f, 1.27139449e-01f, 4.08550352e-01f, -3.63245577e-01f, -6.22293472e-01f, -4.28521246e-01f, -1.32825285e-01f, -9.39066410e-02f,
  -5.39980084e-02f, -1.96931615e-01f, -6.30970448e-02f, -1.22315317e-01f, -5.14159203e-01f, -2.93429852e-01f, -7.53461421e-01f, -5.97121000e-01f, -3.75062108e-01f, -6.57907188e-01f,
  -8.84614959e-02f, -3.63657475e-01f, -1.69317067e-01f, 2.17398539e-01f, -1.91996470e-01f, 9.00189206e-02f, 5.28929420e-02f, -2.24284828e-01f, 9.27067846e-02f, -4.92146285e-03f,
  -1.74780205e-01f, -3.88909355e-02f, 1.01166584e-01f, -7.60689825e-02f, -1.19674392e-01f, 3.67646967e-03f, -2.92592078e-01f, -2.27503523e-01f, -2.31916368e-01f, -9.64840800e-02f,
  7.18691526e-03f, -8.00110474e-02f, -1.89274717e-02f, -5.53189032e-02f, -1.39603317e-01f, -1.08073168e-01f, -4.06214952e-01f, -3.58462363e-01f, -3.80127877e-01f, -2.05238685e-01f,
  -2.78394409e-02f, -1.10657746e-02f, -1.13297284e-01f, -9.72288474e-02f, 8.22974369e-02f, 2.68423613e-02f, -2.19468363e-02f, 1.07022472e-01f, 1.29404545e-01f, -8.24050158e-02f,
  -3.56875323e-02f, -9.94095132e-02f, -4.86325510e-02f, 1.90923978e-02f, -5.43098487e-02f, -1.08256623e-01f, 1.91321298e-01f, 4.29366902e-02f, -8.42680875e-03f, -2.47805938e-02f,
  3.43716936e-03f, -2.64929421e-02f, -9.21936929e-02f, 4.70713936e-02f, -6.52104989e-02f, -7.05686286e-02f, 3.69298197e-02f, 1.17112219e-01f, -2.74839485e-03f, -1.00763336e-01f,
  5.24136245e-01f, -8.43682140e-02f, 3.18740368e-01f, 1.54336795e-01f, -1.04823463e-01f, -8.32952559e-02f, -2.22211763e-01f, 6.41122535e-02f, 7.88000524e-02f, 3.52128446e-02f,
  -4.88903113e-02f, 1.56600147e-01f, 6.34564161e-02f, 6.81476220e-02f, -2.20052782e-03f, 6.43800423e-02f, 7.34539777e-02f, 6.91349655e-02f, -5.13083078e-02f, -1.19735673e-01f,
  -8.40134472e-02f, 2.87701577e-01f, 4.87422913e-01f, 2.41605863e-01f, 9.47341099e-02f, 2.51490086e-01f, 9.54717994e-02f, -2.14398708e-02f, 3.64483416e-01f, 4.84346271e-01f,
  8.06756988e-02f, 4.33547944e-01f, -6.91457272e-01f, 3.05269033e-01f, -8.27105269e-02f, -4.11219150e-01f, 2.75447033e-02f, 3.21482867e-01f, 3.50447655e-01f, 3.21108490e-01f,
  3.98419984e-02f, -3.26470941e-01f, -2.52396524e-01f, -2.75940359e-01f, -4.33687210e-01f, -1.60983473e-01f, -4.13062066e-01f, -7.08620906e-01f, -6.55367672e-01f, -8.36477131e-02f,
  2.03044027e-01f, 1.70356482e-01f, 6.11380152e-02f, -1.17185310e-01f, 1.22476667e-01f, -7.55228996e-02f, 8.73296112e-02f, 4.00250889e-02f, -2.05223903e-01f, -1.23997219e-01f,
  -2.37636611e-01f, -9.28429738e-02f, -2.32941195e-01f, -1.23643048e-01f, 5.26249669e-02f, -1.29682407e-01f, -2.14037523e-01f, -1.43702954e-01f, -2.10446879e-01f, -3.92374061e-02f,
  -1.22425437e-01f, -1.10645801e-01f, -4.48696643e-01f, -9.40108076e-02f, -1.25561967e-01f, -1.70736298e-01f, -9.68366489e-03f, -1.88030481e-01f, -2.06691638e-01f, -2.23741427e-01f,
  -1.31370515e-01f, -4.61160630e-01f, -4.97443765e-01f, -1.31838262e-01f, -3.29479784e-01f, -4.85439092e-01f, -8.60977173e-02f, -1.85228109e-01f, -2.50654221e-01f, 3.60239387e-01f,
  1.61413625e-01f, 5.34793772e-02f, 4.21132930e-02f, 2.09186807e-01f, 1.44741625e-01f, 5.04094213e-02f, 7.02862442e-02f, -7.84636568e-03f, -6.12986200e-02f, -1.10321864e-02f,
  -6.29885122e-03f, 1.65643096e-01f, -6.74065128e-02f, -1.25021592e-01f, -1.47705659e-01f, -2.20581368e-01f, -1.25428602e-01f, 2.52263457e-01f, -3.05293920e-03f, -7.43103027e-02f,
  -1.36399269e-02f, -8.97816867e-02f, -1.07828572e-01f, 7.84608163e-03f, -4.88364436e-02f, -4.72097099e-03f, -1.29538491e-01f, 8.50870162e-02f, -1.31871840e-02f, -9.99731421e-02f,
  5.52727759e-01f, -4.31436151e-01f, 2.39188969e-01f, 5.98910786e-02f, 1.13012031e-01f, 1.48908263e-02f, 3.55843902e-02f, -6.43647313e-02f, -8.91913921e-02f, -3.97803336e-02f,
  -2.36270875e-01f, 2.79162321e-02f, -1.17790371e-01f, 3.91901359e-02f, -1.81977347e-01f, 2.88460292e-02f, 1.55354336e-01f, 5.12192398e-02f, -1.63850635e-01f, 5.94229549e-02f,
  1.23821057e-01f, 5.93658127e-02f, -5.68278320e-02f, 1.07086420e-01f, 2.27421112e-02f, -1.21429965e-01f, 9.36004519e-02f, 1.11817941e-01f, -3.04213434e-01f, 6.72584891e-01f,
  5.51184714e-01f, -6.03289306e-01f, -4.67266083e-01f, -1.41498938e-01f, -3.48156542e-02f, 1.69360310e-01f, -7.23123103e-02f, -9.59682651e-03f, -2.35537589e-02f, -3.14115494e-01f,
  -8.76025036e-02f, -5.83684184e-02f, -6.91236779e-02f, -2.08713114e-01f, -1.52904376e-01f, -4.31043088e-01f, -3.16612273e-01f, 3.22845429e-02f, 4.10953969e-01f, 2.80880779e-01f,
  -1.32534755e-04f, -1.04860365e-01f, -3.37749049e-02f, -1.94427706e-02f, -3.17570001e-01f, -1.33848339e-01f, -3.87504160e-01f, -1.81280464e-01f, -2.95729965e-01f, -4.99603689e-01f,
  -1.62621915e-01f, 1.62857071e-01f, 6.11335151e-02f, -8.62769708e-02f, -8.16040933e-02f, -7.69983158e-02f, 5.97571896e-04f, -1.16607407e-02f, -8.95511266e-03f, -1.28933400e-01f,
  -4.40803677e-04f, 4.87566181e-03f, -7.81202829e-03f, 1.03167266e-01f, 8.18568617e-02f, 1.69615641e-01f, 1.94720700e-01f, 5.24544045e-02f, 3.06966864e-02f, -1.36545286e-01f,
  -1.90976858e-02f, 1.79296508e-01f, 1.91709444e-01f, 1.43194094e-01f, 1.22417502e-01f, 1.76929206e-01f, 7.67052025e-02f, 2.32456937e-01f, 8.82697850e-02f, 1.23322047e-01f,
  -1.16989762e-01f, 4.83950265e-02f, 1.33633152e-01f, 1.82363123e-01f, 3.16794634e-01f, 1.03759557e-01f, 1.99756727e-01f, 4.78361957e-02f, 1.13199048e-01f, 8.61887932e-02f,
  3.47470194e-02f, 5.80585748e-02f, 3.23882066e-02f, 5.47487698e-02f, -5.48391603e-02f, -7.86844268e-02f, 7.84911811e-02f, 5.71490675e-02f, -1.34956064e-02f, -6.96073696e-02f,
  1.53289720e-01f, 7.38278851e-02f, -1.66604310e-01f, -4.94155325e-02f, -4.42697573e-03f, -7.07655028e-02f, 3.07524391e-02f, -1.08534917e-01f, -1.84457414e-02f, -1.18203089e-01f,
  7.17356754e-03f, 3.22370410e-01f, 1.01517782e-01f, -7.81082660e-02f, -9.15484056e-02f, -6.34998679e-02f, 5.83056360e-03f, -1.66502953e-01f, -9.14764032e-02f, 4.93235812e-02f,
  3.50853465e-02f, -2.68028514e-03f, 4.28598523e-02f, 1.23484194e-01f, 2.25712836e-01f, 2.26185530e-01f, 2.18765978e-02f, 8.41525272e-02f, 1.49087626e-02f, -2.12752536e-01f,
  -3.90533358e-02f, 5.73974438e-02f, 9.07582641e-02f, 5.15280664e-02f, 2.31082648e-01f, 1.26127392e-01f, 1.39492363e-01f, 1.45794541e-01f, 8.19184631e-02f, 1.80649370e-01f,
  3.58744979e-01f, -2.53415883e-01f, 4.13312852e-01f, 5.46661131e-02f, 5.39913654e-01f, 5.67764699e-01f, 7.12780952e-01f, 2.85460830e-01f, 3.30295451e-02f, 1.63629323e-01f,
  -3.05943549e-01f, -7.54910648e-01f, -7.20740438e-01f, -6.03222668e-01f, -2.66263008e-01f, 1.78918138e-01f, 3.65661681e-01f, -2.85310973e-03f, -6.33984357e-02f, 9.80109423e-02f,
  -7.97608718e-02f, 2.18034819e-01f, 1.47370443e-01f, -3.26320603e-02f, -1.93111315e-01f, -3.24085683e-01f, 2.17984736e-01f, 2.76337802e-01f, -4.60333237e-03f, -3.12604129e-01f,
  -1.43588692e-01f, 2.77137041e-01f, -1.06768757e-01f, -3.61838132e-01f, -1.88491970e-01f, -1.98941454e-01f, 9.80980545e-02f, -6.07382208e-02f, -1.76083937e-01f, -3.62970829e-02f,
  -2.70482272e-01f, -2.24672332e-01f, -4.12894547e-01f, 4.74885330e-02f, 1.04698174e-01f, 3.07887718e-02f, 1.17328041e-03f, -1.51326224e-01f, -3.48243594e-01f, -1.21552616e-01f,
  -4.14700300e-01f, 2.24262968e-01f, 3.90278727e-01f, 1.35596722e-01f, -1.77089050e-01f, -7.01714307e-03f, 1.22173011e-01f, 8.64376407e-03f, 4.78252880e-02f, -3.68941128e-02f,
  -1.12901675e-02f, 4.29337919e-02f, -3.21938470e-02f, 1.22452438e-01f, 5.31061664e-02f, 4.39264858e-03f, -8.63555074e-02f, -7.37086311e-02f, 1.38415806e-02f, 6.35787621e-02f,
  -5.36479950e-02f, 3.68757248e-02f, 1.89351533e-02f, -1.47416174e-01f, -9.15951431e-02f, -4.85327281e-02f, 1.66571096e-01f, -1.79056630e-01f, -5.56213371e-02f, 8.27635527e-02f,
  6.55120835e-02f, 9.61055160e-02f, -7.81220645e-02f, -1.48832783e-01f, 1.54519886e-01f, -1.31125748e-01f, -7.66357780e-02f, -1.55694366e-01f, -8.02746192e-02f, 2.07416475e-01f,
  -1.80955067e-01f, -8.27151015e-02f, -1.24856532e-01f, -1.17006570e-01f, 1.58406809e-01f, -6.09781854e-02f, -8.73671100e-02f, 4.73194718e-02f, 1.39587015e-01f, -1.60067081e-01f,
  -1.42089546e-01f, -1.40072182e-01f, -1.11688040e-01f, 2.00995803e-01f, 1.24791011e-01f, 6.44569919e-02f, -6.95636347e-02f, -4.28208224e-02f, -1.72071710e-01f, -2.01132111e-02f,
  -2.27522235e-02f, 2.44425207e-01f, 3.08077008e-01f, -2.76799016e-02f, -6.68967143e-02f, 2.29866728e-02f, 1.28240630e-01f, 8.74578580e-02f, 2.76645690e-01f, 2.39357397e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  4.30877984e-01f, 1.64508149e-01f, 5.31092942e-01f, 4.40088838e-01f, 4.45160180e-01f, 3.52975518e-01f, 3.93044233e-01f, 1.18601412e-01f, 1.25366747e-02f, 2.39039287e-01f,
  4.11963642e-01f, 2.68740118e-01f, 6.42189443e-01f, 6.38151348e-01f, 4.99747396e-01f, 4.37940687e-01f, 5.69572806e-01f, 6.52714550e-01f, 8.03626597e-01f, 6.06162250e-01f,
  4.34257627e-01f, 4.47182447e-01f, 4.70908225e-01f, 6.12507403e-01f, 1.37591973e-01f, 8.04061472e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -1.09218746e-01f, 7.89951310e-02f, 4.86443341e-02f, -7.97439367e-03f, -5.94469681e-02f, 2.42682826e-02f, -2.11379394e-01f, 1.82576086e-02f, 2.56902520e-02f, -2.57641822e-01f,
  -7.74143413e-02f, 3.67273912e-02f, -6.65513426e-02f, -3.20119530e-01f, 1.46748409e-01f, -6.33061230e-02f, -1.09377787e-01f, -1.58370867e-01f, -4.42083031e-02f, -5.49743585e-02f,
  4.51342911e-02f, -8.58699679e-02f, -1.85727075e-01f, -1.21119469e-01f, -1.52107641e-01f, -1.41865283e-01f, -1.93908527e-01f, -8.36871937e-03f, -7.14902654e-02f, 3.39945331e-02f,
  -4.21528779e-02f, -5.75766675e-02f, -7.74665326e-02f, -1.09957755e-01f, -1.48824796e-01f, -1.67789266e-01f, -1.52385429e-01f, -1.07304797e-01f, -1.06001772e-01f, -4.80395317e-01f,
  2.22939506e-01f, -4.08127248e-01f, -4.43716161e-02f, -1.88363865e-01f, -1.65254444e-01f, 2.07850188e-02f, 7.29105026e-02f, -2.17263680e-02f, 2.33062934e-02f, -2.42533013e-02f,
  2.66202111e-02f, 2.07470581e-01f, 3.46569717e-02f, 3.99672568e-01f, 2.94153132e-02f, 1.18720897e-01f, -1.68128219e-02f, -7.70454183e-02f, 3.97288725e-02f, -6.41587451e-02f,
  8.19228515e-02f, -1.01109549e-01f, -2.62016118e-01f, -1.01993546e-01f, 2.74245515e-02f, 1.08739212e-01f, -1.47796590e-02f, -3.93012792e-01f, -2.93443620e-01f, -1.32815436e-01f,
  -2.58561134e-01f, 3.05426512e-02f, -6.69529755e-03f, 3.16548720e-02f, 1.14820972e-01f, -1.52958170e-01f, 1.62103847e-01f, 1.84911534e-01f, 2.09576637e-01f, -6.93178996e-02f,
  -8.50759223e-02f, 3.21269408e-02f, 1.65711015e-01f, -4.12269235e-02f, 3.69045697e-02f, -2.21792355e-01f, -1.23510882e-01f, -2.20322423e-03f, -1.94339290e-01f, -1.85469151e-01f,
  -1.86978560e-02f, -1.93853065e-01f, 6.57900870e-02f, 7.24660754e-02f, 2.55191594e-01f, 8.42135996e-02f, -1.83422431e-01f, 7.57250488e-02f, 4.11478616e-02f, -2.58212928e-02f,
  2.49369711e-01f, -2.41860703e-01f, 5.75865030e-01f, -2.14139640e-01f, 8.07099789e-02f, -1.16957176e+00f, -6.78247690e-01f, 3.29912961e-01f, 1.98135767e-02f, 6.69669569e-01f,
  1.32368639e-01f, -9.92490128e-02f, -1.26337320e-01f, 5.94309010e-02f, 2.01631114e-01f, -5.46734333e-01f, -5.08877039e-01f, -1.27163693e-01f, -5.17192036e-02f, -2.65313804e-01f,
  -3.44159991e-01f, 1.71365350e-01f, 6.14049673e-01f, 5.58018824e-03f, 1.66998848e-01f, 9.73825976e-02f, 4.08392757e-01f, -4.97209907e-01f, 9.62638855e-02f, 2.12956481e-02f,
  -2.05239411e-02f, 4.62450758e-02f, -3.52605395e-02f, -3.77369449e-02f, 8.91961008e-02f, 1.15753263e-01f, -2.89344192e-01f, -1.41478013e-02f, -3.75287309e-02f, 5.53001687e-02f,
  -3.65258679e-02f, 6.25812709e-02f, -6.41170144e-02f, 4.85400446e-02f, -2.32142955e-02f, 5.53869233e-02f, 6.73944280e-02f, -1.44571528e-01f, 8.22166577e-02f, 7.13294670e-02f,
  -1.02898262e-01f, 2.87664142e-02f, 1.85617998e-01f, 1.19387686e-01f, 8.24291855e-02f, 1.57323539e-01f, -1.35278376e-02f, -1.89551204e-01f, 9.53602046e-02f, 9.27706882e-02f,
  6.12215847e-02f, 2.61439104e-02f, -5.46039827e-03f, -9.40533727e-02f, 4.75023920e-03f, 5.58911823e-02f, 5.97167984e-02f, -2.35536635e-01f, -2.54364498e-02f, 5.70455231e-02f,
  7.36782327e-02f, -1.19326904e-01f, -1.62866965e-01f, 2.79132575e-02f, 9.39286575e-02f, 1.20083923e-02f, -1.33743525e-01f, 8.73377398e-02f, -3.82646732e-02f, -4.76358570e-02f,
  1.24043010e-01f, 3.26180518e-01f, -1.30163699e-01f, 1.25900850e-01f, -2.52500296e-01f, 5.44954129e-02f, 1.77526727e-01f, -6.67192787e-03f, 1.50210172e-01f, 1.98231339e-01f,
  -7.95957297e-02f, -5.83659224e-02f, 2.38846630e-01f, 2.73429453e-01f, 9.00992081e-02f, -3.17089587e-01f, -3.22372884e-01f, -7.74201080e-02f, -2.02642471e-01f, 1.79310277e-01f,
  1.68736596e-02f, 2.03987896e-01f, -2.16619000e-01f, 9.02249590e-02f, -1.53979242e-01f, 1.57871142e-01f, -1.74142420e-01f, 9.45758447e-02f, 1.90122742e-02f, 4.96745296e-03f,
  -3.11985202e-02f, -8.27610344e-02f, -9.86287277e-03f, -3.15000564e-02f, -2.59026170e-01f, -7.99755231e-02f, -2.64172137e-01f, 4.78921756e-02f, -7.72072598e-02f, 7.49346614e-02f,
  3.14664766e-02f, 1.46650374e-01f, 6.79162890e-02f, -1.08013488e-02f, 1.89224370e-02f, 3.19890194e-02f, -4.99492474e-02f, -3.44461262e-01f, 1.48027137e-01f, -1.97334677e-01f,
  -3.47979873e-01f, 1.66244790e-01f, -2.86317039e-02f, -4.33768958e-01f, 3.88775393e-02f, 9.54846919e-01f, -4.68893588e-01f, -7.51481652e-01f, -7.26745903e-01f, -2.67264171e-04f,
  -7.10105419e-01f, -6.15854561e-01f, 1.13567460e+00f, -6.16297245e-01f, -6.02757514e-01f, 2.98146456e-01f, -6.37747884e-01f, 6.14426374e-01f, -6.71621025e-01f, -6.65473163e-01f,
  -5.94805479e-01f, 2.49154456e-02f, 8.09521317e-01f, -7.03292370e-01f, 3.34395409e-01f, -1.05971003e+00f, 1.30937234e-01f, -5.91195934e-02f, 1.53438210e-01f, -1.02006353e-01f,
  1.23884920e-02f, 8.14035721e-03f, -6.71442319e-03f, 4.25038822e-02f, 1.24962404e-01f, 6.89375103e-02f, 5.28112091e-02f, 2.73650475e-02f, 9.10750497e-03f, 1.17134834e-02f,
  7.06759095e-02f, 2.08109334e-01f, -5.63749671e-02f, -5.32203428e-02f, 6.86005056e-02f, 1.50112227e-01f, -5.28890714e-02f, 2.30087817e-01f, 1.34873673e-01f, 4.39387076e-02f,
  -1.06735639e-01f, -8.19097739e-03f, 3.74325924e-02f, -1.38506191e-02f, 1.49966359e-01f, 2.47898772e-02f, 3.22172418e-02f, -6.39388114e-02f, 1.19777292e-01f, 1.86864603e-02f,
  -5.14896885e-02f, 3.39307263e-02f, 2.77167231e-01f, 1.32160291e-01f, 1.81884822e-02f, 2.29062453e-01f, 1.64493993e-02f, -1.84145616e-03f, 1.69237554e-02f, -6.57451823e-02f,
  7.15851039e-02f, -7.95565695e-02f, 1.21854112e-01f, -3.54657508e-02f, -3.04267500e-02f, 1.05152257e-01f, 1.04256958e-01f, 1.41041458e-01f, -2.96836734e-01f, 2.08558917e-01f,
  -2.37043396e-01f, 4.23696399e-01f, 1.47602320e-01f, 2.79293656e-01f, 3.89367417e-02f, -7.97508806e-02f, -3.93623486e-03f, 1.83635011e-01f, -3.36037487e-01f, -4.25413787e-01f,
  6.46466836e-02f, 2.01149769e-02f, 6.44103214e-02f, -9.09254178e-02f, -1.49503604e-01f, -3.88339758e-02f, -5.45475408e-02f, -8.73376355e-02f, -3.39931220e-01f, -1.72607556e-01f,
  -2.58788228e-01f, -4.02763128e-01f, -2.74206817e-01f, 1.43033326e-01f, -3.82536232e-01f, 2.08426043e-01f, -1.59688249e-01f, -4.94081706e-01f, -3.32511783e-01f, -1.58392668e-01f,
  -1.93942547e-01f, -1.45125195e-01f, -2.26346374e-01f, -1.55804396e-01f, -1.75806165e-01f, 9.54436362e-02f, -3.27075988e-01f, 4.67922874e-02f, 1.52430713e-01f, 4.40604016e-02f,
  3.59828085e-01f, -6.83904439e-02f, 2.26187050e-01f, 1.08149193e-01f, 1.88899115e-01f, -2.61559397e-01f, 2.93553788e-02f, 2.45127365e-01f, 8.65288496e-01f, -7.39446819e-01f,
  -5.06088853e-01f, -4.03366685e-01f, -1.44690543e-01f, 4.32576090e-01f, 3.68607879e-01f, -1.30438492e-01f, -8.08321610e-02f, 1.72471747e-01f, -3.37725639e-01f, 2.76380599e-01f,
  4.94456768e-01f, 7.67932236e-01f, -1.32007927e-01f, -5.33076644e-01f, -1.57394350e-01f, -4.53381566e-03f, -3.71635519e-02f, -6.13380253e-01f, 1.41096011e-01f, 1.23358585e-01f,
  -8.71337831e-01f, -6.15164936e-01f, -7.56812468e-02f, -4.17134851e-01f, 1.15631521e-01f, 1.00035511e-01f, 6.49448782e-02f, -3.10186654e-01f, -1.78912669e-01f, -3.71175702e-03f,
  -1.37081504e-01f, -2.01128855e-01f, 1.09105952e-01f, -1.38440982e-01f, 1.74092636e-01f, -3.23577344e-01f, -6.47963211e-03f, -2.48223916e-01f, -1.00011036e-01f, 1.87901743e-02f,
  -2.02287778e-01f, -9.33786854e-02f, 8.91971309e-03f, -7.47662410e-03f, -2.81352159e-02f, -1.10787794e-01f, 1.74073458e-01f, -1.26044462e-02f, 1.55110478e-01f, -4.76474613e-01f,
  -3.13285589e-01f, -3.72448750e-02f, -1.14265114e-01f, 2.72573799e-01f, -9.65800893e-04f, -2.00656056e-01f, -1.48945868e-01f, -2.98857927e-01f, -1.84926301e-01f, -3.08536261e-01f,
  -7.47037530e-02f, -1.24828957e-01f, 1.15828000e-01f, -3.57097268e-01f, -1.41411394e-01f, 2.75069382e-02f, 1.10827405e-02f, -1.79872662e-02f, -1.40543776e-02f, -7.25679025e-02f,
  -2.19666407e-01f, -1.22996733e-01f, -2.14889750e-01f, 1.72034930e-02f, -1.33223366e-02f, 2.06498638e-01f, 4.68773469e-02f, -1.44962221e-01f, 2.06902891e-01f, 2.97536701e-01f,
  -3.21651608e-01f, -1.47385970e-01f, 6.97298497e-02f, 1.14036746e-01f, -5.07935807e-02f, 1.83024868e-01f, 3.08295965e-01f, -1.73825428e-01f, 2.57326990e-01f, -1.63838238e-01f,
  -3.21452796e-01f, 3.54133427e-01f, 6.42191991e-02f, 1.15548953e-01f, 2.82697380e-01f, 3.53057496e-02f, -5.72929196e-02f, -1.89216718e-01f, 2.86340356e-01f, -1.59786627e-01f,
  4.24771369e-01f, 5.24396598e-02f, 2.23640993e-01f, 6.73700646e-02f, -1.91488251e-01f, -9.14950892e-02f, -4.97556776e-01f, 8.65246281e-02f, 4.03252631e-01f, 1.48491338e-01f,
  -1.37461841e-01f, -1.82707027e-01f, 2.66116083e-01f, 4.85339493e-01f, -1.86105162e-01f, -2.39183247e-01f, -1.70350596e-01f, 3.14773202e-01f, -4.16762888e-01f, 1.69916958e-01f,
  6.85267523e-02f, 2.81636357e-01f, -1.00423992e-01f, 1.62513271e-01f, -9.56899449e-02f, 7.30426982e-02f, 1.21945910e-01f, -5.78039467e-01f, 7.53491148e-02f, 6.15819871e-01f,
  -4.74477381e-01f, -2.93180078e-01f, -4.45081234e-01f, 4.67742860e-01f, -4.62681890e-01f, -2.62360066e-01f, -1.34258616e+00f, 2.33121186e-01f, -1.02413344e+00f, 6.80609941e-01f,
  3.13301861e-01f, -3.81001890e-01f, 5.40269554e-01f, -1.27192259e-01f, -9.73131180e-01f, 2.84434885e-01f, 6.49684966e-01f, -8.76201928e-01f, -2.58890510e-01f, -2.69381225e-01f,
  -2.48306781e-01f, 2.39917547e-01f, -9.09118727e-02f, 3.90582681e-02f, -1.92301467e-01f, -1.29554540e-01f, -4.34254594e-02f, -1.82103172e-01f, 1.06700510e-01f, -2.54453421e-01f,
  -3.91910598e-02f, 1.41012669e-02f, -9.82011631e-02f, -8.12087506e-02f, -1.60353854e-01f, -1.60209134e-01f, -8.95305499e-02f, 4.55062129e-02f, 1.34756982e-01f, -1.80753693e-01f,
  -1.52607150e-02f, -6.07532188e-02f, -3.89798768e-02f, -1.99734136e-01f, 1.13166600e-01f, -5.97238392e-02f, -3.47523540e-02f, 6.12779474e-03f, 1.13558641e-03f, -2.11623624e-01f,
  1.35582432e-01f, -2.51557887e-01f, -2.43847281e-01f, -4.48286086e-02f, -3.49118039e-02f, 5.23153841e-02f, 2.59898826e-02f, -3.16847228e-02f, 3.31828743e-02f, -8.61570016e-02f,
  -2.04303578e-01f, 2.72590220e-01f, -1.00071453e-01f, -1.72636941e-01f, -6.46092072e-02f, 9.79217589e-02f, -3.51496190e-02f, 5.51840244e-03f, 2.36221492e-01f, 5.73204011e-02f,
  -2.50475466e-01f, -6.89716414e-02f, 9.75602344e-02f, 1.32850455e-02f, 2.41241902e-01f, -2.91473061e-01f, 1.39177695e-01f, 1.39285132e-01f, 1.30591944e-01f, -4.08910029e-02f,
  2.57472065e-03f, 2.02869713e-01f, 1.67910621e-01f, -2.00833604e-01f, 1.05881780e-01f, -1.05840139e-01f, 3.20557579e-02f, -1.31059080e-01f, 1.65905237e-01f, 1.47847205e-01f,
  2.69618928e-01f, 7.73897097e-02f, 2.09045708e-01f, 1.11958556e-01f, -3.21689062e-02f, 1.33401304e-01f, -6.61171973e-02f, 1.69688225e-01f, -5.37364222e-02f, 1.88856587e-01f,
  -2.46867955e-01f, 3.37563932e-01f, -1.57921553e-01f, 1.65217400e-01f, 1.33623153e-01f, 1.38391539e-01f, -3.16669792e-01f, 8.22021514e-02f, -1.32698387e-01f, -1.45835489e-01f,
  7.34952465e-02f, -1.21706925e-01f, -1.07380159e-01f, -2.72921529e-02f, -3.39461192e-02f, 1.29424380e-02f, -5.98252639e-02f, 1.81019846e-02f, -6.20667860e-02f, -2.23253116e-01f,
  -8.40092357e-03f, 3.05616677e-01f, -2.50690579e-01f, 8.93496256e-03f, -3.37064624e-01f, 9.65748876e-02f, 2.15136692e-01f, 4.85353947e-01f, 1.20571382e-01f, -5.23678124e-01f,
  -2.36928552e-01f, -3.06484044e-01f, 2.52709955e-01f, -3.43945473e-02f, 7.16024578e-01f, 4.19566721e-01f, 3.14642519e-01f, 3.15161079e-01f, 4.92298573e-01f, -2.01403975e-01f,
  -9.57699418e-02f, -2.81143934e-01f, -1.75504640e-01f, -1.82399243e-01f, -7.72207439e-01f, 2.31204517e-02f, -3.53325427e-01f, 1.74025089e-01f, -5.09896576e-01f, -5.06885588e-01f,
  1.82474121e-01f, 2.31077552e-01f, 9.91173610e-02f, 2.08250023e-02f, 1.29954979e-01f, 1.11944407e-01f, 1.92789912e-01f, 1.36117309e-01f, -2.06768811e-02f, 1.34600207e-01f,
  1.21123813e-01f, 6.69975346e-03f, -5.97833470e-02f, 2.08241805e-01f, 1.12925753e-01f, 1.96156412e-01f, -7.29005411e-03f, 1.74242705e-02f, 6.31750524e-02f, 1.27842695e-01f,
  7.04039633e-02f, 1.81246549e-01f, -4.96680550e-02f, 1.08661890e-01f, 4.17903513e-02f, -4.37287465e-02f, 1.41643941e-01f, 9.87382904e-02f, -6.76070973e-02f, 7.03136995e-02f,
  2.58298844e-01f, -1.52990296e-01f, 1.60243288e-02f, 9.11594629e-02f, -9.44364723e-03f, 1.48091033e-01f, 2.52834886e-01f, 8.62365067e-02f, 2.02408433e-01f, 1.97063327e-01f,
  -1.28663303e-02f, 1.58858761e-01f, -2.98930611e-03f, 6.75648525e-02f, 2.59175953e-02f, -8.98974668e-03f, 1.29349262e-01f, 1.07520603e-01f, 1.99289456e-01f, 1.40176073e-01f,
  -9.03263967e-03f, 7.55941942e-02f, -1.71672300e-01f, -1.04098499e-01f, -1.61215007e-01f, -3.20061177e-01f, -5.15822880e-02f, 1.21022679e-03f, 6.65645078e-02f, 1.45381898e-01f,
  -2.57089883e-01f, -1.70286238e-01f, -2.68254220e-01f, 9.55302641e-02f, 1.25825882e-01f, 2.31029809e-01f, 3.08163404e-01f, 3.00753266e-02f, 2.44468346e-01f, 6.73656240e-02f,
  -2.13169664e-01f, 2.21993448e-03f, 1.01596273e-01f, 1.87314197e-01f, 1.94929749e-01f, 3.91274899e-01f, -4.09489637e-03f, -4.11341608e-01f, 2.97628969e-01f, 1.30006924e-01f,
  -1.63656458e-01f, -1.38943307e-02f, 3.92440885e-01f, -4.28624228e-02f, -1.43348083e-01f, -4.26483810e-01f, 2.49861255e-01f, 1.22472748e-01f, 2.19865859e-01f, -1.26697004e-01f,
  -2.42921695e-01f, 1.64194733e-01f, -4.18836951e-01f, -8.51546302e-02f, -4.28101160e-02f, 1.69011354e-01f, 1.11414619e-01f, 2.12962851e-02f, -5.70621993e-03f, -3.98922078e-02f,
  -1.78149074e-01f, -1.70312867e-01f, -6.73738599e-01f, 1.53137013e-01f, 5.05072117e-01f, -1.03586984e+00f, -8.57708603e-02f, -7.47232080e-01f, -5.77651083e-01f, -5.90416372e-01f,
  -3.83711338e-01f, 1.42406479e-01f, 2.24217385e-01f, -7.57365227e-01f, -3.66562903e-01f, -5.20691693e-01f, -2.19007745e-01f, -2.79982150e-01f, -5.06332278e-01f, -3.97378892e-01f,
  -2.77215242e-02f, 9.90494490e-01f, -6.68554902e-01f, -3.87462825e-02f, 4.44268197e-01f, 7.48804390e-01f, -1.56124607e-01f, -1.41944155e-01f, 6.43258244e-02f, 5.03543504e-02f,
  -1.68435365e-01f, -9.98887196e-02f, -1.21707339e-02f, -5.65125942e-02f, -1.13778874e-01f, 4.12548743e-02f, -2.25354716e-01f, -2.39968505e-02f, -2.28365630e-01f, -5.45617677e-02f,
  -9.81374830e-03f, 5.98818511e-02f, 1.31116599e-01f, -7.71152973e-02f, -5.40768132e-02f, 6.90164939e-02f, 7.52776489e-02f, 1.20824039e-01f, -1.03365968e-03f, -1.98450133e-01f,
  -3.38703319e-02f, -8.37136135e-02f, 1.03989691e-01f, 1.17623834e-02f, -1.80871636e-01f, 1.15720429e-01f, -9.57781374e-02f, 2.18946859e-01f, 2.45839387e-01f, 8.09464455e-02f,
  4.48995875e-03f, 1.72353849e-01f, 1.60866544e-01f, 1.70686424e-01f, 4.32718657e-02f, 5.34567684e-02f, 1.88680403e-02f, -2.20323354e-01f, -2.07077730e-02f, -1.01057149e-01f,
  3.63874771e-02f, 7.56908730e-02f, 1.07399642e-01f, 1.66498840e-01f, -1.58953696e-01f, -2.46861205e-01f, 2.06809163e-01f, 1.46176647e-02f, -2.71631824e-03f, 1.48256915e-02f,
  -2.11752802e-02f, -5.81531346e-01f, -1.65104657e-01f, -1.45042073e-02f, 1.91464514e-01f, 1.64325148e-01f, -3.44225407e-01f, -2.58077085e-01f, -1.11786667e-02f, -3.43146920e-01f,
  2.08929718e-01f, 1.21485904e-01f, 3.80934216e-02f, -1.29144087e-01f, 2.55473912e-01f, 1.67945921e-01f, 3.96665782e-01f, -8.84494483e-02f, -1.31842628e-01f, -1.69936180e-01f,
  5.77103376e-01f, -1.92853555e-01f, -2.41732717e-01f, 3.06392401e-01f, -1.14569038e-01f, -1.74524784e-01f, -1.42584592e-01f, -2.97240257e-01f, 2.01916948e-01f, -7.17464536e-02f,
  -2.45358303e-01f, -2.43128076e-01f, 6.81568235e-02f, -2.72250205e-01f, 9.02200043e-02f, 8.24183300e-02f, -3.59862857e-02f, -1.80046752e-01f, 2.85869658e-01f, 7.74951056e-02f,
  3.19639832e-01f, -2.36995846e-01f, -6.33192286e-02f, -1.58932075e-01f, 2.32377991e-01f, -2.91957676e-01f, 1.09563256e-02f, -2.34580562e-01f, 1.75333172e-01f, 3.55994627e-02f,
  4.74182874e-01f, 1.08197235e-01f, -5.11160076e-01f, -5.11139512e-01f, -5.95533848e-01f, -1.70137525e-01f, 4.88039732e-01f, -4.91569906e-01f, -3.24884981e-01f, 8.98157433e-02f,
  7.72533953e-01f, -9.79608178e-01f, -8.77182424e-01f, 4.76091057e-01f, -4.80488122e-01f, 7.47290552e-02f, -8.15109730e-01f, 1.01007491e-01f, 5.62790334e-01f, -8.07125568e-01f,
  -5.88156462e-01f, 3.13028604e-01f, -1.81700781e-01f, -5.99039376e-01f, -6.91328526e-01f, -3.19826752e-01f, -1.86407059e-01f, -1.79975092e-01f, -1.22838601e-01f, 2.69517442e-03f,
  -6.98712841e-02f, -1.92215275e-02f, -4.09588329e-02f, 1.35070503e-01f, -2.11318657e-01f, -8.29892680e-02f, -1.04642764e-01f, 9.79804769e-02f, -1.62440464e-01f, -5.01728281e-02f,
  -2.00567469e-01f, -7.57272169e-02f, -5.56394123e-02f, 9.76357982e-03f, 3.91742811e-02f, -2.62710810e-01f, -2.88513005e-01f, -2.14697093e-01f, -5.60389608e-02f, -1.58779472e-01f,
  -1.62418455e-01f, 7.15717673e-02f, -3.48882750e-02f, -1.95109367e-01f, -4.59423177e-02f, -1.14830360e-01f, -1.79374576e-01f, -8.27009603e-03f, 2.19818950e-02f, 3.65009122e-02f,
  -6.68655336e-03f, -1.91490084e-01f, -1.50420278e-01f, -1.96109831e-01f, -2.06805486e-02f, 2.42345762e-02f, -6.63022399e-02f, 2.89550964e-02f, -6.43552169e-02f, -7.91062042e-03f,
  7.25335302e-03f, -3.65078524e-02f, 4.85160276e-02f, -6.66182414e-02f, -1.61412463e-01f, -6.57790452e-02f, -8.46180618e-02f, 9.75346789e-02f, -3.20280075e-01f, 1.50585026e-01f,
  2.11464182e-01f, 2.56936904e-02f, -1.13461465e-01f, 8.31859410e-02f, 3.92330959e-02f, -4.37537879e-02f, -5.28366081e-02f, -1.07930116e-01f, 4.84861946e-03f, 1.46202266e-01f,
  -1.22712087e-03f, -1.93189085e-01f, -2.36740828e-01f, 7.14565590e-02f, -1.72006816e-01f, -1.43264569e-02f, 1.09894320e-01f, -1.28305256e-01f, -5.39072081e-02f, -7.34617747e-03f,
  1.62181795e-01f, 9.96131152e-02f, 1.66552588e-01f, -2.38565095e-02f, 1.78147092e-01f, -7.76122883e-02f, 1.25999227e-01f, -5.50026596e-02f, 3.27165462e-02f, -1.03831857e-01f,
  -2.71228790e-01f, -6.86449930e-03f, 5.59671707e-02f, 2.56638438e-01f, -2.35328630e-01f, 1.86480254e-01f, 2.54589856e-01f, -2.03935087e-01f, -2.20576636e-02f, 1.58100814e-01f,
  -2.48312112e-02f, 2.67551430e-02f, 1.11782327e-01f, 1.51990250e-01f, -3.25965255e-01f, 1.74176216e-01f, -2.13192210e-01f, 2.39253193e-01f, -2.40119919e-01f, 8.63489509e-02f,
  -4.02923524e-01f, 5.63118815e-01f, 1.63828179e-01f, -6.72136784e-01f, 6.94198787e-01f, 2.46604774e-02f, -4.64370102e-01f, -5.05456552e-02f, -1.89176493e-03f, -2.76949316e-01f,
  -3.66716504e-01f, 4.38292801e-01f, -4.73292083e-01f, -1.54477671e-01f, 3.48849922e-01f, -4.76283163e-01f, -4.88043576e-01f, 2.95085520e-01f, 5.12995541e-01f, -2.07476690e-01f,
  -2.61922151e-01f, -1.11443922e-01f, -6.83460891e-01f, -3.55257332e-01f, -2.63274927e-02f, 8.36435929e-02f, 7.70901293e-02f, 3.92406574e-03f, -9.27762501e-03f, 6.27932325e-02f,
  -2.73291245e-02f, -1.54189542e-01f, -4.06965315e-02f, 5.02609182e-03f, -1.40950501e-01f, -1.61090549e-02f, 1.92442626e-01f, -1.86209366e-01f, -1.46965146e-01f, -3.96585837e-02f,
  1.40935168e-01f, 1.22785911e-01f, 8.26457702e-03f, 3.60895656e-02f, 1.56816080e-01f, 7.44041428e-02f, 1.18312538e-01f, 1.62962750e-01f, 9.79352221e-02f, 5.19861840e-02f,
  1.09445110e-01f, 1.19103841e-01f, 1.10591017e-01f, 7.24401996e-02f, -3.89905363e-01f, 1.15074746e-01f, 2.18101576e-01f, 6.01778105e-02f, -3.85339372e-02f, 1.76094890e-01f,
  -5.58723025e-02f, 8.14984962e-02f, -3.25499803e-01f, 4.05069739e-01f, 1.03477888e-01f, 6.81239739e-02f, -2.02424973e-02f, 2.87458420e-01f, 1.27277166e-01f, -1.58621326e-01f,
  1.09123148e-01f, 1.40009180e-01f, -1.30445674e-01f, 1.21923774e-01f, 2.10209526e-02f, -2.44215921e-01f, 1.45997584e-01f, 3.86196703e-01f, -4.62778807e-02f, -8.85815397e-02f,
  1.36724398e-01f, -3.09922993e-01f, -1.21725522e-01f, -1.90379009e-01f, 4.33303230e-02f, 3.39250535e-01f, -2.22735763e-01f, 2.30883792e-01f, -4.33576077e-01f, 1.92884311e-01f,
  -3.20408911e-01f, -3.30645293e-01f, -2.40759730e-01f, -2.82228347e-02f, -1.44271627e-01f, 2.54551381e-01f, 3.02950978e-01f, 2.15900108e-01f, 3.35076153e-01f, -2.91911252e-02f,
  -3.89569283e-01f, -9.69688520e-02f, 9.54868868e-02f, -1.71399176e-01f, 1.30875960e-01f, -4.98608947e-01f, -3.04595493e-02f, 1.07392378e-01f, 1.17854007e-01f, 2.65207887e-01f,
  1.95240632e-01f, -2.06034016e-02f, -2.55387604e-01f, 3.19601864e-01f, -1.95306450e-01f, 1.68172240e-01f, 2.45634884e-01f, 2.84593016e-01f, -3.97100970e-02f, -1.56822830e-01f,
  -3.13932210e-01f, 2.92153537e-01f, -1.53765872e-01f, -2.46203110e-01f, 3.97881746e-01f, -2.17132464e-01f, -2.98481703e-01f, -3.05864096e-01f, -5.24476826e-01f, -3.05679113e-01f,
  1.59045935e-01f, -3.82345051e-01f, -1.86500102e-01f, -1.06773265e-01f, -1.21911848e-02f, 2.94520646e-01f, -1.82366282e-01f, -1.87433556e-01f, -3.15540820e-01f, -2.54740506e-01f,
  -1.08294688e-01f, 9.37922969e-02f, -4.34423417e-01f, -7.70822391e-02f, -6.07461929e-01f, -1.14710204e-01f, -3.42235059e-01f, -4.74445075e-01f, -6.33808494e-01f, -4.67922688e-01f,
  2.55725324e-01f, 9.15081382e-01f, 2.39332542e-02f, -2.23852977e-01f, 1.85664102e-01f, -7.84799457e-03f, 4.43319464e-03f, 5.55545129e-02f, -6.71096146e-02f, -7.97560290e-02f,
  9.56412628e-02f, -7.75971487e-02f, -9.91210043e-02f, -3.15212905e-02f, 4.02646884e-02f, 1.72101334e-02f, 3.84481102e-02f, -1.97305188e-01f, 4.48044688e-02f, -6.43379539e-02f,
  3.28138657e-02f, -7.80069306e-02f, 2.82249600e-02f, 2.90669799e-01f, 1.50920719e-01f, -3.88503484e-02f, 7.96116814e-02f, 8.63721594e-02f, -7.47378767e-02f, 1.51556209e-01f,
  -1.08623162e-01f, 2.88567948e-03f, -3.12905222e-01f, 7.31915608e-02f, 5.84981404e-02f, -1.19034618e-01f, 1.32181197e-01f, -1.16103038e-01f, -1.42891273e-01f, 2.41302364e-02f,
  1.40083143e-02f, 1.20706134e-01f, -5.71199600e-03f, -8.61636847e-02f, -1.66293427e-01f, 1.48760945e-01f, -1.08160377e-01f, -1.11434590e-02f, -3.44743848e-01f, 1.71963647e-01f,
  1.09394528e-01f, -2.63743680e-02f, -1.30363656e-02f, 1.60202533e-01f, -2.08440498e-01f, -3.01641151e-02f, -8.19923356e-02f, -3.56748432e-01f, 1.78696379e-01f, 1.81097046e-01f,
  3.24463360e-02f, 1.55035093e-01f, -9.25865117e-03f, -1.56880096e-01f, 1.24377683e-01f, 3.49397480e-01f, -3.13639402e-01f, -8.41063559e-02f, 2.75931150e-01f, -6.51204959e-02f,
  -4.38172847e-01f, 1.65742517e-01f, 4.30257857e-01f, -2.80929962e-03f, -4.89320904e-01f, 1.13005854e-01f, 5.80800287e-02f, -5.16104281e-01f, -4.35254335e-01f, -3.31968397e-01f,
  3.52010578e-01f, -1.74032941e-01f, 1.21240392e-01f, 4.51071292e-01f, 2.52062410e-01f, 1.55188829e-01f, -3.63951057e-01f, -2.24828526e-01f, 4.42774475e-01f, 5.12833595e-02f,
  6.77989572e-02f, -3.06824267e-01f, 5.28981149e-01f, -1.71686113e-01f, 1.69079378e-01f, -1.21541575e-01f, -1.39209092e-01f, -1.13685921e-01f, 4.40431088e-02f, -3.34683776e-01f,
  2.65312970e-01f, 3.66866648e-01f, -1.65161490e-01f, 7.29471296e-02f, -7.16200471e-01f, -2.30238557e-01f, -7.11917207e-02f, 2.47740880e-01f, -2.74516851e-01f, -4.29837614e-01f,
  5.05315848e-02f, -2.30998918e-01f, 1.12175405e+00f, 1.56057447e-01f, -1.39635831e-01f, 6.40900254e-01f, 7.38094091e-01f, -1.07373178e+00f, -9.24566388e-01f, -3.33484769e-01f,
  -3.41253430e-01f, 2.28270084e-01f, 6.25845551e-01f, -7.21747816e-01f, 1.17473908e-01f, 2.66123825e-04f, -6.39408708e-01f, -8.69387016e-03f, -2.41716951e-02f, -6.44077837e-01f,
  2.87759639e-02f, 6.61130324e-02f, 5.16922809e-02f, 2.07302496e-01f, 1.84621528e-01f, -5.54477274e-02f, -1.30618721e-01f, -3.48419137e-02f, 1.85109198e-01f, -4.64706570e-02f,
  -2.31231913e-01f, 8.63405317e-02f, 2.26165295e-01f, -2.66773403e-02f, 4.35149446e-02f, -2.23210771e-02f, -3.62386857e-03f, 1.43046990e-01f, 6.12230003e-02f, 2.67523259e-01f,
  -2.57878788e-02f, 1.21381499e-01f, 6.04556650e-02f, 2.01883197e-01f, 6.14043176e-02f, 1.16450749e-01f, 1.07580401e-01f, 2.28077993e-01f, 4.17916477e-02f, 2.06777722e-01f,
  1.22415431e-01f, 5.75604551e-02f, 7.38849789e-02f, -1.85430571e-01f, 1.96197927e-01f, 1.21799625e-01f, 1.54536087e-02f, 5.85624538e-02f, 1.89739197e-01f, -2.62956530e-01f,
  -6.73733577e-02f, 1.04482383e-01f, 1.29313871e-01f, -5.85799702e-02f, 2.77641080e-02f, 1.09517105e-01f, 3.11462041e-02f, -1.82093397e-01f, 1.80272654e-01f, 1.74730737e-02f,
  -1.11281708e-01f, -2.77750790e-01f, 4.03876722e-01f, 6.35861278e-01f, 1.79435521e-01f, -2.49478772e-01f, -2.85004109e-01f, -1.47174418e-01f, 2.01784119e-01f, 5.99597245e-02f,
  1.70324534e-01f, 3.25264543e-01f, 2.26357237e-01f, -2.56185591e-01f, -2.98852473e-01f, 2.86924332e-01f, -2.17875645e-01f, 9.22197476e-02f, -1.13766856e-01f, 1.82782352e-01f,
  3.10367584e-01f, 3.07459265e-01f, -1.68455914e-01f, 1.23468176e-01f, -1.28185488e-02f, -2.15528965e-01f, 1.15970351e-01f, 2.78154463e-01f, 1.00316122e-01f, 2.25670636e-01f,
  3.40258092e-01f, 1.05771087e-01f, 1.38891861e-01f, 8.73569623e-02f, 4.10366684e-01f, 1.26990870e-01f, -1.44867361e-01f, -1.22205429e-01f, 2.39043027e-01f, 1.60636082e-01f,
  -2.33299613e-01f, 2.99494386e-01f, 3.66021335e-01f, -2.18625113e-01f, 4.48244005e-01f, -5.15503287e-01f, 4.30362374e-01f, 1.76763207e-01f, -1.80612907e-01f, 4.58491482e-02f,
  1.26023009e-01f, -1.69954270e-01f, -6.06399834e-01f, -7.76414052e-02f, -9.98445094e-01f, -2.75978118e-01f, -3.65157694e-01f, -4.94809836e-01f, 1.08074717e-01f, -3.12134206e-01f,
  -5.63547730e-01f, -7.72563756e-01f, -3.15057397e-01f, -5.84219933e-01f, -2.77307510e-01f, -1.89680189e-01f, 7.32019246e-01f, -2.11443126e-01f, 5.99835813e-01f, -3.02865773e-01f,
  9.24187377e-02f, -2.23787084e-01f, -6.36739552e-01f, 3.14025991e-02f, 2.52567500e-01f, 1.44206360e-01f, -1.87097132e-01f, -5.93408108e-01f, 4.00065035e-02f, 1.57505080e-01f,
  -1.47612095e-01f, -3.08136549e-02f, 1.58387735e-01f, 9.59609151e-02f, 1.52500555e-01f, 6.02074750e-02f, 4.63273339e-02f, -1.01934142e-01f, 7.43176043e-02f, 3.91968414e-02f,
  -5.19117750e-02f, 1.48225233e-01f, 9.92285684e-02f, 6.06869832e-02f, -5.01233749e-02f, -1.74313560e-01f, -2.70039253e-02f, 2.04164401e-01f, 7.99692124e-02f, -1.46803141e-01f,
  -2.04161152e-01f, -1.55251967e-02f, -2.18600839e-01f, 2.09064022e-01f, 4.47500125e-02f, -3.98385376e-02f, -2.49550015e-01f, -8.57096389e-02f, 2.43252993e-01f, 1.36832461e-01f,
  -7.95898288e-02f, 3.21283974e-02f, -1.52088791e-01f, 1.34281710e-01f, -9.20369178e-02f, 1.21853722e-03f, 1.54620707e-01f, -2.49628618e-01f, 3.64539549e-02f, 1.48336232e-01f,
  1.21807449e-01f, -2.49486595e-01f, 5.49271740e-02f, -5.05991206e-02f, 1.28958195e-01f, -3.75838615e-02f, 2.01589093e-01f, 6.02136739e-02f, 1.29062841e-02f, -2.70566732e-01f,
  3.20418835e-01f, -7.60649502e-01f, 1.74879566e-01f, 1.30133063e-03f, 9.45508629e-02f, -7.11011514e-02f, -2.29681507e-02f, -2.71244757e-02f, -2.56404102e-01f, -2.20426962e-01f,
  8.84751603e-02f, -6.49831071e-02f, 2.98711751e-02f, -1.93547234e-01f, -2.94183075e-01f, 5.50606310e-01f, 5.69786012e-01f, -1.73146442e-01f, -7.51086622e-02f, -2.50941128e-01f,
  1.64892986e-01f, -2.22204968e-01f, -4.19071287e-01f, 4.27296549e-01f, 3.91640633e-01f, 9.16049927e-02f, -3.22205812e-01f, -1.35476530e-01f, 4.52981927e-02f, 3.07366282e-01f,
  -1.57652542e-01f, 3.60618085e-01f, 2.77212143e-01f, 4.36809719e-01f, -2.42765039e-01f, 1.42134324e-01f, 3.41279775e-01f, 4.73138422e-01f, 1.39494315e-01f, -2.71272033e-01f,
  -1.41099960e-01f, -3.00130397e-01f, -4.78306621e-01f, -5.86871393e-02f, -4.63416696e-01f, -3.63619089e-01f, 9.65446681e-02f, 7.39016384e-02f, -5.19191697e-02f, 3.10838632e-02f,
  3.97935398e-02f, 2.01994672e-01f, -6.79919273e-02f, 6.61791384e-01f, 1.38756856e-01f, -7.68233612e-02f, -9.91923273e-01f, -3.19849968e-01f, -1.21368602e-01f, -1.14333260e+00f,
  -2.27847740e-01f, 3.46740812e-01f, -4.53947872e-01f, -3.80799085e-01f, -5.88092506e-01f, 4.49826956e-01f, 3.64587545e-01f, -6.97252825e-02f, -1.60056233e-01f, -1.67611703e-01f,
  1.61969051e-01f, -7.27589652e-02f, -3.82431418e-01f, -6.44616187e-01f, 7.58421645e-02f, 7.13201940e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -3.36645931e-01f, -4.03445661e-02f, 5.68132214e-02f, -2.16503635e-01f, -2.56191015e-01f, -1.15214512e-02f, 2.05234081e-01f, -6.46890923e-02f, 1.36227772e-01f, 2.02940449e-01f,
  1.88404471e-01f, 1.68583632e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    