/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.52190894e-01f, -1.90460265e-01f, -1.16910916e-02f, 1.52515292e-01f, -2.01016888e-01f, -2.97567189e-01f, 1.59072161e-01f, -2.34755754e-01f, -1.38906226e-01f, -8.03294964e-03f,
  9.66575295e-02f, 8.21185485e-02f, 2.27417022e-01f, -6.46040440e-02f, 2.94907421e-01f, 1.89707100e-01f, -9.55686420e-02f, -3.03751025e-02f, -1.22451901e-01f, -6.21479303e-02f,
  -1.85855627e-02f, -1.77854411e-02f, 2.13691145e-01f, -2.45165899e-01f, -2.00135633e-01f, -1.24976829e-01f, 2.27814063e-01f, 1.87121090e-02f, -7.44695123e-03f, 9.77150910e-03f,
  -9.12649930e-03f, -7.83674568e-02f, -4.85161878e-02f, -3.52892540e-02f, -2.94783693e-02f, 4.49452549e-02f, 5.69638908e-02f, 1.07643373e-01f, 1.10731265e-02f, -9.38653648e-02f,
  -1.11200148e-02f, -4.23662886e-02f, -2.76355911e-02f, -3.06751002e-02f, -7.58947656e-02f, -1.77043881e-02f, -6.13383800e-02f, -7.22685382e-02f, -6.47360981e-02f, -2.55735666e-02f,
  4.53994749e-03f, -5.28170466e-02f, -4.09107879e-02f, -2.93030050e-02f, -5.01696579e-02f, -7.68147036e-02f, -3.50634083e-02f, -9.70785040e-04f, -2.57170927e-02f, -5.47794774e-02f,
  1.10891676e-02f, -1.11165054e-01f, 4.90069464e-02f, 8.77935737e-02f, 1.48732383e-02f, 4.60532634e-03f, -1.62476022e-02f, 7.72122666e-02f, -5.59797026e-02f, 1.81777310e-02f,
  -4.84825112e-02f, 2.31998768e-02f, -5.27599342e-02f, -1.71655547e-02f, -8.95317830e-03f, -1.79198086e-02f, -3.84659395e-02f, -8.25419091e-03f, -4.56586666e-02f, 7.57703604e-03f,
  3.90318111e-02f, -3.26608159e-02f, 6.35615811e-02f, -2.57917214e-03f, 6.55963868e-02f, 3.04394532e-02f, -7.59930760e-02f, -3.13992612e-02f, 1.29175922e-02f, 8.01547617e-02f,
  2.91494131e-02f, 5.46518713e-02f, -1.06269820e-02f, -2.37724166e-02f, 1.07574668e-02f, -1.22211836e-02f, -2.33024806e-02f, -1.45393297e-01f, 3.10800076e-02f, 2.08067223e-02f,
  -8.25795457e-02f, -2.11558994e-02f, 4.02437756e-03f, -2.03174688e-02f, 2.95847431e-02f, -6.96548400e-03f, 1.26975790e-01f, 5.87272178e-03f, 8.22924636e-03f, -4.10472602e-02f,
  1.29708305e-01f, 1.32939480e-02f, 7.15059089e-03f, -8.94159451e-02f, -3.32814939e-02f, 8.90156105e-02f, -8.37196484e-02f, -3.95638775e-03f, 5.73920906e-02f, -4.96551171e-02f,
  -4.69450206e-01f, 3.11276257e-01f, 2.05645531e-01f, 2.98168838e-01f, -3.73808682e-01f, -2.79226094e-01f, 2.76339650e-02f, 1.72867607e-02f, 4.93452931e-03f, 2.36701533e-01f,
  6.16818257e-02f, -3.44118811e-02f, 9.82828066e-02f, 6.55744895e-02f, -3.22571754e-01f, 5.64726442e-02f, 7.76425004e-02f, 1.12345658e-01f, 2.02651229e-02f, 3.20108272e-02f,
  -5.51988818e-02f, -2.18092860e-03f, 1.45205975e-01f, -8.62518549e-02f, -5.24217356e-03f, 1.35659590e-01f, 1.61950484e-01f, -7.86584690e-02f, 5.86032309e-02f, -9.48019922e-02f,
  -5.40719070e-02f, 1.37848824e-01f, 3.55461314e-02f, 3.97890396e-02f, 4.34559062e-02f, 5.26194870e-02f, -1.78550556e-03f, -5.18432185e-02f, -5.85157908e-02f, 5.39709292e-02f,
  -6.46845549e-02f, -8.41322020e-02f, -1.13618020e-02f, -8.19291845e-02f, -2.36711260e-02f, -3.02389823e-02f, -1.02757938e-01f, -2.68564317e-02f, 4.26319055e-02f, -7.51830265e-02f,
  -3.37213315e-02f, 5.86444885e-02f, 2.60737669e-02f, 1.21432766e-01f, -4.43455242e-02f, 1.95072480e-02f, 1.37672937e-02f, -4.42034900e-02f, 2.18314081e-02f, 5.75519074e-03f,
  -3.30258720e-02f, -3.78952883e-02f, -4.95256335e-02f, -1.65761821e-03f, -8.48447904e-02f, 3.88343632e-02f, -5.16306870e-02f, 6.45620457e-04f, -8.56188778e-03f, -1.83306560e-02f,
  4.72950470e-03f, -1.52155729e-02f, 3.24785858e-02f, 7.53205922e-03f, -2.02069432e-02f, 3.22059542e-02f, 2.03729756e-02f, 2.31685340e-02f, -9.27980617e-03f, -3.08938082e-02f,
  4.25850824e-02f, 5.01825195e-03f, -5.61241247e-02f, 5.26046939e-02f, -6.68401364e-03f, 3.64822277e-04f, 2.50371359e-02f, 1.85470860e-02f, 7.53680468e-02f, -6.02385066e-02f,
  4.45040539e-02f, 1.89808801e-01f, 7.67476717e-03f, 2.91245077e-02f, 5.55160604e-02f, -1.12942532e-01f, 1.89169366e-02f, -3.15536000e-02f, 4.31162082e-02f, -1.08588599e-02f,
  1.87653881e-02f, 8.11758339e-02f, -5.65052312e-03f, 3.01060006e-02f, 7.38126133e-03f, -1.01740016e-02f, 5.83102964e-02f, -2.19077654e-02f, 1.73316896e-02f, 5.33362292e-03f,
  7.69863576e-02f, -9.92350560e-03f, 3.31679583e-02f, -4.46706377e-02f, 5.63822128e-03f, 4.17443253e-02f, -7.89483190e-02f, -5.08977212e-02f, -4.58604507e-02f, 5.23401089e-02f,
  -1.10685475e-01f, -5.56159057e-02f, 3.55354160e-01f, -2.71189064e-01f, 1.51974201e-01f, -5.44952750e-02f, -1.70239672e-01f, 5.87331429e-02f, -2.69587878e-02f, -3.41285735e-01f,
  -2.13528663e-01f, 5.38566038e-02f, -4.48146127e-02f, -3.11280847e-01f, 4.42609340e-01f, 3.66093628e-02f, -1.51580647e-01f, -1.58646077e-01f, 6.14983290e-02f, -5.85906431e-02f,
  1.42310441e-01f, -2.70217329e-01f, 1.13746002e-01f, 4.44656163e-02f, -5.81615828e-02f, 1.63395163e-02f, -5.63487411e-02f, 1.28659606e-01f, -2.50072144e-02f, 8.11627284e-02f,
  -5.96264470e-03f, -5.97499758e-02f, -4.55124397e-03f, 3.14853154e-02f, -7.36172423e-02f, -8.51457119e-02f, -4.66746129e-02f, 3.60154249e-02f, 6.85346425e-02f, -3.43927518e-02f,
  -2.42821616e-03f, 1.11823734e-02f, -3.16875391e-02f, 4.20759954e-02f, -3.55810300e-02f, 2.59328522e-02f, 2.64372006e-02f, -3.89673223e-04f, -2.61676945e-02f, 2.34162658e-02f,
  1.59804318e-02f, -2.81167999e-02f, -6.07834980e-02f, 9.59905796e-03f, 9.65299904e-02f, -5.96264005e-02f, 5.13900258e-02f, 6.30315244e-02f, 4.86583589e-03f, -3.03492099e-02f,
  3.71112898e-02f, -5.99738443e-04f, -4.80510406e-02f, 1.29371719e-03f, 9.97687317e-03f, -2.62478217e-02f, -9.65954084e-03f, -3.55230682e-02f, 5.14638312e-02f, -3.25520337e-02f,
  -1.16054108e-03f, 3.07775941e-02f, -8.24836940e-02f, -5.34650125e-02f, -3.22536454e-02f, -8.69061649e-02f, 3.83044221e-02f, -2.72050835e-02f, -1.08354893e-02f, 1.90542843e-02f,
  -9.74945445e-03f, 2.68814098e-02f, 1.20580643e-02f, -4.51150425e-02f, -1.03725241e-02f, 3.43842357e-02f, -9.56360810e-03f, -4.04846249e-03f, -6.31282281e-04f, 5.65847708e-03f,
  3.04433629e-02f, 1.56565253e-02f, 2.14191545e-02f, -4.76961434e-02f, 5.42422570e-02f, 4.80518714e-02f, 4.42472883e-02f, 2.53288671e-02f, 5.74604347e-02f, -1.12631069e-02f,
  -9.57405791e-02f, -2.57075261e-02f, 4.13679630e-02f, 4.79349401e-03f, 9.83866453e-02f, 3.14621069e-02f, -1.29635530e-02f, 9.48186666e-02f, -8.89341254e-03f, 3.35006937e-02f,
  -2.17369813e-02f, -6.20490424e-02f, 4.50012572e-02f, -3.63758467e-02f, -4.48897295e-02f, -5.60183376e-02f, 7.46172890e-02f, -4.56917360e-02f, -9.46053676e-03f, 6.06363975e-02f,
  -2.06889495e-01f, 5.18249512e-01f, 2.40668416e-01f, 6.18109666e-02f, -5.86430132e-02f, 1.21684581e-01f, 6.00835716e-04f, 8.64188597e-02f, -2.66084433e-01f, -2.74774861e-02f,
  -1.50947243e-01f, 1.60066262e-02f, -3.94440591e-02f, 1.24947213e-01f, -9.80887488e-02f, 3.18733156e-02f, -1.90860033e-02f, 4.32721376e-02f, -4.86227032e-03f, 1.16684973e-01f,
  -5.31485602e-02f, -1.04768135e-01f, 8.51128772e-02f, 1.53396893e-02f, 4.24606204e-02f, 4.68848646e-02f, -3.85400318e-02f, 2.58512236e-02f, 1.28585368e-01f, -5.79574443e-02f,
  1.86188072e-02f, -2.12391727e-02f, 2.27450263e-02f, -3.64859737e-02f, -1.53410994e-02f, 2.78752390e-02f, 8.18213727e-03f, -7.01110139e-02f, 1.30528426e-02f, -2.58467831e-02f,
  6.04154542e-03f, -2.28063632e-02f, -1.21912621e-02f, -7.03822300e-02f, -6.50570123e-03f, -2.72252951e-02f, -5.86763164e-03f, 2.46385392e-02f, 1.45556122e-01f, 6.91069514e-02f,
  1.89807918e-02f, 5.45676984e-02f, -5.05585447e-02f, -9.64573678e-03f, -8.63996297e-02f, -4.13667820e-02f, 3.38361897e-02f, -4.63208737e-04f, -2.00926550e-02f, -4.00079750e-02f,
  -1.21314608e-01f, -4.88617783e-03f, 9.88489315e-02f, -6.21479973e-02f, 5.67980595e-02f, -2.92148255e-02f, -2.32862700e-02f, 5.50881587e-03f, -8.74605849e-02f, -4.22551893e-02f,
  -3.23196277e-02f, 8.84704441e-02f, -3.44265141e-02f, -4.25653532e-02f, -3.93335521e-02f, 2.18891818e-02f, -4.12491150e-02f, -1.06109679e-02f, -6.17375523e-02f, -1.37052555e-02f,
  -2.33010016e-02f, 5.80895133e-02f, 2.02830750e-02f, -5.39783575e-02f, -1.65290069e-02f, -8.13446194e-02f, -1.39987208e-02f, 5.66014647e-02f, 3.37771699e-02f, 2.51997225e-02f,
  8.44945833e-02f, 2.21024994e-02f, -3.51526812e-02f, -2.93149333e-03f, -5.60884550e-02f, -7.80523708e-03f, -1.39219603e-02f, -4.60713618e-02f, -7.38940984e-02f, -3.15864682e-02f,
  -5.18084690e-02f, 4.17096466e-02f, 1.92060806e-02f, -6.88079670e-02f, -4.39576916e-02f, -1.21741537e-02f, 9.14285630e-02f, -2.87360046e-02f, -5.93613908e-02f, -2.96394192e-02f,
  -1.32276751e-02f, -2.45314594e-02f, -5.77514097e-02f, -2.08493359e-02f, -1.41493957e-02f, -1.85485166e-02f, 6.34707063e-02f, 1.25440164e-02f, 1.55800628e-02f, -3.45155373e-02f,
  -3.23234171e-01f, 6.74737543e-02f, 9.93606970e-02f, -2.06826672e-01f, 1.52983993e-01f, -1.83257461e-02f, -1.50310853e-02f, 1.11937933e-02f, -1.10369146e-01f, -2.21449230e-02f,
  -9.51619223e-02f, 4.24120314e-02f, -6.87417835e-02f, -9.72759500e-02f, -3.87815982e-01f, -1.81422144e-01f, -2.85992384e-01f, -9.98898894e-02f, -9.92502496e-02f, 3.92643996e-02f,
  -7.30081722e-02f, -8.91845152e-02f, 8.46351087e-02f, 1.61457315e-01f, 2.34390512e-01f, 1.06620342e-01f, -1.65213689e-01f, 1.44383788e-01f, -1.78118441e-02f, 6.42663613e-02f,
  9.02399421e-02f, 4.02245373e-02f, 4.99419533e-02f, 8.52884203e-02f, -4.60349023e-02f, -2.23021787e-02f, 4.53847796e-02f, 4.90901507e-02f, 2.99777742e-02f, -6.87771663e-03f,
  -3.51095572e-02f, 5.69913117e-03f, -4.49027121e-02f, 2.59034820e-02f, -1.31660169e-02f, 1.97909214e-03f, 2.10518185e-02f, -2.82905195e-02f, 6.53933287e-02f, -5.73556311e-02f,
  3.64046916e-03f, -2.56098453e-02f, -1.14591219e-01f, -6.34630322e-02f, 5.78180216e-02f, -4.23768423e-02f, 8.60884693e-03f, 3.30820866e-02f, -5.84435500e-02f, -3.31065468e-02f,
  -6.12109117e-02f, -5.43556362e-02f, -2.81161964e-02f, 3.62618007e-02f, -3.55063588e-03f, 4.86587100e-02f, -5.23093827e-02f, 3.49009596e-02f, -4.61093001e-02f, -5.47821075e-03f,
  -2.75933594e-02f, -4.93028294e-03f, 9.18356236e-03f, 3.28553692e-02f, -9.51629356e-02f, 1.08808853e-01f, -2.21584761e-03f, -1.36669050e-03f, -1.83714554e-02f, 5.59256300e-02f,
  1.06559023e-02f, 9.68476385e-03f, 2.97571775e-02f, -1.77772176e-02f, 3.93623859e-02f, 1.07522239e-03f, 8.71010125e-03f, 3.72299403e-02f, -2.68694982e-02f, -1.48986457e-02f,
  -7.78696090e-02f, -1.91645831e-01f, 1.25865666e-02f, 9.05659497e-02f, 8.12261715e-04f, -8.78582150e-02f, 3.66624282e-03f, 1.22162057e-02f, 5.35240397e-02f, -7.76452129e-04f,
  2.87012868e-02f, -2.06221244e-03f, -2.06022393e-02f, 2.70867422e-02f, 5.81068872e-03f, -3.33020929e-03f, -8.85907374e-03f, 1.58611983e-02f, 2.59806379e-03f, -3.92410420e-02f,
  -4.50712591e-02f, -1.04607875e-02f, 2.17093732e-02f, -1.13339943e-03f, -3.96902338e-02f, -1.87511998e-03f, -2.85638426e-03f, 9.46597476e-03f, -1.81800332e-02f, 8.65333378e-02f,
  4.57919747e-01f, 1.57316193e-01f, -1.59636632e-01f, 2.66101062e-01f, 8.37851912e-02f, 1.62369721e-02f, 4.65859920e-02f, 3.32628489e-02f, 4.16646332e-01f, 1.72593847e-01f,
  -1.68808363e-02f, 5.87567165e-02f, -4.48535830e-02f, 1.60434493e-03f, -2.62560874e-01f, -1.67542413e-01f, -1.05907097e-01f, -6.58253580e-02f, -1.63531676e-02f, -4.96263392e-02f,
  -5.52491173e-02f, -2.37154514e-02f, -3.56668770e-01f, -1.01709537e-01f, -4.72988822e-02f, -3.11821289e-02f, -1.96241960e-01f, -2.98011657e-02f, -1.23741522e-01f, -5.31447157e-02f,
  -1.28831323e-02f, 1.88555747e-01f, -9.69792623e-03f, -4.16516364e-02f, 9.24705435e-03f, -3.64479907e-02f, -1.04194790e-01f, -7.40379617e-02f, 4.59287204e-02f, -8.83091614e-02f,
  7.04404013e-03f, 3.74507196e-02f, -3.02006286e-02f, -4.02259901e-02f, 1.32683724e-01f, 5.61726913e-02f, 1.01687796e-01f, -1.35935862e-02f, -9.56709869e-03f, 8.54196213e-03f,
  -2.64063571e-02f, 1.88097320e-02f, 8.12109709e-02f, 1.96192916e-02f, 2.49597542e-02f, 1.84662044e-01f, 7.11851567e-03f, -5.14936037e-02f, -7.73498416e-03f, 9.03896540e-02f,
  1.26471192e-01f, -4.82407846e-02f, -3.01976614e-02f, 1.37986848e-02f, 3.32601480e-02f, 3.98817211e-02f, -1.69736370e-02f, -3.27174813e-02f, 7.92778097e-03f, 9.95449126e-02f,
  2.29605511e-02f, 1.82585549e-02f, 2.78523061e-02f, 5.85338213e-02f, 1.54301769e-03f, 6.44483939e-02f, -8.42192844e-02f, -3.74948271e-02f, 1.00754453e-02f, -5.25552928e-02f,
  -5.16701303e-02f, 3.99126438e-03f, -3.01582944e-02f, -1.16904780e-01f, 3.91608216e-02f, 4.65855785e-02f, 1.15535827e-02f, 2.34339479e-02f, -9.46691930e-02f, -1.26082972e-01f,
  4.35169041e-03f, 2.64418013e-02f, -2.84115635e-02f, 2.61940435e-02f, -2.47289818e-02f, 4.54805745e-03f, 4.23522142e-04f, 4.68179211e-02f, 6.30012341e-03f, -1.13792485e-02f,
  -4.88513410e-02f, -9.02715623e-02f, 2.86894608e-02f, -2.20451858e-02f, -9.14543122e-02f, -9.21326689e-03f, -4.74520065e-02f, -2.37259623e-02f, -6.21073991e-02f, 1.18123526e-02f,
  -2.09699874e-03f, 7.09402412e-02f, 2.58476641e-02f, -5.40128611e-02f, -1.00618191e-02f, 4.03864458e-02f, -1.94051955e-03f, 6.38371259e-02f, -6.01206645e-02f, -1.66012663e-02f,
  4.72963482e-01f, -1.00480497e-01f, -7.73440450e-02f, 9.25879404e-02f, 1.57462165e-01f, -3.79649177e-02f, 3.38960555e-03f, -4.24727313e-02f, -1.04663298e-02f, -1.08258821e-01f,
  -4.11190987e-02f, -5.82720712e-03f, -2.41561204e-01f, -1.31694615e-01f, 1.51804805e-01f, -2.72348613e-01f, 2.07907319e-01f, 1.15344934e-01f, -2.94751823e-02f, 6.02808036e-02f,
  3.93312536e-02f, 1.05366660e-02f, -1.24063350e-01f, -6.33597672e-02f, 1.14040658e-01f, -8.10947195e-02f, -3.71085852e-02f, -1.13067694e-01f, -2.70830002e-03f, 2.05646195e-02f,
  -1.46399504e-02f, -6.15571849e-02f, 2.84542274e-02f, -3.38688530e-02f, -2.77314857e-02f, 5.37050292e-02f, -1.19586959e-02f, -2.53756810e-03f, -2.71472763e-02f, -2.92685591e-02f,
  -2.71276608e-02f, 3.44245769e-02f, -1.41037563e-02f, -1.70896098e-03f, 5.65828905e-02f, -2.18367949e-02f, -4.84698033e-03f, 2.78544589e-03f, -5.08999228e-02f, -1.33752571e-02f,
  -2.47015022e-02f, 5.65248430e-02f, 8.02207291e-02f, 2.42739692e-02f, -1.87716410e-02f, -9.95587371e-03f, -8.24095914e-04f, 1.79657340e-02f, -6.46964926e-03f, 2.45330725e-02f,
  -1.45821692e-02f, 6.82090297e-02f, 9.94717237e-03f, -1.86814256e-02f, 3.13230194e-02f, 2.06521992e-03f, 7.84336552e-02f, -5.89451715e-02f, 2.58851647e-02f, -2.54313536e-02f,
  1.59732271e-02f, 3.07497997e-02f, 7.83763733e-03f, 1.49390846e-02f, 6.79897517e-02f, -2.58874381e-03f, 3.20178457e-02f, -7.82790110e-02f, 5.16438708e-02f, -1.42189711e-02f,
  -2.65386119e-03f, 1.51075590e-02f, -7.56758898e-02f, 4.60727466e-03f, -8.02158378e-03f, -6.39764359e-03f, 1.54126938e-02f, 1.00104678e-02f, 1.94751844e-02f, 4.79204357e-02f,
  -3.47894952e-02f, -1.57797471e-01f, -9.80189815e-02f, 1.05103496e-02f, -5.18563651e-02f, 4.76837978e-02f, 5.07782325e-02f, 2.07980946e-02f, -3.39888856e-02f, -1.12190312e-02f,
  5.72822876e-02f, 7.51578296e-03f, 6.22288100e-02f, 1.69370305e-02f, 4.84192446e-02f, 1.05644351e-04f, -4.34259996e-02f, 1.23138884e-02f, 3.29734609e-02f, 4.96281683e-02f,
  7.75429234e-03f, -2.35915892e-02f, 7.73111060e-02f, 1.76117418e-03f, 1.10564446e-02f, 1.16917798e-02f, -4.60237404e-03f, 1.84139293e-02f, -5.14295045e-03f, 3.74265462e-02f,
  -2.31650516e-01f, -1.95842743e-01f, -4.46475655e-01f, -2.28968322e-01f, 2.36439750e-01f, 2.33116105e-01f, -1.28832370e-01f, -2.94565205e-02f, -2.29933932e-01f, 1.06198154e-01f,
  4.76547964e-02f, -2.60294497e-01f, -1.57978430e-01f, 1.84663549e-01f, -8.39063227e-02f, -3.88862044e-02f, 1.22610420e-01f, 9.65050980e-03f, -1.44357562e-01f, -1.28651053e-01f,
  -1.07234322e-01f, 3.25419217e-01f, -1.07647218e-01f, 1.51331291e-01f, 6.70305416e-02f, -1.39308542e-01f, 3.35902274e-02f, -1.81334361e-01f, 2.59174824e-01f, 6.79217651e-02f,
  2.04960957e-01f, 4.69068997e-03f, 8.93387198e-02f, -3.70758143e-03f, 1.03774719e-01f, -1.11035210e-04f, -3.80821079e-02f, -3.35586108e-02f, 9.62624513e-03f, -1.88557152e-02f,
  1.89076010e-02f, -6.10571355e-03f, 5.69200888e-02f, -1.74060669e-02f, -8.00907090e-02f, 1.87468249e-03f, 7.20338300e-02f, 6.19279779e-02f, 5.46095055e-03f, -2.80608004e-03f,
  -1.74810328e-02f, -3.07640191e-02f, -4.64282148e-02f, -4.40191142e-02f, -6.74540550e-02f, 1.60943549e-02f, 1.44694652e-03f, -4.47555285e-05f, 6.65502697e-02f, -2.95042600e-02f,
  -1.97318103e-02f, -5.56777567e-02f, -1.69242378e-02f, 6.49348199e-02f, 3.96997668e-02f, 7.25922287e-02f, -1.31032150e-02f, -2.20715394e-03f, -2.54652426e-02f, -5.69364615e-02f,
  6.89777434e-02f, -1.08140521e-02f, -4.20138612e-02f, -3.12906280e-02f, -3.38727683e-02f, 1.13357268e-02f, -6.01448081e-02f, 3.92149761e-02f, -5.00370637e-02f, 7.37597793e-02f,
  -2.85014771e-02f, -6.16286881e-02f, 6.16730303e-02f, 1.76992565e-02f, 1.62103083e-02f, -1.00763477e-01f, -7.16741011e-02f, -8.08719471e-02f, -1.31692621e-03f, 6.26338497e-02f,
  7.65960366e-02f, -1.09620243e-01f, 7.26371780e-02f, 1.24549516e-01f, 2.38551944e-03f, 7.16068298e-02f, -1.05731994e-01f, 3.79935652e-02f, -9.93539393e-02f, -5.14236465e-03f,
  -3.56463790e-02f, 9.55372825e-02f, -1.81424443e-03f, 4.36666533e-02f, 4.04868871e-02f, -1.51760029e-02f, -6.07002825e-02f, 7.07636075e-03f, 5.66183552e-02f, 1.85793024e-02f,
  6.03782423e-02f, 2.20783218e-03f, 1.45015065e-02f, 1.00513496e-01f, 6.72658086e-02f, -5.57372496e-02f, -4.77937162e-02f, -9.68938135e-03f, 9.23457071e-02f, -3.83158610e-03f,
  -5.19224942e-01f, 1.36062056e-01f, 8.69975239e-02f, -2.31562838e-01f, -7.10359067e-02f, 3.19307595e-01f, -1.63353123e-02f, 1.60625391e-02f, -1.39037982e-01f, 7.95805752e-02f,
  -4.32204045e-02f, 5.22557013e-02f, -9.57549457e-03f, 7.85786062e-02f, -4.83334325e-02f, 1.79340336e-02f, 5.71226701e-02f, 1.00804055e-02f, 4.42505665e-02f, -4.08023596e-02f,
  -3.18278186e-02f, -9.40190442e-03f, -9.10790116e-02f, 6.49514645e-02f, 7.64314160e-02f, 8.39364436e-03f, 8.64477232e-02f, -5.90119918e-04f, 8.63528848e-02f, 3.42413299e-02f,
  -1.20668054e-01f, -2.28107601e-01f, 7.51238987e-02f, 4.43001091e-03f, -3.65634635e-02f, 4.08260152e-04f, 7.74013530e-03f, -7.07984762e-03f, -8.98352917e-03f, 6.73390180e-03f,
  3.14662531e-02f, -4.60042106e-03f, -1.45308170e-02f, 4.48772646e-02f, 1.05845086e-01f, 8.07536244e-02f, 4.58033644e-02f, 5.09770177e-02f, 6.62498875e-03f, -1.27353454e-02f,
  -2.76953378e-03f, 1.61324684e-02f, 7.52525106e-02f, -2.73572337e-02f, 3.48413587e-02f, -4.29283008e-02f, -3.38796452e-02f, 6.44018799e-02f, 5.95386960e-02f, -2.09627226e-02f,
  -4.26555015e-02f, -5.42981513e-02f, 8.61008838e-03f, 2.11175568e-02f, -4.73914808e-03f, -5.04888743e-02f, 6.31465912e-02f, -2.49983873e-02f, 5.86287864e-02f, -1.51630193e-02f,
  -3.23333219e-02f, 2.33640019e-02f, -3.11321095e-02f, -2.30947565e-02f, -3.23550403e-03f, -4.57841977e-02f, -2.61678025e-02f, -4.42207344e-02f, 3.46783809e-02f, -1.50253912e-02f,
  -6.49004802e-02f, -5.97279184e-02f, 3.03372573e-02f, -1.75595339e-02f, 7.26007819e-02f, 3.51941250e-02f, 2.16270126e-02f, -4.88167489e-03f, 7.25416541e-02f, -3.05632893e-02f,
  9.27694049e-03f, -1.92255944e-01f, -1.17672645e-02f, 2.67810542e-02f, 1.02315165e-01f, 1.33669823e-01f, -2.98600905e-02f, 1.53987836e-02f, 9.17296484e-02f, 2.50499882e-02f,
  -2.86653768e-02f, -5.54939955e-02f, -4.75320369e-02f, 5.04481532e-02f, 5.98854683e-02f, -1.79517567e-02f, -1.17301442e-01f, -4.78901044e-02f, -6.50121346e-02f, 4.32663150e-02f,
  2.18668003e-02f, -7.10152462e-02f, 1.57103837e-02f, -4.01346497e-02f, 6.92765228e-03f, -3.68997641e-02f, -5.56978546e-02f, 2.64628064e-02f, -4.71332781e-02f, 3.33453715e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.18419689e-01f, 4.79024537e-02f, -3.42477769e-01f, -2.25801453e-01f, 7.17845783e-02f, -2.78148532e-01f, -2.46140674e-01f, 6.21950179e-02f, -1.14728361e-01f, 1.87986776e-01f,
  8.93494394e-03f, -1.39426559e-01f, 1.64343297e-01f, -2.90751129e-01f, -3.84634435e-01f, -1.19644506e-02f, -2.98076600e-01f, -2.04863951e-01f, 6.21057674e-02f, 1.98745020e-02f,
  -6.70785606e-02f, 2.98574381e-02f, -2.30656743e-01f, 2.02687398e-01f, -1.13344237e-01f, 7.74724036e-02f, 2.46464536e-01f, 9.12322700e-02f, -4.31654081e-02f, -1.36686012e-01f,
  -2.24990416e-02f, 9.80251059e-02f, -1.14199193e-02f, -1.14654325e-01f, -8.63511860e-02f, -2.03710049e-03f, -5.94846681e-02f, -6.84718639e-02f, -3.16258185e-02f, -5.84309995e-02f,
  4.15698625e-02f, 4.89663221e-02f, 2.75128018e-02f, 4.01531793e-02f, -3.72004397e-02f, -5.55898547e-02f, 7.19203905e-04f, 4.36093248e-02f, 9.87335667e-02f, -9.96403992e-02f,
  -2.07208693e-02f, -1.62686724e-02f, -8.01099539e-02f, 8.60110596e-02f, -6.96824938e-02f, -8.84007849e-03f, 3.46532278e-03f, 2.89581716e-02f, 8.43430590e-03f, -4.17979322e-02f,
  -7.80836269e-02f, -1.10244349e-01f, -5.02252877e-02f, -6.76931664e-02f, 9.46777835e-02f, -7.40170758e-03f, -7.99620431e-03f, 3.47597972e-02f, -9.97983888e-02f, 1.81515012e-02f,
  -1.16639975e-02f, 6.42051781e-03f, 4.06724699e-02f, -7.40284249e-02f, -4.15325649e-02f, -3.54724005e-02f, 1.45243164e-02f, 3.67143899e-02f, -9.38249826e-02f, 2.02777423e-03f,
  9.36693251e-02f, -1.30282678e-02f, 7.82201625e-03f, 6.16924167e-02f, -1.00703863e-02f, -6.54946789e-02f, 7.25729540e-02f, -7.54880384e-02f, 5.59351929e-02f, 4.78393734e-02f,
  1.09018467e-01f, 2.81448931e-01f, 1.13774583e-01f, 5.48785329e-02f, 5.52177429e-03f, -2.92696524e-02f, -8.42718259e-02f, -1.63745899e-02f, -7.15669319e-02f, 5.67961903e-03f,
  -3.74025404e-02f, 5.81358909e-04f, 2.37937905e-02f, -5.84862567e-02f, 7.76314130e-03f, 1.10507971e-02f, 1.36363029e-01f, 1.24308854e-01f, -1.52780209e-02f, 1.17460124e-01f,
  4.20206338e-02f, 8.82375389e-02f, 6.39468580e-02f, 2.43222173e-02f, -3.15145180e-02f, 3.43091674e-02f, 1.63997174e-03f, 1.47846779e-02f, 9.63132158e-02f, 6.50979951e-02f,
  4.89272475e-01f, 1.59778446e-01f, -1.85668007e-01f, 1.40385896e-01f, -1.39167249e-01f, -1.29155099e-01f, -4.80104089e-01f, -2.48498917e-02f, -3.50595802e-01f, -1.20341010e-01f,
  1.24680206e-01f, -6.22582175e-02f, -2.50525415e-01f, 2.82054991e-01f, 2.35876888e-01f, -1.01884484e-01f, 1.94528922e-01f, 3.20164710e-02f, 7.45874196e-02f, 2.42001176e-01f,
  3.01904172e-01f, 4.33538526e-01f, 2.07585081e-01f, 3.12599480e-01f, 2.75107473e-01f, 1.96446434e-01f, 3.03906560e-01f, 6.10567816e-02f, 1.23786598e-01f, 1.49921775e-01f,
  6.39554784e-02f, 1.45034328e-01f, -3.51885445e-02f, -3.05367727e-02f, 9.74210799e-02f, 1.51879322e-02f, -5.89962266e-02f, 7.11350664e-02f, -7.02802986e-02f, 5.57231391e-03f,
  6.84480891e-02f, 2.12973952e-02f, 8.66781920e-02f, 5.43118827e-03f, 2.41218153e-02f, -9.26374123e-02f, -9.05203354e-03f, -9.80631933e-02f, -1.62225246e-01f, 1.01221271e-01f,
  -2.91031767e-02f, 8.04196149e-02f, -4.96865017e-04f, -8.01623464e-02f, -6.44480139e-02f, 9.79798194e-03f, -2.77862549e-02f, -9.97787062e-03f, 1.11550599e-01f, -1.42170172e-02f,
  1.25577003e-01f, -1.49367759e-02f, 3.56577039e-02f, -3.19279288e-03f, -4.44212519e-02f, -5.92342578e-02f, -6.75042272e-02f, -3.58847007e-02f, -4.46964018e-02f, -1.23761930e-02f,
  -3.77834626e-02f, 3.04472744e-02f, -1.30725782e-02f, -3.05492766e-02f, 4.70557362e-02f, 9.31473076e-02f, 3.86273526e-02f, 1.27970390e-02f, -1.39581442e-01f, -1.10550009e-01f,
  -4.84771542e-02f, 9.33249947e-03f, -1.33909419e-01f, -1.39500387e-03f, 2.16607302e-02f, -8.86288881e-02f, 1.26436621e-01f, -1.38076721e-02f, -1.44906998e-01f, -8.98681022e-03f,
  4.37251963e-02f, 2.72669286e-01f, -1.49660945e-01f, -2.20795125e-02f, -4.16987389e-02f, 4.89411503e-02f, 4.09868024e-02f, 1.63229302e-01f, 9.04395827e-04f, 6.30912408e-02f,
  1.13652587e-01f, -7.08804578e-02f, 1.24462456e-01f, -5.47139049e-02f, 1.04551511e-02f, 3.05770952e-02f, 5.73397093e-02f, -4.60571796e-02f, -2.09903643e-02f, 7.18488470e-02f,
  9.36095864e-02f, 3.88449952e-02f, 4.65461165e-02f, -1.35403663e-01f, -2.20104214e-02f, -1.78549010e-02f, -3.97617295e-02f, -1.56170391e-02f, 9.62833911e-02f, -8.21551085e-02f,
  -1.97903991e-01f, 3.71656686e-01f, 3.42245363e-02f, -2.96664268e-01f, 4.38614003e-02f, -4.05554295e-01f, -4.15000051e-01f, 7.96883777e-02f, 2.20697179e-01f, 5.63189760e-02f,
  -6.72464073e-02f, 2.70151645e-01f, 9.97190624e-02f, -2.10168168e-01f, -1.59649149e-01f, 1.66671909e-02f, -4.00011390e-01f, -1.80931583e-01f, 9.14551988e-02f, -2.11279258e-01f,
  -1.05691940e-01f, -2.74253547e-01f, -1.65872842e-01f, 1.32995239e-02f, -1.74821973e-01f, 4.08061817e-02f, -2.75360882e-01f, 1.35537535e-01f, -1.43405095e-01f, 1.52832136e-01f,
  -1.27493918e-01f, 1.40079930e-01f, -7.72776753e-02f, -1.68926138e-02f, -1.69641063e-01f, -4.04420458e-02f, -1.09147936e-01f, -4.03392129e-03f, -3.63842398e-02f, 1.27151357e-02f,
  -5.77929523e-03f, -2.47017145e-02f, -6.26735948e-03f, 8.38334188e-02f, 9.85827576e-03f, 1.00585558e-01f, 5.82436249e-02f, -1.16628215e-01f, 3.12458202e-02f, 1.59500137e-01f,
  1.05474159e-01f, 7.79589489e-02f, -7.86485747e-02f, 9.89332702e-03f, 1.79021657e-02f, 1.76449551e-03f, -2.79421583e-02f, 2.45058369e-02f, 2.55645625e-02f, -2.62412112e-02f,
  7.21345544e-02f, -1.09163359e-01f, 3.36623676e-02f, -4.15704865e-03f, 3.83773372e-02f, 1.11375183e-01f, 9.17065069e-02f, -2.84189591e-03f, -4.50186692e-02f, -4.78521362e-02f,
  -6.00358322e-02f, 6.86002076e-02f, 7.12547358e-03f, -9.77004468e-02f, -6.01287670e-02f, -6.17120080e-02f, -9.38019902e-02f, 3.43391933e-02f, 5.76067343e-02f, 3.16639780e-03f,
  -2.85130343e-03f, -4.84867282e-02f, 8.27709362e-02f, -8.89608115e-02f, -6.74969107e-02f, -2.78319400e-02f, 4.89311703e-02f, 6.38063326e-02f, -8.76645967e-02f, -3.45346667e-02f,
  -4.02558893e-01f, -2.85451680e-01f, -1.16367444e-01f, 1.11009985e-01f, -5.57387024e-02f, -1.17172435e-01f, -3.67854908e-02f, -2.55613010e-02f, -1.21687479e-01f, 6.40694797e-02f,
  2.61403564e-02f, -6.76709116e-02f, -1.32650256e-01f, -8.25425088e-02f, -5.96581176e-02f, -4.62764017e-02f, -1.66490674e-01f, -8.48546922e-02f, -1.96294844e-01f, 4.64966819e-02f,
  4.06977832e-02f, -2.57037804e-02f, 3.41937244e-02f, 1.54381746e-03f, -2.59153582e-02f, -2.19493210e-02f, -3.50357518e-02f, 9.09469575e-02f, -5.17174378e-02f, -7.23470934e-03f,
  -4.07475144e-01f, 1.12549476e-01f, -3.83048862e-01f, -1.92097604e-01f, -4.98486981e-02f, -6.06879175e-01f, -3.98154199e-01f, -1.84456140e-01f, 1.32797897e-01f, 4.79397029e-02f,
  -1.82970744e-02f, 9.10592824e-02f, 2.50398725e-01f, -2.06618488e-01f, -1.85754687e-01f, 1.38206273e-01f, -4.25347060e-01f, -1.50962606e-01f, 2.50033468e-01f, -1.27467081e-01f,
  -1.73597876e-02f, -6.46446720e-02f, -1.75035730e-01f, 1.48936540e-01f, -1.81339905e-01f, 1.78063214e-02f, 5.57751358e-02f, 8.83843154e-02f, -2.81295657e-01f, 4.82626297e-02f,
  -1.17314912e-01f, 1.73852175e-01f, -6.83080405e-02f, 3.42856497e-02f, -2.62603879e-01f, 1.33117486e-03f, -1.02063626e-01f, 1.51757011e-02f, 1.23297662e-01f, -6.57248348e-02f,
  -1.66836716e-02f, 3.04259807e-02f, 1.56854894e-02f, 1.11943021e-01f, 7.15331547e-03f, 2.79614120e-03f, 5.52373938e-02f, -1.05241925e-01f, 1.75592080e-02f, -3.98482829e-02f,
  -2.97167171e-02f, -1.02733470e-01f, -1.61360145e-01f, -8.94784555e-03f, 3.76215614e-02f, 1.26449876e-02f, -1.27666995e-01f, -5.53196259e-02f, -1.24714948e-01f, -6.83049113e-02f,
  5.07382303e-03f, -1.05667813e-02f, 5.25422813e-03f, 2.98889130e-02f, -1.74824689e-02f, 2.50679292e-02f, -1.20539926e-02f, 1.44453719e-02f, 3.46180759e-02f, -2.42680553e-02f,
  -1.81716606e-02f, 5.00487275e-02f, 3.00376769e-02f, -4.66450155e-02f, -2.06402075e-02f, 1.33334007e-02f, -2.33178101e-02f, -2.03097723e-02f, -6.30091205e-02f, -1.85848549e-02f,
  1.05772637e-01f, -2.08522808e-02f, -1.38403960e-02f, 4.68563922e-02f, -1.54449614e-02f, 2.55512279e-02f, -3.36416289e-02f, -3.39994431e-02f, 1.90735571e-02f, -6.04570135e-02f,
  -1.86596066e-01f, -5.74224554e-02f, 1.17488503e-01f, 6.21540844e-02f, 6.67870790e-02f, -2.84770690e-02f, -1.11999270e-02f, 3.48895648e-03f, 5.29136555e-03f, 3.53585631e-02f,
  -7.48561472e-02f, -2.02203076e-02f, -1.25581905e-01f, 4.05076407e-02f, -2.27165483e-02f, -2.68326309e-02f, 1.62729470e-03f, 4.89229634e-02f, -9.41810831e-02f, -5.66377193e-02f,
  -9.04564187e-02f, -2.15626713e-02f, 7.82513618e-02f, 2.48488635e-02f, -2.53819171e-02f, -7.46242478e-02f, -3.75677831e-02f, 2.21748333e-02f, -1.86016958e-03f, -4.64919815e-03f,
  9.89724323e-02f, -6.14872813e-01f, -9.14143920e-02f, 1.70126811e-01f, 2.84122020e-01f, 1.45246387e-01f, 5.11074722e-01f, -3.93352211e-01f, -4.18946028e-01f, -3.60112548e-01f,
  2.30640769e-01f, 5.86346649e-02f, 2.76258644e-02f, -1.35866508e-01f, 4.49285299e-01f, -8.50779116e-02f, -9.54626277e-02f, 1.57969177e-01f, -8.18781927e-02f, 4.09861654e-02f,
  6.46452755e-02f, -4.51310389e-02f, 1.95832029e-01f, -3.39914143e-01f, 1.23760067e-01f, -8.62506703e-02f, 2.08364204e-01f, 1.82052016e-01f, -1.73308910e-03f, 2.11173579e-01f,
  -1.07639536e-01f, -1.50171235e-01f, 3.36790159e-02f, -1.46875873e-01f, -4.83707339e-02f, 5.28248176e-02f, 7.71397650e-02f, 2.22584128e-01f, 1.18880346e-01f, -3.69247212e-03f,
  1.09237082e-01f, 3.19731585e-03f, -8.59548077e-02f, 8.51011574e-02f, -6.83106035e-02f, -7.80941173e-02f, -5.83865382e-02f, -1.80983357e-02f, -7.67186135e-02f, 3.78409699e-02f,
  -3.27767693e-02f, -1.13126542e-02f, -4.09332616e-03f, -6.61239699e-02f, 5.86387329e-02f, 1.96046866e-02f, 1.85289998e-02f, 1.33924812e-01f, -5.56832738e-03f, -3.13648880e-02f,
  2.08184798e-03f, -6.21115230e-03f, 9.03955847e-03f, -1.19540133e-01f, 2.67093349e-02f, 1.16640935e-02f, -5.50632551e-03f, 6.50488362e-02f, 7.81885535e-03f, -4.38329987e-02f,
  -3.18720266e-02f, -2.28170305e-02f, -4.97152545e-02f, -4.62284312e-02f, 5.48954904e-02f, -4.27981168e-02f, 1.29850611e-01f, 3.43692377e-02f, -8.76686256e-03f, 1.70175508e-02f,
  -7.98458606e-03f, -1.01999063e-02f, -5.40187582e-03f, -2.55328249e-02f, -7.87967537e-03f, 2.35961229e-02f, -2.67632045e-02f, -5.24438135e-02f, 1.22855939e-02f, 1.05629608e-01f,
  -2.72745579e-01f, -4.15421307e-01f, 2.58526932e-02f, -6.70665950e-02f, -1.28894271e-02f, -3.89681570e-02f, -4.03206646e-02f, -1.24372996e-01f, -6.97859079e-02f, -9.92325991e-02f,
  -3.84802930e-02f, 8.58838707e-02f, -9.03210342e-02f, -4.17614058e-02f, -5.96353784e-05f, 2.49841646e-03f, 6.97150603e-02f, 3.64190936e-02f, 8.56906548e-02f, -3.62423025e-02f,
  -4.15453501e-02f, -9.12185106e-03f, 7.87287056e-02f, -2.93087158e-02f, -3.57142277e-02f, 1.12236008e-01f, -5.68424128e-02f, 3.49067934e-02f, 1.34207178e-02f, -9.73463524e-03f,
  5.22973120e-01f, -4.61916029e-01f, -1.79420225e-02f, 5.72478712e-01f, 3.50554198e-01f, -2.59103984e-01f, -1.78560764e-01f, 2.83022374e-01f, 3.25471252e-01f, -3.70364994e-01f,
  5.98499924e-02f, -2.57629037e-01f, -4.85848516e-01f, 2.75033563e-01f, 2.11834013e-01f, -2.91842848e-01f, 2.90756285e-01f, -4.73757945e-02f, 1.86582282e-01f, 7.95246363e-02f,
  3.30229163e-01f, 2.84140587e-01f, 1.37040049e-01f, 8.42437521e-02f, 2.21868604e-01f, 1.69235691e-01f, 1.50793150e-01f, -2.09655970e-01f, 1.70706004e-01f, -3.51673178e-02f,
  7.62770250e-02f, 1.21720679e-01f, 9.30266008e-02f, 9.40680411e-03f, 3.28073055e-02f, -7.09912702e-02f, -1.00526161e-01f, -1.34947211e-01f, 7.71149546e-02f, -6.62363693e-02f,
  -1.79838136e-01f, 6.73031956e-02f, 1.09855868e-01f, -3.26474570e-02f, -1.23495106e-02f, 1.21382780e-01f, 9.41560343e-02f, 4.34165373e-02f, 9.55352094e-03f, -2.82821972e-02f,
  2.78443042e-02f, -1.23100495e-02f, 7.49004558e-02f, -1.04352258e-01f, 4.85697500e-02f, 6.96090311e-02f, -2.72005908e-02f, -1.14159890e-01f, -9.46400389e-02f, 4.94223237e-02f,
  -2.83468259e-03f, -1.02409720e-01f, -2.44776048e-02f, 4.06913720e-02f, 3.26100029e-02f, 1.03883490e-01f, -1.02002233e-01f, -1.70565920e-03f, -6.96523190e-02f, -5.81568060e-03f,
  1.34862512e-01f, 8.39709118e-02f, 1.11063987e-01f, -4.84964438e-03f, -8.50614277e-04f, 8.16818029e-02f, 7.96145003e-04f, -4.37573297e-03f, 5.15193902e-02f, 1.05104305e-01f,
  -3.07722396e-04f, 4.32494953e-02f, -6.58960119e-02f, 4.03751619e-02f, 2.39954721e-02f, -5.03048934e-02f, 4.56981584e-02f, -5.50739318e-02f, 7.91100189e-02f, -7.66630247e-02f,
  -2.94345289e-01f, -2.37580568e-01f, 1.22813759e-02f, 1.35207893e-02f, -2.62148492e-02f, -6.28519580e-02f, 2.87021473e-02f, 3.73158641e-02f, -9.63075384e-02f, 9.73441452e-02f,
  5.19664772e-02f, 2.84719071e-03f, -1.00874275e-01f, 3.96740064e-02f, -2.69461032e-02f, -4.42442950e-03f, -4.45140190e-02f, -4.75405566e-02f, 1.91228315e-02f, -2.75693759e-02f,
  -1.35260755e-02f, -1.17490038e-01f, -7.39303455e-02f, 1.10413536e-01f, 6.17000498e-02f, -6.48548752e-02f, -1.24090421e-03f, 3.47486623e-02f, -8.24135467e-02f, -6.91098394e-03f,
  2.72840202e-01f, 5.61247230e-01f, 4.80042130e-01f, 3.64542812e-01f, -3.60971332e-01f, -5.72490394e-01f, -2.16414928e-01f, -3.20452973e-02f, 5.08284755e-02f, 1.27496168e-01f,
  -1.91930249e-01f, 5.57749569e-01f, -1.78580865e-01f, 1.72453403e-01f, -3.18326592e-01f, -2.91865170e-01f, 1.90003961e-01f, 3.62033583e-02f, -2.78034410e-03f, 3.00924957e-01f,
  1.79901019e-01f, -1.99517056e-01f, 2.60834664e-01f, -1.77492365e-01f, 1.98347434e-01f, 4.07573372e-01f, 1.56485885e-01f, -3.85965854e-02f, 3.29088837e-01f, -9.33903530e-02f,
  -1.76423028e-01f, 7.14544058e-02f, 1.56773150e-01f, 6.69118240e-02f, 1.11773424e-01f, -9.58480220e-03f, 3.15873660e-02f, -1.15858838e-01f, -3.87790985e-02f, -3.03373095e-02f,
  -4.72291466e-03f, -3.64342742e-02f, 5.03658503e-02f, -4.27324325e-02f, -2.25191377e-02f, 4.43156138e-02f, 1.09448679e-01f, 1.57891586e-01f, 1.28614977e-01f, 5.17411083e-02f,
  1.04858331e-01f, 1.22913219e-01f, 6.64246902e-02f, 1.05846412e-01f, 1.51638597e-01f, 3.70738730e-02f, 2.99397353e-02f, 1.34409800e-01f, 3.24152708e-02f, 3.14396694e-02f,
  -1.52673479e-02f, -1.35954365e-01f, -9.31877643e-02f, -2.43943501e-02f, -5.22170626e-02f, -2.04338636e-02f, -4.04652357e-02f, 1.86382923e-02f, -2.87964214e-02f, -9.20899138e-02f,
  -4.42079864e-02f, 8.99672061e-02f, -1.49714321e-01f, -6.50118478e-03f, 5.41455578e-03f, -6.87059313e-02f, 8.53253249e-03f, -9.12270322e-02f, 1.05078116e-01f, 7.14068264e-02f,
  -5.94276264e-02f, -1.06289640e-01f, 4.14616540e-02f, 1.58575065e-02f, -1.77967727e-01f, 3.74320671e-02f, 9.74842608e-02f, 1.06057329e-02f, -3.47693102e-03f, 5.25999535e-03f,
  2.69305967e-02f, 2.74490327e-01f, 1.78603992e-01f, -4.99632657e-02f, -3.46626304e-02f, -2.19138083e-03f, -7.13964403e-02f, 7.63109326e-02f, 8.92976522e-02f, -5.93988374e-02f,
  2.13537961e-02f, 2.61404198e-02f, -3.05653438e-02f, -2.64036693e-02f, -2.85080560e-02f, 9.86621007e-02f, 4.49371263e-02f, 6.14368916e-02f, 3.83204892e-02f, 1.15827926e-01f,
  3.86126041e-02f, -1.72959805e-01f, -2.70614810e-02f, 4.96067256e-02f, -1.09093299e-03f, 5.67854159e-02f, -3.44967693e-02f, 6.30771369e-02f, -2.16872315e-03f, 9.35389698e-02f,
  -1.85167640e-01f, 5.22152007e-01f, -3.93039405e-01f, 2.15337440e-01f, -2.52173960e-01f, 5.62515676e-01f, 6.64687097e-01f, -1.00092730e-02f, 2.31008366e-01f, 5.90106785e-01f,
  2.42758006e-01f, 2.05480456e-01f, 1.75745770e-01f, 4.78756994e-01f, 1.17604323e-01f, 4.14406568e-01f, 4.05046612e-01f, 3.11086118e-01f, -2.90600583e-04f, 1.89107895e-01f,
  -8.18281714e-03f, 4.28483903e-01f, -1.97882593e-01f, -1.63574889e-01f, 9.45507642e-03f, -2.43869126e-01f, -3.93395796e-02f, -2.97136456e-01f, 8.32463279e-02f, 6.46984130e-02f,
  3.15765925e-02f, 1.28552224e-02f, -2.88928561e-02f, -6.52712882e-02f, -1.27491489e-01f, -9.51818153e-02f, -1.59153286e-02f, -1.13012940e-01f, -1.27192870e-01f, -2.18352047e-03f,
  8.10472146e-02f, -3.52428108e-02f, 2.47404352e-02f, -1.15504451e-01f, -1.07137166e-01f, -1.06647231e-01f, -8.80702436e-02f, -1.75156612e-02f, -2.25520227e-02f, 2.58264467e-02f,
  -1.26834437e-01f, -1.03689343e-01f, 2.58512925e-02f, 1.39685616e-01f, -7.54849315e-02f, 4.62487377e-02f, 1.09934509e-01f, -5.56070805e-02f, 4.70459387e-02f, 7.46077448e-02f,
  3.51670608e-02f, 3.85150351e-02f, 1.59219950e-02f, -6.76435009e-02f, 1.95926167e-02f, -4.60709445e-02f, 6.39107227e-02f, -8.95835645e-03f, -4.36348394e-02f, 9.40400548e-03f,
  3.53344083e-02f, 1.72806904e-02f, 4.14980315e-02f, -7.77856214e-03f, 1.07460439e-01f, 1.67880803e-02f, -5.17461970e-02f, -4.96237865e-03f, 4.56650965e-02f, 1.23521546e-02f,
  6.11236170e-02f, 3.07492949e-02f, 4.64479662e-02f, -9.24774818e-03f, 3.68594117e-02f, -7.36504048e-02f, 8.04703310e-02f, 2.10353658e-02f, -6.21357523e-02f, 7.29363132e-03f,
  3.14969331e-01f, 4.66063887e-01f, 4.50540856e-02f, -9.57426894e-03f, -1.06371082e-02f, -1.07724806e-02f, -2.28026509e-02f, 4.75848354e-02f, 9.90946814e-02f, -4.89070127e-03f,
  -4.50257771e-02f, -1.16359461e-02f, 2.99546309e-02f, -9.84398648e-02f, 2.38778368e-02f, 2.07570165e-01f, 1.35888636e-01f, 7.27010146e-02f, 1.18830778e-01f, -6.10628426e-02f,
  1.34705296e-02f, 8.41000974e-02f, -9.79456771e-03f, -4.21897247e-02f, 6.11498952e-02f, 4.85819317e-02f, 9.96296015e-03f, -8.50248784e-02f, -7.63023198e-02f, 9.88193229e-02f,
  -3.43327135e-01f, -2.29337495e-02f, -3.34810376e-01f, -3.06863457e-01f, 2.50903249e-01f, -2.88780212e-01f, -2.27098584e-01f, -1.02948010e-01f, -2.85217375e-01f, 1.75155610e-01f,
  4.22409289e-02f, -1.08133905e-01f, 8.12509749e-03f, -3.25901210e-01f, -5.11188269e-01f, -3.59829962e-01f, -3.73294175e-01f, -2.04058334e-01f, -1.44572705e-01f, 1.51869893e-01f,
  -7.99089968e-02f, 1.19891107e-01f, -1.90546334e-01f, 3.48770410e-01f, 1.51301632e-02f, 2.36166403e-01f, 3.55275542e-01f, 1.80326387e-01f, 1.11375198e-01f, -3.54513749e-02f,
  -2.21576557e-01f, -1.47101939e-01f, -1.95978284e-02f, -5.56564480e-02f, 5.78730963e-02f, 1.19468123e-01f, -8.67925957e-03f, -4.79563186e-03f, -2.50781253e-02f, -2.00913511e-02f,
  -1.13962553e-02f, 9.01816320e-03f, -1.40326135e-02f, 4.90930863e-02f, -3.88091058e-03f, -5.12832142e-02f, -1.08407162e-01f, -6.25790581e-02f, -2.99071968e-02f, -4.77697626e-02f,
  -1.46898255e-01f, -2.81036906e-02f, -5.88897467e-02f, 8.15569703e-03f, -1.78797282e-02f, -2.33363081e-03f, 2.86465343e-02f, 1.36107847e-01f, -1.29356325e-01f, 1.12100085e-02f,
  7.63118714e-02f, 8.13408867e-02f, 9.49734449e-03f, -1.74922094e-01f, 9.44901351e-03f, 4.07718820e-03f, -5.83874956e-02f, -1.18383961e-02f, 2.46360968e-03f, 1.27248354e-02f,
  3.26578729e-02f, -1.31640481e-02f, -5.29259592e-02f, 9.13443789e-03f, 4.64696810e-02f, -7.51662478e-02f, -2.51357909e-02f, 2.44720932e-02f, 7.39615858e-02f, -1.91131607e-01f,
  -3.46896127e-02f, -1.63890491e-03f, 8.12237784e-02f, -1.94610134e-02f, -1.36993855e-01f, 1.53966039e-01f, 1.02237858e-01f, -3.71005014e-02f, -6.64301366e-02f, -6.85753301e-02f,
  1.20672762e-01f, 1.87362671e-01f, 6.85772672e-03f, 5.53686731e-02f, -3.23585644e-02f, -7.24320784e-02f, -1.96345076e-01f, -2.10154504e-02f, 1.26620836e-03f, 2.17270125e-02f,
  1.59978494e-01f, 4.82004508e-02f, 5.91846593e-02f, -1.52819296e-02f, -2.88801594e-03f, 1.37830228e-01f, 1.17162585e-01f, 7.48124868e-02f, -1.71019398e-02f, 6.80179223e-02f,
  1.23137526e-01f, 1.14441223e-01f, 5.27478196e-03f, 2.15337500e-02f, 4.11106795e-02f, 1.23507842e-01f, 4.91639599e-02f, 7.13508949e-02f, -1.27639696e-02f, -7.32964464e-03f,
  -2.59687901e-01f, 2.16274858e-01f, -1.42500445e-01f, -7.03748763e-02f, 1.03580646e-01f, -1.53053984e-01f, -4.31111343e-02f, 7.25234821e-02f, -1.61263391e-01f, 2.88709015e-01f,
  -9.22728181e-02f, -5.02974913e-02f, -1.72531575e-01f, -1.34631768e-01f, -6.08272612e-01f, -3.75847727e-01f, -3.00539702e-01f, -3.44262272e-02f, -2.36222371e-01f, 1.57918800e-02f,
  -1.98622897e-01f, -7.55062997e-02f, -2.23672360e-01f, 2.79303998e-01f, 2.65310585e-01f, 1.73835516e-01f, 1.31098613e-01f, 1.82958812e-01f, 9.06037390e-02f, -4.23618257e-02f,
  8.70378613e-02f, -8.29628408e-02f, 1.05100259e-01f, 6.32005259e-02f, -2.20784452e-02f, 1.52341530e-01f, 2.60257214e-01f, 8.90533999e-03f, -6.36247322e-02f, -1.44734234e-01f,
  1.16482697e-01f, -5.29458188e-02f, -5.01636378e-02f, -8.57047364e-02f, 4.88401651e-02f, -5.33202849e-02f, -8.56907815e-02f, 4.24367338e-02f, -6.73286319e-02f, 1.78117342e-02f,
  -7.96363652e-02f, -3.98988128e-02f, 1.26938671e-02f, -4.47296537e-02f, -1.11900717e-01f, -5.37710786e-02f, -6.29319474e-02f, 1.81721542e-02f, 7.36981770e-03f, -1.01368256e-01f,
  4.01401632e-02f, 6.77817687e-02f, -5.16725518e-02f, 4.42778617e-02f, -9.02174860e-02f, 7.23612532e-02f, -1.57719068e-02f, -1.59951497e-03f, -6.53915629e-02f, -1.14624593e-02f,
  -7.21852928e-02f, 3.26560512e-02f, -2.14108266e-03f, 5.30141778e-02f, 3.73666137e-02f, 3.31490897e-02f, 4.06628177e-02f, -1.46062535e-04f, -7.33058304e-02f, -3.64673100e-02f,
  7.21917450e-02f, 2.61438172e-02f, -7.48360297e-03f, 5.71644641e-02f, -1.88458189e-02f, -5.96732572e-02f, 5.23541123e-02f, 3.17417346e-02f, -3.22472863e-02f, 3.83750983e-02f,
  6.56789243e-02f, 4.21969108e-02f, 8.39894172e-03f, 3.53378132e-02f, -1.50185321e-02f, 2.25160979e-02f, 3.18275653e-02f, 6.44240109e-03f, -1.97728630e-02f, 3.43607962e-02f,
  4.64264825e-02f, -1.29000694e-02f, 1.43451735e-01f, -5.90171665e-02f, -8.19577128e-02f, 5.33342026e-02f, 2.38279738e-02f, -5.60518913e-03f, 1.00179955e-01f, 2.37616338e-02f,
  1.05165757e-01f, -5.99161685e-02f, -6.30164072e-02f, 4.85372804e-02f, 8.67171064e-02f, 4.78555746e-02f, 3.44358720e-02f, -2.25992291e-03f, 5.20985713e-03f, -1.44253355e-02f,
  1.28032446e-01f, -2.64673263e-01f, -1.20889433e-01f, -3.39461803e-01f, -9.41113085e-02f, -1.63113028e-02f, 2.90126633e-02f, -3.78231049e-01f, -2.19067112e-01f, -5.69958426e-02f,
  -2.05458879e-01f, 1.38682857e-01f, 3.42082918e-01f, -2.95594424e-01f, 2.66727448e-01f, 3.10198158e-01f, -3.55289280e-01f, -1.00173183e-01f, -1.05365984e-01f, -2.70199209e-01f,
  -2.15920538e-01f, -2.65677273e-01f, 7.92548805e-02f, -2.44284809e-01f, -2.22645864e-01f, -1.32358089e-01f, 3.10258437e-02f, -2.27677058e-02f, -2.94391364e-01f, -1.34535702e-02f,
  -5.32922186e-02f, -2.69521121e-02f, 9.42453444e-02f, 1.77232355e-01f, -4.94647399e-02f, 9.56967548e-02f, 9.26799402e-02f, 2.24717215e-01f, -1.90584715e-02f, -3.06579154e-02f,
  8.95819440e-02f, 7.57051483e-02f, -8.02434906e-02f, 1.67597845e-01f, -1.76155642e-01f, -8.65217298e-02f, -2.23912094e-02f, -7.72230104e-02f, -4.45228629e-02f, 7.63908550e-02f,
  -2.35681771e-04f, -5.17864414e-02f, -7.96879306e-02f, -2.70586833e-02f, -1.06074763e-02f, 2.72523798e-02f, 1.00237124e-01f, 1.86120301e-01f, -1.23910345e-01f, -7.38578737e-02f,
  8.08290020e-02f, 6.17606118e-02f, 4.19953726e-02f, -4.11736779e-02f, -1.17711369e-02f, -2.72326041e-02f, -5.37783839e-02f, 3.26496363e-02f, -3.24691795e-02f, 1.97650194e-02f,
  -4.29857522e-02f, -5.37921265e-02f, 3.51866111e-02f, 6.62208572e-02f, -5.57403490e-02f, 1.10420898e-01f, 1.28983334e-01f, -1.30355489e-02f, -1.93222553e-01f, -6.31823111e-03f,
  8.09833314e-03f, -7.36478891e-04f, -4.65956405e-02f, 1.57933345e-03f, -3.85477543e-02f, 1.39236763e-01f, -7.62102306e-02f, 2.01934557e-02f, -1.12839282e-01f, 4.85019647e-02f,
  -9.54071209e-02f, -1.52732834e-01f, -1.99928079e-02f, 4.27160375e-02f, 1.66797891e-01f, 9.17430967e-03f, -1.14784194e-02f, -1.73212327e-02f, -1.45791531e-01f, -9.35221389e-02f,
  -1.20090052e-01f, 3.45654693e-03f, -5.61086014e-02f, -1.66915245e-02f, -1.49189726e-01f, -9.64320004e-02f, -3.27501781e-02f, -7.10783601e-02f, -5.66768646e-03f, -1.37493938e-01f,
  -2.59525771e-03f, 2.06782669e-02f, 1.44898236e-01f, -1.04472472e-03f, -2.53534666e-03f, -2.54083723e-02f, -1.27988085e-02f, 8.88224095e-02f, -5.89934140e-02f, -1.03494823e-01f,
  -4.71996889e-02f, -4.86423038e-02f, -5.24425626e-01f, 1.31707102e-01f, 1.91691443e-01f, 6.87769800e-02f, -2.39293441e-01f, 2.12133363e-01f, -3.15823525e-01f, 1.70811296e-01f,
  3.07739884e-01f, 2.26225201e-02f, -1.96718544e-01f, 5.30060887e-01f, 4.12055850e-01f, -2.10560992e-01f, 3.68342787e-01f, 1.19594239e-01f, -1.21572219e-01f, 1.91738978e-01f,
  6.12335913e-02f, 5.46700716e-01f, 1.43990979e-01f, 3.75808060e-01f, 1.57891363e-01f, 1.81805529e-02f, 3.98754060e-01f, -1.41477421e-01f, 4.90262955e-01f, 2.31680095e-01f,
  -4.72205169e-02f, -8.52501914e-02f, -5.01071811e-02f, -1.52026668e-01f, 8.16579349e-03f, -5.83214797e-02f, -6.98644817e-02f, -2.32172981e-02f, 2.36265771e-02f, -2.16153078e-02f,
  -1.50038391e-01f, 1.79510452e-02f, 3.16576138e-02f, 1.32124722e-02f, -2.33406201e-02f, 2.21033152e-02f, -6.10156357e-02f, -2.57830936e-02f, -4.65408415e-02f, -5.02448454e-02f,
  -1.42196238e-01f, 1.39904097e-02f, -6.36200700e-03f, 1.46300241e-03f, -2.98926402e-02f, 8.83218497e-02f, -4.95865867e-02f, -8.35767239e-02f, -6.50266558e-02f, 4.39209156e-02f,
  3.71454060e-02f, -1.29512474e-01f, -1.74665470e-02f, -2.29371693e-02f, 1.01364031e-02f, 5.15077598e-02f, 1.24334402e-01f, 8.48977640e-02f, -3.44411060e-02f, 5.56998141e-02f,
  1.93925928e-02f, 6.52883723e-02f, -9.05921962e-03f, -3.50938886e-02f, 2.09078586e-04f, -7.81393796e-02f, -1.64257046e-02f, 5.40962741e-02f, -3.62176113e-02f, 8.34410936e-02f,
  2.63171699e-02f, 3.84346694e-02f, 9.74215660e-03f, -1.61762889e-02f, -2.48642061e-02f, 2.12988872e-02f, 1.06432229e-01f, -7.76711712e-03f, -3.55049223e-02f, -4.24494483e-02f,
  1.27902582e-01f, 1.72810987e-01f, -4.51028254e-03f, 3.07332855e-02f, -3.57051082e-02f, 9.78175551e-02f, -4.40899376e-03f, 4.52934904e-03f, 3.97780724e-02f, -6.23524189e-02f,
  6.45271549e-03f, 2.22007837e-03f, -3.55300941e-02f, 4.50797938e-02f, 3.56936529e-02f, -1.06986333e-03f, -1.58937257e-02f, 2.88672019e-02f, 1.28785715e-01f, 1.49940848e-01f,
  2.09296104e-02f, -5.74072218e-03f, -6.06611110e-02f, 1.84278172e-02f, 7.79316276e-02f, 1.99001078e-02f, 1.82548109e-02f, -1.16133085e-02f, 9.83525068e-03f, -3.00035886e-02f,
  -1.12953007e+00f, 2.32964754e-01f, -1.18610241e-01f, 3.22723687e-02f, -1.27382100e-01f, 5.31113297e-02f, 9.98763070e-02f, -8.51439685e-02f, -1.97457671e-01f, 2.49395266e-01f,
  2.06076041e-01f, -2.43058324e-01f, 1.31427497e-01f, 3.62126082e-01f, -2.69647747e-01f, 2.43232489e-01f, 3.19120437e-02f, -1.18549630e-01f, -4.85426607e-03f, -1.55937463e-01f,
  -8.53322297e-02f, 2.49334186e-01f, 4.90614735e-02f, 1.87007338e-01f, -4.62014079e-02f, -9.13667828e-02f, 1.41132064e-02f, 1.49774671e-01f, 1.16477661e-01f, 3.25267427e-02f,
  -2.52855688e-01f, -3.16914380e-01f, -1.81859419e-01f, -8.87345672e-02f, -1.01094663e-01f, -3.46813686e-02f, -1.11636452e-01f, -6.70705223e-03f, -7.37065747e-02f, -7.85075724e-02f,
  -6.53163642e-02f, -1.08282473e-02f, 1.56835420e-03f, -3.82627435e-02f, -1.25972003e-01f, -1.78939558e-03f, 1.00634187e-01f, -2.40918226e-03f, 6.45907130e-03f, 1.02788404e-01f,
  7.69493356e-02f, 1.63994655e-02f, 1.28140161e-02f, 1.01288967e-01f, 4.10587117e-02f, 1.38085306e-01f, 9.08219963e-02f, -7.64542595e-02f, -1.56446144e-01f, -4.75066900e-02f,
  4.18001525e-02f, -6.39790297e-02f, 6.70834780e-02f, -4.45700735e-02f, 4.67714481e-02f, 4.78577875e-02f, 4.20948258e-04f, -5.39305340e-03f, -1.67486034e-02f, 5.29603623e-02f,
  -3.47767398e-02f, -5.81297427e-02f, -6.35959283e-02f, 5.80220073e-02f, 2.69726869e-02f, -5.68642095e-02f, 1.99846774e-02f, -8.01331550e-02f, -7.40960590e-04f, -6.37876093e-02f,
  2.25265957e-02f, -2.70853620e-02f, 6.57055201e-03f, -7.96376116e-05f, -6.51595965e-02f, 6.34675846e-02f, 3.75040248e-02f, 3.80891487e-02f, -2.78150570e-02f, -8.65525007e-02f,
  -5.27904630e-01f, -4.89779860e-01f, 8.31421018e-02f, -1.56442448e-01f, -8.27437043e-02f, -1.54172620e-02f, 6.80562854e-02f, 1.70045178e-02f, -1.05498746e-01f, -7.90073276e-02f,
  -9.13563296e-02f, -7.62019008e-02f, -4.62441705e-02f, -2.98614502e-02f, -8.17741826e-03f, 1.02623813e-01f, -2.98958812e-02f, 6.70447247e-04f, -9.97396037e-02f, -4.14339378e-02f,
  -5.00115566e-02f, -5.53432405e-02f, 8.48492682e-02f, -2.97799986e-03f, 8.42601992e-03f, 1.33120352e-02f, -1.58479854e-01f, 4.79219332e-02f, -1.12572880e-02f, 3.36750261e-02f,
  2.35212222e-01f, 1.33537382e-01f, 2.04809923e-02f, 7.72141339e-03f, 4.38005775e-02f, -3.01040202e-01f, -1.03022493e-01f, -1.12500660e-01f, 1.00811444e-01f, 2.47569457e-01f,
  -3.15836854e-02f, 3.03089589e-01f, -5.43191172e-02f, -1.00814570e-02f, -5.92531323e-01f, -3.23925465e-01f, -3.95052880e-01f, -5.98891266e-02f, -6.66394364e-03f, -1.82805769e-02f,
  -1.61465064e-01f, -1.66827202e-01f, -2.59066075e-01f, -1.14778452e-01f, 1.42770126e-01f, 1.55684531e-01f, -2.42008105e-01f, 1.03979483e-01f, -1.32541046e-01f, -2.14816108e-01f,
  1.89440772e-02f, 2.33934775e-01f, 1.79477319e-01f, 3.83236445e-02f, 4.36266810e-02f, 5.30199669e-02f, -1.01054803e-01f, -3.19571495e-02f, 7.63820037e-02f, 2.31295675e-02f,
  1.11042351e-01f, -7.56755248e-02f, 4.24332246e-02f, 3.66918221e-02f, 1.39969975e-01f, 2.66095195e-02f, -8.98523182e-02f, 3.01071592e-02f, 8.91574919e-02f, -1.23828202e-01f,
  4.87350039e-02f, -1.87541766e-03f, 5.20149767e-02f, -5.96703403e-02f, -6.64354488e-02f, 2.23586820e-02f, -4.50438857e-02f, -6.00863434e-02f, -3.31015810e-02f, 2.37255311e-03f,
  -3.37173343e-02f, -7.60995038e-03f, 2.82988772e-02f, 1.46548107e-01f, 7.66792744e-02f, -4.73889820e-02f, -1.08890049e-02f, -2.58733779e-02f, 8.03692788e-02f, -5.09098805e-02f,
  -3.20076309e-02f, 5.06002344e-02f, 3.71309705e-02f, -6.50824606e-02f, 1.64759122e-02f, 1.56975120e-01f, -4.03354578e-02f, -3.32111754e-02f, -9.91329476e-02f, 3.80915478e-02f,
  1.12649389e-02f, -1.38207525e-01f, 9.25191641e-02f, -1.07027784e-01f, -4.73377518e-02f, 3.36198248e-02f, -4.12024818e-02f, 4.47067060e-02f, -5.47662750e-02f, -8.75465050e-02f,
  -9.00458395e-02f, -1.76552981e-01f, 1.08240843e-01f, 4.65623736e-02f, 4.34767315e-03f, 9.48780775e-02f, -1.16427280e-01f, -1.26263462e-02f, -1.17902651e-01f, -3.77332903e-02f,
  -5.31000681e-02f, 6.87007755e-02f, 1.19506037e-02f, -2.28564553e-02f, -5.87209985e-02f, -8.28556791e-02f, -9.76088867e-02f, 3.07251103e-02f, -2.34064367e-02f, -7.94118345e-02f,
  1.05596229e-01f, 2.93066297e-02f, 9.23025906e-02f, 5.48332930e-02f, 7.15439965e-04f, -6.50258660e-02f, 6.19499497e-02f, -2.02380028e-02f, -5.65355383e-02f, -1.06005676e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  3.36117536e-01f, 3.05526227e-01f, 3.24005157e-01f, 8.32660869e-02f, 4.21126068e-01f, 2.95218349e-01f, 1.74575016e-01f, 2.51875997e-01f, 1.24237932e-01f, 3.93050909e-01f,
  3.75195026e-01f, 1.89216644e-01f, 3.08564693e-01f, 4.48867440e-01f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -4.58208807e-02f, 7.05822185e-02f, -8.45521614e-02f, -1.40920579e-01f, -5.68287298e-02f, -2.91796386e-01f, -4.57240939e-02f, 2.97957081e-02f, -1.42513245e-01f, 1.55132506e-02f,
  1.09467171e-02f, 2.91704118e-01f, -6.00940026e-02f, 2.16176063e-01f, -9.72373113e-02f, -1.99163511e-01f, -1.09539613e-01f, 5.62468804e-02f, 1.67900711e-01f, -2.16093822e-03f,
  2.27646306e-01f, 3.22754174e-01f, -2.51600564e-01f, -1.98640555e-01f, -2.15244859e-01f, -1.93433493e-01f, -1.27025023e-01f, -1.98157594e-01f, 1.02368616e-01f, -2.90932089e-01f,
  2.23626882e-01f, 3.50921936e-02f, -1.16668031e-01f, -2.13837609e-01f, -2.34924167e-01f, -5.42530678e-02f, 4.63973321e-02f, 5.83784422e-03f, 1.31449252e-01f, 4.23857532e-02f,
  -1.37807146e-01f, 1.68993846e-01f, 2.78962612e-01f, 3.61813232e-02f, -1.77750915e-01f, 1.42981842e-01f, -3.10528666e-01f, -2.42732033e-01f, 7.77751580e-02f, 9.79574323e-02f,
  3.70903969e-01f, -2.94873744e-01f, 5.25210313e-02f, 2.82177091e-01f, 3.55076969e-01f, -2.56655067e-01f, -2.77924448e-01f, 2.60246471e-02f, 1.39087871e-01f, 1.72989845e-01f,
  1.04593970e-01f, -1.82168454e-01f, 2.33663544e-01f, 7.49748871e-02f, -9.91571993e-02f, -7.49910250e-02f, -2.35224254e-02f, 8.92893877e-03f, 6.48014843e-02f, -2.22218528e-01f,
  1.96197316e-01f, 1.31156193e-02f, -4.53008413e-02f, 2.07608446e-01f, -1.04465432e-01f, 3.13227803e-01f, 7.68653750e-02f, 1.28174707e-01f, -1.17056906e-01f, -1.56538934e-01f,
  -2.80750692e-01f, -4.62765060e-02f, -7.12448880e-02f, -1.09221235e-01f, 1.65861815e-01f, -1.04468174e-01f, 1.23316087e-01f, 9.79889482e-02f, 1.71139330e-01f, -3.84851217e-01f,
  -3.95113885e-01f, -1.68658957e-01f, 1.04011685e-01f, -1.04146354e-01f, 4.98684160e-02f, -1.19180024e-01f, 1.67521998e-01f, 2.03746408e-01f, -1.30991831e-01f, 1.84862465e-01f,
  -2.43688468e-02f, 1.78246379e-01f, 1.35722250e-01f, -8.94819275e-02f, 2.50283442e-02f, -1.92249417e-01f, -1.64253861e-01f, -1.88210100e-01f, 1.67859066e-02f, -1.95251316e-01f,
  1.19048640e-01f, -7.72814527e-02f, 3.45379859e-01f, 9.93069559e-02f, 1.05312862e-01f, 1.73258558e-02f, -2.69021451e-01f, -1.62508667e-01f, -1.04009412e-01f, -2.62002528e-01f,
  -2.16526926e-01f, 2.83923328e-01f, 2.81891406e-01f, 1.42483041e-01f, -2.31105328e-01f, 3.65925193e-01f, -3.63894612e-01f, -1.89644739e-01f, 3.94152813e-02f, -2.04170290e-02f,
  -4.68482673e-02f, -1.08300835e-01f, 2.57353969e-02f, 8.33234712e-02f, 9.64792073e-02f, -9.53879058e-02f, 1.23509742e-01f, -1.22255579e-01f, 2.29077607e-01f, -1.54353008e-01f,
  2.16429353e-01f, -8.44031498e-02f, -4.47918214e-02f, -8.64896178e-02f, 1.40814751e-01f, 2.51951396e-01f, -2.14388356e-01f, 2.10380077e-01f, -1.85582042e-01f, -2.73323447e-01f,
  -2.61857629e-01f, -3.31157357e-01f, 2.68226713e-01f, 2.73398668e-01f, -2.06929427e-02f, -2.71052103e-02f, 6.32431433e-02f, 1.50598034e-01f, -6.77547157e-02f, -1.37022078e-01f,
  2.71554768e-01f, 1.28484800e-01f, -7.37769380e-02f, 1.76084638e-02f, -1.18835801e-02f, 1.23520665e-01f, -8.11911002e-02f, -1.26055107e-01f, -2.25906968e-02f, -2.43299112e-01f,
  -3.17639917e-01f, -2.27490962e-01f, 5.51950149e-02f, -1.83480591e-01f, 2.36870393e-01f, -9.16040465e-02f, 1.96465850e-01f, 1.98654786e-01f, -2.42350131e-01f, 1.47154093e-01f,
  -2.75384903e-01f, -1.71997666e-01f, -2.86334276e-01f, 3.44641447e-01f, -3.43407035e-01f, 3.84441972e-01f, -2.46381238e-01f, -2.01031063e-02f, -7.22151026e-02f, 4.48828712e-02f,
  -5.64202899e-03f, 2.18911655e-02f, 2.59444833e-01f, 1.42515615e-01f, 2.34481916e-01f, 2.22753033e-01f, -4.87969369e-02f, -5.05910292e-02f, 7.81354159e-02f, 1.94620132e-01f,
  -6.41239528e-03f, -3.92438978e-01f, -1.37177765e-01f, -3.76648433e-03f, 7.92674050e-02f, 5.28312437e-02f, 1.89981773e-01f, -6.83855861e-02f, -1.10472828e-01f, 4.09773402e-02f,
  1.50872946e-01f, -2.81802922e-01f, -3.46020684e-02f, -6.32299557e-02f, -1.15422733e-01f, 4.57464643e-02f, 1.32206887e-01f, -2.01517269e-01f, 1.61884725e-01f, 1.84286311e-01f,
  -2.44382977e-01f, -3.03410023e-01f, -6.92585111e-02f, 2.68769443e-01f, 1.14873704e-02f, -9.70583502e-03f, 3.37504387e-01f, 6.73192665e-02f, 7.36548901e-02f, -1.46396339e-01f,
  7.26047307e-02f, -2.90045422e-02f, 1.63883701e-01f, -1.06787756e-02f, -3.54447424e-01f, 9.74591225e-02f, -5.55427233e-03f, -1.03197142e-01f, 2.42918715e-01f, 3.13939512e-01f,
  -3.09118778e-01f, -3.43429625e-01f, -3.17293972e-01f, 1.92825347e-02f, 4.75245435e-03f, -1.39963523e-01f, -5.08111864e-02f, 2.67189682e-01f, 4.44088876e-01f, -1.31068781e-01f,
  -6.48332387e-02f, -1.90970093e-01f, -1.21513337e-01f, -1.09477744e-01f, -3.57315809e-01f, 1.63438339e-02f, -1.44226775e-01f, -2.98818052e-02f, -1.88813388e-01f, 7.11673349e-02f,
  5.60703203e-02f, 1.45908207e-01f, 1.73854753e-01f, -1.48356622e-02f, -1.08315453e-01f, 1.86081782e-01f, 2.98583627e-01f, 4.35799733e-02f, -1.26487911e-01f, 4.53781411e-02f,
  -2.95365542e-01f, -2.08870858e-01f, 2.22456232e-02f, 9.74642262e-02f, 2.93438882e-01f, -8.70787203e-02f, 2.92533636e-02f, 2.02205300e-01f, 2.82719165e-01f, -3.09251189e-01f,
  -3.71533811e-01f, 2.51390010e-01f, 2.15450153e-02f, 4.51122150e-02f, 2.78137177e-01f, -1.64439976e-01f, 2.31482908e-01f, -4.93740961e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  3.08072299e-01f, 4.92337435e-01f, 2.26269245e-01f, 4.41716202e-02f, 8.36996064e-02f, 3.59317698e-02f, 2.38277733e-01f, 3.83779347e-01f, 7.24364072e-02f, -5.55543303e-01f,
  -5.14311135e-01f, 1.12521194e-01f, -1.13156885e-01f, -5.63668981e-02f, 6.30937397e-01f, -3.98363099e-02f, -3.33774805e-01f, -3.12161967e-02f, 2.16902778e-01f, 1.82943270e-01f,
  6.27498746e-01f, 4.34694976e-01f, -4.31372672e-01f, 4.90620404e-01f, -3.49700563e-02f, 4.41374183e-01f, -2.86290139e-01f, -3.02280277e-01f, 2.65364021e-01f, -5.44223547e-01f,
  2.03632452e-02f, 5.72184205e-01f, 1.66925475e-01f, 1.88510776e-01f, 3.44617605e-01f, 5.33887625e-01f, 2.33067393e-01f, 2.67153978e-01f, 4.69568670e-01f, 2.99669772e-01f,
  5.10960221e-01f, 3.50047767e-01f, -1.62287176e-01f, 2.50441164e-01f, -4.29361820e-01f, -4.20993716e-01f, -2.68220995e-02f, 3.32189292e-01f, -1.72336310e-01f, -5.10428369e-01f,
  3.17889363e-01f, 8.55959058e-02f, -3.34013581e-01f, -5.76076321e-02f, 6.96165144e-01f, 3.79810274e-01f, 1.31761387e-01f, 1.94575675e-02f, 6.13447368e-01f, 1.58552900e-02f,
  2.11820483e-01f, 3.63962084e-01f, -6.19304001e-01f, -3.18394363e-01f, 2.74045736e-01f, 4.15194482e-01f, 2.47295618e-01f, 3.12220007e-01f, 1.80687606e-01f, -9.93041992e-02f,
  1.43600330e-01f, 1.93065405e-01f, 1.84333503e-01f, -5.50640047e-01f, -3.43570530e-01f, 3.28421444e-01f, 2.54757166e-01f, 6.49126828e-01f, -3.52046266e-02f, -5.53453937e-02f,
  6.18791282e-02f, 3.28555614e-01f, 8.09062272e-02f, 2.04354301e-02f, 3.45048517e-01f, -3.16666901e-01f, 5.62629402e-01f, 5.33232331e-01f, 2.49045670e-01f, -7.54216552e-01f,
  3.03702336e-02f, 5.54218888e-01f, -2.55358666e-01f, 2.05212086e-01f, 4.32884246e-01f, 3.33097756e-01f, 2.41979286e-01f, 3.67893040e-01f, 2.17786580e-01f, 2.13612109e-01f,
  2.98292875e-01f, 4.11668688e-01f, 1.86158389e-01f, -7.14872926e-02f, 2.84161299e-01f, -1.52493134e-01f, -6.82902575e-01f, -2.47968212e-01f, -3.23652267e-01f, -1.10262848e-01f,
  3.37689936e-01f, 4.67684418e-01f, 5.43515146e-01f, -7.80212805e-02f, -2.03753665e-01f, 1.54170871e-01f, -2.99764246e-01f, -2.82710284e-01f, 5.18055260e-01f, 5.18888593e-01f,
  -6.00476623e-01f, 2.19932988e-01f, 2.44134784e-01f, 3.26798052e-01f, 2.53003510e-03f, 2.81575441e-01f, -4.22308117e-01f, 1.24391004e-01f, 1.27422571e-01f, 3.08049560e-01f,
  1.59794554e-01f, 1.36516765e-01f, 2.46215284e-01f, 3.71352822e-01f, 3.58255506e-01f, 2.04022706e-01f, 3.59550714e-01f, -2.28630334e-01f, 4.55527902e-01f, -4.46944743e-01f,
  4.90959466e-01f, -3.46185595e-01f, 1.00744143e-01f, -1.30757749e-01f, -1.47750694e-02f, 2.69279689e-01f, -2.00830966e-01f, 4.30903137e-01f, -1.35193095e-02f, -4.12161648e-01f,
  -4.15902168e-01f, -4.06427085e-01f, 7.86976695e-01f, 7.78181076e-01f, -8.29222500e-02f, 7.63223693e-02f, 1.96898684e-01f, 1.30873188e-01f, -8.28233510e-02f, 1.25359118e-01f,
  -3.79270986e-02f, 6.48552924e-02f, 3.49348098e-01f, 1.54128447e-01f, 2.41233200e-01f, 2.18665615e-01f, 1.57081589e-01f, 1.00996457e-01f, 3.61116022e-01f, 1.82908610e-01f,
  -2.06964523e-01f, -1.05541803e-01f, 3.06229740e-01f, 2.97488123e-01f, -7.05562979e-02f, 3.14587504e-01f, -9.54336897e-02f, 5.47819324e-02f, -3.94011497e-01f, -7.97896609e-02f,
  5.72406501e-02f, -5.36127329e-01f, 7.47656047e-01f, -1.70298502e-01f, 4.04213160e-01f, -4.86289114e-01f, -1.67456880e-01f, 3.23960900e-01f, 4.00112987e-01f, -4.47915822e-01f,
  -6.52883127e-02f, 4.55532730e-01f, 2.61963874e-01f, -1.55083448e-01f, -1.32661521e-01f, 1.46189228e-01f, 5.18188849e-02f, 9.12313238e-02f, 3.24416161e-02f, -7.57808387e-02f,
  9.12584886e-02f, 1.67837307e-01f, 5.40763676e-01f, -2.86667287e-01f, 2.04771459e-01f, -5.56352176e-02f, -4.12391067e-01f, -2.03131303e-01f, 1.88144907e-01f, 2.77625829e-01f,
  2.94532925e-01f, 5.88508964e-01f, -1.48489282e-01f, 1.68868452e-02f, -1.71175942e-01f, 2.78165609e-01f, 3.28717947e-01f, 5.79623818e-01f, 2.53879279e-01f, 3.62488747e-01f,
  -7.97212943e-02f, 6.66307747e-01f, 7.24752247e-01f, -2.05752105e-01f, 2.05719694e-02f, -1.31815284e-01f, -3.14989337e-03f, -9.59724709e-02f, 1.39004067e-01f, 2.63306081e-01f,
  7.60721639e-02f, -2.12623224e-01f, 3.88852507e-02f, 4.54100490e-01f, -4.91114169e-01f, 1.19598366e-01f, -3.50600779e-01f, -3.98086071e-01f, -5.91667020e-04f, 4.13806826e-01f,
  1.10524103e-01f, -4.77959514e-01f, -2.65632644e-02f, 5.07019877e-01f, 1.90727398e-01f, 2.86075473e-01f, 5.37265718e-01f, 7.03165889e-01f, 8.52452964e-03f, 1.09985001e-01f,
  -2.53018625e-02f, -2.65847504e-01f, 2.26198182e-01f, 5.75091302e-01f, -3.99957865e-01f, -8.55289027e-02f, 2.76024699e-01f, 4.74464893e-01f, 2.39771884e-02f, 2.06181347e-01f,
  5.41961312e-01f, 3.65825176e-01f, 5.25071442e-01f, 3.00359130e-01f, 3.07629049e-01f, 9.52580869e-02f, 4.08644415e-02f, 2.26814464e-01f, 1.62315503e-01f, -1.54840574e-01f,
  -3.10043335e-01f, -3.67887408e-01f, 9.30974707e-02f, 6.92809880e-01f, 5.99867515e-02f, 2.84184694e-01f, 2.24059522e-01f, 1.93088964e-01f, 2.37951100e-01f, -6.17032766e-01f,
  -5.57775915e-01f, 7.88458109e-01f, -5.65483689e-01f, -4.22054321e-01f, 9.22229409e-01f, 1.04519740e-01f, 8.33895504e-01f, -7.16024339e-02f, 2.68815041e-01f, 4.82722402e-01f,
  2.40517303e-01f, 8.58151987e-02f, 2.82991737e-01f, -1.03703201e-01f, 4.57894862e-01f, 2.54171908e-01f, 2.35793442e-01f, -3.65033150e-01f, -9.36118215e-02f, 2.91186839e-01f,
  1.30357206e-01f, 3.12118620e-01f, -6.64490387e-02f, -1.93862408e-01f, -1.59224033e-01f, 2.89246798e-01f, 5.26571989e-01f, -6.17476776e-02f, 5.88232756e-01f, 1.73095360e-01f,
  2.75533181e-02f, -5.40363133e-01f, 3.74292314e-01f, -1.56787455e-01f, 4.62870896e-01f, 3.32736552e-01f, 2.61120796e-01f, -7.88216069e-02f, 1.10736571e-01f, 3.73858690e-01f,
  -2.59832609e-02f, 1.41565762e-02f, -7.14626461e-02f, -1.56420693e-01f, -2.28808939e-01f, 1.17504723e-01f, -2.74930179e-01f, -1.60204574e-01f, 2.43556220e-02f, 2.04633191e-01f,
  6.50036037e-02f, -3.49815547e-01f, -9.26613808e-02f, -1.16121717e-01f, -6.70003146e-02f, 4.26476561e-02f, 3.67662013e-01f, 3.70436907e-02f, 1.98582143e-01f, 5.36398411e-01f,
  5.45656204e-01f, 6.13501668e-01f, -8.99420902e-02f, 2.46264622e-01f, -1.51259914e-01f, 6.42514229e-02f, 2.79806465e-01f, 3.96342069e-01f, 1.81430250e-01f, 6.70102775e-01f,
  4.64572638e-01f, 4.82242882e-01f, 3.22720110e-01f, 3.68452109e-02f, 2.89235562e-01f, 4.44748282e-01f, 1.22963548e-01f, 3.84036124e-01f, 1.48924008e-01f, 3.40601146e-01f,
  2.34521747e-01f, -6.77909106e-02f, 3.97623450e-01f, -4.59976196e-01f, -1.33406401e-01f, -1.72917008e-01f, 2.94437945e-01f, 9.09832120e-02f, -2.03841701e-01f, -1.22258915e-02f,
  2.00275511e-01f, -4.42763329e-01f, -3.50293756e-01f, 2.13177372e-02f, 2.25009337e-01f, 1.08768709e-01f, 8.23782459e-02f, 7.04050601e-01f, 4.22449529e-01f, 3.84565175e-01f,
  -3.54010910e-02f, -5.79642892e-01f, 1.36756510e-01f, 3.01814735e-01f, 2.85427213e-01f, 3.34390193e-01f, 3.08176309e-01f, 2.38203108e-01f, -3.74801718e-02f, 2.79441714e-01f,
  4.97329384e-02f, 5.78310303e-02f, 1.53884456e-01f, -3.27142239e-01f, -3.59043449e-01f, -2.85921991e-01f, -3.78019720e-01f, -2.26998135e-01f, 5.69050372e-01f, 4.38112915e-01f,
  2.03980669e-01f, -3.89373571e-01f, 3.44783306e-01f, -1.13055125e-01f, 7.19870776e-02f, 4.49757963e-01f, -1.71998620e-01f, 5.21991193e-01f, -1.96320623e-01f, 2.33547196e-01f,
  7.23551035e-01f, 3.00382704e-01f, -1.63812265e-01f, 1.02961995e-01f, -4.67532545e-01f, 4.14877951e-01f, 1.21815801e-01f, 3.51088256e-01f, 5.25942862e-01f, 3.43968809e-01f,
  3.62743765e-01f, 1.13674335e-01f, 5.77021718e-01f, 4.69185323e-01f, 4.11606461e-01f, 1.64123923e-01f, 1.64775282e-01f, 2.48887748e-01f, 2.55601294e-02f, -3.82356226e-01f,
  2.53145814e-01f, 9.43212509e-02f, -8.94612670e-01f, -5.01868010e-01f, -5.92440441e-02f, -8.31531659e-02f, 3.36971611e-01f, 3.96785066e-02f, -5.47944866e-02f, 3.19956332e-01f,
  1.01294053e+00f, 1.55745745e-01f, -3.23216885e-01f, -4.41749454e-01f, 3.07478160e-01f, -5.23850620e-01f, -5.06559014e-01f, 1.17407396e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  2.94306040e-01f, 2.35956728e-01f, 4.10293102e-01f, 2.69944489e-01f, 2.10367516e-01f, 2.99452364e-01f, 1.32109433e-01f, 2.23148495e-01f, 4.35802400e-01f, 2.57114470e-01f,
  1.26625597e-01f, 3.80291432e-01f, 2.15529799e-01f, 1.72919556e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  6.95837885e-02f, -1.54539317e-01f, -1.88391030e-01f, 1.33003756e-01f, 2.34766956e-02f, -4.12378907e-02f, -1.29018411e-01f, -5.55578470e-01f, -5.55417299e-01f, -2.41119668e-01f,
  6.20116413e-01f, -3.07424814e-01f, 3.54006320e-01f, 2.77558416e-01f, 3.82808477e-01f, -3.51967305e-01f, 1.60206482e-01f, 8.23141187e-02f, -3.46450388e-01f, -8.54181707e-01f,
  -5.31643093e-01f, -3.69734049e-01f, 2.25621790e-01f, -2.78825074e-01f, 5.60301483e-01f, -5.34439027e-01f, 5.27291477e-01f, -4.25518364e-01f, 1.88151196e-01f, 4.14215893e-01f,
  -7.55907118e-01f, -6.05673730e-01f, -3.13971698e-01f, 3.27353738e-02f, -4.03515756e-01f, -5.63106775e-01f, -2.09526122e-01f, -2.95732558e-01f, -2.43327364e-01f, 3.56991112e-01f,
  4.78565186e-01f, -2.16777958e-02f, -6.45565212e-01f, 7.56910443e-02f, -2.61225700e-01f, 3.36722434e-01f, 7.52514005e-02f, -2.69049078e-01f, -5.62794149e-01f, 1.60342455e-01f,
  -9.22040194e-02f, -2.87804961e-01f, -6.07740283e-01f, 4.85429734e-01f, 3.37656945e-01f, 5.26118726e-02f, 9.35022160e-02f, 3.53635579e-01f, 2.87173957e-01f, -5.67598999e-01f,
  3.42083752e-01f, -3.31781209e-01f, 9.40867364e-02f, -8.13693583e-01f, -1.61835834e-01f, -1.34198874e-01f, 2.71111369e-01f, 7.04135895e-02f, 1.68777600e-01f, -1.48316264e-01f,
  -2.17669308e-01f, 1.81014270e-01f, -1.59830943e-01f, -3.73660177e-02f, -2.59755373e-01f, -1.30512238e-01f, 3.66374403e-01f, -3.87083948e-01f, 3.83515358e-01f, -2.83158123e-01f,
  1.87237695e-01f, -2.82685697e-01f, -7.96822011e-01f, 3.25422734e-01f, 4.91602004e-01f, 4.91417408e-01f, -7.99037755e-01f, -3.07130098e-01f, 9.82015058e-02f, 3.36885512e-01f,
  -5.83207309e-01f, -5.55481911e-01f, 2.78025746e-01f, -6.40107036e-01f, 1.87729254e-01f, -7.75319636e-01f, -3.51752490e-02f, -4.15845037e-01f, -2.36742422e-01f, 3.20624262e-01f,
  -5.03974080e-01f, -3.03636849e-01f, -1.82238787e-01f, -2.12693900e-01f, -3.72422487e-01f, 4.79256719e-01f, -2.70340115e-01f, -3.39604765e-01f, -2.10450053e-01f, -2.79096574e-01f,
  -1.99727625e-01f, 3.36641639e-01f, 2.40297653e-02f, 2.06396341e-01f, 2.92902410e-01f, -7.42009044e-01f, 2.07938239e-01f, -8.17524016e-01f, -6.06645167e-01f, -6.13094449e-01f,
  -9.58869606e-02f, -4.44580823e-01f, -2.37558603e-01f, 3.37899417e-01f, 6.02207065e-01f, 1.25677392e-01f, 2.61427522e-01f, -5.28872967e-01f, 3.17010611e-01f, 4.46785897e-01f,
  4.30887759e-01f, 3.06386769e-01f, 2.93615788e-01f, 6.09142840e-01f, 3.32478672e-01f, 2.36717269e-01f, 1.70628086e-01f, 7.09148169e-01f, 5.12597382e-01f, 4.16099161e-01f,
  -4.02579457e-01f, -1.29400700e-01f, -1.45941228e-01f, 3.96693766e-01f, -7.17981040e-01f, 4.21303034e-01f, 2.46689901e-01f, -4.92744297e-01f, 6.12716615e-01f, -2.67552525e-01f,
  -1.32877067e-01f, -4.31443378e-02f, -9.46779996e-02f, -5.67024827e-01f, 5.88050783e-01f, 3.71942580e-01f, -2.42530942e-01f, -4.07243758e-01f, -7.19767034e-01f, -2.45804176e-01f,
  1.79481328e-01f, 2.12982818e-01f, -5.47410874e-03f, 2.12980434e-01f, 1.64161056e-01f, 7.41921887e-02f, 7.39282966e-02f, 4.00798440e-01f, 2.74039507e-01f, -2.70389199e-01f,
  -3.99747580e-01f, -2.12645918e-01f, 6.47231996e-01f, 4.08461332e-01f, 5.49830973e-01f, 2.11180240e-01f, 3.48087490e-01f, 3.71721871e-02f, 4.32776660e-01f, 1.38906211e-01f,
  -6.23664975e-01f, -1.21905424e-01f, 3.49246830e-01f, -6.31521344e-01f, -2.65136302e-01f, -5.26165366e-01f, 2.37304240e-01f, -1.78425550e-01f, -7.24921882e-01f, 3.81899565e-01f,
  3.37217040e-02f, 7.39614606e-01f, -5.37606068e-02f, 2.00880527e-01f, 1.78482324e-01f, 3.07372063e-01f, -2.65332609e-01f, -2.82616373e-02f, 2.26867665e-02f, -3.00107718e-01f,
  2.39091933e-01f, -2.39441097e-01f, -5.19436717e-01f, 2.10637022e-02f, -2.80392289e-01f, -3.39264601e-01f, 5.31868160e-01f, 4.74056423e-01f, 4.21861380e-01f, -6.57894909e-01f,
  4.51349497e-01f, 2.21184000e-01f, 1.00559518e-01f, 3.68770897e-01f, -7.38389313e-01f, 5.96148008e-03f, -6.97414696e-01f, 2.02915251e-01f, -9.14795399e-01f, -5.85665762e-01f,
  -3.73841584e-01f, 3.02735597e-01f, 5.35676301e-01f, 1.86131239e-01f, -2.13513643e-01f, -2.14129854e-02f, 3.87296043e-02f, -1.94750682e-01f, -1.21256143e-01f, -1.53051198e-01f,
  -6.19341843e-02f, 1.29893973e-01f, -1.59928188e-01f, 3.26812506e-01f, 1.63620058e-02f, 1.86229020e-01f, -1.27919286e-01f, -2.20641688e-01f, -9.85398293e-02f, -2.47160897e-01f,
  -2.51137950e-02f, 5.17339297e-02f, 3.82664382e-01f, 2.19845831e-01f, -6.87441647e-01f, -4.66635972e-01f, -4.74716097e-01f, -4.85404313e-01f, -4.94549632e-01f, 3.74678761e-01f,
  1.11079164e-01f, 2.64922619e-01f, 2.13545531e-01f, -5.50615489e-01f, 2.24026546e-01f, 4.31104183e-01f, -1.41235054e-01f, -6.07365295e-02f, 1.42882884e-01f, 1.24290340e-01f,
  -1.15911044e-01f, 1.17586613e-01f, -3.34402956e-02f, 7.35353259e-03f, -1.21469535e-01f, -5.40420301e-02f, -2.23157331e-01f, 2.37207890e-01f, -2.56457210e-01f, 2.03049198e-01f,
  -3.59346956e-01f, -2.70434678e-01f, 3.18238288e-01f, -3.41315150e-01f, -4.82101768e-01f, 3.63818765e-01f, -5.45563921e-02f, -6.87757015e-01f, 2.91886061e-01f, -3.69099528e-01f,
  5.63249290e-01f, 3.65115672e-01f, -7.96268404e-01f, -2.00045124e-01f, 1.12237453e-01f, -5.39140642e-01f, -3.20264220e-01f, 4.87182081e-01f, 8.02589133e-02f, 7.93184787e-02f,
  5.57025485e-02f, 1.79487951e-02f, -1.07581727e-01f, -1.39045119e-01f, 1.45925492e-01f, 3.42912078e-01f, -1.77605852e-01f, -3.15986812e-01f, 4.33583021e-01f, 4.40737575e-01f,
  -3.83226603e-01f, -3.32831264e-01f, -6.21322632e-01f, -4.69076693e-01f, 1.50843725e-01f, 4.66597319e-01f, -8.09218466e-01f, 5.35276830e-01f, -7.83143416e-02f, 1.00527890e-01f,
  -4.33997661e-01f, 6.68701351e-01f, -5.71514368e-01f, 1.95351273e-01f, 2.86033392e-01f, -2.37420470e-01f, -3.58398199e-01f, -1.06629189e-02f, -4.02653009e-01f, 1.49574414e-01f,
  5.64096309e-02f, -2.31002420e-01f, -3.87048542e-01f, -4.18661177e-01f, 9.88743082e-02f, -4.34158593e-02f, -2.27028474e-01f, 3.32357511e-02f, 6.84333667e-02f, -5.93997061e-01f,
  4.31528270e-01f, -3.75514217e-02f, 5.09747028e-01f, 1.74696203e-02f, -2.68189996e-01f, 2.07074821e-01f, -2.96444148e-01f, 1.14590012e-01f, -6.22072041e-01f, 5.83126009e-01f,
  2.81322181e-01f, 1.64702863e-01f, -8.34314078e-02f, -6.50560260e-02f, 4.50603515e-02f, -5.63787937e-01f, -6.13484681e-01f, 3.48155200e-01f, -2.60507971e-01f, 3.48838091e-01f,
  4.71066564e-01f, -5.71510017e-01f, -3.19098458e-02f, 1.24342993e-01f, 1.52034879e-01f, 5.29422015e-02f, -8.27050731e-02f, -5.41910082e-02f, -1.93686828e-01f, 3.58822681e-02f,
  -5.08587509e-02f, -9.79607552e-02f, -2.20872819e-01f, 2.91133281e-02f, -3.93633336e-01f, 1.24905378e-01f, -2.79768378e-01f, 3.45508754e-01f, 4.10911828e-01f, -4.85931188e-01f,
  6.36641458e-02f, -5.30401587e-01f, 3.69494468e-01f, -5.33248544e-01f, 4.88922864e-01f, 6.03066444e-01f, -3.82439137e-01f, -5.91368914e-01f, -8.48185360e-01f, 2.73024112e-01f,
  -2.65926063e-01f, 8.46388638e-02f, -1.04069240e-01f, 5.67022979e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  5.30183762e-02f, 3.07197566e-03f, -1.25597984e-01f, -1.38163706e-02f, 2.17723086e-01f, -1.90636322e-01f, 9.00654718e-02f, -1.57258227e-01f, -7.49342293e-02f, 5.34610683e-03f,
  1.47854937e-02f, -1.57749757e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    