/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -8.43626931e-02f, -3.15444738e-01f, -7.74024948e-02f, -2.30628029e-01f, -2.19932999e-02f, -1.41399419e-02f, -1.41490400e-01f, -6.93418607e-02f, -6.07376844e-02f, -2.00497180e-01f,
  -5.99395148e-02f, 1.87228397e-01f, 1.23856597e-01f, 2.03308463e-01f, 2.25673914e-01f, -1.62685644e-02f, -8.81500468e-02f, 2.42000550e-01f, 4.47190136e-01f, 1.56468481e-01f,
  1.27317041e-01f, -6.09239973e-02f, 2.40068566e-02f, 4.29885797e-02f, -2.39463925e-01f, 1.61793947e-01f, -1.63189843e-01f, -1.18468605e-01f, 4.80176928e-03f, -1.62726030e-01f,
  -5.10525629e-02f, -2.36724079e-01f, 1.83154300e-01f, 1.11034781e-01f, -8.05059448e-02f, 9.13422331e-02f, -2.89141275e-02f, -2.00458206e-02f, 4.82742414e-02f, -6.49786592e-02f,
  6.40296377e-03f, -8.99235159e-02f, 8.11391976e-03f, -7.29960427e-02f, -6.90495893e-02f, -7.71858469e-02f, -1.12684861e-01f, 3.88225839e-02f, -6.94551542e-02f, -2.88927667e-02f,
  -7.17940181e-02f, -5.81594184e-02f, -2.66645420e-02f, 1.92476250e-02f, 9.11649968e-03f, 4.75114956e-02f, -5.92569374e-02f, 1.15543604e-02f, -6.78117275e-02f, -1.32754907e-01f,
  6.95662871e-02f, 1.07073067e-02f, 3.04054953e-02f, 2.80311424e-02f, -9.95887443e-03f, 4.50274386e-02f, -2.84403116e-02f, 6.84162974e-02f, 3.50285470e-02f, -1.19581716e-02f,
  2.33855955e-02f, 1.97454989e-02f, -1.95006151e-02f, -1.41168963e-02f, -3.75327431e-02f, -7.14727566e-02f, 2.27729082e-02f, -3.06311585e-02f, 1.17552020e-02f, -2.26528905e-02f,
  5.07721752e-02f, 2.04695519e-02f, -4.31953929e-02f, -2.96781235e-03f, 2.55898125e-02f, -2.12860480e-02f, -1.64108891e-02f, 4.13576514e-02f, -5.36348298e-02f, -1.47953033e-02f,
  -3.26094851e-02f, 1.55305907e-01f, -4.73240912e-02f, 1.09009877e-01f, -5.74941263e-02f, -7.36859441e-03f, -1.77642121e-03f, -1.07230181e-02f, 5.77984098e-03f, -8.88572540e-03f,
  -3.69500485e-03f, 2.23801658e-02f, -3.31441127e-02f, -2.68938541e-02f, 9.35115814e-02f, 2.36215582e-03f, -5.63648306e-02f, 4.77929935e-02f, 5.06340526e-02f, -1.80558145e-01f,
  -1.10901415e-01f, 8.53702575e-02f, 1.56600505e-01f, 6.09920919e-02f, 4.82082218e-02f, 2.83194751e-01f, 1.01801239e-01f, 7.80085325e-02f, 1.85217798e-01f, -2.90922225e-02f,
  7.74840685e-03f, -1.96745306e-01f, -3.75155121e-01f, 1.87905401e-01f, 1.08185299e-01f, -2.34481379e-01f, -3.57306451e-01f, -1.38799176e-01f, 1.01802833e-01f, 4.13783155e-02f,
  1.33304968e-01f, 2.79008240e-01f, 1.49045452e-01f, -2.12784298e-02f, -1.31496906e-01f, -2.78400540e-01f, -2.58522779e-01f, -2.37229645e-01f, -5.49332127e-02f, 1.11726031e-01f,
  2.51316369e-01f, 1.61287695e-01f, -2.55203503e-03f, 3.35428789e-02f, 2.78035216e-02f, 1.54399067e-01f, -1.57946661e-01f, 3.18452641e-02f, -7.37280995e-02f, -2.61110421e-02f,
  9.42778438e-02f, -1.77219316e-01f, 2.51800437e-02f, 4.97491919e-02f, 2.26558000e-03f, -6.13342598e-03f, 3.65531892e-02f, -6.60268739e-02f, 9.91498902e-02f, 8.48212838e-03f,
  3.51941735e-02f, 2.89490633e-02f, -1.97459739e-02f, 4.82385792e-02f, -1.07904878e-02f, 5.84731027e-02f, -4.02481817e-02f, -8.29357430e-02f, -1.27955258e-01f, -9.55497622e-02f,
  5.43172434e-02f, -9.39745679e-02f, -1.13656618e-01f, -7.80842826e-02f, -5.50929196e-02f, -6.25721812e-02f, -2.63573583e-02f, 7.40382522e-02f, -8.91020000e-02f, 3.77144068e-02f,
  1.58063862e-02f, -3.93266454e-02f, -7.74872536e-03f, 3.35372845e-03f, 1.18356720e-02f, 5.14476933e-02f, -6.89131673e-03f, -2.72435509e-02f, 8.24668258e-02f, -4.17363942e-02f,
  2.95098945e-02f, -3.16796415e-02f, -7.05998158e-03f, -2.64767706e-02f, 9.78346355e-03f, -5.62193356e-02f, 8.01530480e-03f, -6.11095056e-02f, -2.96256542e-02f, -5.60948513e-02f,
  7.37461001e-02f, 1.13889771e-02f, 9.74219758e-03f, 3.87741104e-02f, -4.79150191e-02f, 1.02568353e-02f, -4.40864526e-02f, 3.54501754e-02f, -6.52861362e-03f, 4.02983762e-02f,
  2.64256686e-01f, -1.57870591e-01f, 1.64609607e-02f, -1.17164470e-01f, 5.05779572e-02f, 4.03966606e-02f, 1.56049719e-02f, 6.70435885e-03f, 4.75305282e-02f, 2.10678466e-02f,
  -2.64706928e-02f, -1.77685115e-02f, 3.44099477e-02f, -4.97428514e-02f, 6.46012798e-02f, -4.05352004e-02f, 7.22641870e-02f, -2.38703787e-02f, 3.01539320e-02f, -1.42595163e-02f,
  3.40373218e-02f, -4.34621237e-02f, 5.22023104e-02f, 2.10830495e-02f, -1.33360713e-03f, 2.20229737e-02f, 1.80241782e-02f, -4.33278270e-03f, -8.37516934e-02f, 2.78914589e-02f,
  3.68816733e-01f, -1.71163911e-03f, 1.49453267e-01f, 3.54900509e-01f, 3.47286969e-01f, 2.53209114e-01f, 4.14956622e-02f, 1.08003981e-01f, 1.94852754e-01f, -4.38643396e-02f,
  -5.28719723e-02f, -8.78078192e-02f, 3.99294794e-02f, 1.30204186e-02f, 7.36857057e-02f, 6.13502041e-02f, 1.14155926e-01f, 2.97238499e-01f, 3.22611302e-01f, 2.14748248e-01f,
  1.58283830e-01f, 2.28049845e-01f, 2.07172543e-01f, 8.69382843e-02f, 4.59664362e-03f, -8.20069294e-03f, -2.98158475e-03f, 1.61594510e-01f, 2.18193419e-02f, 9.81217176e-02f,
  -1.17415205e-01f, 6.36195838e-02f, -1.20848157e-02f, 5.43965846e-02f, -6.28893916e-03f, -1.06328741e-01f, -5.51051721e-02f, -1.25788422e-02f, -1.10580228e-01f, -1.67219024e-02f,
  4.24096733e-03f, 5.32485283e-05f, -4.50079031e-02f, -9.58282594e-03f, 4.81909364e-02f, 7.19639510e-02f, 7.77892843e-02f, 6.33929893e-02f, 4.03767079e-02f, 7.06051942e-03f,
  -7.79074132e-02f, 2.09576711e-02f, 3.48000862e-02f, -3.46396142e-03f, -8.68133977e-02f, 1.44480467e-02f, 2.15719733e-02f, 4.02788781e-02f, -3.37153971e-02f, -2.73261927e-02f,
  4.92009968e-02f, -1.18487686e-01f, 1.55165419e-02f, -8.56799167e-03f, 7.53339007e-02f, -9.29368809e-02f, 5.30195888e-03f, -2.12000273e-02f, 5.74775934e-02f, -9.94434580e-03f,
  -1.06488150e-02f, 2.50031124e-03f, -2.44541168e-02f, -1.16745085e-01f, -5.05697243e-02f, 7.40278512e-02f, -3.94337438e-02f, -1.36146499e-02f, -8.19951575e-03f, -3.37918997e-02f,
  5.78077994e-02f, -3.29049714e-02f, -2.04335637e-02f, -3.75361964e-02f, -2.11959723e-02f, 4.34257910e-02f, -4.71508084e-03f, 3.09011037e-03f, 3.93385664e-02f, 3.66921164e-02f,
  -1.15233541e-01f, 6.69617951e-02f, -7.62608126e-02f, 3.20941806e-02f, 2.31772121e-02f, -6.37798607e-02f, -7.81974494e-02f, -6.06563240e-02f, -5.64174168e-02f, -9.88516957e-03f,
  7.52219707e-02f, -7.80907273e-02f, 1.34839145e-02f, -3.29973586e-02f, 1.01634130e-01f, 1.22235464e-02f, -2.10218802e-02f, 3.18749994e-02f, 7.67674763e-03f, -7.27404505e-02f,
  5.14644794e-02f, 5.73430620e-02f, -7.92960972e-02f, -3.62143442e-02f, -2.40016840e-02f, 3.38260680e-02f, -1.48559898e-01f, -5.00628948e-02f, -3.33878770e-02f, -1.13743395e-01f,
  2.50046313e-01f, 4.30666953e-01f, -3.01351398e-01f, 3.05048913e-01f, 1.17956121e-02f, -1.88771158e-01f, 2.61893012e-02f, -1.14080776e-02f, 1.54799774e-01f, 1.75932720e-01f,
  -2.86317635e-02f, -1.59712628e-01f, -2.04393238e-01f, -1.29563510e-01f, -2.14039341e-01f, -3.37539501e-02f, -7.26527255e-03f, -2.76539177e-01f, -4.64899093e-01f, -2.23488852e-01f,
  5.12142554e-02f, 2.18919769e-01f, 6.70787022e-02f, 1.17588252e-01f, 4.45511281e-01f, 9.51267108e-02f, 7.39802979e-03f, 1.33617029e-01f, -1.25533901e-02f, 2.85384715e-01f,
  -6.61027208e-02f, 6.27767593e-02f, -1.53732061e-01f, 2.30761315e-03f, -1.81954112e-02f, 3.48394513e-02f, -4.80812835e-03f, 4.74069454e-02f, -1.55202616e-02f, 9.75008868e-03f,
  2.35126875e-02f, -2.89067645e-02f, -1.48550235e-02f, 5.97886890e-02f, 4.23923954e-02f, -7.52853677e-02f, 4.89987284e-02f, -9.22024325e-02f, -4.68501858e-02f, -9.45540816e-02f,
  8.99923369e-02f, -1.80953462e-02f, -1.38475955e-01f, -2.29331180e-02f, -6.61567748e-02f, -2.30110019e-01f, -2.07302887e-02f, 2.69684345e-02f, -1.34539798e-01f, 3.09547573e-01f,
  7.28784800e-02f, 2.55246088e-02f, 1.91971976e-02f, 9.09146853e-03f, 1.04589108e-02f, -2.16853083e-03f, -1.57200992e-02f, 8.22829306e-02f, -2.97937039e-02f, 4.46910374e-02f,
  -4.23441939e-02f, 1.96595863e-02f, -1.91470154e-03f, 2.61564623e-03f, -4.32755984e-02f, 4.51017767e-02f, -5.21122441e-02f, 2.54169572e-02f, -3.84632535e-02f, 5.13004474e-02f,
  -2.41749045e-02f, -3.57335694e-02f, 1.78341419e-02f, 1.94544941e-02f, 2.26338785e-02f, -2.11198460e-02f, -4.12089564e-02f, 1.93636566e-02f, 1.27550587e-02f, 4.03067842e-02f,
  4.46619801e-02f, -2.76774198e-01f, 1.08073547e-01f, -4.73206714e-02f, 3.83950323e-02f, -4.46147770e-02f, -5.15972450e-02f, -6.27040640e-02f, 1.78496502e-02f, 2.04911013e-03f,
  -5.87383807e-02f, -8.74379128e-02f, 2.36196090e-02f, -4.89065126e-02f, -3.91682833e-02f, -3.28873098e-02f, 2.48801010e-03f, 1.86092015e-02f, -6.83207437e-02f, 5.44275269e-02f,
  5.76646850e-02f, 3.03126574e-02f, -1.47797585e-01f, -2.90688220e-02f, 8.39398056e-02f, -1.75721452e-01f, -4.99500670e-02f, -2.49027163e-02f, -2.83376694e-01f, 1.14926755e-01f,
  -8.53361309e-01f, -2.94870973e-01f, 1.57164901e-01f, -6.24939986e-02f, 2.71750689e-01f, 1.15333848e-01f, -3.84021699e-02f, -2.12450817e-01f, -9.90326609e-03f, -5.14842011e-02f,
  4.44724262e-02f, 1.63887620e-01f, 5.69638647e-02f, 5.45745008e-02f, -1.70538276e-01f, -1.06416129e-01f, 7.58950040e-02f, 7.68386200e-02f, 6.56413063e-02f, 1.12865128e-01f,
  5.34402095e-02f, -3.83249074e-02f, -2.88839579e-01f, -1.11905009e-01f, 1.42252341e-01f, 1.15009159e-01f, 4.21357825e-02f, 1.23678735e-02f, 1.81618910e-02f, 2.05714032e-01f,
  1.95412040e-01f, -2.76408136e-01f, 1.38147473e-01f, 7.46643450e-03f, 6.07426167e-02f, -1.34220093e-01f, -3.17349588e-03f, -7.43604153e-02f, -3.00480127e-02f, -1.02796704e-01f,
  2.78711808e-03f, 4.41225581e-02f, 8.10890719e-02f, 1.08938873e-01f, -9.54401717e-02f, 3.08583789e-02f, -7.80371577e-02f, -1.84605151e-01f, -3.79120298e-02f, -5.95474020e-02f,
  1.56981856e-01f, 1.48365393e-01f, -3.76632996e-02f, -7.53366873e-02f, -6.32247254e-02f, 8.19742382e-02f, -3.47331800e-02f, -1.39303654e-02f, -2.37314194e-03f, -1.91369250e-01f,
  -4.47937325e-02f, 2.15918310e-02f, 3.72309349e-02f, -4.78091836e-02f, 3.02747521e-03f, 7.14449398e-03f, 5.86070679e-03f, 3.46927568e-02f, 4.06596102e-02f, -3.41339633e-02f,
  7.15496242e-02f, 1.48921981e-02f, 1.04550198e-02f, -1.13650784e-01f, 1.01406366e-01f, 1.28754331e-02f, -2.26675402e-02f, -2.39167549e-02f, -2.50593610e-02f, -3.51087525e-02f,
  1.07154101e-02f, 3.09304334e-02f, 7.81960133e-03f, 1.68448370e-02f, 1.58067904e-02f, -1.53107615e-02f, -1.45796267e-02f, 6.34481758e-02f, 5.19642606e-02f, -2.99598780e-02f,
  -1.08171567e-01f, 8.27461034e-02f, -2.81722937e-02f, -5.88545576e-03f, -4.93799988e-03f, 3.38805094e-02f, 3.61378118e-02f, 7.61490362e-03f, 2.03260798e-02f, -3.95334288e-02f,
  7.52804726e-02f, -6.20182939e-02f, -3.60083766e-02f, 3.91884381e-03f, 1.57407466e-02f, 4.46642824e-02f, -1.18108094e-02f, 9.86863524e-02f, -6.83639199e-02f, -5.31580187e-02f,
  -3.80441882e-02f, -9.30825695e-02f, -7.03366622e-02f, 7.73048494e-03f, -7.73333386e-02f, 5.53498156e-02f, 2.14544423e-02f, 8.36454108e-02f, 4.29689506e-04f, -1.21358924e-01f,
  1.60098091e-01f, 1.40389010e-01f, 4.05745625e-01f, -4.41609621e-02f, -3.52884978e-02f, -6.73860833e-02f, -1.17251836e-02f, -1.95734605e-01f, -4.06308733e-02f, -9.97160450e-02f,
  2.83104777e-02f, -2.91302335e-02f, 1.91510729e-02f, 2.51473431e-02f, 1.12101110e-02f, -1.77925527e-02f, 1.55026793e-01f, 1.12140045e-01f, 5.35250343e-02f, -1.30726278e-01f,
  -1.64516509e-01f, -1.39142245e-01f, -1.65740401e-02f, -8.87016649e-04f, 1.20873181e-02f, -4.17368449e-02f, 9.45558771e-02f, 8.45760182e-02f, -7.57288411e-02f, 1.94386363e-01f,
  3.60550284e-01f, 2.51148283e-01f, -1.34858891e-01f, -4.85803038e-02f, 7.14799464e-02f, 3.64750102e-02f, -1.84699008e-03f, 4.81857359e-03f, 1.25881126e-02f, -3.67361121e-02f,
  7.21352845e-02f, -6.34338185e-02f, -3.52695435e-02f, -2.77604572e-02f, 8.60895887e-02f, -4.07269895e-02f, -1.52993361e-02f, 3.42180729e-02f, 1.48446271e-02f, 7.39744753e-02f,
  -7.07328692e-02f, -6.35428801e-02f, 7.27222562e-02f, -6.40889034e-02f, 1.02283917e-01f, 5.97339449e-03f, 9.95890573e-02f, -3.48301306e-02f, 7.11749047e-02f, -1.22684911e-02f,
  -2.96474528e-02f, 8.29385668e-02f, 8.99842288e-03f, -5.79844192e-02f, -3.31496038e-02f, 2.15795115e-02f, 3.54214720e-02f, -2.41983868e-03f, 4.15736139e-02f, -1.85696874e-02f,
  -6.21619597e-02f, 7.49776214e-02f, -2.13955715e-02f, 4.62674396e-03f, 2.69095460e-03f, 2.21411474e-02f, 1.27175702e-02f, -3.79001983e-02f, -2.51611415e-02f, -3.93948816e-02f,
  5.65890502e-03f, 5.34681529e-02f, 5.12237661e-03f, -5.67342639e-02f, 4.60789278e-02f, 5.72392531e-03f, -4.17459123e-02f, 3.03091556e-02f, -7.65895620e-02f, -1.94474999e-02f,
  -1.12622157e-01f, 7.00242966e-02f, 5.57273589e-02f, 2.48645227e-02f, 5.92980199e-02f, -8.68353322e-02f, 4.56324480e-02f, 3.97995077e-02f, 2.85360627e-02f, 3.42503889e-03f,
  4.76511121e-02f, -2.50041522e-02f, -3.39259729e-02f, -9.81988572e-03f, 1.41783822e-02f, -3.22392806e-02f, -1.22128367e-01f, 1.00896858e-01f, -1.78234652e-04f, -4.14962955e-02f,
  -1.23087086e-01f, -9.13719274e-03f, 3.66189890e-03f, 1.37720872e-02f, -8.35266337e-02f, -7.08329771e-03f, 1.93136726e-02f, 6.18080795e-02f, 5.02625294e-02f, -9.53430608e-02f,
  7.73667574e-01f, 2.25260742e-02f, -4.12793308e-01f, 2.53752410e-01f, -6.47350922e-02f, -7.50965253e-03f, -4.99420017e-02f, 1.74578801e-01f, 1.02477729e-01f, -1.24314472e-01f,
  1.43396139e-01f, 1.80937827e-01f, 4.82772961e-02f, -1.09421656e-01f, 1.34316131e-01f, -3.56857628e-01f, -2.61032850e-01f, -2.01611072e-01f, 9.48088467e-02f, 3.19254816e-01f,
  1.59410432e-01f, 1.66651025e-01f, 1.48484379e-01f, 1.10255420e-01f, -1.11501731e-01f, -2.85952743e-02f, -2.84395427e-01f, 3.61110941e-02f, -1.95532262e-01f, -3.83435607e-01f,
  -2.12946460e-01f, 2.04855800e-01f, 1.96335884e-03f, 8.22560713e-02f, 1.27153853e-02f, -7.84475822e-03f, 2.84402259e-02f, -1.14612155e-01f, 5.93494028e-02f, -5.51940221e-03f,
  -8.50163028e-02f, 7.23136514e-02f, -5.96763976e-02f, -4.01093476e-02f, 2.48693284e-02f, -6.54077008e-02f, -6.80029988e-02f, -6.58788979e-02f, -1.27808955e-02f, -4.92831282e-02f,
  5.20634353e-02f, 1.86581817e-02f, -2.48672557e-03f, -3.33385058e-02f, 4.92773205e-02f, 6.05608150e-02f, -9.41142812e-02f, -3.88828143e-02f, -1.38124928e-01f, -3.04008462e-02f,
  2.78143268e-02f, -4.90901934e-04f, 1.97490137e-02f, 3.63228507e-02f, -3.23483092e-03f, 1.88046452e-02f, -6.24335930e-02f, 4.61760350e-02f, 5.86805791e-02f, -4.12899442e-02f,
  2.28838976e-02f, -3.79136950e-02f, -7.58798514e-03f, 1.66999921e-02f, 1.23921409e-02f, -8.62136297e-03f, 1.10490825e-02f, -5.15859947e-02f, 4.90435446e-03f, -2.22848002e-02f,
  4.35400531e-02f, -4.11348678e-02f, -1.82308648e-02f, -5.61458170e-02f, -1.44897848e-02f, -6.82153925e-02f, 3.18088499e-03f, 3.03366613e-02f, 8.88671353e-03f, 5.80778830e-02f,
  1.23221949e-01f, -4.01396416e-02f, 3.27899903e-02f, 2.17652209e-02f, -1.68997832e-02f, -3.30055431e-02f, 5.07991994e-03f, -1.29639367e-02f, -2.62204241e-02f, -2.71425839e-03f,
  8.62870887e-02f, 3.78941968e-02f, -1.23155145e-02f, -2.50079576e-02f, 3.76030453e-03f, 4.17548753e-02f, 5.42680696e-02f, 3.70893721e-03f, -4.36628312e-02f, 1.89834721e-02f,
  -5.17853983e-02f, -5.00944862e-03f, 1.43499121e-01f, -2.60893069e-02f, 9.40369293e-02f, 7.87390023e-02f, -9.06019732e-02f, -1.62873715e-02f, -8.72454699e-03f, -3.98863219e-02f,
  -2.52121925e-01f, -1.98814660e-01f, 1.37525380e-01f, 9.11029428e-02f, -1.00439198e-01f, -4.16714817e-01f, -4.68128622e-01f, -3.96275550e-01f, -2.99457293e-02f, -2.63266582e-02f,
  -9.78277177e-02f, 2.01107766e-02f, 6.13134652e-02f, -2.90173776e-02f, -1.62961528e-01f, -1.64112784e-02f, 2.13668779e-01f, 2.55724519e-01f, -6.74404949e-03f, -1.95933908e-01f,
  -3.20591615e-03f, 1.86875015e-01f, 7.45267197e-02f, 1.14788897e-01f, 2.23626360e-01f, 2.16134280e-01f, 2.53130943e-01f, 1.06034227e-01f, -6.51329681e-02f, 3.60152245e-01f,
  1.82127878e-01f, -8.91252086e-02f, 5.12162456e-03f, 1.48395440e-02f, 1.44184813e-01f, -1.56995431e-02f, -5.93948252e-02f, 7.73762092e-02f, 2.39494443e-02f, 3.86955403e-02f,
  8.85959938e-02f, 4.15769741e-02f, 7.91736320e-02f, 3.15006599e-02f, -2.67568883e-02f, 2.02461947e-02f, -2.66143996e-02f, -4.58285734e-02f, -2.81837843e-02f, -4.65866625e-02f,
  1.02361485e-01f, -4.34171036e-02f, -6.75193295e-02f, -1.09544650e-01f, -6.72685429e-02f, 1.04250304e-01f, -1.45786718e-01f, 2.20830422e-02f, -1.93058029e-01f, 6.47692615e-03f,
  2.19929162e-02f, 8.28918628e-03f, 3.00584529e-02f, -5.12977839e-02f, -1.54065965e-02f, 1.78970806e-02f, -6.92939619e-03f, 2.16924101e-02f, 1.82343423e-02f, -6.45816326e-02f,
  -1.65727213e-02f, -4.06565592e-02f, 4.77075800e-02f, -4.97069163e-03f, 3.03664319e-02f, 7.26837292e-02f, 7.33744446e-03f, -2.01224852e-02f, 2.43025292e-02f, -3.94520536e-02f,
  -2.04890296e-02f, 4.52894382e-02f, 1.26565799e-01f, 1.92736834e-02f, 1.53082106e-02f, -1.78680010e-02f, 4.82289605e-02f, -4.81879413e-02f, 1.45583721e-02f, -6.46395832e-02f,
  -3.96494605e-02f, -7.63161927e-02f, 5.23952022e-02f, 7.73456227e-03f, 6.91879913e-02f, 2.72472817e-02f, 6.43666908e-02f, -7.45734796e-02f, 6.34120256e-02f, -7.20610246e-02f,
  -1.46537041e-02f, 3.45825367e-02f, 4.55062650e-02f, 5.24329208e-03f, -1.88917629e-02f, -5.71908429e-02f, -3.96252684e-02f, 6.91029057e-03f, -3.97887602e-02f, -1.32718338e-02f,
  3.16794738e-02f, -8.34908858e-02f, -1.37179121e-01f, -4.61593121e-02f, 3.09248045e-02f, -4.37472202e-02f, 2.29365863e-02f, -1.08922876e-01f, -1.71736225e-01f, -1.73749417e-01f,
  1.48569390e-01f, -3.38273287e-01f, 1.88613594e-01f, -9.55385938e-02f, 1.87523395e-01f, 2.08376527e-01f, 8.04440975e-02f, -1.86466146e-02f, 1.63154583e-02f, -1.36184409e-01f,
  -2.32752003e-02f, -4.69929576e-02f, -6.96802214e-02f, -3.82835642e-02f, 1.15268305e-01f, 5.79032563e-02f, 1.51445210e-01f, 2.40163699e-01f, 2.74830818e-01f, 1.54561713e-01f,
  -4.08465415e-02f, -4.91531156e-02f, 3.81742716e-02f, 3.39904428e-02f, -1.55881271e-01f, -1.48246880e-03f, -4.14016135e-02f, 5.07729761e-02f, 7.94626996e-02f, -6.11245595e-02f,
  -1.13191359e-01f, 7.78899118e-02f, 1.90829396e-01f, 1.37608526e-02f, -3.22055481e-02f, 9.38854180e-03f, 2.94807721e-02f, 8.57439935e-02f, -5.52655868e-02f, -2.11770516e-02f,
  -6.00548983e-02f, -3.82582135e-02f, 4.11419608e-02f, -1.10253297e-01f, -4.19755206e-02f, 6.72429428e-02f, 1.30456742e-02f, 7.76718780e-02f, 6.50575608e-02f, -7.08114728e-02f,
  2.13616174e-02f, -2.52882540e-02f, 6.09716848e-02f, -5.52780218e-02f, 8.84980932e-02f, 6.26836345e-02f, 1.23945456e-02f, 5.08992113e-02f, 1.60850696e-02f, -1.34752244e-01f,
  2.02143099e-02f, -3.71313244e-02f, -1.57399178e-02f, 1.25884414e-02f, -7.32783675e-02f, 5.32252379e-02f, -2.13441290e-02f, -6.67806193e-02f, -3.25193815e-03f, 9.68685187e-03f,
  -4.77344729e-02f, -4.52001207e-02f, -1.31246880e-01f, 4.57268395e-02f, -1.17414827e-02f, 1.20526636e-02f, 9.54742804e-02f, -8.85789916e-02f, -5.16368747e-02f, 3.19751725e-02f,
  -1.89239532e-02f, -1.08731417e-02f, 3.72154005e-02f, -2.53165979e-02f, 4.72456627e-02f, 4.15368415e-02f, 3.95974191e-03f, -4.27440507e-03f, 4.93020080e-02f, 1.95431672e-02f,
  -2.80150145e-01f, 1.60979256e-01f, -3.19147743e-02f, -8.18684057e-05f, -3.66836414e-02f, 5.28500155e-02f, -7.20094070e-02f, -3.06587722e-02f, 1.31286141e-02f, -3.43760587e-02f,
  -4.06347364e-02f, 2.25575417e-02f, -2.47687530e-02f, -4.28313278e-02f, 4.43384238e-03f, -7.88779780e-02f, -9.08854455e-02f, 3.09601817e-02f, 3.00630182e-02f, 6.14168029e-03f,
  -9.87113789e-02f, 6.62981495e-02f, -3.12028266e-02f, 7.64166713e-02f, 3.48051004e-02f, 1.61204115e-01f, -3.92927974e-03f, -9.81843472e-02f, 4.32783999e-02f, -1.75071880e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.26595724e-01f, 7.60336593e-02f, 9.04237032e-02f, 4.52100001e-02f, -6.93235546e-02f, -2.87302017e-01f, -2.29757428e-01f, -2.50123084e-01f, -1.20743260e-01f, -6.49059489e-02f,
  -5.02114519e-02f, 8.05501193e-02f, 3.33695374e-02f, 5.81395477e-02f, 1.87787898e-02f, -1.19556800e-01f, -1.45957684e-02f, 2.64901429e-01f, 1.65408164e-01f, 1.40666470e-01f,
  8.22457448e-02f, 2.12972909e-01f, 3.77628237e-01f, 2.05915675e-01f, 3.50047871e-02f, 8.53895620e-02f, 8.87078121e-02f, 2.05626458e-01f, 1.23072743e-01f, 3.49151462e-01f,
  1.65610120e-01f, 1.81496277e-01f, -5.98633625e-02f, 7.87469894e-02f, -2.29146220e-02f, 4.17789854e-02f, 2.70392820e-02f, 9.79776233e-02f, 3.76459882e-02f, -4.44824062e-02f,
  -2.68552750e-02f, 5.08346921e-03f, 7.46674612e-02f, 1.73215549e-02f, 2.70633791e-02f, 7.03465268e-02f, 7.11051002e-02f, 1.09490409e-01f, -2.63956636e-02f, -3.08407824e-02f,
  -4.00224552e-02f, 4.74372096e-02f, 5.32744592e-03f, -1.64755821e-01f, 6.33273646e-02f, -3.65807451e-02f, -2.05165576e-02f, 1.48811117e-01f, -4.83751446e-02f, 6.26048967e-02f,
  -4.05974910e-02f, 9.32374075e-02f, 9.07363091e-03f, 2.62555610e-02f, 8.90140012e-02f, -4.32345271e-02f, -7.19530275e-03f, 4.98228930e-02f, -4.69147228e-02f, 1.52660189e-02f,
  2.04773173e-02f, -1.13884555e-02f, -5.91141172e-02f, -1.21517815e-02f, 5.95394336e-02f, -2.13446915e-02f, 3.76509801e-02f, -3.07203922e-02f, 3.28191184e-02f, -3.07504851e-02f,
  2.05733776e-02f, 2.14416953e-03f, 4.42818142e-02f, 3.22555564e-02f, 6.78423271e-02f, 1.02453671e-01f, 5.53089492e-02f, -1.18976021e-02f, 3.65825817e-02f, 1.13999464e-01f,
  -2.16929317e-01f, -2.75660194e-02f, -3.35672759e-02f, -1.94641612e-02f, 5.53260967e-02f, 5.65747097e-02f, -6.02989756e-02f, 6.14248738e-02f, 1.39978463e-02f, -1.54850064e-02f,
  4.04158607e-02f, 7.42102042e-02f, -1.28242865e-01f, -1.35871824e-02f, 1.93122737e-02f, -8.41131061e-02f, -2.74331793e-02f, -1.44860300e-03f, -3.42199281e-02f, 1.83135103e-02f,
  -1.11229733e-01f, -1.08382940e-01f, -1.71721220e-01f, -2.33441651e-01f, -1.43351719e-01f, -6.68722242e-02f, -9.22185034e-02f, -1.66585818e-01f, -1.40491828e-01f, -2.32309386e-01f,
  -5.20666599e-01f, 4.23956811e-02f, -7.99053088e-02f, 1.65603161e-01f, 1.20097660e-01f, 8.77713710e-02f, 2.00757787e-01f, 2.22116411e-01f, 1.80122048e-01f, 1.15202382e-01f,
  -1.59508996e-02f, 3.75127904e-02f, 1.10739976e-01f, 8.78733303e-03f, 5.59060685e-02f, 2.44620338e-01f, 2.80321985e-01f, -4.61955257e-02f, -1.29765406e-01f, 1.97678478e-03f,
  1.97072253e-01f, 1.24891251e-01f, -2.03966111e-01f, 2.44284570e-02f, 2.11715624e-01f, 1.70296386e-01f, 9.72821862e-02f, 3.66377532e-02f, 7.03549087e-02f, 1.90450385e-01f,
  -1.54423431e-01f, -2.35323101e-01f, 1.70051269e-02f, -1.96510572e-02f, -3.68723869e-02f, -1.49682760e-01f, -7.38938451e-02f, -3.99720259e-02f, -4.66219187e-02f, -3.00340224e-02f,
  5.58890030e-02f, 2.09425073e-02f, 1.18270509e-01f, -1.01932315e-02f, 3.71198374e-04f, -1.03068039e-01f, -8.02856982e-02f, 1.62547622e-02f, 1.10102762e-02f, 9.26375911e-02f,
  1.68125898e-01f, 1.25018492e-01f, -1.01082101e-01f, 8.39104354e-02f, 7.44103789e-02f, 1.17025198e-02f, 8.53717967e-04f, -6.38060644e-02f, -2.02596635e-01f, 2.35741623e-02f,
  -3.32086324e-03f, -3.54154520e-02f, 2.71589379e-03f, 2.33492372e-03f, 4.65326086e-02f, 1.02909811e-01f, 2.66287178e-02f, -7.37721287e-03f, 8.71532317e-03f, 1.12309894e-02f,
  -4.67621572e-02f, -2.34855711e-02f, 7.21229613e-02f, 5.13716862e-02f, -3.49216796e-02f, 2.14086343e-02f, 8.02375823e-02f, -2.93257367e-02f, 5.27173057e-02f, -4.24746163e-02f,
  -4.43736315e-02f, -2.92746238e-02f, -4.09714356e-02f, 8.21831003e-02f, -1.07051665e-02f, 6.51604161e-02f, -2.97888368e-02f, -1.95651166e-02f, 3.77565287e-02f, -5.31605557e-02f,
  -3.35489362e-02f, -2.08325088e-02f, 1.50118187e-01f, -2.60585416e-02f, -1.80020053e-02f, -5.46524674e-03f, 8.82839188e-02f, 3.05134412e-02f, 1.50930500e-02f, -1.03801731e-02f,
  -2.29887906e-02f, -3.65162045e-02f, 5.14553934e-02f, -5.15027903e-02f, -6.01189248e-02f, -5.08911256e-03f, -6.50301063e-03f, 1.02372520e-01f, -1.92638561e-02f, 2.47427262e-02f,
  1.10351577e-01f, 3.49630080e-02f, 3.89523953e-02f, 6.77701309e-02f, 2.20711008e-02f, -1.12821870e-02f, -8.28558430e-02f, -9.99974161e-02f, -2.79811751e-02f, -8.60372484e-02f,
  -3.41729939e-01f, -8.48732963e-02f, 1.00735031e-01f, 5.29142246e-02f, 7.10143223e-02f, 6.11555800e-02f, 1.43707842e-01f, 4.55735996e-02f, 9.16535209e-04f, -4.96867448e-02f,
  -8.94216523e-02f, 4.99506928e-02f, 1.01572864e-01f, 4.81353961e-02f, 7.34740198e-02f, 5.13016209e-02f, 2.40645647e-01f, 5.64380996e-02f, 9.23846513e-02f, 8.93261209e-02f,
  7.47652426e-02f, -1.02017894e-01f, -4.76373956e-02f, -7.39743561e-02f, 4.21874449e-02f, -1.54484920e-02f, 6.83505908e-02f, 2.20095664e-02f, -8.89525749e-03f, 4.59687188e-02f,
  1.08539023e-01f, -1.28266528e-01f, -6.25964766e-03f, -5.89373335e-02f, 2.52970047e-02f, -9.22744349e-02f, -4.82902303e-03f, -9.02771503e-02f, -8.30608979e-02f, 7.88980499e-02f,
  -7.42951557e-02f, 4.06432040e-02f, -5.73670752e-02f, 3.71087156e-02f, -7.87325278e-02f, -3.12790908e-02f, 1.87566725e-03f, -3.29755358e-02f, -7.30952919e-02f, -4.29376438e-02f,
  6.36173934e-02f, -5.37050553e-02f, 5.53727113e-02f, 7.18828067e-02f, 7.94835463e-02f, -4.59048226e-02f, -8.08130726e-02f, 7.28699863e-02f, -2.73511428e-02f, -8.59640688e-02f,
  9.45635885e-02f, -6.09073527e-02f, -2.50478312e-02f, 8.38525966e-02f, 6.17828779e-02f, -2.47497577e-02f, 2.08475869e-02f, 1.46747276e-03f, -8.08611736e-02f, 4.35856134e-02f,
  9.72336978e-02f, -4.51733060e-02f, -4.50111786e-03f, -2.74095163e-02f, 3.80825177e-02f, -6.97495714e-02f, -6.90142214e-02f, 1.61343627e-02f, -2.38705296e-02f, -1.10207483e-01f,
  5.95226623e-02f, -3.17192986e-03f, -2.93244496e-02f, 6.89216778e-02f, -1.04292169e-01f, 3.32966112e-02f, -4.63026837e-02f, -4.97154333e-02f, -6.11414388e-03f, 3.01602185e-02f,
  1.34870648e-01f, -1.52678981e-01f, 9.91519839e-02f, 4.99398261e-02f, -3.20207477e-02f, -1.00526877e-01f, 4.57055587e-03f, -1.67185795e-02f, 1.94429867e-02f, -2.92557646e-02f,
  -4.83767241e-02f, 1.26485508e-02f, 8.87671392e-03f, -9.17214155e-03f, 1.96705125e-02f, 1.51615692e-02f, -1.23618454e-01f, 3.75974849e-02f, -2.76712831e-02f, 1.06136678e-02f,
  -3.57409157e-02f, 8.48406628e-02f, 1.19225830e-02f, -1.57058779e-02f, 3.18242051e-02f, 8.73144865e-02f, 1.45738631e-01f, 7.40100890e-02f, 7.98863098e-02f, 1.23804167e-01f,
  -6.48000762e-02f, 1.39503956e-01f, 6.02675974e-02f, 1.01469696e-01f, 1.76944971e-01f, 1.25905290e-01f, 9.30966213e-02f, 1.30560488e-01f, 1.39657065e-01f, 1.59447789e-01f,
  8.99468809e-02f, 1.35501146e-01f, 1.24750659e-01f, 1.41820818e-01f, 1.58538252e-01f, 1.73571974e-01f, 1.37860641e-01f, -8.53874721e-04f, 2.22960915e-02f, 1.11152127e-01f,
  1.83318675e-01f, -6.04725629e-03f, -6.14847690e-02f, 1.20014101e-01f, 2.75858283e-01f, 1.16092212e-01f, 7.42015839e-02f, 1.04049854e-01f, 1.48348864e-02f, 3.22563261e-01f,
  -4.26748358e-02f, -5.90043701e-02f, -6.18223511e-02f, -1.30113319e-01f, -2.28856634e-02f, -3.86824012e-02f, 2.14021858e-02f, -6.69510141e-02f, -2.12908722e-02f, -6.71127439e-02f,
  -7.09381998e-02f, -8.99591744e-02f, 2.23718453e-02f, 3.32733355e-02f, -1.09814079e-02f, -1.39826089e-02f, -7.48192593e-02f, -5.39249405e-02f, -8.50457773e-02f, -5.94950188e-03f,
  8.65409747e-02f, -2.83937380e-02f, -2.11833301e-03f, -5.54406904e-02f, -3.02296337e-02f, 1.78810526e-02f, -4.89533395e-02f, -1.22126359e-02f, -1.20204084e-01f, -4.47807275e-02f,
  4.64504585e-03f, 3.72476391e-02f, -1.73031036e-02f, 7.61893913e-02f, 2.94245686e-02f, -1.65443942e-02f, 1.08051091e-01f, -1.81052033e-02f, 6.09595217e-02f, 2.11657528e-02f,
  1.52256321e-02f, -4.83481474e-02f, -4.24840935e-02f, 7.06911534e-02f, 3.53398435e-02f, -2.22065803e-02f, 7.70794600e-02f, -1.84185952e-02f, -6.62019104e-02f, -3.02445497e-02f,
  6.22018389e-02f, -4.76322547e-02f, 5.10447770e-02f, -2.46734712e-02f, -3.55297402e-02f, 2.75068711e-02f, -5.62925078e-02f, 4.24536616e-02f, -8.67815688e-02f, 5.76242581e-02f,
  -1.42853558e-01f, -2.31113851e-01f, 9.69126597e-02f, 4.94637853e-03f, 4.68941126e-03f, -2.21854299e-02f, 4.23584320e-02f, -1.63474411e-01f, 7.10231194e-04f, 3.71508859e-02f,
  -1.06077187e-01f, 1.02378530e-02f, -6.53312653e-02f, -5.96234836e-02f, -9.12972167e-02f, -5.19627072e-02f, -7.49690980e-02f, 4.46955487e-02f, 1.03174876e-02f, -6.24947669e-03f,
  1.31725753e-02f, -1.26668751e-01f, -5.87084703e-02f, -3.13640907e-02f, -3.96636128e-02f, -1.40193272e-02f, -1.49952918e-01f, -1.24038931e-03f, -1.54837564e-01f, -1.03283837e-01f,
  4.04337078e-01f, -1.93415835e-01f, 2.88244784e-01f, 6.62384257e-02f, 1.43118277e-01f, 3.19115847e-01f, 2.34694272e-01f, 1.62981510e-01f, -7.38811716e-02f, -1.02257179e-02f,
  -1.81948349e-01f, -1.51478186e-01f, -1.95525825e-01f, -1.12797357e-01f, 1.03797704e-01f, 1.25847921e-01f, 5.54612465e-02f, 1.01233497e-01f, 1.19898126e-01f, -1.33203985e-02f,
  -1.52670652e-01f, -4.29456607e-02f, 6.85584545e-02f, 1.18613698e-01f, -1.47113174e-01f, -2.98656244e-02f, 1.60265388e-03f, -4.94492911e-02f, 3.30163091e-02f, -1.11520141e-01f,
  -1.24801956e-01f, 2.10531443e-01f, 6.22812426e-04f, -1.74530521e-01f, -8.75361115e-02f, 1.09387038e-03f, 3.34074534e-02f, -4.91449721e-02f, 7.42235361e-03f, -3.88050079e-02f,
  -4.46579084e-02f, -3.74389417e-03f, 8.54544565e-02f, -8.69407430e-02f, 1.23895139e-01f, -9.50124580e-03f, -9.50603560e-02f, 6.80759102e-02f, 1.17971040e-02f, -1.57547981e-01f,
  -2.10449696e-01f, 1.89533830e-01f, 2.37531692e-01f, 7.89183155e-02f, 1.00129239e-01f, 7.12751225e-02f, 4.14728783e-02f, 4.40383777e-02f, 7.61921033e-02f, -4.49052453e-02f,
  -2.21428704e-02f, 4.33413722e-02f, -7.32588582e-03f, 4.38799290e-03f, 2.80196685e-02f, -4.80171703e-02f, -6.63227737e-02f, 2.02211179e-02f, 3.96437049e-02f, 5.58515936e-02f,
  1.19539187e-03f, 7.49496445e-02f, 4.31671680e-04f, 6.32416224e-03f, -1.20702051e-01f, 3.97310220e-02f, 4.44738613e-03f, -5.17737679e-02f, 1.40919508e-02f, -3.19169424e-02f,
  6.71976060e-03f, 1.01592056e-01f, -5.96035160e-02f, 4.00444753e-02f, 1.52889336e-03f, 5.38636260e-02f, 5.25043681e-02f, -8.93274788e-03f, -4.46038954e-02f, -4.16053012e-02f,
  -2.00668558e-01f, 1.63312510e-01f, -1.05698422e-01f, -2.42368411e-02f, 6.95918351e-02f, -3.06373220e-02f, 3.46717946e-02f, -4.08827551e-02f, -1.25602027e-02f, 1.74931996e-02f,
  5.93425594e-02f, 1.50675485e-02f, -2.81032212e-02f, -5.18777706e-02f, 1.16533548e-01f, 6.74741492e-02f, 1.00930186e-03f, 2.87770554e-02f, -9.22998786e-02f, -1.06800690e-01f,
  -6.82535768e-02f, 1.33249998e-01f, 1.19776160e-01f, 8.48451350e-03f, 1.85496323e-02f, 1.84616596e-01f, -7.22298250e-02f, 3.02082840e-02f, 1.77843645e-01f, -1.83859929e-01f,
  7.91182667e-02f, 1.97170451e-01f, 6.32894859e-02f, -1.31800696e-01f, 2.12234691e-01f, 2.73543417e-01f, 2.80612797e-01f, 6.77312762e-02f, -1.69704333e-01f, -4.14034389e-02f,
  2.67472327e-01f, 2.58600223e-03f, -8.58612359e-02f, 3.11342776e-02f, -2.35591587e-02f, -1.03517748e-01f, -4.07973155e-02f, -3.90391909e-02f, -1.19896695e-01f, 1.06637374e-01f,
  -9.59290117e-02f, -8.79264176e-02f, -5.36760911e-02f, -8.08263794e-02f, -1.78029597e-01f, -1.32528305e-01f, 2.13561207e-02f, 1.09734669e-01f, 1.94316596e-01f, -1.56672314e-01f,
  1.13410614e-01f, 1.96764007e-01f, -4.37723473e-02f, 2.22728439e-02f, 5.98714687e-02f, -2.52738558e-02f, -4.41289134e-02f, -1.21246658e-01f, 6.23385608e-02f, 4.43198644e-02f,
  9.15352628e-03f, 6.69468492e-02f, 3.56812403e-02f, 4.94666696e-02f, 3.94585952e-02f, -3.01322415e-02f, -1.70530245e-01f, -1.86172530e-01f, -1.45507440e-01f, 9.47484076e-02f,
  7.90653452e-02f, 5.75345866e-02f, 1.49410337e-01f, -9.15966481e-02f, 4.03407738e-02f, -4.55831476e-02f, -1.28129683e-02f, -8.56135786e-02f, 1.59811322e-02f, -2.24136725e-01f,
  5.02417348e-02f, 5.83085120e-02f, 1.52493715e-02f, 8.33502710e-02f, -9.15046856e-02f, 7.76206776e-02f, -4.20821942e-02f, 1.68074984e-02f, 5.43061271e-02f, 4.83459234e-03f,
  1.71107743e-02f, 4.39264737e-02f, 9.12133455e-02f, -5.58014512e-02f, -6.44688383e-02f, 4.25253669e-03f, 1.65438023e-03f, -2.94996854e-02f, 8.69248584e-02f, -4.30530682e-02f,
  2.23556254e-02f, -3.87785174e-02f, -6.72849128e-03f, 9.14548058e-03f, -3.89773250e-02f, 4.15138202e-03f, -2.84647476e-02f, 1.61855984e-02f, -1.14131428e-01f, 5.17424271e-02f,
  -2.86495686e-01f, 9.71803293e-02f, -1.64617732e-01f, -1.33902177e-01f, -1.22141829e-02f, -6.38213754e-02f, -3.23147774e-02f, -3.56111340e-02f, -7.24234385e-03f, -9.66207236e-02f,
  1.15381688e-01f, -1.51622221e-02f, -5.37575446e-02f, -4.34819162e-02f, -7.43353292e-02f, -9.34311841e-03f, 1.23342853e-02f, -5.34442849e-02f, -1.22389235e-02f, -6.41620830e-02f,
  -3.84782031e-02f, -5.09445332e-02f, -1.49663210e-01f, -1.27353936e-01f, -9.36857685e-02f, -6.36835545e-02f, -1.18984774e-01f, -1.13216765e-01f, -1.95991561e-01f, -2.76475310e-01f,
  7.06842616e-02f, 1.19812228e-01f, 2.09621731e-02f, 1.02670252e-01f, 3.24730948e-02f, -7.48495162e-02f, -1.09088227e-01f, -5.84391579e-02f, 5.71230687e-02f, 4.83187623e-02f,
  2.15241462e-01f, 2.27058709e-01f, 1.89075321e-01f, 1.49403766e-01f, -2.38422602e-02f, 4.19866368e-02f, -1.15149416e-01f, -7.99390022e-03f, -5.27517647e-02f, -5.38014695e-02f,
  -1.55126154e-02f, 3.06647569e-02f, -7.35600367e-02f, -7.79374316e-02f, 5.45034930e-02f, 1.06530905e-01f, -2.42300779e-02f, -1.19207194e-02f, -4.79867496e-02f, -1.38888359e-02f,
  2.10546419e-01f, 4.75133955e-02f, 6.49606660e-02f, 6.95089027e-02f, 3.38681936e-02f, 1.64180063e-02f, 7.59991482e-02f, 4.37535867e-02f, 2.46524159e-02f, -5.33665642e-02f,
  -3.21431225e-03f, 1.00525571e-02f, -4.77101356e-02f, 2.49752612e-03f, 1.53217930e-02f, 9.73657370e-02f, -5.73980175e-02f, -6.52048141e-02f, -1.52181080e-02f, 3.37669887e-02f,
  4.87907417e-02f, -2.56180540e-02f, 1.15014866e-01f, 3.27625088e-02f, 1.04767971e-01f, -2.26993188e-02f, 1.50288522e-01f, 9.31104496e-02f, 6.69745430e-02f, 1.22961483e-03f,
  -2.13152021e-02f, -6.82611167e-02f, 4.92079854e-02f, 9.97185986e-03f, -8.21701512e-02f, -5.37338220e-02f, -1.49711771e-02f, -8.08139145e-02f, -1.36878109e-03f, 3.31048071e-02f,
  -5.35232499e-02f, 1.65099418e-03f, -7.67764002e-02f, -4.01551090e-02f, 1.50003746e-01f, 3.69956717e-02f, -6.06036447e-02f, 6.08872399e-02f, -1.05394730e-02f, 2.26171184e-02f,
  -6.48995638e-02f, 3.16555388e-02f, -1.38556687e-02f, 2.19613891e-02f, 4.70664445e-03f, 3.89693938e-02f, -1.03547489e-02f, 5.35708889e-02f, -3.61284912e-02f, -9.62609574e-02f,
  2.09654480e-01f, 7.79416114e-02f, -4.11233976e-02f, 8.16965997e-02f, -4.76242090e-03f, 6.02099411e-02f, -3.24914195e-02f, -1.38567202e-02f, -1.80617347e-03f, 2.07483098e-02f,
  8.99426043e-02f, 4.20104824e-02f, -3.98969650e-03f, -1.07314158e-03f, -7.62052238e-02f, 1.16128340e-01f, -1.15002571e-02f, 4.05211933e-03f, 8.72635096e-02f, 1.39392242e-01f,
  6.94219694e-02f, 6.65462539e-02f, -1.07226456e-02f, 2.44871192e-02f, 1.99484937e-02f, 1.29814278e-02f, 6.56420588e-02f, -9.38637764e-04f, 1.28783062e-01f, -1.80633739e-02f,
  -5.82841277e-01f, 1.14573933e-01f, 3.55438799e-01f, -5.33468843e-01f, -3.64868678e-02f, 1.23792917e-01f, 6.02845624e-02f, 4.17281352e-02f, -2.11101353e-01f, -3.78614366e-02f,
  5.56352437e-02f, -1.56955764e-01f, 1.66410897e-02f, -4.99088094e-02f, 1.95040163e-02f, 1.38076410e-01f, 7.91249871e-02f, 7.48104006e-02f, -6.16377294e-02f, -7.49033615e-02f,
  -1.49456531e-01f, -2.73132592e-01f, -1.65428236e-01f, -1.57020479e-01f, -9.72724408e-02f, -4.37952019e-02f, -1.06258076e-02f, -7.71322986e-03f, 1.43574446e-01f, 2.89775636e-02f,
  2.24820692e-02f, -1.29539564e-01f, -3.55403163e-02f, -6.52519912e-02f, 1.05783483e-02f, 2.23332420e-02f, 3.07141077e-02f, -6.03410453e-02f, 6.87324107e-02f, 6.72246143e-02f,
  -4.75498773e-02f, 3.69802825e-02f, -4.79994379e-02f, 3.13445330e-02f, -9.84922722e-02f, -7.84404129e-02f, 8.84303749e-02f, 6.77449405e-02f, 2.48936843e-02f, 1.14120550e-01f,
  5.89223020e-02f, 4.83978502e-02f, -5.08386679e-02f, 7.55662993e-02f, 1.25207096e-01f, 8.82307068e-02f, 1.27033647e-02f, 1.57641824e-02f, 9.21798944e-02f, 6.04018085e-02f,
  5.98294884e-02f, 3.39367352e-02f, -2.02245992e-02f, -2.48109177e-02f, -7.13679790e-02f, 2.27632676e-03f, -4.47559431e-02f, 5.36613166e-02f, -6.17544875e-02f, -2.44633146e-02f,
  -1.38137676e-02f, 6.64002448e-02f, -8.29486698e-02f, -3.00638005e-02f, 8.64232332e-02f, -3.32913101e-02f, -5.39896302e-02f, 7.36318380e-02f, -1.24168852e-02f, -2.71744300e-02f,
  2.14195810e-02f, -2.10618377e-02f, -3.11501157e-02f, 4.38275151e-02f, 3.73180583e-02f, 4.10415456e-02f, 1.89725291e-02f, 6.99097142e-02f, 4.94789146e-02f, 4.00685109e-02f,
  -2.46154472e-01f, 2.05045983e-01f, -1.27751336e-01f, -4.96780984e-02f, -3.70124094e-02f, 5.21490239e-02f, 5.28287201e-04f, -1.16353473e-02f, -5.27368858e-02f, 2.61233523e-02f,
  3.62442099e-02f, -5.50890900e-02f, -1.29151912e-02f, 7.25497827e-02f, -6.22493699e-02f, 2.76519917e-03f, 4.42860201e-02f, -3.93946320e-02f, 1.65024884e-02f, 1.00572914e-01f,
  1.25253126e-01f, -7.37858266e-02f, -1.10531397e-01f, 4.50091548e-02f, -2.41986942e-02f, -1.32416248e-01f, -1.52189413e-03f, -6.18299991e-02f, -3.24712619e-02f, -1.15226395e-01f,
  3.66002947e-01f, 2.01624081e-01f, 2.92960018e-01f, 6.19206876e-02f, -2.00444043e-01f, 8.33498221e-03f, 1.98108852e-02f, 4.70607467e-02f, 1.49284657e-02f, 6.66164309e-02f,
  -1.34835377e-01f, -1.00325152e-01f, -8.80041420e-02f, 6.61138669e-02f, 1.45429403e-01f, 1.22719765e-01f, 9.79537740e-02f, 2.44318947e-01f, 2.60892808e-01f, 1.03850618e-01f,
  -2.74525452e-02f, 3.62551063e-02f, 1.34998292e-01f, 1.01267651e-01f, -2.46862192e-02f, -1.14055797e-01f, 1.31074727e-01f, 7.73125887e-02f, -3.17834914e-02f, -1.86170209e-02f,
  -2.36254558e-02f, 1.78209767e-01f, -1.51234463e-01f, -1.76687330e-01f, -9.51469615e-02f, 5.20658605e-02f, 3.85437943e-02f, 3.83439288e-02f, 4.16196510e-02f, -1.56056937e-02f,
  -2.93336734e-02f, -3.04740164e-02f, -1.22443829e-02f, -5.90208992e-02f, -7.92575255e-02f, 1.11557931e-01f, 2.95615103e-02f, 2.22048566e-01f, 5.05803898e-02f, 5.60344048e-02f,
  -6.87701553e-02f, -7.92597048e-03f, 1.01180963e-01f, 9.48503986e-03f, 3.35297547e-02f, -4.63411398e-03f, 8.58715829e-03f, 1.08730376e-01f, 6.40956163e-02f, 7.08086789e-03f,
  -4.98342663e-02f, 3.28490324e-02f, -3.00038438e-02f, 1.08875427e-03f, 2.80556045e-02f, 3.56926918e-02f, -8.18536282e-02f, 2.42217397e-03f, 5.03559336e-02f, 7.21129403e-02f,
  -1.88307464e-02f, -4.93619256e-02f, 2.50020567e-02f, -1.24084195e-02f, -1.97278876e-02f, 2.17885599e-02f, 3.00513394e-02f, -5.47471680e-02f, 1.99746564e-02f, -7.23014101e-02f,
  -3.57413548e-03f, 9.66344178e-02f, 1.58825498e-02f, -4.77925949e-02f, 1.78090390e-02f, -3.63193266e-03f, -5.87286130e-02f, -4.20919023e-02f, -6.88244402e-02f, 3.69510725e-02f,
  -2.01142192e-01f, -1.12213627e-01f, -1.07411623e-01f, 1.38937324e-01f, 7.66198291e-03f, -5.40869236e-02f, -9.01163891e-02f, -3.97861674e-02f, -1.41069397e-01f, -1.71108078e-02f,
  7.74079785e-02f, 1.05016731e-01f, 8.45318474e-03f, -1.15211485e-02f, -3.55056562e-02f, -5.92575409e-02f, -7.98704550e-02f, 2.29255259e-02f, 4.54444848e-02f, 2.73123942e-02f,
  -8.65655988e-02f, 2.50126105e-02f, -3.58412676e-02f, -4.06524613e-02f, -7.54300952e-02f, -6.94918111e-02f, 3.00225941e-03f, 8.96789227e-03f, 7.66326785e-02f, 2.56615337e-02f,
  -2.23498628e-01f, -5.29356347e-03f, -3.21489461e-02f, -9.92582589e-02f, 1.60175309e-01f, 1.68984905e-01f, 3.58738489e-02f, 1.90084904e-01f, 3.27238142e-02f, -8.31244364e-02f,
  6.78126365e-02f, -4.45481343e-03f, -9.04526487e-02f, -4.67267483e-02f, -5.60641885e-02f, -2.93679964e-02f, -2.32667044e-01f, -1.80720538e-01f, -9.04054716e-02f, 7.04576075e-02f,
  -8.80089775e-02f, -4.55683880e-02f, -1.53330237e-01f, -3.20402421e-02f, -1.54537156e-01f, -2.02704653e-01f, -6.70276061e-02f, -1.19284205e-01f, -5.14250854e-03f, -2.24803448e-01f,
  -9.80175138e-02f, 1.15447812e-01f, -1.47802196e-02f, -1.89904034e-01f, 1.74077917e-02f, -3.00469436e-03f, 6.85336292e-02f, -1.11114178e-02f, 3.97562720e-02f, -7.31703937e-02f,
  1.00007001e-02f, 3.25676762e-02f, -6.68238029e-02f, 1.03864558e-02f, -3.77093330e-02f, -1.38986856e-02f, -3.53498310e-02f, -3.67353112e-02f, -1.07275583e-01f, 1.53536826e-01f,
  -5.50592057e-02f, 4.43730364e-03f, -1.19613864e-01f, 7.41382316e-02f, 1.02299877e-01f, -1.49761125e-01f, 8.25421792e-03f, 1.34480027e-02f, -1.16054885e-01f, -2.53886908e-01f,
  1.50309200e-03f, 6.80487156e-02f, -3.03673893e-02f, 5.82783818e-02f, -3.71471941e-02f, 7.05582201e-02f, -3.16969194e-02f, 1.44140534e-02f, 2.73876283e-02f, -3.05033922e-02f,
  4.46331948e-02f, 4.05799709e-02f, -6.18890189e-02f, 2.22801715e-02f, 9.62894876e-03f, 5.80700524e-02f, -4.58027236e-02f, -9.83493105e-02f, -6.49598753e-03f, -6.07268943e-04f,
  -6.15646355e-02f, 1.32645657e-02f, 3.59160490e-02f, -4.42579426e-02f, -4.60014306e-02f, 1.30615933e-02f, -5.28837442e-02f, -2.15782188e-02f, -5.18996753e-02f, 6.27389029e-02f,
  -1.79431617e-01f, 4.25729640e-02f, -1.56493276e-01f, -1.01718530e-01f, -3.50097455e-02f, 6.29467517e-02f, 1.13260830e-02f, 2.71789972e-02f, 5.66968136e-02f, 2.32177880e-02f,
  2.62224507e-02f, -5.07002324e-02f, -6.57978002e-03f, -3.69844250e-02f, 4.30364907e-02f, -8.92396569e-02f, -1.08765684e-01f, -1.83139607e-01f, -4.19799685e-02f, 4.94457707e-02f,
  -9.29709226e-02f, -1.90998077e-01f, -2.61107594e-01f, -9.54591855e-02f, -1.07284792e-01f, -2.61440217e-01f, -1.48751959e-01f, -1.30157337e-01f, -1.96708828e-01f, -2.41810143e-01f,
  3.05734426e-02f, -1.34194076e-01f, 3.23022082e-02f, 4.84120324e-02f, 6.50155544e-02f, 2.96705127e-01f, 2.74933219e-01f, 2.25165077e-02f, -2.91481167e-02f, -1.06579214e-02f,
  -9.20426399e-02f, -1.58659309e-01f, -1.57356218e-01f, -1.96297109e-01f, -1.02656618e-01f, 1.71894044e-01f, 4.28257808e-02f, 9.80760083e-02f, 2.47756205e-02f, 3.86361852e-02f,
  1.16824813e-01f, 1.12661399e-01f, -1.63422469e-02f, -2.13198480e-03f, -1.11463144e-01f, -3.39336134e-02f, -1.27570242e-01f, -4.39202972e-02f, -1.12106428e-01f, -1.46601528e-01f,
  8.38560238e-02f, -3.21389973e-01f, -5.19746915e-02f, -1.17387533e-01f, -1.39084443e-01f, -1.75476167e-02f, 5.01858145e-02f, -1.23227447e-01f, -6.26172647e-02f, 1.09078228e-01f,
  -4.28072624e-02f, -9.51862335e-02f, -6.13636933e-02f, 2.48901336e-03f, 1.10280432e-01f, 4.68827337e-02f, -7.15851933e-02f, -3.85543890e-02f, -6.55975565e-02f, -1.20346829e-01f,
  -1.89175814e-01f, -1.11562945e-01f, 9.82514862e-03f, -2.64552627e-02f, -1.00923672e-01f, -3.73450220e-02f, -4.84683514e-02f, -1.26754358e-01f, -1.49889216e-01f, 1.01115026e-01f,
  4.38285396e-02f, 3.94755118e-02f, -4.59799394e-02f, -9.95496139e-02f, -1.27174705e-02f, 2.93322522e-02f, 4.97484356e-02f, -2.45836452e-02f, 1.01483643e-01f, 8.92355219e-02f,
  -7.00257570e-02f, -4.42344919e-02f, 4.56370190e-02f, 7.62252510e-03f, 6.73312135e-03f, -1.21208047e-02f, 6.81410134e-02f, 4.33309264e-02f, -1.23536810e-01f, -3.43123190e-02f,
  -4.38861288e-02f, 4.30024043e-03f, 6.40341118e-02f, 4.07170579e-02f, -2.74988078e-02f, -4.89508454e-03f, 5.25805494e-03f, -4.97473367e-02f, -2.60059685e-02f, 2.88701942e-03f,
  2.27495849e-01f, -2.54167527e-01f, 6.62436262e-02f, -2.44797934e-02f, 9.12718847e-03f, -7.61941522e-02f, -2.21918803e-02f, -1.75470412e-02f, -8.04108232e-02f, 7.08491169e-03f,
  -4.17232662e-02f, -3.50439474e-02f, -9.83829275e-02f, 7.18785599e-02f, 2.41626278e-01f, 1.36608541e-01f, 2.09603994e-03f, 4.83924821e-02f, -1.02913983e-01f, 3.55745330e-02f,
  1.16995916e-01f, 2.46648848e-01f, 2.07495496e-01f, 9.54920277e-02f, 1.06728643e-01f, 9.37381312e-02f, 1.21136844e-01f, 1.82551771e-01f, 1.61105782e-01f, 4.71332997e-01f,
  1.27720848e-01f, 1.39542148e-01f, -5.73410876e-02f, 9.47890058e-02f, 1.08005077e-01f, 1.32942230e-01f, 3.64573412e-02f, 2.49233674e-02f, 1.18444748e-01f, 6.56754151e-02f,
  1.80633157e-01f, 1.02031574e-01f, 1.68062180e-01f, 1.22574732e-01f, 1.17214128e-01f, 7.26203397e-02f, -1.41621986e-02f, 1.55499103e-02f, 5.51968254e-02f, -2.13892572e-03f,
  8.95289984e-03f, -7.14165857e-03f, -9.39701963e-03f, -6.25563338e-02f, 6.40119761e-02f, -3.16997990e-02f, -5.89834563e-02f, 3.33896764e-02f, 2.26179622e-02f, -5.44927642e-02f,
  -2.52392404e-02f, 1.34796603e-02f, 8.55623037e-02f, 6.22610524e-02f, -8.70339349e-02f, -1.00495830e-01f, -3.74162458e-02f, -2.58214604e-02f, -1.01197898e-01f, -9.60645974e-02f,
  -1.10264709e-02f, -1.44163041e-05f, 3.49730179e-02f, 1.98461488e-03f, -8.60393941e-02f, 5.37925027e-02f, -8.66539963e-03f, 7.29263760e-03f, 2.04402208e-02f, -4.71949726e-02f,
  -2.45023686e-02f, -4.65639047e-02f, 8.46086256e-03f, -2.80310046e-02f, 1.20981432e-01f, 1.12625569e-01f, -2.17207987e-02f, -9.23670921e-03f, 9.83945578e-02f, -4.93842363e-02f,
  1.89746879e-02f, 6.77378923e-02f, 1.23705015e-01f, -7.49363154e-02f, 3.45513187e-02f, 6.23801490e-03f, 2.23732963e-02f, -5.97517453e-02f, 7.83861428e-02f, -4.60056104e-02f,
  8.07174891e-02f, 7.80617222e-02f, 3.15342508e-02f, 5.55020235e-02f, 5.37528247e-02f, -9.95916650e-02f, -4.07380797e-02f, -1.10492948e-03f, -1.41372043e-03f, -8.73958599e-03f,
  8.85494873e-02f, 2.35580262e-02f, 1.73902139e-02f, 9.52616781e-02f, 3.17005627e-02f, 8.75046849e-02f, 5.98262437e-02f, -8.46252292e-02f, 9.01409015e-02f, -7.04525039e-02f,
  -9.04654246e-03f, 1.86140373e-01f, 3.79665866e-02f, -4.44105417e-02f, 3.34398523e-02f, 4.12412407e-03f, -2.52018180e-02f, -8.91069844e-02f, -1.27424404e-01f, -4.11312170e-02f,
  -4.63307351e-02f, -1.03133067e-01f, 4.73621264e-02f, -1.46437651e-02f, 8.63612071e-03f, -7.75528550e-02f, 2.04195152e-04f, 2.80808713e-02f, 8.95769969e-02f, 9.04790312e-02f,
  8.47869739e-02f, -9.48553346e-03f, 3.26606259e-03f, -2.80743372e-02f, 3.09335757e-02f, -4.86728409e-03f, 2.07570288e-02f, -4.94780438e-03f, 8.82483348e-02f, 6.13841005e-02f,
  -4.81714979e-02f, -1.13700390e-01f, -2.27740183e-01f, 1.82266943e-02f, 5.27005866e-02f, 6.03615344e-02f, 1.95158422e-02f, 2.14627869e-02f, -1.95908118e-02f, 1.69797416e-03f,
  5.91105185e-02f, 8.18775520e-02f, 1.05165370e-01f, 7.95182660e-02f, 4.52811085e-02f, 7.70309940e-03f, -2.13942342e-02f, -3.15790088e-03f, -5.16276062e-02f, 6.65585548e-02f,
  3.02091781e-02f, 9.55688581e-02f, -7.50920251e-02f, -1.25341378e-02f, 2.16464512e-02f, 4.30455171e-02f, -2.13292111e-02f, 1.03140496e-01f, 1.04724474e-01f, 1.47926033e-01f,
  -1.50490433e-01f, 3.30971293e-02f, 4.57500555e-02f, -6.43718941e-03f, -5.81269301e-02f, 4.40964922e-02f, 1.97314993e-02f, -2.63262307e-03f, -6.62321895e-02f, 4.28072922e-02f,
  4.30534454e-03f, 1.96236819e-02f, 6.08886778e-02f, 3.26860212e-02f, 7.80219352e-03f, -8.76617506e-02f, -5.53147309e-02f, -3.12047191e-02f, -2.11473578e-03f, -8.62667635e-02f,
  -2.22313181e-02f, 9.90618207e-03f, -6.89975172e-02f, -4.53363508e-02f, -1.09196305e-01f, -4.61460203e-02f, -1.22574894e-02f, -7.41413757e-02f, -8.59303474e-02f, 3.60739455e-02f,
  -5.05466945e-02f, -3.94447744e-02f, -7.40547031e-02f, 1.14598833e-02f, -2.18288172e-02f, 7.59250373e-02f, -4.06048261e-02f, 6.54420406e-02f, 5.71386032e-02f, 1.79630555e-02f,
  -2.71460041e-02f, -4.43109013e-02f, -9.80231315e-02f, 1.17025422e-02f, 7.99299106e-02f, -7.25497752e-02f, 3.51234302e-02f, 1.61657538e-02f, -8.59074816e-02f, -5.27535938e-03f,
  -5.72865270e-02f, -5.44839278e-02f, -6.54005632e-02f, 4.39301915e-02f, -9.40421447e-02f, 8.66890769e-04f, 3.23594026e-02f, 9.42042563e-03f, 5.46347629e-03f, 6.65751398e-02f,
  -6.25368059e-02f, -2.72955336e-02f, -8.24448168e-02f, 5.29959984e-03f, -4.97780852e-02f, -6.00943603e-02f, 2.73040477e-02f, -4.03621942e-02f, -8.99319127e-02f, 4.49894629e-02f,
  3.61546576e-02f, -9.30200219e-02f, -8.00404027e-02f, -6.74107894e-02f, -6.91649392e-02f, -6.29099533e-02f, -1.06641345e-01f, -7.06839189e-02f, 4.33787995e-04f, -8.75381008e-02f,
  -7.17939883e-02f, 3.03178281e-02f, -1.19849809e-01f, -9.31162760e-02f, -5.20232804e-02f, 2.43317802e-02f, 1.11637609e-02f, 3.13022807e-02f, -6.99562728e-02f, -2.12828466e-03f,
  -1.78028762e-01f, -3.99858087e-01f, -3.95250976e-01f, -1.56964481e-01f, -1.49503902e-01f, -1.30672798e-01f, -2.10092485e-01f, -1.37045547e-01f, -4.52634878e-02f, -3.14745754e-01f,
  -7.50735104e-02f, -6.29552528e-02f, -2.12596074e-01f, -1.99398831e-01f, -2.84278870e-01f, -4.36295211e-01f, -4.18113738e-01f, -2.66086489e-01f, -1.18532134e-02f, 4.88523282e-02f,
  -7.03364536e-02f, -7.71347582e-02f, -5.02486974e-02f, 3.03666387e-02f, 1.04844116e-01f, 2.18434911e-02f, -1.98427096e-01f, -9.50024799e-02f, -4.96255308e-02f, -4.08592150e-02f,
  -1.44063696e-01f, 7.13243335e-02f, 6.10470511e-02f, 7.42544904e-02f, -7.60757029e-02f, 2.34796070e-02f, 1.93031020e-02f, -2.37137415e-02f, 6.41007051e-02f, -1.78255551e-02f,
  4.41940129e-02f, 5.58695830e-02f, 8.98811817e-02f, -2.89184563e-02f, 3.56246979e-04f, 5.15065119e-02f, -6.84938803e-02f, -3.08248401e-02f, -1.30149145e-02f, 1.11137502e-01f,
  6.24802075e-02f, 5.00607565e-02f, -4.29808721e-02f, 5.64992428e-02f, 1.47978127e-01f, -4.54817601e-02f, 2.95081325e-02f, 1.98887855e-01f, 1.73447937e-01f, 1.59504693e-02f,
  -1.28949750e-02f, 1.41703878e-02f, 1.94935407e-02f, -3.69200781e-02f, 2.22439524e-02f, -6.23851530e-02f, -1.57554056e-02f, -1.86029058e-02f, 3.03707505e-03f, -6.92116767e-02f,
  -6.13615140e-02f, 1.74020045e-02f, 5.66508099e-02f, -6.85773343e-02f, 1.63369104e-02f, -7.32481852e-02f, 4.55060303e-02f, 4.09296295e-03f, -4.18903157e-02f, -3.72085832e-02f,
  9.98511259e-03f, 1.53885424e-01f, 4.23579589e-02f, 7.36937672e-02f, -3.37713882e-02f, -8.09508786e-02f, 3.46698985e-02f, 1.57500859e-02f, 1.03215195e-01f, -1.35728586e-02f,
  -1.13117188e-01f, -4.14365483e-03f, -8.09120983e-02f, 5.49039021e-02f, -2.83877812e-02f, 3.88971926e-03f, -3.59431393e-02f, -1.05124079e-02f, 2.63652056e-02f, -1.72459241e-02f,
  3.32517736e-02f, -4.47329879e-03f, -1.19948797e-01f, 5.16172014e-02f, 6.31651878e-02f, 5.50949946e-02f, -1.45863786e-01f, 6.70192949e-03f, 4.25554924e-02f, 9.04899389e-02f,
  -7.06979930e-02f, -2.70310286e-02f, -9.39814225e-02f, -1.15644835e-01f, 1.25947192e-01f, -8.30539688e-02f, -3.61662991e-02f, 1.23816036e-01f, -1.03064209e-01f, -2.22728327e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  2.24674627e-01f, 1.15146488e-02f, 1.40245810e-01f, 1.18855186e-01f, 4.50608373e-01f, 3.31827313e-01f, 7.45110735e-02f, 1.90543398e-01f, 1.15225598e-01f, 2.18272567e-01f,
  3.84010345e-01f, 7.29753524e-02f, 1.90668423e-02f, 1.04499578e-01f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.81127861e-01f, 1.29873529e-01f, -4.58595231e-02f, 4.69676405e-02f, 5.38575388e-02f, 2.35375091e-01f, 3.20017785e-01f, 9.98981819e-02f, -1.09538257e-01f, -4.36563700e-01f,
  -4.48240846e-01f, 2.98853457e-01f, 3.16964537e-01f, -3.60798329e-01f, 1.98150933e-01f, -3.93947065e-01f, 4.63208586e-01f, 8.67343619e-02f, 1.85567558e-01f, 1.29533876e-02f,
  1.40676886e-01f, 4.50632647e-02f, 1.38973594e-01f, -1.46866247e-01f, -2.22359300e-01f, -1.16038367e-01f, -5.03724739e-02f, -1.10569879e-01f, 2.12565750e-01f, -2.18141034e-01f,
  -2.42072530e-02f, -2.83696383e-01f, -2.44755536e-01f, 1.62594616e-01f, -1.27770424e-01f, 9.49893147e-02f, 2.89863907e-02f, 2.89284140e-01f, 1.55713230e-01f, -1.23058632e-01f,
  -3.66143361e-02f, 5.56957461e-02f, -1.04195170e-01f, -1.49587363e-01f, -3.15207154e-01f, 4.61000293e-01f, 1.26863644e-01f, -6.28861070e-01f, 3.35643351e-01f, -1.10041194e-01f,
  2.55300477e-02f, 7.74932504e-02f, 2.50436544e-01f, -4.64261584e-02f, -3.13589126e-01f, 7.46867284e-02f, 1.42257243e-01f, 2.36459434e-01f, -2.48856246e-01f, 4.25160564e-02f,
  -1.87319815e-01f, 3.73867452e-02f, -2.34838333e-02f, -2.22005799e-01f, -1.34926736e-01f, 2.39671290e-01f, 1.07783754e-03f, -3.08828093e-02f, -9.41908807e-02f, 4.38185483e-02f,
  1.46962300e-01f, 1.77446827e-01f, -9.61143523e-03f, 2.52827317e-01f, -2.15169072e-01f, 2.66267538e-01f, -2.24791691e-01f, 1.09869987e-01f, -1.70252204e-01f, -3.52443039e-01f,
  -8.17870721e-02f, 8.96529034e-02f, -2.17717335e-01f, 2.30393603e-01f, 2.15098500e-01f, 3.64086442e-02f, 2.71776259e-01f, -2.14628130e-01f, -1.10926099e-01f, 2.97572881e-01f,
  2.16734439e-01f, -3.27640474e-01f, 3.31222057e-01f, -3.66995782e-02f, -6.42467514e-02f, -3.29145938e-01f, 7.03621283e-02f, -2.75166810e-01f, -8.86547640e-02f, 2.91702282e-02f,
  1.27469242e-01f, -2.18497753e-01f, -1.27773866e-01f, -2.70707250e-01f, 7.61147812e-02f, -3.83338571e-01f, -1.42243341e-01f, -2.52814829e-01f, 2.27400407e-01f, -2.21290171e-01f,
  8.76977574e-03f, 7.32250437e-02f, -1.99828386e-01f, -2.72067279e-01f, 2.52532780e-01f, -2.17298791e-01f, -1.26893088e-01f, 4.39001173e-02f, -2.79312730e-01f, 3.63317847e-01f,
  2.32655659e-01f, 1.14320844e-01f, -6.82190880e-02f, 4.12481189e-01f, -2.06373438e-01f, 8.37158635e-02f, 7.76367933e-02f, 1.34969652e-01f, 1.17824621e-01f, 7.29474649e-02f,
  1.03650816e-01f, 2.91464031e-01f, 5.64939529e-02f, -2.40877792e-01f, 4.28368524e-02f, 6.40045404e-02f, 7.08314329e-02f, 9.16236788e-02f, -1.33856252e-01f, -2.29730129e-01f,
  -3.39226633e-01f, -2.99657017e-01f, -1.49482071e-01f, 2.72043258e-01f, -5.71333587e-01f, 1.03974305e-01f, -2.97418863e-01f, -3.03437263e-01f, -1.66224748e-01f, -1.81264892e-01f,
  2.84941643e-01f, 2.16410741e-01f, 3.70839655e-01f, 1.75659105e-01f, -9.94245522e-03f, 2.36128673e-01f, 1.11241579e-01f, 7.22738802e-02f, -5.60373366e-02f, -4.71018218e-02f,
  -2.14382149e-02f, -2.45498851e-01f, -6.76786378e-02f, -2.73829103e-01f, -1.94779798e-01f, -2.85934191e-02f, -3.24083567e-01f, -1.06081598e-01f, 6.70073703e-02f, 2.35410389e-02f,
  5.00541270e-01f, -2.24981979e-01f, 2.22698927e-01f, 2.84203887e-01f, -1.78811327e-01f, 3.79616290e-01f, -2.63616174e-01f, -2.09735826e-01f, -1.64920673e-01f, 2.99875796e-01f,
  2.38683019e-02f, 2.42696404e-01f, -2.26384416e-01f, -1.64964706e-01f, 2.76199222e-01f, -3.46737891e-01f, -3.43529820e-01f, 1.65587172e-01f, -1.20789461e-01f, 6.03042776e-03f,
  2.27580294e-01f, 3.03944916e-01f, -2.23681089e-02f, 1.04951732e-01f, -1.75134495e-01f, 3.19998083e-03f, 3.30999911e-01f, 6.15514442e-02f, -2.07133383e-01f, 2.40920216e-01f,
  5.61227240e-02f, 3.83689910e-01f, -9.45278779e-02f, -2.17432410e-01f, -6.42924488e-01f, 3.14285010e-01f, -1.23149619e-01f, -4.56699915e-02f, -5.73993087e-01f, 2.81082660e-01f,
  -2.59059250e-01f, -1.53421834e-02f, 2.04200462e-01f, -6.19011559e-02f, 3.18555176e-01f, 1.15991324e-01f, -1.16137974e-01f, 2.48702943e-01f, -1.54412642e-01f, 2.02106655e-01f,
  1.17785431e-01f, 6.18371479e-02f, -7.78380111e-02f, 2.06267357e-01f, -3.18147317e-02f, 8.34288448e-02f, 7.15704933e-02f, -1.82082355e-01f, 1.14144899e-01f, 9.10345763e-02f,
  2.57672787e-01f, -9.81619507e-02f, 1.57667592e-01f, -3.57761569e-02f, -5.39934993e-01f, 2.38092408e-01f, -2.34059542e-01f, 1.91520467e-01f, 2.25449845e-01f, -3.63500297e-01f,
  -3.05077791e-01f, 4.45840269e-01f, 2.63974845e-01f, -3.09616596e-01f, 5.32173142e-02f, 2.77005471e-02f, 1.68640748e-01f, 4.41875011e-01f, -1.27723381e-01f, 2.85836369e-01f,
  2.81822801e-01f, -5.74893132e-02f, 9.50963572e-02f, -1.15498401e-01f, -5.44822365e-02f, -2.45388925e-01f, 1.07057236e-01f, 3.69212836e-01f, 3.07615072e-01f, 1.73990548e-01f,
  2.59893626e-01f, 1.38176709e-01f, -6.80314228e-02f, -2.68347412e-01f, 2.25088909e-01f, 1.33086324e-01f, 1.06598683e-01f, -3.38664800e-01f, -4.84153539e-01f, 2.53691941e-01f,
  -1.72891751e-01f, 2.85701137e-02f, -2.62847543e-02f, 3.31464596e-02f, 1.09555252e-01f, -1.81102648e-01f, -1.07766375e-01f, -2.11067736e-01f, -2.41114095e-01f, 2.94237703e-01f,
  4.51922268e-02f, 3.69531184e-01f, -3.23869139e-01f, 1.63396537e-01f, -3.41770113e-01f, 6.58358559e-02f, 1.49255589e-01f, 3.23579818e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -9.54835787e-02f, 2.33082637e-01f, 4.92185839e-02f, 1.35580644e-01f, -8.34522024e-02f, 1.33051395e-01f, 2.19290853e-01f, 3.02096069e-01f, 1.70975089e-01f, 1.42483622e-01f,
  -2.75561988e-01f, 3.43615919e-01f, -1.57736599e-01f, -1.17273383e-01f, -1.75218899e-02f, 1.27346039e-01f, -3.15442868e-02f, 2.69273460e-01f, -1.82371736e-01f, 5.59531331e-01f,
  2.10509479e-01f, 5.23734868e-01f, 4.26779419e-01f, 2.84952521e-01f, -1.63406417e-01f, -1.23416156e-01f, -1.37230128e-01f, -6.92814291e-02f, -1.58171896e-02f, 2.60762453e-01f,
  2.43814379e-01f, 2.11424399e-02f, -3.57880779e-02f, 2.09106013e-01f, -2.15945281e-02f, 1.25689819e-01f, -5.97900338e-02f, 1.57644302e-01f, 4.81037982e-02f, 2.63005272e-02f,
  6.58818036e-02f, 3.65112811e-01f, 2.66926698e-02f, -2.19265923e-01f, -5.26446640e-01f, -2.32832089e-01f, 8.68602917e-02f, 2.64922474e-02f, -1.02642655e-01f, 2.86640763e-01f,
  9.25869048e-02f, -1.11927986e-02f, -8.58569890e-02f, 2.35004649e-01f, -5.17366119e-02f, -9.95002761e-02f, -7.01313242e-02f, 8.39376077e-02f, 2.55150586e-01f, -1.17349783e-02f,
  1.18472483e-02f, 1.29007414e-01f, -7.47226253e-02f, 1.12883553e-01f, 1.62219349e-02f, 7.57789910e-02f, 1.98107466e-01f, 3.80986691e-01f, 1.73629880e-01f, 2.16981202e-01f,
  -1.88922696e-02f, 9.07246545e-02f, 3.46600175e-01f, 4.90267798e-02f, 2.10214809e-01f, 5.51027246e-03f, -1.68326553e-02f, -2.61710525e-01f, -1.63971469e-01f, 5.15512705e-01f,
  -1.01704039e-01f, 9.71999019e-02f, 2.58290529e-01f, -1.95283875e-01f, -2.77341753e-01f, -3.88605334e-02f, 2.86053479e-01f, 4.26300973e-01f, 1.23158351e-01f, -2.77216136e-01f,
  -6.13300204e-02f, 1.42184675e-01f, -3.09304386e-01f, -8.17501247e-02f, 3.53317708e-02f, 4.94626462e-01f, -1.48962587e-01f, 2.67413765e-01f, -8.68861377e-02f, -3.11878938e-02f,
  -2.32860465e-02f, 1.28987148e-01f, 3.06711137e-01f, 3.45914871e-01f, 2.29840636e-01f, -4.41358417e-01f, -2.61564940e-01f, 6.81999847e-02f, 1.85532987e-01f, -7.56513476e-01f,
  5.33654392e-01f, 3.03255051e-01f, -1.65535763e-01f, -1.14875935e-01f, 4.44858044e-01f, -2.56129615e-02f, 4.66345102e-02f, 1.29070848e-01f, 1.91165164e-01f, 1.07717596e-01f,
  -5.53946197e-02f, -8.34971964e-02f, 4.29443359e-01f, -6.44062553e-03f, -3.43252867e-01f, 1.16136760e-01f, -7.53804576e-03f, 1.21747300e-01f, 1.79401845e-01f, -9.72830430e-02f,
  1.90643311e-01f, 1.65960547e-02f, -1.46939503e-02f, 5.10384440e-02f, -1.83877707e-01f, -4.43749037e-03f, 1.53980553e-01f, 2.55244195e-01f, 5.56624979e-02f, -3.91529612e-02f,
  -1.65841039e-02f, 1.43711388e-01f, -1.97128564e-01f, 3.02475840e-01f, -1.62131891e-01f, 1.60865799e-01f, 2.40794271e-01f, 2.99947232e-01f, 3.81173305e-02f, 3.30395043e-01f,
  -7.50575960e-02f, 4.08863649e-02f, -3.92003357e-02f, -1.65811628e-01f, -2.29401693e-01f, 7.37188710e-03f, 1.70090333e-01f, 1.33233726e-01f, 2.30204836e-01f, 4.26072031e-01f,
  5.36158681e-01f, 1.54030964e-01f, -9.70320478e-02f, 4.19661760e-01f, -5.37443273e-02f, 2.47518525e-01f, 2.18496814e-01f, 3.33518595e-01f, 2.94019170e-02f, 2.56288856e-01f,
  1.91347703e-01f, -1.54865244e-02f, 2.94550002e-01f, -3.08780432e-01f, -2.06384599e-01f, 3.61908287e-01f, -1.60516113e-01f, -1.84340581e-01f, 8.58339965e-02f, -1.00091152e-01f,
  1.73692033e-01f, 1.12023532e-01f, -9.89208817e-02f, -4.17368501e-01f, 1.21511169e-01f, -1.57421663e-01f, 2.87217628e-02f, -2.77120739e-01f, 6.71515822e-01f, -4.12156247e-02f,
  1.08042024e-01f, -1.05265062e-02f, 1.98068932e-01f, 1.05557814e-01f, 3.06288958e-01f, 5.03307283e-01f, 1.64638132e-01f, 1.46141663e-01f, 3.47730309e-01f, 1.82512090e-01f,
  1.82094559e-01f, -1.86437830e-01f, -4.41191524e-01f, 2.04294622e-01f, -4.87982817e-02f, -4.33181643e-01f, -1.05439052e-02f, 1.04785509e-01f, -4.49571759e-01f, 3.52394998e-01f,
  3.73740774e-03f, -2.02110887e-01f, -1.69241399e-01f, -7.70508051e-02f, 5.36591768e-01f, -3.33985090e-02f, -3.03022236e-01f, 1.31465822e-01f, 4.05412674e-01f, 2.80696839e-01f,
  3.84469569e-01f, 1.45256847e-01f, -4.11102874e-03f, -9.99846533e-02f, 1.06458843e-03f, 5.39123416e-01f, -2.10022554e-01f, 1.16283678e-01f, 2.69656211e-01f, 4.68985409e-01f,
  -4.61650528e-02f, 3.65987808e-01f, 9.87649634e-02f, 3.70983422e-01f, 2.50324309e-01f, -4.64686394e-01f, -6.50534093e-01f, 5.06291032e-01f, 1.23281553e-01f, -2.33760700e-01f,
  -1.97351158e-01f, -1.53763490e-02f, -1.95409805e-01f, -1.40375361e-01f, 1.36816755e-01f, -4.18848433e-02f, 1.05002530e-01f, -1.78815961e-01f, 7.87145644e-03f, 4.80190873e-01f,
  9.39125121e-02f, 2.79763132e-01f, 8.02261531e-02f, 2.66207069e-01f, -8.70416760e-02f, 3.11893284e-01f, -8.26466456e-03f, 2.34035999e-01f, -8.73420015e-02f, 1.37587219e-01f,
  -1.75948903e-01f, 5.43107763e-02f, -2.79463138e-02f, 5.41586690e-02f, -1.60229161e-01f, -1.38485089e-01f, 3.57305706e-02f, 1.03954971e-01f, -8.60984698e-02f, -8.10864419e-02f,
  -1.10707834e-01f, -1.67526543e-01f, 4.57651429e-02f, -1.47874027e-01f, 3.22779380e-02f, 2.30565339e-01f, 7.72499368e-02f, 1.35629386e-01f, -5.72576113e-02f, -4.02812138e-02f,
  1.81037456e-01f, -4.15214375e-02f, 2.04713698e-02f, 1.84046283e-01f, 1.06022976e-01f, 2.62282626e-03f, 1.93650976e-01f, -1.96415908e-03f, 4.94133234e-02f, 2.79817820e-01f,
  -1.83210135e-01f, 1.17726669e-01f, 2.44699791e-01f, 2.42460534e-01f, 2.25980282e-02f, 1.12512760e-01f, -1.03625655e-01f, 2.24371389e-01f, 4.86302637e-02f, 1.63458586e-01f,
  -3.31521153e-01f, 7.36834109e-02f, 2.04777569e-01f, -2.40163967e-01f, 7.10718520e-03f, 2.38026947e-01f, -7.15892836e-02f, -2.25962386e-01f, -5.25456294e-03f, -9.61914882e-02f,
  1.58277199e-01f, -1.36337485e-02f, 1.17164835e-01f, -8.68792757e-02f, -1.12586506e-01f, -2.35072538e-01f, 4.23280805e-01f, -5.45371436e-02f, 7.15828687e-02f, -1.57351166e-01f,
  -2.62185007e-01f, -1.38038784e-01f, -1.94359776e-02f, -1.20613232e-01f, 2.68070012e-01f, 6.57656267e-02f, 3.21391039e-02f, -9.12655964e-02f, 2.91281879e-01f, 5.49600869e-02f,
  4.26033378e-01f, -2.67373264e-01f, -3.72463346e-01f, 2.61279345e-02f, 1.77863628e-01f, 3.71383697e-01f, 8.44542459e-02f, 2.03177601e-01f, 1.84135273e-01f, -1.36573330e-01f,
  -1.51211351e-01f, 1.21150374e-01f, 2.34589249e-01f, -1.43984081e-02f, 1.60157919e-01f, -1.04586460e-01f, 1.06068462e-01f, -1.00929132e-02f, -2.04268068e-01f, 2.02543154e-01f,
  -2.50316896e-02f, 4.88037884e-01f, 1.43305706e-02f, 4.17376786e-01f, -3.73142585e-02f, 1.88706163e-02f, 6.23164587e-02f, 2.89561719e-01f, -4.11547907e-02f, 1.96940526e-01f,
  -4.17190716e-02f, -3.60054672e-01f, -1.45343080e-01f, -8.32128376e-02f, -1.28424719e-01f, 4.32745785e-01f, -3.22049744e-02f, -4.79471505e-01f, 2.39642970e-02f, 5.76335303e-02f,
  -1.18564544e-02f, 2.24147663e-01f, 1.06767967e-01f, -1.01002365e-01f, 6.26375666e-03f, 3.83858204e-01f, 5.74896559e-02f, 5.35109758e-01f, -1.51359271e-02f, 3.92538965e-01f,
  -2.28073094e-02f, -8.82673189e-02f, 3.64176817e-02f, 1.92017511e-01f, 2.80784547e-01f, 4.29859906e-01f, 5.24368763e-01f, 2.85521179e-01f, 3.39863122e-01f, 3.11732262e-01f,
  3.70101392e-01f, -1.46629468e-01f, 2.48462439e-01f, 2.37146258e-01f, 1.17505662e-01f, 3.33910733e-01f, 1.21390320e-01f, 2.84684598e-01f, 3.09212655e-01f, -5.06924510e-01f,
  7.18971908e-01f, 9.98140648e-02f, 7.33157158e-01f, -1.67260647e-01f, 6.20759688e-02f, -2.46380661e-02f, -1.57943055e-01f, -1.13240883e-01f, -2.41255730e-01f, 1.65362358e-01f,
  -1.65168233e-02f, -8.97246134e-03f, -4.79402766e-02f, -1.84921399e-01f, 8.60331282e-02f, -8.75724107e-02f, 4.21935737e-01f, -3.91631648e-02f, -1.59641787e-01f, 2.24808604e-01f,
  6.78938106e-02f, -3.04951263e-03f, 1.94012269e-01f, -6.11878969e-02f, 6.17222525e-02f, -2.95593470e-01f, 1.07663833e-01f, -1.13783948e-01f, 2.61179358e-01f, 7.40574673e-02f,
  -2.62616158e-01f, -1.59747228e-01f, -6.17563650e-02f, -2.65891075e-01f, -1.99057028e-01f, 2.54140705e-01f, -6.31414503e-02f, 2.73621351e-01f, -2.32510149e-01f, 8.12924504e-02f,
  -1.01390325e-01f, 2.55006015e-01f, -1.82683766e-01f, 5.04158795e-01f, 1.21833056e-01f, 2.64394358e-02f, 1.99845657e-01f, 4.09825444e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.99812114e-01f, 1.93450347e-01f, 3.53930384e-01f, 1.03353269e-01f, 3.22858430e-02f, 1.81051344e-01f, 1.90459058e-01f, 4.56767023e-01f, -8.77757519e-02f, 1.20493084e-01f,
  1.96530700e-01f, 4.47407328e-02f, 2.33847335e-01f, 2.18417510e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -7.39232421e-01f, -1.45523429e-01f, -5.56787908e-01f, -2.77332157e-01f, -2.26689428e-01f, -6.34042263e-01f, -2.93412685e-01f, -5.09597063e-02f, -4.12262648e-01f, -1.13858327e-01f,
  -2.75141954e-01f, -1.92063585e-01f, 2.41663247e-01f, 8.74561816e-02f, 3.89026761e-01f, 7.23303556e-02f, -2.94779718e-01f, 9.36124027e-02f, -3.84689420e-01f, -5.99016137e-02f,
  4.09501016e-01f, -4.07898009e-01f, 4.55219477e-01f, 6.35772571e-02f, -2.09485680e-01f, 2.43869588e-01f, -1.01974420e-01f, 8.06761384e-02f, 4.67246860e-01f, -1.69382855e-01f,
  -3.83098155e-01f, 3.97977054e-01f, 1.96184471e-01f, 1.29409090e-01f, 4.08409178e-01f, 3.16770941e-01f, -7.28787184e-02f, 2.34675467e-01f, -3.44193846e-01f, 2.16621116e-01f,
  -4.06358950e-02f, -8.02407801e-01f, -4.54999268e-01f, 7.45289624e-02f, -4.67566311e-01f, 2.51137912e-01f, 1.92609176e-01f, 4.89043742e-01f, -5.24201989e-02f, 4.00613755e-01f,
  3.55775237e-01f, 5.63293457e-01f, 3.20254117e-01f, 2.63819009e-01f, 1.53063044e-01f, 8.13178271e-02f, -8.60806704e-02f, 3.61428201e-01f, -7.17024133e-02f, 7.18373209e-02f,
  5.77815652e-01f, -5.61130226e-01f, -6.28856301e-01f, -5.71905315e-01f, 6.17236551e-03f, 4.49038334e-02f, 3.30172211e-01f, 1.62379760e-02f, 4.52515990e-01f, -4.86369669e-01f,
  6.98393703e-01f, 3.36157605e-02f, -2.80743390e-01f, 2.94968814e-01f, 5.45894682e-01f, 2.21534923e-01f, -9.96680409e-02f, -1.93437248e-01f, -5.97785294e-01f, -1.55485913e-01f,
  2.32448980e-01f, 3.40489388e-01f, -1.46251142e-01f, -8.20101053e-03f, 5.94265237e-02f, -5.02976835e-01f, -2.26308912e-01f, -2.22275808e-01f, 1.77154496e-01f, 1.27865136e-01f,
  7.98940435e-02f, 2.47174546e-01f, 1.23103775e-01f, 5.62482253e-02f, 9.74668384e-01f, -2.27474973e-01f, -1.20158531e-02f, 2.63470765e-02f, 1.82151869e-01f, -1.11876115e-01f,
  -3.22764456e-01f, 2.18233481e-01f, -3.89857799e-01f, -8.45857859e-02f, -4.57596689e-01f, -4.54311222e-01f, 4.00228739e-01f, -3.55071992e-01f, 2.46370181e-01f, 4.10288990e-01f,
  -1.74016386e-01f, 1.05082005e-01f, 8.50051820e-01f, -1.97305024e-01f, -3.99669297e-02f, 7.13747293e-02f, -3.86240035e-01f, -3.16313773e-01f, -1.54266879e-01f, -3.19297194e-01f,
  1.51493803e-01f, 6.33761466e-01f, 7.79794976e-02f, -1.45563319e-01f, -3.79310489e-01f, 7.16223478e-01f, -1.53753445e-01f, 2.07771257e-01f, 4.63002652e-01f, 1.56274706e-01f,
  -5.47253132e-01f, -5.95226139e-02f, 1.69883460e-01f, 3.69150847e-01f, 5.25724292e-01f, 3.04036528e-01f, -3.38236064e-01f, -1.91743255e-01f, 2.83647120e-01f, -5.45450807e-01f,
  3.98120224e-01f, -1.49819121e-01f, 5.17422557e-01f, 5.87718487e-01f, -6.30124092e-01f, 5.60740888e-01f, -2.51195669e-01f, -3.40726763e-01f, -8.93986225e-02f, 4.23210740e-01f,
  -4.70267892e-01f, -3.62594664e-01f, -2.47100890e-01f, 3.72937590e-01f, 1.32913530e-01f, 2.72555719e-03f, 1.20753169e-01f, 4.21031743e-01f, -1.38852283e-01f, 4.85624224e-01f,
  5.04190981e-01f, -1.62246063e-01f, 1.84681922e-01f, 3.29030156e-01f, 7.58992583e-02f, 3.53131354e-01f, 6.40644133e-01f, 2.24912316e-01f, 5.28731406e-01f, -1.40922129e-01f,
  -6.59225166e-01f, -1.66668057e-01f, 2.29012787e-01f, 5.21985292e-01f, 2.09115848e-01f, -4.97535244e-02f, -6.88443422e-01f, 2.27791712e-01f, -1.45787910e-01f, -2.61826962e-01f,
  1.14647426e-01f, -1.13056950e-01f, 3.10032442e-02f, 9.77786303e-01f, 4.57621753e-01f, -2.30137303e-01f, 2.10551694e-01f, -2.50648320e-01f, -3.99383128e-01f, -4.00364101e-01f,
  -4.02069896e-01f, 3.66565645e-01f, -5.44579864e-01f, 1.00813434e-01f, 3.55475098e-01f, 1.58341110e-01f, -1.88933417e-01f, -4.50273812e-01f, -4.65827823e-01f, -2.12470755e-01f,
  1.17946729e-01f, 3.21095362e-02f, -1.74927324e-01f, 1.56523705e-01f, 2.70853937e-01f, -6.99583113e-01f, -4.50108975e-01f, -5.56153953e-01f, 7.49592111e-02f, -6.59433901e-01f,
  -1.11519871e-02f, 2.05735080e-02f, -2.10339591e-01f, 7.88127422e-01f, -3.24679703e-01f, 2.22680807e-01f, 6.83619007e-02f, -5.72014630e-01f, 8.39171484e-02f, -1.93622597e-02f,
  -2.01899782e-01f, -3.30035716e-01f, 3.34237963e-01f, -2.11968511e-01f, -1.65078580e-01f, -1.76059008e-01f, -2.71922708e-01f, -1.51977971e-01f, -4.82334495e-01f, 7.61296973e-02f,
  2.13402048e-01f, 2.38771349e-01f, -2.71283954e-01f, 4.10210341e-01f, 2.55915225e-01f, 4.47047442e-01f, -2.82349348e-01f, -5.23613334e-01f, 3.73630106e-01f, -2.08561599e-01f,
  -5.31810261e-02f, -5.17014921e-01f, 8.72093379e-01f, -1.89378500e-01f, -3.99723500e-01f, -3.33377391e-01f, 1.43136337e-01f, -9.92655233e-02f, -3.60929757e-01f, -1.08894698e-01f,
  2.97394216e-01f, -1.88471317e-01f, -1.56102374e-01f, 2.54405588e-01f, -1.21853963e-01f, 3.78871799e-01f, -1.03425443e-01f, -6.41580373e-02f, -5.32999992e-01f, -6.59652770e-01f,
  1.13449134e-01f, -2.29564011e-01f, -2.23019242e-01f, -3.50749582e-01f, -1.58019103e-02f, 4.15512472e-01f, -3.69402111e-01f, 4.88137811e-01f, -5.21086037e-01f, 2.23637074e-01f,
  -3.27282131e-01f, 4.48687494e-01f, 5.63865043e-02f, -4.86805618e-01f, 4.27849770e-01f, -1.31170809e-01f, -3.11530679e-01f, -2.04331309e-01f, -6.98799938e-02f, 2.97210127e-01f,
  5.99008441e-01f, -2.80756969e-02f, -9.42000560e-03f, 4.87122118e-01f, -2.36521214e-01f, -7.02791847e-03f, 1.47942947e-02f, -3.00065577e-01f, 2.17932239e-01f, 2.31767356e-01f,
  3.89019772e-03f, 2.11359948e-01f, -1.29626513e-01f, 3.92117828e-01f, -1.82915062e-01f, 3.58594805e-01f, 4.77291226e-01f, 5.63726366e-01f, 1.73261195e-01f, -4.24260557e-01f,
  4.45805818e-01f, -4.84733284e-01f, 1.10073887e-01f, -9.34405684e-01f, 1.24381445e-01f, 3.65875959e-01f, 6.83540776e-02f, -3.65435988e-01f, 3.05168122e-01f, -1.91008672e-02f,
  2.19201073e-01f, -7.96795338e-02f, -6.13911569e-01f, -6.23634100e-01f, -4.99710143e-02f, -1.28380880e-01f, 9.51120853e-02f, -7.18851537e-02f, 8.28777492e-01f, 8.44958276e-02f,
  3.69991690e-01f, -2.07034141e-01f, -9.82511602e-03f, 3.12879309e-03f, 3.70211959e-01f, 4.14483964e-01f, 4.83311154e-02f, 3.01274508e-01f, 4.49492127e-01f, -2.09075272e-01f,
  5.80982566e-01f, 6.82203174e-01f, -4.95596170e-01f, -7.58159831e-02f, -1.73965558e-01f, 4.46129024e-01f, -6.16343971e-03f, 2.77127206e-01f, -4.14688647e-01f, -4.75267833e-03f,
  -7.40422189e-01f, -5.52697539e-01f, -2.12254018e-01f, 4.02965575e-01f, -5.15865624e-01f, 8.16879034e-01f, -4.30352911e-02f, 4.32309002e-01f, -1.69392794e-01f, 3.14503908e-02f,
  6.77063242e-02f, -4.00225744e-02f, 1.53853312e-01f, 1.26280384e-02f, 2.93210030e-01f, 8.24069530e-02f, 9.65543762e-02f, -1.69739604e-01f, 5.16714573e-01f, -5.07913232e-01f,
  1.94670543e-01f, 1.70231745e-01f, -3.04078668e-01f, -3.01446281e-02f, 3.65070045e-01f, 4.57601428e-01f, -5.95830940e-02f, 7.57986382e-02f, 1.60977662e-01f, -3.50205809e-01f,
  2.49158263e-01f, -1.86698705e-01f, 4.50548202e-01f, 5.51545680e-01f, -2.74226874e-01f, -4.86439377e-01f, 7.25286663e-01f, -5.76683521e-01f, -1.63113952e-01f, -1.95730627e-01f,
  1.42255891e-02f, -1.23283379e-01f, -6.19455874e-01f, -9.56929624e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  2.49661021e-02f, -1.62085235e-01f, 2.89711263e-02f, -1.53750762e-01f, 2.51097810e-02f, 2.43705869e-01f, 1.22639626e-01f, 4.90811504e-02f, -5.70568033e-02f, -9.16746724e-03f,
  -3.85156162e-02f, -5.31252697e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    