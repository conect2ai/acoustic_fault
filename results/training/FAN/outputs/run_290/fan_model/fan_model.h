/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.91270486e-01f, 4.48172927e-01f, 1.58095002e-01f, -2.61412501e-01f, -1.79818049e-01f, -1.76789448e-01f, -2.68392682e-01f, 5.52397221e-02f, 1.24226687e-02f, 3.83837149e-02f,
  -1.57567590e-01f, 1.65858701e-01f, 2.05752924e-01f, -1.52833521e-01f, -1.65735483e-01f, 3.04641545e-01f, -2.21857712e-01f, -8.01002160e-02f, 1.15898296e-01f, -1.12141361e-02f,
  -3.50367762e-02f, -8.44785124e-02f, -5.97329773e-02f, 6.87359124e-02f, -1.47132292e-01f, 2.50638351e-02f, -1.93932112e-02f, 8.42669755e-02f, -9.98679474e-02f, -2.73288283e-02f,
  -1.13224708e-01f, 7.98455253e-02f, -2.18458064e-02f, 6.99879527e-02f, -7.62913898e-02f, -3.75754982e-02f, -1.10752173e-01f, -1.06003694e-02f, -3.43426801e-02f, -2.18712483e-02f,
  3.57219465e-02f, -3.34756598e-02f, 2.18053758e-02f, 8.76669139e-02f, -1.07941449e-01f, 4.88697104e-02f, 2.67181043e-02f, -3.65479738e-02f, 1.16724418e-02f, 6.30791718e-03f,
  5.74789457e-02f, -1.40522681e-02f, -3.53534222e-02f, 3.11558824e-02f, -9.52823926e-03f, -1.20927405e-03f, 1.08291013e-02f, 1.68248527e-02f, -1.30172521e-02f, 1.92161798e-02f,
  5.74295409e-02f, 6.28766092e-03f, 6.30832165e-02f, -9.41327235e-05f, -4.04424742e-02f, -4.23265919e-02f, -2.99342293e-02f, 6.80682191e-04f, 1.67934410e-02f, 3.37627456e-02f,
  -6.71775639e-02f, -2.51688492e-02f, -4.35673930e-02f, -1.08883046e-02f, -5.20235524e-02f, -5.30597195e-02f, -1.69608686e-02f, 6.15995266e-02f, -7.19323829e-02f, -1.88531522e-02f,
  3.80855426e-02f, -1.68414246e-02f, 2.66172178e-02f, -1.16162887e-02f, 1.85478721e-02f, 1.42856371e-02f, 5.21125719e-02f, 1.91180333e-02f, 4.32751374e-03f, -7.06803054e-02f,
  4.53818589e-02f, 3.17333341e-01f, 4.35273089e-02f, -2.71263532e-02f, 7.51168057e-02f, 5.30401766e-02f, 5.26487939e-02f, 1.80917960e-02f, 5.11570424e-02f, 5.48841879e-02f,
  -2.47656610e-02f, -2.65882406e-02f, -2.76502315e-03f, -7.20955804e-02f, 2.48226058e-02f, 1.35410586e-02f, 1.82847846e-02f, -1.75598972e-02f, -4.51130383e-02f, 2.42435876e-02f,
  7.30695762e-03f, -2.50550564e-02f, -2.79086325e-02f, -2.17798036e-02f, -1.78853944e-02f, 5.67526789e-03f, 4.62272838e-02f, -6.13040640e-04f, 4.02165279e-02f, 7.53085092e-02f,
  7.78686255e-02f, -7.48265460e-02f, -3.09829175e-01f, 6.59337118e-02f, 7.61694536e-02f, 2.03753397e-01f, 1.65643662e-01f, 1.54244415e-02f, -1.11397676e-01f, 1.79661721e-01f,
  1.59172222e-01f, -1.40323922e-01f, 5.35912365e-02f, 1.79127231e-01f, 2.11808816e-01f, -1.26578268e-02f, 1.73587158e-01f, 1.38889089e-01f, -1.46297202e-01f, 7.92673826e-02f,
  -5.56748174e-02f, 3.75273615e-01f, -3.40523720e-02f, 8.26695655e-03f, 1.15831673e-01f, -1.39690146e-01f, 3.12682509e-01f, -1.03167549e-01f, 1.55862272e-01f, 7.47549161e-02f,
  9.17033404e-02f, -5.94222955e-02f, -7.17276409e-02f, -3.77971642e-02f, 1.24914825e-01f, 3.28757577e-02f, -6.95429742e-03f, -9.91505105e-03f, -3.90771925e-02f, -7.23072365e-02f,
  2.18022969e-02f, 5.48694469e-03f, -5.83717674e-02f, -3.61285754e-03f, -2.05155369e-02f, -1.04927018e-01f, -3.63533758e-02f, -2.06131339e-02f, -2.19282582e-02f, 8.19074642e-03f,
  -9.45385769e-02f, -4.53606248e-02f, -1.61048081e-02f, -2.59489380e-02f, -5.03401719e-02f, -3.52311544e-02f, -4.68398351e-03f, 1.09661818e-02f, -1.15208523e-02f, -1.01252291e-02f,
  -6.59608096e-02f, 2.55105570e-02f, 4.29820269e-03f, -1.89935174e-02f, 8.86142347e-03f, 1.73796210e-02f, 3.67049426e-02f, 5.57953976e-02f, 1.93528449e-05f, 5.51254600e-02f,
  3.67903411e-02f, 4.29360047e-02f, -2.51599103e-02f, -2.01842226e-02f, 8.90873596e-02f, -3.82515579e-03f, 1.79763287e-02f, 8.78917705e-03f, -3.99923921e-02f, -3.01379934e-02f,
  -4.57256194e-03f, 7.95088895e-03f, 5.60435466e-03f, 3.37606631e-02f, 7.89983850e-03f, -9.33024287e-03f, 2.64033545e-02f, -1.72941331e-02f, -2.13961098e-02f, 1.05096057e-01f,
  3.63592237e-01f, 3.15347016e-01f, -5.75869791e-02f, 5.04409596e-02f, 8.75680998e-04f, 5.23510389e-02f, 4.12984975e-02f, -1.90727692e-02f, 4.19206135e-02f, 2.41264310e-02f,
  -3.83667904e-03f, 1.60492714e-02f, 6.93621784e-02f, 4.41874713e-02f, 4.13318351e-02f, 6.02465048e-02f, 8.22437853e-02f, 6.45084754e-02f, 6.63953125e-02f, 6.13736250e-02f,
  6.62303790e-02f, 5.18569015e-02f, -4.13452871e-02f, -5.58942044e-03f, 4.84305471e-02f, 5.91759477e-03f, -1.52612256e-03f, -5.93571290e-02f, 5.52325323e-02f, 7.69870402e-03f,
  -2.09439084e-01f, -1.23730190e-01f, 2.30461314e-01f, -2.77914226e-01f, 1.00905411e-01f, 1.80747271e-01f, 2.17631832e-01f, -1.91269740e-01f, -6.50229082e-02f, -1.55772135e-01f,
  -4.88445051e-02f, -5.74663058e-02f, 2.78596550e-01f, -3.38968664e-01f, 4.15964834e-02f, 1.07333682e-01f, -1.93921581e-01f, -7.32354447e-02f, 5.63232526e-02f, -1.70992628e-01f,
  -8.70084837e-02f, -2.65722871e-01f, -4.32878695e-02f, -1.65075939e-02f, -1.93114117e-01f, -3.15037034e-02f, -2.07985371e-01f, 3.04652214e-01f, -9.99337658e-02f, 4.08346532e-03f,
  -4.75452617e-02f, -1.97950616e-01f, 2.26344503e-02f, -2.00869739e-02f, -1.30884260e-01f, 1.01837538e-01f, 3.20110321e-02f, 1.09177500e-01f, 8.95916000e-02f, 2.07042210e-02f,
  6.73482120e-02f, 9.37295798e-03f, -1.16401732e-01f, 3.68201956e-02f, 4.19977605e-02f, 6.73473030e-02f, -4.13897932e-02f, 3.71488258e-02f, -2.74671540e-02f, 7.48934820e-02f,
  1.85441895e-04f, 5.57872131e-02f, -5.62510360e-03f, -2.05717031e-02f, 4.19859253e-02f, 5.37558384e-02f, 6.43727463e-03f, 5.24648279e-02f, 7.73709454e-03f, -2.66861673e-02f,
  1.74880084e-02f, 5.55067249e-02f, -1.52180148e-02f, -1.73318516e-02f, -8.95170346e-02f, -9.40354168e-02f, 4.08726595e-02f, -3.54115739e-02f, 2.92270202e-02f, -2.90594194e-02f,
  -5.14928028e-02f, -2.45171897e-02f, -5.12097254e-02f, 8.32421333e-02f, -3.40972655e-02f, -5.32994755e-02f, 3.44877504e-02f, -2.31710132e-02f, -4.38037254e-02f, 4.37542470e-03f,
  -4.21034321e-02f, 1.04158614e-02f, 1.11480686e-03f, 2.98698433e-02f, -1.40781188e-02f, 2.84111593e-02f, -1.13687478e-02f, 1.75702048e-03f, 2.21310649e-02f, 1.41681470e-02f,
  -4.67375889e-02f, -2.58766294e-01f, 8.58941860e-03f, 6.00883178e-02f, 3.73315141e-02f, -3.66368368e-02f, 4.73563783e-02f, -3.88819873e-02f, -5.51478937e-03f, -3.52470465e-02f,
  -1.90964714e-02f, -1.46680539e-02f, -1.70908067e-02f, 2.77956054e-02f, 6.59763664e-02f, -3.63007188e-02f, -8.73811264e-03f, 5.11267781e-03f, -2.24254001e-03f, -1.20111657e-02f,
  7.90295471e-03f, -2.28330698e-02f, 2.68693622e-02f, -7.34634027e-02f, 3.31688449e-02f, -5.49802557e-03f, -4.76024114e-02f, 7.10134655e-02f, 5.53776063e-02f, 4.84390184e-02f,
  3.57117541e-02f, 1.50511444e-01f, 3.20621848e-01f, 9.07958373e-02f, -1.32839188e-01f, -1.27050458e-02f, 8.51563066e-02f, 2.46241167e-02f, 2.32245892e-01f, -6.95974380e-02f,
  -1.23662010e-01f, 1.15348296e-02f, 2.24170908e-01f, 2.98193954e-02f, 1.60660341e-01f, 2.02326357e-01f, 3.92537266e-02f, -1.08853936e-01f, 1.36371329e-01f, -1.11846020e-02f,
  9.08582062e-02f, -1.86674371e-01f, 2.54018217e-01f, -1.39754295e-01f, -4.48285900e-02f, -1.65309943e-02f, -2.89697379e-01f, -3.85244167e-03f, -3.10838580e-01f, -1.03779666e-01f,
  -7.83507451e-02f, 1.03724480e-01f, 1.04276724e-01f, 6.51210770e-02f, 3.90512161e-02f, -8.49959552e-02f, -1.35560776e-03f, 3.47533193e-03f, 2.03898530e-02f, 8.31546448e-03f,
  -3.08299512e-02f, -8.07008892e-02f, -9.66815501e-02f, 6.09620623e-02f, 5.60471155e-02f, -5.69676887e-03f, -1.69698393e-03f, 8.51565693e-03f, -3.30216391e-03f, 4.14400995e-02f,
  1.70692742e-01f, 3.60574499e-02f, 4.55812365e-02f, 3.20101948e-03f, 8.20676833e-02f, 2.01864205e-02f, 6.17398843e-02f, 1.80551186e-02f, -1.13879619e-02f, -2.15509050e-02f,
  2.11044513e-02f, 1.14863748e-02f, 6.57542199e-02f, -1.04073063e-02f, 2.79816613e-03f, -5.16924784e-02f, 3.24504599e-02f, -3.36712636e-02f, -2.17816811e-02f, -7.78969657e-03f,
  -6.34101108e-02f, -1.69766750e-02f, -4.48394381e-02f, 2.16687694e-02f, 8.95676482e-03f, -2.09308788e-02f, -6.30512554e-03f, -1.10413440e-01f, 7.01091215e-02f, -5.68116084e-02f,
  3.14659881e-03f, -3.58823361e-03f, 1.88249592e-02f, -1.37194498e-02f, 4.91484478e-02f, 1.95907205e-02f, 1.37101440e-02f, 6.39106855e-02f, -5.18407766e-03f, -2.63519026e-02f,
  -1.78749889e-01f, -1.93604559e-01f, -7.31616765e-02f, -5.12408465e-02f, -7.12024271e-02f, -4.83395671e-03f, 1.04628634e-02f, -6.17605448e-02f, 2.68492959e-02f, 1.89550146e-02f,
  -2.71325614e-02f, -3.19722481e-03f, -2.02222280e-02f, -1.38193171e-03f, 4.44602594e-03f, 3.80042568e-02f, -2.30853502e-02f, -7.68962875e-02f, -9.62416828e-02f, -8.64919350e-02f,
  -1.20227963e-01f, -1.80489812e-02f, -1.90482801e-03f, -8.35345685e-02f, -8.85599703e-02f, -6.16695657e-02f, -9.25495103e-02f, 5.33580408e-02f, -7.64614493e-02f, 5.04134782e-02f,
  4.15378027e-02f, 3.98934752e-01f, -1.88760743e-01f, -1.99711338e-01f, -1.53912306e-01f, 1.24617636e-01f, 2.17064135e-02f, -9.38844159e-02f, 1.39717370e-01f, 2.72285551e-01f,
  -1.15404591e-01f, 1.62011385e-01f, 6.17948957e-02f, -7.37498105e-02f, -1.54028490e-01f, 1.34183168e-01f, -2.60031200e-03f, 1.99292764e-01f, 7.55861402e-02f, 4.89318445e-02f,
  -1.49765536e-01f, -9.62716118e-02f, -2.41440848e-01f, -9.67064872e-02f, -1.25984803e-01f, -3.90762165e-02f, -5.98797649e-02f, -7.81269297e-02f, 2.65683867e-02f, -6.89206645e-02f,
  5.70694217e-03f, -5.00712134e-02f, -7.53593519e-02f, -7.68934144e-03f, -9.91253704e-02f, -4.39469106e-02f, 4.64897938e-02f, -6.88507706e-02f, -7.37388954e-02f, 6.55271485e-03f,
  1.01062745e-01f, -5.46492971e-02f, -1.70956608e-02f, 4.42341827e-02f, 7.05590239e-03f, 7.00597093e-03f, -1.05149277e-01f, -3.28858234e-02f, -1.06119230e-01f, -7.61172995e-02f,
  -4.14208584e-02f, -4.59191054e-02f, -1.20891303e-01f, -6.37184083e-03f, -3.63801718e-02f, -4.54213545e-02f, -4.02253643e-02f, -5.92534803e-02f, -1.09161325e-02f, -2.25033443e-02f,
  3.40243652e-02f, 4.44122963e-03f, -4.63208705e-02f, -1.79099478e-02f, 2.12775059e-02f, -6.45307004e-02f, 2.55206749e-02f, -5.42467162e-02f, -2.10798737e-02f, -2.86651921e-04f,
  -2.68561523e-02f, -1.84883066e-02f, 7.09952181e-03f, 1.55637767e-02f, -1.18645281e-02f, 5.67439049e-02f, -3.11108958e-02f, -1.77339669e-02f, -3.96559723e-02f, -3.86852883e-02f,
  2.50517782e-02f, 5.48417196e-02f, 6.61563352e-02f, -6.46656081e-02f, 5.72075099e-02f, -3.81952263e-02f, -6.07196912e-02f, 3.11223678e-02f, -5.59628829e-02f, 1.93810482e-02f,
  2.68815756e-01f, 2.78862029e-01f, -3.47452462e-02f, 4.55815084e-02f, 1.29772991e-01f, 1.13024162e-02f, -1.97726558e-03f, 4.15276960e-02f, 9.22066644e-02f, 4.15746979e-02f,
  -6.96582794e-02f, -6.58908784e-02f, 1.05708614e-01f, 2.44230242e-03f, -6.71695024e-02f, 9.32689663e-03f, 8.50500911e-02f, 2.40301108e-03f, 1.08165592e-02f, -3.96839902e-03f,
  -5.07863238e-03f, -5.13856285e-05f, -4.68131043e-02f, -7.52338991e-02f, -1.42001063e-02f, 6.69935048e-02f, 6.36303946e-02f, 5.34132309e-02f, 2.98861023e-02f, 7.39060268e-02f,
  -5.21487772e-01f, 9.65355113e-02f, -1.65450051e-01f, -1.69710413e-01f, 2.26373911e-01f, 9.53834504e-02f, -4.36273552e-02f, 1.96510360e-01f, -2.68833041e-02f, 2.04138041e-01f,
  4.10444215e-02f, -2.17324734e-01f, -3.26025002e-02f, -7.85816982e-02f, -3.45768511e-01f, -1.37493536e-01f, -9.89181399e-02f, -1.19807839e-01f, 2.73988582e-02f, -6.65719509e-02f,
  -5.05007319e-02f, 1.13678254e-01f, -1.42714545e-01f, 3.72163862e-01f, 2.43262127e-02f, 8.35849717e-02f, -6.34360984e-02f, 2.00480357e-01f, -2.82737762e-02f, 5.83831593e-02f,
  3.77092138e-02f, -5.36858989e-03f, -1.02057699e-02f, 3.38298343e-02f, -4.89899237e-03f, -4.87746820e-02f, -7.28575513e-03f, -1.19030178e-02f, -5.09039685e-02f, 5.00031933e-02f,
  -4.08876427e-02f, -1.88095830e-02f, 5.44711202e-02f, 6.17949143e-02f, 1.84838269e-02f, -5.06268553e-02f, -9.13029239e-02f, -3.21492516e-02f, 4.91782278e-02f, -5.39927222e-02f,
  -4.84455489e-02f, -7.18594640e-02f, -7.36506358e-02f, 4.58538570e-02f, -5.44386618e-02f, -3.66687663e-02f, -5.17595634e-02f, -4.95792255e-02f, -2.70865355e-02f, -3.37074511e-03f,
  -1.12105263e-02f, 2.26823073e-02f, 1.03452066e-02f, -1.47693120e-02f, 2.82925647e-02f, 5.49957296e-03f, 2.68581435e-02f, 4.96014487e-03f, -3.36164259e-03f, 1.99056119e-02f,
  2.17406023e-02f, -2.15761550e-02f, 4.20199372e-02f, -2.96486448e-02f, -2.60480922e-02f, 2.72607487e-02f, -3.75267901e-02f, -3.69387567e-02f, -1.78902335e-02f, -3.57580520e-02f,
  8.45528319e-02f, 3.02915601e-03f, -2.62331888e-02f, 2.61025485e-02f, 1.68681424e-02f, -9.41252988e-03f, 2.76020858e-02f, 2.18511838e-02f, -5.44656441e-03f, -1.39502874e-02f,
  5.37867770e-02f, 5.64156026e-02f, 5.65584078e-02f, 3.66073623e-02f, 2.82408297e-02f, 8.62395465e-02f, 1.59716746e-03f, -5.77433314e-03f, 8.62642154e-02f, -3.96115138e-05f,
  -2.45763287e-02f, 2.82219257e-02f, -6.71087801e-02f, -4.35004979e-02f, 7.89680425e-03f, 4.05969173e-02f, -5.56060858e-02f, 6.73640147e-02f, 1.92574004e-03f, 7.90126808e-03f,
  6.12278469e-03f, -4.00390010e-03f, 3.67751382e-02f, 1.10668140e-02f, 5.92027828e-02f, 9.40590166e-03f, 1.25418445e-02f, 2.22996864e-02f, -2.79744063e-02f, 8.72609206e-03f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.95510518e-02f, 1.52186900e-01f, -1.46206969e-03f, -2.34468028e-01f, -4.42399979e-02f, 3.95614281e-02f, -1.29805520e-01f, 1.64440274e-01f, 2.05590948e-01f, 9.57043767e-02f,
  -4.64781150e-02f, -3.86674516e-02f, 1.70046121e-01f, -8.18097964e-02f, -3.82660180e-02f, 1.41009584e-01f, -2.21664622e-01f, -2.20866725e-01f, 9.22610313e-02f, -1.51929155e-01f,
  -1.41032308e-01f, -2.58442879e-01f, -1.76083252e-01f, -1.34010121e-01f, -2.68938154e-01f, -5.80131188e-02f, -1.90713331e-01f, -5.49186654e-02f, -1.96267858e-01f, -2.53395196e-02f,
  1.22920871e-02f, 9.41256210e-02f, 1.11996248e-01f, 1.38152167e-01f, 6.16825484e-02f, -6.15937412e-02f, 2.83837728e-02f, -3.96023430e-02f, -5.22716939e-02f, 8.70135427e-02f,
  -8.10734257e-02f, 4.82543670e-02f, -2.92363614e-02f, 2.60362849e-02f, -3.25837284e-02f, 6.48270771e-02f, -1.30748162e-02f, -7.49009103e-02f, 2.64334157e-02f, -2.63777114e-02f,
  -7.45875239e-02f, 9.67890769e-02f, 8.15534778e-03f, 3.91080454e-02f, -4.83609829e-03f, -8.80687162e-02f, -7.10112378e-02f, -1.03303418e-01f, 2.71160174e-02f, 8.00279807e-03f,
  -3.20817456e-02f, 8.26023892e-02f, -6.61208183e-02f, 7.53682703e-02f, 3.28835957e-02f, 3.85657884e-02f, -9.28971469e-02f, 4.62078582e-03f, 4.77721691e-02f, 2.29862928e-02f,
  2.40678079e-02f, 4.05123569e-02f, 2.73199212e-02f, -5.44817783e-02f, -8.71029198e-02f, -5.81472442e-02f, 4.01629927e-03f, 2.16959231e-02f, -1.02104276e-01f, 2.71724183e-02f,
  -4.01017116e-03f, -2.25425791e-02f, -3.56391892e-02f, 6.60587382e-03f, -5.51050715e-02f, 5.87091371e-02f, -3.74487638e-02f, 2.12993212e-02f, 3.92568186e-02f, -7.02895075e-02f,
  -3.98896374e-02f, -5.86704686e-02f, 9.80663002e-02f, 1.23457797e-01f, -1.38622092e-03f, 2.76550520e-02f, 5.42209148e-02f, 8.83148462e-02f, 6.29988387e-02f, 6.18071184e-02f,
  3.68049070e-02f, -1.33867748e-02f, -4.99189459e-02f, 4.30799797e-02f, -6.56339452e-02f, 1.04706381e-02f, -1.39473051e-01f, -8.09962302e-02f, -5.35491183e-02f, 5.92183918e-02f,
  -2.43019629e-02f, -4.93232422e-02f, -8.23036060e-02f, -8.90816823e-02f, 9.56718903e-03f, -3.94616798e-02f, 1.03176080e-01f, 9.76698846e-02f, 2.10049283e-02f, -7.04964995e-02f,
  -1.18414521e-01f, 5.56988157e-02f, -2.51771901e-02f, 2.96808649e-02f, -1.75624102e-01f, -1.03029102e-01f, -1.48268966e-02f, -8.60078037e-02f, -2.54567303e-02f, 5.45680895e-02f,
  1.20650440e-01f, -8.75224918e-02f, 2.41889730e-01f, 1.70231331e-02f, 5.92395589e-02f, 3.62922728e-01f, -1.04690477e-01f, 7.27576464e-02f, -2.31798855e-03f, -8.64852443e-02f,
  1.25951157e-03f, -7.52084479e-02f, 1.72921285e-01f, -1.19524948e-01f, -2.28392065e-01f, -5.78901209e-02f, 8.77440274e-02f, -9.36593488e-02f, -2.05559865e-01f, 4.79267016e-02f,
  -8.76209661e-02f, -6.37795124e-03f, -1.95503887e-03f, -5.88848963e-02f, -1.33446887e-01f, -1.19319007e-01f, 3.66394222e-02f, 3.51284482e-02f, -4.79545332e-02f, -8.74070674e-02f,
  1.68038756e-02f, 5.29838540e-02f, -5.66479266e-02f, -1.94599442e-02f, -1.03318661e-01f, 3.25432830e-02f, 4.44744788e-02f, 3.09930779e-02f, 4.69597913e-02f, -3.94080766e-02f,
  -1.29476748e-02f, -4.94546373e-04f, 4.68320064e-02f, 1.51369709e-03f, -1.86576620e-02f, -9.10365283e-02f, 5.10050915e-02f, 3.06430925e-02f, -1.01606362e-01f, -7.57148340e-02f,
  -7.25048333e-02f, -4.24824692e-02f, 3.77173051e-02f, 2.38537230e-02f, -9.94951651e-03f, 7.62912706e-02f, 1.51104173e-02f, 9.83494520e-02f, 4.09371257e-02f, 5.45400903e-02f,
  1.17647350e-02f, -5.68121262e-02f, -1.68782584e-02f, 1.41421882e-02f, 2.83748843e-02f, 3.50505821e-02f, 4.53208275e-02f, -7.51229972e-02f, -2.72031724e-02f, 4.57223952e-02f,
  -2.79117487e-02f, 2.15742886e-02f, -2.82373820e-02f, -1.04741193e-01f, -8.30065683e-02f, 1.12863727e-01f, -1.95477121e-02f, -3.24814171e-02f, 7.23709241e-02f, 7.56025128e-03f,
  -5.52852526e-02f, -1.97705301e-03f, 5.24797998e-02f, 2.13429867e-03f, 1.88141223e-02f, -7.64851049e-02f, 5.82838953e-02f, -7.63376057e-02f, -2.12237071e-02f, 5.15332296e-02f,
  -8.59203264e-02f, -4.55077998e-02f, -9.75592434e-02f, -1.72589719e-02f, -7.96345770e-02f, -1.00076415e-01f, -5.42653091e-02f, -2.08343137e-02f, -8.31824467e-02f, 5.44512784e-03f,
  4.78713028e-02f, -1.16718169e-02f, 3.47459093e-02f, -7.11273402e-02f, -4.57532965e-02f, 6.24107979e-02f, 1.11316433e-02f, -3.94036323e-02f, -1.06696852e-01f, 4.84658256e-02f,
  8.17221627e-02f, -1.03622094e-01f, -6.79520220e-02f, 7.69648775e-02f, 3.08717079e-02f, -6.29627553e-04f, -6.06561378e-02f, -1.23374678e-01f, -8.05598870e-02f, -5.09563871e-02f,
  -2.26576868e-02f, 1.27325132e-01f, -1.93771049e-01f, -2.38158643e-01f, -2.69343287e-01f, -1.86086074e-01f, -1.34108633e-01f, -1.92186553e-02f, 2.86778319e-03f, 1.36664249e-02f,
  6.70844037e-03f, -1.55194327e-01f, -1.87174052e-01f, -5.71275353e-02f, 5.56121580e-02f, 2.28462130e-01f, 1.61169827e-01f, -2.64255982e-02f, 1.33768320e-01f, 4.41396832e-02f,
  3.30432580e-04f, -3.19256075e-02f, -5.91330491e-02f, -2.91523654e-02f, 1.24923671e-02f, 4.54738811e-02f, 3.93588841e-02f, -4.70253639e-02f, 7.13136867e-02f, 3.37443613e-02f,
  1.26067847e-01f, 7.53347352e-02f, 2.59406231e-02f, -1.89446211e-02f, -8.09187256e-03f, 1.34692919e-02f, -4.80749980e-02f, 4.50294986e-02f, 6.13306388e-02f, 1.96887203e-03f,
  -6.53793514e-02f, 1.08175084e-01f, 1.06548399e-01f, 2.05282848e-02f, -1.46841733e-02f, -5.26401363e-02f, 3.41570787e-02f, 1.03200562e-01f, 3.17892954e-02f, -5.94028234e-02f,
  4.04941328e-02f, 7.91117921e-02f, 4.18180898e-02f, -7.49686360e-02f, -7.33327940e-02f, -2.00324021e-02f, 3.54874283e-02f, -5.85571192e-02f, 1.41355600e-02f, -1.54470885e-02f,
  2.45518181e-02f, 6.34514680e-03f, -4.03107554e-02f, -4.20290530e-02f, 7.12789502e-03f, -6.45905435e-02f, 2.20299996e-02f, 4.33208756e-02f, 5.98663241e-02f, 2.85591744e-02f,
  -1.97284613e-02f, -3.93526517e-02f, 4.87794634e-03f, 1.63412541e-02f, 1.51319308e-02f, -9.55711827e-02f, 6.18644468e-02f, -2.64956076e-02f, -4.40123305e-03f, -2.26781960e-03f,
  -4.38228957e-02f, 4.59546186e-02f, 5.63317686e-02f, -5.89037687e-02f, -2.17652414e-02f, 6.74661323e-02f, -1.04753606e-01f, -1.15736187e-01f, -7.64436424e-02f, -9.66216624e-02f,
  1.33927628e-01f, 4.95559350e-03f, 6.20936044e-02f, -6.32588845e-03f, 6.71558008e-02f, -4.28939648e-02f, -1.12885404e-02f, 8.03165957e-02f, 1.42079681e-01f, 5.32141998e-02f,
  6.08524755e-02f, 4.02799658e-02f, 1.55175924e-02f, -1.47115579e-02f, 3.11304606e-03f, 2.21883561e-02f, 4.74672802e-02f, 4.75487560e-02f, -7.83981849e-03f, -1.08618550e-02f,
  -7.98412636e-02f, -4.33261320e-02f, 1.85955942e-01f, -2.42968738e-01f, -2.22359486e-02f, 2.83359349e-01f, 1.12112314e-01f, 5.76249808e-02f, 1.44567238e-02f, -2.14639559e-01f,
  -1.88161001e-01f, 4.12078500e-02f, 1.63155884e-01f, -6.39571473e-02f, 3.08935493e-01f, 1.69833928e-01f, -3.83416638e-02f, -1.39969081e-01f, 2.71436088e-02f, -1.89963102e-01f,
  -5.35521470e-02f, -1.92343906e-01f, -5.77369332e-02f, 1.24636451e-02f, -1.37612820e-01f, -1.69332206e-01f, -1.46454852e-02f, 6.19599111e-02f, -1.83400914e-01f, 1.44157246e-01f,
  4.93702516e-02f, -1.56756058e-01f, 2.53915805e-02f, 1.27784759e-01f, 7.50806704e-02f, 2.46116752e-03f, -1.36766443e-02f, 2.95531214e-03f, -4.40568477e-02f, -1.10240944e-01f,
  3.48124281e-02f, 5.41313961e-02f, 1.13406451e-03f, -2.76499949e-02f, -1.23179488e-01f, -9.69004631e-03f, 8.25280622e-02f, -5.74145429e-02f, 4.00288403e-02f, -3.98173146e-02f,
  -6.09622262e-02f, 4.35865335e-02f, -6.21492714e-02f, -7.90090859e-02f, -5.62423468e-02f, -2.28148745e-03f, -7.56804040e-03f, 8.34664181e-02f, 6.14615902e-02f, -6.73190430e-02f,
  -4.37085554e-02f, 1.00717068e-01f, -8.19696020e-03f, -1.01212241e-01f, 6.90831766e-02f, 6.04237206e-02f, -4.29292992e-02f, -8.20095912e-02f, -7.55714402e-02f, -5.88306189e-02f,
  -1.04625575e-01f, -6.92330003e-02f, -3.46397310e-02f, -8.10915139e-03f, -3.91842835e-02f, -9.05864090e-02f, -2.96413247e-02f, 1.40658319e-02f, 5.34640849e-02f, 1.39897745e-02f,
  -6.90565929e-02f, 5.12740202e-02f, -3.98384817e-02f, -9.94377807e-02f, 5.66655248e-02f, -1.39644521e-03f, -9.41202790e-03f, 3.77834626e-02f, -6.20788056e-03f, -2.93930620e-02f,
  1.21941514e-01f, -4.30205325e-03f, -1.60372742e-02f, 5.96829802e-02f, 5.50565869e-02f, 3.92684080e-02f, 8.76415968e-02f, 2.42905691e-02f, 5.06105684e-02f, 5.93481250e-02f,
  -3.01767867e-02f, -7.03865811e-02f, -3.59748267e-02f, -3.50802206e-02f, -3.19140702e-02f, 2.81426534e-02f, -3.00093777e-02f, 7.98390806e-02f, 5.98828234e-02f, 3.28219645e-02f,
  3.50731798e-02f, 3.50834355e-02f, 8.96440223e-02f, -8.40872824e-02f, -2.71562543e-02f, -1.60343498e-02f, 1.18630356e-03f, -2.67684031e-02f, -7.11588636e-02f, 6.34121075e-02f,
  3.51982653e-01f, 2.11278990e-01f, -2.29978040e-01f, -1.68726414e-01f, -7.42200837e-02f, 2.13662192e-01f, 1.71935290e-01f, 6.55646324e-02f, -3.12519744e-02f, 2.44522214e-01f,
  9.62589383e-02f, 6.11832552e-02f, 8.46610516e-02f, 2.50372559e-01f, 1.14997640e-01f, 4.13122177e-02f, 2.62998343e-01f, 2.47583643e-01f, -9.11254510e-02f, 1.83901295e-01f,
  -5.55551350e-02f, 1.88508943e-01f, -1.68504626e-01f, 4.04871628e-02f, 1.63738638e-01f, -1.46963134e-01f, -1.53196275e-01f, -2.68020928e-01f, -1.20858392e-02f, 2.78315041e-02f,
  1.58280596e-01f, 2.77653113e-02f, -1.64489597e-02f, -8.94759521e-02f, 1.17216252e-01f, 1.08903833e-01f, -9.59678181e-03f, -1.12568833e-01f, -6.13325201e-02f, -7.41591454e-02f,
  6.79658428e-02f, -7.26412758e-02f, 5.12012839e-02f, -6.89390078e-02f, 6.17094599e-02f, -5.69171011e-02f, 2.32352745e-02f, -1.04966991e-01f, 2.65516085e-03f, 5.99935874e-02f,
  -3.75551544e-02f, 7.26080015e-02f, -2.06999704e-02f, 8.95178318e-02f, 1.56306438e-02f, -4.74662222e-02f, -4.29068506e-02f, 4.83034551e-02f, 6.49795905e-02f, 4.51039374e-02f,
  3.36843915e-02f, 5.64234667e-02f, 1.68338306e-02f, -4.40096967e-02f, 2.19524149e-02f, 4.09861617e-02f, -5.10235503e-02f, -8.81580822e-03f, 1.96232926e-02f, 4.56256904e-02f,
  -1.08997494e-01f, -4.27361503e-02f, 6.09205030e-02f, 9.71838757e-02f, 2.26513743e-02f, -8.22217949e-03f, 3.74907516e-02f, -1.57348607e-02f, 3.80890109e-02f, -1.05598323e-01f,
  2.22395360e-02f, 7.77316242e-02f, -4.88806143e-02f, -5.23996577e-02f, 1.58363190e-02f, -1.38326893e-02f, 6.79711923e-02f, -4.48410341e-04f, -9.39670205e-03f, -5.97218163e-02f,
  8.00126418e-02f, 2.15998758e-02f, 4.45232876e-02f, 1.34857465e-02f, -1.35693466e-02f, 1.41784355e-01f, -3.11800907e-03f, 1.00674696e-01f, -6.71736971e-02f, -2.30884850e-02f,
  2.86691263e-02f, -3.89116071e-02f, 1.45775191e-02f, -9.64631978e-03f, -9.34242904e-02f, 1.12522513e-01f, -3.28033566e-02f, -7.72754177e-02f, -2.56501473e-02f, 7.55714029e-02f,
  -5.09273410e-02f, 2.78708395e-02f, 4.43817116e-02f, -3.77989225e-02f, -1.12917386e-02f, -6.65344447e-02f, -2.16711201e-02f, -1.32742420e-01f, 2.54609641e-02f, 4.39159125e-02f,
  -6.42175972e-02f, -1.14195727e-01f, -2.45637655e-01f, -1.60779878e-01f, -2.28881165e-02f, -2.20928609e-01f, -2.50045836e-01f, -1.79126099e-01f, -4.42092493e-02f, 3.86345834e-02f,
  -2.87250075e-02f, 5.12275919e-02f, 1.68820411e-01f, -2.33683273e-01f, -8.20076168e-02f, 1.07697666e-01f, -3.51043195e-01f, -2.13669881e-01f, -5.09597883e-02f, -2.21206203e-01f,
  -1.40273854e-01f, -7.60679320e-02f, -1.55473739e-01f, -7.14369640e-02f, -2.21157402e-01f, 4.89514768e-02f, 1.60420671e-01f, 6.95382208e-02f, -1.36841685e-01f, -2.74447985e-02f,
  -1.97157972e-02f, -1.01045266e-01f, -8.25376734e-02f, 4.98657264e-02f, -5.18992692e-02f, -6.33788703e-04f, -4.78522442e-02f, 7.68745467e-02f, -5.96258976e-02f, -1.12905212e-01f,
  1.53916692e-02f, -3.93170258e-03f, -8.47273469e-02f, 1.96467899e-02f, 3.89184617e-02f, 1.28577352e-02f, -9.35006812e-02f, 4.91394522e-03f, -3.48875560e-02f, 4.11525927e-02f,
  -5.96095324e-02f, 1.56793837e-02f, -8.46591145e-02f, -4.19440866e-02f, 4.82613966e-02f, -4.14580591e-02f, -2.36777272e-02f, -3.95224430e-02f, 1.96084529e-02f, -6.81334585e-02f,
  1.10800024e-02f, -1.98678225e-02f, -8.18336010e-02f, 6.42784312e-02f, 1.68852098e-02f, 4.86205630e-02f, -4.71227616e-02f, 2.98214033e-02f, 7.66675100e-02f, -5.63161559e-02f,
  -5.95542081e-02f, 4.33832891e-02f, -2.83058342e-02f, 2.41992977e-02f, -2.33205594e-02f, -5.11535406e-02f, -8.54704063e-03f, -4.48529748e-03f, -7.44874328e-02f, -5.17190807e-02f,
  1.18832663e-02f, -6.97505772e-02f, 3.57585102e-02f, -3.11651081e-02f, 9.86231957e-03f, -2.65424629e-03f, 8.28673989e-02f, -7.30147138e-02f, 5.30691333e-02f, -5.81159955e-03f,
  -1.21973753e-01f, -1.63983181e-01f, -9.34991688e-02f, 6.13747686e-02f, 3.37706096e-02f, 3.59590054e-02f, 2.68797744e-02f, -5.64834066e-02f, -1.60855427e-02f, -9.81328338e-02f,
  5.21390736e-02f, -4.56130542e-02f, -5.25295213e-02f, -5.46424650e-02f, -8.49688128e-02f, -4.72783223e-02f, 4.43393178e-02f, 2.53923796e-02f, -4.58671749e-02f, 7.07280338e-02f,
  2.23717839e-02f, -3.50064263e-02f, 3.46929617e-02f, -1.62711125e-02f, -3.74535322e-02f, 6.70145750e-02f, 4.94487174e-02f, 9.93794799e-02f, 2.03275476e-02f, -3.51306871e-02f,
  -2.81832188e-01f, 3.46954226e-01f, 2.02268869e-01f, -2.51121283e-01f, 1.83310121e-01f, 6.69039339e-02f, -8.93809646e-02f, 1.07474029e-01f, 6.49850443e-02f, -3.27849798e-02f,
  -9.56233814e-02f, -1.15359657e-01f, 2.11945608e-01f, -7.75082707e-02f, -1.96762785e-01f, 6.33610561e-02f, -2.72285402e-01f, -2.07237482e-01f, 1.04861952e-01f, -5.70605546e-02f,
  -3.71686444e-02f, -5.96675724e-02f, 1.34824321e-01f, 2.94452429e-01f, 8.27171952e-02f, -6.03094744e-03f, -1.15326673e-01f, 1.60319239e-01f, -8.76297429e-02f, 4.41090502e-02f,
  -1.74220189e-01f, -1.42556727e-01f, -1.64261669e-01f, -1.25079617e-01f, -7.42156729e-02f, -8.34923312e-02f, -1.08772814e-01f, -6.26422092e-02f, -2.81863008e-02f, 2.78375968e-02f,
  -5.74297924e-03f, 1.26825757e-02f, 3.69509347e-02f, 6.42429739e-02f, 6.44048378e-02f, 3.99342105e-02f, -7.43105030e-03f, 2.31358837e-02f, 5.62238358e-02f, 1.77090481e-01f,
  4.78139035e-02f, -5.94378561e-02f, -9.14175585e-02f, -1.23972602e-01f, 5.92588494e-03f, 9.04677883e-02f, -8.85559898e-03f, 9.31686535e-03f, -1.00871377e-01f, -1.63636729e-03f,
  1.20719187e-02f, -7.74525180e-02f, -3.77823738e-03f, -5.11093922e-02f, 8.07797238e-02f, -1.64255798e-02f, -3.11010629e-02f, 2.49438435e-02f, -6.18205965e-02f, 1.11329993e-02f,
  6.39341995e-02f, -3.97356004e-02f, 3.06061991e-02f, -8.40175804e-03f, -6.20712563e-02f, -7.62803946e-03f, -4.83474135e-02f, -5.42147085e-02f, -1.14797130e-02f, 7.90521055e-02f,
  -8.89372174e-03f, 1.72181167e-02f, 1.41258584e-02f, -4.75467518e-02f, 3.60630378e-02f, 2.91339029e-03f, 5.62404282e-02f, -9.34059545e-03f, -7.64430910e-02f, 3.71604525e-02f,
  -2.54527301e-01f, -2.10278824e-01f, -2.31675785e-02f, -9.51905102e-02f, -3.82075794e-02f, -1.24296350e-02f, -1.04451634e-01f, -2.74886005e-02f, -1.06820032e-01f, -5.16692847e-02f,
  -6.83305636e-02f, -2.44201608e-02f, -2.13758182e-02f, -5.73769175e-02f, -6.02589138e-02f, -1.00468807e-01f, -2.79469807e-02f, -1.06429800e-01f, -1.54177606e-01f, -4.85732853e-02f,
  3.50079127e-02f, 6.04787935e-03f, -7.91291073e-02f, 2.88914349e-02f, -8.18302780e-02f, -1.06464349e-01f, -1.00403436e-01f, -1.36678275e-02f, 6.39476031e-02f, 3.42412181e-02f,
  1.40864002e-02f, 5.45853138e-01f, 2.96304196e-01f, 5.71614429e-02f, 2.61307843e-02f, -3.35389286e-01f, -8.19447488e-02f, 6.05058409e-02f, 9.47502558e-04f, 2.13677660e-01f,
  -2.14062743e-02f, 4.12473410e-01f, 1.24410994e-01f, -9.92320478e-02f, -8.20814312e-01f, -3.06357026e-01f, -3.38071257e-01f, -1.06261231e-01f, -1.15425311e-01f, 5.51186875e-02f,
  -2.25715518e-01f, -1.68028206e-01f, -6.72086030e-02f, 9.06062871e-02f, 1.98459297e-01f, 3.61290753e-01f, -1.10245124e-01f, 2.15853661e-01f, 1.62811041e-01f, -6.31601289e-02f,
  -7.48657361e-02f, 2.01203033e-01f, 2.15720683e-01f, 3.21258232e-02f, -6.95453957e-02f, 1.51617015e-02f, 3.74536682e-03f, -6.31801318e-03f, -4.36586881e-04f, -5.94602898e-02f,
  7.95785785e-02f, 1.88271347e-02f, -3.34862433e-02f, 1.77533608e-02f, 1.10727906e-01f, 9.76762846e-02f, 1.82905141e-02f, 9.14376080e-02f, 5.25465682e-02f, 9.25572291e-02f,
  1.01469725e-01f, 1.94984842e-02f, 6.23856634e-02f, -2.06169896e-02f, -5.13868965e-02f, -3.82318310e-02f, -4.39173989e-02f, 2.78094038e-02f, 5.40613011e-02f, -5.82165532e-02f,
  7.75357801e-03f, -3.98553424e-02f, -4.59661968e-02f, -4.51470958e-03f, 2.02907510e-02f, 4.40991074e-02f, -4.41738442e-02f, 1.68772209e-02f, 2.45766006e-02f, -4.01295833e-02f,
  -1.35867046e-02f, 9.46508050e-02f, 3.46255787e-02f, -7.85727277e-02f, -3.68434712e-02f, -3.56752202e-02f, -3.56326848e-02f, -1.78835820e-02f, -8.98075465e-04f, 1.64264138e-03f,
  -8.92593898e-03f, -7.09370747e-02f, 2.99974550e-02f, 1.31451916e-02f, -6.31268770e-02f, -1.55004868e-02f, 5.14803976e-02f, 2.85998862e-02f, -3.94625366e-02f, -2.26400159e-02f,
  -2.09432259e-01f, -7.36880153e-02f, 3.84331420e-02f, 7.94517100e-02f, -1.58888381e-02f, -4.08746414e-02f, 6.40305318e-03f, 3.46937589e-03f, -1.03960231e-01f, -1.25293434e-02f,
  1.29275378e-02f, -6.66421046e-03f, -2.56878175e-02f, 4.39501181e-02f, -8.74399692e-02f, -1.91456545e-02f, 4.12452035e-02f, 2.45861653e-02f, -5.55445291e-02f, 1.31929163e-02f,
  9.64503363e-02f, 5.91960698e-02f, -1.05193323e-02f, -3.37521806e-02f, -3.99396792e-02f, 4.69344333e-02f, -5.25944214e-03f, 5.15730232e-02f, -3.92030552e-02f, -1.11009488e-02f,
  1.44959614e-01f, -5.74085526e-02f, -1.60886973e-01f, 1.73383690e-02f, -4.41969447e-02f, -3.76571804e-01f, -3.95955056e-01f, -7.08319247e-02f, 1.82115912e-01f, -2.93202400e-02f,
  1.06219202e-02f, 2.58438103e-02f, 1.28154680e-01f, -2.68380225e-01f, 3.05602141e-02f, 1.53467849e-01f, -3.54943901e-01f, -1.57008544e-01f, 1.94247682e-02f, -1.09719172e-01f,
  -4.09860611e-02f, 4.85303253e-02f, -3.57125066e-02f, -6.71930462e-02f, -1.86561316e-01f, 4.42144796e-02f, 1.40209690e-01f, 6.50657043e-02f, -2.27788329e-01f, 8.78819674e-02f,
  -8.80291089e-02f, 1.75040185e-01f, -4.10020240e-02f, -3.84545289e-02f, -9.81471315e-02f, -9.64242294e-02f, -1.02141552e-01f, 4.49608685e-03f, 5.10432459e-02f, -2.06298232e-02f,
  8.55385363e-02f, 1.25353606e-02f, -3.86301614e-02f, 8.92414227e-02f, -2.50077974e-02f, -4.30429131e-02f, -3.08996700e-02f, -3.47012132e-02f, 7.67378062e-02f, 1.24105271e-02f,
  -5.91852516e-03f, -5.86957671e-02f, 3.92275043e-02f, -4.64815460e-02f, -9.04228818e-03f, 1.55846383e-02f, -2.28543002e-02f, 2.96100453e-02f, -2.72124354e-02f, -1.45426411e-02f,
  -1.27772419e-02f, -7.79491803e-03f, 3.34365517e-02f, 1.89890172e-02f, -1.96398553e-02f, 1.40632270e-02f, 2.55268700e-02f, -4.23051082e-02f, -4.50239182e-02f, -1.03967227e-01f,
  4.97120954e-02f, -4.40782588e-03f, 8.08878615e-02f, -1.16712553e-02f, 5.59755638e-02f, 1.66962352e-02f, 3.04022171e-02f, -1.31097781e-02f, -9.86725371e-03f, 5.81511855e-03f,
  3.46364118e-02f, 2.24425644e-02f, -1.74638499e-02f, 6.65959492e-02f, -7.10278228e-02f, -3.90651748e-02f, 7.22160637e-02f, -4.87211347e-02f, -2.93699428e-02f, 5.88381179e-02f,
  -4.96987738e-02f, -3.00048050e-02f, -5.00658760e-03f, 1.16960062e-02f, -4.48304601e-02f, 9.76202730e-03f, -2.50138696e-02f, 9.35187656e-03f, -1.13821412e-02f, 6.36017844e-02f,
  -1.19307481e-01f, -2.51004118e-02f, -1.14498138e-02f, 1.02541536e-01f, -3.03424913e-02f, 4.53451136e-03f, 4.75343652e-02f, 3.36559042e-02f, -4.21477705e-02f, 1.57994013e-02f,
  1.26118250e-02f, 1.03625720e-02f, 2.92876121e-02f, -5.40020019e-02f, 4.45237346e-02f, 4.90804277e-02f, 1.28658852e-02f, 6.89222366e-02f, -5.91239110e-02f, -9.58950631e-03f,
  -2.41835997e-01f, -1.55454069e-01f, 1.65118143e-01f, -2.87990272e-01f, 1.18193634e-01f, 1.58692509e-01f, 1.34395733e-01f, -1.14748858e-01f, -3.69413078e-01f, -2.01092795e-01f,
  6.24944605e-02f, -1.39731690e-01f, 7.09597841e-02f, -1.06430121e-01f, 1.17662430e-01f, 9.11797658e-02f, -1.10551015e-01f, 9.57494825e-02f, -5.22569716e-02f, -7.24801719e-02f,
  3.49031501e-02f, 3.10417116e-02f, 2.08053842e-01f, 6.15434013e-02f, 1.37825194e-03f, -1.02572538e-01f, 1.30227417e-01f, 1.76013142e-01f, 1.14303596e-01f, 1.23192519e-01f,
  -1.44088641e-01f, -1.13655649e-01f, -8.55157748e-02f, 8.85949507e-02f, 1.10109905e-02f, 1.65155362e-02f, 8.26246887e-02f, 9.26765725e-02f, -2.80025471e-02f, -3.83058377e-02f,
  -1.21863596e-02f, 9.03743319e-03f, -6.84304768e-03f, 2.68923603e-02f, -8.76948014e-02f, -5.36278486e-02f, -4.28819582e-02f, -2.31291652e-02f, -3.67202982e-02f, 1.18726023e-01f,
  4.49728109e-02f, 5.11934496e-02f, -2.09742673e-02f, -1.91558916e-02f, -4.21265047e-03f, -9.92572978e-02f, -7.24314945e-03f, 8.46737549e-02f, -3.65271680e-02f, -1.65010281e-02f,
  -1.45847048e-03f, 8.85132775e-02f, -8.46071243e-02f, -1.66271832e-02f, -8.99121223e-04f, -8.46183598e-02f, 2.85639358e-03f, 1.40813785e-02f, 3.15550528e-02f, -3.68707739e-02f,
  -3.72323096e-02f, -8.29893872e-02f, -4.73832339e-02f, 2.45502713e-04f, -2.36749314e-02f, -9.45974290e-02f, 3.28243673e-02f, -3.40764597e-02f, -6.78650737e-02f, 2.87191756e-02f,
  -1.14289075e-01f, 6.06381185e-02f, 2.36576274e-02f, 6.32708967e-02f, 5.84744033e-04f, 1.04586504e-01f, -2.99812388e-02f, -4.93288375e-02f, -2.55143084e-02f, 8.45080987e-02f,
  -1.28008991e-01f, -2.49377161e-01f, -8.21326673e-02f, 1.03483601e-02f, -1.31861670e-02f, 8.59764218e-03f, -5.76850772e-02f, -3.96682471e-02f, -1.77346300e-02f, 3.31886392e-03f,
  2.77173221e-02f, 2.77996995e-03f, 6.21533999e-03f, -5.39199002e-02f, 8.35827813e-02f, -7.16608530e-03f, -9.79783162e-02f, 6.76202253e-05f, -5.61040342e-02f, -3.49570811e-02f,
  -6.59066997e-03f, -6.15864201e-03f, 9.30224806e-02f, 1.79081934e-03f, 2.09960658e-02f, 5.75508997e-02f, -6.89396709e-02f, 8.82601715e-04f, 6.03943616e-02f, 1.44565534e-02f,
  -9.64331254e-02f, 3.64355370e-02f, 4.20958698e-02f, -1.14435360e-01f, 8.30966309e-02f, -3.16545591e-02f, -1.44351181e-02f, 1.22643083e-01f, 1.05458371e-01f, 1.31828412e-01f,
  -6.02603965e-02f, 6.65061474e-02f, -5.58608864e-03f, -1.18468598e-01f, -2.28990614e-01f, -9.89648104e-02f, -8.73146802e-02f, -1.68608800e-01f, -7.02051148e-02f, -1.57473758e-02f,
  -1.49885446e-01f, -5.40847741e-02f, -1.01247899e-01f, 1.50458798e-01f, 9.42641422e-02f, 1.28266990e-01f, -3.50469761e-02f, 1.35026187e-01f, -7.25132078e-02f, -5.08696064e-02f,
  8.43794364e-03f, 7.00119808e-02f, 3.02102584e-02f, -3.72833684e-02f, 8.36300943e-03f, 3.75209898e-02f, 1.80519167e-02f, 7.53059536e-02f, -8.39148238e-02f, 5.85776903e-02f,
  3.36893797e-02f, -7.72969499e-02f, 8.73649865e-03f, -3.52607109e-02f, 4.71349396e-02f, 1.27262305e-02f, 7.07037933e-03f, 8.55109021e-02f, 4.82966937e-02f, 5.49424216e-02f,
  -6.26690313e-02f, 5.31377867e-02f, -3.74508649e-02f, 3.89877595e-02f, 1.77612770e-02f, 5.85575141e-02f, 1.63396169e-02f, -9.70752910e-02f, 6.44856170e-02f, -1.01761289e-01f,
  5.53463921e-02f, 6.99652359e-02f, -6.35248646e-02f, -3.26009877e-02f, 4.19748574e-02f, 8.41826722e-02f, -1.71132591e-02f, -2.84202839e-03f, -5.48490770e-02f, 1.75173907e-03f,
  -3.27451224e-03f, 8.98032784e-02f, 4.25822996e-02f, -4.67546992e-02f, -2.95876320e-02f, 6.09528907e-02f, 8.46478492e-02f, 1.69037897e-02f, -1.68884099e-02f, 2.39577284e-03f,
  5.67422770e-02f, 2.78391298e-02f, 8.29661265e-02f, -6.67355880e-02f, -7.71766603e-02f, -2.11901888e-02f, -5.54734841e-02f, 1.79851502e-02f, 6.49370924e-02f, -4.65591997e-02f,
  -7.18890280e-02f, 3.46524119e-02f, -1.17860194e-02f, 9.05735418e-02f, 8.21503550e-02f, 8.54254514e-02f, 5.20507805e-02f, 3.52235623e-02f, 6.43920526e-02f, 7.81998858e-02f,
  -6.69864491e-02f, 1.16541237e-02f, 5.45080267e-02f, -6.62710965e-02f, 5.71105555e-02f, 4.81592901e-02f, 6.38612360e-03f, 8.10249150e-02f, 3.10064703e-02f, -8.77568796e-02f,
  -1.53662730e-02f, 7.79451504e-02f, -3.17347422e-02f, -3.87851708e-02f, 9.17376801e-02f, 1.00990020e-01f, 4.76284921e-02f, 1.23867085e-02f, 1.19173396e-02f, -8.94968491e-03f,
  6.27123117e-02f, 5.99855091e-03f, 1.86265171e-01f, 1.42317176e-01f, -1.48129240e-01f, 2.99625278e-01f, 4.90699738e-01f, -1.86517507e-01f, 2.18918920e-01f, 5.03857173e-02f,
  -4.56305109e-02f, 9.84874964e-02f, 2.09933355e-01f, 2.77471654e-02f, 4.05733049e-01f, 1.99850768e-01f, 1.14707328e-01f, 1.32790685e-01f, 3.88752036e-02f, -6.30820519e-04f,
  -4.25526239e-02f, -1.45249560e-01f, 1.34338951e-02f, -3.70286077e-01f, -1.78571165e-01f, -1.49823084e-01f, -1.45079002e-01f, 1.27120733e-01f, -2.01830104e-01f, 8.43161568e-02f,
  -6.64906949e-02f, -8.85106158e-03f, -1.20771892e-01f, -2.74008885e-02f, -8.69126469e-02f, 4.76902463e-02f, 1.01240233e-01f, 1.50593938e-02f, 4.87389928e-03f, 1.38419895e-02f,
  -2.37021800e-02f, -2.13010684e-02f, 2.06477265e-03f, -4.75171357e-02f, -1.24458654e-03f, -1.43868908e-01f, -7.30203763e-02f, -1.63559601e-01f, 4.46331762e-02f, -5.16235083e-02f,
  1.71364173e-02f, -1.25005662e-01f, -7.33358786e-02f, 4.56139492e-03f, -3.65697220e-02f, -5.47021218e-02f, 8.00886229e-02f, -1.51886549e-02f, -6.69836923e-02f, 4.58620116e-02f,
  6.78221509e-02f, 1.18696749e-01f, -1.60622131e-02f, -6.82093501e-02f, 3.49291377e-02f, -1.23278484e-01f, -3.26234475e-02f, -5.95704168e-02f, 2.65715569e-02f, 2.11264063e-02f,
  1.42453462e-02f, -4.08962078e-04f, -7.11834431e-02f, -2.13573966e-02f, 4.36227694e-02f, -1.94779523e-02f, -3.69415395e-02f, 4.83149514e-02f, 1.42603870e-02f, -3.83532271e-02f,
  3.10455337e-02f, -1.13516776e-02f, 4.58475910e-02f, 1.65354256e-02f, 7.90394470e-03f, -6.43206313e-02f, -2.31874478e-03f, 7.32790679e-03f, -2.88721453e-02f, 3.50703001e-02f,
  1.87856052e-02f, 1.15451455e-01f, 3.44492383e-02f, -5.28656207e-02f, -3.50508355e-02f, -5.70949093e-02f, 6.34270757e-02f, -3.76198180e-02f, 8.85604173e-02f, 2.06898134e-02f,
  4.84899767e-02f, 2.46610623e-02f, 9.32993963e-02f, -3.30815837e-02f, 1.30449444e-01f, -2.50697061e-02f, 1.50141865e-01f, 8.84949341e-02f, 2.27394421e-02f, -8.13006312e-02f,
  -1.12307139e-01f, 9.68747661e-02f, -4.43489011e-03f, -1.69817153e-02f, -5.79238422e-02f, 1.38683748e-02f, 7.03866407e-02f, 3.36080678e-02f, 5.24806269e-02f, 4.33528461e-02f,
  2.40142018e-01f, -2.09034964e-01f, -3.13115269e-01f, -6.01415895e-02f, 1.28667146e-01f, 1.06909811e-01f, 8.57115686e-02f, -5.26811481e-02f, -1.87551036e-01f, 7.39435107e-02f,
  1.43658131e-01f, -8.11066255e-02f, -7.54724219e-02f, -1.13316976e-01f, 5.71031384e-02f, -1.71205252e-01f, -6.20644577e-02f, 7.09981695e-02f, -1.65434539e-01f, 1.96715780e-02f,
  -5.37463464e-02f, 1.38189569e-01f, -2.17099339e-01f, -1.85913276e-02f, 8.20059255e-02f, 3.16062793e-02f, 1.65297925e-01f, -2.02716365e-02f, -5.46648130e-02f, -2.63803452e-02f,
  8.84880865e-06f, -1.45484423e-02f, -4.88533825e-03f, -6.08252697e-02f, 7.07888603e-02f, 1.55777663e-01f, -1.62226316e-02f, -1.01067470e-02f, -1.05424009e-01f, 4.14230488e-02f,
  -5.70077151e-02f, -8.53362307e-02f, -5.81679270e-02f, 1.84973031e-02f, 6.13502264e-02f, -1.39265787e-02f, -8.27201754e-02f, 6.89798221e-02f, -1.50481701e-01f, -7.65616521e-02f,
  -9.08801332e-02f, -4.86693196e-02f, 1.45923393e-02f, -2.01852228e-02f, -4.08015177e-02f, 5.42195216e-02f, -8.91809314e-02f, -5.73908873e-02f, 8.46782625e-02f, -1.15160961e-02f,
  9.68622491e-02f, 1.03120938e-01f, 1.04201414e-01f, -2.41487511e-02f, 8.80862027e-02f, -9.34040099e-02f, -3.87745351e-02f, -5.63255092e-03f, 3.30087692e-02f, 6.77261576e-02f,
  3.44926566e-02f, -4.23801392e-02f, 3.31585780e-02f, 1.89013798e-02f, 3.28424387e-02f, -8.47934652e-03f, -6.53620064e-02f, 6.29592091e-02f, -6.43837228e-02f, 3.31642553e-02f,
  -1.09521620e-01f, 4.26863432e-02f, 1.27295302e-02f, -3.35626751e-02f, -3.40608135e-02f, -4.79241014e-02f, 1.06639273e-01f, 8.70131142e-03f, 4.94512431e-02f, 7.34004751e-03f,
  -1.13484962e-03f, 9.48388204e-02f, -8.99114739e-03f, -8.00288096e-02f, -9.32234079e-02f, 1.12437308e-01f, 6.39897287e-02f, 1.92782059e-02f, 9.64081206e-04f, 2.33223476e-02f,
  5.51041551e-02f, -1.42106032e-02f, 5.23849465e-02f, -1.90567691e-02f, -5.29243760e-02f, 7.12160245e-02f, -2.56224405e-02f, 3.00034285e-02f, -3.61769088e-02f, -9.18366686e-02f,
  1.14514939e-01f, 1.35719597e-01f, -3.50607117e-03f, -6.90381601e-02f, 2.26726364e-02f, 8.83504525e-02f, 8.51624086e-02f, -2.17095055e-02f, -1.37923900e-02f, -3.04468740e-02f,
  -1.08496353e-01f, 5.05579002e-02f, 1.12905264e-01f, 8.31763893e-02f, 6.50973991e-02f, -4.56092767e-02f, -8.15716907e-02f, 7.36338943e-02f, -4.53518927e-02f, -2.28382081e-01f,
  -1.25299722e-01f, -4.71640192e-02f, 1.28606036e-01f, 2.58072861e-04f, 1.05989732e-01f, 1.76084071e-01f, -8.41009803e-03f, -1.49052903e-01f, 1.47593081e-01f, 5.15183387e-03f,
  1.33433649e-02f, -1.27145469e-01f, 2.04406798e-01f, 7.31526017e-02f, -1.27177006e-02f, -4.08684500e-02f, 3.00607029e-02f, 1.83797643e-01f, -8.62594415e-03f, 4.00561579e-02f,
  -1.19103253e-01f, 1.20237758e-02f, -9.73437354e-02f, -3.24366428e-02f, -1.03229456e-01f, -9.33791772e-02f, -1.94138996e-02f, -1.49017535e-02f, -1.35366479e-03f, 3.61178517e-02f,
  8.90314300e-03f, 7.63106626e-03f, -9.06289443e-02f, -3.02701946e-02f, -3.95309776e-02f, 6.15138710e-02f, 7.39936009e-02f, 7.42860511e-02f, -6.66467380e-03f, 4.74283509e-02f,
  -4.90322486e-02f, -9.97168943e-02f, 7.35011399e-02f, -8.25318620e-02f, 1.03018656e-01f, -1.08584113e-01f, -5.61724277e-03f, -3.25683169e-02f, -1.13563098e-01f, 1.55399414e-02f,
  5.83510771e-02f, 1.66187491e-02f, 7.30062127e-02f, -4.01926367e-03f, -3.58264893e-02f, -4.64959964e-02f, -2.01381352e-02f, -3.34082879e-02f, -4.09863107e-02f, 4.67341719e-03f,
  4.52013426e-02f, -3.99387591e-02f, -3.24561931e-02f, -1.42087089e-02f, -3.50937061e-02f, -9.20410901e-02f, -3.03175729e-02f, 2.79647298e-02f, 2.75614299e-02f, 8.76109526e-02f,
  -4.25309176e-03f, 6.75041676e-02f, -9.37389284e-02f, -7.24008121e-03f, -8.59758332e-02f, -6.99666739e-02f, -3.03697214e-02f, 4.20718566e-02f, -5.71481287e-02f, -3.49865183e-02f,
  -1.39693215e-01f, 1.80434547e-02f, -7.27665499e-02f, -6.60577044e-02f, 3.19193825e-02f, 2.53577065e-02f, 8.78226086e-02f, 3.17512043e-02f, -6.40931353e-02f, -1.11093521e-02f,
  -3.68072428e-02f, 2.85819992e-02f, -1.01015091e-01f, -2.79207006e-02f, -1.55619523e-02f, 4.02892893e-03f, 8.18340257e-02f, 2.55136900e-02f, -6.78994656e-02f, 9.22824889e-02f,
  -6.90292567e-02f, -5.33624105e-02f, -4.64409702e-02f, 1.75689459e-02f, 6.32000342e-03f, -5.11363894e-02f, 3.86113338e-02f, -6.69862702e-03f, 3.90804447e-02f, 2.19069812e-02f,
  -4.29482944e-02f, -1.62490472e-01f, 1.53063452e-02f, 4.71495092e-02f, 3.11179638e-01f, 2.55109519e-01f, 1.47717118e-01f, 1.61706150e-01f, 9.18161497e-02f, -1.15306467e-01f,
  -8.99964347e-02f, -1.36289135e-01f, -2.63001531e-01f, 5.22030257e-02f, 2.13577077e-01f, 2.65197759e-03f, 7.91470483e-02f, 1.92785461e-03f, 5.67262284e-02f, -7.38808513e-02f,
  5.89617901e-02f, 3.98701355e-02f, -8.71352926e-02f, -3.81788760e-02f, 2.82766595e-02f, 1.74735878e-02f, -4.98180185e-03f, 4.90090139e-02f, 6.29461035e-02f, 3.89205515e-02f,
  1.67612825e-02f, -2.45040618e-02f, -1.29868746e-01f, -9.89957824e-02f, -2.04823934e-03f, 1.53627731e-02f, 5.89750782e-02f, -4.13924567e-02f, 2.91061420e-02f, 1.39882155e-02f,
  -4.19662930e-02f, 3.24330777e-02f, -5.69515163e-03f, -8.17330368e-03f, 2.53152326e-02f, 4.69309166e-02f, -8.65198374e-02f, 2.93326899e-02f, -5.51358871e-02f, 2.81140022e-02f,
  -9.12477002e-02f, 3.69114205e-02f, -5.39648123e-02f, -4.81116436e-02f, -4.19780314e-02f, 8.59583393e-02f, 5.10490201e-02f, -1.04025297e-01f, 2.18378380e-02f, -3.10692973e-02f,
  8.46160501e-02f, 7.15226606e-02f, -5.42151518e-02f, -2.70997025e-02f, -7.57710710e-02f, -6.37922585e-02f, -6.13736250e-02f, -8.41989219e-02f, -1.76025126e-02f, -8.92841071e-02f,
  -1.49796326e-02f, -7.58833364e-02f, -3.62989865e-02f, -5.39699644e-02f, 3.10751386e-02f, -3.60337012e-02f, -7.36608356e-03f, 6.14993013e-02f, 4.61168848e-02f, -7.21095875e-02f,
  1.74084771e-02f, 4.46319096e-02f, 2.72252504e-02f, -1.43025620e-02f, -6.88948110e-02f, 2.55500935e-02f, -3.04774176e-02f, -1.02808205e-02f, -9.21181366e-02f, 1.70224737e-02f,
  3.34258452e-02f, 1.98411029e-02f, 8.87466595e-03f, 7.55153298e-02f, -1.05607018e-01f, -7.15754833e-03f, 6.88526183e-02f, 5.82031161e-02f, -1.13195954e-02f, 7.89949596e-02f,
  -5.35284579e-02f, -2.83708121e-03f, 4.12526913e-02f, 3.91791239e-02f, 7.77196512e-02f, 4.67663817e-02f, -7.65605643e-03f, 3.80184539e-02f, 7.55334692e-03f, 4.65455577e-02f,
  -5.90272658e-02f, -5.17675318e-02f, -3.59697007e-02f, 7.72308782e-02f, 5.15122488e-02f, -6.06578682e-03f, 8.51850435e-02f, 7.69042876e-03f, 1.71799324e-02f, 8.13039094e-02f,
  2.98770934e-01f, 1.78903282e-01f, 5.70378713e-02f, 1.96050897e-01f, -1.17815003e-01f, -2.10255206e-01f, -1.03808805e-01f, 1.86170429e-01f, 6.29761592e-02f, -8.95863697e-02f,
  1.27621546e-01f, 1.30472705e-01f, -1.04524143e-01f, 2.33317509e-01f, 9.24307555e-02f, -1.40225738e-01f, 1.63585693e-01f, 3.88877839e-02f, 8.43486842e-03f, 2.77228862e-01f,
  1.88335508e-01f, 2.37910315e-01f, 1.38202623e-01f, 1.72792315e-01f, 2.35475704e-01f, 2.19421908e-01f, 8.65805969e-02f, -6.18778691e-02f, 1.64725214e-01f, 9.10038315e-03f,
  -6.57913312e-02f, 1.83351830e-01f, 2.25759745e-02f, -5.65221272e-02f, -5.61342835e-02f, -6.30426630e-02f, -7.47273490e-02f, -1.44930616e-01f, 3.31414267e-02f, 5.20302840e-02f,
  -3.19610164e-02f, -7.02368319e-02f, 2.19787527e-02f, 6.21107705e-02f, 5.91655262e-02f, 9.59937423e-02f, -4.27324325e-02f, 2.02918779e-02f, 2.77398173e-02f, 7.54348338e-02f,
  6.47156015e-02f, 2.83468645e-02f, 6.03813194e-02f, -6.01056106e-02f, 8.47418681e-02f, -3.07143833e-02f, -6.75804615e-02f, -2.99105011e-02f, -1.09308551e-03f, 2.38474738e-02f,
  8.65570083e-02f, 1.61920022e-02f, -2.98594814e-02f, -6.08701818e-02f, 1.66826677e-02f, -3.96163203e-02f, 2.82014757e-02f, 2.05560811e-02f, -6.89100986e-03f, 6.30376711e-02f,
  -5.27554899e-02f, 8.56292024e-02f, -3.42680956e-03f, 3.52774113e-02f, 1.39773577e-01f, -4.52867188e-02f, 3.56391892e-02f, 8.02790299e-02f, 7.77623430e-02f, -3.31045724e-02f,
  -2.91208923e-02f, 5.76447994e-02f, 4.76279259e-02f, -9.17664096e-02f, -2.91488110e-03f, 7.25297481e-02f, 4.50987145e-02f, 5.52601032e-02f, 5.54680824e-03f, 1.58592837e-03f,
  9.61886719e-02f, 2.91195035e-01f, 2.73403302e-02f, -2.64740195e-02f, 1.58562288e-02f, 4.73144986e-02f, -7.70107433e-02f, 7.23937377e-02f, 4.35687266e-02f, -2.50168797e-02f,
  4.41806242e-02f, 3.84901688e-02f, 6.62672669e-02f, 1.26167685e-02f, 1.91356242e-02f, 1.29095450e-01f, -4.35047522e-02f, -1.82434730e-02f, 2.96794567e-02f, -9.88804922e-03f,
  -9.61891469e-03f, -6.25011697e-02f, 9.10003018e-03f, -1.25214204e-01f, -2.21509673e-03f, 1.31716095e-02f, -2.47202702e-02f, 7.70883858e-02f, 6.31722286e-02f, -2.37720516e-02f,
  -3.37290764e-02f, -7.20634758e-02f, -3.36799324e-02f, 1.28872022e-01f, -2.94768691e-01f, -8.55143070e-02f, 7.71852359e-02f, -7.63414502e-02f, 4.95332852e-02f, 8.83063674e-03f,
  9.34839621e-02f, 1.00086242e-01f, 1.25093997e-01f, 7.48627856e-02f, 6.04577102e-02f, 1.71291873e-01f, 4.53435332e-02f, 4.98503447e-02f, -7.16786087e-02f, -8.86682700e-03f,
  5.48435040e-02f, -5.20059792e-03f, 7.53260478e-02f, -1.28875077e-01f, -1.01787604e-01f, -9.10016894e-02f, 2.76740249e-02f, -6.38500899e-02f, 2.75363252e-02f, -1.36403605e-01f,
  -1.03177376e-01f, -2.32183207e-02f, 5.42138098e-03f, -2.74975337e-02f, 4.79239672e-02f, -8.35152045e-02f, 1.42576415e-02f, 7.99376518e-02f, 1.64397378e-02f, -5.36758490e-02f,
  8.46327282e-03f, -6.69049993e-02f, -5.38159832e-02f, -1.48654301e-02f, -1.08792111e-02f, 3.94305475e-02f, 2.77045555e-02f, 3.90526503e-02f, 9.66352673e-05f, -4.45802622e-02f,
  8.09732378e-02f, -3.29350233e-02f, 6.97121322e-02f, 1.10644348e-01f, 8.80546272e-02f, -6.70504943e-02f, 3.08737960e-02f, -3.06776203e-02f, 5.48898354e-02f, -6.56220876e-03f,
  6.71725869e-02f, -1.33635346e-02f, -7.41386637e-02f, -1.23939626e-01f, -3.59095186e-02f, 5.38289882e-02f, 8.25545415e-02f, -6.99288845e-02f, -4.01605777e-02f, 3.21020521e-02f,
  -8.27943254e-03f, -2.32501812e-02f, -1.53809125e-02f, 3.45822573e-02f, 1.81828849e-02f, 5.27049489e-02f, 5.91744818e-02f, -1.08053431e-01f, 3.13768908e-03f, 5.69370054e-02f,
  -5.63844331e-02f, -4.87586595e-02f, -2.10134573e-02f, -2.01393552e-02f, -5.64615577e-02f, 4.21238542e-02f, 5.99422790e-02f, 2.51661148e-02f, -5.20948227e-03f, -1.11098094e-02f,
  4.08384278e-02f, 9.34465602e-02f, 7.08370805e-02f, 4.53112833e-02f, 7.12185949e-02f, -7.08495229e-02f, 7.46339094e-04f, -8.12475681e-02f, 5.00621088e-02f, -2.06415541e-02f,
  6.38161972e-02f, 4.14789990e-02f, 4.05445658e-02f, 3.75768244e-02f, 6.50818879e-03f, -6.34306893e-02f, 2.74484642e-02f, 8.54883566e-02f, -6.20701015e-02f, -3.48678301e-03f,
  -4.91514690e-02f, -6.40491396e-02f, 8.51908475e-02f, 4.40796874e-02f, 3.75251621e-02f, 1.50650982e-02f, 2.27425108e-03f, 7.56869316e-02f, 2.12893616e-02f, -5.69719709e-02f,
  1.55758142e-01f, -2.19316930e-01f, -2.81716269e-02f, 1.88214213e-01f, 1.92718983e-01f, 2.63156509e-03f, 5.83766960e-02f, -1.24556804e-02f, 1.87220529e-01f, -1.46709144e-01f,
  -1.20047010e-01f, 4.78517115e-02f, -3.92327420e-02f, -2.76400775e-01f, -1.46506578e-01f, -1.93322390e-01f, -9.11107734e-02f, -2.94392556e-02f, 7.25074708e-02f, 9.20974165e-02f,
  -7.55937630e-03f, -1.74029469e-01f, -1.54775798e-01f, -1.79254860e-01f, 2.02681944e-02f, 1.18292697e-01f, -4.73738350e-02f, -2.01278031e-02f, 2.05712095e-02f, -1.33047760e-01f,
  -2.72149052e-02f, -7.25265145e-02f, -1.16962492e-01f, 5.28279580e-02f, 9.62562338e-02f, 5.32035567e-02f, 5.37925214e-02f, -8.02929997e-02f, 7.83724412e-02f, 2.87601002e-03f,
  1.17911741e-01f, -3.97060663e-02f, -4.34506051e-02f, 4.35948605e-04f, -5.05027324e-02f, 3.44374403e-02f, -3.94698568e-02f, -7.03957817e-03f, -3.32703292e-02f, -6.14273287e-02f,
  6.99814335e-02f, 7.17915408e-03f, 3.77436578e-02f, 2.76385713e-02f, -4.68738787e-02f, -6.70620650e-02f, 9.18596834e-02f, 4.39703241e-02f, 1.13315031e-01f, -4.25508544e-02f,
  1.86129380e-02f, 3.17495167e-02f, -3.46968323e-02f, 2.10578572e-02f, -1.99169237e-02f, 4.65480126e-02f, -1.79999601e-02f, -6.89035431e-02f, 2.87623778e-02f, -2.21598018e-02f,
  -2.88213398e-02f, -6.28352761e-02f, -4.32699025e-02f, 3.22737209e-02f, -4.48175818e-02f, 3.51450592e-02f, 2.71475650e-02f, -1.09444037e-02f, 6.05028383e-02f, 6.93404814e-03f,
  -4.96872477e-02f, 7.91257694e-02f, -7.40048438e-02f, 1.83501821e-02f, -2.82406919e-02f, -6.02714308e-02f, -4.34414484e-02f, -9.08669829e-02f, 7.46318176e-02f, 1.59167740e-02f,
  4.40907292e-02f, 1.25079826e-02f, -1.41901553e-01f, -4.16256189e-02f, -6.03945404e-02f, 2.18100194e-02f, 3.75917628e-02f, -8.70091096e-02f, 2.32994487e-03f, -8.73062462e-02f,
  5.80746774e-03f, 3.44942622e-02f, 8.78735706e-02f, 8.14288855e-02f, -1.00653827e-01f, -1.86033044e-02f, 1.83937009e-02f, -4.59882766e-02f, -3.52838635e-02f, 4.53202240e-02f,
  8.23753700e-02f, -3.09899263e-02f, -2.02369466e-02f, -3.28921191e-02f, 3.33505347e-02f, 5.44787310e-02f, 1.52052585e-02f, -5.53772636e-02f, 1.73880160e-02f, 5.89020699e-02f,
  -1.74845532e-02f, -9.47488174e-02f, 1.22890538e-02f, -1.41925558e-01f, 2.05835178e-01f, 2.25617126e-01f, 6.41864687e-02f, 1.16839312e-01f, -5.34028113e-02f, -1.78653877e-02f,
  1.46549791e-02f, -2.79309630e-01f, -1.65122494e-01f, -1.44166127e-01f, -2.35239953e-01f, -1.13985784e-01f, -1.97685957e-02f, -1.00865580e-01f, 8.57876521e-03f, -2.09051166e-02f,
  3.56309563e-02f, -2.21171886e-01f, -7.17019364e-02f, 1.64515659e-01f, 8.27427953e-03f, 2.05417812e-01f, 1.21679097e-01f, 1.13505639e-01f, -4.84671183e-02f, -1.07617259e-01f,
  5.82640991e-02f, -1.29713506e-01f, 8.93489644e-03f, 4.39658761e-02f, 6.98819011e-02f, 3.19193602e-02f, 2.85624452e-02f, -1.17085338e-01f, -4.78338152e-02f, -1.70858297e-02f,
  -7.82964677e-02f, -3.59397121e-02f, 1.62936021e-02f, -7.01623783e-02f, -2.21325085e-02f, -2.00046115e-02f, -3.52143164e-04f, 1.72520969e-02f, -8.68044887e-03f, 1.68840699e-02f,
  2.25941036e-02f, 4.81775664e-02f, 5.84691539e-02f, -5.94458804e-02f, 4.71390188e-02f, 1.06965497e-01f, 3.66281345e-02f, 1.00554466e-01f, -1.16797881e-02f, 2.02241074e-02f,
  -9.92842857e-03f, -2.37954631e-02f, 5.56989871e-02f, -7.91020170e-02f, 8.38241354e-03f, 3.08826137e-02f, 7.47399107e-02f, 3.15531194e-02f, -5.73617108e-02f, 7.79456049e-02f,
  5.64196594e-02f, -1.40344314e-02f, 4.89572473e-02f, -2.02744491e-02f, -1.78833511e-02f, -2.75115985e-02f, 1.24551915e-03f, 4.24982756e-02f, 7.10018724e-02f, -1.14114173e-02f,
  -1.43417940e-02f, -6.10132813e-02f, 3.48933414e-02f, 2.71171611e-02f, -3.05750780e-02f, 2.89825965e-02f, -8.06975737e-02f, 3.88762653e-02f, -2.70304848e-02f, -1.31282052e-02f,
  1.25388056e-01f, 7.36901583e-03f, 3.24312747e-02f, -5.78672439e-02f, 7.07389489e-02f, 3.71991582e-02f, -1.17136613e-01f, 4.69994470e-02f, 5.35996333e-02f, 5.21158092e-02f,
  9.83762592e-02f, 5.64163402e-02f, 2.04983521e-02f, 2.88070831e-02f, -1.97872017e-02f, -3.27552706e-02f, 5.44032827e-02f, 5.90292644e-03f, 3.32150459e-02f, 4.22595665e-02f,
  8.43106061e-02f, 2.05848143e-02f, -1.32983306e-03f, 9.99368057e-02f, -4.19680914e-03f, 9.69701931e-02f, 7.23672062e-02f, 8.84348750e-02f, 3.73943150e-02f, -1.07941248e-01f,
  -2.31487259e-01f, 1.54919345e-02f, 3.50462683e-02f, -2.14341462e-01f, 1.29610822e-02f, 1.61683268e-03f, -1.63020223e-01f, 1.05815975e-03f, -6.60662875e-02f, -3.86543386e-02f,
  4.99240868e-02f, -1.09730996e-01f, 4.40443009e-02f, -1.55837670e-01f, -1.10554524e-01f, -1.36521697e-01f, 2.79414151e-02f, -1.54757529e-01f, 4.57923748e-02f, 2.63908529e-03f,
  -1.47124631e-02f, -6.51001260e-02f, 6.04232252e-02f, 1.97740495e-01f, -8.70077219e-03f, 9.28784758e-02f, 2.06129309e-02f, 7.42258728e-02f, 5.79677746e-02f, 6.30694106e-02f,
  -2.21049171e-02f, -3.45724672e-02f, -2.90012024e-02f, -8.78693834e-02f, 4.55954038e-02f, 3.48524787e-02f, 7.44602233e-02f, -3.85660827e-02f, 6.69608712e-02f, -2.01489460e-02f,
  3.63891982e-02f, 6.79063499e-02f, -1.01536937e-01f, 3.59026641e-02f, -9.90998819e-02f, 1.57868471e-02f, 8.79661888e-02f, -6.25723824e-02f, -7.35139400e-02f, -8.39206576e-03f,
  -4.45071869e-02f, 7.20780119e-02f, 1.33135086e-02f, -3.69672887e-02f, 2.87571233e-02f, -3.69300693e-02f, -1.00998804e-01f, -4.24797880e-03f, -6.24042861e-02f, 4.73187678e-02f,
  5.29844612e-02f, 9.75345671e-02f, -7.81103000e-02f, -4.34540547e-02f, -8.01203772e-02f, 7.17674196e-02f, -6.82104230e-02f, -6.61826972e-03f, -4.51273024e-02f, 3.69218066e-02f,
  1.19761014e-02f, 2.55338792e-02f, -9.33634639e-02f, 5.06502315e-02f, -9.61450562e-02f, -8.22271854e-02f, -7.54078999e-02f, -1.02761015e-03f, 5.71357533e-02f, -3.72297876e-02f,
  -7.34199062e-02f, 6.36073351e-02f, 5.09491153e-02f, 1.55349849e-02f, -6.58531338e-02f, -4.50712293e-02f, 6.80017546e-02f, 3.75509225e-02f, -9.76054184e-03f, 8.98135528e-02f,
  -5.29595301e-04f, 7.35552087e-02f, 7.33335596e-03f, 4.87878919e-02f, 8.41030777e-02f, -4.15640213e-02f, 8.97917673e-02f, -2.59913020e-02f, 1.05546154e-01f, 6.80091009e-02f,
  3.11923213e-02f, 7.32688457e-02f, 2.33210754e-02f, -4.08668816e-02f, 9.89165306e-02f, -5.82401790e-02f, 2.49805525e-02f, -8.88155103e-02f, 2.42817104e-02f, 6.33154735e-02f,
  -1.61035992e-02f, 7.54226372e-02f, 5.11914752e-02f, -3.02249435e-02f, -6.84143007e-02f, -8.00395533e-02f, 8.27836394e-02f, 5.95968328e-02f, -5.62807806e-02f, 3.39565054e-02f,
  1.03375994e-01f, -1.90511066e-02f, -4.11158912e-02f, 1.43291578e-01f, -1.61852979e-03f, -2.27781422e-02f, -8.23649913e-02f, 9.11616012e-02f, -3.18941586e-02f, -1.73519954e-01f,
  -3.82362902e-02f, -1.20350532e-01f, 2.42335736e-04f, 8.74387324e-02f, 3.15780489e-05f, 1.02856839e-02f, 1.29002109e-01f, -8.15019533e-02f, 9.65202320e-03f, 1.31465524e-01f,
  1.07802726e-01f, 1.40692845e-01f, 1.00215547e-01f, 1.23315558e-01f, 1.42039999e-01f, 3.70262675e-02f, 1.74399108e-01f, -2.25307420e-02f, 8.87325481e-02f, -3.83448079e-02f,
  -6.63253963e-02f, 4.70533706e-02f, -2.90513914e-02f, -9.00634378e-02f, 1.02983102e-01f, 6.48389980e-02f, -1.55678270e-02f, -5.85402511e-02f, -7.89487511e-02f, 5.00321649e-02f,
  -1.34272426e-02f, -2.12262776e-02f, 2.56063193e-02f, -7.28808194e-02f, -1.07354522e-02f, 5.86487651e-02f, 7.75124133e-02f, -4.01048996e-02f, -1.93014629e-02f, 1.35308495e-02f,
  -4.92230803e-02f, -5.72412908e-02f, 9.04506296e-02f, 1.45519078e-02f, 6.53288960e-02f, 5.35976402e-02f, -2.70572361e-02f, 9.65967681e-03f, -1.00216386e-03f, 7.31334612e-02f,
  7.80102238e-02f, -4.83805835e-02f, 5.17555065e-02f, -3.68109122e-02f, -1.96299702e-02f, 2.82434225e-02f, -6.98090643e-02f, -3.14467810e-02f, 9.11532566e-02f, -7.78242350e-02f,
  8.36830065e-02f, 6.73411638e-02f, -6.28748536e-02f, -5.57722710e-02f, -2.21363120e-02f, 5.98565973e-02f, -5.42523153e-02f, -5.11626080e-02f, 7.33029842e-02f, -3.47482413e-02f,
  1.04691256e-02f, 1.76258963e-02f, -5.42311631e-02f, -8.66569281e-02f, 3.27586569e-02f, -8.03081766e-02f, 4.33957465e-02f, 3.59101966e-02f, 1.51452916e-02f, -3.98921333e-02f,
  7.64748678e-02f, 1.41971558e-01f, -3.08780018e-02f, -5.76863438e-02f, -2.36521512e-02f, -3.27374749e-02f, 7.22092241e-02f, 2.63786651e-02f, -1.96683779e-02f, -7.00274706e-02f,
  5.98444194e-02f, 8.36611316e-02f, 1.59647863e-03f, -3.56195122e-02f, 6.96227700e-02f, 4.50812168e-02f, 7.52604976e-02f, 8.07928443e-02f, 4.40087765e-02f, 1.43061087e-01f,
  1.04863010e-01f, -2.36558598e-02f, -6.62855105e-03f, 9.87790897e-02f, 3.84826288e-02f, 4.62602936e-02f, -8.97387136e-03f, 6.55227080e-02f, 3.98269556e-02f, -1.49959847e-02f,
  -3.12757313e-01f, 4.23919931e-02f, -2.81042576e-01f, -2.34909326e-01f, 1.33307189e-01f, -3.03419530e-01f, -2.58182883e-01f, -3.80213968e-02f, 6.03893399e-02f, 1.94301680e-01f,
  1.28305361e-01f, -1.23241544e-01f, 1.85391396e-01f, -2.89948076e-01f, -4.78089839e-01f, -1.88354120e-01f, -4.46610034e-01f, -1.70289472e-01f, -1.23404354e-01f, -1.21129472e-02f,
  -1.78571120e-01f, -3.32363173e-02f, -2.29171142e-01f, 1.61932066e-01f, -5.15335277e-02f, 6.40746728e-02f, 1.13964446e-01f, 2.47509405e-01f, -1.23695597e-01f, 3.42164151e-02f,
  -3.70158255e-02f, 1.20547093e-01f, -5.41717187e-02f, 2.98357643e-02f, -7.67740607e-02f, -2.23497991e-02f, -3.75255644e-02f, -2.59453952e-02f, 6.10188358e-02f, -7.27578718e-03f,
  3.46209034e-02f, 8.72566104e-02f, -7.26788193e-02f, 1.65889534e-04f, -5.47060557e-02f, -4.38273661e-02f, -7.09337043e-03f, -1.10878021e-01f, 1.54679539e-02f, -1.39789760e-01f,
  -8.64497945e-02f, -8.12351853e-02f, -6.13623783e-02f, -8.18636343e-02f, -1.31927934e-02f, 2.96029765e-02f, -1.21750653e-01f, 3.06644272e-02f, -1.06482767e-01f, -7.30903000e-02f,
  1.89315211e-02f, 3.37415412e-02f, -1.19489087e-02f, -2.68544368e-02f, -2.64135394e-02f, 5.90058714e-02f, -1.10171018e-02f, -3.47980931e-02f, 7.23722801e-02f, -3.40991211e-03f,
  -4.92420830e-02f, -3.58146653e-02f, -1.04038371e-02f, 7.80040352e-03f, -7.60319643e-03f, -2.17360607e-03f, 2.16647293e-02f, 9.53832641e-03f, -6.46191742e-03f, -1.10726118e-01f,
  7.02496469e-02f, -8.11387300e-02f, 9.42319408e-02f, -4.11378406e-02f, 3.29867564e-02f, 6.46587312e-02f, 8.27544462e-03f, -8.04760829e-02f, 5.33633083e-02f, 1.75972153e-02f,
  -3.81431095e-02f, 3.03926915e-02f, 1.58983916e-02f, 4.17016856e-02f, -2.27245167e-02f, -5.66626228e-02f, -1.83437765e-02f, -9.47885662e-02f, -6.78317174e-02f, -3.56726386e-02f,
  3.86419371e-02f, -2.75452714e-02f, 7.91325886e-03f, 4.88996953e-02f, 3.02444175e-02f, -4.08150218e-02f, 4.26314026e-02f, -3.05081904e-03f, -1.25747854e-02f, -1.40286097e-02f,
  8.76252800e-02f, 1.16181493e-01f, 2.15487685e-02f, 1.10872082e-01f, 4.65665795e-02f, -3.25820819e-02f, 6.93464419e-03f, -6.03959262e-02f, -1.57163367e-02f, -5.14889993e-02f,
  2.80320883e-01f, -2.93352362e-02f, -1.27100706e-01f, 1.47609323e-01f, 1.11105122e-01f, -6.03675656e-02f, -7.26305842e-02f, 1.40502840e-01f, -5.29096201e-02f, -3.52627155e-03f,
  1.17052905e-01f, -1.42944669e-02f, -1.48204520e-01f, 7.28290975e-02f, 8.87885764e-02f, -2.13915840e-01f, 7.56994039e-02f, -6.73629642e-02f, -1.08736083e-01f, 3.50587368e-01f,
  1.93416774e-01f, 2.20430449e-01f, -2.35602409e-02f, 6.33827671e-02f, 8.86078104e-02f, 1.58578575e-01f, 2.18613088e-01f, 1.14685670e-02f, 4.87728901e-02f, -6.43098354e-02f,
  -9.95109007e-02f, 9.86680612e-02f, -8.40576142e-02f, -1.28855854e-01f, 5.80777749e-02f, -3.21941376e-02f, -7.63886869e-02f, -3.57484221e-02f, 2.81504262e-02f, 8.19836184e-03f,
  5.76441288e-02f, -4.48848866e-02f, -2.54819728e-02f, 3.97885926e-02f, 6.20147325e-02f, 2.82139517e-02f, -7.00276047e-02f, -2.64320169e-02f, 1.78130642e-02f, 9.43909213e-02f,
  -8.49160030e-02f, 5.84378466e-02f, 4.73105162e-02f, -8.94090012e-02f, -3.08737438e-02f, -3.38097997e-02f, 4.17962894e-02f, -8.39212164e-03f, 3.73740830e-02f, 5.15639745e-02f,
  1.12662584e-01f, 6.67378828e-02f, -3.82744707e-02f, -4.21787985e-02f, 3.51139270e-02f, -5.18447198e-02f, 5.47429025e-02f, 4.17453907e-02f, -3.02648172e-02f, 6.21960871e-02f,
  7.39543959e-02f, -6.51618466e-02f, -3.79533656e-02f, 9.06290635e-02f, -4.25740145e-03f, -2.13539731e-02f, -6.22016042e-02f, -4.85402299e-03f, -2.66598985e-02f, -6.12693466e-02f,
  -3.55912372e-02f, 2.82297134e-02f, -5.00700623e-02f, -2.07240650e-04f, -8.85181800e-02f, -1.18646137e-02f, 7.41885155e-02f, 4.80469167e-02f, 1.94668137e-02f, 2.04940122e-02f,
  3.24143581e-02f, 3.71786803e-01f, 4.09708768e-02f, -5.47445118e-02f, -5.82705177e-02f, 9.55614224e-02f, 5.34701161e-02f, -3.07915360e-03f, 6.53699636e-02f, 8.69047195e-02f,
  1.33862659e-01f, -3.02755740e-03f, 4.78742160e-02f, -5.92900403e-02f, -5.64225763e-02f, 6.62932247e-02f, 7.98098668e-02f, 1.24013815e-02f, -7.68704992e-03f, 4.92970198e-02f,
  1.32767797e-01f, 8.95500258e-02f, 1.34092169e-02f, -8.96273181e-03f, 4.06647958e-02f, 5.95774837e-02f, -2.70501114e-02f, 2.48990860e-02f, 9.01768878e-02f, 3.72436345e-02f,
  3.91070396e-02f, -1.46536455e-01f, 1.17066056e-01f, 1.18596554e-01f, 2.67868757e-01f, 2.16194987e-01f, 1.05737202e-01f, 8.58127475e-02f, 1.79837570e-01f, -6.06029555e-02f,
  1.04193799e-01f, -7.84978643e-02f, -4.36443426e-02f, -2.56969854e-02f, 1.35601565e-01f, -4.53860201e-02f, -1.08929409e-03f, -6.51138425e-02f, 4.12640460e-02f, 1.67794749e-01f,
  1.02116056e-01f, -4.75628935e-02f, -9.23213586e-02f, -1.11462563e-01f, 3.42267640e-02f, -5.90466261e-02f, -6.92230687e-02f, 5.91749214e-02f, -2.99140923e-02f, 6.80230483e-02f,
  7.76598882e-03f, 4.23163064e-02f, 3.31447646e-03f, -6.85710609e-02f, -1.83431171e-02f, 6.92589805e-02f, 2.26305816e-02f, -9.45401192e-02f, -1.93865895e-02f, -5.92152309e-03f,
  -1.44593632e-02f, 5.70122562e-02f, -7.00824037e-02f, -3.08120530e-02f, 1.05115678e-02f, 2.84822518e-03f, -5.47103100e-02f, 8.62822384e-02f, 6.73241913e-02f, 3.69177945e-02f,
  1.06295317e-01f, -2.39788704e-02f, -1.19799627e-02f, 3.98323573e-02f, 1.04417875e-02f, -4.84957881e-02f, 8.78728833e-03f, 2.79256282e-03f, 1.68523695e-02f, 7.08600879e-02f,
  3.17274593e-02f, -3.52350660e-02f, -2.06302144e-02f, 5.56791797e-02f, 6.36876673e-02f, -6.27014637e-02f, -8.19720328e-02f, -2.85243187e-02f, -5.00762761e-02f, 6.52315021e-02f,
  -4.98544984e-02f, 2.77804639e-02f, 2.34560352e-02f, 5.90633648e-03f, 5.51806912e-02f, -7.13317916e-02f, -3.43567617e-02f, -8.71690398e-04f, 5.36805093e-02f, 8.47463403e-03f,
  -7.10811242e-02f, 7.76757672e-02f, 6.40928522e-02f, 5.93663827e-02f, -3.51858437e-02f, 8.78658518e-02f, -3.99213843e-02f, -6.83107302e-02f, 2.41832598e-03f, -3.34514268e-02f,
  -6.73901057e-03f, 2.06630081e-02f, 6.82482868e-02f, 5.36660152e-03f, -1.01305597e-01f, -2.88102403e-03f, 1.60804146e-03f, -2.82333624e-02f, -3.26050520e-02f, -8.03309083e-02f,
  -4.04840373e-02f, -4.68014739e-02f, -2.85123866e-02f, 8.61611310e-03f, -8.81275684e-02f, 1.04920551e-01f, -3.87811437e-02f, -4.32209969e-02f, -6.63972571e-02f, -8.42721611e-02f,
  -4.27096663e-03f, -8.18776935e-02f, 2.93450952e-02f, -2.49379454e-03f, -4.39295061e-02f, -2.09798738e-02f, 4.05246317e-02f, 9.25991975e-04f, 4.56527583e-02f, -3.15184444e-02f,
  1.50136232e-01f, -2.63151109e-01f, 2.52310812e-01f, 3.03084459e-02f, 5.17280623e-02f, 1.12040110e-01f, 2.92622566e-01f, -2.65607446e-01f, -4.10371691e-01f, -2.96026230e-01f,
  -6.91944510e-02f, 2.09920749e-01f, 2.61332124e-01f, -1.17780313e-01f, 1.76579103e-01f, -6.41572177e-02f, -1.90663978e-01f, 8.30500573e-02f, -1.34955078e-01f, -5.00359982e-02f,
  -1.26556069e-01f, -1.51449844e-01f, 2.01492921e-01f, -2.85751790e-01f, 1.25938684e-01f, -8.06976855e-02f, 5.93259148e-02f, 2.20803484e-01f, -1.28146544e-01f, 1.61223307e-01f,
  -1.11426711e-01f, -1.45804852e-01f, 1.12013444e-01f, -8.28891098e-02f, 3.53991240e-02f, 6.54577911e-02f, 1.59578845e-01f, 1.27262995e-01f, -2.59897094e-02f, 4.07863781e-02f,
  9.81895551e-02f, -2.37178057e-02f, -6.41969368e-02f, 4.94422615e-02f, -1.25162885e-01f, -9.72268134e-02f, -3.48674729e-02f, 5.12952134e-02f, 2.87490208e-02f, 5.55750094e-02f,
  -3.03813294e-02f, -9.31869261e-03f, -3.02178171e-02f, -5.37969023e-02f, 8.33464712e-02f, 5.28468238e-03f, -2.43510120e-02f, 1.66826114e-01f, -3.76185775e-02f, -5.50616160e-02f,
  2.80788094e-02f, -1.67931302e-03f, 5.75436242e-02f, 2.25798097e-02f, 2.13233549e-02f, 1.17447842e-02f, 7.46318549e-02f, 9.75059122e-02f, 4.85415645e-02f, 1.09150261e-02f,
  4.50236797e-02f, -3.60466875e-02f, 1.13280583e-02f, -5.46184927e-02f, 4.23019938e-02f, 1.65695902e-02f, 7.47649744e-02f, 3.64125893e-02f, 3.09382658e-02f, -4.03856896e-02f,
  6.23121448e-02f, 4.84779337e-03f, -5.05877696e-02f, 5.70720844e-02f, -7.55333826e-02f, 9.51030999e-02f, -1.12910405e-01f, 4.48112525e-02f, -4.95596081e-02f, 5.01572378e-02f,
  -9.40209180e-02f, -2.61738271e-01f, -7.68627152e-02f, 9.25220549e-03f, -4.12154645e-02f, -2.63272356e-02f, -3.98586653e-02f, -5.75729832e-02f, -7.14906603e-02f, -6.36673570e-02f,
  2.02874802e-02f, -8.93006008e-03f, -1.28652766e-01f, 3.63876522e-02f, 4.59474884e-02f, -2.51984280e-02f, -1.72312316e-02f, -7.99345411e-03f, 4.69320975e-02f, -2.59881243e-02f,
  9.53743160e-02f, 2.52186134e-02f, 1.45883057e-02f, -3.60213220e-02f, -1.04000904e-01f, 4.33060676e-02f, 4.41934243e-02f, 1.16319917e-02f, -3.87067832e-02f, -7.30458125e-02f,
  -9.55454782e-02f, -1.94914714e-01f, -1.51444804e-02f, 9.21531394e-02f, 2.06001461e-01f, -1.27462462e-01f, -9.98749584e-02f, 1.20453157e-01f, -2.91035846e-02f, -1.34421855e-01f,
  -1.52084581e-03f, -2.04359189e-01f, -1.01026975e-01f, -1.45751879e-01f, -7.42036700e-02f, -1.96468934e-01f, -1.50352314e-01f, -1.43159643e-01f, -4.27199602e-02f, -7.31230974e-02f,
  4.62497957e-02f, 1.12072468e-01f, -1.15471482e-02f, 2.35903114e-01f, 1.34575501e-01f, 2.08409816e-01f, 1.59243777e-01f, 2.87177637e-02f, 3.29577923e-02f, -3.12301144e-02f,
  -3.97736728e-02f, -9.34465080e-02f, 9.75529663e-03f, 7.38304481e-02f, 4.57105227e-02f, 8.39208625e-03f, -4.24212366e-02f, 7.89368302e-02f, -2.35906173e-03f, -3.41015048e-02f,
  -8.44849274e-02f, 6.19677640e-02f, 5.78549132e-02f, 1.04565829e-01f, 1.08981192e-01f, 9.35871678e-04f, -4.95084561e-03f, -5.26359640e-02f, -1.47031276e-02f, -6.69231191e-02f,
  5.64684197e-02f, -5.56163900e-02f, -6.61190227e-02f, -5.37592098e-02f, 3.39474762e-03f, 1.30467182e-02f, -1.01931684e-01f, -2.81737503e-02f, 6.29420951e-02f, 6.63531199e-02f,
  8.09558257e-02f, -1.60262780e-03f, -4.96126078e-02f, -5.03788181e-02f, 5.42251812e-03f, 2.60997079e-02f, 6.66662976e-02f, -2.31270026e-02f, -5.35878763e-02f, 4.87476662e-02f,
  6.47010133e-02f, 1.94539484e-02f, 1.65844411e-02f, 7.22222477e-02f, 5.29680513e-02f, 4.15360294e-02f, -4.27675359e-02f, 5.47561236e-02f, 1.48568088e-02f, 7.49896839e-02f,
  -1.46793935e-03f, -1.91261116e-02f, -8.81408602e-02f, 4.57240529e-02f, -6.78180382e-02f, 4.02799025e-02f, 8.47747549e-02f, 1.18924659e-02f, -4.77350876e-02f, 5.68393767e-02f,
  5.68637401e-02f, -8.89141113e-02f, -1.56121925e-02f, 8.44076946e-02f, -2.75995918e-02f, 4.44046259e-02f, -3.29666622e-02f, -5.88652119e-02f, -9.04527828e-02f, 4.91177738e-02f,
  7.18189329e-02f, 9.92484242e-02f, -8.05026963e-02f, -8.88438709e-03f, 4.86133900e-03f, -6.31773546e-02f, 7.77197555e-02f, 7.74007663e-02f, -3.03318501e-02f, 8.64110216e-02f,
  -5.29666618e-02f, -7.40465149e-02f, 4.92086969e-02f, 1.12394258e-01f, 7.37758577e-02f, 2.21740361e-02f, -4.94858585e-02f, -3.26638967e-02f, 4.44648825e-02f, -5.80746755e-02f,
  -2.54898429e-01f, 2.59740174e-01f, -2.73130804e-01f, 1.26933176e-02f, 1.14565402e-01f, 2.42657289e-01f, 1.21879138e-01f, 1.33762896e-01f, 8.16791356e-02f, 2.67887861e-01f,
  2.41967529e-01f, -4.57825214e-02f, 6.30271286e-02f, 1.04273744e-01f, -5.16276285e-02f, 1.32503301e-01f, 1.46420985e-01f, 2.27119118e-01f, -4.53572460e-02f, -7.90719539e-02f,
  -3.65601145e-02f, 7.90736079e-02f, -2.32398942e-01f, 9.56871454e-03f, -8.05566311e-02f, -1.81512713e-01f, -7.82363266e-02f, -2.14313179e-01f, 1.17867894e-01f, 4.22814190e-02f,
  -5.18450551e-02f, 3.45836170e-02f, -9.11825076e-02f, -1.26941696e-01f, -1.29756555e-01f, -1.11217044e-01f, -1.24514922e-01f, -5.31646051e-02f, -2.74289548e-02f, 8.56183320e-02f,
  -7.33951256e-02f, 8.92902538e-03f, 8.67607817e-02f, 1.82560850e-02f, -2.06874553e-02f, -4.23520319e-02f, 3.12963054e-02f, 7.16383681e-02f, 7.10871071e-02f, 3.33280787e-02f,
  4.52750251e-02f, -4.77510653e-02f, -3.03327441e-02f, 2.14689951e-02f, -5.01445774e-03f, 5.24062365e-02f, 4.52462621e-02f, 3.17075178e-02f, 1.15321346e-01f, -3.93684097e-02f,
  3.92326340e-02f, -2.57810801e-02f, -2.48543173e-02f, 7.19297603e-02f, -4.92409691e-02f, -5.95222227e-02f, 6.10235557e-02f, 4.16073985e-02f, -5.06184399e-02f, 1.23476628e-02f,
  5.62515445e-02f, -6.59747124e-02f, -3.79025787e-02f, -7.45729730e-02f, -5.56079671e-02f, -3.57915275e-02f, -4.18158285e-02f, 9.85685587e-02f, -2.61817556e-02f, 7.91660789e-03f,
  -7.26005509e-02f, 3.42883617e-02f, -1.60005093e-02f, 1.00868985e-01f, 1.45246526e-02f, -2.37320010e-02f, 6.19080253e-02f, -1.35840168e-02f, 2.58141402e-02f, 4.19353209e-02f,
  2.17730463e-01f, 1.49991050e-01f, 4.74653486e-03f, 7.85463527e-02f, -1.11146972e-01f, 5.48760630e-02f, 2.48605348e-02f, 7.83134624e-02f, 5.36668748e-02f, -4.49564755e-02f,
  4.55637686e-02f, -2.74334624e-02f, 2.59421412e-02f, -6.62017912e-02f, -7.54491775e-04f, 1.32859960e-01f, -7.96486214e-02f, 7.38366544e-02f, -4.53398935e-03f, -9.58903953e-02f,
  2.17108685e-03f, 7.47129768e-02f, 5.10451868e-02f, 1.02665372e-01f, 1.44411726e-02f, 6.33438006e-02f, 4.82606441e-02f, 3.12415287e-02f, -2.31660698e-02f, -3.72178145e-02f,
  -7.00561255e-02f, 1.78500161e-01f, 1.01331733e-01f, 1.76274195e-01f, -1.51003852e-01f, -2.04784069e-02f, 1.26128837e-01f, 6.28572851e-02f, 2.65266865e-01f, 2.12898597e-01f,
  -9.53352973e-02f, 1.91848293e-01f, -5.47571369e-02f, 6.75812215e-02f, 4.48644869e-02f, 3.42013757e-03f, 1.48173496e-01f, 1.61351398e-01f, 9.51303244e-02f, 1.18511066e-01f,
  5.62714040e-02f, 4.55173254e-02f, -5.50119653e-02f, -1.47840232e-01f, 3.87857258e-02f, -2.00473033e-02f, -7.41286278e-02f, -1.01021565e-01f, -9.01437644e-03f, -1.47632927e-01f,
  -4.47151326e-02f, 2.14826688e-02f, 3.67411114e-02f, 1.16534503e-02f, 9.23896059e-02f, -6.12671524e-02f, -7.82556981e-02f, 2.18965709e-02f, 4.61234190e-02f, -5.36952261e-03f,
  1.32940859e-01f, -9.81770679e-02f, -1.10002747e-02f, -2.16540340e-02f, -2.27042977e-02f, 1.45053305e-02f, -2.52239760e-02f, -5.09470291e-02f, 5.54484827e-03f, -8.21524709e-02f,
  -6.24023750e-02f, 7.92308152e-02f, -2.10126285e-02f, 6.55627400e-02f, -6.33783787e-02f, -1.53146284e-02f, 1.04954809e-01f, -4.62579429e-02f, 2.29547434e-02f, 4.47594076e-02f,
  -9.81225669e-02f, 9.14766267e-02f, 2.10799780e-02f, -5.52426130e-02f, 2.76385397e-02f, 2.87573542e-02f, 5.84000759e-02f, 7.58674145e-02f, -5.74207380e-02f, 8.40061903e-03f,
  -3.13362032e-02f, -2.86493301e-02f, 4.14821953e-02f, 1.89866163e-02f, 3.94979753e-02f, 2.59176195e-02f, -9.71062928e-02f, 1.95228886e-02f, 4.21915986e-02f, -6.60736486e-02f,
  3.06503028e-02f, -6.56475052e-02f, -1.78921595e-02f, 5.47156520e-02f, -3.69312242e-02f, 3.54012623e-02f, -2.25104783e-02f, -6.34008870e-02f, 6.00936124e-03f, -4.95591899e-03f,
  1.23240866e-01f, 2.37975881e-01f, 1.25600901e-02f, 1.49740670e-02f, 3.16683799e-02f, 2.04798076e-02f, 7.46339038e-02f, -1.24843363e-02f, -2.38023736e-02f, -6.83872029e-03f,
  4.62820642e-02f, 9.94977802e-02f, -6.23176433e-02f, 4.79652509e-02f, 4.62882146e-02f, -4.71497402e-02f, 1.05816185e-01f, 6.99790120e-02f, 9.35166925e-02f, 5.49187884e-02f,
  4.37023118e-02f, 1.09851092e-01f, 1.12594076e-01f, 1.07860133e-01f, 1.39872320e-02f, 5.37671261e-02f, -2.75773145e-02f, 1.06111476e-02f, -4.45051901e-02f, 1.38685843e-02f,
  -1.26142213e-02f, 1.79264769e-01f, -3.24945040e-02f, 1.39920563e-01f, 6.12639170e-03f, -1.57886669e-01f, -2.90605444e-02f, 1.12473138e-01f, -3.94520462e-02f, 7.43273720e-02f,
  6.18507676e-02f, 1.41579479e-01f, -1.31627887e-01f, 9.81833264e-02f, -1.96748793e-01f, -1.87599838e-01f, -1.03450492e-01f, -5.65193444e-02f, -1.57816354e-02f, -1.08330622e-02f,
  2.52858736e-02f, 1.43071979e-01f, 6.81164488e-03f, 1.44863902e-02f, 1.36134746e-02f, 8.64725113e-02f, -4.04225476e-02f, 1.87867302e-02f, 8.42306986e-02f, 4.48965356e-02f,
  -6.48439452e-02f, 1.03032060e-01f, 9.11825057e-03f, -4.25596572e-02f, -6.52382150e-02f, -5.55088855e-02f, 3.02483439e-02f, -7.90248588e-02f, 5.18405586e-02f, -4.63840105e-02f,
  -2.74399649e-02f, 4.76096980e-02f, 5.38407154e-02f, -3.18835750e-02f, 4.78555262e-03f, 9.45621505e-02f, 3.23411897e-02f, -7.66708329e-02f, -2.74535716e-02f, 3.83216403e-02f,
  -3.26842964e-02f, 6.60285279e-02f, -7.40582198e-02f, -3.83725017e-02f, 2.98482925e-02f, -2.38524117e-02f, 5.15011251e-02f, 1.79618951e-02f, 3.93235236e-02f, -4.90626022e-02f,
  2.96884831e-02f, 3.25566195e-02f, -1.48324464e-02f, 1.15542091e-01f, 7.43211806e-02f, 4.94983494e-02f, -1.66380759e-02f, 5.96755929e-03f, 3.96851264e-02f, -8.96052923e-04f,
  -7.31962547e-02f, 8.09895322e-02f, -6.53277934e-02f, -9.87805650e-02f, -7.62030929e-02f, 5.22316769e-02f, -1.13182487e-02f, -5.76702394e-02f, -1.87765006e-02f, 1.83274392e-02f,
  -1.23227211e-02f, 2.39896514e-02f, -3.34550031e-02f, -2.96830181e-02f, -5.26248030e-02f, -1.61004644e-02f, 5.44272400e-02f, 8.37485194e-02f, 6.98904991e-02f, -7.67983198e-02f,
  -7.38840327e-02f, -8.14291686e-02f, 3.06783468e-02f, 7.10536391e-02f, 2.24831868e-02f, -4.10452448e-02f, -8.53938013e-02f, 6.71924800e-02f, -9.64258686e-02f, -4.95421402e-02f,
  -2.65651215e-02f, -1.92470499e-03f, -2.31469944e-02f, -5.47009334e-02f, 4.48064953e-02f, -9.67728421e-02f, 4.50247005e-02f, 4.85081412e-02f, 7.48304278e-02f, -1.48561951e-02f,
  6.27178028e-02f, -7.93162882e-02f, 4.03234810e-02f, -4.27846126e-02f, -6.31945133e-02f, 9.90499370e-03f, -4.84095544e-05f, -3.05188876e-02f, 2.32360177e-02f, 2.73669045e-02f,
  1.32055745e-01f, 1.04874961e-01f, 4.70596224e-01f, 2.72892296e-01f, 5.08209206e-02f, 2.93165386e-01f, 2.34460905e-01f, 6.21787831e-02f, 4.88674581e-01f, -2.03728527e-01f,
  -3.37510288e-01f, 2.86925972e-01f, -6.75089881e-02f, 4.38866951e-02f, 4.42295894e-02f, -1.38202086e-01f, 8.27274248e-02f, 5.81876263e-02f, 1.25638470e-01f, 1.14935376e-01f,
  -2.64417939e-02f, -3.21698815e-01f, -1.00361474e-01f, -3.25222462e-01f, -8.90509933e-02f, -5.81105202e-02f, -3.42221946e-01f, -9.40064788e-02f, -1.73270047e-01f, 3.24326917e-03f,
  -5.94228245e-02f, -1.48212025e-02f, -2.54252274e-03f, 9.34479609e-02f, 6.08861260e-02f, 6.25692168e-03f, 4.12582681e-02f, -1.03698922e-02f, 1.25153497e-01f, 6.47773733e-03f,
  -1.00408979e-02f, 5.73050193e-02f, 8.71904567e-02f, -7.76230916e-02f, 1.40673980e-01f, -5.02633825e-02f, 2.94971410e-02f, 4.21115495e-02f, 1.28909737e-01f, 6.39076084e-02f,
  9.33201835e-02f, 1.00288711e-01f, 4.42698486e-02f, -3.69628854e-02f, 2.41490509e-02f, -4.87575959e-03f, 3.96677777e-02f, 5.05107753e-02f, 4.48770635e-02f, 8.48490652e-03f,
  -3.64260958e-03f, -9.13322158e-03f, -7.05494136e-02f, 6.07343875e-02f, -9.28016156e-02f, -7.30742961e-02f, -6.53529093e-02f, 1.76188201e-02f, 1.19497225e-01f, 3.81650813e-02f,
  4.88951243e-03f, 5.29929958e-02f, -7.35369418e-03f, 1.57848597e-02f, -1.03940470e-02f, 4.62298840e-02f, 2.93928050e-02f, -6.47264123e-02f, -7.29706585e-02f, 5.00434777e-03f,
  1.75908282e-02f, 6.76979348e-02f, -9.41163003e-02f, -7.68817663e-02f, 6.67936206e-02f, 2.97199804e-02f, -1.52924284e-02f, 9.50667486e-02f, 2.74738856e-02f, -1.58181023e-02f,
  1.16297022e-01f, 8.78562406e-02f, 1.09267328e-02f, -4.72978577e-02f, -1.58060789e-02f, -3.44501659e-02f, 2.14126967e-02f, -4.41018827e-02f, -1.50261335e-02f, -7.02213496e-02f,
  2.57314239e-02f, -2.24323235e-02f, 3.08154430e-02f, 2.36529112e-02f, -1.15922559e-02f, -6.15328550e-02f, 6.48415238e-02f, 3.76043804e-02f, -4.22008708e-02f, -9.67062414e-02f,
  3.01391799e-02f, -5.78635298e-02f, 2.20977645e-02f, -9.96602327e-03f, 5.91646135e-02f, 3.27377580e-02f, 3.94485295e-02f, 5.17789386e-02f, -2.95753293e-02f, 1.00716755e-01f,
  4.96929809e-02f, 9.73553881e-02f, 1.37466967e-01f, 2.15655923e-01f, -7.18339607e-02f, -1.57292649e-01f, -1.31877020e-01f, -1.53767178e-02f, -1.07835174e-01f, -1.30364373e-01f,
  1.37740532e-02f, 4.88919690e-02f, -1.86507981e-02f, 6.38509393e-02f, 1.57022122e-02f, -1.80674568e-01f, 8.72319713e-02f, 5.05542662e-03f, 2.70572510e-02f, 1.89626992e-01f,
  2.16982454e-01f, -3.02836299e-02f, 1.72838122e-01f, 1.78287295e-03f, 1.13195546e-01f, 2.34750971e-01f, 3.00066590e-01f, 8.93078595e-02f, 1.75755695e-01f, 6.09416887e-02f,
  -7.46827051e-02f, 4.36696894e-02f, -4.29829722e-03f, -1.30814058e-03f, 3.02992947e-02f, 3.82447466e-02f, -6.02936186e-02f, -8.26612785e-02f, 5.82854263e-02f, 4.94154021e-02f,
  3.81370783e-02f, 4.60327715e-02f, -1.54874026e-04f, -1.19321216e-02f, -2.59647630e-02f, 7.50408992e-02f, -2.68591698e-02f, 1.66993085e-02f, 6.59745857e-02f, 6.87255338e-02f,
  8.09541941e-02f, 6.92785978e-02f, -6.51517659e-02f, 2.19330154e-02f, 8.05426482e-03f, -6.32494614e-02f, -2.70690545e-02f, 2.96278670e-02f, 7.44508207e-02f, 3.93864401e-02f,
  6.99081644e-02f, -6.64413869e-02f, -3.89252603e-02f, 4.56484593e-02f, -3.22355665e-02f, 4.80399765e-02f, 2.20557246e-02f, 3.28902155e-02f, -4.76961061e-02f, -6.56423494e-02f,
  1.60982665e-02f, 2.79135257e-02f, 1.03619378e-02f, -7.43983462e-02f, -5.18298149e-02f, -6.67217821e-02f, 2.17215903e-02f, -7.34581426e-02f, -1.07119624e-02f, -3.38093191e-03f,
  5.57349138e-02f, -3.76106327e-05f, 7.32572675e-02f, -1.51681108e-02f, -4.61347103e-02f, 8.48615170e-02f, 8.34700316e-02f, -1.69530530e-02f, -4.61605787e-02f, 1.04945406e-01f,
  4.81987791e-03f, 2.67271012e-01f, 9.49840546e-02f, 1.99071802e-02f, 5.30811585e-02f, -3.47951753e-03f, -2.38522924e-02f, 5.09656034e-02f, 1.26333997e-01f, 3.40968519e-02f,
  1.32782143e-02f, -2.35900041e-02f, -3.37691307e-02f, 3.23873535e-02f, 7.01985434e-02f, -3.47352889e-03f, 1.05121195e-01f, 5.43591641e-02f, -1.47504592e-03f, 1.61153935e-02f,
  -6.13338053e-02f, 4.96547967e-02f, 6.91351015e-03f, -8.33282098e-02f, 3.58352363e-02f, 6.15906790e-02f, 4.94041331e-02f, 4.54644226e-02f, -2.21989397e-02f, 7.63394684e-02f,
  -3.14483434e-01f, -2.80699600e-02f, -2.05406323e-01f, -1.42029688e-01f, -4.61241081e-02f, -9.17578265e-02f, -1.85703561e-02f, -7.19716623e-02f, -1.06793545e-01f, 2.15346262e-01f,
  8.33942369e-02f, -1.11790709e-01f, 7.33003691e-02f, -1.28570989e-01f, -2.87901074e-01f, -7.95120597e-02f, -1.42103612e-01f, -9.35299248e-02f, -1.37116551e-01f, -1.58699930e-01f,
  -1.38293281e-01f, -1.97435468e-02f, 1.07542221e-02f, -1.73039492e-02f, 2.66890638e-02f, -6.08130498e-03f, 5.91090992e-02f, -3.59383561e-02f, 7.52016380e-02f, -1.31051075e-02f,
  -4.22490947e-02f, -1.47803828e-01f, -1.08635230e-02f, -5.40285297e-02f, -6.05019517e-02f, 7.40900338e-02f, 1.58540513e-02f, 1.98414922e-02f, 5.23467064e-02f, -9.64591652e-02f,
  2.03839447e-02f, 2.80102226e-03f, -1.75220962e-03f, -2.70095700e-03f, 8.55556950e-02f, -8.27464368e-03f, 1.91741325e-02f, -3.96565907e-02f, -4.24657725e-02f, -5.21467403e-02f,
  -1.32480226e-02f, 5.06448150e-02f, -2.38654297e-02f, -6.20626286e-02f, 4.68398212e-03f, -6.85075074e-02f, -3.39297540e-02f, 3.47880125e-02f, -7.84446448e-02f, -9.82653070e-03f,
  -3.35017629e-02f, 4.67415521e-04f, -5.42116016e-02f, -3.95915955e-02f, -3.05445082e-02f, -2.29608808e-02f, 5.24589233e-02f, 7.23651126e-02f, 3.59932482e-02f, 5.00640087e-02f,
  3.36776003e-02f, -4.65782210e-02f, -4.15792875e-02f, -3.56081426e-02f, -5.17581254e-02f, 1.83368102e-02f, -4.05982733e-02f, -2.76063327e-02f, 6.63410127e-02f, 5.87474257e-02f,
  5.26780710e-02f, -3.68953757e-02f, 1.72101408e-02f, 1.13428235e-01f, 4.82191853e-02f, 1.94101259e-02f, -5.19016683e-02f, -4.24177945e-02f, -4.10496779e-02f, -1.31382979e-02f,
  -2.00930193e-01f, -2.94110849e-02f, 3.04603577e-02f, 5.83541431e-02f, -8.55776519e-02f, -1.40128154e-02f, 4.47687041e-03f, 9.58696660e-03f, -1.22030444e-01f, -3.05251833e-02f,
  -6.50201440e-02f, -3.19720469e-02f, -6.00378625e-02f, 5.83105646e-02f, 6.52504573e-03f, -2.19671950e-02f, -4.03040962e-04f, 1.18889473e-02f, -1.66021865e-02f, 1.58768166e-02f,
  -6.27591759e-02f, -5.61062694e-02f, -2.00070199e-02f, 8.06715563e-02f, 8.52813572e-02f, 2.94662621e-02f, 1.08230067e-02f, 4.58743051e-02f, 9.69961435e-02f, -4.54194993e-02f,
  2.05029875e-01f, -6.10343516e-02f, 3.53484862e-02f, 1.34849876e-01f, -2.26947106e-02f, 1.77924661e-03f, -1.90949161e-02f, 3.98849212e-02f, 3.34527105e-01f, -1.13731720e-01f,
  -6.49237633e-02f, 3.96370254e-02f, -9.31322873e-02f, 3.51939611e-02f, -1.45053649e-02f, -1.24212474e-01f, 4.21058573e-02f, -3.56370807e-02f, 9.56142098e-02f, -2.38968246e-02f,
  1.08028837e-01f, 3.54590192e-02f, -1.63638934e-01f, -8.26702043e-02f, 7.68935159e-02f, -4.16845754e-02f, -1.23935796e-01f, -4.83147502e-02f, -1.00502849e-01f, 1.95542015e-02f,
  -1.16892448e-02f, 1.29763097e-01f, 1.11409530e-01f, 4.06649336e-02f, -6.18047900e-02f, 6.47402480e-02f, -6.76317140e-02f, -7.08123744e-02f, -2.10588500e-02f, 2.25066617e-02f,
  -1.15752891e-02f, -5.55577241e-02f, 6.71616197e-02f, -8.84242281e-02f, -8.72324407e-03f, 1.06203899e-01f, 5.85597977e-02f, 5.90060204e-02f, -5.95283171e-04f, -7.75183877e-03f,
  -1.69925224e-02f, -2.25222111e-02f, 4.14546803e-02f, -8.08999389e-02f, -2.85711908e-03f, 8.52618441e-02f, -9.19739380e-02f, -5.83248809e-02f, 1.14267925e-02f, 3.57703157e-02f,
  -6.15068786e-02f, 2.52005756e-02f, -1.88481491e-02f, -1.24829868e-02f, 9.63080302e-03f, -6.15986660e-02f, 4.35586646e-02f, -1.63212996e-02f, 4.97842543e-02f, 1.79861225e-02f,
  3.83396707e-02f, 8.68185330e-03f, 5.79660386e-02f, 2.72119157e-02f, 6.47361055e-02f, 7.04334825e-02f, 2.01609842e-02f, -6.17116690e-03f, 6.11859150e-02f, 3.84843647e-02f,
  -4.45590243e-02f, -6.76821619e-02f, 1.03027232e-01f, -5.74680492e-02f, -8.04175436e-02f, 5.47969975e-02f, -9.37018469e-02f, 9.14246738e-02f, -2.53734142e-02f, 1.05254371e-02f,
  -2.87617296e-02f, -2.08233241e-02f, 5.57853356e-02f, 6.65173260e-03f, -3.64839397e-02f, -6.94896802e-02f, 3.11830733e-02f, -3.13543119e-02f, 7.28544816e-02f, 6.00130446e-02f,
  -1.54798944e-02f, -4.54915175e-03f, -2.47106664e-02f, -8.05142522e-02f, -2.22998671e-02f, 6.22869702e-03f, -2.50582397e-02f, 7.39983991e-02f, -7.11612701e-02f, -1.21770285e-01f,
  5.59888408e-02f, 1.86464526e-02f, 5.22495806e-02f, 3.29568982e-02f, 2.18443740e-02f, 7.21139684e-02f, -1.08529078e-02f, 2.90167909e-02f, 2.59802248e-02f, 6.16704896e-02f,
  2.64051855e-02f, 2.41775215e-01f, -3.61725390e-02f, 3.96185517e-02f, -1.33705005e-01f, 3.37250233e-02f, 7.04057440e-02f, 6.24995492e-02f, 2.30143234e-01f, 2.23311350e-01f,
  3.16587500e-02f, 1.28331795e-01f, 8.68282169e-02f, 5.51678278e-02f, 7.52072334e-02f, 1.39105871e-01f, 8.05138703e-03f, 7.63492137e-02f, 5.37983105e-02f, 9.03983042e-02f,
  1.14501603e-02f, 2.79523414e-02f, -6.76409900e-02f, -8.32083169e-03f, -9.81850475e-02f, -7.94859231e-02f, -8.29364210e-02f, -1.93186030e-01f, -9.65929851e-02f, 1.69778094e-02f,
  -3.51679884e-02f, -1.21328561e-02f, -8.90177116e-02f, 5.32265529e-02f, -7.24107251e-02f, -6.73981681e-02f, 7.24757090e-02f, -7.56027102e-02f, -8.78430828e-02f, 6.05130345e-02f,
  -4.16073902e-03f, -2.30720663e-03f, -1.80602521e-02f, 5.53318858e-02f, -1.40419509e-02f, 3.32691520e-02f, -3.76216993e-02f, -4.33127917e-02f, 3.90587375e-02f, -2.23099012e-02f,
  -4.15118001e-02f, 4.01074067e-03f, 2.91736443e-02f, -4.49329466e-02f, -8.24976191e-02f, -3.47363390e-02f, -6.15870543e-02f, 1.90325808e-02f, 5.91576248e-02f, 1.49319153e-02f,
  3.91228721e-02f, 1.01653129e-01f, 6.33130744e-02f, 1.32204918e-02f, 5.59701212e-02f, -1.13402000e-02f, 7.22511113e-02f, 8.70090872e-02f, -1.46416877e-03f, 2.77894940e-02f,
  7.08410367e-02f, -9.17922109e-02f, -2.90433317e-02f, 2.82917935e-02f, 2.70756539e-02f, 4.04209457e-02f, -2.12796163e-02f, 5.00787422e-03f, 3.42574678e-02f, 8.21597502e-02f,
  -1.14659602e-02f, -7.72718340e-02f, -8.60871449e-02f, -5.99191114e-02f, -5.24053955e-03f, 6.96585253e-02f, -6.98359385e-02f, -9.25632343e-02f, -3.99120040e-02f, -7.60635361e-02f,
  1.00178555e-01f, 7.52530247e-02f, -5.92352673e-02f, 1.24221640e-02f, 8.96446109e-02f, -3.03383861e-02f, -4.21656016e-03f, -3.93955074e-02f, 6.49689287e-02f, 9.39301699e-02f,
  -5.22684008e-02f, 2.30085589e-02f, -2.57697459e-02f, 3.74872424e-02f, -1.82787441e-02f, 5.34845926e-02f, 3.74299735e-02f, -1.44406045e-02f, -3.80663463e-04f, 7.37786666e-02f,
  -3.25345658e-02f, 2.12706588e-02f, -4.17456962e-02f, 5.58244921e-02f, 6.52759001e-02f, -7.78391287e-02f, -8.86837579e-03f, -3.02537773e-02f, -4.75953333e-02f, 6.45467266e-02f,
  -3.00297707e-01f, 6.60376325e-02f, -8.49213824e-02f, 6.68952316e-02f, -2.52611786e-01f, -3.12073052e-01f, -1.92744523e-01f, -1.07375674e-01f, -3.02478354e-02f, 2.52379984e-01f,
  1.62418932e-01f, -1.99954510e-02f, 5.48367612e-02f, 1.57527998e-01f, -1.57255977e-01f, 1.38938487e-01f, 1.47505492e-01f, 2.01475956e-02f, -5.59513010e-02f, 5.04775681e-02f,
  3.22734658e-03f, 1.56466186e-01f, 2.35790119e-01f, 2.62664054e-02f, 7.05353916e-02f, 1.13772579e-01f, 2.63958365e-01f, 9.09679476e-03f, 2.23250791e-01f, -7.68513530e-02f,
  -1.60623521e-01f, -3.53098469e-04f, -4.85573784e-02f, -9.74743664e-02f, -9.74097662e-03f, -2.78579928e-02f, 8.83801728e-02f, -9.46788192e-02f, 6.15349896e-02f, -3.83879244e-02f,
  -1.10465117e-01f, -4.38555852e-02f, -5.42060472e-02f, 3.79974470e-02f, -3.46010663e-02f, -7.46785551e-02f, 3.99961658e-02f, 6.48289472e-02f, -4.92774770e-02f, -3.73909809e-02f,
  4.50557843e-02f, 7.68137574e-02f, 8.89671370e-02f, 7.63892904e-02f, 1.59234460e-02f, 2.38225032e-02f, 7.08067939e-02f, 2.68402100e-02f, -2.95887161e-02f, -2.33867560e-02f,
  -1.03808552e-01f, 2.96636652e-02f, 4.07819934e-02f, 2.00424669e-03f, -4.35358547e-02f, 5.53367601e-04f, -9.21024159e-02f, -3.45618068e-03f, 3.58139686e-02f, 4.37344797e-02f,
  -9.37210917e-02f, -2.97853779e-02f, -1.46313831e-02f, 3.13010626e-02f, 3.63261476e-02f, 1.71471741e-02f, -7.14446139e-03f, 7.11014494e-02f, -1.59686618e-02f, 7.53587186e-02f,
  -5.34368621e-04f, -6.31045178e-02f, 8.47993195e-02f, 2.69712396e-02f, -3.98694053e-02f, 2.32360121e-02f, 3.25143263e-02f, -7.97803551e-02f, 5.12088276e-02f, 8.38692859e-02f,
  -1.15978248e-01f, 8.32938477e-02f, -5.81164705e-03f, -4.20058668e-02f, 4.15182821e-02f, 6.61309883e-02f, -2.08226182e-02f, -3.51021588e-02f, 3.87148522e-02f, -8.52845982e-02f,
  6.31297827e-02f, -4.14984860e-02f, -4.37430590e-02f, -2.55509745e-02f, -4.51819859e-02f, -4.84987721e-02f, 6.62060874e-03f, -4.28090133e-02f, 6.05027899e-02f, 8.12428370e-02f,
  4.54141833e-02f, -6.20981818e-03f, 4.20716293e-02f, 6.51757047e-03f, 4.42647375e-02f, 5.99096231e-02f, -1.16335370e-01f, -4.11067642e-02f, 9.30543318e-02f, 2.43024044e-02f,
  2.27182567e-01f, 1.78707913e-01f, 6.76724538e-02f, 1.95825547e-01f, -1.05816253e-01f, -1.76534683e-01f, -1.92174166e-01f, -1.20558433e-01f, 1.40687332e-01f, 4.86984774e-02f,
  -1.87136635e-01f, 3.69686037e-01f, -1.50623545e-01f, 7.21634924e-02f, -2.27600902e-01f, -2.58932084e-01f, -7.29418918e-02f, 9.60606262e-02f, 5.15046879e-04f, 1.50983117e-03f,
  3.79313380e-02f, -2.39868522e-01f, -9.93548706e-02f, -1.38943151e-01f, 1.11851640e-01f, 1.60166457e-01f, -7.03905672e-02f, -6.44592866e-02f, 6.14110306e-02f, -1.04182415e-01f,
  -5.57536334e-02f, -1.55176653e-03f, 5.96900769e-02f, 1.08030014e-01f, -8.97139385e-02f, 1.01781443e-01f, 7.19430223e-02f, -2.17710268e-02f, -2.03558337e-02f, 6.99865893e-02f,
  4.84780408e-02f, -8.05647019e-03f, -2.70148925e-03f, -2.60424539e-02f, -1.59470141e-02f, 1.07387252e-01f, 2.44815648e-02f, 3.26398797e-02f, 3.73840258e-02f, 1.23937115e-01f,
  -1.71106793e-02f, 4.81316214e-03f, -3.65608931e-02f, -2.85529695e-03f, -1.27592087e-02f, 6.28287196e-02f, 3.63642424e-02f, -1.63901132e-02f, 4.63373661e-02f, 6.10229373e-03f,
  1.69962943e-02f, 3.35565023e-02f, -1.63559895e-02f, -4.96918149e-02f, -9.45165977e-02f, 5.52562019e-03f, 3.72325256e-02f, 6.00301139e-02f, -2.91796634e-03f, -3.17728473e-03f,
  -7.54795969e-02f, 7.62739033e-02f, 2.55266577e-02f, 8.30001570e-03f, 2.31857225e-02f, -8.95414408e-03f, -5.32074124e-02f, -1.11880386e-02f, -2.05137823e-02f, -1.86019465e-02f,
  -1.19668161e-02f, -3.32349725e-02f, -4.84787747e-02f, 2.85281911e-02f, -2.64237653e-02f, 4.67825634e-03f, 3.18547674e-02f, -4.50684177e-03f, -5.46890385e-02f, -1.01997569e-01f,
  -1.71198323e-01f, -1.97454467e-01f, 7.03245029e-03f, 6.44281507e-02f, 1.33640307e-03f, -5.81387542e-02f, 5.23176566e-02f, 7.08270073e-02f, -6.90847412e-02f, -9.72132310e-02f,
  2.93110237e-02f, 6.26875162e-02f, -3.01304385e-02f, -6.26305342e-02f, 1.58883911e-02f, -4.33996543e-02f, -1.61483437e-02f, 1.35837179e-02f, -7.19685107e-02f, -2.89975032e-02f,
  8.08400661e-02f, 1.42830368e-02f, 3.68141159e-02f, 5.42911999e-02f, -4.48435405e-03f, -8.47395211e-02f, -2.13030148e-02f, -1.04658334e-02f, 1.87804345e-02f, 2.14415672e-03f,
  -3.37324053e-01f, -1.18551686e-01f, -1.68446004e-01f, -2.25474179e-01f, -1.82303656e-02f, 6.41503357e-05f, -5.06918021e-02f, -3.85196321e-02f, -2.91694164e-01f, 2.71249443e-01f,
  2.12739691e-01f, -2.93819129e-01f, 1.96877792e-01f, -5.04233725e-02f, -2.10244998e-01f, 1.26199760e-02f, 4.41231169e-02f, 1.45629704e-01f, -1.72334507e-01f, -5.58708198e-02f,
  3.67955714e-02f, 8.70024040e-02f, 6.03531338e-02f, 6.07771091e-02f, -7.32778804e-03f, 5.62067851e-02f, 2.14277521e-01f, -4.15757596e-02f, 1.36535048e-01f, -1.38539663e-02f,
  4.69090641e-02f, -8.56208578e-02f, -5.43313287e-02f, -1.14069507e-01f, 1.00601107e-01f, 7.12923855e-02f, 1.10723130e-01f, 4.70776223e-02f, -9.21499804e-02f, 2.58870367e-02f,
  3.15745436e-02f, 6.03842596e-03f, -1.29261374e-01f, -1.96950957e-02f, -8.03720653e-02f, 4.36534174e-02f, -1.08231030e-01f, 3.44832167e-02f, 4.38606075e-04f, -9.69248265e-02f,
  -5.54216877e-02f, 7.31583387e-02f, 9.40171629e-03f, 2.15358119e-02f, -3.96475643e-02f, -3.32657583e-02f, 1.06687844e-01f, -3.86865088e-03f, -1.40351960e-02f, -1.45059386e-02f,
  -5.28185396e-03f, 1.48049761e-02f, 6.91618323e-02f, -8.33034143e-02f, -1.81553103e-02f, 3.54564376e-02f, -6.24484867e-02f, -6.35681581e-03f, -3.01096030e-02f, 2.99949553e-02f,
  8.73222947e-03f, -1.67675535e-04f, 1.73484255e-02f, 3.83616053e-02f, 2.45399475e-02f, 1.19702015e-02f, 4.47820798e-02f, -5.76390065e-02f, -2.54389811e-02f, -2.90646069e-02f,
  5.47159323e-03f, -3.47565301e-02f, 1.41415074e-02f, 5.51104769e-02f, -4.48381715e-02f, 1.03530437e-01f, -1.51810981e-03f, 4.38159704e-02f, -4.31490913e-02f, 1.69662312e-02f,
  1.79803580e-01f, 5.43207936e-02f, 3.12235318e-02f, -4.11611646e-02f, 3.97968367e-02f, -2.72449572e-02f, 4.29106364e-03f, -2.58340221e-02f, 2.38175131e-02f, 2.37321910e-02f,
  8.97487700e-02f, 3.46965566e-02f, -3.55108851e-03f, -4.86856475e-02f, -3.10369655e-02f, 1.07427754e-01f, 1.18332915e-01f, 6.56333342e-02f, -1.98435374e-02f, -1.59652084e-02f,
  7.44073838e-02f, 1.05590805e-01f, -9.37776715e-02f, -6.12555034e-02f, 3.18992622e-02f, 7.92316124e-02f, 5.85693680e-02f, -3.84514853e-02f, -7.72675779e-03f, 8.14715326e-02f,
  3.59663814e-01f, -1.69677660e-01f, 2.44951800e-01f, 4.56215918e-01f, 2.79425472e-01f, -1.23762131e-01f, 8.44008997e-02f, 2.08049789e-01f, 4.09351498e-01f, -2.49474511e-01f,
  3.56344879e-02f, -1.34581327e-01f, -1.87471092e-01f, 2.64080502e-02f, -7.98613951e-02f, -9.46793705e-02f, 2.31840629e-02f, -1.18164666e-01f, 2.12042525e-01f, 1.48108557e-01f,
  2.54251093e-01f, -6.73105568e-02f, 4.00951207e-02f, -1.65939465e-01f, 1.05224907e-01f, 1.28170595e-01f, -1.45035401e-01f, -9.98102650e-02f, -1.30028516e-01f, -1.14007838e-01f,
  7.93888345e-02f, 2.12595001e-01f, 1.09069623e-01f, -8.35722089e-02f, -2.05998565e-03f, 8.33769608e-03f, -6.13979213e-02f, -1.62844211e-02f, 5.67807481e-02f, 5.34271039e-02f,
  -1.19412625e-02f, -2.26680823e-02f, 7.53748491e-02f, -3.56452055e-02f, 4.02291901e-02f, -2.38764156e-02f, 1.41392887e-01f, 2.63582487e-02f, -3.94312590e-02f, 2.62274705e-02f,
  2.84420364e-02f, 3.43938693e-02f, 1.18216388e-01f, -1.22454166e-01f, 9.83054042e-02f, 7.97718242e-02f, -3.83013636e-02f, -1.42651320e-01f, -1.14387684e-01f, 6.05144259e-03f,
  7.79997651e-03f, -9.03702225e-04f, 4.89946455e-02f, -1.39515819e-02f, 2.90326085e-02f, 1.07655488e-01f, 1.28177889e-02f, 1.76748913e-02f, -7.15014860e-02f, -2.51211263e-02f,
  4.57401527e-03f, 1.07302547e-01f, 1.76558979e-02f, 2.77206637e-02f, 3.20020169e-02f, 1.88017227e-02f, -1.05042234e-01f, -3.50264274e-02f, 4.53023314e-02f, 6.39087260e-02f,
  -5.39532155e-02f, 4.50486317e-02f, -6.00516312e-02f, 6.90541863e-02f, 7.66988285e-03f, 2.67386585e-02f, 4.15907986e-02f, -4.13801614e-03f, 4.66953404e-02f, -6.36825413e-02f,
  -1.60396278e-01f, -8.51003975e-02f, -6.72422871e-02f, 2.54532024e-02f, -8.80481079e-02f, -7.34186471e-02f, -1.29360761e-02f, 6.11233898e-02f, 1.85862475e-03f, 3.76608670e-02f,
  -2.56857574e-02f, -4.47179638e-02f, -3.22013944e-02f, -8.13928321e-02f, -4.29995172e-02f, 6.10942282e-02f, -8.68328512e-02f, -1.64429713e-02f, 3.66627164e-02f, -5.29794442e-03f,
  -2.05046423e-02f, 3.58111970e-02f, 4.32320312e-03f, 1.02640778e-01f, -1.30425140e-01f, -6.07525706e-02f, -6.01693802e-03f, -3.66260819e-02f, -8.96523222e-02f, -1.55538283e-02f,
  1.41704485e-01f, -2.31100976e-01f, -2.34583970e-02f, -2.19520312e-02f, 1.45773843e-01f, 1.01140089e-01f, 1.93612948e-01f, -7.57999942e-02f, 1.98030919e-01f, -1.56099901e-01f,
  5.17099276e-02f, -1.88007697e-01f, 4.25314419e-02f, -3.38002667e-02f, 1.78189978e-01f, 1.10718764e-01f, -3.06428201e-03f, -4.03826386e-02f, 8.93778652e-02f, -4.46763486e-02f,
  1.08136468e-01f, -9.96721815e-03f, -1.34657267e-02f, -2.18508750e-01f, -7.94322789e-02f, -6.99709654e-02f, -2.64369287e-02f, -9.62834433e-02f, -2.42035821e-01f, -4.34049964e-02f,
  1.09819710e-01f, 8.05044249e-02f, 3.49426121e-02f, -2.06633043e-02f, -2.20117755e-02f, -9.66196805e-02f, -1.29015014e-01f, -5.79070188e-02f, 1.09610327e-01f, 1.08524509e-01f,
  4.24800292e-02f, -1.01479217e-02f, -5.90828694e-02f, -1.68468039e-02f, 6.92458004e-02f, -3.00839543e-02f, -9.23529360e-03f, 7.20993727e-02f, 3.65445577e-02f, -7.23634735e-02f,
  -1.05880965e-02f, -2.94283330e-02f, -6.59554377e-02f, 4.70527820e-03f, -2.13111211e-02f, -5.03178164e-02f, -4.14768830e-02f, -1.17436983e-01f, -1.27384707e-01f, 2.36185305e-02f,
  -3.62909548e-02f, 7.33196065e-02f, -1.48172434e-02f, 1.04730628e-01f, 5.33642024e-02f, 1.18071737e-03f, 6.14946410e-02f, -1.14505440e-02f, 6.42395318e-02f, 3.36817130e-02f,
  4.81431521e-02f, -4.41344418e-02f, -1.38922576e-02f, -7.85910338e-02f, -5.99628780e-03f, -1.32868662e-02f, -6.32570032e-03f, -2.66488697e-02f, 6.34288788e-02f, -5.88420965e-02f,
  5.71505688e-02f, 5.23622259e-02f, 4.65240963e-02f, 5.31705981e-03f, 4.61383946e-02f, -5.74802607e-03f, -7.97470957e-02f, -7.33798966e-02f, 4.78558280e-02f, 8.29472616e-02f,
  -9.28626955e-02f, -1.38260141e-01f, 6.75211996e-02f, 2.05818973e-02f, 1.35318814e-02f, 3.10157705e-02f, -7.28884190e-02f, 7.14672133e-02f, 1.56246987e-03f, 5.84462732e-02f,
  -9.90718380e-02f, -3.10592819e-02f, -5.43531664e-02f, 2.51581613e-02f, 9.39834770e-03f, 1.03439521e-02f, -1.46243926e-02f, -6.77995607e-02f, -6.16696775e-02f, -1.84624642e-01f,
  -7.66456127e-02f, -4.64486256e-02f, 3.15747187e-02f, -9.56016686e-03f, -1.06656134e-01f, -3.83135080e-02f, -1.57989599e-02f, -3.13964859e-02f, 2.40366790e-03f, -3.12829390e-02f,
  1.03959456e-01f, -2.51323334e-03f, -9.63773206e-02f, -1.18199572e-01f, 9.22568515e-02f, 2.10392937e-01f, 1.01731323e-01f, -2.88865864e-02f, -2.56056823e-02f, -3.49260606e-02f,
  4.67358939e-02f, 2.95033008e-02f, -1.18975192e-01f, 5.36516570e-02f, 1.06374651e-01f, 1.98959317e-02f, 4.98755910e-02f, 1.27002016e-01f, -8.86296630e-02f, -2.24896632e-02f,
  7.60782585e-02f, 1.95923168e-02f, -7.95725435e-02f, -2.82224603e-02f, -4.42954451e-02f, -9.11538005e-02f, -6.84852228e-02f, -9.90190823e-03f, 2.64536645e-02f, 1.37208208e-01f,
  6.86837807e-02f, 7.02750832e-02f, 1.20785628e-02f, -9.96968672e-02f, 5.41796125e-02f, -6.62149414e-02f, -5.22635542e-02f, -1.02321459e-02f, 6.90328553e-02f, -3.57475877e-02f,
  8.68919864e-02f, 9.29117762e-03f, -5.77211753e-03f, -5.07353954e-02f, 6.11684509e-02f, 6.16663322e-02f, 4.70058694e-02f, -7.82265738e-02f, -4.13380452e-02f, 2.73718424e-02f,
  -1.29701689e-01f, 4.17932682e-02f, -1.06555000e-01f, 4.23760489e-02f, -6.56569377e-02f, -2.52047405e-02f, -5.45177758e-02f, -8.29098225e-02f, 1.39467483e-02f, 4.85129058e-02f,
  4.85125668e-02f, -2.89447550e-02f, 4.00635637e-02f, -4.30272482e-02f, -3.50706652e-02f, 5.01530692e-02f, 7.59621859e-02f, 6.90353289e-02f, 6.54082298e-02f, 4.10114788e-02f,
  3.81782204e-02f, -4.50863764e-02f, 5.07506393e-02f, 4.05248068e-02f, 4.78017554e-02f, 4.68747988e-02f, -2.42039617e-02f, -3.74765024e-02f, -2.71945689e-02f, 1.48517108e-02f,
  -3.07471547e-02f, 4.30997834e-02f, -1.43287862e-02f, -6.33472800e-02f, 8.14307630e-02f, 5.24851643e-02f, 6.07989216e-03f, -9.41202566e-02f, -1.75963193e-02f, -3.44646834e-02f,
  -5.33610806e-02f, 1.47835508e-01f, -8.12436715e-02f, -7.93999955e-02f, 7.39751235e-02f, 1.11272968e-01f, 5.95348477e-02f, 1.09018140e-01f, 2.18731947e-02f, 1.16135411e-01f,
  -1.02527402e-02f, 1.34034008e-02f, 1.24400994e-02f, -4.09251191e-02f, 4.71335910e-02f, 4.63331304e-02f, -3.17792036e-02f, -1.45996772e-02f, 7.04319254e-02f, -3.42350230e-02f,
  -1.53608490e-02f, -2.14878693e-02f, 2.26371400e-02f, 7.03758225e-02f, -4.79360074e-02f, -6.57396913e-02f, 1.06758690e-02f, 6.70399368e-02f, 4.50032651e-02f, 2.61532534e-02f,
  4.59263444e-01f, -4.96508300e-01f, -4.03086662e-01f, 1.35218233e-01f, 2.71570891e-01f, 2.94056177e-01f, 1.62569955e-01f, -1.41065270e-02f, -1.36287034e-01f, -2.60291457e-01f,
  1.88751563e-01f, -1.00916782e-02f, -2.75814354e-01f, 2.89171964e-01f, 4.87032145e-01f, -2.69389212e-01f, 2.93788821e-01f, 7.56461620e-02f, -3.44842747e-02f, 5.72980829e-02f,
  1.27587989e-01f, 3.61176908e-01f, -5.14037348e-02f, 3.72652002e-02f, 2.54506409e-01f, -1.34191409e-01f, 1.45712957e-01f, -1.77906170e-01f, 2.15047017e-01f, 2.48993784e-01f,
  3.67548726e-02f, 2.97199301e-02f, -1.59837641e-02f, -5.07237948e-02f, -3.07398587e-02f, -7.92253017e-03f, 4.51184101e-02f, 7.84338564e-02f, -2.28783507e-02f, -6.59037149e-03f,
  1.21035716e-02f, 4.90079038e-02f, 9.85814109e-02f, 2.76002418e-02f, -1.35542154e-02f, -5.57530858e-03f, 3.77665199e-02f, -8.24225172e-02f, -7.06387758e-02f, -3.76403555e-02f,
  -8.95463973e-02f, -4.84203622e-02f, -4.29243781e-02f, -5.82538024e-02f, -4.81566787e-02f, 6.63963184e-02f, 6.40392900e-02f, -5.48205748e-02f, 5.14698029e-03f, 7.03968555e-02f,
  3.30938287e-02f, 2.50005517e-02f, -2.16132980e-02f, 1.10998768e-02f, -1.32450101e-03f, -4.44598012e-02f, 7.69712031e-02f, -5.01708277e-02f, -8.36687610e-02f, -3.83548974e-03f,
  6.37334865e-03f, 1.63944643e-02f, -9.67210066e-03f, 2.29610447e-02f, 4.59127203e-02f, -4.96354960e-02f, 3.45007554e-02f, 1.40417982e-02f, -8.89159143e-02f, -1.16265779e-02f,
  -8.95603374e-02f, -1.25068575e-02f, 3.43378447e-03f, -4.17080596e-02f, -2.51997747e-02f, 1.98999550e-02f, 1.21766562e-02f, -3.04014068e-02f, -8.00060034e-02f, 1.53561085e-02f,
  -7.18812644e-02f, -2.08339244e-01f, -1.10130198e-01f, 5.23709692e-02f, -1.44747887e-02f, 1.02699265e-01f, -8.53072628e-02f, -4.42084409e-02f, 3.62173712e-04f, -3.97341736e-02f,
  3.02706156e-02f, 1.95896029e-02f, -4.37038876e-02f, 5.61083220e-02f, -3.39927804e-03f, -1.45956371e-02f, 3.20616439e-02f, -4.42318916e-02f, 8.40672925e-02f, 1.30200274e-02f,
  -6.19154945e-02f, 4.23046574e-02f, 1.69130899e-02f, -3.07199620e-02f, 4.19175141e-02f, -1.70346331e-02f, -1.78576987e-02f, -8.11293796e-02f, -2.57130363e-03f, -7.31823221e-02f,
  -2.50490487e-01f, 2.18602538e-01f, -3.00785899e-01f, -1.58829987e-01f, -5.39264753e-02f, 1.33854508e-01f, 1.68224365e-01f, -6.19062148e-02f, -1.13885529e-01f, 4.48649704e-01f,
  3.21203619e-01f, -1.64911762e-01f, 2.94578940e-01f, 3.52078497e-01f, -3.61543417e-01f, 1.10536516e-01f, 2.54679948e-01f, 2.21807122e-01f, -1.64494023e-01f, 7.37053454e-02f,
  -1.31816357e-01f, 2.76002288e-01f, -1.09843962e-01f, 4.83483225e-02f, -2.63782404e-03f, -1.17086537e-01f, 1.31701782e-01f, 8.00732430e-03f, 6.90013927e-04f, -4.29240018e-02f,
  1.43926784e-01f, -5.49274944e-02f, -2.81102452e-02f, 3.36947106e-02f, -1.93427615e-02f, 9.24912915e-02f, 2.27716914e-03f, -8.72248486e-02f, -3.55369076e-02f, -4.63657305e-02f,
  -8.82209539e-02f, -6.35556355e-02f, 5.59756905e-02f, 1.27144838e-02f, -1.04144983e-01f, -8.35497975e-02f, -3.13811079e-02f, -1.00890938e-02f, 4.03312128e-03f, -7.75158927e-02f,
  -9.40657258e-02f, -5.46872057e-02f, -2.83888783e-02f, 6.32251278e-02f, -9.75921750e-02f, -2.82426775e-02f, -6.43441752e-02f, -6.98890761e-02f, 4.77798432e-02f, -9.14446786e-02f,
  2.02301294e-02f, 1.17710061e-01f, 1.07857086e-01f, 3.15448530e-02f, -8.10395833e-03f, 8.16120282e-02f, 3.53952982e-02f, 4.09238599e-02f, -5.86516038e-02f, -1.87933762e-02f,
  -4.11934517e-02f, -9.32334140e-02f, -2.56283823e-02f, 5.11320718e-02f, 6.49850443e-02f, 4.64604143e-03f, -5.35366824e-03f, 2.08079889e-02f, 2.34615952e-02f, -5.15386537e-02f,
  6.50855377e-02f, 2.87901089e-02f, 5.54665774e-02f, 8.99975076e-02f, 1.79785974e-02f, -2.30305176e-02f, 8.77210796e-02f, -1.71225052e-02f, -4.16076109e-02f, -4.04720865e-02f,
  1.16825625e-01f, -9.93812308e-02f, 3.11921015e-02f, -1.69244912e-02f, 8.40796828e-02f, 3.41383964e-02f, 8.55124891e-02f, -1.00086905e-01f, -2.13757213e-02f, -2.79256161e-02f,
  -4.29157354e-02f, -2.12557823e-03f, 3.53151895e-02f, 6.67548180e-02f, 4.70043942e-02f, 7.02317506e-02f, 4.34121154e-02f, -3.60819846e-02f, 7.38710770e-03f, -4.53375913e-02f,
  4.01403047e-02f, -5.25441989e-02f, -6.00214675e-02f, -4.35111895e-02f, 3.33364457e-02f, 5.93880489e-02f, -1.40655190e-02f, 4.49567400e-02f, -7.34546930e-02f, -1.28207784e-02f,
  -3.40475887e-01f, 9.26882699e-02f, 2.20084023e-02f, -2.11048260e-01f, 1.02798253e-01f, -6.67689294e-02f, -1.07699037e-01f, 1.17540635e-01f, -9.83417928e-02f, 2.04602182e-02f,
  -1.05051212e-01f, -1.99510962e-01f, -3.26350071e-02f, -7.01508820e-02f, -8.62043723e-02f, -3.79611030e-02f, -1.42157733e-01f, -1.88712552e-01f, -6.81605786e-02f, 9.30499807e-02f,
  -1.01977959e-01f, 5.14588412e-03f, 1.66836441e-01f, 1.86997578e-01f, 6.79931268e-02f, 1.40324965e-01f, -1.57072023e-02f, 1.88857764e-01f, -1.20864501e-02f, -2.38376670e-02f,
  -1.00027688e-01f, -6.56415671e-02f, 7.49724582e-02f, 9.79376510e-02f, 6.17018603e-02f, 4.55093235e-02f, -4.33449298e-02f, 2.15512551e-02f, -7.07371086e-02f, 9.33866762e-03f,
  -9.29017961e-02f, -1.01439320e-02f, -5.09436876e-02f, 3.25759128e-02f, 1.11530513e-01f, 3.90611216e-03f, 8.89081210e-02f, -1.56587474e-02f, 9.35750455e-03f, 5.25900163e-02f,
  2.18256656e-02f, -5.73854474e-03f, -8.72865245e-02f, -1.53203132e-02f, -3.93038653e-02f, -4.30764258e-02f, 4.19931561e-02f, 8.75135884e-03f, -8.83024037e-02f, 6.00782782e-02f,
  4.09408920e-02f, -3.84212169e-03f, 7.41841570e-02f, 4.91070934e-02f, -7.27255642e-02f, 8.40526149e-02f, -1.87930502e-02f, 6.69233426e-02f, 1.00834779e-02f, 2.21504085e-02f,
  -6.29243394e-03f, 1.41869364e-02f, -6.60225525e-02f, -5.29309846e-02f, 5.79099432e-02f, -4.27094698e-02f, -6.17560931e-03f, 4.45225723e-02f, 5.53684384e-02f, -7.47219846e-02f,
  -3.30143310e-02f, -7.60264248e-02f, 5.69796488e-02f, -3.03833727e-02f, -8.27835780e-03f, -7.71416305e-03f, -2.33478961e-03f, -1.07079871e-01f, 5.24255745e-02f, -4.59342562e-02f,
  1.34119075e-02f, 1.39438599e-01f, 8.46589282e-02f, -4.07864787e-02f, 1.47632833e-04f, -3.66952047e-02f, 8.18699002e-02f, -1.36730960e-02f, 3.45684513e-02f, -2.28159484e-02f,
  5.39764054e-02f, -7.90130422e-02f, -2.11804807e-02f, -4.66707833e-02f, 7.47078508e-02f, 7.58783221e-02f, -3.89147028e-02f, 1.89601183e-02f, 6.67207241e-02f, 1.22467130e-02f,
  3.17374896e-03f, 6.20526448e-02f, -7.98054338e-02f, 3.46901938e-02f, -1.12455048e-01f, -8.19350313e-03f, 2.01569553e-02f, -6.49652630e-02f, -3.86493243e-02f, 5.13700806e-02f,
  3.33819501e-02f, -8.78046006e-02f, -8.89576375e-02f, 1.25172781e-03f, 2.10134104e-01f, -7.94931799e-02f, 1.09657921e-01f, 6.76398277e-02f, 2.11682003e-02f, 6.13147207e-02f,
  -4.68564816e-02f, -2.40382478e-02f, -1.87660664e-01f, -2.08857954e-01f, -2.04448730e-01f, -2.96909630e-01f, -1.06236592e-01f, -1.07958518e-01f, 1.88117828e-02f, 6.07301947e-03f,
  -3.12939398e-02f, 1.42103732e-02f, -7.48671889e-02f, -1.04888342e-02f, 1.45603895e-01f, 1.58660829e-01f, 1.71223059e-01f, 7.59830698e-02f, 8.36664289e-02f, -1.43718466e-01f,
  -9.06406902e-03f, 4.22333404e-02f, -3.65740582e-02f, -1.05549641e-01f, 4.73675458e-03f, 1.30427688e-01f, 4.23101261e-02f, 2.96005979e-02f, 2.18081884e-02f, -3.43293250e-02f,
  5.87321110e-02f, 1.82771608e-02f, 4.15898822e-02f, -6.28294125e-02f, 1.40744925e-01f, 1.23725515e-02f, -2.96902694e-02f, -2.77292281e-02f, -3.67541015e-02f, 2.26652585e-02f,
  5.39330132e-02f, -9.53963920e-02f, 2.88740490e-02f, -8.09923559e-02f, 7.40250945e-02f, 7.77698681e-02f, -2.30664876e-03f, -2.90855709e-02f, 4.24559824e-02f, -6.41075298e-02f,
  2.72898637e-02f, 3.13497595e-02f, -6.19217567e-02f, 4.02364656e-02f, 3.56141254e-02f, 5.15357638e-03f, -6.74456581e-02f, 4.13854653e-03f, 3.84981930e-02f, -6.23999946e-02f,
  7.83685148e-02f, 3.82332131e-02f, 2.63209175e-02f, 4.72724698e-02f, 5.73534817e-02f, 1.43195856e-02f, -3.43241468e-02f, -5.05698137e-02f, -1.31322704e-02f, 2.34590899e-02f,
  4.26536761e-02f, -2.42836052e-03f, -5.10142520e-02f, 2.85904147e-02f, -7.06983283e-02f, 1.89236682e-02f, -3.36869881e-02f, 2.55673639e-02f, -3.77685875e-02f, 4.65542227e-02f,
  -4.67143673e-03f, -6.61845086e-03f, 3.74474637e-02f, -7.33789578e-02f, 4.03900146e-02f, 9.39165428e-02f, 3.62770222e-02f, -4.54984717e-02f, -2.61019506e-02f, -1.70082133e-02f,
  7.20013008e-02f, 1.03214845e-01f, 9.83117297e-02f, -1.03634438e-02f, -1.10314758e-02f, -5.26184775e-02f, -3.49700428e-03f, -1.50887473e-02f, 9.18541700e-02f, 6.77329004e-02f,
  8.76076072e-02f, 2.13570502e-02f, 6.65547103e-02f, -2.40733903e-02f, -1.58559717e-02f, -5.89097105e-02f, 5.18573001e-02f, 8.09546839e-03f, -1.83599978e-03f, -4.13955227e-02f,
  -5.11006534e-01f, 1.77314758e-01f, -2.33228225e-02f, -2.06186965e-01f, -1.35302365e-01f, -2.40697246e-02f, 8.31583887e-02f, -3.40704285e-02f, -2.61602104e-01f, 1.34066731e-01f,
  2.05356538e-01f, -1.53084740e-01f, 2.10061908e-01f, 1.14914887e-01f, -3.81760597e-02f, 1.35560319e-01f, -1.34818321e-02f, 3.84513997e-02f, -1.02223679e-02f, -2.06393674e-01f,
  -1.23935938e-01f, 3.09488308e-02f, 8.49598050e-02f, 9.23354998e-02f, -1.01893097e-01f, -1.74838066e-01f, -7.33873947e-03f, 6.51099905e-02f, 3.77427600e-02f, 1.46856591e-01f,
  -1.09109163e-01f, -2.74724036e-01f, -1.92254692e-01f, -9.89160240e-02f, -1.42718762e-01f, 4.61521652e-03f, -8.11963994e-03f, -1.93618014e-02f, -6.28951490e-02f, -2.10286342e-02f,
  2.12730747e-03f, -6.14449680e-02f, 1.04649388e-03f, -1.79336201e-02f, -7.93295056e-02f, 1.46324383e-02f, 6.52816072e-02f, -3.85622717e-02f, -7.44057670e-02f, -5.47427684e-02f,
  -1.05669769e-02f, -2.97718607e-02f, -2.96263434e-02f, 8.98242891e-02f, 1.14898458e-02f, 4.98299599e-02f, -2.21449602e-03f, 9.69757885e-03f, -1.90904569e-02f, -9.21615660e-02f,
  -3.19411233e-02f, -9.25155208e-02f, -3.45098041e-02f, -4.21171673e-02f, -8.06433111e-02f, 4.03751656e-02f, 4.35575210e-02f, 7.64420405e-02f, -6.57578707e-02f, 4.71544676e-02f,
  -8.80867243e-02f, 3.68768759e-02f, -9.49934684e-03f, 7.39298016e-03f, -6.94501922e-02f, -9.30927768e-02f, -7.05109462e-02f, -4.25699875e-02f, -6.55573234e-02f, 5.23190722e-02f,
  -1.62039287e-02f, -5.02188057e-02f, -3.51952799e-02f, -4.68589999e-02f, -4.08274606e-02f, -1.35460347e-02f, -3.10270581e-04f, 4.05026414e-02f, 7.98148662e-02f, -7.29044527e-02f,
  -3.23203266e-01f, -2.41962940e-01f, -4.78074811e-02f, -1.52773783e-01f, -1.30983308e-01f, -8.63042697e-02f, 2.83325533e-03f, -4.60968167e-02f, -1.07038721e-01f, -1.36859149e-01f,
  1.21998694e-02f, 2.71787047e-02f, -1.91076752e-02f, -3.74294072e-02f, -2.56844368e-02f, -4.10897173e-02f, 1.57733578e-02f, -4.25108299e-02f, -4.67730910e-02f, 5.27104326e-02f,
  -5.66967949e-03f, 1.57286897e-02f, 8.18364546e-02f, -3.87334488e-02f, 7.56885903e-03f, -3.07471473e-02f, -1.04362696e-01f, -5.48315607e-03f, 5.36891259e-02f, 6.97995946e-02f,
  5.81982769e-02f, -2.59061277e-01f, 5.33272512e-02f, 2.73463607e-01f, 6.80377409e-02f, -4.83072884e-02f, -1.44961759e-01f, -1.50811702e-01f, -1.11241646e-01f, -3.08998227e-01f,
  -1.05596676e-01f, 3.86978537e-02f, -4.11100388e-01f, 2.63832539e-01f, 4.55904901e-01f, -1.97469547e-01f, 2.43435636e-01f, 8.25857669e-02f, 1.05786035e-02f, 3.78477834e-02f,
  2.10375622e-01f, 2.52476186e-01f, 1.85153663e-01f, 2.36440510e-01f, 1.84648916e-01f, 1.40934974e-01f, 2.42830381e-01f, 8.00348818e-02f, 3.47893447e-01f, 1.43057302e-01f,
  5.66163100e-02f, -7.73347691e-02f, 4.99235354e-02f, -3.65746650e-03f, -1.15873456e-01f, -6.57075867e-02f, 9.02597904e-02f, 3.08257695e-02f, 5.68337217e-02f, -8.03874899e-03f,
  -7.52182305e-02f, 6.20693937e-02f, 5.70151284e-02f, 3.83491181e-02f, 7.20748082e-02f, 1.11405790e-01f, -1.19663449e-03f, -8.88322145e-02f, 3.66999838e-03f, -1.07593484e-01f,
  -1.06055394e-01f, -1.05261942e-02f, -2.66599562e-02f, 6.94422647e-02f, 3.64262387e-02f, -2.63648108e-03f, 3.18200514e-02f, -3.25042158e-02f, -1.91624295e-02f, 7.34374672e-02f,
  1.41396625e-02f, 1.85382012e-02f, -9.27490219e-02f, 1.58935525e-02f, -3.64736915e-02f, -3.88681032e-02f, -3.18504013e-02f, -2.07572244e-02f, 1.78497881e-02f, -5.33505790e-02f,
  2.91599389e-02f, -5.01154289e-02f, 6.73949942e-02f, -2.23345328e-02f, -2.97989286e-02f, -4.97058826e-03f, -2.11576093e-03f, 7.98536930e-03f, -7.38393590e-02f, 4.91849631e-02f,
  -1.37196826e-02f, 6.16713017e-02f, 1.84706114e-02f, 6.16498664e-03f, 3.20833884e-02f, -4.45390344e-02f, 8.26321263e-03f, -9.61835980e-02f, 6.48115426e-02f, 2.45246459e-02f,
  -2.92986020e-04f, 2.93548293e-02f, 1.48623731e-04f, 4.79825810e-02f, 3.08503280e-03f, -1.56390611e-02f, 7.73592219e-02f, 8.64977762e-02f, 5.58850579e-02f, 1.94748882e-02f,
  -2.79015098e-02f, 3.67954746e-02f, 2.99857277e-03f, 1.24595195e-01f, 1.51495859e-02f, -9.84668508e-02f, 5.36717027e-02f, -2.45588198e-02f, -2.83451397e-02f, -5.21984976e-03f,
  5.18694259e-02f, -1.01164967e-01f, 2.51183398e-02f, -4.02587950e-02f, -8.77061393e-03f, 5.00936247e-02f, 7.03142285e-02f, -1.53851109e-02f, 4.78065833e-02f, 7.03872973e-03f,
  1.10766985e-01f, -3.91734429e-02f, 4.41289693e-02f, -5.28728142e-02f, 1.65898860e-01f, 1.28681928e-01f, -7.81573430e-02f, 1.61658883e-01f, 2.86184885e-02f, -8.86836722e-02f,
  3.87526602e-02f, -1.36207968e-01f, -5.49118891e-02f, -4.80803996e-02f, 8.88684765e-02f, -5.66085875e-02f, -6.80073723e-02f, -7.98727795e-02f, 9.13728550e-02f, -4.38873842e-02f,
  1.05911963e-01f, -6.68847561e-02f, 4.38048318e-02f, -2.05270015e-02f, 8.68912861e-02f, 7.80032426e-02f, -1.84455363e-03f, -1.12675779e-01f, 1.13970660e-01f, 8.40101466e-02f,
  3.97607684e-02f, -1.18823327e-01f, 4.03612852e-02f, 2.78174151e-02f, -5.42084686e-02f, 1.56273134e-02f, 1.40273047e-03f, 5.66564053e-02f, -4.08318043e-02f, -7.99915791e-02f,
  -3.66441021e-03f, -1.68476701e-02f, 1.73642114e-02f, -1.76105369e-02f, 1.17638158e-02f, 7.14202598e-02f, 1.05078913e-01f, -6.16194494e-03f, 7.50841349e-02f, 1.18451118e-01f,
  1.01638608e-01f, -1.40334694e-02f, -4.03040834e-02f, 5.91442175e-02f, -3.80868986e-02f, -8.43641236e-02f, 8.49765465e-02f, 6.08354397e-02f, 4.73821685e-02f, -5.05528785e-02f,
  3.35034020e-02f, -5.93856350e-02f, -5.09927087e-02f, 1.04741760e-01f, 3.18645015e-02f, 1.02387004e-01f, 4.60872799e-02f, 3.40002961e-02f, 7.55584463e-02f, -3.20208296e-02f,
  -5.82474582e-02f, -1.61910821e-02f, 4.09391709e-02f, 6.87722340e-02f, -2.92363539e-02f, 6.21194541e-02f, 8.97351000e-03f, -1.89309195e-02f, 1.90258678e-02f, 2.05219276e-02f,
  9.14812647e-03f, -1.89717077e-02f, -9.36841741e-02f, -9.18660536e-02f, 4.44834679e-02f, -1.13717295e-01f, 3.79131697e-02f, 7.60431960e-02f, -1.64789651e-02f, 8.16537812e-02f,
  2.84795463e-02f, -7.88691640e-02f, -6.62323013e-02f, 2.32773945e-02f, -2.40680929e-02f, -3.93329561e-03f, -9.39826965e-02f, 1.17706366e-01f, 1.86432991e-02f, -2.23934036e-02f,
  2.96079647e-02f, -5.95244132e-02f, 9.71078724e-02f, -4.07398865e-02f, -5.92397116e-02f, 9.61401686e-02f, 1.59618650e-02f, -2.99144611e-02f, 7.60145187e-02f, 1.29997417e-01f,
  2.94048842e-02f, -5.46286926e-02f, 2.48936843e-02f, 7.23598450e-02f, 4.58072647e-02f, -5.01151718e-02f, 5.76547123e-02f, 7.25481734e-02f, -4.26857658e-02f, -6.09943010e-02f,
  -3.42845507e-02f, -8.14690068e-02f, 1.35665789e-01f, -5.21001630e-02f, -9.52610672e-02f, 1.24857230e-02f, -1.44120052e-01f, -1.54637238e-02f, -2.57465933e-02f, -1.25440195e-01f,
  -1.26291141e-01f, 5.48432693e-02f, -4.47588786e-02f, -6.40876740e-02f, -8.72356072e-02f, -4.62418944e-02f, -9.42651033e-02f, -2.34085484e-03f, -2.00622194e-02f, 2.59684790e-02f,
  -7.19331652e-02f, -1.45497069e-01f, 3.14208828e-02f, -8.92476961e-02f, -6.65851757e-02f, 1.08403079e-01f, 1.98457297e-02f, 6.92296326e-02f, -9.81731620e-03f, -6.62080497e-02f,
  -5.60373068e-03f, 3.81594822e-02f, 8.03744122e-02f, 2.47646011e-02f, 4.33167107e-02f, 9.37330946e-02f, 7.75809363e-02f, 5.78770377e-02f, 7.45783653e-03f, 5.73221520e-02f,
  -2.92353769e-04f, -1.95489395e-02f, 3.52789313e-02f, 2.11820733e-02f, 6.17719814e-02f, 7.83234909e-02f, 7.27796853e-02f, 3.74999531e-02f, 8.34381059e-02f, 9.42308456e-02f,
  -5.44839166e-03f, 2.69477926e-02f, -6.58075660e-02f, 3.76950726e-02f, 8.49108249e-02f, -5.94157316e-02f, 3.87647301e-02f, 1.02968253e-01f, -7.58458823e-02f, 4.13830169e-02f,
  -4.72767605e-03f, 8.35043639e-02f, -1.33556295e-02f, -1.78330690e-02f, 3.57395783e-02f, 2.42694430e-02f, 4.96623069e-02f, 6.39167130e-02f, 1.75069105e-02f, -3.73199619e-02f,
  7.29038939e-02f, 2.52802181e-03f, -9.14494023e-02f, 1.12903481e-02f, -3.82172130e-02f, 6.37687892e-02f, 1.02407768e-01f, -5.10268025e-02f, 7.09009096e-02f, 8.57484788e-02f,
  -5.79517670e-02f, -3.98334377e-02f, 7.52127692e-02f, -1.37751643e-02f, -5.35045415e-02f, -7.84054026e-02f, -8.53853151e-02f, 7.15602636e-02f, 2.87908758e-03f, 5.40248863e-02f,
  -6.80438461e-05f, -8.61199275e-02f, 7.27815926e-02f, 8.31895918e-02f, 4.33430597e-02f, -5.97121790e-02f, -4.18504700e-02f, 4.55710553e-02f, -6.15489148e-02f, -6.24071844e-02f,
  9.16672051e-02f, -5.96301705e-02f, 6.45321012e-02f, -3.97829115e-02f, -9.48948860e-02f, -4.30925637e-02f, -3.10071912e-02f, 6.82507679e-02f, 7.92308226e-02f, -2.92493403e-02f,
  -1.34490700e-02f, 6.18549101e-02f, -1.03357799e-01f, -8.24596062e-02f, -5.60762845e-02f, 4.97324914e-02f, -5.18383272e-02f, 9.18506309e-02f, 3.37547110e-03f, -1.76487816e-03f,
  1.78163573e-01f, -3.14722717e-01f, 1.01677448e-01f, 1.43899590e-01f, 6.46141842e-02f, -8.56686607e-02f, 2.34683961e-01f, -1.66028932e-01f, -9.10782218e-02f, -3.11194718e-01f,
  7.17060491e-02f, -8.35534930e-02f, 1.97749615e-01f, -1.46083668e-01f, 4.04121310e-01f, 2.13521644e-01f, -8.31552371e-02f, -6.48472756e-02f, -6.86059147e-02f, -6.69941530e-02f,
  1.19485274e-01f, -1.03507906e-01f, 1.28626332e-01f, -3.05160761e-01f, -4.95010149e-03f, -8.04843456e-02f, -1.79161672e-02f, 6.74068779e-02f, -8.43226835e-02f, -6.82922155e-02f,
  2.10753586e-02f, -2.53376532e-02f, -7.24991262e-02f, -5.53674884e-02f, 1.12566045e-02f, 2.35567312e-03f, -2.84314174e-02f, 9.60517824e-02f, 1.24300517e-01f, 1.34733394e-02f,
  -6.27629533e-02f, -1.72691792e-02f, -7.36109540e-02f, 7.50576556e-02f, -8.34619030e-02f, -1.92475095e-02f, -6.79390132e-02f, 4.28428724e-02f, -1.18444763e-01f, 5.05038053e-02f,
  -5.72646875e-03f, -2.95440052e-02f, 3.91527591e-03f, 3.80290067e-03f, 9.12081525e-02f, 3.15981247e-02f, 3.21235470e-02f, 7.28964508e-02f, -1.28768668e-01f, -5.63942753e-02f,
  -5.15981056e-02f, 6.54390305e-02f, 5.60841933e-02f, 4.64295521e-02f, 3.99257280e-02f, 7.46269301e-02f, -6.27429858e-02f, -3.29311639e-02f, -5.24177551e-02f, 6.23805858e-02f,
  5.41686490e-02f, 4.13001366e-02f, -9.61702038e-03f, 8.32324149e-04f, 1.16491225e-03f, 6.55480176e-02f, 4.56832126e-02f, -4.71014380e-02f, 5.12738489e-02f, -5.47960587e-03f,
  5.85194714e-02f, 3.77848707e-02f, 5.52903935e-02f, -3.31244878e-02f, 1.32718980e-02f, -2.02437211e-02f, 4.23161173e-03f, -4.46007513e-02f, 6.31314442e-02f, 5.09760752e-02f,
  -7.46068805e-02f, -2.02045068e-01f, 4.89520244e-02f, -6.43769577e-02f, -3.87677513e-02f, -1.24292932e-02f, -4.93488871e-02f, -1.30009586e-02f, 4.93298620e-02f, -4.30923775e-02f,
  -9.03168321e-02f, 2.74823718e-02f, -3.26552279e-02f, 4.20280360e-02f, -5.32088242e-02f, -5.76495519e-03f, 4.59571406e-02f, -1.03491172e-01f, -3.37735824e-02f, 7.15588173e-03f,
  5.80234565e-02f, -3.18097360e-02f, 7.21496940e-02f, 3.30028534e-02f, 2.12350413e-02f, -2.00410578e-02f, -9.82132107e-02f, -2.80078929e-02f, 4.08953391e-02f, -3.49646546e-02f,
  2.81556379e-02f, -1.07280627e-01f, -1.55254647e-01f, -4.68023755e-02f, -7.88876116e-02f, -1.05463065e-01f, -2.78697670e-01f, -1.00722648e-01f, -3.58638689e-02f, -7.22749857e-03f,
  -1.77432343e-01f, -5.71194887e-02f, 2.23049559e-02f, -3.04655552e-01f, 1.10876672e-01f, -4.28067520e-02f, -2.02995598e-01f, -1.80114552e-01f, -1.51547953e-01f, -5.85306734e-02f,
  -7.30301812e-02f, -7.09129721e-02f, -2.28803158e-01f, -1.56901985e-01f, -2.06401661e-01f, -1.29396683e-02f, 1.07733905e-01f, -8.38744268e-02f, -1.62653685e-01f, -5.04896194e-02f,
  -8.76595005e-02f, -8.47192854e-02f, -1.66159030e-02f, -7.05920011e-02f, -2.49118563e-02f, -2.09898185e-02f, 1.03320979e-01f, -7.25445524e-02f, -2.23408360e-03f, 2.85285264e-02f,
  1.69655215e-02f, 3.78746800e-02f, 5.07287756e-02f, 6.65931078e-03f, -5.90343215e-02f, -2.44977176e-02f, 7.53122419e-02f, -1.94212832e-02f, -8.12715068e-02f, -1.22431610e-02f,
  -1.26128763e-01f, -3.34089585e-02f, 7.54882991e-02f, 1.39262095e-01f, -2.03765240e-02f, 2.91909538e-02f, 2.38844324e-02f, 1.99489314e-02f, 1.00749349e-02f, -1.21284334e-03f,
  3.26060876e-02f, 7.73877800e-02f, 8.83253850e-03f, -7.97397420e-02f, -2.45621279e-02f, -5.93249425e-02f, 5.78612462e-02f, 1.25071794e-01f, -4.38864296e-03f, 3.72791034e-03f,
  5.44797070e-02f, -1.25024803e-02f, 4.95666601e-02f, 6.37096167e-02f, 8.25799406e-02f, -3.79769243e-02f, -5.88132031e-02f, 9.73003730e-03f, 3.58231962e-02f, -2.69921925e-02f,
  3.00704222e-02f, 5.78655936e-02f, -1.09263800e-01f, -4.71892580e-02f, -4.37632157e-03f, 4.45056707e-03f, 4.85623218e-02f, -2.74190754e-02f, -7.79534876e-02f, -3.18856165e-02f,
  1.99754182e-02f, 1.27279520e-01f, -7.32481154e-03f, -5.33240400e-02f, -4.04416490e-03f, -1.74309351e-02f, -1.17318491e-02f, -1.48847159e-02f, -3.23951803e-02f, 6.84816688e-02f,
  -5.19899419e-03f, 3.42892706e-02f, 1.31327540e-01f, 2.04328634e-02f, 5.77643402e-02f, -2.54084319e-02f, 2.96237469e-02f, 6.22833818e-02f, 1.29882814e-02f, 3.01325098e-02f,
  2.41836943e-02f, 9.49969515e-02f, 3.01690120e-02f, 7.85573050e-02f, 3.49581726e-02f, 1.74267776e-02f, 4.80175354e-02f, -4.48294058e-02f, -3.15962156e-04f, 1.47387665e-02f,
  3.83889601e-02f, -6.27811402e-02f, 7.01970682e-02f, -2.66817026e-02f, -1.10996917e-01f, -2.59823740e-01f, -3.00321132e-01f, -8.58504027e-02f, -5.56314252e-02f, -1.47668988e-01f,
  -1.78389773e-01f, 2.54866898e-01f, -2.57230759e-01f, 1.52522624e-02f, -3.86266261e-02f, -3.62545922e-02f, -7.45069683e-02f, -5.96084297e-02f, -3.82941775e-02f, -1.45839497e-01f,
  5.58904856e-02f, -5.31970598e-02f, 1.07529938e-01f, -9.97214392e-02f, -4.32696231e-02f, 1.36084005e-01f, 1.64758563e-01f, 6.95349532e-04f, 1.34818807e-01f, 6.51553422e-02f,
  -1.18004091e-01f, -1.34589866e-01f, -5.83987199e-02f, -6.92605525e-02f, -4.50138096e-03f, 4.05690148e-02f, 9.46989208e-02f, 6.88654557e-02f, -1.28768915e-02f, -4.84388918e-02f,
  -1.19534098e-02f, -3.94776873e-02f, 7.34928772e-02f, -2.26336978e-02f, -6.04996830e-02f, -4.50450704e-02f, 5.41578559e-03f, 7.46024773e-02f, -2.35038605e-02f, 2.17565857e-02f,
  2.40436289e-02f, 6.60950616e-02f, 1.19718015e-02f, 1.26014620e-01f, 7.31471553e-02f, -4.43160124e-02f, 9.63815525e-02f, 6.83190227e-02f, 8.48792419e-02f, 1.12933286e-01f,
  -1.07293181e-01f, -7.36995935e-02f, 2.87307352e-02f, -7.15569928e-02f, -3.33018973e-02f, -2.47586519e-02f, 7.81703591e-02f, -6.34970143e-02f, -9.54613648e-03f, -9.93350297e-02f,
  1.87376607e-02f, 2.86005214e-02f, -5.99500202e-02f, -4.10462264e-03f, -3.98479402e-02f, 6.66209608e-02f, -5.68694212e-02f, -5.11795916e-02f, 1.94168352e-02f, -3.38345990e-02f,
  -5.73736392e-02f, -3.01045235e-02f, -5.52346297e-02f, 2.55942121e-02f, -4.16614860e-02f, 4.49985936e-02f, 3.68325338e-02f, -1.35431057e-02f, -4.24737595e-02f, -2.70503834e-02f,
  -6.69067577e-02f, -5.42024001e-02f, -1.75092164e-02f, 1.44740110e-02f, 1.97740626e-02f, -3.68669257e-02f, 6.16927743e-02f, 4.01339717e-02f, -6.37691393e-02f, -5.55930659e-02f,
  -5.00602722e-02f, -3.14791165e-02f, 3.23064029e-02f, -1.88385230e-02f, 5.86146023e-03f, -4.65941206e-02f, 7.13703483e-02f, 8.02783147e-02f, 7.49891624e-02f, -5.16548306e-02f,
  2.71167569e-02f, -6.81130365e-02f, 5.23582473e-02f, 5.25832847e-02f, 5.71616692e-03f, 8.01809598e-03f, 9.52481776e-02f, 9.42555144e-02f, 1.47021301e-02f, 2.33660862e-02f,
  -5.81515878e-02f, -1.51824191e-01f, 7.93567896e-02f, -8.50257576e-02f, 1.34898633e-01f, 1.73838213e-01f, 4.83277813e-02f, -2.21678577e-02f, -2.95924038e-01f, -2.17308342e-01f,
  1.46860406e-02f, -8.83762762e-02f, -7.56797343e-02f, -2.28475109e-02f, 6.87359199e-02f, -9.41299051e-02f, -1.35047778e-01f, -1.06285259e-01f, -6.85992464e-02f, 2.27367654e-02f,
  4.08271253e-02f, -7.88135082e-02f, -5.53721935e-03f, -9.89797176e-04f, 4.91399616e-02f, 1.22146904e-02f, -9.45288613e-02f, 1.89286634e-01f, 4.35093828e-02f, 1.48489401e-01f,
  -6.77079707e-02f, -7.31573924e-02f, 2.17591543e-02f, -1.69726275e-02f, -6.63475022e-02f, -5.60921989e-03f, -3.18109170e-02f, 7.39480406e-02f, 9.79376733e-02f, -9.69524309e-03f,
  -5.13980016e-02f, 4.93129566e-02f, -1.17476908e-02f, -1.28761062e-03f, -3.94888595e-02f, 9.52373724e-03f, 2.39532199e-02f, -3.04164197e-02f, 9.41530243e-02f, 8.47055987e-02f,
  3.28125544e-02f, -2.06041383e-03f, 4.60032001e-02f, -3.65557410e-02f, 4.42120153e-03f, 4.08644900e-02f, -2.98592597e-02f, -4.72232066e-02f, 2.65511405e-02f, -1.09143248e-02f,
  -9.89785865e-02f, -7.56308436e-02f, 9.44300145e-02f, 9.18737128e-02f, 5.84896579e-02f, -5.76210544e-02f, -3.24614011e-02f, 1.00468487e-01f, 2.67774966e-02f, 1.37572512e-02f,
  2.81483866e-02f, -1.78604422e-03f, 4.08818908e-02f, -2.85927914e-02f, 6.84283972e-02f, -7.28918388e-02f, 3.32370326e-02f, 5.05658984e-02f, -7.38699362e-02f, -2.64979098e-02f,
  1.29242819e-02f, 3.75387669e-02f, -6.43266812e-02f, 3.73816974e-02f, 8.99472535e-02f, -1.39601491e-02f, 1.00414846e-02f, -6.37253150e-02f, -2.06807274e-02f, -6.83223009e-02f,
  5.08601358e-03f, -1.91803426e-01f, 1.99261419e-02f, -5.30572571e-02f, -3.32615711e-02f, -1.83606297e-02f, 5.15491441e-02f, -5.15507348e-02f, -1.56066725e-02f, -4.14823219e-02f,
  -6.79879710e-02f, -7.85698593e-02f, 5.96641712e-02f, 5.86389117e-02f, 3.90717462e-02f, -2.05867235e-02f, -1.08312078e-01f, -9.92539525e-03f, 2.69256029e-02f, -4.61040214e-02f,
  -2.17826236e-02f, -1.98126063e-02f, -6.45095631e-02f, -9.57777798e-02f, -1.04791053e-01f, -1.96481347e-02f, -8.74371529e-02f, -8.46593305e-02f, 9.65316668e-02f, -6.99339211e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  1.30248114e-01f, 1.95006445e-01f, 1.78503618e-01f, 2.38971546e-01f, 1.44240335e-01f, 1.96554229e-01f, 1.40216038e-01f, 3.73019606e-01f, 1.28280014e-01f, 2.77873665e-01f,
  6.84769675e-02f, 2.54438102e-01f, 1.44102827e-01f, 1.59516931e-01f, 1.77467898e-01f, 2.00653821e-01f, 3.30565870e-02f, 2.40995839e-01f, 2.10177615e-01f, 7.73884654e-02f,
  6.85920343e-02f, 3.79960239e-02f, 3.32456797e-01f, 8.96431133e-02f, 2.36642301e-01f, 1.23067640e-01f, 1.54224277e-01f, 5.70101738e-02f, 7.13076890e-02f, 3.48780334e-01f,
  1.94112677e-02f, 1.69602156e-01f, 1.62405208e-01f, 4.61652875e-02f, 1.45862073e-01f, 7.36098439e-02f, 1.47973701e-01f, 1.47065550e-01f, 2.09901869e-01f, -2.51690280e-02f,
  2.96687186e-01f, 2.54107207e-01f, 1.56858832e-01f, 2.39136703e-02f, 2.41202310e-01f, 5.18009253e-02f, 1.57989472e-01f, 4.81100194e-03f, 1.93393692e-01f, 1.33231908e-01f,
  7.31002018e-02f, 2.30266005e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  1.32955685e-01f, 6.85159042e-02f, 2.83519477e-01f, 1.02933012e-01f, 8.63733068e-02f, 9.51877534e-02f, -1.32738143e-01f, 3.23261738e-01f, -4.44430746e-02f, 1.29964784e-01f,
  1.50956586e-01f, 7.41885379e-02f, -1.31035686e-01f, 3.50830168e-01f, -2.87345827e-01f, -1.68637231e-01f, 1.86897174e-01f, -5.11012785e-02f, -1.80965260e-01f, -1.74859077e-01f,
  -2.92531341e-01f, 4.65400182e-02f, -1.95529819e-01f, 1.73697621e-01f, -1.85675547e-01f, -1.09102212e-01f, -1.73778176e-01f, -2.54429430e-01f, 2.97595173e-01f, -2.60459572e-01f,
  -1.66291341e-01f, -1.19179383e-01f, -1.07770398e-01f, -6.66433200e-02f, -4.16867018e-01f, -2.44796395e-01f, -1.24583654e-01f, -2.64658302e-01f, 3.34692240e-01f, 1.23906426e-01f,
  -8.37144926e-02f, -4.18354660e-01f, -1.73877493e-01f, 2.14947134e-01f, -2.04212740e-01f, 1.52341947e-01f, 3.99577886e-01f, -9.39379111e-02f, 4.37375516e-01f, -2.60487050e-01f,
  1.12045228e-01f, -1.15763098e-01f, -3.87594849e-01f, 8.39660764e-01f, -1.14631221e-01f, -2.59906173e-01f, 5.97681999e-01f, -3.46876234e-01f, -2.88715988e-01f, -1.31660238e-01f,
  1.00168228e-01f, -2.86167353e-01f, -1.64880112e-01f, -2.85243481e-01f, 9.27648470e-02f, -6.96916699e-01f, -1.42343968e-01f, 1.50824308e-01f, 2.52462387e-01f, 4.63338383e-03f,
  -1.93847761e-01f, 4.95396942e-01f, -5.48695803e-01f, -4.89125967e-01f, 3.95823598e-01f, -1.95552018e-02f, -1.17108069e-01f, -1.80692524e-01f, -1.30401179e-01f, -7.79558122e-02f,
  6.64365709e-01f, 3.56214345e-02f, -1.04357421e-01f, -3.56887102e-01f, 7.53177181e-02f, -5.59526831e-02f, -5.64955994e-02f, -5.86841553e-02f, 4.81979698e-01f, -2.96845108e-01f,
  1.37665272e-01f, 3.03432286e-01f, -1.57243848e-01f, -2.27256358e-01f, -1.47833809e-01f, -6.75861463e-02f, 3.15800756e-02f, -1.38046101e-01f, 3.10463995e-01f, 1.51527792e-01f,
  -7.08515048e-02f, -2.12357476e-01f, 4.98001724e-01f, -6.84275255e-02f, 6.82943389e-02f, -3.25462908e-01f, -1.58797592e-01f, -2.16346934e-01f, -2.45092961e-04f, 1.16903737e-01f,
  -1.49800539e-01f, -9.02343914e-02f, 1.77538283e-02f, -1.82851240e-01f, 1.27495332e-02f, 2.85434723e-01f, 6.86564326e-01f, 3.45654756e-01f, -2.00640619e-01f, -4.25826982e-02f,
  -1.59521207e-01f, -1.09609842e-01f, 1.09233581e-01f, -1.95498735e-01f, -2.42341124e-02f, -1.27108857e-01f, -3.11398357e-01f, -7.14351162e-02f, -6.14846170e-01f, 4.38326746e-02f,
  -1.61996596e-02f, -3.03392410e-01f, -3.75783384e-01f, -2.38383651e-01f, -3.12691242e-01f, 3.35085392e-01f, -2.33871147e-01f, -4.01441157e-01f, -3.83792907e-01f, 5.88163324e-02f,
  -5.92348389e-02f, -1.93811223e-01f, 4.04573455e-02f, 4.51300777e-02f, -1.78503871e-01f, -1.01259634e-01f, -1.59245104e-01f, -1.90457463e-01f, -7.57341087e-02f, 2.35393241e-01f,
  -7.44867399e-02f, -2.51175970e-01f, -1.28364563e-01f, -8.55854303e-02f, 2.82317698e-01f, 2.56249029e-02f, -1.32190719e-01f, -8.26855823e-02f, -1.01425417e-01f, 4.43741791e-02f,
  7.89568350e-02f, -4.30438295e-02f, -5.42472489e-03f, -1.24201551e-01f, -1.29103109e-01f, 2.45567977e-01f, -1.35388136e-01f, -1.41290575e-01f, 1.60139665e-01f, -2.14771926e-01f,
  4.96296920e-02f, 2.04355307e-02f, -8.54440182e-02f, -2.02142566e-01f, -3.08926515e-02f, 4.44345437e-02f, -1.57350183e-01f, -1.89322680e-01f, -1.14082545e-01f, 8.69535804e-02f,
  8.41546834e-01f, -2.67410785e-01f, 9.09366086e-02f, -9.49083269e-03f, 7.88154379e-02f, 8.74818861e-01f, 1.46420226e-01f, -9.77203622e-02f, 1.57085266e-02f, -9.30878893e-03f,
  2.34048948e-01f, 1.75696373e-01f, -2.23499164e-01f, -1.34441838e-01f, -4.98536900e-02f, 6.52939975e-02f, -1.61522985e-01f, -4.75846887e-01f, 4.21442658e-01f, -3.24525058e-01f,
  1.27974600e-01f, -9.46765468e-02f, -7.62147829e-03f, 2.47718573e-01f, 2.05036551e-01f, 2.49708667e-02f, -1.48145229e-01f, -1.72857732e-01f, -2.79292792e-01f, 2.97443271e-01f,
  4.92156118e-01f, 6.80541992e-01f, 3.62167567e-01f, -6.46834914e-03f, 3.03539187e-01f, -3.52534324e-01f, -1.41987517e-01f, 6.79763183e-02f, -9.99939293e-02f, -1.00909352e-01f,
  -1.84673429e-01f, -1.91720456e-01f, -1.90913275e-01f, 1.44006044e-01f, -2.09033996e-01f, 8.32373917e-01f, -2.11602852e-01f, -1.96329877e-01f, -1.44754022e-01f, 9.22843814e-02f,
  6.98931292e-02f, -6.00470901e-02f, 2.49683842e-01f, -3.81549954e-01f, -2.34818682e-01f, 2.38158077e-01f, 5.37896231e-02f, 3.56800705e-02f, 3.99318598e-02f, 1.90907046e-02f,
  -7.27773234e-02f, -2.74791978e-02f, 1.89519542e-05f, -7.55036920e-02f, -1.14598647e-01f, 2.45499104e-01f, 2.37679020e-01f, -8.22332036e-03f, 2.49584571e-01f, -2.73780257e-01f,
  -2.12102547e-01f, -1.75317317e-01f, -2.06012383e-01f, -1.36603579e-01f, -1.62492931e-01f, 2.56411452e-03f, 4.22720999e-01f, -3.99993360e-02f, -1.83529213e-01f, 5.50227873e-02f,
  3.55824083e-01f, 3.36967140e-01f, 5.28779149e-01f, -6.33801043e-01f, 6.00887299e-01f, 4.96949703e-01f, -2.29640469e-01f, 4.20531154e-01f, 4.39888626e-01f, 9.30767581e-02f,
  -3.29198509e-01f, 4.97667909e-01f, -1.13125786e-01f, -2.44601984e-02f, 6.28926873e-01f, -1.03966840e-01f, -2.76302457e-01f, 5.08990109e-01f, 4.22650911e-02f, -1.26893044e-01f,
  -2.29527682e-01f, 3.36912990e-01f, 1.21626779e-01f, -2.29031116e-01f, -2.05350578e-01f, -2.15432629e-01f, 2.46610150e-01f, 2.81067342e-01f, 7.59638567e-03f, -2.22449392e-01f,
  -3.48685622e-01f, 8.61581266e-02f, -7.10450485e-03f, -1.76694077e-02f, 6.53329864e-02f, -2.68777460e-01f, -1.37341172e-01f, 1.89598262e-01f, -1.28670037e-01f, -4.62164693e-02f,
  -1.65950015e-01f, -3.44187431e-02f, -9.07640681e-02f, -2.72605270e-01f, 3.03428229e-02f, -1.77602634e-01f, 2.60448623e-02f, -4.65929061e-02f, -4.59430248e-01f, -6.22049384e-02f,
  3.63350838e-01f, -2.92853534e-01f, 4.87995952e-01f, -1.23446897e-01f, 2.35833079e-01f, 1.12803385e-01f, -2.70927767e-03f, -1.25985250e-01f, -9.90705341e-02f, 3.08243901e-01f,
  3.92969996e-01f, 4.95688349e-01f, 2.65039951e-01f, 2.58170515e-01f, -6.39913883e-03f, 3.40876222e-01f, 3.06191891e-01f, 2.05034018e-01f, 1.04583845e-01f, 2.27913782e-01f,
  7.51298487e-01f, 4.02310565e-02f, 2.23927826e-01f, 4.92216945e-02f, -8.66729245e-02f, 2.82686740e-01f, 2.90798426e-01f, -3.05728942e-01f, -2.66779065e-01f, -4.61501569e-01f,
  -5.25769442e-02f, -3.83188307e-01f, -1.28046013e-02f, 6.90759838e-01f, -1.34764701e-01f, 2.29553622e-03f, 2.41775841e-01f, 3.20702121e-02f, 1.50883943e-01f, 6.57599717e-02f,
  -6.35668784e-02f, -1.19475857e-03f, -8.65762159e-02f, -2.12330714e-01f, 5.62237389e-02f, 4.87964377e-02f, -3.72066110e-01f, -3.44818383e-01f, 2.38856658e-01f, 4.67491806e-01f,
  -1.07602052e-01f, 6.02130473e-01f, 2.07388792e-02f, -3.85345727e-01f, 1.58451006e-01f, 4.32296842e-01f, -3.40011835e-01f, -5.16485535e-02f, -3.54665905e-01f, -1.15293249e-01f,
  4.22889814e-02f, 2.00044200e-01f, -2.33437136e-01f, -1.39887929e-01f, -1.39050499e-01f, -1.40544876e-01f, -3.92008454e-01f, 3.29886489e-02f, -8.99415985e-02f, -2.11211190e-01f,
  -1.95536450e-01f, 8.74185041e-02f, -9.92852673e-02f, -2.79982239e-01f, -1.63163006e-01f, 2.07711473e-01f, 2.57204086e-01f, 4.98884283e-02f, -6.35554865e-02f, -1.97215304e-01f,
  -6.44659281e-01f, -4.52048153e-01f, 2.62058079e-02f, 4.32324916e-01f, -5.86505413e-01f, -1.89982150e-02f, -7.66819576e-03f, -8.00492540e-02f, -1.45646762e-02f, -9.86902565e-02f,
  -7.58849308e-02f, -2.66707122e-01f, 5.75798228e-02f, -2.98830926e-01f, 1.01118311e-02f, -3.31268579e-01f, -2.30159555e-02f, -3.17436904e-02f, 6.51263595e-02f, 6.52200431e-02f,
  2.66490430e-01f, 5.95352203e-02f, -4.62572463e-03f, 3.34310830e-01f, 1.70908615e-01f, -1.29116088e-01f, 8.96023661e-02f, -2.15269357e-01f, 1.31088376e-01f, 3.52665931e-01f,
  -2.17767492e-01f, 2.79560268e-01f, -2.61805534e-01f, -6.58866465e-02f, -9.42022502e-02f, 4.27062929e-01f, -8.84031355e-02f, -1.74560651e-01f, 3.67957711e-01f, -6.70661554e-02f,
  -3.51983160e-01f, 5.55220880e-02f, -2.60171413e-01f, 8.79078388e-01f, 4.99838650e-01f, -1.38523011e-02f, 2.57993490e-01f, -1.88718930e-01f, -1.98038872e-02f, 2.37960264e-01f,
  -3.68861049e-01f, -7.84759000e-02f, 1.76119968e-01f, -3.58745828e-02f, 2.82220483e-01f, -1.30664170e-01f, -2.08302006e-01f, -1.28574623e-03f, -4.11719024e-01f, -1.96174338e-01f,
  -1.56803742e-01f, -9.94535759e-02f, -2.66858846e-01f, -2.18449026e-01f, 3.15343529e-01f, -6.71393573e-02f, -7.82313049e-02f, 7.03614950e-02f, 2.22226202e-01f, -3.79151374e-01f,
  4.21555728e-01f, 3.10122937e-01f, 9.16707441e-02f, 1.31433249e-01f, -1.67930096e-01f, 6.36298716e-01f, -7.07673877e-02f, -3.70485395e-01f, 6.27174795e-01f, -1.66736599e-02f,
  -1.16991118e-01f, 1.43935885e-02f, 1.25988759e-02f, 9.32769105e-02f, -1.05304345e-01f, -1.28252000e-01f, 9.54992622e-02f, 1.59716174e-01f, -1.45639941e-01f, 8.66051670e-03f,
  -1.22596733e-01f, 2.70298153e-01f, -1.08066417e-01f, -1.95813403e-01f, -3.65505703e-02f, -2.80162529e-03f, -2.70059835e-02f, -6.55148104e-02f, -7.91563839e-02f, -1.70574784e-01f,
  -3.19902748e-02f, 1.74255639e-01f, 3.46499383e-02f, 1.08748570e-01f, 1.27804250e-01f, 2.59367049e-01f, 7.28078783e-02f, -1.96488410e-01f, 1.97280005e-01f, 4.92980517e-02f,
  -1.72629505e-01f, -2.96109915e-01f, -9.29055363e-02f, -6.17505498e-02f, 1.09975427e-01f, -1.79204315e-01f, 8.57775472e-03f, 1.56953782e-01f, 2.34065056e-01f, 5.64384878e-01f,
  4.43065256e-01f, -2.06151664e-01f, 1.74175445e-02f, -1.76361024e-01f, -4.98111814e-01f, 1.38433129e-02f, -1.95722133e-01f, -1.71943799e-01f, 2.30522677e-01f, 1.97523132e-01f,
  -2.67934412e-01f, 5.14924675e-02f, -3.59390020e-01f, -2.48521939e-01f, -1.78204238e-01f, 1.25605404e-01f, -1.11535765e-01f, -9.22841430e-02f, -1.59977421e-01f, -2.08837703e-01f,
  -4.12154645e-02f, 1.16605937e-01f, 1.45551369e-01f, -3.63572016e-02f, -1.45055860e-01f, -4.13090922e-03f, -1.94733769e-01f, 1.90037087e-01f, -2.35077649e-01f, 7.51910448e-01f,
  2.06409648e-01f, -1.25004336e-01f, -8.85750726e-02f, 1.03805974e-01f, 3.26112211e-01f, -2.02661291e-01f, 5.13274729e-01f, 1.14191452e-03f, -1.43360734e-01f, 1.05581813e-01f,
  -2.50781208e-01f, 1.75749674e-01f, 8.67691785e-02f, -1.59888417e-01f, 5.79645097e-01f, -1.97936445e-01f, -4.40966710e-02f, 2.72456035e-02f, 4.90392148e-01f, -1.06079370e-01f,
  3.84187847e-02f, 1.28122777e-01f, -2.33937889e-01f, -1.69377223e-01f, -1.23190030e-01f, -2.32272968e-01f, 1.70319036e-01f, -2.87822708e-02f, 3.62902833e-03f, 3.60932708e-01f,
  -1.57079324e-02f, -5.59341274e-02f, 1.34565577e-01f, -6.47735521e-02f, 8.05715844e-02f, -1.77377209e-01f, 5.22442050e-02f, 1.53044492e-01f, -3.27514619e-01f, -6.90343827e-02f,
  4.85849418e-02f, -1.15286589e-01f, -4.32422906e-01f, 8.26335400e-02f, 5.49050450e-01f, 1.22016398e-02f, -3.36279482e-01f, -5.33215582e-01f, -1.67954952e-01f, 1.90058962e-01f,
  -3.75178792e-02f, 2.88149446e-01f, -2.23607525e-01f, 8.61438066e-02f, -1.54037446e-01f, -5.35393730e-02f, 6.81685135e-02f, 4.10908878e-01f, -1.38133600e-01f, 4.94062513e-01f,
  3.02777290e-02f, 9.72635597e-02f, 3.09663136e-02f, -2.86582738e-01f, 1.03908218e-01f, 8.60854387e-02f, -1.73568860e-01f, -1.12652563e-01f, -2.29044586e-01f, -1.37373060e-01f,
  -1.65220976e-01f, 5.84033616e-02f, 9.19691801e-01f, -1.78822473e-01f, -3.66375536e-01f, -1.57308534e-01f, -1.57876194e-01f, 1.18198164e-01f, -3.84943001e-02f, -1.10632874e-01f,
  -1.87785804e-01f, -1.69045463e-01f, -2.31344447e-01f, -1.64734647e-01f, -1.01720884e-01f, -2.39299521e-01f, 2.26763740e-01f, -1.66795915e-03f, 2.50229299e-01f, -2.50660360e-01f,
  -2.88589299e-01f, -8.93117934e-02f, 2.48128939e-02f, 4.22511362e-02f, -4.27505784e-02f, 1.61068942e-02f, 6.74617112e-01f, -1.47244567e-02f, -2.22848379e-04f, 2.80663580e-01f,
  1.04234576e-01f, 9.80326384e-02f, 3.08784783e-01f, -3.73835921e-01f, 4.98271137e-02f, -1.31291524e-01f, -1.30414635e-01f, 3.36196959e-01f, 3.44929174e-02f, -6.05682135e-01f,
  -8.47065449e-02f, 5.03147662e-01f, -2.63625354e-01f, -2.82595903e-01f, 3.85804057e-01f, -1.19268008e-01f, -1.57226458e-01f, 1.66612864e-01f, -2.38886133e-01f, 1.75101265e-01f,
  -1.57409802e-01f, 1.79031670e-01f, 2.28355870e-01f, -2.32891053e-01f, 3.47490519e-01f, -1.85819194e-01f, 2.65535414e-02f, -1.29987255e-01f, -9.86966342e-02f, 3.52110922e-01f,
  4.65539604e-01f, 3.25054914e-01f, 7.46023702e-03f, 4.41790462e-01f, 2.38384798e-01f, 5.90530224e-02f, -5.34527586e-04f, 2.63278455e-01f, 2.26617176e-02f, -1.04763918e-01f,
  -1.23657256e-01f, -1.24897160e-01f, 1.04694076e-01f, 2.42699265e-01f, -1.26229838e-01f, -1.48214951e-01f, 1.34332553e-01f, -1.14034355e-01f, 5.18727779e-01f, -1.93413138e-01f,
  -2.19472289e-01f, 2.35736538e-02f, -1.40452236e-01f, 2.13783070e-01f, 2.85301715e-01f, 3.96994352e-01f, -5.15225008e-02f, -3.69492680e-01f, 6.60497919e-02f, 5.18849269e-02f,
  -1.92501739e-01f, 2.90284574e-01f, -6.87093567e-03f, 4.82149608e-02f, 1.84379041e-01f, -1.16775870e-01f, 1.10706046e-01f, 2.77992692e-02f, 1.80798769e-02f, 1.57060608e-01f,
  9.02626142e-02f, -4.79324967e-01f, -1.58031471e-02f, 1.22994997e-01f, 9.06271785e-02f, -3.01632315e-01f, -2.82469206e-02f, -2.00631425e-01f, 2.30739027e-01f, -2.75011271e-01f,
  9.32324976e-02f, -1.29211023e-01f, -3.63883860e-02f, 9.66449559e-01f, -7.32341483e-02f, -2.54510701e-01f, 1.13250889e-01f, -1.53751940e-01f, -2.03292832e-01f, -1.47716209e-01f,
  -2.57311255e-01f, 1.37800992e-01f, 1.43452324e-02f, 2.19312236e-01f, -2.19492018e-02f, -1.14160404e-01f, -1.44775242e-01f, -1.84821993e-01f, -1.62391990e-01f, -1.16147950e-01f,
  1.59876823e-01f, -1.68070197e-01f, -1.24900803e-01f, 1.60761684e-01f, 2.58263886e-01f, 4.54259217e-01f, 6.89120069e-02f, -4.41049896e-02f, 1.58641919e-01f, 6.32228628e-02f,
  -1.17824087e-02f, 6.94041789e-01f, -2.47588351e-01f, 1.63627237e-01f, -3.46161515e-01f, -1.50271222e-01f, -2.36969888e-01f, -7.12035373e-02f, -1.56171903e-01f, 8.10188726e-02f,
  -2.30684400e-01f, -2.05068260e-01f, 8.30686986e-02f, 1.89744160e-01f, -2.59870291e-01f, -1.33305103e-01f, 2.66777724e-01f, -6.82625398e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  1.20428793e-01f, 4.94103432e-02f, -8.51551220e-02f, -2.14262128e-01f, 3.80579770e-01f, 3.50407988e-01f, -4.01235819e-02f, -1.61598980e-01f, -2.01634601e-01f, 7.91665632e-03f,
  4.79030758e-02f, -4.25126366e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    