/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.89245009e-01f, -7.45147839e-02f, -3.60126495e-02f, 6.20236844e-02f, -1.27367556e-01f, -3.60078104e-02f, -1.21254697e-01f, -1.20270930e-01f, 3.12172379e-02f, -1.41224533e-01f,
  -1.30809322e-01f, 2.39348859e-02f, 1.91142540e-02f, -4.35147546e-02f, 2.31672645e-01f, 4.73680161e-02f, -5.29333726e-02f, -1.73731111e-02f, 7.54820630e-02f, 1.46292793e-02f,
  1.00251533e-01f, 8.43908265e-03f, 1.54064909e-01f, 1.92782208e-02f, 2.85276282e-03f, -2.13644598e-02f, 3.17256749e-02f, 2.12098323e-02f, -5.19112200e-02f, -7.01356633e-03f,
  -3.73047739e-02f, -1.66817801e-03f, 5.00198081e-02f, -4.22510430e-02f, -5.26060797e-02f, -8.61898661e-02f, -3.89176682e-02f, -1.79733075e-02f, 6.37840927e-02f, 1.24841984e-02f,
  -1.01898226e-03f, 2.48676781e-02f, 3.57215246e-03f, -2.17162259e-02f, -6.43832013e-02f, 8.84383731e-03f, 3.48828137e-02f, -4.49401364e-02f, -3.60386446e-02f, 5.15651777e-02f,
  4.55958582e-02f, -2.27760579e-02f, 5.81897907e-02f, -3.13914940e-02f, 2.96818092e-02f, -1.59236398e-02f, -1.30708618e-02f, -3.56741659e-02f, -2.58993637e-02f, -4.15858328e-02f,
  6.68916181e-02f, -7.77777508e-02f, 8.39965697e-03f, 4.49399725e-02f, 2.07082126e-02f, -2.85001956e-02f, -1.03344303e-02f, 6.95256218e-02f, 4.85653840e-02f, -1.65137742e-02f,
  2.21802108e-03f, -2.11113673e-02f, 2.71464381e-02f, 4.13239747e-02f, 2.61155143e-02f, 2.67853262e-03f, 8.25276598e-03f, -8.06111321e-02f, -5.02778701e-02f, 1.28678549e-02f,
  2.17458252e-02f, 3.88956666e-02f, -3.03268228e-02f, -8.35103318e-02f, -4.38786857e-02f, -6.46606982e-02f, 2.54923403e-02f, 8.21677223e-02f, 1.15558170e-02f, -4.66229022e-02f,
  -2.97019165e-02f, -1.21906176e-01f, -6.17487021e-02f, 7.19854794e-03f, -3.75550129e-02f, -3.68258953e-02f, -1.97955444e-02f, 6.40269369e-03f, 3.67846265e-02f, -3.70299146e-02f,
  -8.37803036e-02f, -7.68148992e-03f, -7.49311820e-02f, -4.18428034e-02f, -4.60781604e-02f, -1.03118509e-01f, 2.92794704e-02f, 5.73562570e-02f, 2.60229725e-02f, 2.16419846e-02f,
  -4.67310436e-02f, -3.52389179e-02f, 4.26319689e-02f, -6.36796504e-02f, -6.26433194e-02f, -3.23845237e-03f, -5.72812185e-02f, 4.09778990e-02f, -6.02264442e-02f, 3.02268639e-02f,
  -6.66322038e-02f, 4.32717688e-02f, 4.85725561e-03f, 4.82395999e-02f, 5.50429225e-02f, -1.70333877e-01f, -1.47500768e-01f, 1.25823572e-01f, 1.22252174e-01f, 1.00955069e-01f,
  1.73224270e-01f, -2.36816797e-02f, -7.00078830e-02f, 1.26959858e-02f, -3.48445803e-01f, -2.76782751e-01f, -1.11232042e-01f, -1.32253543e-01f, -1.67459510e-02f, 6.89788982e-02f,
  -1.09894343e-01f, -7.63388304e-03f, -1.21112436e-01f, 1.46235883e-01f, 5.49012274e-02f, 6.40210658e-02f, 8.31235759e-03f, -1.55692529e-02f, 8.79128277e-02f, 8.20927322e-02f,
  5.01921140e-02f, 1.79956838e-01f, 1.30919605e-01f, 3.30083794e-03f, 1.66688822e-02f, -1.55872265e-02f, -1.84656959e-02f, 7.25518093e-02f, 1.07431728e-02f, 4.88385335e-02f,
  4.40361351e-02f, 5.98873422e-02f, 1.88496262e-02f, 1.16287638e-02f, 7.09104836e-02f, 1.25353009e-01f, 8.70907679e-03f, -5.85477650e-02f, 8.05269331e-02f, 4.83872332e-02f,
  -6.56764805e-02f, 7.72848576e-02f, -1.00674354e-01f, -5.31357899e-02f, -6.54613674e-02f, 7.42684603e-02f, -4.03851606e-02f, -2.28950474e-02f, 4.88436818e-02f, -5.33400066e-02f,
  -1.63661614e-02f, -4.82166484e-02f, -1.05078695e-02f, 6.20565452e-02f, 1.76309515e-02f, 1.04146868e-01f, 5.02840243e-02f, 4.95267520e-03f, -1.14303552e-01f, 1.44276256e-02f,
  -2.62056142e-02f, -1.21558141e-02f, 2.10358799e-02f, -9.09460988e-03f, 8.76792520e-03f, 1.12905741e-01f, -4.14834544e-02f, -2.14854423e-02f, -3.14323255e-03f, -2.57733352e-02f,
  4.45005186e-02f, 1.66570190e-02f, 1.58139970e-02f, -4.54267599e-02f, 6.52173534e-02f, 1.33926198e-02f, -5.56502491e-02f, 6.70003444e-02f, -2.38782447e-02f, -9.54663903e-02f,
  -6.40783608e-02f, 1.25805974e-01f, 1.02274148e-02f, 9.87622142e-02f, 4.18455675e-02f, 7.18986616e-02f, -8.18075836e-02f, -1.09791392e-02f, -4.01193090e-02f, -1.01434933e-02f,
  -1.10781956e-02f, -3.84652168e-02f, -4.54897061e-02f, -3.43404450e-02f, -2.56015770e-02f, 2.70148460e-02f, 6.75804988e-02f, -8.88458628e-04f, 3.66184898e-02f, -3.41020077e-02f,
  3.72118391e-02f, 3.57467751e-03f, -4.17975932e-02f, -4.25133184e-02f, -1.19176358e-02f, -3.06970589e-02f, 1.01233227e-02f, -2.65713893e-02f, -6.44913269e-03f, 2.35865712e-02f,
  1.61723733e-01f, -3.54217917e-01f, -8.52039680e-02f, -1.84446070e-02f, 2.05000415e-01f, 6.39084056e-02f, 7.75090326e-03f, 4.38088849e-02f, -1.13275491e-01f, -1.05202265e-01f,
  1.85690690e-02f, -2.36535564e-01f, -6.02097884e-02f, -9.24567431e-02f, 5.99309653e-02f, -1.33729011e-01f, -6.85198307e-02f, 3.97480577e-02f, 1.39271282e-02f, -4.25853115e-03f,
  3.33278589e-02f, 6.65905103e-02f, -5.89653887e-02f, 7.66528025e-02f, 1.29631221e-01f, 7.60297999e-02f, 1.30616367e-01f, 7.16172829e-02f, 5.74513376e-02f, 2.76901778e-02f,
  6.77306503e-02f, -2.98565459e-02f, 3.34471837e-02f, -6.04864545e-02f, -6.50139302e-02f, 5.97018600e-02f, -6.39169849e-03f, 1.78375617e-02f, -2.05088276e-02f, -1.07216857e-01f,
  -3.79318222e-02f, 6.32705539e-02f, -7.37948641e-02f, -5.16252853e-02f, -2.97128945e-03f, -6.57613724e-02f, -3.91762704e-02f, -1.67779885e-02f, -5.42542674e-02f, -5.66681102e-02f,
  1.59838740e-02f, -7.81340301e-02f, -4.11341824e-02f, -8.41897633e-03f, 5.75433224e-02f, 6.32622316e-02f, 4.54595461e-02f, 6.04251660e-02f, -9.34375972e-02f, 5.11621684e-03f,
  1.00796651e-02f, 5.05854636e-02f, 2.79633589e-02f, -1.29596959e-03f, -2.70454423e-03f, 1.81408580e-02f, -3.95100787e-02f, -7.60850012e-02f, -2.13938560e-02f, -3.51548344e-02f,
  2.89047379e-02f, -6.00128621e-02f, -6.21336550e-02f, 2.36596898e-04f, 2.57637422e-03f, 5.87115530e-03f, -4.63123955e-02f, 1.01240635e-01f, 4.62226523e-03f, -6.01745285e-02f,
  -5.64412363e-02f, 2.79894583e-02f, 8.02548900e-02f, -1.13949189e-02f, -4.92601022e-02f, 3.01580392e-02f, 5.43158166e-02f, -6.02358729e-02f, 1.57765727e-02f, -4.28992584e-02f,
  -1.25256732e-01f, -8.12205896e-02f, 2.85512991e-02f, -1.14467628e-02f, 1.24495914e-02f, -1.87679958e-02f, -4.99495938e-02f, -5.05596139e-02f, -3.19877788e-02f, -1.79589931e-02f,
  1.10822588e-01f, 3.42460275e-02f, -6.64476901e-02f, 4.61449064e-02f, -5.15475832e-02f, 6.70113340e-02f, -2.34667994e-02f, 1.69326589e-02f, -4.09257645e-03f, -3.91858555e-02f,
  1.92341674e-02f, 5.14664873e-03f, -2.54544076e-02f, 1.04110867e-01f, 1.20848045e-02f, -4.80003580e-02f, 9.62417647e-02f, 1.29094941e-03f, -7.21755577e-03f, -2.47673336e-02f,
  1.86331645e-01f, -8.89790654e-02f, -1.14461578e-01f, 1.95871919e-01f, -7.56753236e-02f, 1.98481187e-01f, 1.90109879e-01f, -1.33746373e-03f, -4.17514443e-02f, 1.10034198e-01f,
  1.44323587e-01f, -7.23345429e-02f, 4.18087281e-02f, 1.02325283e-01f, 6.55828491e-02f, 1.70971267e-03f, 2.53397852e-01f, 9.78006572e-02f, -6.08213879e-02f, 1.33697325e-02f,
  -4.41626005e-04f, 2.18564481e-01f, 5.34879789e-02f, 7.41079673e-02f, 2.01225188e-02f, -1.50357604e-01f, -1.90970786e-02f, -3.61971781e-02f, 1.05859213e-01f, -3.85894137e-03f,
  3.82113978e-02f, -1.43522903e-01f, -5.03344312e-02f, -6.99854270e-02f, 3.46256867e-02f, 6.50592372e-02f, -1.28402170e-02f, 9.31188837e-03f, -4.16650623e-02f, -8.33589509e-02f,
  2.54914612e-02f, 6.45104272e-04f, -3.40145379e-02f, 1.33766094e-02f, 1.41028473e-02f, -1.55458907e-02f, 2.55951602e-02f, -7.63515607e-02f, -5.92901558e-03f, -3.59537937e-02f,
  -5.23980595e-02f, 1.29481135e-02f, 3.35381776e-02f, 6.37968928e-02f, -4.85006794e-02f, -2.36980896e-03f, -1.66311953e-02f, -3.51132601e-02f, -4.95507121e-02f, -2.62842216e-02f,
  2.25224029e-02f, 5.85520547e-03f, 8.15779716e-02f, 1.91022530e-02f, 4.48128395e-02f, -1.12076523e-02f, 7.31410235e-02f, -5.97890327e-03f, -2.28933636e-02f, 5.52507043e-02f,
  3.11940126e-02f, -5.92115559e-02f, -4.45316024e-02f, -6.12830706e-02f, 4.11691852e-02f, 5.70475124e-03f, 3.65249291e-02f, -4.38012891e-02f, 8.74852836e-02f, 4.10894025e-03f,
  1.29582444e-02f, -1.94874033e-02f, 3.42860296e-02f, 4.52403352e-02f, 4.94930148e-02f, 1.98926572e-02f, -1.44316745e-03f, 1.45905484e-02f, 1.14080608e-02f, -4.96844277e-02f,
  -6.56534592e-03f, 3.35363261e-02f, 1.59996878e-02f, -1.33053865e-02f, 3.48887108e-02f, 3.13063785e-02f, 4.59034331e-02f, 3.40470187e-02f, 5.65127144e-03f, 4.73093428e-02f,
  2.38665659e-02f, -1.93624962e-02f, -5.20362630e-02f, -5.35695115e-04f, 3.43327597e-02f, 3.61370519e-02f, 2.35874504e-02f, -1.40380785e-02f, -2.50821039e-02f, 3.14699523e-02f,
  8.02750736e-02f, 7.29060965e-03f, 2.67359857e-02f, -3.21953781e-02f, 6.90864399e-02f, -1.13706347e-02f, -2.92320568e-02f, 1.63443631e-03f, -7.49379322e-02f, -5.23747504e-02f,
  1.58030570e-01f, -1.12731099e-01f, 5.35601713e-02f, -6.13741502e-02f, 1.21171854e-01f, 4.28529829e-02f, 1.42597884e-01f, -4.91950884e-02f, 1.52721539e-01f, -2.26851612e-01f,
  -2.46425606e-02f, -8.25463012e-02f, 4.67259996e-02f, -1.97824195e-01f, 4.12567228e-01f, 1.01050109e-01f, 1.33657511e-02f, -1.05852075e-01f, 1.58107519e-01f, -1.12659365e-01f,
  4.72134501e-02f, -1.37971625e-01f, 3.02019268e-02f, -5.84263466e-02f, -6.48291036e-02f, -7.99376294e-02f, -9.68985856e-02f, -1.60747319e-02f, -1.96224868e-01f, 8.37144554e-02f,
  2.93978713e-02f, 2.58254725e-02f, 3.36061791e-02f, 1.76188275e-02f, -8.58765543e-02f, -4.73092087e-02f, -5.04292585e-02f, 6.90805838e-02f, -3.12534794e-02f, 1.56624038e-02f,
  -6.96169492e-03f, -7.45378211e-02f, 6.72757998e-02f, 2.01370493e-02f, -2.37511471e-03f, -8.06492195e-03f, -9.20405891e-03f, 1.60882322e-04f, 5.02641452e-03f, -8.72185174e-03f,
  5.09068370e-02f, 3.62617858e-02f, -7.01698214e-02f, -1.41977342e-02f, 7.62585774e-02f, 6.34137839e-02f, 5.66085912e-02f, -2.50638276e-02f, -1.67181455e-02f, 1.32369716e-02f,
  1.00912921e-01f, 6.17949292e-02f, 1.60867479e-02f, -1.09343790e-01f, -4.43965867e-02f, 3.12216710e-02f, 1.69256479e-02f, -7.01074814e-03f, 3.15870084e-02f, 3.31001282e-02f,
  -9.31314528e-02f, -4.66187578e-03f, 7.81814009e-03f, -1.47247510e-02f, 4.46982905e-02f, -3.86353657e-02f, 2.52685091e-03f, 2.81127505e-02f, 8.18693861e-02f, -2.88574416e-02f,
  2.71241218e-02f, 8.75137339e-04f, -3.05603035e-02f, 7.78817162e-02f, -2.58202222e-03f, -2.92012561e-03f, -6.39735088e-02f, -5.49502159e-03f, -3.57685648e-02f, 1.21809393e-02f,
  6.75173700e-02f, -4.75654900e-02f, -2.27686707e-02f, 3.72223817e-02f, 3.60773578e-02f, -2.29715593e-02f, 1.15758769e-01f, -2.25686748e-02f, 9.34751704e-02f, -3.25356759e-02f,
  -7.33414963e-02f, -3.33407260e-02f, -3.07168458e-02f, 8.79172012e-02f, 3.88306752e-02f, 3.91455069e-02f, -4.80077378e-02f, 2.72722244e-02f, 5.77438716e-03f, 3.33393291e-02f,
  -6.65525943e-02f, 2.46441346e-02f, -2.70517766e-02f, -2.30188277e-02f, -3.27270739e-02f, -4.16772515e-02f, 5.23895584e-03f, 5.88858910e-02f, 5.79334199e-02f, 5.00398539e-02f,
  -1.63356274e-01f, -5.42624556e-02f, 2.30363995e-01f, -1.64531901e-01f, 7.21369982e-02f, -1.24428459e-01f, -2.63260175e-02f, -1.23729154e-01f, 1.48539180e-02f, -1.37255322e-02f,
  -1.07618921e-01f, 2.66613215e-01f, 1.78314894e-02f, -2.07929432e-01f, -1.09135330e-01f, -3.84168774e-02f, -2.61368245e-01f, -1.76171243e-01f, 3.06749679e-02f, -1.73800234e-02f,
  9.51380730e-02f, -1.29875436e-01f, 5.46213984e-02f, -2.89544538e-02f, 4.80687730e-02f, 5.91883548e-02f, -3.02862916e-02f, 2.38004163e-01f, 6.52384982e-02f, 2.31021270e-02f,
  -4.62681130e-02f, -9.18156058e-02f, -2.53626350e-02f, 8.97249058e-02f, -2.03861040e-03f, 1.95270143e-02f, -8.04779492e-03f, 1.05871961e-01f, 1.57613121e-02f, -3.08846887e-02f,
  8.09801444e-02f, 6.20210283e-02f, -1.42273724e-01f, 1.56011552e-01f, 9.00681615e-02f, 3.02274469e-02f, 7.91192725e-02f, -8.69764909e-02f, 7.21554831e-02f, 1.02695040e-01f,
  8.55994746e-02f, 5.56963645e-02f, -2.43541822e-02f, 2.31243502e-02f, 1.44582493e-02f, -9.61648077e-02f, -2.34299228e-02f, 1.03954151e-01f, 1.66728869e-02f, -2.73970515e-02f,
  6.17568381e-02f, -2.93567758e-02f, 6.86303005e-02f, -1.75967235e-02f, -3.63162160e-02f, -4.91500013e-02f, -1.36800222e-02f, 8.96173622e-03f, 1.61328353e-02f, -3.77021916e-02f,
  -1.26660168e-01f, -4.18002345e-02f, -8.26260373e-02f, 3.62535901e-02f, 1.26204761e-02f, 4.59024645e-02f, 4.11075316e-02f, -5.40138893e-02f, 4.90935706e-03f, 6.77624047e-02f,
  -9.55854543e-04f, 4.39036340e-02f, -8.64623580e-03f, 2.25285981e-02f, 4.98341222e-04f, 4.85755317e-02f, 1.88337080e-02f, 3.87546197e-02f, -1.94689706e-02f, 4.71877456e-02f,
  -1.57614931e-01f, -6.37616264e-03f, 2.37381496e-02f, 3.13969627e-02f, -2.59217918e-02f, -2.88424660e-02f, 3.00434306e-02f, 1.99726224e-02f, 4.41421196e-02f, -3.23882303e-03f,
  3.57934944e-02f, -7.27743357e-02f, -2.34773364e-02f, -2.32734922e-02f, 4.97031622e-02f, 1.18778665e-02f, -2.45079156e-02f, -1.40472399e-02f, -1.16209738e-01f, -3.16201933e-02f,
  -6.75464096e-03f, -6.18677251e-02f, 1.67189410e-03f, -5.62166832e-02f, -2.39468669e-03f, 8.09219554e-02f, 3.12449150e-02f, 1.03109446e-03f, -1.08786803e-02f, -1.79126952e-02f,
  2.56387889e-01f, -9.65619553e-03f, 1.00047871e-01f, 1.64357662e-01f, -1.87481213e-02f, -4.95245680e-02f, -1.27026930e-01f, 7.35713169e-02f, -1.84888840e-01f, -4.84607704e-02f,
  -8.45302045e-02f, 7.24480078e-02f, -1.17430612e-01f, -7.94906076e-03f, -9.78569239e-02f, -1.82324260e-01f, -4.14294638e-02f, -1.04999477e-02f, -9.19513032e-02f, 3.35726477e-02f,
  6.75470978e-02f, 1.04129724e-02f, 1.24103855e-02f, 8.29801783e-02f, 1.30972043e-01f, 1.97388038e-01f, 1.36246741e-01f, -1.58434790e-02f, 1.17045365e-01f, -9.81150493e-02f,
  7.50716962e-03f, -5.22636212e-02f, 5.54128438e-02f, -7.74037093e-02f, 2.52955616e-03f, 6.14603497e-02f, 5.93774766e-02f, 2.21826080e-02f, -1.36939017e-02f, 1.05637286e-04f,
  4.69060382e-03f, 1.26430336e-02f, 8.68621618e-02f, 1.47085870e-02f, -5.98329678e-02f, -2.42983294e-03f, 4.35067303e-02f, 7.48162195e-02f, 5.81867099e-02f, -5.32971807e-02f,
  3.12028993e-02f, 1.07675716e-01f, 9.16015729e-02f, 1.34752889e-04f, 6.27324954e-02f, -2.78678760e-02f, 3.45441140e-02f, 1.92295760e-02f, 4.03844304e-02f, -5.95547706e-02f,
  6.97126910e-02f, -8.42725262e-02f, 5.02454825e-02f, 8.67390353e-03f, -7.21904635e-02f, 6.22703023e-02f, 2.44535115e-02f, -4.48178761e-02f, -9.68161505e-03f, 1.88440252e-02f,
  -6.70482293e-02f, 2.60561667e-02f, 1.81404836e-02f, -2.65250057e-02f, 1.08895963e-02f, 6.56326637e-02f, -2.39987355e-02f, 2.02110205e-02f, -4.09494564e-02f, 2.34919116e-02f,
  -2.71708313e-02f, -5.48146432e-03f, -2.26820689e-02f, 5.77880889e-02f, -2.93917283e-02f, 3.79158333e-02f, -2.39880178e-02f, 1.43949809e-02f, 1.93569139e-02f, 2.11963598e-02f,
  -5.25476076e-02f, -1.50481895e-01f, -3.92345861e-02f, 3.87363099e-02f, -2.19640899e-02f, -5.35239838e-02f, 1.01407180e-02f, -3.99856381e-02f, -3.18580680e-02f, 2.68533174e-02f,
  6.10175692e-02f, -1.63204223e-02f, 8.05272087e-02f, 7.01593757e-02f, 4.96743470e-02f, 1.46147292e-02f, -1.52229553e-03f, -7.56873786e-02f, 5.81397163e-03f, 5.12832999e-02f,
  5.17697744e-02f, -6.58955146e-03f, 3.98990186e-03f, 1.96536947e-02f, 9.98685658e-02f, 6.82483539e-02f, 9.69600771e-03f, 6.21288177e-03f, 2.11414304e-02f, 4.69494164e-02f,
  -3.11598212e-01f, -1.91848595e-02f, -2.32287943e-01f, -1.22697026e-01f, -1.21872760e-01f, -2.26358220e-01f, -8.42614546e-02f, -1.62345603e-01f, -3.00940484e-01f, 1.59713607e-02f,
  8.99872743e-03f, -1.46617904e-01f, 8.52963403e-02f, -1.80924237e-02f, -1.76456362e-01f, 6.61623627e-02f, -1.18459381e-01f, 2.11889744e-02f, 1.06966810e-03f, -2.85493135e-02f,
  -3.54283378e-02f, 3.83313894e-02f, 8.43885262e-03f, 1.00247800e-01f, -5.42390086e-02f, 5.82245179e-02f, 1.61257610e-01f, 3.46650593e-02f, 2.07911860e-02f, -7.67775699e-02f,
  -5.14651164e-02f, 9.91101339e-02f, 9.27544013e-02f, 4.19656038e-02f, 3.82459648e-02f, 2.00846680e-02f, 7.04144640e-03f, 3.11013535e-02f, 1.79862790e-02f, -2.43047327e-02f,
  5.99160045e-03f, -3.86920981e-02f, -8.36928859e-02f, -2.11057365e-02f, 5.50330207e-02f, -5.77090979e-02f, -1.30387526e-02f, 9.47832596e-03f, -1.66199598e-02f, 1.88718773e-02f,
  -3.97321247e-02f, -6.35550218e-03f, 5.03672548e-02f, 1.52680352e-02f, 5.77955693e-02f, -6.08852804e-02f, -3.86968330e-02f, -2.88274363e-02f, -2.45942851e-03f, 3.85544561e-02f,
  6.30403832e-02f, -1.93768423e-02f, -3.72163765e-02f, -6.96016848e-02f, -4.14928906e-02f, 2.56260652e-02f, -7.57166594e-02f, 1.81544703e-02f, -5.93741573e-02f, -2.82978034e-03f,
  -7.29905516e-02f, 3.46156280e-03f, 6.25893697e-02f, -4.94266376e-02f, 9.84367877e-02f, 4.18766681e-03f, 1.75770540e-02f, -4.30335887e-02f, 3.09779700e-02f, 4.50360067e-02f,
  -1.10567803e-03f, -7.08467439e-02f, 5.00344671e-02f, -1.18804807e-02f, -2.22871006e-02f, -3.35841370e-03f, 1.02623971e-03f, -1.30445249e-02f, 2.15432458e-02f, 5.19617125e-02f,
  1.69261210e-02f, -9.17731375e-02f, 5.29888868e-02f, -4.19954248e-02f, 1.02672867e-01f, 5.91313839e-02f, -3.63529213e-02f, -7.58781210e-02f, -6.07266761e-02f, -2.34126057e-02f,
  -1.68174990e-02f, 1.14985006e-02f, 3.27661522e-02f, -2.33524237e-02f, -1.81633364e-02f, -6.97457790e-02f, -5.77527918e-02f, -2.12916657e-02f, -3.65718501e-03f, 1.82649866e-02f,
  -2.63140313e-02f, 1.41036166e-02f, 9.09443665e-03f, -4.61785048e-02f, 4.13384624e-02f, 8.69604051e-02f, 6.93519483e-04f, -1.15344159e-01f, -5.74860834e-02f, -3.16482000e-02f,
  -4.04543996e-01f, 2.26154760e-01f, -8.89635980e-02f, 1.72355443e-01f, -2.22057596e-01f, -2.44057089e-01f, -1.74869999e-01f, 3.93413082e-02f, 6.56092912e-02f, 1.74359664e-01f,
  -5.46769686e-02f, -1.22381784e-02f, 8.96641891e-03f, 1.18635140e-01f, -1.41300797e-01f, 9.31957960e-02f, -9.43853036e-02f, -1.23613058e-02f, 8.12846869e-02f, -8.59175920e-02f,
  6.54972345e-02f, -1.42578091e-02f, 3.22039574e-02f, -3.25608137e-03f, -4.48124819e-02f, -6.56088591e-02f, -1.01472428e-02f, -2.25324035e-02f, -1.49387319e-03f, -4.25475053e-02f,
  -1.33420020e-01f, 1.69838332e-02f, -6.48527741e-02f, -4.56955992e-02f, -1.86421528e-01f, -3.34275253e-02f, -5.27556501e-02f, -5.75866662e-02f, -3.01050991e-02f, 1.55370757e-02f,
  -4.50153127e-02f, -3.86843970e-03f, -5.39185619e-03f, -4.31538559e-02f, -8.11862648e-02f, 1.78760681e-02f, 4.81637102e-03f, -8.37629065e-02f, -2.11515743e-02f, -6.88727126e-02f,
  5.40867960e-03f, -3.45642902e-02f, 1.69869177e-02f, 2.09035072e-02f, -4.40636985e-02f, -1.66631751e-02f, -1.86276622e-02f, -3.95981297e-02f, 1.01593579e-03f, -6.93813935e-02f,
  -4.87686601e-03f, 1.22566847e-02f, 4.38578501e-02f, 4.46685739e-02f, 4.02587987e-02f, -1.64700821e-02f, 1.29101872e-02f, 9.72768571e-03f, 4.64808308e-02f, 1.90421455e-02f,
  2.25315392e-02f, 8.03669542e-03f, -2.75608078e-02f, -6.15940150e-03f, 2.68001948e-03f, -5.85171208e-02f, 1.18823745e-03f, 1.24184275e-02f, 5.64750955e-02f, -3.61545794e-02f,
  5.77943064e-02f, 5.23685738e-02f, 4.90216278e-02f, 1.74447838e-02f, 1.99520849e-02f, 4.53632325e-02f, 9.06923041e-02f, 1.05763534e-02f, 4.27797390e-03f, -2.53438801e-02f,
  4.31700647e-02f, -2.46227277e-03f, -1.33954352e-02f, -2.54863091e-02f, 7.10702091e-02f, -3.90882269e-02f, 9.08555984e-02f, -2.72700507e-02f, 7.54571483e-02f, -7.35822320e-02f,
  -3.14982943e-02f, -5.55980764e-02f, -5.23611903e-02f, 2.41293292e-03f, 1.76878646e-02f, 1.12890445e-01f, -1.28551386e-02f, 8.67921188e-02f, -8.02908652e-03f, 3.99992689e-02f,
  6.30214578e-03f, -3.04384041e-03f, 6.77725114e-03f, 4.08229269e-02f, 1.45807359e-02f, -6.31713793e-02f, -3.34937163e-02f, 1.14116289e-01f, -1.15397107e-02f, 1.93673577e-02f,
  -2.81411558e-01f, -5.42068742e-02f, -1.13210484e-01f, -1.71036512e-01f, 1.14084035e-01f, 2.15463206e-01f, 8.14267844e-02f, -1.24416500e-01f, -4.97581214e-02f, 1.40472829e-01f,
  -1.38982870e-02f, -2.15838820e-01f, 1.04528889e-01f, -9.88646001e-02f, -1.65979087e-01f, 2.49759126e-02f, -7.81907588e-02f, 1.75227132e-02f, 3.09538096e-02f, -8.51278827e-02f,
  -1.07233398e-01f, -3.95197757e-02f, -1.45802870e-01f, 2.21814495e-02f, -1.30517453e-01f, -8.31855610e-02f, 6.81073358e-03f, -2.20167693e-02f, -9.11806673e-02f, 5.52302748e-02f,
  -1.28979813e-02f, -1.43863648e-01f, -3.48412208e-02f, -9.11704302e-02f, -5.45521379e-02f, 7.75451213e-02f, 8.50896686e-02f, -5.80815747e-02f, 3.54933292e-02f, -5.85245974e-02f,
  4.11728583e-02f, -5.03964871e-02f, -5.18470071e-02f, 7.71263689e-02f, 3.63216512e-02f, -1.36048822e-02f, 5.00697382e-02f, 1.62982233e-02f, -9.88635048e-02f, -1.10813588e-01f,
  -8.43642056e-02f, -7.79029205e-02f, -3.61258797e-02f, 4.54228837e-03f, 4.78157513e-02f, 2.21693404e-02f, 5.19141816e-02f, -3.91224287e-02f, -7.04752728e-02f, 1.02015901e-02f,
  6.33609742e-02f, -6.44396618e-03f, -8.16699211e-03f, -6.76900372e-02f, -6.45764219e-03f, 4.93476912e-02f, 2.49829423e-02f, 2.61604842e-02f, 4.30874862e-02f, 9.05665159e-02f,
  -3.95807996e-02f, -5.88123081e-03f, -1.27009517e-02f, -3.55156548e-02f, -3.27152163e-02f, -4.04112116e-02f, 1.89087354e-02f, -2.19069608e-02f, 3.10853925e-02f, -2.02168953e-02f,
  -2.90102959e-02f, -1.57457832e-02f, -1.98966451e-02f, -1.91748627e-02f, -2.36108508e-02f, -7.78923407e-02f, 4.28327639e-03f, 1.10609248e-01f, 3.38502675e-02f, -9.70775113e-02f,
  1.38902422e-02f, -1.82065025e-01f, 3.13541517e-02f, -7.18417615e-02f, 1.66213028e-02f, -5.02671767e-03f, -5.21892458e-02f, -3.78867164e-02f, 4.69892062e-02f, 6.95424378e-02f,
  -1.40922675e-02f, -3.15068886e-02f, 2.60680225e-02f, -6.54160306e-02f, -3.27484682e-02f, -9.18794889e-03f, -2.66066324e-02f, -8.28531086e-02f, 4.78048995e-02f, -9.69067290e-02f,
  -1.01894982e-01f, -4.92663402e-03f, 1.21483654e-02f, 7.11444318e-02f, -1.16219511e-02f, -2.12877360e-03f, -1.49841672e-02f, 5.75383939e-02f, -3.72784324e-02f, 6.53541312e-02f,
  3.65395397e-02f, 3.36932801e-02f, -1.36638314e-01f, 1.66071713e-01f, -1.39022814e-02f, 4.18286165e-03f, 6.30275533e-02f, -1.22183487e-01f, -6.24363869e-02f, 1.33667141e-01f,
  3.43972333e-02f, 5.32915406e-02f, -2.04426665e-02f, 3.04376215e-01f, 1.99721858e-01f, 1.83290377e-01f, 1.51689008e-01f, 5.01454510e-02f, -9.51895863e-02f, 2.16337778e-02f,
  -3.22132148e-02f, 1.81631997e-01f, 2.23888010e-02f, -3.79006825e-02f, 6.51191846e-02f, -1.07983239e-01f, 1.68262348e-01f, -1.05402872e-01f, 5.56252226e-02f, 1.06678411e-01f,
  3.63990441e-02f, -6.27703443e-02f, -8.97166599e-03f, -1.32224383e-03f, 8.64019319e-02f, -3.04552075e-02f, 1.24578647e-01f, -7.44286133e-03f, -6.34264350e-02f, 5.89275025e-02f,
  6.51507732e-03f, 4.62923907e-02f, -3.75028998e-02f, 5.61636733e-03f, -4.01800610e-02f, -2.85448935e-02f, -7.87801761e-03f, 6.00231737e-02f, -7.76712596e-02f, -6.29113540e-02f,
  -3.12422812e-02f, 6.09475970e-02f, -1.99204665e-02f, 1.02220751e-01f, -4.05784696e-03f, 1.28188785e-02f, 2.40199994e-02f, 1.95701257e-03f, 3.32512036e-02f, -7.69803300e-03f,
  2.14903783e-02f, -5.98442517e-02f, 9.23132896e-02f, 1.17101436e-02f, 2.64086388e-02f, 4.38425168e-02f, 3.02865617e-02f, -2.94397082e-02f, -6.75678402e-02f, -9.11135878e-03f,
  -5.90221807e-02f, 5.76640256e-02f, 4.90263514e-02f, 7.84968771e-03f, 5.38166128e-02f, -2.35652048e-02f, 5.75980321e-02f, 6.80402815e-02f, 4.47640456e-02f, -1.03302643e-01f,
  6.10325150e-02f, -3.14406492e-02f, -3.09158321e-02f, 3.58118527e-02f, 1.99402794e-02f, 6.80973530e-02f, -8.65314901e-03f, -6.55442551e-02f, -3.33003029e-02f, -5.81136234e-02f,
  7.37161785e-02f, 1.55913308e-01f, -6.20208383e-02f, -2.09721029e-02f, -6.15297481e-02f, -2.67506130e-02f, 5.63394791e-03f, -6.53750300e-02f, -1.74872652e-02f, -5.07730059e-02f,
  -1.79545712e-02f, -3.49098514e-03f, 5.32737561e-02f, 1.91347431e-02f, 2.13046446e-02f, -1.53529933e-02f, 8.39005038e-02f, -5.81966676e-02f, -4.30687778e-02f, -6.02671318e-02f,
  -3.65726277e-02f, 1.70768462e-02f, -6.52423967e-03f, 1.65707264e-02f, 1.58990715e-02f, 6.08606674e-02f, -5.78524619e-02f, -7.77696893e-02f, 6.39822185e-02f, -7.08077997e-02f,
  6.80601830e-03f, 1.45490155e-01f, 7.55489022e-02f, 9.44662243e-02f, -7.38592222e-02f, -1.32268697e-01f, 3.07551846e-02f, 3.77902910e-02f, 9.66867208e-02f, -1.64483171e-02f,
  -1.13497205e-01f, 9.21982974e-02f, 1.59832314e-02f, 8.71891603e-02f, 7.61227012e-02f, 9.99018252e-02f, 8.24170187e-02f, -3.47151048e-03f, 4.11050282e-02f, -5.31793050e-02f,
  1.34098485e-01f, -9.71209407e-02f, 1.54372156e-02f, 1.37461033e-02f, -1.50960926e-02f, 2.61399485e-02f, -1.55474588e-01f, -1.45167157e-01f, -6.30002245e-02f, -2.84142345e-02f,
  -2.79153436e-02f, -7.76626915e-02f, -1.85864326e-02f, -7.56894201e-02f, -1.63708255e-01f, -6.93550482e-02f, -7.37247467e-02f, -1.43223554e-02f, -3.03685274e-02f, -7.30384886e-02f,
  1.80388298e-02f, 4.40264028e-03f, 1.38103859e-02f, 1.15380893e-02f, 9.46988631e-03f, 5.97538687e-02f, -9.11133550e-03f, 4.90139350e-02f, 3.10741514e-02f, 1.89938787e-02f,
  -3.71437822e-03f, -3.80697623e-02f, -4.35103551e-02f, 6.46263957e-02f, -8.57190788e-03f, -6.80662831e-03f, -4.21505719e-02f, -5.10202609e-02f, -1.12804109e-02f, -1.69371243e-03f,
  -2.12493469e-03f, -2.34423671e-02f, -2.01441254e-03f, -2.33699065e-02f, -3.37641500e-02f, -3.12179513e-02f, -3.78692113e-02f, 2.84261350e-02f, 1.01835802e-04f, -9.92072970e-02f,
  3.02793849e-02f, 2.53617167e-02f, 4.58104759e-02f, 2.46260539e-02f, -4.94163297e-02f, -3.26547772e-02f, 3.01973126e-03f, -9.34150517e-02f, 8.62060413e-02f, 8.07420537e-03f,
  1.36378314e-02f, -4.22005765e-02f, 1.38273863e-02f, 9.81300371e-04f, 3.65165621e-02f, 2.36834586e-03f, 1.64607037e-02f, 1.30728697e-02f, -2.55271755e-02f, 2.64710784e-02f,
  -2.44621381e-01f, -6.59883320e-02f, -9.54181999e-02f, -6.64487481e-02f, -6.45986712e-03f, 2.35420112e-02f, 1.29598072e-02f, 3.01584043e-02f, -1.09660596e-01f, 5.58405742e-02f,
  -7.03018233e-02f, -1.60058972e-03f, -1.21764950e-02f, -2.04880107e-02f, 1.27726318e-02f, -3.42628807e-02f, 3.16796787e-02f, -2.38369405e-02f, -1.98096782e-02f, -2.61174794e-02f,
  -1.57035496e-02f, -4.24602665e-02f, -4.28742655e-02f, -5.23408363e-03f, 3.20134684e-02f, -1.36802122e-02f, 1.10056074e-02f, -1.73444543e-02f, -1.12758148e-02f, 1.38739431e-02f,
  -3.16077352e-01f, 3.12176794e-01f, 5.79820462e-02f, 1.38345182e-01f, -1.35559425e-01f, -1.92423671e-01f, -1.26366481e-01f, 1.53763905e-01f, -2.04895571e-01f, 9.16858464e-02f,
  -1.35249510e-01f, -5.17557338e-02f, -3.42810377e-02f, 8.65089595e-02f, -2.56505489e-01f, 9.96143743e-02f, -6.21112548e-02f, 2.46973056e-02f, -5.55906724e-03f, 2.83953138e-02f,
  4.70954403e-02f, -2.90909223e-02f, 7.58543462e-02f, 4.07274701e-02f, 7.22325444e-02f, 1.02139205e-01f, 8.26762393e-02f, 3.11510712e-02f, 1.30674765e-01f, -7.65745342e-02f,
  -1.46850139e-01f, 5.19876890e-02f, 8.58101547e-02f, -5.68251871e-02f, -5.19223474e-02f, -6.93711713e-02f, -2.95295026e-02f, 1.71477720e-02f, 5.83449332e-03f, -3.10197379e-02f,
  -4.66921069e-02f, -8.44039489e-03f, 1.13933226e-02f, 4.57813293e-02f, -1.46002891e-02f, -3.11053097e-02f, 1.42103527e-02f, 1.07719339e-01f, 4.20738868e-02f, -1.86176728e-02f,
  4.91601713e-02f, 3.18857841e-02f, 1.88483316e-02f, 4.96259481e-02f, 3.57833467e-02f, 3.73857059e-02f, 4.32942435e-02f, -7.82800466e-02f, -1.59556065e-02f, -7.18993321e-02f,
  -7.84105808e-02f, 2.74048019e-02f, 2.04319581e-02f, -4.48482707e-02f, 7.61003746e-03f, -7.37910643e-02f, 5.88352373e-03f, -1.50162550e-02f, -1.31423529e-02f, -2.19010264e-02f,
  2.72860844e-03f, 3.28912660e-02f, -5.86681291e-02f, 6.32459670e-02f, -4.22353260e-02f, 2.60973745e-03f, -1.98628996e-02f, 1.46369338e-02f, -3.11980974e-02f, -4.85484302e-02f,
  7.29039498e-03f, -1.82876941e-02f, 3.58225964e-02f, 8.80927518e-02f, -7.21535832e-02f, -1.15352562e-02f, -3.39654577e-03f, -4.26429836e-03f, -1.31089892e-03f, -3.42736878e-02f,
  -1.04408920e-01f, -1.78898554e-02f, -3.54795791e-02f, -4.05770168e-02f, -1.83722153e-02f, -3.89040746e-02f, 6.14530779e-02f, 9.43213925e-02f, -2.03143377e-02f, -5.99967432e-04f,
  -3.32145654e-02f, 6.19849935e-02f, 2.15522870e-02f, 3.50577794e-02f, 1.09741455e-02f, -1.97533462e-02f, -4.81653735e-02f, -1.81827508e-02f, -5.31348102e-02f, 3.83322127e-02f,
  2.58452483e-02f, -5.58948927e-02f, -1.13882013e-02f, -3.29914093e-02f, 1.05171159e-01f, -4.68266197e-02f, -1.31858349e-01f, 1.56797152e-02f, -1.92691537e-03f, -1.52870687e-02f,
  3.66125524e-01f, 1.55695260e-01f, 3.03472877e-01f, 2.77429909e-01f, 2.29731705e-02f, -1.88188568e-01f, -2.11490393e-01f, 3.81860249e-02f, 8.42917562e-02f, -1.75627932e-01f,
  -1.13050900e-01f, 6.03011250e-02f, -1.93590954e-01f, 8.53348896e-02f, 9.03641358e-02f, -8.50027427e-02f, 5.58876991e-03f, -1.35555714e-02f, 9.49414819e-02f, -3.55840921e-02f,
  9.94959176e-02f, -2.62637679e-02f, 1.72865987e-01f, 4.22535557e-03f, 4.33703512e-02f, 9.65332910e-02f, -7.09471107e-02f, -2.14514248e-02f, 1.53904185e-01f, 4.50562499e-02f,
  -1.64757576e-02f, 4.50273044e-02f, 9.20208097e-02f, 3.14740539e-02f, -1.01982588e-02f, -3.74389216e-02f, -3.63760293e-02f, -2.41331328e-02f, 2.79806200e-02f, -8.69791806e-02f,
  -4.81697358e-02f, 1.43369231e-02f, -5.73092476e-02f, 1.61715541e-02f, 4.16805632e-02f, 8.58025029e-02f, 6.01272732e-02f, 4.31175902e-02f, 2.26906594e-03f, -7.51655996e-02f,
  3.50932889e-02f, 3.57373506e-02f, -6.86536264e-03f, 5.28387614e-02f, 6.97515979e-02f, 6.24223351e-02f, -2.63560731e-02f, 1.95001271e-02f, -3.29832174e-02f, 2.33055633e-02f,
  -1.44287810e-01f, 1.23403594e-03f, -9.76708625e-03f, -5.12585379e-02f, 5.96990399e-02f, 1.16529763e-02f, -1.89271048e-02f, 1.28242755e-02f, 2.09620432e-03f, -1.10169649e-02f,
  -2.45115664e-02f, 4.90048751e-02f, -6.22430863e-03f, -1.62169486e-02f, -2.59719901e-02f, -4.92064841e-02f, -8.59436393e-02f, -2.63702963e-02f, 2.08451226e-02f, 3.65247503e-02f,
  1.61287468e-02f, 5.09699509e-02f, -2.33067404e-02f, -3.38040106e-02f, -4.86382060e-02f, 3.67582636e-03f, 2.89409757e-02f, -2.88417656e-02f, 5.71007617e-02f, -1.57480203e-02f,
  -1.35062605e-01f, -8.06415528e-02f, -2.92063151e-02f, -2.12403722e-02f, -5.80785330e-03f, 4.09497647e-03f, 6.06298856e-02f, -8.06564116e-04f, 1.47526506e-02f, 2.89118104e-03f,
  1.07408511e-02f, 5.65069430e-02f, 3.86247574e-03f, 1.14309350e-02f, 1.01970183e-02f, -6.12280853e-02f, -1.09324142e-01f, -5.35672754e-02f, -1.56733524e-02f, 2.00379500e-03f,
  -8.89316127e-02f, -4.79639210e-02f, 4.52279970e-02f, -2.03651246e-02f, -1.45112555e-02f, -3.09021194e-02f, -3.10757998e-02f, 2.44462620e-02f, 2.15860549e-02f, 3.37526947e-02f,
  -1.98845744e-01f, -2.52225906e-01f, -7.24562556e-02f, -2.79663473e-01f, -2.93357316e-02f, -5.91570847e-02f, -3.55453975e-02f, 6.35504499e-02f, -1.77888453e-01f, -4.54117395e-02f,
  1.54745296e-01f, -1.02957182e-01f, 2.10501179e-01f, -4.54218462e-02f, -2.79099233e-02f, 1.62969112e-01f, -2.83185244e-01f, -3.53710428e-02f, -9.95592251e-02f, -1.68167725e-01f,
  -8.40210449e-03f, -1.02131896e-01f, 1.53195545e-01f, 7.10835457e-02f, -6.29811510e-02f, -5.97468726e-02f, -1.13188930e-01f, 7.97587559e-02f, -2.71630865e-02f, -9.85417217e-02f,
  -1.88911170e-01f, -1.35694847e-01f, -5.66217564e-02f, 1.65417381e-02f, -4.89037670e-02f, 5.80641516e-02f, 2.71974187e-02f, 1.25964969e-01f, -3.61447260e-02f, 2.28976738e-02f,
  -3.55911888e-02f, 1.00891665e-01f, -1.49074635e-02f, 1.33719947e-02f, -5.42979985e-02f, -3.33728716e-02f, -2.69466881e-02f, -4.56547812e-02f, 1.87526960e-02f, 6.02356531e-02f,
  -5.29980250e-02f, -2.99232807e-02f, -5.22781722e-02f, -5.96434735e-02f, -1.28379324e-02f, -2.07490548e-02f, 2.06837822e-02f, 4.85665910e-02f, -8.48788247e-02f, -9.77739692e-02f,
  6.79436699e-03f, 6.39369991e-03f, -4.94652614e-02f, 1.78627092e-02f, -3.91677916e-02f, 5.90902269e-02f, -9.50446278e-02f, 3.24531016e-03f, -7.82415364e-03f, -9.99718253e-03f,
  6.28258660e-02f, 1.44955749e-02f, 3.99225717e-03f, 1.09118624e-02f, -5.97833730e-02f, -1.66256763e-02f, 7.45020360e-02f, -6.18724041e-02f, -2.82102954e-02f, -4.58316281e-02f,
  2.66863275e-02f, 2.36789901e-02f, 4.50287610e-02f, -1.14555275e-02f, -2.28434484e-02f, 4.03582267e-02f, -6.54224493e-03f, -2.49866769e-02f, -3.51848565e-02f, -1.67084038e-02f,
  -2.60550648e-01f, -2.22600445e-01f, -1.05629794e-01f, -2.23216228e-02f, -5.05096726e-02f, -1.97185930e-02f, -2.38731690e-02f, -4.29045074e-02f, -1.64313599e-01f, 3.44112217e-02f,
  -4.67862301e-02f, -3.31694931e-02f, -6.67437688e-02f, 2.63927225e-02f, 4.84156981e-02f, -7.00957030e-02f, -2.79822052e-02f, 4.16182205e-02f, -4.95068282e-02f, -9.42426324e-02f,
  1.90809704e-02f, 2.35609040e-02f, -2.12309305e-02f, 5.29779978e-02f, 5.05843274e-02f, -7.74060041e-02f, -6.29334375e-02f, -9.86640230e-02f, 2.10058317e-02f, 4.39686840e-03f,
  -3.08489949e-01f, 1.85139388e-01f, 7.88836777e-02f, -9.29435343e-03f, 4.76912409e-02f, 5.22641353e-02f, 1.48150489e-01f, 3.04553043e-02f, 1.66854531e-01f, 1.42591476e-01f,
  2.02215426e-02f, 1.14844121e-01f, 5.02503477e-02f, 1.52702089e-02f, 1.07529620e-02f, 1.79018721e-01f, -4.10857610e-02f, 9.28307176e-02f, 3.80733088e-02f, -4.47384343e-02f,
  -3.70899849e-02f, -1.35217691e-02f, -8.12205486e-03f, -1.62692100e-01f, -1.51721984e-01f, -1.70123175e-01f, -1.91658959e-01f, 1.74419731e-02f, -1.94323093e-01f, -7.73133561e-02f,
  -3.83805223e-02f, 5.66785894e-02f, -4.85434756e-02f, 4.74890843e-02f, -1.05731539e-01f, -6.59397617e-02f, -1.93088260e-02f, -7.71001950e-02f, -4.49231192e-02f, 2.92430781e-02f,
  -1.01188459e-02f, -1.87869780e-02f, -2.37759273e-03f, -9.11595859e-03f, -9.62988734e-02f, 9.54486895e-03f, 5.09176850e-02f, 2.42193025e-02f, 7.24380687e-02f, -3.07873096e-02f,
  6.41809106e-02f, 3.39831263e-02f, -2.07397831e-03f, -2.21452881e-02f, 8.02794099e-03f, -7.05241133e-03f, 3.74179408e-02f, 2.03803089e-02f, -1.07852980e-01f, 9.19891614e-03f,
  -6.78067133e-02f, -3.55552137e-02f, 6.57631010e-02f, -4.16907705e-02f, -6.09142594e-02f, -3.65302898e-02f, 6.13098918e-03f, 1.38523299e-02f, -1.12098888e-01f, 1.69038530e-02f,
  -4.21842076e-02f, -5.22349365e-02f, 1.05699822e-02f, 5.10304533e-02f, -2.44156942e-02f, 2.69102193e-02f, -1.07692055e-01f, 2.72070896e-02f, 3.56265455e-02f, 3.89361605e-02f,
  -5.63785248e-02f, 3.08214650e-02f, -1.17174853e-02f, -1.61556415e-02f, -6.72659725e-02f, 1.26179978e-02f, 2.69212518e-02f, 3.81000340e-02f, 3.79161797e-02f, -6.62755296e-02f,
  1.07080668e-01f, 2.95817386e-02f, 8.96633565e-02f, 1.23053268e-02f, 6.27085492e-02f, -4.06207368e-02f, -2.19538510e-02f, -3.30136679e-02f, 4.87116948e-02f, -8.63867626e-03f,
  3.36579159e-02f, -1.44630373e-02f, 4.25216295e-02f, -6.42533367e-03f, -6.04754388e-02f, 5.95511906e-02f, 2.77117174e-02f, -4.04554233e-03f, -1.29177626e-02f, 2.48469096e-02f,
  4.34531048e-02f, -3.35278027e-02f, -3.68097350e-02f, -2.22850610e-02f, -2.86134165e-02f, 6.34216368e-02f, -4.44851965e-02f, -3.34654562e-03f, -8.29590857e-02f, 2.74235979e-02f,
  -1.58959646e-02f, -4.78693135e-02f, -4.25419770e-02f, 1.33508071e-01f, -1.09818503e-01f, 1.33663550e-01f, 1.32744610e-01f, -4.31701131e-02f, -6.48208112e-02f, 1.72334164e-01f,
  1.38608649e-01f, -7.53472298e-02f, 1.45767108e-01f, 8.63825306e-02f, 9.77471843e-02f, 5.99584877e-02f, 1.61534384e-01f, 6.29092306e-02f, -6.82884157e-02f, -1.21651655e-02f,
  5.04031479e-02f, 5.93316481e-02f, -4.80040200e-02f, -4.11135182e-02f, -1.47384303e-02f, -1.15331300e-01f, 1.13074459e-01f, -7.54040703e-02f, 2.56077014e-02f, -3.50985192e-02f,
  -4.91023846e-02f, 7.46627674e-02f, -7.63891935e-02f, -4.45924560e-03f, 8.95279869e-02f, -2.90401485e-02f, -4.59437743e-02f, 3.68212946e-02f, -4.49291081e-04f, 2.99373246e-03f,
  -5.78999370e-02f, -3.57135907e-02f, -3.09594441e-02f, 4.86452878e-02f, 8.60463828e-02f, -1.28743604e-01f, -8.45992714e-02f, -3.60283852e-02f, -7.34620467e-02f, -5.22007793e-02f,
  -3.46691534e-02f, -3.49960523e-03f, -1.21240867e-02f, 1.05608152e-02f, -1.62434410e-02f, 2.59838533e-02f, 4.66624573e-02f, 4.99818064e-02f, -2.86642034e-02f, 6.92000687e-02f,
  6.52852235e-03f, -5.73080145e-02f, -4.03355900e-03f, -3.87827158e-02f, -4.69237007e-02f, -8.57384279e-02f, 3.87180899e-03f, -3.56947370e-02f, 4.47214767e-02f, 3.33992764e-02f,
  -4.39432114e-02f, -7.87904263e-02f, -4.50667925e-02f, 2.31170282e-02f, 7.12364465e-02f, -1.18521284e-02f, -8.72569159e-03f, -3.76918055e-02f, 8.41054879e-03f, -2.58199759e-02f,
  -4.72413227e-02f, 1.15626073e-03f, -5.49761616e-02f, 5.68675101e-02f, -1.10135498e-02f, -8.86441302e-03f, 3.49853449e-02f, -3.82993519e-02f, -6.01580143e-02f, 9.40148160e-02f,
  1.58288881e-01f, 1.21336535e-01f, 1.25453770e-02f, -3.93519253e-02f, -2.79893130e-02f, 1.34744160e-02f, -2.57880799e-03f, 6.56879973e-03f, 4.77912091e-02f, 6.99456409e-02f,
  3.05044129e-02f, 3.77238204e-04f, -7.05712587e-02f, 2.18220633e-02f, -3.84735614e-02f, 7.24618882e-02f, 5.79039454e-02f, 3.60212997e-02f, 8.68944675e-02f, -3.41618881e-02f,
  4.60750461e-02f, 2.29757223e-02f, -2.55313944e-02f, 1.14650205e-02f, 6.94429651e-02f, 8.88551846e-02f, -5.24103306e-02f, 1.88510909e-04f, 6.10839836e-02f, -6.01149350e-02f,
  -2.70298552e-02f, -2.35566664e-02f, -5.20991236e-02f, 2.47638691e-02f, 1.33950531e-01f, -9.62207913e-02f, -1.60182819e-01f, 6.02233969e-02f, -2.28739768e-01f, 4.21841182e-02f,
  4.71272552e-03f, -5.59215732e-02f, -2.62887850e-02f, -4.17709835e-02f, -1.33503586e-01f, -1.73773646e-01f, -1.57980070e-01f, -1.42199531e-01f, -8.26182738e-02f, 7.46680796e-03f,
  -1.55485263e-02f, 7.86888748e-02f, -7.46266171e-02f, 2.14614153e-01f, 8.23449269e-02f, 1.16263874e-01f, 1.17679648e-01f, 2.83779986e-02f, 4.17279229e-02f, 5.86515665e-02f,
  2.14497652e-02f, -1.09026082e-01f, -5.11380211e-02f, 2.90188249e-02f, -2.77273655e-02f, 1.05526283e-01f, 5.38158752e-02f, -9.51678492e-03f, -9.43232402e-02f, 1.35866133e-02f,
  6.87392429e-02f, -3.04271951e-02f, -4.80633304e-02f, -2.19366588e-02f, -5.51276607e-03f, -4.87061292e-02f, -2.51281802e-02f, -5.89503050e-02f, 2.06136890e-02f, -2.76089925e-02f,
  3.20276967e-03f, -3.91243957e-03f, -1.36455176e-02f, 5.89189753e-02f, -2.98064458e-03f, -2.23000590e-02f, 3.61279510e-02f, 7.80849010e-02f, -5.60248131e-03f, 7.61207473e-03f,
  6.67844489e-02f, -3.07570852e-04f, 8.90770853e-02f, -4.73606810e-02f, 2.20819656e-02f, 7.70760030e-02f, -1.07695879e-02f, -7.56799616e-03f, -6.51007667e-02f, 1.28057906e-02f,
  4.99054417e-02f, 2.00302503e-03f, 1.76897328e-02f, 7.39524588e-02f, -1.70307476e-02f, -5.47843706e-03f, -1.01079894e-02f, -2.25260016e-02f, 2.89050210e-02f, 1.39504094e-02f,
  4.54472825e-02f, 1.61282327e-02f, 3.99682373e-02f, -1.06504969e-02f, 2.84709539e-02f, 2.54312325e-02f, 3.33368704e-02f, -5.58965877e-02f, -2.24535074e-02f, 4.46614400e-02f,
  1.30844014e-02f, 6.59605712e-02f, -6.12147488e-02f, 2.01320499e-02f, 4.41331118e-02f, -5.09955047e-04f, -4.00463343e-02f, 8.92193755e-04f, 1.66603248e-03f, -5.40719368e-02f,
  3.58254574e-02f, 8.57224911e-02f, -1.43347243e-02f, 4.78991158e-02f, -2.44089290e-02f, 3.73111106e-03f, 6.73593394e-03f, 9.18126628e-02f, 1.38743212e-02f, -4.78842780e-02f,
  -2.78348234e-02f, -4.47501168e-02f, -5.08552603e-02f, 2.80736033e-02f, -2.13346444e-02f, 1.06347963e-01f, -4.60246280e-02f, 7.01397434e-02f, -2.43536243e-03f, -6.43429831e-02f,
  -3.08628887e-01f, 8.56657028e-02f, 5.68836322e-03f, 4.46573049e-02f, 8.35505873e-02f, 1.13311060e-01f, -9.34570432e-02f, 9.21755433e-02f, 2.87909657e-02f, 1.38502017e-01f,
  1.34763286e-01f, -1.71223745e-01f, -9.10449401e-02f, 9.12945122e-02f, -2.57659137e-01f, -1.11015305e-01f, 1.80638969e-01f, 4.70986124e-04f, -5.72057888e-02f, 1.23476358e-02f,
  1.88827189e-03f, 1.43049166e-01f, 6.42499235e-03f, 2.23049104e-01f, 5.69530353e-02f, 4.20679413e-02f, -1.11868586e-02f, 4.42281738e-02f, 7.72091448e-02f, -3.95610891e-02f,
  -4.63448558e-03f, 1.88445915e-02f, -4.50130925e-02f, -4.54736874e-02f, -9.50877294e-02f, -3.13033126e-02f, -5.93563057e-02f, -1.57399818e-01f, -2.46903463e-03f, -4.99107987e-02f,
  -1.35583840e-02f, -6.29924908e-02f, 5.68116754e-02f, -2.40666023e-03f, 4.98666540e-02f, 2.83551402e-02f, -1.73599087e-02f, 1.17461625e-02f, 1.91934512e-03f, -1.11225415e-02f,
  8.42535403e-03f, 9.22073871e-02f, 6.73480704e-02f, 1.22977355e-02f, 6.10392280e-02f, 1.24048747e-01f, 1.35907009e-02f, -6.58929497e-02f, 6.37879819e-02f, 2.41513327e-02f,
  -1.67062543e-02f, -3.31098847e-02f, 3.80528197e-02f, -4.84531596e-02f, -2.15491373e-02f, 6.70708939e-02f, 7.11622089e-02f, -4.70006987e-02f, 3.90092172e-02f, 4.06100452e-02f,
  6.98485523e-02f, 6.29786262e-03f, -7.77719468e-02f, 5.28790094e-02f, -5.84167987e-02f, 1.23459743e-02f, 2.96746772e-02f, 2.66570318e-03f, 4.66104783e-02f, 3.61324009e-03f,
  2.18229182e-02f, -5.16144484e-02f, -2.22790200e-04f, 4.90545034e-02f, 1.64251903e-03f, -6.01376519e-02f, 6.64346442e-02f, 4.57382053e-02f, -5.33585846e-02f, 7.47011369e-03f,
  9.33944657e-02f, -5.57524003e-02f, 2.31149793e-02f, 4.26806584e-02f, -4.06222455e-02f, -3.05650514e-02f, -1.68027896e-02f, 6.42888024e-02f, 1.51983267e-02f, 5.16853295e-02f,
  3.28298286e-02f, -1.98990870e-02f, -1.36795929e-02f, 4.26567867e-02f, 1.02662500e-02f, -2.19209196e-05f, -5.28135570e-03f, 2.44204346e-02f, 1.01141848e-01f, 7.76085630e-02f,
  4.37274054e-02f, 4.01619188e-02f, -7.27791488e-02f, 2.29212288e-02f, -4.20424156e-02f, -4.20573540e-02f, 2.71556489e-02f, 4.31151316e-03f, -2.38745436e-02f, -1.02100903e-02f,
  1.26513600e-01f, 5.66442050e-02f, -1.59030423e-01f, 1.03891008e-01f, -2.54075183e-03f, 6.25684410e-02f, -2.08783373e-02f, -1.26006082e-01f, -1.91357687e-01f, 1.37879355e-02f,
  1.79316983e-01f, -7.16346782e-04f, -1.64700523e-01f, -4.53599310e-03f, 2.73502581e-02f, -1.56155884e-01f, 1.16692066e-01f, 9.94010791e-02f, -1.24660574e-01f, 2.00028457e-02f,
  9.04676169e-02f, 7.14552104e-02f, -9.81746018e-02f, -4.44374718e-02f, 2.20673606e-02f, 8.66599753e-02f, 2.43695736e-01f, 1.46872904e-02f, 2.16924205e-01f, 1.07161097e-01f,
  -1.65566858e-02f, -2.77486406e-02f, 4.11242843e-02f, -2.21541408e-03f, 1.94414109e-02f, 1.05643705e-01f, -1.77907683e-02f, 4.25534137e-02f, 7.18664154e-02f, -8.01977515e-02f,
  3.00236158e-02f, 4.53952421e-03f, -4.60896939e-02f, 1.48531829e-03f, -6.40484318e-02f, 1.08765094e-02f, -3.09311356e-02f, 1.26170032e-02f, -3.58376279e-02f, 1.65983085e-02f,
  -6.31706044e-02f, 1.54115236e-03f, 3.00889509e-03f, 1.89858917e-02f, 5.02964929e-02f, 3.24011855e-02f, -6.29569888e-02f, 1.31865907e-02f, -4.27270494e-02f, -5.13671571e-03f,
  -5.55222929e-02f, -5.26805073e-02f, -3.32595557e-02f, -7.98036084e-02f, -5.20362183e-02f, -1.87274013e-02f, -4.27266397e-02f, 6.20324500e-02f, 8.12047999e-03f, -4.23420817e-02f,
  -6.56597456e-03f, 2.47673318e-03f, 8.55749100e-03f, 5.03749959e-02f, -3.90196443e-02f, -4.45169099e-02f, 1.97921414e-02f, -8.08974728e-02f, -1.59543492e-02f, 6.92677349e-02f,
  -2.81566288e-02f, 2.50828583e-02f, -4.67835367e-02f, 8.36007856e-03f, 2.90347394e-02f, -9.27041844e-02f, 7.71595016e-02f, -5.46392985e-02f, -1.92707665e-02f, 3.64301465e-02f,
  3.64478827e-02f, 1.36993766e-01f, 3.99696827e-02f, 2.13868660e-03f, -4.62238267e-02f, 5.01415096e-02f, -4.68273908e-02f, -4.05153958e-03f, 1.87933631e-02f, 4.42514047e-02f,
  3.78412455e-02f, -3.12076546e-02f, 1.13700673e-01f, 3.96669060e-02f, -2.79528555e-02f, 7.63151282e-03f, 2.49211006e-02f, 7.15697333e-02f, 1.31867871e-01f, 5.71720116e-02f,
  8.22818093e-03f, -5.39091378e-02f, 3.31963412e-02f, 1.52059961e-02f, 9.76310447e-02f, -5.19203767e-03f, -7.00570131e-03f, -2.19363924e-02f, 9.35338140e-02f, 2.37938501e-02f,
  -4.62378144e-01f, 4.93444204e-02f, -2.99458448e-02f, -2.35875338e-01f, -6.62099347e-02f, 6.20343648e-02f, 1.44493222e-01f, -1.57403782e-01f, -2.01767385e-01f, 5.31634409e-03f,
  1.12577423e-03f, 1.71067007e-02f, 1.91658899e-01f, -8.43191519e-02f, 2.54992675e-02f, 2.17654034e-01f, -4.94356416e-02f, 4.31389548e-02f, -6.53777421e-02f, -1.13526456e-01f,
  -1.05990991e-01f, -4.09194641e-02f, -5.23185031e-03f, -6.80919737e-02f, -1.32985972e-02f, -5.87750487e-02f, 7.92674199e-02f, 1.10808410e-01f, -2.97912415e-02f, 7.45845959e-02f,
  -8.74441862e-02f, -6.49531111e-02f, -1.49132222e-01f, 1.94734130e-02f, 5.50503936e-03f, -3.18127871e-02f, 2.76275333e-02f, 6.66169077e-02f, -1.16968952e-01f, 2.59637344e-03f,
  4.13170718e-02f, 1.63118262e-02f, -6.07310273e-02f, -1.60142649e-02f, -5.56559786e-02f, -3.10198707e-03f, 2.80335825e-03f, 2.36982275e-02f, -3.58345658e-02f, 1.19156744e-02f,
  -3.98221910e-02f, 1.68927684e-02f, -3.79190072e-02f, 9.69981179e-02f, -5.24869189e-02f, 2.65821889e-02f, -2.19183285e-02f, -3.52868065e-02f, 2.92659346e-02f, -6.89426437e-02f,
  -1.31009622e-02f, 8.73925984e-02f, 1.96806379e-02f, -4.01633093e-03f, 4.34952090e-03f, -2.32255831e-02f, 3.12385033e-04f, 4.16876785e-02f, -8.63485336e-02f, -4.23183702e-02f,
  -5.80150560e-02f, -5.68446107e-02f, 4.55112243e-03f, 2.18673199e-02f, -6.18262328e-02f, 9.07783117e-03f, -2.42918115e-02f, -4.94609363e-02f, -2.16615740e-02f, 6.66608009e-03f,
  7.50995129e-02f, 3.08851916e-02f, 4.04224582e-02f, -2.20424719e-02f, 6.95224032e-02f, -1.29690329e-02f, -4.69162278e-02f, -1.80219002e-02f, 7.61894435e-02f, 2.39421856e-02f,
  1.52000949e-01f, 9.03302878e-02f, 5.38501889e-02f, 5.70310727e-02f, -4.84024584e-02f, 5.37682604e-03f, 6.22478779e-03f, -1.32478578e-02f, 8.50813091e-02f, -3.76864970e-02f,
  -7.30978474e-02f, 1.91465579e-02f, 4.68294285e-02f, -3.08482945e-02f, 3.28266615e-04f, 1.20678153e-02f, 4.84686978e-02f, -5.16223572e-02f, 3.93901169e-02f, 1.34663628e-02f,
  -1.15785645e-02f, 1.98930353e-02f, 3.69246081e-02f, -8.11421871e-02f, -3.41602936e-02f, 2.82539753e-03f, -7.96555355e-02f, -1.08952532e-02f, 9.55664665e-02f, 1.17108915e-02f,
  -1.23503797e-01f, 1.24144495e-01f, -9.03632119e-03f, 7.59302825e-02f, -1.12872057e-01f, -1.43914431e-01f, -7.44879618e-02f, 2.80338712e-02f, 8.34721923e-02f, 9.21619162e-02f,
  -5.34047559e-02f, 2.34363470e-02f, -9.29381419e-03f, 2.06009567e-01f, -1.85121641e-01f, 1.02141961e-01f, 8.81929994e-02f, 7.11109862e-02f, 9.64778587e-02f, -3.61984409e-03f,
  -6.13897629e-02f, -8.61679669e-03f, -2.69603338e-02f, 9.16803777e-02f, -1.35861203e-01f, -5.56033105e-03f, -7.38288239e-02f, -1.13638483e-01f, 5.57278842e-02f, -7.30378032e-02f,
  5.31168878e-02f, 1.55673251e-02f, -8.97308718e-03f, 7.63385892e-02f, -3.03258281e-02f, -6.47723824e-02f, 2.10542046e-02f, -6.14757314e-02f, 5.25905862e-02f, 1.78506842e-03f,
  7.45022744e-02f, 5.35751171e-02f, 3.01701967e-02f, 5.60986698e-02f, 2.96553224e-03f, -1.23268245e-02f, 4.83025461e-02f, -5.86615205e-02f, 2.12637056e-02f, -5.78258447e-02f,
  4.23099957e-02f, 1.19782174e-02f, -4.57274308e-03f, 6.47909492e-02f, 2.00010333e-02f, -4.86264639e-02f, -2.82080863e-02f, -1.90618671e-02f, 3.17875557e-02f, 4.80234176e-02f,
  -3.39227021e-02f, 1.00929860e-03f, -3.15483995e-02f, -2.37372760e-02f, 7.55665917e-03f, 2.49474775e-02f, -1.51219284e-02f, -6.17224462e-02f, 2.09961552e-03f, -6.91298097e-02f,
  -4.21426259e-03f, -1.83843933e-02f, 6.38869330e-02f, 2.61690076e-02f, -3.55573818e-02f, 7.33139785e-03f, 2.91899331e-02f, 9.08683836e-02f, -3.37873138e-02f, -6.35280088e-02f,
  -2.18991023e-02f, -5.72283305e-02f, -4.80428077e-02f, -6.89757094e-02f, -3.67093049e-02f, 9.92436428e-03f, -3.65652554e-02f, 1.00876624e-02f, -6.26311824e-02f, -6.05982728e-02f,
  8.16587210e-02f, 8.56293440e-02f, 1.17073553e-02f, -3.62030715e-02f, -8.84342939e-03f, 2.37391051e-02f, -1.64750405e-02f, 4.44189198e-02f, 8.63044783e-02f, -3.24309096e-02f,
  7.01062102e-03f, -3.32422042e-03f, -9.90316346e-02f, -1.55005548e-02f, 4.03628312e-02f, -1.62009685e-03f, 3.30106057e-02f, -2.58515552e-02f, 5.79548068e-02f, 5.40597625e-02f,
  -5.00972979e-02f, -3.28614525e-02f, -2.24368032e-02f, -4.68514152e-02f, -4.49113622e-02f, -4.22548242e-02f, 4.86094132e-02f, 8.07379112e-02f, -3.98263521e-02f, -5.97751467e-03f,
  -6.89641908e-02f, 7.83998892e-02f, -9.71462876e-02f, 2.78662294e-01f, -1.67392448e-01f, 1.80807710e-02f, -9.00486410e-02f, 3.73711325e-02f, 7.94968084e-02f, 4.72773723e-02f,
  1.23319618e-01f, 1.10105909e-02f, 4.80764769e-02f, 3.66559774e-01f, 3.15467030e-01f, 1.79317996e-01f, 3.06101412e-01f, 9.89864394e-02f, 1.16046056e-01f, -8.60211672e-04f,
  1.95969939e-01f, 2.56817997e-01f, 1.59935802e-01f, 7.61972740e-02f, -5.90902045e-02f, -8.27831042e-04f, 8.66100341e-02f, -7.55399689e-02f, 9.57553089e-02f, 8.58249143e-02f,
  -8.81897658e-02f, -2.46003233e-02f, -5.98280355e-02f, 3.61559959e-03f, -5.51529452e-02f, -7.60273188e-02f, -7.57729411e-02f, -3.67072485e-02f, -4.64354418e-02f, 5.02324523e-03f,
  -1.02288656e-01f, 5.89650683e-03f, 2.76896004e-02f, 9.63319317e-02f, -4.59465198e-02f, 2.53653200e-03f, 4.16678922e-05f, 3.67703401e-02f, 2.76344642e-03f, 6.51066611e-03f,
  -5.55121116e-02f, -6.21851347e-03f, -9.79541764e-02f, -2.03136411e-02f, 4.62548016e-03f, -1.47204958e-02f, 3.44384313e-02f, 1.11544793e-02f, -1.73748713e-02f, -1.10636489e-03f,
  -7.16724852e-03f, 3.34864892e-02f, -8.68199673e-03f, 1.94213428e-02f, 1.76580399e-02f, 5.54626510e-02f, 8.72552395e-03f, 1.69686284e-02f, -1.19890738e-02f, 2.12382991e-02f,
  2.99890433e-02f, 3.38853039e-02f, -3.24668884e-02f, -3.86376004e-03f, -1.01111950e-02f, -6.42928248e-03f, -2.18639057e-02f, 4.45622653e-02f, -4.23037931e-02f, 6.52391613e-02f,
  1.22777121e-02f, 4.36890610e-02f, 6.10635579e-02f, -4.97162109e-03f, 4.25100736e-02f, -1.06613422e-02f, 9.15818885e-02f, -1.98159069e-02f, -2.31263433e-02f, 1.57383904e-02f,
  1.40683621e-01f, 9.70520005e-02f, -1.11378338e-02f, -1.29909990e-02f, 3.74304056e-02f, -3.60220857e-02f, 8.06427002e-02f, 3.38750146e-02f, 4.52188514e-02f, -1.94217842e-02f,
  -2.76115933e-03f, -1.44360466e-02f, -4.27472219e-02f, -3.62387560e-02f, 8.68867785e-02f, 3.12679522e-02f, -3.53243276e-02f, -7.77423084e-02f, -8.24529771e-03f, 5.13896625e-03f,
  -3.35268304e-02f, -3.95712741e-02f, 1.17258448e-02f, -5.81893064e-02f, 3.64800468e-02f, -3.19265872e-02f, -3.12386192e-02f, -2.36557145e-02f, 3.32509517e-04f, 3.99820060e-02f,
  -2.17430845e-01f, 3.01832020e-01f, -1.23933524e-01f, 1.65594056e-01f, 1.23074725e-01f, 7.75416121e-02f, 1.21736996e-01f, 2.11158723e-01f, 1.21657774e-02f, 2.29039356e-01f,
  1.05437420e-01f, 2.13462431e-02f, -4.88839597e-02f, 2.04608351e-01f, -9.07497555e-02f, -1.03185706e-01f, 1.20985493e-01f, 5.31237945e-02f, -4.21457402e-02f, 2.37968668e-01f,
  -1.38304224e-02f, 1.98023736e-01f, -4.80944514e-02f, 1.44968867e-01f, 2.55863275e-03f, -7.08207786e-02f, -2.19217781e-02f, -3.84530388e-02f, 1.31958887e-01f, 1.45454332e-02f,
  7.38210902e-02f, -9.35669765e-02f, -5.97448088e-02f, 2.92552146e-03f, 1.84817072e-02f, 5.51635996e-02f, 3.27835195e-02f, -2.28634737e-02f, -6.31657243e-02f, 2.12176749e-03f,
  -4.18369323e-02f, -2.10656729e-02f, -2.79518105e-02f, -4.74553630e-02f, -1.78889725e-02f, 6.55431009e-04f, -1.08791459e-02f, -1.60550941e-02f, 2.41368115e-02f, -7.35248625e-02f,
  -5.77670475e-03f, -2.93617658e-02f, 2.71727238e-02f, 5.02343709e-03f, -2.01949291e-02f, 3.67674008e-02f, 5.73871545e-02f, -6.31148964e-02f, -5.09546809e-02f, 1.45300804e-03f,
  6.83029070e-02f, 2.70871539e-02f, -6.40048757e-02f, 2.80362298e-03f, 8.40201229e-03f, 4.95973974e-02f, -1.69889499e-02f, 5.01111038e-02f, -2.69807950e-02f, 7.30156014e-03f,
  -2.12589540e-02f, 1.34417806e-02f, -2.44890954e-02f, 4.58557531e-02f, 4.60735597e-02f, 1.10712580e-01f, -6.39419854e-02f, -8.53603408e-02f, -2.41763331e-02f, 9.08395182e-03f,
  5.87763228e-02f, 5.36449626e-02f, -5.33037484e-02f, -3.93052250e-02f, 4.08919863e-02f, -3.89894173e-02f, 2.49920394e-02f, 3.89862284e-02f, 2.37423163e-02f, -1.75660644e-02f,
  1.58395320e-01f, 9.34557617e-02f, 3.06594055e-02f, -2.70901751e-02f, 8.01766366e-02f, -6.05132878e-02f, 4.67652036e-03f, -6.02151863e-02f, 2.73290817e-02f, -2.36896183e-02f,
  2.11100020e-02f, 7.90871307e-02f, 1.19645437e-02f, 9.63795930e-03f, 1.07845731e-01f, -5.00688655e-03f, 4.49915975e-02f, 5.65621369e-02f, -1.40893022e-02f, 2.02394631e-02f,
  1.40868397e-02f, 2.07754225e-02f, -2.02854890e-02f, 6.35192320e-02f, 1.41387647e-02f, -2.23430246e-02f, 6.63971752e-02f, -2.91520562e-02f, 1.67975165e-02f, 1.09377950e-01f,
  -3.08973610e-01f, -1.56191990e-01f, -3.05911422e-01f, -1.93149805e-01f, 3.42574082e-02f, 2.10927185e-02f, 6.15767203e-02f, -1.99564457e-01f, -2.58484840e-01f, 1.15959942e-02f,
  5.84165715e-02f, -1.07520439e-01f, 8.31201226e-02f, -1.04545087e-01f, 1.34262979e-01f, 8.52737650e-02f, -1.39156550e-01f, -4.38223453e-03f, -1.08320586e-01f, -1.13543756e-01f,
  -1.11770771e-01f, 1.38194576e-01f, -4.83672954e-02f, 9.32952315e-02f, -1.77558549e-02f, -1.09603301e-01f, 6.18169196e-02f, 1.26621425e-01f, 5.38494289e-02f, 9.82056782e-02f,
  9.12788212e-02f, -1.61571428e-01f, -6.52285814e-02f, -3.56954150e-02f, -6.89740898e-03f, 1.21970465e-02f, 5.93795488e-03f, 1.50426015e-01f, 5.43099940e-02f, -4.53832820e-02f,
  4.62206639e-02f, -2.97097377e-02f, 3.94685715e-02f, 3.83824445e-02f, -1.39310118e-02f, -4.85085659e-02f, 3.37333232e-02f, 1.16047487e-02f, -8.12963992e-02f, -6.29054233e-02f,
  -4.46408316e-02f, -3.60117704e-02f, -9.41671282e-02f, -4.55703028e-03f, 5.73319755e-02f, 2.19032392e-02f, -2.52379514e-02f, -3.71256024e-02f, -2.97539998e-02f, -9.24836323e-02f,
  -4.60747816e-02f, 6.46312814e-03f, -1.80754866e-02f, 2.41308007e-02f, 1.85724236e-02f, -2.42793076e-02f, 4.47143987e-02f, 6.34541139e-02f, 1.05035350e-01f, -5.16580883e-03f,
  2.36574374e-02f, -2.16992688e-03f, 7.83597399e-03f, 1.24900462e-02f, 8.13717209e-03f, -1.72572210e-02f, -1.66329574e-02f, 4.00836580e-02f, -3.21113393e-02f, -9.17111039e-02f,
  -1.17337601e-02f, 2.20089070e-02f, 1.29062394e-02f, -6.84016431e-03f, -4.66104075e-02f, 1.60509627e-02f, -3.25999595e-02f, -6.38052076e-02f, 2.19951905e-02f, 4.69282120e-02f,
  2.42296934e-01f, -3.56289186e-03f, 4.12452081e-03f, 2.75190007e-02f, 1.97661854e-02f, 1.50459353e-02f, 2.56262682e-02f, 3.07904929e-02f, 8.53260234e-03f, 2.90768658e-05f,
  1.44825748e-03f, 1.35761648e-02f, -2.05222536e-02f, -4.48001996e-02f, -7.64952553e-03f, 8.90944153e-03f, 4.37878724e-03f, -4.02750596e-02f, 4.72945869e-02f, 2.85800323e-02f,
  3.11403219e-02f, 1.02313243e-01f, 4.39389721e-02f, -2.29475200e-02f, -4.34155017e-02f, 1.88763663e-02f, -4.20177579e-02f, 3.57468687e-02f, 2.66644787e-02f, 1.00566885e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  8.62115547e-02f, -3.30616683e-02f, -2.45974272e-01f, -7.79456049e-02f, -1.20346002e-01f, -2.91005164e-01f, -3.22106630e-01f, -4.79188487e-02f, 3.94378006e-02f, -2.25547086e-02f,
  -5.85965589e-02f, 1.39249027e-01f, -5.95723875e-02f, -8.88273343e-02f, -1.24880992e-01f, 2.71910392e-02f, -2.57888496e-01f, -9.77322236e-02f, 7.32757002e-02f, -3.45771722e-02f,
  -1.33551896e-01f, 2.76743453e-02f, -1.13683887e-01f, -5.33718504e-02f, -2.40841159e-03f, 6.50769323e-02f, 1.07584685e-01f, -9.60546266e-03f, -1.57283634e-01f, 3.37121896e-02f,
  -1.21206855e-02f, 1.24218665e-01f, -3.09418775e-02f, -7.89806396e-02f, -2.20353771e-02f, -4.20307778e-02f, -7.90087059e-02f, -2.64707319e-02f, 1.33624999e-02f, -8.16020146e-02f,
  -1.64220128e-02f, 1.66369434e-02f, -2.35100854e-02f, -2.63432581e-02f, -6.68859622e-03f, -3.17311585e-02f, 2.66829459e-03f, 2.11552549e-02f, -1.73435900e-02f, -2.02429499e-02f,
  1.48737868e-02f, 7.09385276e-02f, -9.57580134e-02f, -1.48810390e-02f, -4.37732115e-02f, 3.92489657e-02f, -2.35924460e-02f, 6.10609278e-02f, -8.09361860e-02f, -1.69590767e-02f,
  3.03936545e-02f, 7.82186538e-02f, 3.30744572e-02f, 8.44895467e-02f, 7.66805038e-02f, 6.55259145e-03f, -4.99303080e-02f, 5.80597818e-02f, 4.02730843e-03f, 1.20131727e-02f,
  -5.45035936e-02f, 5.60275465e-02f, 5.86090237e-02f, -7.58945197e-02f, -5.84593527e-02f, -3.11144963e-02f, -5.37014715e-02f, -3.98048200e-02f, -2.05387026e-02f, -4.73332815e-02f,
  5.44142425e-02f, 5.90174310e-02f, -6.24171868e-02f, -4.67994586e-02f, -5.52129447e-02f, 5.54699078e-02f, -1.65016912e-02f, 5.63054485e-03f, -2.96370033e-02f, -7.99229834e-03f,
  -2.08414048e-02f, -1.06409773e-01f, 3.83650064e-02f, 8.35557282e-02f, -4.32371944e-02f, -6.45976365e-02f, -3.84854265e-02f, -5.78004681e-02f, -1.26855522e-01f, 3.47800143e-02f,
  -7.14476779e-02f, 3.56760509e-02f, -4.81564477e-02f, 3.21006142e-02f, -7.03149587e-02f, -3.76445265e-03f, 7.00860396e-02f, -2.71858387e-02f, -5.21557871e-03f, 2.68238671e-02f,
  -1.19349845e-02f, -4.84446958e-02f, 4.95815501e-02f, -6.13782778e-02f, 4.99979854e-02f, -3.56481560e-02f, -6.03856519e-02f, -3.03526837e-02f, 2.95822807e-02f, -7.48370811e-02f,
  6.80346563e-02f, 1.55392677e-01f, 6.84411675e-02f, 1.41513914e-01f, -1.72713682e-01f, -1.72057271e-01f, -2.06212282e-01f, 1.05812892e-01f, -7.36418068e-02f, -1.48583381e-02f,
  1.71066355e-02f, 4.56278101e-02f, 8.19547772e-02f, 5.37520945e-02f, -7.86334574e-02f, -5.06513007e-02f, 2.26393025e-02f, -2.05444507e-02f, 9.51412618e-02f, 1.68496951e-01f,
  1.03385791e-01f, 1.12344138e-01f, 1.72171250e-01f, 9.40541625e-02f, 2.23667789e-02f, 2.26748034e-01f, 1.39765412e-01f, 6.46520033e-02f, 1.06456466e-01f, 3.26338857e-02f,
  -2.83602886e-02f, 1.20311484e-01f, 4.17970084e-02f, -8.52067620e-02f, -6.25108108e-02f, -5.95087670e-02f, 1.12758612e-03f, 5.62606752e-02f, -2.48010065e-02f, 7.65367225e-02f,
  -5.59306778e-02f, 4.80846241e-02f, 6.56056926e-02f, -4.52045202e-02f, -3.02807055e-02f, -1.33336440e-03f, -7.19135348e-03f, -7.17952698e-02f, -2.19938271e-02f, 3.88764925e-02f,
  -4.06199098e-02f, -1.26794623e-02f, -8.75368640e-02f, -7.92214349e-02f, -5.45845851e-02f, -8.58224407e-02f, 3.72502208e-02f, 6.73982576e-02f, -3.44401225e-02f, -4.44025472e-02f,
  -7.44193345e-02f, -1.04185764e-03f, -1.49893882e-02f, -6.56843111e-02f, -2.41629165e-02f, 4.04016627e-03f, 2.61003282e-02f, 4.98813838e-02f, -4.49193493e-02f, 6.16422929e-02f,
  -4.82748449e-02f, 4.80303504e-02f, 1.05461357e-02f, -4.16200422e-03f, -8.87828134e-03f, -6.99818060e-02f, 1.33448141e-02f, -9.34384065e-04f, 1.09422013e-01f, -6.76915646e-02f,
  -9.23668407e-03f, -5.13346754e-02f, 4.27794233e-02f, 3.24256383e-02f, -5.64859249e-02f, -6.09346293e-02f, 6.40760809e-02f, 4.08132300e-02f, 7.87740722e-02f, -8.25322643e-02f,
  -1.61494017e-02f, 1.72495067e-01f, -2.44937949e-02f, 2.05063131e-02f, 3.87810133e-02f, -5.21449093e-03f, -9.05115083e-02f, -6.67796806e-02f, 4.64703888e-02f, -7.53598437e-02f,
  4.08207849e-02f, -5.73186912e-02f, -8.09569359e-02f, 4.68000807e-02f, 7.80168995e-02f, -3.13629694e-02f, 8.52956399e-02f, -1.95653569e-02f, 5.63884452e-02f, 2.65080389e-03f,
  -3.59347463e-02f, -4.44246717e-02f, -4.53733541e-02f, -6.95166513e-02f, 2.25534346e-02f, 3.33642066e-02f, 5.80619499e-02f, 3.13524865e-02f, 6.20883852e-02f, 2.27849949e-02f,
  3.74427661e-02f, -1.76419895e-02f, -1.56466261e-01f, -1.09130427e-01f, -5.46765588e-02f, -2.67362576e-02f, -1.63075656e-01f, -4.84348983e-02f, -4.36409302e-02f, -7.52906725e-02f,
  -4.56349663e-02f, 1.69125497e-02f, 8.64180028e-02f, -1.30287945e-01f, -1.15128038e-02f, 4.26515229e-02f, 4.45947126e-02f, 6.71535134e-02f, -3.38631906e-02f, -1.11761555e-01f,
  8.49158019e-02f, -8.38705003e-02f, 3.41268741e-02f, 5.81106097e-02f, -2.58672014e-02f, -7.37320930e-02f, -3.88140120e-02f, -1.29823640e-01f, 2.69386508e-02f, -1.12870224e-01f,
  6.18692748e-02f, -2.12739818e-02f, -1.01178639e-01f, -6.09056838e-02f, -1.81695949e-02f, 1.04988785e-02f, 2.10699122e-02f, -4.95295674e-02f, 3.93061452e-02f, -8.65324661e-02f,
  6.06721416e-02f, -6.05035722e-02f, 4.20709960e-02f, 7.97871128e-02f, 4.56958562e-02f, 2.98213977e-02f, 6.27451465e-02f, -1.98942851e-02f, 3.62881087e-02f, 3.52839455e-02f,
  -5.21923639e-02f, 6.41273111e-02f, -8.10812190e-02f, 1.08104743e-01f, -2.19660588e-02f, -4.17861342e-02f, -2.60937330e-03f, 2.24001724e-02f, -4.04400155e-02f, 1.08435685e-02f,
  6.68693706e-02f, 3.78250843e-03f, 8.15767273e-02f, -5.58385719e-03f, -6.33132607e-02f, 5.95117696e-02f, 5.58675490e-02f, 7.18469918e-02f, -4.26110178e-02f, -7.41028041e-02f,
  2.28850599e-02f, 4.25768904e-02f, -1.54008558e-02f, 6.09662710e-03f, 1.85900666e-02f, 6.81251884e-02f, -7.03503862e-02f, -4.28053252e-02f, -1.38277728e-02f, -4.59106602e-02f,
  -6.14114979e-04f, 2.80173924e-02f, -2.56414562e-02f, 7.79005364e-02f, 6.60677105e-02f, -9.45753977e-02f, 1.06254080e-02f, -2.51495130e-02f, -2.81723477e-02f, 2.36459076e-02f,
  6.71355650e-02f, -1.73568223e-02f, 6.37927800e-02f, -7.54902586e-02f, -1.23969177e-02f, -1.93262808e-02f, 6.06897241e-03f, 7.98164904e-02f, 4.82791960e-02f, 1.02309901e-02f,
  8.75424519e-02f, 3.22411745e-03f, 4.24088212e-04f, -3.95489261e-02f, 7.59763643e-02f, 5.71225509e-02f, -5.00166304e-02f, -7.75106102e-02f, 1.28123118e-03f, -1.97761487e-02f,
  6.60011247e-02f, 1.05703296e-02f, -4.93648313e-02f, 8.24023634e-02f, 7.03575984e-02f, -3.23032662e-02f, -7.29079247e-02f, 5.36007769e-02f, 2.66870745e-02f, 6.44654110e-02f,
  1.44408703e-01f, -1.86480165e-01f, 4.67946753e-02f, 1.27355874e-01f, 1.77433923e-01f, 1.60623761e-03f, -1.90866087e-02f, 8.76334012e-02f, -3.96655276e-02f, -1.77396342e-01f,
  6.69777021e-02f, -3.45707173e-03f, -1.18879534e-01f, 3.67139513e-03f, -4.72791083e-02f, -2.15389989e-02f, 1.30649954e-02f, 9.08475518e-02f, 1.50536711e-03f, -4.28843088e-02f,
  -3.06705404e-02f, -3.39009985e-02f, -5.73081784e-02f, 5.35109527e-02f, -2.88407691e-02f, 7.14358464e-02f, 1.39110899e-02f, -3.87882032e-02f, -2.85615399e-02f, -3.32094282e-02f,
  4.19832356e-02f, -1.80841264e-04f, -1.10927165e-01f, 4.14452180e-02f, -9.67139974e-02f, -9.30289999e-02f, -2.90776249e-02f, -9.09983069e-02f, 9.51667354e-02f, 7.19086528e-02f,
  -8.33449699e-03f, -7.83230513e-02f, -5.71184196e-02f, 7.97512680e-02f, 3.88191082e-02f, 4.63410057e-02f, 1.59136709e-02f, 7.85892159e-02f, -2.42850520e-02f, -6.44933730e-02f,
  5.91011755e-02f, 5.44683114e-02f, 8.38369057e-02f, 7.15474188e-02f, -1.84687506e-02f, -3.26697864e-02f, -5.33416383e-02f, -3.37489415e-04f, 1.05439827e-01f, 2.48226598e-02f,
  -4.17847559e-02f, -6.19720109e-02f, 7.79267633e-03f, 1.05179705e-01f, -2.63846330e-02f, -5.29981554e-02f, 4.99063767e-02f, 6.03480265e-02f, 9.70690474e-02f, -4.88833375e-02f,
  2.27196179e-02f, 5.55525087e-02f, -4.06711176e-02f, 2.87185293e-02f, -4.87149991e-02f, -5.57798818e-02f, -4.77818102e-02f, 8.36601655e-04f, 6.05756091e-03f, -5.15185893e-02f,
  -1.64864231e-02f, 4.16197442e-02f, -9.56661031e-02f, -8.79554171e-03f, -6.79353774e-02f, 3.56316417e-02f, -1.83370225e-02f, -1.36913387e-02f, 2.75536608e-02f, -7.88261816e-02f,
  -5.52558899e-02f, -1.32842228e-01f, -1.25766983e-02f, -4.62999716e-02f, 4.25504297e-02f, 3.12760123e-03f, -5.80772348e-02f, -2.89732385e-02f, 1.46134524e-02f, 4.77409922e-02f,
  -2.80876346e-02f, -1.00958850e-02f, 8.11714586e-03f, 7.76956156e-02f, 4.65024486e-02f, -7.14561045e-02f, -2.22575758e-02f, -1.09573543e-01f, -8.73140097e-02f, 2.30920650e-02f,
  -9.41859111e-02f, -4.68963496e-02f, 7.63287991e-02f, -1.29651204e-02f, 2.31587086e-02f, 4.24898192e-02f, -8.90694093e-03f, -3.01499646e-02f, 3.64941433e-02f, -3.25060748e-02f,
  7.88380727e-02f, 2.15160847e-01f, 5.83582558e-02f, -2.88398210e-02f, -8.56386125e-02f, -1.11554787e-01f, -7.73762539e-02f, -2.64124330e-02f, 9.69538614e-02f, 2.61591878e-02f,
  -7.34600127e-02f, 2.07557306e-01f, -1.73459128e-01f, -6.77835196e-02f, -1.97714970e-01f, -1.09936632e-01f, 6.39378205e-02f, 7.52253160e-02f, 1.01690955e-01f, -7.74655491e-02f,
  3.25509124e-02f, -2.07741320e-01f, -3.15439142e-02f, -7.12906430e-03f, 8.52530971e-02f, 2.86942045e-03f, -1.44523233e-01f, -2.44826563e-02f, 3.93095724e-02f, 5.83429746e-02f,
  4.29304615e-02f, -2.04368830e-02f, 1.60714641e-01f, 4.46387641e-02f, 7.83124119e-02f, 9.09382105e-02f, -5.95827922e-02f, -6.00362979e-02f, -3.36187892e-02f, 7.05369636e-02f,
  3.21924314e-02f, 1.15624513e-03f, 5.52184097e-02f, 5.80537990e-02f, 3.13634574e-02f, 7.33244866e-02f, 6.13764003e-02f, 1.01527639e-01f, 5.27794287e-03f, 3.04443948e-02f,
  -4.92075160e-02f, 9.11165997e-02f, -2.51808539e-02f, 7.92918727e-02f, 6.63104281e-02f, 6.54085875e-02f, 3.36609557e-02f, 4.51934524e-02f, 1.87154692e-02f, 6.03985116e-02f,
  1.45116234e-02f, -1.34610320e-02f, -1.04789525e-01f, -1.72953792e-02f, -6.11827336e-02f, -7.22228214e-02f, -3.27626355e-02f, -8.95223841e-02f, 2.51935218e-02f, -2.85531189e-02f,
  2.39211097e-02f, -3.25144827e-02f, -1.52936708e-02f, -3.96721624e-02f, 6.19465001e-02f, -4.28864434e-02f, -3.19200680e-02f, -1.74686443e-02f, 1.86813120e-02f, -7.72253750e-03f,
  -1.29349120e-02f, -7.38884658e-02f, 2.33645253e-02f, -8.51151347e-03f, 8.26583058e-02f, -2.17958596e-02f, -5.43967560e-02f, 3.69025790e-03f, -2.78941672e-02f, 5.19419983e-02f,
  -1.52239949e-02f, -8.96233395e-02f, 3.90264280e-02f, 3.69921848e-02f, 4.81958501e-02f, -6.89722002e-02f, 2.33108876e-03f, 5.90703301e-02f, 1.58128515e-02f, -3.59754427e-03f,
  7.07588270e-02f, 6.33878559e-02f, -4.61418070e-02f, -3.26811410e-02f, -7.93191865e-02f, -5.33400476e-02f, -4.28313687e-02f, -7.86854252e-02f, 3.32962275e-02f, -1.41327567e-02f,
  3.61867696e-02f, -4.57885005e-02f, -4.67271619e-02f, 5.99663658e-03f, 2.88854539e-02f, 7.87186529e-03f, 5.44123352e-02f, 5.96363731e-02f, -5.15702404e-02f, -5.09888045e-02f,
  2.57042676e-01f, -2.98276991e-01f, -1.89358015e-02f, 1.53658912e-01f, 2.18176946e-01f, 7.11004362e-02f, 6.03078417e-02f, 5.16536869e-02f, 7.49699771e-02f, -1.05337746e-01f,
  4.75994013e-02f, -1.22258708e-01f, -1.07445665e-01f, 4.51327935e-02f, 8.94813836e-02f, -7.75252655e-02f, 6.86787665e-02f, -7.63141438e-02f, 5.28151952e-02f, 5.34115247e-02f,
  1.29914567e-01f, 1.31354675e-01f, -6.17275387e-02f, -1.03320375e-01f, 4.17694822e-02f, 2.74393684e-03f, 1.24461375e-01f, 3.47647890e-02f, 4.05035615e-02f, -4.14379723e-02f,
  -5.84841184e-02f, 1.20186247e-02f, 3.20373848e-02f, -5.65573648e-02f, -1.11542093e-02f, -6.56799227e-02f, 5.93350828e-02f, -5.69401905e-02f, -3.99374682e-03f, -5.96616901e-02f,
  4.47727703e-02f, 3.67797874e-02f, 2.22055689e-02f, 1.57298148e-02f, 2.16431580e-02f, -1.18148597e-02f, 5.56293018e-02f, -2.93028969e-02f, -6.97290152e-02f, -1.17403701e-01f,
  -1.07595146e-01f, -1.09417580e-01f, -6.50066584e-02f, -4.63487767e-02f, -5.40142506e-02f, 5.35272248e-02f, -1.05917148e-01f, -8.31274763e-02f, 5.30602150e-02f, -3.13500017e-02f,
  4.92949821e-02f, 1.23136686e-02f, -9.32145491e-02f, -8.46287236e-02f, -8.11657012e-02f, 4.56771143e-02f, 1.36649180e-02f, 3.47464904e-02f, -5.71377054e-02f, -2.71085519e-02f,
  -1.58492625e-02f, 8.11111182e-02f, 8.54500756e-02f, 4.10639457e-02f, 2.64764261e-02f, -3.16810384e-02f, 8.23926833e-03f, -3.65080163e-02f, 5.12926579e-02f, 7.81256589e-04f,
  3.12895775e-02f, 1.00270472e-02f, -8.22687745e-02f, 7.29637593e-02f, 1.18190274e-02f, -5.79528473e-02f, 5.11312392e-03f, -6.64047748e-02f, 3.36997584e-02f, 3.81148644e-02f,
  -1.75617845e-03f, -4.94032241e-02f, -1.98848899e-02f, -1.04823727e-02f, -4.55427170e-02f, -1.33279428e-01f, -1.15998425e-01f, -4.16379143e-03f, 3.68367918e-02f, 2.34841891e-02f,
  7.48468637e-02f, -2.59033199e-02f, 1.14132036e-02f, -1.12047657e-01f, 4.96838130e-02f, 2.14270037e-02f, -1.51105048e-02f, -6.20596483e-02f, 9.89279598e-02f, 7.96644837e-02f,
  -1.37052163e-02f, -6.00196421e-02f, -9.24745947e-02f, -7.64874741e-02f, 6.63416684e-02f, 2.35370314e-03f, -5.82628474e-02f, -1.40091581e-02f, -4.47757691e-02f, -6.86341748e-02f,
  1.60447255e-01f, -8.86266604e-02f, -1.64653897e-01f, 5.17084636e-02f, 1.11221418e-01f, -5.17657027e-02f, -1.00223541e-01f, -5.07896617e-02f, -3.21855173e-02f, -7.37192705e-02f,
  -8.21719412e-03f, -1.31351247e-01f, -1.57400802e-01f, 7.34629333e-02f, -2.01194901e-02f, -7.64572918e-02f, -2.73713227e-02f, 2.90173050e-02f, -6.22577257e-02f, -9.37962383e-02f,
  4.71052788e-02f, 2.93259844e-02f, 2.94762999e-02f, 1.66810200e-01f, 3.41247953e-02f, 7.84430951e-02f, 1.76470384e-01f, 7.77900890e-02f, 2.04405069e-01f, 8.73750076e-02f,
  1.75997019e-02f, -1.08440958e-01f, -5.97075112e-02f, 1.32004032e-02f, 8.44005048e-02f, -1.70166958e-02f, 9.52264816e-02f, -4.74888384e-02f, -2.53868308e-02f, -5.64262122e-02f,
  -6.37844130e-02f, -2.91305389e-02f, 8.30407068e-02f, 6.93807527e-02f, 6.76464885e-02f, 8.49773958e-02f, 4.47497889e-02f, -1.64099671e-02f, -3.52245122e-02f, 4.81970087e-02f,
  -4.60641272e-02f, 2.42781453e-02f, -5.92573546e-02f, 7.25764483e-02f, -1.00810729e-01f, -7.13851973e-02f, 4.03353050e-02f, -2.80280858e-02f, -3.48392949e-02f, 3.71128805e-02f,
  6.99932873e-02f, 4.87071835e-02f, 5.48709966e-02f, 5.75548112e-02f, 1.74777750e-02f, -1.01533961e-02f, 9.67021808e-02f, -1.56397708e-02f, 4.74095084e-02f, 5.64730056e-02f,
  9.35653001e-02f, -3.58029567e-02f, 2.13109027e-03f, 4.71635498e-02f, -8.87418613e-02f, 1.80718284e-02f, 7.15895817e-02f, 9.30766854e-03f, -2.02446934e-02f, 6.95167109e-02f,
  -3.83225158e-02f, 8.69972631e-02f, 6.50854930e-02f, 4.88319397e-02f, -3.60912010e-02f, 2.04124097e-02f, -1.31340949e-02f, 5.20622469e-02f, -8.23527575e-02f, 1.15283996e-01f,
  4.31278236e-02f, -3.05164997e-02f, -4.74919705e-03f, 7.99956769e-02f, -3.81200798e-02f, 1.13585725e-01f, -2.24632304e-03f, 7.82743767e-02f, 6.66272491e-02f, 4.72785421e-02f,
  -6.19208775e-02f, -6.64660474e-03f, -7.67744565e-03f, -5.99522814e-02f, 4.77452353e-02f, 5.08521758e-02f, 2.72992235e-02f, 1.01610385e-01f, 8.91697928e-02f, 4.49303053e-02f,
  5.51765412e-02f, -4.22548801e-02f, 4.32485901e-02f, 9.06181186e-02f, 2.53955759e-02f, 3.85344364e-02f, -1.14265895e-02f, -2.97235418e-02f, -4.03301977e-02f, 1.49340532e-03f,
  1.07409075e-01f, 3.70038897e-02f, -7.32331127e-02f, 1.32768735e-01f, -1.23046055e-01f, -9.51198768e-03f, -1.36657372e-01f, -8.60858243e-03f, -1.98832169e-01f, -2.94364262e-02f,
  -5.79572469e-02f, -6.64627459e-03f, -1.06982701e-01f, 1.35130495e-01f, 1.53059155e-01f, -7.25248083e-02f, 2.36605573e-02f, 3.74209173e-02f, -3.51906680e-02f, -4.18714248e-02f,
  4.94315773e-02f, 6.49793670e-02f, 1.19512275e-01f, 1.73295796e-01f, 6.61876574e-02f, 7.72374123e-02f, 1.81956351e-01f, 7.81479329e-02f, 1.23938613e-01f, 1.52519271e-01f,
  3.88241857e-02f, -4.53333035e-02f, -6.58072978e-02f, 9.49050039e-02f, -7.25122308e-03f, -5.33067025e-02f, 1.20320208e-02f, 2.73101940e-03f, 2.92805918e-02f, -9.89197940e-03f,
  2.87658144e-02f, -5.19907251e-02f, -5.00976071e-02f, 3.66507173e-02f, -5.00662364e-02f, 2.43810900e-02f, -5.94645739e-02f, -1.07629187e-02f, -1.04638696e-01f, 2.73037329e-03f,
  -6.76376969e-02f, -3.07025388e-02f, -3.59766968e-02f, -4.87474464e-02f, -3.11192144e-02f, 1.83066111e-02f, -9.21170264e-02f, -3.94646674e-02f, 6.50962442e-02f, 7.03088939e-04f,
  7.88770393e-02f, -3.81760113e-02f, 6.79713935e-02f, -9.99033637e-03f, -5.56292981e-02f, -5.82107231e-02f, -7.61200935e-02f, 1.02582928e-02f, 2.59099603e-02f, -3.17691714e-02f,
  3.76152969e-03f, -1.02278264e-02f, 7.68229738e-02f, -1.03173025e-01f, -5.62280715e-02f, 5.92188537e-03f, 1.26620634e-02f, 3.70568074e-02f, 5.19718640e-02f, -7.09193647e-02f,
  -4.35002260e-02f, -6.60012849e-03f, -6.56305179e-02f, -1.09958639e-02f, -3.34052891e-02f, -7.12802410e-02f, 4.71784435e-02f, -7.02021420e-02f, -6.58573657e-02f, -8.59127045e-02f,
  -3.17404494e-02f, 1.05113797e-01f, -1.73583422e-02f, -1.67895667e-02f, -7.12652653e-02f, 3.81972864e-02f, -4.10034098e-02f, -7.05238208e-02f, 1.11823119e-02f, -4.86290194e-02f,
  -5.20671755e-02f, 6.66667372e-02f, 5.15815467e-02f, -1.89828202e-02f, -6.10184148e-02f, 3.42203565e-02f, -4.24694754e-02f, -8.09749663e-02f, 8.58629197e-02f, 5.68905137e-02f,
  5.92953935e-02f, -7.74938911e-02f, 4.35736515e-02f, -6.28330708e-02f, -7.04349056e-02f, -7.51321241e-02f, 3.46044451e-02f, 1.66388229e-02f, 7.41341114e-02f, -3.95995528e-02f,
  1.91212490e-01f, -4.01289091e-02f, -2.72728622e-01f, -1.68618098e-01f, -2.33615637e-01f, -1.90852553e-01f, -2.29721263e-01f, -1.36107713e-01f, 9.82239768e-02f, 3.60910632e-02f,
  2.57412717e-02f, 1.36205733e-01f, 9.72825214e-02f, -4.51078489e-02f, 1.40075728e-01f, 2.77205139e-01f, -1.21973781e-02f, -3.06625850e-02f, -3.99682000e-02f, -4.50302362e-02f,
  8.22871551e-02f, -8.19544718e-02f, -4.27730707e-03f, -1.42639384e-01f, -2.26518586e-01f, -9.13096443e-02f, -6.34580199e-03f, -1.36682004e-01f, -1.85265109e-01f, -4.37518209e-02f,
  -8.61358121e-02f, -4.23725061e-02f, -8.67502019e-02f, -2.29014978e-02f, -5.43558896e-02f, -3.23176337e-03f, 8.90449993e-03f, 8.94922356e-04f, -1.26453787e-02f, -6.19215630e-02f,
  7.25905299e-02f, 7.73316771e-02f, 6.74472973e-02f, -5.97737730e-03f, 3.35819051e-02f, -1.54682621e-01f, -5.44710308e-02f, -3.08296029e-02f, -4.62069586e-02f, -2.20705681e-02f,
  -5.52811325e-02f, 2.87251826e-02f, -6.64982125e-02f, -9.82167013e-03f, -5.16362675e-02f, 5.85354539e-03f, 1.35223895e-01f, 4.13141474e-02f, -4.76605631e-02f, -1.64295407e-03f,
  -2.23675277e-03f, 3.89437340e-02f, 8.09092599e-05f, -4.68225293e-02f, -1.00740209e-01f, 1.56656746e-02f, -7.10465899e-03f, -2.52785552e-02f, -2.06596795e-02f, 5.24019115e-02f,
  5.34152240e-02f, -6.70181736e-02f, 5.63003495e-03f, 2.58697029e-02f, 7.65568241e-02f, -8.36502295e-03f, 4.89964597e-02f, -5.11706695e-02f, -1.99629739e-02f, -1.85594559e-02f,
  -3.48392762e-02f, -1.91776715e-02f, -3.24741192e-02f, 4.28710729e-02f, -9.24043544e-03f, 4.30619391e-03f, -3.70566570e-03f, -3.13695229e-04f, 1.59309171e-02f, -5.86340018e-02f,
  6.13084659e-02f, -6.86919913e-02f, 5.44196330e-02f, 8.53941664e-02f, 5.32629862e-02f, 5.91468289e-02f, -1.73764024e-02f, -9.01001021e-02f, -5.00359721e-02f, 6.84725046e-02f,
  -1.63711552e-02f, -3.40485722e-02f, 3.81552130e-02f, 2.37138271e-02f, 5.32518281e-03f, 5.16018867e-02f, -1.48704713e-02f, 2.78116725e-02f, -3.60221490e-02f, 6.33662194e-02f,
  4.58677635e-02f, 7.43920058e-02f, 5.40273041e-02f, 5.25044575e-02f, -2.69096773e-02f, 4.48321365e-02f, 9.08748619e-03f, -6.40324131e-02f, 3.18594947e-02f, 2.07413323e-02f,
  -8.84143859e-02f, 3.58041786e-02f, -1.86904311e-01f, -7.33476281e-02f, -1.56284168e-01f, -4.71728891e-02f, -5.97191788e-02f, -6.48613796e-02f, 7.93421045e-02f, 4.85802218e-02f,
  8.36126953e-02f, 5.69626167e-02f, 1.08771004e-01f, -3.36921848e-02f, 7.14501515e-02f, 6.00501373e-02f, 5.37855923e-03f, 1.76566336e-02f, -7.02643991e-02f, -1.66349672e-02f,
  -2.27238275e-02f, -3.29383314e-02f, -3.16647328e-02f, -8.97579864e-02f, -3.66827138e-02f, -6.00072071e-02f, 9.43630785e-02f, -1.20530099e-01f, -1.01794265e-01f, -1.98360309e-02f,
  -1.30691856e-01f, -7.36255869e-02f, -9.57423747e-02f, 8.07204843e-02f, 2.89175753e-02f, -2.26188102e-03f, -2.06169859e-02f, 2.98853125e-02f, 3.67748216e-02f, -3.05816997e-03f,
  7.66904801e-02f, -6.22216575e-02f, -1.92641802e-02f, 3.56332399e-02f, -7.50167808e-03f, -7.52073377e-02f, 6.27537519e-02f, -7.15731159e-02f, -5.41571248e-03f, -9.58175510e-02f,
  -7.35788122e-02f, -3.70608903e-02f, -2.56386437e-02f, -1.48652513e-02f, 9.24803838e-02f, 8.38866364e-03f, -3.59312706e-02f, 3.18982676e-02f, -7.13828206e-02f, 2.03880537e-02f,
  -6.80960640e-02f, -7.00750798e-02f, -6.54071793e-02f, 3.78663503e-02f, -9.35250297e-02f, -2.62956694e-02f, 5.46170734e-02f, -3.22098173e-02f, -8.12606663e-02f, 3.97016443e-02f,
  -4.84996401e-02f, 1.84707232e-02f, -3.96891609e-02f, -1.86328106e-02f, -4.72788699e-02f, -3.97527441e-02f, -4.45762798e-02f, -6.91534281e-02f, 5.60545847e-02f, 6.60877153e-02f,
  8.70371014e-02f, -5.51118664e-02f, -6.33453801e-02f, 2.60840356e-02f, -5.01283519e-02f, -2.44746655e-02f, 3.18685509e-02f, -2.80951969e-02f, -6.24856725e-02f, -3.07169668e-02f,
  -8.45264047e-02f, -1.40537098e-01f, -5.16310669e-02f, 1.85026880e-02f, -9.26692486e-02f, 8.25546086e-02f, -6.10641837e-02f, -6.01978861e-02f, -4.05147411e-02f, 1.08729973e-02f,
  -1.55387940e-02f, 5.21734469e-02f, 5.50633147e-02f, 4.66850735e-02f, -5.87559082e-02f, -4.18157056e-02f, 3.62774394e-02f, -5.71344681e-02f, -8.21942613e-02f, -6.14471920e-02f,
  -5.03714234e-02f, -7.15281144e-02f, -4.47275303e-02f, 4.28364612e-02f, -3.98336612e-02f, -5.77365700e-03f, 9.70539525e-02f, 6.27875626e-02f, 1.59922168e-02f, 1.15628692e-03f,
  -9.40397084e-02f, 1.37418926e-01f, 3.30019221e-02f, 2.81311385e-02f, -8.69922042e-02f, -2.30956584e-01f, -1.54484943e-01f, 1.11827090e-01f, 9.13141295e-03f, -6.62665591e-02f,
  -7.21998885e-02f, 2.93337181e-02f, 9.84775349e-02f, -4.48789559e-02f, -1.19305462e-01f, 1.34965107e-02f, -8.98892432e-02f, -7.28269443e-02f, -4.06916179e-02f, 1.17882632e-01f,
  8.30617473e-02f, 5.18772751e-02f, 4.75530662e-02f, 1.10198654e-01f, 4.34119217e-02f, 4.61399890e-02f, 1.86976120e-01f, 1.69016927e-01f, -3.30572762e-03f, 5.89044280e-02f,
  -1.99238099e-02f, 1.24004737e-01f, 9.40160751e-02f, 1.50211221e-02f, 5.07405438e-02f, 2.95798816e-02f, -7.44003104e-03f, -6.33183345e-02f, -3.54679972e-02f, 4.69496213e-02f,
  -5.89910597e-02f, 3.07485908e-02f, -1.33535755e-03f, 2.95063760e-03f, -2.62325983e-02f, 8.32689181e-02f, -8.87833387e-02f, -2.43044831e-03f, 5.98122273e-03f, 1.24869887e-02f,
  4.79508117e-02f, -9.33279321e-02f, -6.48418888e-02f, -3.49744968e-02f, 2.28479076e-02f, 4.43679420e-03f, -7.50981048e-02f, 7.45837167e-02f, -4.56627645e-02f, 4.00207341e-02f,
  1.52689982e-02f, -4.43682447e-02f, 1.07651036e-02f, -3.72831821e-02f, -8.21430385e-02f, -1.11177173e-02f, 6.31206483e-02f, -4.64202836e-02f, 7.89962634e-02f, 7.96597153e-02f,
  -7.64428899e-02f, 5.20920902e-02f, 1.04163485e-02f, 3.52998488e-02f, 2.21190304e-02f, 4.68150862e-02f, 3.53754684e-02f, -1.13400468e-03f, -4.23414744e-02f, 5.63643761e-02f,
  6.31227046e-02f, -6.18999042e-02f, -5.63680846e-03f, -1.81182250e-02f, -1.82993878e-02f, -1.91930998e-02f, 8.91327709e-02f, -5.65922447e-02f, 4.65643592e-02f, -1.24733724e-01f,
  -1.83779597e-02f, 1.86813608e-01f, -1.94869284e-03f, -8.13841373e-02f, -1.59836598e-02f, -8.52366388e-02f, -6.88151419e-02f, -4.65172380e-02f, -2.81416178e-02f, 6.78891987e-02f,
  -3.67813595e-02f, -7.21981302e-02f, -3.75866257e-02f, 8.23525861e-02f, 4.80759293e-02f, 5.00702150e-02f, 5.98635785e-02f, 1.82865951e-02f, -1.61951575e-02f, 7.77283460e-02f,
  6.09811805e-02f, -5.63996248e-02f, 1.02264702e-03f, 5.56223746e-03f, -5.19374050e-02f, -5.05948886e-02f, 6.85102865e-02f, -6.78869942e-03f, 4.28402238e-02f, 7.02208281e-02f,
  1.60091102e-01f, -1.25795230e-01f, 5.90818003e-02f, 2.61504501e-02f, 6.85062185e-02f, -4.68623936e-02f, 8.35779607e-02f, -1.15056723e-01f, 4.73538749e-02f, -1.38790727e-01f,
  6.45268522e-03f, 3.98238301e-02f, -3.15817520e-02f, 2.19173869e-03f, 1.96530178e-01f, -8.72257650e-02f, 8.48535746e-02f, -3.61137241e-02f, 9.22985282e-03f, 5.08458167e-02f,
  7.78860226e-02f, -2.85805445e-02f, 6.37872191e-03f, -1.11667976e-01f, 1.06649706e-02f, -5.86386882e-02f, 1.81822870e-02f, -5.46018444e-02f, -8.50335285e-02f, 8.87852535e-02f,
  -2.53461413e-02f, 5.08381166e-02f, 2.06666011e-02f, -1.68139562e-02f, -1.47897052e-02f, -5.49716875e-02f, 8.01122412e-02f, -4.74975295e-02f, 5.59574030e-02f, -1.25808399e-02f,
  -1.11972928e-01f, 4.47273552e-02f, 6.01358488e-02f, 2.64675114e-02f, 3.10010966e-02f, 4.39941362e-02f, 3.90504822e-02f, -7.75747607e-03f, -8.84036273e-02f, -4.65493836e-02f,
  1.15414970e-02f, -7.47794136e-02f, -5.03529273e-02f, -3.63562256e-02f, -1.82706378e-02f, -7.93965980e-02f, -5.22086471e-02f, -7.08515244e-03f, -2.82511190e-02f, -1.32998107e-02f,
  -9.93804559e-02f, 5.15654981e-02f, -3.07575092e-02f, 4.54830006e-02f, 5.06151281e-02f, 1.00359255e-02f, -5.18814363e-02f, 7.57059380e-02f, -9.27897729e-03f, 4.03957963e-02f,
  -7.35766394e-03f, -1.76842622e-02f, -7.72203971e-03f, -8.07279197e-04f, -6.23694956e-02f, -4.48054308e-03f, -5.60845397e-02f, -9.65933222e-03f, 1.08423934e-03f, 6.87076226e-02f,
  1.13608846e-02f, -4.02077176e-02f, 4.17376086e-02f, -5.63764609e-02f, 8.97072721e-03f, 7.47602507e-02f, 4.44111973e-02f, 1.59426779e-02f, -1.66417174e-02f, -5.54467849e-02f,
  -1.01736329e-01f, -1.08481877e-01f, 4.46181931e-02f, -7.04506338e-02f, -5.50103188e-02f, 6.38336986e-02f, 5.20256348e-02f, -2.20158119e-02f, -1.51046924e-02f, 5.11082411e-02f,
  -4.83775921e-02f, 7.33268335e-02f, 3.33801471e-02f, 8.30559060e-02f, -5.51949255e-02f, -7.47874677e-02f, 3.69613767e-02f, -7.93646351e-02f, -3.91348489e-02f, -7.50830770e-02f,
  -6.99216649e-02f, 3.16319684e-03f, -3.31505231e-04f, 2.97360271e-02f, 4.83811200e-02f, -3.03858761e-02f, 5.91057092e-02f, 2.20503900e-02f, 8.22158679e-02f, -2.64261551e-02f,
  -1.33669734e-01f, 8.68305117e-02f, -8.44703764e-02f, 8.28165635e-02f, -1.07574947e-01f, -2.47302894e-02f, 1.11966789e-01f, -3.14538293e-02f, 1.08796380e-01f, 9.21524987e-02f,
  -6.59463927e-02f, 5.86023703e-02f, -4.44607548e-02f, 4.74450327e-02f, 2.03718673e-02f, 2.22754125e-02f, 2.86242850e-02f, 3.32431756e-02f, 8.13405812e-02f, -5.29362857e-02f,
  -8.42844471e-02f, -5.53428661e-04f, 3.58689167e-02f, -2.35268679e-02f, -5.58156632e-02f, -8.97265673e-02f, -7.54311457e-02f, -1.62974074e-02f, -7.36179054e-02f, -4.99531478e-02f,
  7.38117471e-03f, -8.77216607e-02f, -6.15502857e-02f, 1.59052797e-02f, 2.81215943e-02f, 6.94358870e-02f, -4.96645570e-02f, -8.25377405e-02f, 1.45987505e-02f, -4.77106012e-02f,
  3.79684977e-02f, -8.51061270e-02f, -5.17896488e-02f, -3.55945043e-02f, 9.23516229e-02f, 4.94269170e-02f, -5.05852625e-02f, -5.27722016e-02f, 8.52803588e-02f, 3.97983529e-02f,
  -2.72361152e-02f, -7.50381425e-02f, -5.84909366e-03f, 4.19755019e-02f, -5.56718037e-02f, -6.21138550e-02f, 6.37937784e-02f, 2.61303633e-02f, 6.16848879e-02f, -6.94523007e-02f,
  4.73692305e-02f, 6.71580806e-02f, -1.44583099e-02f, -3.29438336e-02f, -7.70822018e-02f, 4.13498096e-02f, -7.66145661e-02f, 6.90688416e-02f, -2.67504044e-02f, -7.84597099e-02f,
  -2.83220015e-03f, 2.17034351e-02f, -3.33931595e-02f, 4.43209745e-02f, 1.34052038e-02f, -5.81662636e-03f, -5.57433292e-02f, -3.25297080e-02f, 7.13876449e-03f, 5.59660532e-02f,
  -1.59173533e-02f, 3.13422121e-02f, -6.65215924e-02f, 4.65620011e-02f, 6.18612207e-02f, -6.96910694e-02f, -6.03170693e-02f, -7.18096718e-02f, 1.38357338e-02f, -7.46847540e-02f,
  -8.32745582e-02f, 7.06169605e-02f, 7.29065239e-02f, 2.49768570e-02f, -4.51272577e-02f, -3.33324564e-03f, -4.89897877e-02f, -1.35231130e-02f, -6.90726489e-02f, 6.57438189e-02f,
  7.47155026e-02f, 5.97780459e-02f, 5.98761030e-02f, -6.25270680e-02f, -8.02432001e-02f, 1.06595848e-02f, -6.85710907e-02f, 5.55331036e-02f, 6.23189248e-02f, -7.69578218e-02f,
  7.59570897e-02f, 6.06647432e-02f, -4.20181155e-02f, 1.39170615e-02f, 1.77233778e-02f, 5.36399856e-02f, -3.00505906e-02f, 6.64606690e-02f, -5.23734018e-02f, 2.39003003e-02f,
  1.32758468e-01f, 3.73674817e-02f, -1.98689878e-01f, 4.93897125e-02f, 8.46517831e-02f, 2.75322646e-02f, 5.46082295e-02f, 8.67775232e-02f, -7.27594048e-02f, 6.29976317e-02f,
  8.58785510e-02f, -3.14762741e-02f, -9.88135263e-02f, 1.47654966e-01f, 2.07523048e-01f, -1.69194415e-02f, 1.94709361e-01f, 7.14736879e-02f, 3.52982841e-02f, -7.56095489e-03f,
  1.23767490e-02f, 2.08079278e-01f, -1.14237867e-01f, 6.22666478e-02f, 9.44306701e-02f, -4.84357774e-02f, -3.69541161e-02f, -1.56431198e-01f, 1.03026859e-01f, 1.31368592e-01f,
  6.76233545e-02f, -2.32080370e-02f, -4.62365709e-02f, -2.46375147e-02f, -9.51053016e-03f, 5.96955828e-02f, 4.12821025e-02f, -3.58749591e-02f, -6.95491061e-02f, 3.49553674e-02f,
  4.38267477e-02f, 2.17845626e-02f, 4.83441651e-02f, -2.51915678e-02f, 9.11270306e-02f, 4.18371670e-02f, -1.01119071e-01f, -2.21213959e-02f, 5.23714174e-04f, 3.43720987e-02f,
  4.24024798e-02f, 9.97420475e-02f, 6.80854619e-02f, -2.42929570e-02f, -7.14773014e-02f, -5.83507419e-02f, 4.19862084e-02f, -5.82499728e-02f, 5.26148714e-02f, 9.77622420e-02f,
  -1.13079287e-02f, 1.78373884e-02f, 3.02135609e-02f, 9.14388299e-02f, -4.35410552e-02f, -1.15046866e-01f, -4.58605355e-03f, 4.24876204e-03f, -5.47595434e-02f, -3.15861553e-02f,
  -1.46391625e-02f, -9.10299867e-02f, -3.15981917e-02f, 1.03539415e-02f, 3.01382076e-02f, -1.69538725e-02f, -6.10081628e-02f, 2.69148592e-02f, -8.27650055e-02f, 2.13396978e-02f,
  1.64532231e-03f, -6.70099556e-02f, 3.75097170e-02f, 6.07070513e-03f, -5.85828573e-02f, -2.77154278e-02f, -9.64990875e-04f, 5.88393994e-02f, 3.86528969e-02f, 5.65842539e-02f,
  1.08566664e-01f, 5.92522547e-02f, -1.32836979e-02f, 6.55818582e-02f, -9.00335312e-02f, -1.43509973e-02f, 7.91722685e-02f, 9.04649124e-02f, 5.30200861e-02f, -5.08157797e-02f,
  -1.39001748e-02f, -3.54354307e-02f, 8.49764273e-02f, -1.83872469e-02f, -2.84711719e-02f, -2.41296627e-02f, -3.63834612e-02f, -7.41160437e-02f, -1.62162408e-02f, -6.93455935e-02f,
  -8.75613838e-03f, -8.57470334e-02f, 2.04892103e-02f, -7.15456679e-02f, 3.27257663e-02f, 5.21513857e-02f, 7.03033572e-03f, 8.83343592e-02f, -2.20778957e-02f, 4.48101386e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.14221208e-01f, -9.79405176e-03f, -7.80023187e-02f, -2.86051407e-02f, 1.30148143e-01f, 1.12972111e-01f, 4.82032113e-02f, -2.21379250e-02f, -2.35865675e-02f, -3.44164521e-02f,
  9.41645503e-02f, 4.99515682e-02f, 5.18578850e-02f, 2.78953221e-02f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  4.75735627e-02f, -6.39035478e-02f, 8.64309445e-02f, 2.65876260e-02f, -1.46107301e-02f, 3.48201245e-02f, -1.43544346e-01f, -3.15855779e-02f, 1.09858342e-01f, -1.03767835e-01f,
  7.40019307e-02f, 1.01052441e-01f, -4.52523232e-02f, 9.66288969e-02f, 7.44833751e-03f, 6.81277886e-02f, 1.37030929e-01f, -9.96469185e-02f, 1.24499917e-01f, -6.55248463e-02f,
  -1.92867711e-01f, -9.47228372e-02f, 3.33348699e-02f, -9.57507864e-02f, -1.07507668e-01f, 1.77671507e-01f, 3.00128888e-02f, -2.88590100e-02f, 3.46583985e-02f, 9.30575933e-03f,
  9.77984071e-02f, 3.01493779e-02f, -5.50024025e-02f, -6.35081679e-02f, -1.29919976e-01f, -1.13451108e-01f, 1.27529442e-01f, 1.45368360e-03f, 1.44027933e-01f, 8.05052668e-02f,
  -2.03049213e-01f, -9.11809057e-02f, -3.36519927e-02f, -1.88811749e-01f, -3.63502242e-02f, -2.29416355e-01f, -1.00759305e-02f, -4.21213135e-02f, -6.94942474e-02f, -1.65799856e-01f,
  2.49836762e-02f, -5.25882058e-02f, -1.04518212e-01f, 1.57257065e-01f, 3.71281728e-02f, 1.48931578e-01f, 9.50477570e-02f, -6.58615679e-02f, -1.76142789e-02f, -5.63849099e-02f,
  1.06099024e-01f, 1.77743360e-01f, -3.53771895e-02f, 1.18148548e-03f, -9.20956023e-03f, 1.33918584e-05f, 4.18672934e-02f, -1.28654331e-01f, -7.46996105e-02f, 1.11906655e-01f,
  -1.11056305e-01f, 1.01474427e-01f, -1.14475980e-01f, -7.95423836e-02f, -8.22177157e-02f, 9.17693079e-02f, -1.55169228e-02f, -1.38973698e-01f, -1.71498209e-01f, 1.12454630e-01f,
  -1.62543535e-01f, 6.84578568e-02f, -3.22324559e-02f, 4.39616926e-02f, -8.92202631e-02f, 4.11179885e-02f, 9.21641961e-02f, -1.38079181e-01f, 8.85475725e-02f, 9.31776017e-02f,
  5.33801802e-02f, -1.21849410e-01f, -1.61239848e-01f, 5.50362468e-02f, 1.07543066e-01f, -1.87043965e-01f, 5.19583151e-02f, 2.09424958e-01f, 3.87057886e-02f, 1.05233736e-01f,
  1.79345578e-01f, 2.35121742e-01f, 1.70786120e-02f, 3.70399430e-02f, 1.52938262e-01f, -1.96288005e-01f, -4.74759676e-02f, 1.53978512e-01f, -2.04611957e-01f, 2.13428233e-02f,
  1.96181521e-01f, 1.50819778e-01f, 2.48023588e-02f, 7.46643022e-02f, 4.69416007e-02f, -3.01977955e-02f, 1.37209073e-01f, -1.27223134e-01f, 1.84263200e-01f, -2.71472007e-01f,
  -3.65696885e-02f, -1.18441433e-02f, 1.58811003e-01f, 8.16926509e-02f, -8.76762904e-03f, -3.88464779e-02f, 1.80752993e-01f, -1.23145171e-01f, 8.33886862e-02f, -2.56762356e-02f,
  -4.43640463e-02f, -1.13520538e-02f, 4.46169227e-02f, -1.58833507e-02f, -2.15817168e-02f, 2.93831956e-02f, -7.35062659e-02f, -6.81013390e-02f, -1.10727940e-02f, -3.65345292e-02f,
  -5.69693930e-03f, -2.26769168e-02f, -9.82863978e-02f, -2.23259479e-01f, -1.04442723e-02f, -4.47958298e-02f, -9.94538218e-02f, 7.32485205e-02f, 1.63331684e-02f, -6.06294386e-02f,
  -2.59179752e-02f, -1.66282505e-01f, -3.52003574e-02f, 1.11658812e-01f, -1.79073513e-01f, -8.51480588e-02f, 2.58367598e-01f, 7.60841370e-02f, -3.22676569e-01f, -1.65923476e-01f,
  -3.57607827e-02f, 3.41245979e-02f, -9.15794745e-02f, 2.69135803e-01f, 1.23097450e-01f, 8.27726051e-02f, -3.18235084e-02f, -1.08079366e-01f, -3.28710787e-02f, 2.45875984e-01f,
  -2.17155024e-01f, -3.98872979e-02f, 8.01860541e-02f, -1.04830950e-01f, 2.06658512e-01f, 2.44366571e-01f, 2.62181699e-01f, -8.94904360e-02f, -6.58759475e-02f, -1.45157631e-02f,
  3.72527316e-02f, 1.04729673e-02f, -1.52386233e-01f, 1.47383481e-01f, 1.35535792e-01f, 1.58168003e-01f, 1.17367782e-01f, 7.51588792e-02f, 3.08293067e-02f, 3.66876051e-02f,
  7.06151547e-03f, 1.61890149e-01f, 1.43646728e-02f, -1.71437673e-03f, -1.32677808e-01f, -9.93118733e-02f, 1.34228796e-01f, 5.65847941e-03f, -1.85605228e-01f, 1.83393329e-01f,
  1.68544993e-01f, -1.32979512e-01f, 5.49543314e-02f, -7.19160438e-02f, 4.18002233e-02f, -7.13777617e-02f, 9.86897051e-02f, -1.83406249e-01f, 1.23911621e-02f, -2.94334963e-02f,
  -1.55639369e-02f, -3.97188403e-02f, 3.33287641e-02f, 3.47871929e-02f, -1.38229385e-01f, -1.24949381e-01f, 1.33730307e-01f, -2.15519685e-02f, 7.07866549e-02f, -5.77255897e-02f,
  1.85109660e-01f, -6.42677844e-02f, -2.77174205e-01f, 9.67857987e-02f, -5.11060432e-02f, -1.82305779e-02f, -1.62729695e-01f, 3.35635804e-02f, 1.60904359e-02f, 1.03745177e-01f,
  -3.82215977e-02f, -1.90644816e-01f, 2.44774073e-02f, 1.67608216e-01f, 3.67653207e-03f, 1.28242701e-01f, 1.36787547e-02f, 8.96614492e-02f, 1.18455559e-01f, 3.11348617e-01f,
  2.47470096e-01f, -8.42473060e-02f, 4.11007367e-02f, 1.52289331e-01f, 1.49911374e-01f, -4.53258120e-02f, -3.48606184e-02f, -4.73454855e-02f, 1.45898402e-01f, 1.67817056e-01f,
  1.27585635e-01f, 1.49231022e-02f, 1.15945153e-01f, -2.91008502e-02f, -4.20088880e-02f, 1.83440432e-01f, 4.91850898e-02f, -1.71335056e-01f, 6.55791685e-02f, -5.35094785e-03f,
  7.26905391e-02f, -3.51928622e-02f, 1.21295668e-01f, -9.48679373e-02f, -5.96916340e-02f, 9.30117443e-02f, -8.05799142e-02f, -1.37984142e-01f, 2.19758786e-02f, 1.00071318e-01f,
  -1.15757687e-02f, 8.86484887e-03f, -3.10259499e-03f, -1.07024044e-01f, -1.37639463e-01f, -1.88607611e-02f, 1.39004979e-02f, 8.87992457e-02f, 8.01610202e-02f, 6.38734102e-02f,
  8.17458406e-02f, -8.73006433e-02f, 1.03762805e-01f, 9.10267085e-02f, 1.68236911e-01f, -2.30876193e-03f, 5.85933328e-02f, 8.59095901e-02f, 2.03111786e-02f, 2.64821742e-02f,
  1.72946945e-01f, -2.10395958e-02f, -9.46149006e-02f, 5.49805760e-02f, -1.99011996e-01f, 2.32771724e-01f, -1.07494198e-01f, -2.92411484e-02f, 1.15755007e-01f, 4.15005870e-02f,
  -6.51834682e-02f, 1.44165739e-01f, -1.06105112e-01f, -6.71973974e-02f, 4.79484312e-02f, 2.77038485e-01f, -3.53604817e-04f, -7.81117454e-02f, -6.34005144e-02f, -1.87278371e-02f,
  -2.08087191e-01f, -3.47098112e-02f, 1.56482924e-02f, 7.31370598e-02f, -1.00641035e-01f, -1.51159391e-02f, -9.21331495e-02f, 8.82030278e-02f, 1.80740897e-02f, 7.09197372e-02f,
  -2.05679163e-02f, 1.40589297e-01f, -1.16551027e-01f, 3.71657475e-03f, -5.46894260e-02f, 2.92727333e-02f, 1.08878717e-01f, -9.11670327e-02f, -5.11725992e-02f, 2.89777182e-02f,
  -1.89456786e-03f, 2.08758600e-02f, 1.56279933e-02f, 6.52537942e-02f, 1.18220069e-01f, -1.23746917e-02f, 1.50399050e-02f, -1.18377265e-02f, -1.07733555e-01f, 1.25804380e-01f,
  -6.92375451e-02f, -8.09148028e-02f, 2.79481057e-02f, 2.46631149e-02f, 1.13260463e-01f, 2.41036415e-02f, -1.66095838e-01f, 2.36779854e-01f, 2.08504274e-01f, 1.76992878e-01f,
  -8.71384889e-02f, 1.82505175e-02f, -9.69815627e-02f, -3.29244316e-01f, -8.65190173e-04f, -1.41872941e-02f, -7.76789337e-02f, -2.43479759e-01f, -1.21603876e-01f, -7.36063942e-02f,
  -3.05146370e-02f, 1.31842732e-01f, 1.38161974e-02f, -4.86409664e-02f, 2.48166591e-01f, -2.65719593e-02f, -1.96665645e-01f, 7.77210593e-02f, -2.24295203e-02f, 1.19159326e-01f,
  -5.34727760e-02f, -1.95511475e-01f, 9.51395184e-02f, 9.84577984e-02f, -1.84005126e-01f, 1.84056148e-01f, 1.18274577e-01f, -9.13764164e-02f, 1.32998675e-01f, -7.41728842e-02f,
  -1.45361960e-01f, 1.75983965e-01f, -2.16563605e-02f, 9.26747173e-03f, 7.66623840e-02f, -7.99771696e-02f, 1.65270284e-01f, 1.29675657e-01f, 2.06387881e-02f, 1.21427037e-01f,
  1.30578011e-01f, -4.14963216e-02f, -8.61428753e-02f, 1.37027651e-01f, 1.07050680e-01f, 1.50308199e-02f, -4.28305968e-04f, 1.85818836e-01f, -1.88929394e-01f, 1.84293598e-01f,
  9.88366231e-02f, 2.01419756e-01f, -8.08836445e-02f, -1.20841134e-02f, 7.87295029e-02f, 9.70585197e-02f, 1.68844745e-01f, 5.79357967e-02f, 7.76733533e-02f, -1.39012113e-01f,
  2.92294882e-02f, 3.68984230e-02f, -1.14779554e-01f, 1.56967878e-01f, 1.38281718e-01f, -5.55900373e-02f, -2.30136625e-02f, -6.00826880e-03f, 1.69629112e-01f, -1.68961152e-01f,
  2.78700609e-02f, 1.08201280e-01f, 5.71258068e-02f, 1.76267341e-01f, 8.54195505e-02f, -4.17526700e-02f, -1.42836154e-01f, -4.07964066e-02f, -2.21644461e-01f, 1.89500019e-01f,
  -5.38385026e-02f, 2.17337105e-02f, -1.62681893e-01f, -1.06671527e-01f, -1.25356708e-02f, -8.12224224e-02f, 7.20771253e-02f, -4.37679403e-02f, 7.17351809e-02f, -9.65486392e-02f,
  -1.17992960e-01f, -3.12744863e-02f, -7.95310885e-02f, -1.49819478e-02f, 1.13037139e-01f, 8.96749422e-02f, 1.35899018e-02f, -9.93671715e-02f, 9.28766932e-03f, -1.84143335e-01f,
  8.81693214e-02f, -1.94637384e-02f, -7.34718069e-02f, 1.18875755e-02f, -2.96746735e-02f, -1.12764768e-01f, -5.16889878e-02f, 4.70038597e-03f, -1.16079273e-02f, 1.77076198e-02f,
  6.33450076e-02f, 1.07744314e-01f, -1.42780766e-01f, 8.81072655e-02f, 3.11963912e-02f, 6.42022640e-02f, -4.01142947e-02f, 1.37166291e-01f, 1.02031343e-01f, -1.38564169e-01f,
  -3.80982034e-04f, -1.18630931e-01f, -3.84291112e-02f, -1.23633686e-02f, -4.79216948e-02f, -2.47948050e-01f, -1.49532184e-01f, 1.28174648e-01f, 2.58062661e-01f, -3.72660831e-02f,
  7.96262398e-02f, 4.59813848e-02f, 1.12959007e-02f, 3.11567020e-02f, 8.73459652e-02f, 1.05214439e-01f, 6.70830235e-02f, -9.25500970e-03f, 1.41252086e-01f, -2.49649044e-02f,
  -1.09859288e-01f, -6.89527467e-02f, -1.16610944e-01f, 1.52948871e-01f, 1.36939138e-01f, -2.53782328e-02f, -1.56795502e-01f, -1.46768317e-01f, 1.35202378e-01f, -1.92420278e-02f,
  -9.65016708e-02f, -3.28440815e-02f, 2.95950323e-02f, -7.47902915e-02f, -1.97950572e-01f, -5.69976903e-02f, 1.47293970e-01f, 4.75125536e-02f, -1.02029145e-02f, 9.89078209e-02f,
  -5.34401014e-02f, 9.64312255e-03f, 1.09668247e-01f, 5.53613864e-02f, 6.27846271e-03f, -6.04701117e-02f, -5.71070313e-02f, -4.79550362e-02f, -1.01672791e-01f, -1.06220320e-01f,
  1.51836863e-02f, -2.84404252e-02f, 1.02476180e-01f, 7.81696662e-02f, -4.73179072e-02f, -8.33080783e-02f, 1.29241318e-01f, -1.69359490e-01f, 9.89391506e-02f, -1.17172621e-01f,
  2.28898510e-01f, -1.15550280e-01f, 2.99328417e-02f, -2.51722690e-02f, -1.05843633e-01f, 1.62937909e-01f, -2.44686864e-02f, 8.87805223e-02f, 1.54577523e-01f, -1.42979585e-02f,
  8.68193731e-02f, -4.01053987e-02f, -1.27907306e-01f, 1.47422254e-01f, -1.30253926e-01f, -5.18459417e-02f, -4.05794196e-02f, 8.51293057e-02f, 9.62126553e-02f, 1.37846008e-01f,
  2.12628856e-01f, -2.17782587e-01f, -2.66704559e-02f, 6.31626174e-02f, 1.91401877e-02f, 2.25913730e-02f, -9.58669409e-02f, -2.81675994e-01f, 5.58594652e-02f, 1.56492725e-01f,
  7.47154951e-02f, -2.42139876e-01f, -1.72084421e-01f, -3.96327376e-02f, -6.48224205e-02f, 8.31966326e-02f, 8.78525004e-02f, 1.39520958e-01f, 1.89791992e-02f, -1.45424576e-02f,
  -1.46222323e-01f, -1.01964429e-01f, 9.13824234e-03f, 4.04348448e-02f, 5.59705161e-02f, 1.18200034e-02f, -2.40115868e-03f, -1.03966095e-01f, -1.54705290e-02f, -3.96514274e-02f,
  1.04640098e-02f, -1.63537636e-02f, 1.71900988e-01f, -6.59319684e-02f, 6.44039810e-02f, 9.94146056e-03f, -1.17706507e-02f, 1.50906411e-03f, 5.26521169e-02f, 6.47169584e-03f,
  -1.51573718e-01f, 1.53709799e-01f, 2.31859386e-02f, 7.78068602e-02f, -8.85733366e-02f, 1.44889668e-01f, 1.08047582e-01f, 9.06636380e-03f, 1.69832874e-02f, -1.64254293e-01f,
  1.32469311e-01f, -2.12400574e-02f, -1.13924079e-01f, -1.48011386e-01f, -1.30896896e-01f, -3.56655717e-02f, 1.41961828e-01f, -1.63113534e-01f, 1.09495103e-01f, 2.08060071e-01f,
  2.19442472e-02f, 5.24530411e-02f, 5.63604943e-02f, -5.92720285e-02f, -2.45289743e-01f, 1.36118025e-01f, 1.89836323e-02f, 1.54423863e-01f, -3.05313952e-02f, -1.05525665e-02f,
  5.22993058e-02f, 2.58237749e-01f, 8.34549312e-03f, -4.50955555e-02f, 6.69924021e-02f, 7.23663718e-02f, -6.21822756e-03f, -6.17036931e-02f, 2.84955297e-02f, -6.49069548e-02f,
  -1.23137079e-01f, -2.66941655e-02f, -9.12661254e-02f, 7.66909122e-02f, -7.59834936e-03f, -6.80604950e-02f, 9.03825015e-02f, -5.21221459e-02f, 5.36798202e-02f, 3.67722623e-02f,
  1.54549172e-02f, 5.45580871e-02f, -1.44590855e-01f, -8.28917399e-02f, 6.60184622e-02f, -2.36457679e-02f, -6.39191121e-02f, -2.81765126e-02f, 1.27458543e-01f, 1.97486848e-01f,
  -6.10971451e-02f, -3.25653702e-02f, 6.74299372e-04f, 5.08998148e-02f, 1.95674166e-01f, -8.69551152e-02f, -4.51415181e-02f, -5.64052090e-02f, -1.07926652e-01f, -1.18212089e-01f,
  -2.09930562e-03f, 7.68534699e-03f, 1.56963035e-01f, -2.47156024e-01f, 1.85183927e-01f, 8.29710215e-02f, -3.83836664e-02f, 1.89941213e-01f, 1.08557776e-01f, 2.51052231e-01f,
  -4.94788587e-02f, -9.37051550e-02f, -2.34281689e-01f, -2.70248175e-01f, -3.51132192e-02f, 1.46857828e-01f, -2.28467751e-02f, -3.56352329e-01f, -4.04670648e-02f, -1.18025001e-02f,
  -1.92210376e-01f, -1.02241095e-02f, 2.75989994e-02f, -1.12194985e-01f, 1.17003866e-01f, 3.93306911e-02f, -6.65335506e-02f, -3.26735638e-02f, 1.35784149e-02f, 1.53722301e-01f,
  8.66688862e-02f, -1.51392967e-01f, 5.74842058e-02f, 8.18103924e-02f, 2.66042948e-02f, 2.19232708e-01f, 1.01633161e-01f, 1.30573079e-01f, 2.04905435e-01f, 2.09441353e-02f,
  -1.76624745e-01f, 1.54513761e-01f, -4.09313757e-03f, 1.79143488e-01f, -3.26343812e-02f, 3.20943668e-02f, 5.32837771e-02f, 8.80084857e-02f, 3.82506251e-02f, 1.06410637e-01f,
  -6.30844831e-02f, -4.16480610e-03f, 4.24017459e-02f, -1.40798792e-01f, -1.03929184e-01f, -8.23133718e-03f, -4.08017002e-02f, -1.06705591e-01f, 5.16826287e-02f, 1.10087872e-01f,
  -6.88412860e-02f, -5.47124706e-02f, 1.24608397e-01f, 8.92377421e-02f, 1.39193028e-01f, 1.16173647e-01f, -2.10879460e-01f, 1.21970460e-01f, -1.00917965e-02f, -2.33252779e-01f,
  2.04732254e-01f, -1.02566287e-01f, -1.01096138e-01f, -2.92825311e-01f, 9.12932679e-03f, 1.00765785e-04f, 2.08484396e-01f, 2.63647676e-01f, 2.49988567e-02f, 2.71618683e-02f,
  -1.12827241e-01f, 2.71740139e-01f, -4.72258478e-02f, -1.94458008e-01f, 1.06821440e-01f, -2.66952887e-02f, 1.42693952e-01f, 1.44695520e-01f, 4.95082587e-02f, 1.07338749e-01f,
  4.43140939e-02f, -1.83440950e-02f, 1.34323046e-01f, 2.09839530e-02f, 8.49165320e-02f, 8.90223607e-02f, 1.34783024e-02f, -2.66191959e-02f, 7.12260455e-02f, -2.12607235e-01f,
  -6.36469945e-02f, 8.78838003e-02f, -1.90355152e-01f, 6.39425516e-02f, 2.04423778e-02f, -1.48187697e-01f, 1.28146946e-01f, 9.11117494e-02f, -1.37901813e-01f, -1.11353897e-01f,
  1.40420511e-01f, -6.06452376e-02f, -5.52062951e-02f, 7.37795457e-02f, 3.43441069e-02f, 1.05339356e-01f, -4.95883338e-02f, 1.10852264e-03f, -8.89540687e-02f, -1.25760527e-03f,
  -9.04528424e-02f, 7.42806867e-02f, -7.85616636e-02f, 2.22578738e-02f, -1.26725718e-01f, -7.21263885e-02f, -2.09819585e-01f, 4.89111617e-02f, 1.09306714e-02f, -3.53285633e-02f,
  -6.16510175e-02f, -7.73876831e-02f, 1.22359604e-01f, 1.26224533e-01f, -1.02715835e-01f, 1.10973753e-01f, 5.16971610e-02f, -7.46208355e-02f, 1.87236711e-01f, 4.89778584e-03f,
  2.41023183e-01f, 7.07961768e-02f, -8.63412321e-02f, 1.31749153e-01f, -1.40821248e-01f, -1.14426322e-01f, -2.16895435e-02f, 1.57159343e-01f, 8.62333253e-02f, 6.89217895e-02f,
  1.52007550e-01f, -1.20731436e-01f, -7.87418261e-02f, 2.23437637e-01f, -1.16899557e-01f, -5.29849418e-02f, -1.61501333e-01f, 2.79683113e-01f, 1.20366089e-01f, 1.11343779e-01f,
  1.83833595e-02f, -5.63110262e-02f, -2.01734841e-01f, 4.13291529e-02f, -1.32214837e-02f, 2.56392993e-02f, 1.64496496e-01f, 1.41188085e-01f, -6.01356290e-02f, 1.05271630e-01f,
  -3.19178961e-02f, -9.47708115e-02f, -1.87185910e-02f, 5.00705391e-02f, 1.57946721e-02f, 8.62489715e-02f, -1.44395649e-01f, -7.47276656e-03f, 7.78707415e-02f, 1.03608258e-02f,
  -6.22552857e-02f, -1.14965133e-01f, -7.06549957e-02f, 8.68824683e-03f, -6.03848808e-02f, 5.92126474e-02f, 5.96493743e-02f, 4.74319905e-02f, 3.12193832e-03f, -1.13858603e-01f,
  6.09611757e-02f, -7.36849084e-02f, 7.00400844e-02f, -1.35377496e-01f, 1.60639902e-05f, -7.74116069e-02f, -9.74362642e-02f, -1.88537445e-02f, 9.35536772e-02f, -1.01632373e-02f,
  -5.96265607e-02f, 1.15650274e-01f, 7.65584856e-02f, -8.24661106e-02f, -2.12119535e-01f, -7.27517530e-02f, -1.74920186e-02f, 1.67278331e-02f, 3.70038934e-02f, -2.86233407e-02f,
  1.42732322e-01f, -2.15503536e-02f, 1.26776665e-01f, -1.04442410e-01f, -9.93761569e-02f, -1.55662179e-01f, -8.38614926e-02f, -1.49888158e-01f, -9.07409638e-02f, -6.71346113e-02f,
  -1.38405055e-01f, -6.07129224e-02f, -3.10520045e-02f, 1.13156632e-01f, -1.29044324e-01f, 8.12866464e-02f, -2.81022880e-02f, 8.88419077e-02f, -4.02655229e-02f, -1.33982685e-04f,
  -1.25300884e-01f, -7.49327019e-02f, -3.63176912e-02f, 6.46205246e-02f, 4.11661044e-02f, 7.64157670e-03f, 2.69834604e-02f, -1.15398653e-01f, 4.61489670e-02f, -9.44101661e-02f,
  -1.29542220e-02f, -8.66327137e-02f, 9.89721119e-02f, -1.12279654e-01f, -1.73015371e-02f, -8.60553160e-02f, -5.88516369e-02f, -1.55352280e-01f, 2.48664841e-02f, -3.87415551e-02f,
  -1.49026334e-01f, -7.44723901e-02f, -1.18011169e-01f, -9.67618898e-02f, 5.53786829e-02f, 1.66835450e-02f, 1.67202979e-01f, -2.58745402e-02f, -1.19351804e-01f, -1.54042408e-01f,
  4.35318463e-02f, -8.96466002e-02f, 2.29881585e-01f, -1.17327653e-01f, -1.01469807e-01f, -8.92652050e-02f, 5.87954931e-02f, -1.28942102e-01f, 2.30586976e-01f, 2.74589449e-01f,
  -5.08868322e-02f, 1.48174718e-01f, -1.73369497e-01f, 6.48515522e-02f, -3.03565860e-01f, -2.06257850e-01f, 3.18218023e-02f, 6.44937903e-02f, 2.08673831e-02f, 4.05627228e-02f,
  9.58116055e-02f, 1.67833105e-01f, 3.28751504e-02f, 2.26077251e-02f, 1.05262123e-01f, 2.03728169e-01f, 2.17136487e-01f, 1.59869090e-01f, 4.86778915e-02f, -8.70275944e-02f,
  -6.33158907e-02f, -1.49440020e-02f, 8.97232909e-03f, -1.12555593e-01f, 1.48867786e-01f, 5.08333445e-02f, 1.46881372e-01f, -9.85799357e-02f, -3.38345505e-02f, 1.50950387e-01f,
  -9.21499133e-02f, 1.20582134e-01f, 1.24956101e-01f, 7.27738962e-02f, 5.91468774e-02f, 1.27403792e-02f, 7.74245039e-02f, 1.25540480e-01f, -3.78808146e-03f, -4.79115639e-03f,
  8.03314596e-02f, -5.41763846e-03f, 7.37095624e-02f, 2.47612931e-02f, -8.36565718e-02f, -3.34892757e-02f, -4.88879345e-03f, -5.89364246e-02f, 5.49004506e-03f, 9.67360213e-02f,
  2.79666446e-02f, 8.10952336e-02f, -1.96712017e-01f, 1.31663799e-01f, 1.07309446e-01f, -8.85504410e-02f, 1.73583731e-01f, 3.93022522e-02f, -2.18913723e-02f, -2.51549929e-01f,
  -1.68067247e-01f, -2.89627276e-02f, 6.53619170e-02f, 2.36335546e-01f, 9.30745825e-02f, 8.72111470e-02f, 1.03693493e-02f, 2.49805987e-01f, -1.50531322e-01f, -1.78434387e-01f,
  -1.21340817e-02f, 1.39484137e-01f, 1.38904959e-01f, 6.05330616e-02f, -7.49765635e-02f, 6.06667697e-02f, 1.65101647e-01f, 4.90614027e-02f, 3.56658511e-02f, -2.73013879e-02f,
  1.56190405e-02f, 1.80526301e-01f, 8.03069994e-02f, -6.72453940e-02f, -1.16428696e-02f, -6.21474497e-02f, 1.13692373e-01f, -2.22881138e-02f, -1.12775952e-01f, -9.57519859e-02f,
  1.39897481e-01f, -1.54339448e-01f, -4.45900438e-03f, 1.53836161e-01f, 8.80266204e-02f, -1.51191130e-01f, 2.37681083e-02f, -2.58892756e-02f, 5.08932397e-02f, -1.42581714e-02f,
  1.92451596e-01f, 6.53418452e-02f, 9.73570272e-02f, -8.67799595e-02f, 9.07379910e-02f, -3.35783958e-02f, 7.12464526e-02f, 1.46296248e-01f, 4.37308401e-02f, 5.24050295e-02f,
  -5.96169606e-02f, -8.81827921e-02f, 1.25511095e-01f, -1.10096680e-02f, -2.82700304e-02f, 2.49901973e-02f, 8.41852799e-02f, 1.64030194e-01f, 8.98622200e-02f, -1.42208844e-01f,
  1.04747966e-01f, 3.78771089e-02f, 6.71292171e-02f, -1.16740994e-01f, 9.88839716e-02f, -9.15981159e-02f, 1.30325913e-01f, -4.13584970e-02f, 2.26226643e-01f, 4.68570627e-02f,
  -1.12525761e-01f, 7.77276382e-02f, -1.75846338e-01f, 1.24396093e-01f, -2.21096613e-02f, 5.54274470e-02f, 1.36493206e-01f, 2.13779926e-01f, 1.05660292e-03f, 2.04919070e-01f,
  -3.45600513e-03f, -2.01002941e-01f, 8.50260705e-02f, 1.95759639e-01f, -4.79675978e-02f, 2.06721518e-02f, 4.76767905e-02f, 2.23476514e-02f, -1.74579993e-01f, 6.26074076e-02f,
  3.39757651e-02f, -1.36674911e-01f, -2.05483913e-01f, -2.96447370e-02f, 8.34299400e-02f, -2.59335134e-02f, 8.35362747e-02f, -6.63815960e-02f, 3.26310955e-02f, -3.43140960e-02f,
  1.97376907e-01f, -2.01236270e-02f, 2.06722803e-02f, -5.04274480e-02f, -6.22842042e-03f, 7.13816062e-02f, -4.27719243e-02f, 1.67993560e-01f, -8.45156685e-02f, 5.57697117e-02f,
  7.76063800e-02f, 1.82413012e-01f, 7.77031630e-02f, 6.35301694e-02f, 3.01649664e-02f, 6.71543106e-02f, -1.70722678e-01f, -6.73311725e-02f, 6.47819713e-02f, 2.83094682e-02f,
  8.86166319e-02f, 4.40893471e-02f, 1.31122097e-01f, -1.79887637e-01f, 3.63690332e-02f, -1.77130416e-01f, -1.55218970e-02f, 8.81437883e-02f, -3.49590518e-02f, -2.21281111e-01f,
  1.79473475e-01f, 2.77867392e-02f, 1.72636777e-01f, 4.38201539e-02f, -1.07817374e-01f, -1.66465834e-01f, -3.58326465e-01f, 9.37961265e-02f, 2.37760812e-01f, 6.24017604e-02f,
  -1.15155116e-01f, 2.48713233e-02f, 2.35503633e-03f, 3.34514588e-01f, 1.13509782e-02f, 1.24578454e-01f, 1.10088401e-01f, 3.07056129e-01f, 1.00603402e-01f, -7.02244416e-02f,
  -3.60227637e-02f, -1.32496268e-01f, -1.81295142e-01f, -1.29822150e-01f, -8.92078876e-02f, -1.75850570e-01f, 1.77257419e-01f, 1.82257995e-01f, 2.21150648e-02f, -1.44474164e-01f,
  7.60004595e-02f, 1.48490027e-01f, 2.37741251e-03f, 9.73130390e-02f, -3.63185741e-02f, -6.10067789e-03f, -5.86292818e-02f, -1.01258390e-01f, -5.71258329e-02f, -1.09781988e-01f,
  6.57066926e-02f, -3.39662246e-02f, 7.34994635e-02f, 7.39543661e-02f, -6.97952555e-03f, 2.40684394e-02f, -9.22582299e-03f, -1.71935678e-01f, 1.26783580e-01f, -2.13383399e-02f,
  -1.23261549e-02f, 2.06715763e-02f, -2.83887312e-02f, -1.36062540e-02f, 8.38366225e-02f, -7.00345561e-02f, 1.58013567e-01f, -1.09582460e-02f, -1.83486775e-01f, -8.58829468e-02f,
  2.91331172e-01f, 2.01316684e-01f, -2.59745657e-01f, -7.79339345e-03f, -1.45347178e-01f, -5.32237953e-03f, -2.44652387e-02f, 2.41862983e-01f, 3.91870625e-02f, -5.85247129e-02f,
  -6.07503653e-02f, -1.26735359e-01f, 2.00745672e-01f, 2.52702028e-01f, -2.15308413e-01f, -1.21939247e-02f, 4.68793064e-02f, 5.61391637e-02f, 1.04398727e-01f, 2.92366743e-01f,
  1.43802658e-01f, 3.25491093e-02f, -2.77947858e-02f, 5.12146130e-02f, 6.17443137e-02f, -2.67202239e-02f, -1.17984571e-01f, 4.18405943e-02f, -2.27395613e-02f, -2.82123536e-02f,
  1.39393076e-01f, 1.83198527e-01f, -1.73378110e-01f, 7.20368102e-02f, 1.40130416e-01f, 1.85793698e-01f, -1.28246784e-01f, -6.01529516e-02f, -7.60738701e-02f, 8.70109946e-02f,
  1.35267666e-02f, 6.28905594e-02f, -7.77597204e-02f, -4.66554798e-02f, 1.59425773e-02f, 2.06613522e-02f, -7.81695321e-02f, -1.24344394e-01f, -8.99293721e-02f, 1.61142424e-02f,
  4.79118451e-02f, -9.44418013e-02f, -8.46109241e-02f, -6.16614148e-02f, 6.14841655e-02f, 4.36092131e-02f, -9.78175774e-02f, -1.37567177e-01f, -5.11476249e-02f, 6.72893152e-02f,
  -2.96243280e-03f, -1.30683362e-01f, -9.87352803e-02f, 4.83644521e-03f, 1.91707715e-01f, 5.53042591e-02f, 2.80402452e-02f, 4.93080579e-02f, -1.40816018e-01f, -1.00714378e-01f,
  -1.25353605e-01f, 1.73493490e-01f, 1.10993169e-01f, -3.60514075e-02f, -1.66240513e-01f, -8.38517174e-02f, 7.24343657e-02f, 6.13052808e-02f, 4.82722670e-02f, -3.39674056e-02f,
  -6.03693835e-02f, 5.84616512e-02f, -3.45723778e-02f, 3.42253558e-02f, -6.31564185e-02f, -5.61751537e-02f, -1.56215385e-01f, -6.74859062e-02f, -1.25287145e-01f, -1.45555940e-02f,
  -1.37994155e-01f, -6.80401847e-02f, -4.45788875e-02f, -9.36965719e-02f, 3.83221341e-04f, -9.65419486e-02f, -1.10766254e-01f, -5.09262308e-02f, 3.07174176e-02f, 6.72589168e-02f,
  7.41309375e-02f, -7.44346296e-03f, -1.35457683e-02f, 1.17953353e-01f, 9.11466181e-02f, 1.61685243e-01f, 9.31637138e-02f, 1.22332558e-01f, -3.53802927e-02f, 1.20784426e-02f,
  8.04562718e-02f, -4.38191965e-02f, 9.09819677e-02f, 3.43970768e-02f, 1.18628711e-01f, 1.03735529e-01f, 1.42745033e-01f, -4.46872227e-02f, 5.38890772e-02f, 1.04954801e-01f,
  -1.13628216e-01f, 1.06667839e-01f, 1.62834510e-01f, 1.77542150e-01f, -1.06242679e-01f, -9.24110413e-02f, 7.20115304e-02f, 9.40995216e-02f, -1.51728809e-01f, -4.57907505e-02f,
  2.25808293e-01f, 4.47081141e-02f, -8.68709460e-02f, -1.26894474e-01f, 4.94620204e-02f, -2.96980262e-01f, -1.63964659e-01f, 7.12101758e-02f, 8.30141380e-02f, 6.12802543e-02f,
  6.91889459e-03f, -2.21038073e-01f, 4.13823500e-02f, 1.61131341e-02f, -9.37660784e-02f, -2.01675043e-01f, -2.17750147e-02f, -2.67043322e-01f, -9.82120186e-02f, -9.50895101e-02f,
  1.65885948e-02f, -2.46216618e-02f, -5.41609973e-02f, 1.33286357e-01f, 1.25032499e-01f, 1.04857318e-01f, 4.32821661e-02f, -3.89730148e-02f, -2.06275925e-01f, -2.63267402e-02f,
  -5.90220317e-02f, -7.78820291e-02f, -1.35394827e-01f, -1.77688777e-01f, -6.60936087e-02f, 8.40420574e-02f, -5.89567283e-03f, -1.48652777e-01f, -5.52407242e-02f, -2.49407757e-02f,
  8.05779546e-03f, 1.90945249e-02f, -9.35272798e-02f, -1.11327507e-01f, -3.88925453e-03f, 6.15976797e-03f, -4.54670005e-02f, -2.20478866e-02f, -9.00759827e-03f, -2.33986586e-01f,
  1.01766726e-02f, 5.75027950e-02f, -2.87101436e-02f, 5.16583771e-02f, -6.20499961e-02f, 1.09420471e-01f, -9.54133719e-02f, 2.44922377e-02f, -8.50747712e-03f, -5.67925870e-02f,
  1.93702634e-02f, -6.36607483e-02f, 2.01963812e-01f, -2.17269734e-01f, -2.78199166e-01f, 6.98052421e-02f, 9.76848528e-02f, -4.58059013e-02f, -6.51448518e-02f, 1.57660827e-01f,
  -1.00948870e-01f, 2.00373977e-01f, -8.46464708e-02f, -1.76450267e-01f, -5.35811335e-02f, 9.60843936e-02f, 1.45489916e-01f, 1.68672502e-01f, 2.77150899e-01f, 6.72420934e-02f,
  2.17321403e-02f, 2.63522178e-01f, 1.92763343e-01f, 1.38344049e-01f, -5.08203469e-02f, 2.16394737e-01f, -4.52425256e-02f, -6.23164177e-02f, -3.21974382e-02f, 1.06542483e-02f,
  -4.11191024e-02f, 2.17594594e-01f, 1.96002889e-02f, -1.16270058e-01f, 1.29877314e-01f, 4.25685011e-03f, -1.17512845e-01f, 7.56303519e-02f, -1.02042794e-01f, -7.45185167e-02f,
  1.67537048e-01f, -1.34993270e-01f, 2.06341073e-02f, -1.10998511e-01f, 3.42294537e-02f, -4.60259095e-02f, 4.36201431e-02f, 1.23247402e-02f, -8.29309598e-02f, -1.59339145e-01f,
  -1.82192065e-02f, 1.11273974e-01f, -1.53070325e-02f, 8.02651346e-02f, -9.62656438e-02f, 1.04883045e-01f, -1.39476821e-01f, -6.34694397e-02f, -5.34714498e-02f, 4.09923606e-02f,
  -7.11525604e-02f, -1.67986155e-01f, 1.07889317e-01f, -1.32761419e-01f, 1.10500883e-02f, -3.69893536e-02f, -1.06011689e-01f, -6.05307594e-02f, 8.64288583e-02f, -6.85243905e-02f,
  2.58609235e-01f, 1.79213464e-01f, 1.09820724e-01f, 1.31184101e-01f, 5.63647039e-02f, 2.79549435e-02f, -2.32844472e-01f, 9.33836475e-02f, -3.88109609e-02f, -7.95088559e-02f,
  1.03874624e-01f, 6.05474263e-02f, 7.24094659e-02f, 2.11795513e-02f, 9.25973207e-02f, 2.65369266e-02f, -9.00011510e-03f, 8.22787210e-02f, 1.40557781e-01f, 3.46172117e-02f,
  7.03950152e-02f, -1.04462422e-01f, -4.01707292e-02f, -1.21290639e-01f, -6.61991015e-02f, -2.45921873e-02f, 1.24599919e-01f, 1.09902836e-01f, 4.49184738e-02f, 1.40123256e-02f,
  -4.04022895e-02f, 7.74612501e-02f, 5.28208464e-02f, 5.39175086e-02f, -1.28128543e-01f, 1.02143936e-01f, -7.50649162e-03f, 5.22491373e-02f, 4.59607132e-03f, -1.02292940e-01f,
  9.23505202e-02f, 9.38286930e-02f, 1.71692401e-01f, -1.01351209e-01f, -5.27152531e-02f, 4.97989990e-02f, 1.26125654e-02f, -8.50259885e-02f, 4.98732552e-02f, -1.11515753e-01f,
  -1.90219767e-02f, -4.49927747e-02f, 9.41384658e-02f, -9.40203965e-02f, 6.85496256e-02f, 1.13865361e-01f, 3.08221132e-02f, -1.30804271e-01f, -4.61197384e-02f, 2.45406218e-02f,
  -4.85714413e-02f, 3.93691659e-02f, -3.32255065e-02f, 8.80721211e-03f, -2.75648743e-01f, -2.87285447e-01f, -9.96076316e-02f, -7.29023740e-02f, -7.10583180e-02f, -2.67255932e-01f,
  1.14236094e-01f, -7.12368563e-02f, -1.10909380e-01f, -6.82142451e-02f, -1.85550917e-02f, 5.99443130e-02f, -4.58361134e-02f, -1.59229055e-01f, -1.66262239e-01f, -6.44383505e-02f,
  7.54980147e-02f, 5.96029758e-02f, -2.36849740e-01f, -1.56497002e-01f, -7.78728351e-02f, 9.66617465e-02f, 1.17501728e-01f, 1.74320891e-01f, 9.91075635e-02f, -1.09856576e-02f,
  -7.30096847e-02f, -1.19237445e-01f, -2.16969371e-01f, -7.61068463e-02f, 1.13939419e-01f, 1.06513448e-01f, -6.15863875e-02f, 8.97600204e-02f, 3.17603350e-02f, -1.62380114e-02f,
  -6.33955002e-02f, 4.65882979e-02f, -1.10151947e-01f, -4.20478024e-02f, 1.29170865e-01f, -8.84544924e-02f, 5.89207076e-02f, 1.01706050e-01f, 2.51021180e-02f, -8.82216822e-03f,
  -2.03659043e-01f, 5.49878925e-02f, -9.51650590e-02f, -1.09696817e-02f, 7.61133358e-02f, -2.28804220e-02f, 7.75302202e-02f, 5.25790527e-02f, 1.38548896e-01f, -6.21348135e-02f,
  -5.24718948e-02f, -4.44045477e-02f, 1.54352635e-01f, -3.39327067e-01f, -1.24607638e-01f, 1.02490801e-02f, 1.33969605e-01f, -1.15053847e-01f, -2.23348476e-02f, 2.39268020e-01f,
  -3.84828486e-02f, -1.11663848e-01f, 1.91629410e-01f, 3.24173458e-02f, -4.18490283e-02f, -1.86580554e-01f, 1.58445597e-01f, 4.07448076e-02f, -5.31932302e-02f, -1.36413753e-01f,
  -9.89662036e-02f, 6.64824736e-04f, 1.96368814e-01f, -2.56282426e-02f, -4.16700402e-03f, -2.20146775e-01f, 1.79009527e-01f, 5.02204560e-02f, 1.57456156e-02f, -2.03981977e-02f,
  9.99834910e-02f, -2.16973022e-01f, 3.57863819e-03f, -4.36355583e-02f, 8.83889347e-02f, -2.22886708e-02f, -4.64602560e-02f, -1.02710240e-01f, 1.02545738e-01f, -4.26851474e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.07239306e-01f, 4.97387238e-02f, 7.28422925e-02f, -8.08057711e-02f, -2.57722978e-02f, 9.98286232e-02f, 1.54527545e-01f, -6.80667758e-02f, 5.00994995e-02f, -9.19013470e-02f,
  -1.00195684e-01f, -9.25835297e-02f, 1.02537908e-02f, 2.31115241e-02f, -7.40280971e-02f, 2.30510738e-02f, -1.03722792e-02f, 1.70016997e-02f, 5.36139123e-02f, -4.23321687e-02f,
  -3.30223404e-02f, 1.17684484e-01f, 7.32289925e-02f, 8.51705745e-02f, 1.28100619e-01f, -1.55448809e-01f, 2.67426018e-02f, 2.56019346e-02f, 5.85167557e-02f, -1.20901391e-01f,
  -1.38554245e-01f, -4.78997864e-02f, 1.69147134e-01f, 1.63402721e-01f, 1.73133567e-01f, 5.16264923e-02f, 1.00973353e-01f, 1.21828198e-01f, -4.73299958e-02f, 1.68188047e-02f,
  -7.64825046e-02f, -7.03896806e-02f, 2.74513159e-02f, 1.26511022e-01f, -9.62742642e-02f, -6.52624443e-02f, -4.42726277e-02f, 5.77689037e-02f, 1.59747064e-01f, 1.50629103e-01f,
  1.82688177e-01f, 8.70777667e-02f, -1.23434134e-01f, 2.96990704e-02f, 1.19986281e-01f, -1.04610855e-03f, -3.00746467e-02f, -1.09163620e-01f, 3.25136520e-02f, 6.71450049e-02f,
  9.99263395e-03f, -3.94689105e-03f, 8.82336050e-02f, 6.68035671e-02f, 1.13302439e-01f, 1.32719278e-01f, 2.20773444e-02f, -6.63825125e-02f, -2.93172728e-02f, -7.37247169e-02f,
  -3.44555601e-02f, 9.18612406e-02f, -1.25960098e-03f, -1.41285714e-02f, 3.82674821e-02f, 6.39443099e-02f, -3.15523595e-02f, 7.16639012e-02f, -5.57236224e-02f, 5.76396585e-02f,
  4.76408601e-02f, 1.04360171e-01f, 9.48560704e-03f, 1.12044655e-01f, 5.16387671e-02f, 1.87848695e-02f, 1.06938571e-01f, 6.91943690e-02f, 7.52562210e-02f, 9.85000208e-02f,
  5.26910275e-02f, 2.42656469e-02f, 9.46996957e-02f, -4.20421809e-02f, -9.81913656e-02f, -5.59628122e-02f, -1.05035007e-01f, 1.54383868e-01f, 7.97126964e-02f, 1.29221499e-01f,
  2.81210709e-02f, -1.19024264e-02f, -6.93103597e-02f, -8.94149914e-02f, 8.22242573e-02f, 2.49414761e-02f, -1.33037940e-01f, 4.90377210e-02f, 5.58311231e-02f, -5.33395307e-03f,
  -4.32058983e-02f, 1.88762724e-01f, 6.89220279e-02f, 1.04155950e-01f, -4.82540168e-02f, -1.08785979e-01f, 2.50537302e-02f, 1.36987679e-02f, -6.23471104e-02f, -3.66741940e-02f,
  -7.04597607e-02f, 7.94469863e-02f, 8.04537684e-02f, 2.90457588e-02f, 4.93696146e-03f, 6.85807411e-03f, 1.14716552e-01f, 1.57399662e-02f, -6.86090216e-02f, -4.35956530e-02f,
  9.40663293e-02f, -1.28073841e-01f, -6.60427064e-02f, 9.32368934e-02f, -1.13548212e-01f, 8.97344276e-02f, -1.20621093e-01f, -8.11138004e-02f, -9.00988728e-02f, 9.46732238e-03f,
  -1.00643836e-01f, 1.07306398e-01f, -1.16708413e-01f, -4.03427798e-03f, 5.19081466e-02f, -1.58909187e-02f, -1.92847196e-02f, 3.80936079e-02f, 2.08046436e-02f, 7.84160048e-02f,
  1.64956488e-02f, 1.25290332e-02f, -2.78212018e-02f, 1.06849670e-01f, -6.06920719e-02f, -1.97846368e-02f, 1.55118823e-01f, -8.13157037e-02f, -1.05603740e-01f, -1.66322161e-02f,
  5.21843582e-02f, 4.31677774e-02f, 8.08534250e-02f, 5.94347343e-02f, -6.06841072e-02f, -1.05938770e-01f, 6.75604790e-02f, -2.29797121e-02f, 6.09311387e-02f, -6.60590008e-02f,
  5.51858135e-02f, 8.13984498e-02f, -2.92830281e-02f, 8.32140520e-02f, -1.26272999e-02f, 1.37980804e-01f, 1.30433843e-01f, -2.68606585e-03f, 6.58108890e-02f, -2.99074333e-02f,
  -3.89494584e-03f, -8.66706967e-02f, -1.22324616e-01f, -5.73121384e-02f, 8.52596015e-02f, -8.66508931e-02f, 5.55988438e-02f, 8.39206204e-02f, 1.64571814e-02f, -1.24431036e-01f,
  2.18541343e-02f, -4.25655469e-02f, 1.30191937e-01f, 6.58987388e-02f, 2.03887280e-02f, 9.76233035e-02f, 1.28875837e-01f, -7.29538351e-02f, -9.10706744e-02f, -7.70568848e-03f,
  6.47437274e-02f, -6.61587268e-02f, -3.42323259e-02f, -2.17987690e-02f, -5.86017445e-02f, 1.86107196e-02f, 2.08288245e-02f, -7.64403269e-02f, -1.02611884e-01f, -9.82425921e-03f,
  2.97595449e-02f, -4.01805267e-02f, 1.19050674e-01f, 3.98691706e-02f, -1.20192811e-01f, 3.03383321e-02f, -4.08743396e-02f, -1.08303010e-01f, 1.12138256e-01f, -9.96631309e-02f,
  3.81332859e-02f, -7.78269768e-02f, -8.90882164e-02f, 8.99078473e-02f, 9.89907384e-02f, -1.12665556e-01f, -1.15349360e-01f, -1.02963246e-01f, 6.85663596e-02f, 2.31157579e-02f,
  1.41805664e-01f, -1.54266313e-01f, -1.42582133e-01f, -1.37405261e-01f, 9.10725594e-02f, 3.92638408e-02f, 1.35206088e-01f, -1.36834845e-01f, -7.54079074e-02f, -1.41560405e-01f,
  -7.64062032e-02f, -3.73209454e-02f, 3.75295058e-02f, -7.93072302e-03f, -6.96388111e-02f, -1.91306565e-02f, -3.20080929e-02f, -1.13246113e-01f, 5.48476204e-02f, -1.91400070e-02f,
  6.13093236e-03f, -2.54855435e-02f, 1.08259790e-01f, -3.04570198e-02f, 1.09284818e-01f, 1.06981143e-01f, 1.36650234e-01f, 1.82027996e-01f, -3.81804518e-02f, -8.01129192e-02f,
  4.24062796e-02f, -7.88824726e-03f, -1.95606705e-02f, -8.12403299e-03f, 9.61666405e-02f, 1.12065867e-01f, 9.25002322e-02f, 1.12239858e-02f, 7.24677136e-03f, -4.97276150e-02f,
  1.14856645e-01f, -5.92942536e-02f, 1.84593931e-01f, -9.24234390e-02f, 1.31832853e-01f, -6.60575852e-02f, 2.94346530e-02f, -2.52186656e-02f, 9.87021178e-02f, -4.06590886e-02f,
  3.36549431e-02f, 1.64517641e-01f, -6.43395483e-02f, -8.60896613e-03f, 1.84493423e-01f, 1.13797717e-01f, -1.68913946e-01f, 1.72741357e-02f, -1.23570124e-02f, -1.72864601e-01f,
  -9.00576711e-02f, 1.10740349e-01f, 1.38582140e-01f, -1.99122101e-01f, 5.39946258e-02f, 5.71109951e-02f, -5.06287068e-02f, -1.01565659e-01f, -5.72341830e-02f, 4.45822738e-02f,
  -5.09804785e-02f, -1.85508713e-01f, -4.83564138e-02f, 8.68973732e-02f, -8.86115655e-02f, -1.35871828e-01f, 7.19185174e-02f, -5.66488691e-02f, -1.09414265e-01f, -4.67760153e-02f,
  -4.15167660e-02f, 1.64637528e-02f, 8.29553902e-02f, 1.02258772e-01f, 1.93601626e-03f, 7.87830502e-02f, -1.32842302e-01f, 6.59370348e-02f, -6.16933294e-02f, 1.53531551e-01f,
  9.86416861e-02f, -7.31800050e-02f, 1.82204977e-01f, 1.93183407e-01f, 4.85858880e-02f, 1.10366911e-01f, 1.75770402e-01f, -2.68473178e-02f, -5.16332593e-03f, -5.64419702e-02f,
  4.46179733e-02f, -2.19250489e-02f, -1.68057401e-02f, 4.61933278e-02f, 9.00742859e-02f, 2.04858273e-01f, 3.74036469e-02f, 1.89144358e-01f, 6.74786717e-02f, 1.74083412e-01f,
  -3.59605774e-02f, 1.34745717e-01f, -9.30244923e-02f, 2.06252143e-01f, -3.85594256e-02f, 7.05046207e-02f, 1.75881386e-01f, 2.03942810e-03f, -5.56135401e-02f, -2.14129388e-02f,
  -1.91818539e-03f, 9.26516950e-03f, 1.18797101e-01f, 5.21284528e-02f, -9.22801793e-02f, -9.37782526e-02f, 1.06912620e-01f, 1.93506405e-01f, 5.98327257e-02f, 7.73963109e-02f,
  4.79398109e-02f, -1.12461329e-01f, -5.72324656e-02f, 7.63283065e-03f, 6.61865249e-02f, 5.68387005e-03f, -5.76326177e-02f, -1.10413440e-01f, -7.94364139e-02f, -9.73113403e-02f,
  -2.63213702e-02f, 6.94621056e-02f, -5.67195006e-02f, -1.20982826e-02f, -5.65486252e-02f, 2.48406846e-02f, -1.09032117e-01f, -4.48608212e-02f, -1.89157054e-01f, -1.51004061e-01f,
  1.70883283e-01f, 6.77478313e-02f, -4.37693372e-02f, -1.06767775e-03f, -1.90533698e-02f, -5.27815521e-03f, -6.72153085e-02f, 6.06188551e-02f, 2.35961601e-02f, 4.75879349e-02f,
  -5.00194505e-02f, -1.38960471e-02f, -2.73607597e-02f, -1.03824869e-01f, 1.06416367e-01f, -8.93568099e-02f, -3.50738764e-02f, -9.84608904e-02f, -4.80731055e-02f, 1.29646882e-01f,
  1.17494144e-01f, -3.89325991e-02f, 3.05808224e-02f, -4.23989370e-02f, -7.44770169e-02f, 5.69049567e-02f, 6.41347244e-02f, -1.07478075e-01f, -1.26438197e-02f, 2.70449780e-02f,
  -1.59363121e-01f, 7.28586465e-02f, -1.27704106e-02f, -3.38039100e-02f, -5.11387549e-02f, 1.89929910e-04f, -1.37958704e-02f, 3.05858888e-02f, -2.86806431e-02f, -2.61812825e-02f,
  3.14181224e-02f, 3.90695147e-02f, -1.41903125e-02f, 9.40029100e-02f, -6.89255074e-02f, 1.14298902e-01f, 7.14471340e-02f, -5.28438501e-02f, -9.76946577e-02f, -5.40090613e-02f,
  9.77974311e-02f, -6.89449087e-02f, -6.31437972e-02f, 7.72955120e-02f, 1.76430028e-02f, -1.05747685e-01f, 7.64051527e-02f, 4.07081880e-02f, -1.00620344e-01f, 7.75909722e-02f,
  -1.40623197e-01f, 4.50885622e-03f, -3.71830501e-02f, 2.47880649e-02f, -2.56936960e-02f, 1.56446677e-02f, 7.39403218e-02f, 1.51609851e-03f, 6.47772178e-02f, 1.85464635e-01f,
  -8.50780495e-03f, 1.13864645e-01f, 1.52925819e-01f, 1.26376860e-02f, -5.00460677e-02f, -4.12883097e-03f, 4.06315783e-03f, -1.16494633e-01f, 7.08524659e-02f, 1.64052099e-01f,
  -4.70949039e-02f, 9.63117927e-02f, -7.47138113e-02f, 1.56532321e-02f, 1.68445051e-01f, 8.46585184e-02f, 4.06793617e-02f, -4.65032235e-02f, 3.13936546e-03f, -9.26203653e-03f,
  -1.23935558e-01f, -3.35194170e-02f, -3.33302952e-02f, 5.21924794e-02f, -3.25164981e-02f, -1.20097883e-01f, -5.80944121e-03f, -7.37703815e-02f, 7.75399059e-02f, -7.17428029e-02f,
  -9.37276185e-02f, 8.93074796e-02f, -1.01756476e-01f, 1.35711804e-01f, -2.15767045e-02f, 6.21122718e-02f, 3.99253219e-02f, -1.51747122e-01f, -6.21220609e-03f, 9.13355674e-04f,
  6.14495687e-02f, -2.80195400e-02f, 2.45584697e-02f, 1.01251900e-01f, 9.73115116e-02f, 2.06385791e-01f, 1.10644020e-01f, -3.25697362e-02f, 8.33906308e-02f, 1.18400656e-01f,
  -1.35369468e-02f, -1.01035424e-01f, -6.93982467e-02f, 8.49766061e-02f, 1.08454293e-02f, 4.54856083e-02f, 1.39880180e-01f, 1.13899313e-01f, 5.42691834e-02f, -7.62012079e-02f,
  -2.73149852e-02f, 2.22826712e-02f, 1.26473889e-01f, -3.05951037e-03f, 2.36200362e-01f, 9.27084405e-03f, -9.20060370e-03f, 1.06111258e-01f, 1.21847846e-01f, 3.44129466e-02f,
  3.23911868e-02f, 1.23621896e-01f, 7.86952768e-03f, 4.98864390e-02f, 1.72498465e-01f, 1.67009592e-01f, -1.31092042e-01f, -2.79245991e-03f, 1.59801230e-01f, 2.18356565e-01f,
  -1.73212722e-01f, 7.39120459e-03f, 4.71706539e-02f, -4.35389653e-02f, 1.83267087e-01f, -1.29780367e-01f, 8.66837576e-02f, 4.15611714e-02f, -1.89582959e-01f, -6.97029680e-02f,
  7.60854746e-04f, 2.85011709e-01f, 2.31986314e-01f, -1.55162543e-01f, 3.74911018e-02f, 1.19163714e-01f, -5.01515195e-02f, 1.79640111e-02f, 8.23446363e-02f, -7.40852430e-02f,
  1.00862667e-01f, 5.28289489e-02f, 4.97285463e-02f, -2.09167320e-02f, -5.72606102e-02f, -8.24018866e-02f, -1.39251262e-01f, 2.13517562e-01f, -1.03903838e-01f, 8.05498436e-02f,
  -2.41986945e-01f, 1.89766914e-01f, 1.62583232e-01f, -9.63716209e-02f, 8.23788717e-02f, 7.01003000e-02f, 3.86064835e-02f, -8.88873115e-02f, -6.22280203e-02f, 7.58238882e-02f,
  2.21221939e-01f, 3.64391096e-02f, -3.39954831e-02f, -3.63241062e-02f, -7.77515993e-02f, 4.96701859e-02f, 6.95767701e-02f, 2.91204005e-01f, 4.85430993e-02f, -2.33124308e-02f,
  1.78406551e-01f, 1.92888305e-02f, 6.67916015e-02f, 2.22543150e-01f, 1.70729354e-01f, -7.70133063e-02f, -2.68483385e-02f, 1.64580911e-01f, -6.68299198e-02f, -7.92306885e-02f,
  4.52107899e-02f, 6.10593148e-02f, 5.23622110e-02f, 1.44135132e-01f, 8.95425007e-02f, 6.16891608e-02f, 1.93089042e-02f, 2.15503231e-01f, -1.62643969e-01f, 4.04140204e-02f,
  2.06300970e-02f, 3.81918550e-02f, 2.24231735e-01f, 1.14818037e-01f, 1.73311189e-01f, -1.49905816e-01f, -1.76273689e-01f, 2.94103473e-01f, -3.33458744e-02f, -7.69224763e-02f,
  -1.85996428e-01f, 2.11888552e-01f, -1.09842882e-01f, 1.09376997e-01f, 2.03957751e-01f, -2.60218173e-01f, -1.24703266e-01f, -6.39201626e-02f, 2.19741255e-01f, -4.45157923e-02f,
  2.57389277e-01f, -2.53507048e-01f, 4.39007021e-02f, 2.25514382e-01f, 2.86583826e-02f, -4.65859547e-02f, -4.16543242e-03f, 2.96743959e-01f, -3.71621996e-02f, 6.20527156e-02f,
  1.18991666e-01f, 1.02585003e-01f, 2.27503702e-01f, 2.54322678e-01f, -6.87021092e-02f, -3.98173705e-02f, 8.22272003e-02f, -5.61323977e-05f, -1.46415681e-01f, 2.04008982e-01f,
  -6.09271368e-03f, 5.37086055e-02f, 4.09968384e-02f, 6.58420548e-02f, -7.72709697e-02f, 1.23257235e-01f, 7.91910291e-02f, 1.57570094e-02f, 4.29665446e-02f, -2.36217212e-02f,
  4.90852520e-02f, 8.62993151e-02f, -4.49564792e-02f, 3.95216756e-02f, 1.24414958e-01f, 1.39321219e-02f, 3.68598849e-02f, 1.06912248e-01f, -1.01127043e-01f, 1.57241970e-01f,
  1.01836696e-01f, -2.53497884e-02f, 1.31495014e-01f, -1.50251329e-01f, 3.89681496e-02f, 1.69844568e-01f, -5.70165440e-02f, 3.00344042e-02f, 1.83116868e-02f, 1.76514611e-01f,
  1.16794102e-01f, 1.77722760e-02f, 8.49840492e-02f, -4.88432311e-02f, -2.70043090e-02f, -3.46554108e-02f, -1.01002663e-01f, -1.45599201e-01f, -8.37591588e-02f, 9.86645892e-02f,
  -6.52949214e-02f, 1.10859476e-01f, 9.46724489e-02f, -1.83477774e-01f, -2.46589929e-02f, 1.16971664e-01f, -1.74801454e-01f, -3.45693938e-02f, -1.60442919e-01f, 1.54623520e-02f,
  1.29244188e-02f, -5.40839769e-02f, -1.18287746e-02f, -1.01536252e-01f, -1.07908137e-01f, -1.46106519e-02f, 3.07043665e-04f, 1.02389738e-01f, 1.63927585e-01f, 2.09465083e-02f,
  -1.28422022e-01f, -3.98412347e-02f, -1.14288755e-01f, -1.37972198e-02f, 1.69166714e-01f, 2.11548567e-01f, 1.26606733e-01f, 2.14183077e-01f, 5.34231588e-02f, 1.28785178e-01f,
  -2.27378067e-02f, 1.16062351e-01f, 1.36408076e-01f, 1.17707781e-01f, -1.93378348e-02f, 1.78522423e-01f, 6.48458228e-02f, -1.93207082e-03f, 2.79584341e-02f, 4.60763909e-02f,
  8.47730041e-02f, 1.36130705e-01f, 1.01311371e-01f, -2.59113163e-02f, -4.24918830e-02f, 1.38036922e-01f, 2.70652801e-01f, 6.45192042e-02f, -2.71791052e-02f, 2.21915562e-02f,
  -9.58512910e-03f, -7.26641789e-02f, 2.39170585e-02f, 1.33769631e-01f, -8.30961689e-02f, -1.07740864e-01f, -3.20213169e-01f, -9.78768691e-02f, -1.26458228e-01f, -5.47501743e-02f,
  7.00368807e-02f, -2.46120155e-01f, 1.56761363e-01f, -6.07637726e-02f, 8.77572000e-02f, -1.20633387e-03f, -1.95305407e-01f, -7.29335323e-02f, -1.11005887e-01f, -2.63560452e-02f,
  3.98866646e-03f, 4.30938788e-02f, 7.41714910e-02f, -1.99739829e-01f, -1.26155943e-01f, 1.46350283e-02f, -9.78380442e-02f, -6.46443591e-02f, -1.72799993e-02f, 1.44774720e-01f,
  -1.19890325e-01f, -9.34326798e-02f, 1.40175834e-01f, -9.65795144e-02f, -1.66851118e-01f, 3.89879644e-02f, -6.31629452e-02f, 7.73260668e-02f, -7.01099709e-02f, -5.62368706e-02f,
  -4.94568422e-02f, 1.39683723e-01f, 4.86544184e-02f, -7.94975609e-02f, -7.65142664e-02f, 9.10560414e-02f, -2.73642819e-02f, 2.83606183e-02f, 3.45012266e-03f, 1.18672922e-01f,
  -7.47001842e-02f, -8.97806287e-02f, -5.48684224e-02f, -7.66282007e-02f, 1.18808232e-01f, -7.27811530e-02f, 1.10266186e-01f, -5.93234673e-02f, -1.02310993e-01f, 5.20887002e-02f,
  -5.89528084e-02f, 9.66414437e-02f, 1.04769036e-01f, -4.32276390e-02f, 1.08460262e-01f, -5.83715178e-02f, -1.24623716e-01f, -6.02192469e-02f, -5.40685356e-02f, -3.98133621e-02f,
  -9.54404920e-02f, 8.23519677e-02f, -8.87146667e-02f, 4.85518612e-02f, 7.35776424e-02f, -1.10420778e-01f, 9.48652849e-02f, -8.87349471e-02f, 1.43896453e-02f, -9.17901322e-02f,
  -4.56675328e-02f, 1.09832510e-02f, 1.80245209e-02f, -1.44914433e-01f, 1.04541719e-01f, -9.47740152e-02f, -8.52831751e-02f, -1.10170066e-01f, -4.04151194e-02f, -1.17357619e-01f,
  -1.19483523e-01f, 1.16885878e-01f, -2.20127851e-02f, -8.90766308e-02f, 1.02394134e-01f, 2.91140918e-02f, -1.15199991e-01f, 6.00145422e-02f, 3.59943919e-02f, 1.27007797e-01f,
  8.69210809e-02f, 7.60528520e-02f, 7.32593760e-02f, 7.22666532e-02f, 4.46707569e-02f, -4.96675633e-02f, 1.12848811e-01f, 2.78952159e-02f, 8.17792043e-02f, 1.16978675e-01f,
  1.00641191e-01f, -1.81643385e-02f, 7.12547824e-02f, 8.26832727e-02f, 6.37070611e-02f, 1.27169564e-01f, -1.26342863e-01f, 1.69372872e-01f, -7.80109391e-02f, 1.15031160e-01f,
  -4.54465719e-03f, -2.73143593e-02f, 9.00576338e-02f, 3.41335833e-02f, 1.58225298e-01f, 2.31011044e-02f, -8.44632015e-02f, -4.22857441e-02f, -1.00090355e-01f, -2.30501425e-02f,
  6.32476807e-02f, 5.30812331e-02f, 3.87565456e-02f, -4.44681086e-02f, -6.40332792e-03f, 4.85278256e-02f, 1.84926689e-01f, -2.00947851e-01f, 1.01648539e-01f, 1.15104489e-01f,
  -5.77122606e-02f, 1.81203231e-01f, 1.77666321e-01f, -1.22528732e-01f, 1.04970120e-01f, 1.08964697e-01f, -1.18578173e-01f, -6.33846670e-02f, -1.06284060e-02f, -8.22960809e-02f,
  -8.15871730e-02f, -1.28902882e-01f, -7.90644959e-02f, 1.77356601e-02f, -8.31674114e-02f, 1.23753168e-01f, 7.04123229e-02f, 5.42384945e-02f, -7.31257200e-02f, 4.36435193e-02f,
  6.02502525e-02f, -8.87332261e-02f, -3.60297710e-02f, -4.29766551e-02f, -3.73282768e-02f, 7.18752667e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  -4.62855259e-03f, -4.65327920e-03f, 1.11232169e-01f, 2.54748892e-02f, 1.68854162e-01f, 1.43915325e-01f, 1.01276049e-02f, 4.05942127e-02f, 4.85571846e-02f, 1.58588454e-01f,
  1.47523046e-01f, 1.46525070e-01f, 5.41162305e-03f, -3.13875973e-02f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  6.06096573e-02f, 4.06342894e-02f, -6.45023957e-02f, -1.29226893e-01f, 9.12287608e-02f, 4.13452163e-02f, 2.05618694e-01f, -1.04341060e-01f, -1.72917202e-01f, 6.27335608e-02f,
  -7.60262534e-02f, 1.18547328e-01f, 7.17974594e-03f, -5.95329739e-02f, 1.53023839e-01f, 3.15683112e-02f, 1.03258200e-01f, 6.46070242e-02f, 2.31544813e-03f, -1.13492928e-01f,
  4.60962206e-02f, -1.94594145e-01f, 8.97091534e-03f, -2.95253797e-03f, -1.13862984e-01f, 1.22048464e-02f, 6.40763864e-02f, -1.42105455e-02f, 2.68364131e-01f, -6.40899166e-02f,
  -9.40511972e-02f, -2.04589486e-01f, -8.33491012e-02f, 1.62496209e-01f, -1.05737112e-01f, -4.83619561e-03f, 2.00985506e-01f, -5.89119364e-03f, -1.83226690e-01f, 1.98068127e-01f,
  1.31488755e-01f, -1.42403916e-01f, -1.72367766e-01f, -1.51037633e-01f, -5.82587793e-02f, -2.08455294e-01f, 2.84516931e-01f, 6.13791384e-02f, -1.04359873e-01f, -1.14073441e-03f,
  9.76135060e-02f, -8.10650885e-02f, 6.08351864e-02f, 1.96890328e-02f, 1.01197146e-01f, 1.23510420e-01f, -1.25758231e-01f, 8.75806250e-03f, -1.15384623e-01f, 3.40190113e-01f,
  -6.53106868e-02f, -2.05359340e-01f, -2.21476220e-02f, -1.86396480e-01f, 5.63366823e-02f, 1.89028792e-02f, -1.29434288e-01f, -3.35740335e-02f, 1.68481434e-03f, -4.97690290e-02f,
  -1.11721851e-01f, 1.06573924e-01f, 1.15134649e-01f, -1.25956088e-01f, -2.20807940e-02f, -5.09756282e-02f, 1.30628869e-01f, -9.75765884e-02f, 1.76694319e-01f, -1.08272992e-01f,
  7.36926049e-02f, -2.03433171e-01f, -1.40398413e-01f, -1.10647909e-01f, 2.88976301e-02f, -9.02891383e-02f, 1.19424962e-01f, 4.53909114e-02f, 6.22041002e-02f, -9.49645787e-02f,
  2.72962511e-01f, 1.50240153e-01f, 4.11647744e-03f, -6.99515268e-02f, -3.85391325e-01f, 4.44632806e-02f, 2.98114829e-02f, 1.06328957e-01f, -5.56992646e-03f, -4.41858917e-01f,
  2.35257730e-01f, -6.56067654e-02f, 4.29788493e-02f, -1.05807021e-01f, 2.62844831e-01f, 7.36003742e-02f, -1.89501241e-01f, -5.76063467e-04f, 7.97616243e-02f, 3.61097753e-02f,
  1.06932968e-01f, -7.31037706e-02f, -3.43305282e-02f, 1.70751199e-01f, 1.29525855e-01f, -5.19940108e-02f, -3.52715366e-02f, 3.00342757e-02f, -1.31572276e-01f, 1.70462713e-01f,
  4.08248715e-02f, 1.54922307e-01f, -1.72632039e-01f, -1.03410013e-01f, -1.34545311e-01f, -1.36919960e-01f, -5.74067868e-02f, 1.14570752e-01f, -4.22728658e-02f, -6.79080039e-02f,
  -3.60505693e-02f, -1.75007552e-01f, 3.20016220e-02f, 1.82783306e-02f, 4.77220342e-02f, -1.33940682e-01f, -5.53183071e-02f, -1.40304714e-02f, -1.13922134e-01f, -2.74995789e-02f,
  -3.07517555e-02f, 1.01510637e-01f, -1.16963491e-01f, -1.39363974e-01f, 9.97853838e-03f, 2.45662510e-01f, 1.88938025e-02f, -5.44811459e-03f, -7.14528859e-02f, -2.37726998e-02f,
  -1.73618272e-02f, 1.75659135e-01f, -1.07831515e-01f, -2.87183207e-02f, -3.76493841e-01f, 4.30800766e-02f, 2.26071887e-02f, -7.64524341e-02f, 1.86849982e-01f, -1.03172846e-01f,
  -3.43783587e-01f, 2.08245561e-01f, -8.26568902e-02f, 1.68572068e-01f, -2.72748768e-02f, -6.48116916e-02f, 1.27044231e-01f, -6.47105835e-03f, 8.74898210e-02f, 4.43587415e-02f,
  -2.26076499e-01f, -1.00973509e-01f, -7.44161755e-02f, -4.14662482e-03f, 1.28757939e-01f, -2.23658115e-01f, 2.62625009e-01f, -3.23358923e-01f, -2.46731807e-02f, -7.31819421e-02f,
  -8.12796727e-02f, 1.32378280e-01f, -3.90980486e-03f, 3.75502668e-02f, -4.85338792e-02f, -3.14011201e-02f, -1.86877102e-01f, 1.72033578e-01f, 4.99430783e-02f, -5.72414622e-02f,
  2.84901727e-02f, -1.00452997e-01f, -1.45149395e-01f, -1.07799165e-01f, -9.83229205e-02f, -2.10570265e-02f, -5.67800067e-02f, 2.44791582e-02f, -1.68466177e-02f, 7.72378445e-02f,
  8.44541565e-02f, 1.65881738e-02f, 4.22635004e-02f, -1.59952015e-01f, 1.08226864e-02f, 2.06200927e-02f, -1.10884532e-01f, -1.51762888e-01f, -6.45727217e-02f, 8.01285803e-02f,
  2.05446351e-02f, -6.58536181e-02f, -2.07716450e-01f, -1.66872531e-01f, -2.86486261e-02f, 1.03824094e-01f, 8.39906558e-02f, 1.65147856e-01f, -3.01122218e-01f, -8.51597264e-02f,
  -9.02832672e-02f, -1.49166867e-01f, -8.47830027e-02f, 4.06656712e-02f, -2.53640682e-01f, 2.13704258e-01f, -8.40558633e-02f, 5.35592157e-03f, 9.03969631e-02f, -1.51374623e-01f,
  1.38712972e-01f, 4.94532585e-02f, -1.04463811e-03f, 1.07642911e-01f, -2.70920604e-01f, -2.82779694e-01f, -7.06570596e-02f, 2.40313962e-01f, 9.54769701e-02f, -1.21174432e-01f,
  1.28600031e-01f, -1.59742922e-01f, -1.74128979e-01f, -1.69009104e-01f, -1.54313773e-01f, 5.19482382e-02f, -1.06230818e-01f, 1.05633311e-01f, 7.57725462e-02f, 8.53715166e-02f,
  -2.38329291e-01f, 2.03804731e-01f, 1.09695174e-01f, -1.06055066e-01f, -1.84063823e-03f, 4.37505133e-02f, -6.01794161e-02f, -1.06783770e-01f, 1.33433327e-01f, 9.08308998e-02f,
  1.40041038e-01f, 1.54399782e-01f, -1.91525981e-01f, 7.37950299e-03f, 6.71500049e-04f, -5.54618724e-02f, 1.80652589e-01f, 4.67460528e-02f, -6.00034930e-03f, 1.30957007e-01f,
  9.51596871e-02f, 6.08598255e-02f, 1.23506874e-01f, 1.91018656e-01f, 9.72942933e-02f, -2.27663722e-02f, 1.55220553e-01f, 1.27922650e-02f, -6.16393983e-03f, 7.04821348e-02f,
  1.85070224e-02f, 5.31130238e-04f, 9.88760516e-02f, -2.11638048e-01f, -1.76570565e-01f, 5.60862161e-02f, -3.03895660e-02f, 1.11391768e-01f, 1.92880809e-01f, -2.52729565e-01f,
  9.95210260e-02f, 9.29452702e-02f, -2.12823153e-01f, 1.31827325e-01f, 1.21247135e-01f, -2.33781636e-01f, -2.80613154e-01f, 9.80724171e-02f, 1.39405176e-01f, 5.45742139e-02f,
  6.24572262e-02f, 1.92231268e-01f, -1.91744328e-01f, 9.97965690e-04f, -7.67305195e-02f, -1.41576067e-01f, -1.64337784e-01f, -6.07429780e-02f, -3.23085971e-02f, -8.78333598e-02f,
  4.52083768e-03f, 2.31811870e-02f, 7.19861761e-02f, 6.93726866e-03f, 2.58294553e-01f, -2.56810427e-01f, 7.69182816e-02f, 2.40810513e-02f, -7.87106901e-02f, 1.37173440e-02f,
  -1.40969351e-01f, 1.30491450e-01f, 1.76006183e-02f, 3.84300798e-02f, -1.16010062e-01f, 5.35973050e-02f, 8.09254050e-02f, 2.52635986e-01f, 1.21765353e-01f, 7.65843913e-02f,
  2.14616135e-02f, -1.37651619e-02f, 6.48508146e-02f, -1.07464798e-01f, -5.89767098e-02f, 3.17432322e-02f, -1.20734632e-01f, 6.23866692e-02f, -9.24774110e-02f, -7.34039349e-03f,
  6.60544680e-03f, -8.88597162e-04f, 1.09595239e-01f, -1.22093499e-01f, 9.78187397e-02f, -1.08244389e-01f, 1.20163552e-01f, 8.29660706e-03f, 3.42333801e-02f, 2.24919096e-02f,
  -2.56870031e-01f, 1.10543333e-01f, -4.07468602e-02f, -7.16268048e-02f, -1.24260169e-02f, -3.51883084e-01f, 3.53611410e-01f, -2.47427598e-02f, 4.32397351e-02f, 2.09653676e-01f,
  2.47877002e-01f, 7.17049688e-02f, 2.67939959e-02f, -1.24384880e-01f, -2.05148067e-02f, -8.59359279e-02f, -5.26989950e-03f, 1.52019225e-02f, -2.24417020e-02f, 1.63438800e-03f,
  2.34830212e-02f, -2.83225123e-02f, -1.10846207e-01f, 3.89887728e-02f, -9.20864493e-02f, 5.65922819e-02f, 1.13823656e-02f, -1.13272436e-01f, -3.98761556e-02f, -1.49732098e-01f,
  -5.08026667e-02f, -6.32477328e-02f, -2.14599185e-02f, 8.65378417e-03f, -1.25528082e-01f, -5.91279007e-04f, 1.15004502e-01f, -1.74640268e-02f, -7.47323260e-02f, -5.43790236e-02f,
  4.87800017e-02f, -8.66775587e-03f, -9.02315751e-02f, -3.04427538e-02f, -8.80297646e-02f, -1.41558632e-01f, 4.60585766e-02f, 2.35489733e-03f, -1.06988437e-01f, 1.09932184e-01f,
  -8.97876024e-02f, 5.52429818e-02f, -2.35847663e-02f, -5.31432442e-02f, -5.68237826e-02f, 5.02139051e-03f, 3.75892781e-02f, 1.13135897e-01f, -2.89921872e-02f, 1.67707369e-01f,
  -1.27758399e-01f, -9.28378925e-02f, -3.75617854e-02f, -2.64654364e-02f, 2.31962919e-01f, 5.58818225e-03f, -1.56686813e-01f, 2.10992526e-03f, -2.10567996e-01f, 3.17332774e-01f,
  -2.91738331e-01f, 5.26660755e-02f, 1.31851465e-01f, -2.46321410e-01f, -4.34197374e-02f, -8.62849280e-02f, -6.01244159e-02f, 5.62067814e-02f, 8.21418315e-02f, 8.07260945e-02f,
  1.74423940e-02f, -2.27779731e-01f, 2.46176958e-01f, -2.87900984e-01f, 2.27555656e-03f, -1.27833277e-01f, -4.14320007e-02f, -8.40248913e-02f, 1.51961684e-01f, -1.96567439e-02f,
  1.33580819e-01f, -1.48302913e-01f, 2.86437683e-02f, -1.17668308e-01f, 1.20230682e-01f, -7.81072006e-02f, -2.36398838e-02f, 2.39134133e-02f, 6.12016097e-02f, 5.98385483e-02f,
  -6.11527674e-02f, -5.55710793e-02f, 1.29727632e-01f, 1.53015926e-01f, 2.18959346e-01f, -1.43463373e-01f, 1.19587079e-01f, 7.88745806e-02f, -3.67274173e-02f, 1.46258458e-01f,
  -8.90975967e-02f, -8.25976655e-02f, 2.07262978e-01f, -9.49602574e-02f, -1.35652557e-01f, -8.61143321e-02f, 6.49876744e-02f, -5.45586869e-02f, 6.64751232e-02f, -6.45431131e-03f,
  -1.84488129e-02f, -3.24062668e-02f, 1.00562043e-01f, -1.12628929e-01f, -1.14820361e-01f, 1.78243622e-01f, 2.83400089e-01f, 6.51284903e-02f, 1.27747923e-01f, -9.52591896e-02f,
  -1.36718541e-01f, 4.79632765e-02f, 1.85857549e-01f, 1.92060918e-02f, -2.17051599e-02f, 4.16449569e-02f, -2.06614569e-01f, 2.12146163e-01f, 2.03039628e-02f, -1.44633269e-02f,
  2.66211331e-01f, 2.09830195e-01f, 3.83137241e-02f, -2.63439685e-01f, 2.45640859e-01f, 1.69130355e-01f, 1.62061099e-02f, -2.07888797e-01f, -7.59976432e-02f, -4.68064882e-02f,
  -1.00284433e-02f, -3.11143417e-02f, -5.53005673e-02f, -9.82444659e-02f, -4.38589565e-02f, 1.65149942e-01f, 6.66346848e-02f, 2.31348127e-01f, 1.35708466e-01f, -1.75761104e-01f,
  -8.68893638e-02f, -3.40642631e-02f, -6.60400931e-03f, -7.20074102e-02f, 4.39099483e-02f, -1.22420508e-02f, -8.00437555e-02f, -6.87318370e-02f, 9.80966957e-04f, 8.71236250e-02f,
  2.09102482e-01f, 1.16359545e-02f, -2.60651875e-02f, 3.45730223e-02f, -4.38326448e-02f, 7.90023729e-02f, 8.73191655e-02f, 8.30967352e-02f, 1.42327979e-01f, 4.95475680e-02f,
  -7.37369582e-02f, 5.29882982e-02f, 7.16246814e-02f, 1.90194638e-03f, 9.17455852e-02f, 1.06257454e-01f, 7.44207203e-02f, -1.51421323e-01f, -2.13775635e-01f, 1.00481018e-01f,
  -7.79223293e-02f, 1.36865646e-01f, 2.86252677e-01f, 1.00840949e-01f, -1.04169086e-01f, 5.35480604e-02f, 1.18958555e-01f, 2.80261874e-01f, -2.83561051e-01f, 1.80029184e-01f,
  -9.21187282e-04f, 7.98903555e-02f, -1.57756597e-01f, 5.67685179e-02f, 2.14352518e-01f, 2.06847906e-01f, 6.24556243e-02f, -1.63493067e-01f, 7.14417826e-03f, -7.22345486e-02f,
  2.04713032e-01f, -1.82409480e-01f, -6.74890727e-02f, -5.42892097e-03f, 8.85351375e-03f, -8.99440721e-02f, 1.79930648e-04f, -6.95319697e-02f, -7.66965514e-03f, 1.10451989e-01f,
  9.75970551e-02f, -1.45333081e-01f, 1.17992416e-01f, 9.52076167e-02f, -1.56658534e-02f, -5.19087678e-03f, -6.39536008e-02f, 5.09269051e-02f, -1.16574854e-01f, 1.48586661e-01f,
  -4.94131036e-02f, -4.04704213e-02f, 2.17806324e-01f, 3.74565162e-02f, 1.73577398e-01f, 4.93997149e-02f, -7.02565238e-02f, -3.83044779e-02f, -8.14117491e-02f, -1.09322928e-01f,
  -2.36582682e-02f, 7.27315545e-02f, 7.90444948e-03f, -4.41435948e-02f, -7.06762224e-02f, -3.84330377e-02f, -5.90044335e-02f, 9.87582728e-02f, 7.52897412e-02f, 9.34957415e-02f,
  6.14844859e-02f, -1.79224402e-01f, -3.11178476e-01f, -3.37980166e-02f, 1.25344917e-01f, 1.45095006e-01f, 1.13277331e-01f, -4.06615511e-02f, -2.78300852e-01f, 2.86898166e-02f,
  -2.01369479e-01f, -3.74837294e-02f, 1.43271968e-01f, -2.16774255e-01f, -1.01616390e-01f, 7.79856071e-02f, 2.37143617e-02f, 1.06462874e-01f, -1.12131469e-01f, -2.05903962e-01f,
  9.87561233e-03f, 7.44013563e-02f, 5.94506748e-02f, 2.58911704e-03f, 2.25172430e-01f, 1.68753602e-02f, 1.41909480e-01f, -9.32521597e-02f, -4.91469279e-02f, 1.55840322e-01f,
  9.45163891e-02f, -4.62734513e-02f, -1.16554819e-01f, -1.11937955e-01f, -2.39033267e-01f, 1.39906585e-01f, -1.78687453e-01f, -7.16184452e-02f, -4.00585979e-02f, -1.34402201e-01f,
  7.74749666e-02f, -7.64551805e-03f, -6.40543103e-02f, -7.43181854e-02f, 1.05505273e-01f, -1.12317473e-01f, -5.73217161e-02f, 5.33740520e-02f, 7.37107126e-03f, -5.70717454e-02f,
  9.59059894e-02f, -1.59509399e-03f, 1.25337467e-01f, 1.10481776e-01f, 1.27099812e-01f, -1.65765524e-01f, -1.56840011e-01f, -2.99891941e-02f, 1.35398552e-01f, -3.42476591e-02f,
  -1.41552418e-01f, 3.14083584e-02f, 1.03047103e-01f, 2.76458859e-02f, 7.67336935e-02f, -1.22080065e-01f, -1.00354450e-02f, -1.41928121e-01f, -1.51674464e-01f, 2.15374485e-01f,
  -2.25746274e-01f, -6.00103475e-02f, -2.18613341e-01f, 5.85943088e-02f, -3.83586995e-02f, -4.27997679e-01f, 2.33243376e-01f, 3.63799818e-02f, -4.35730442e-02f, 8.72107521e-02f,
  1.84511364e-01f, 2.44180977e-01f, -8.72278661e-02f, -2.57721424e-01f, -1.30449980e-01f, 4.85392809e-02f, 5.73835522e-02f, 1.28855761e-02f, -2.13158935e-01f, 2.60089175e-03f,
  1.62091881e-01f, -8.12723786e-02f, 1.07082255e-01f, -1.53126288e-02f, -1.79004118e-01f, 1.67693511e-01f, -1.07213221e-01f, 9.60359573e-02f, -1.88766584e-01f, 6.28839852e-03f,
  -4.40190695e-02f, -2.49998823e-01f, 6.88749701e-02f, 1.45230114e-01f, -1.50468573e-01f, -1.31795928e-01f, 2.85003167e-02f, 6.00477494e-02f, 7.18897730e-02f, 1.10400140e-01f,
  1.49053693e-01f, -1.45761549e-01f, 1.44754136e-02f, -1.41382292e-01f, -1.59469336e-01f, -3.71803492e-02f, -2.66815852e-02f, -5.63647822e-02f, -7.47682676e-02f, 3.34210880e-02f,
  1.22981399e-01f, 4.27093953e-02f, -1.49826393e-01f, -7.55090732e-03f, 4.74510938e-02f, -9.12862867e-02f, -3.95884737e-02f, -1.96303248e-01f, -7.31642300e-04f, 8.54903087e-02f,
  7.02604800e-02f, 3.34191233e-01f, 1.33196935e-01f, -1.11966729e-01f, 1.01656988e-01f, -1.79071888e-01f, 3.24743092e-02f, 1.18091561e-01f, -1.30679205e-01f, 1.66119769e-01f,
  -1.02127641e-01f, 5.91707975e-02f, -4.17962000e-02f, -6.95956349e-02f, 2.83429399e-02f, -1.42821684e-01f, -6.63869306e-02f, 2.38408998e-01f, 1.11042000e-01f, -2.37992108e-01f,
  1.21583946e-01f, -1.08098425e-02f, -1.36585072e-01f, 4.29818332e-02f, -1.15918435e-01f, 1.30961716e-01f, 1.15708597e-01f, 4.07491997e-02f, 1.41557559e-01f, -1.73236076e-02f,
  9.10113603e-02f, 8.81085843e-02f, 7.03285187e-02f, 2.23172396e-01f, 6.66214153e-02f, 4.09319624e-02f, -8.73799399e-02f, -1.29591048e-01f, 2.52921078e-02f, -7.64624923e-02f,
  1.18541539e-01f, -1.14756398e-01f, -3.63437869e-02f, -4.26566899e-02f, 2.54299864e-02f, -1.28231421e-01f, -1.21031076e-01f, 6.35152869e-03f, -2.02865545e-02f, 2.58177835e-02f,
  5.90046169e-03f, 6.92645535e-02f, -9.64279771e-02f, 4.68988456e-02f, 1.69708893e-01f, 5.88180274e-02f, 1.77563593e-01f, 9.58057120e-02f, 1.70969591e-01f, -1.14293337e-01f,
  -1.46932319e-01f, 2.81029548e-02f, -4.36589047e-02f, 1.08282752e-01f, 4.94970344e-02f, 4.66241501e-02f, 4.07534540e-02f, -2.61411309e-01f, 2.07536027e-01f, 6.10301793e-02f,
  3.34455110e-02f, 1.11972339e-01f, -8.68352801e-02f, 1.73843235e-01f, -2.55217552e-01f, 1.29922166e-01f, 1.19476147e-01f, -7.07711503e-02f, -1.88232675e-01f, -2.43486524e-01f,
  -1.49974778e-01f, 2.32398182e-01f, 9.53346193e-02f, -7.24794269e-02f, -1.54795662e-01f, -2.20938906e-01f, 5.84433414e-02f, -4.76017259e-02f, -1.62124321e-01f, 5.46778329e-02f,
  -5.37478812e-02f, -1.06597610e-01f, 4.51015458e-02f, 1.56046711e-02f, -1.12701565e-01f, 1.33772582e-01f, 5.47838733e-02f, 4.98638004e-02f, 3.26306708e-02f, 2.67472476e-01f,
  2.96953712e-02f, -3.19868512e-02f, -3.11453100e-02f, -8.45854878e-02f, 8.71459991e-02f, -8.51103440e-02f, -1.47234676e-02f, 1.29221916e-01f, 2.29211710e-02f, 7.79651329e-02f,
  9.44254512e-04f, 1.35619074e-01f, -2.54993532e-02f, -5.05892225e-02f, 4.90672365e-02f, 2.43432671e-02f, 1.87083989e-01f, -1.73496619e-01f, 2.40255520e-02f, 2.38424931e-02f,
  -6.20371923e-02f, 5.13415560e-02f, 8.79770443e-02f, 3.81128155e-02f, 1.09331109e-01f, 8.55497830e-03f, -6.39537945e-02f, -1.81088850e-01f, -2.22106323e-01f, 1.67825297e-01f,
  1.81510538e-01f, 7.21927583e-02f, 1.56453446e-01f, -5.39202914e-02f, -1.96775228e-01f, -2.51024812e-02f, 6.05969094e-02f, 7.01049715e-02f, 2.20062479e-01f, 6.33509085e-02f,
  -6.16519433e-03f, 6.80960044e-02f, 2.33069718e-01f, 3.40854451e-02f, 1.02037832e-01f, 6.58303350e-02f, 3.54027785e-02f, -3.58577557e-02f, 1.28489196e-01f, 7.86624998e-02f,
  1.33733302e-01f, 1.60077568e-02f, -5.00224531e-02f, 1.00310475e-01f, -5.45910634e-02f, 1.94389168e-02f, 1.09756114e-02f, -1.45529017e-01f, -5.30765690e-02f, 8.28569680e-02f,
  -1.29211113e-01f, 1.04481548e-01f, -5.39055839e-02f, -1.14401400e-01f, -6.36481717e-02f, -1.12814248e-01f, 2.46406402e-02f, 6.78150654e-02f, 4.41617286e-03f, 3.53077687e-02f,
  -5.31314500e-02f, 3.21092503e-03f, -1.52577400e-01f, -1.33553222e-01f, -2.10890651e-01f, 4.59488556e-02f, 4.11511771e-02f, -5.12785576e-02f, -8.76742825e-02f, 1.11685604e-01f,
  -2.44294573e-02f, -1.79651994e-02f, 1.09073162e-01f, -7.00948983e-02f, -7.05285966e-02f, -1.41889617e-01f, -4.15902138e-02f, 9.11083519e-02f, 3.76327448e-02f, 5.40443975e-03f,
  8.91019870e-03f, 2.42985096e-02f, 2.97791302e-01f, -1.55728668e-01f, -2.09055264e-02f, -1.82387978e-01f, -2.25071549e-01f, 9.33067873e-02f, 3.21433246e-01f, -2.31963024e-02f,
  -4.91303615e-02f, -1.26405224e-01f, -3.83839756e-02f, 1.21114053e-01f, 2.73342635e-02f, 2.14286625e-01f, -1.12351459e-02f, -2.30479971e-01f, 4.90317270e-02f, -1.32037029e-01f,
  -1.66088164e-01f, 6.90238625e-02f, -1.45894483e-01f, 9.14458930e-02f, -2.43313834e-01f, 3.43267322e-01f, 1.04472406e-01f, 3.25806960e-02f, 6.21966459e-02f, -4.57207076e-02f,
  -7.17230812e-02f, -6.06384203e-02f, -5.47783747e-02f, 3.88716199e-02f, 2.26323873e-01f, -1.26669779e-01f, -2.46011447e-02f, -1.30669221e-01f, -6.87636435e-02f, 5.72179332e-02f,
  1.45215735e-01f, 2.44721957e-03f, 1.73022002e-01f, 9.64655206e-02f, 7.84255713e-02f, 8.47664848e-02f, -3.13396044e-02f, 1.36901796e-01f, 1.84144557e-01f, 1.21186905e-01f,
  5.54880127e-02f, 3.76229919e-02f, 4.64022197e-02f, -4.24720533e-02f, 7.40295425e-02f, 1.67365551e-01f, 1.14968084e-02f, 1.02113135e-01f, 1.94120198e-01f, 8.91104434e-03f,
  -1.36167809e-01f, 1.64057508e-01f, -4.27065268e-02f, 1.26309544e-01f, 1.15357839e-01f, 5.78300171e-02f, -5.32877147e-02f, -3.37403804e-01f, -3.72021377e-01f, 1.76189631e-01f,
  -3.47973295e-02f, 2.55232036e-01f, 5.21398522e-02f, -1.78794339e-01f, 3.61267626e-02f, 1.49460905e-03f, -1.27664849e-01f, 4.30491269e-02f, 2.70069111e-02f, -3.44912037e-02f,
  -1.60151005e-01f, 3.81415375e-02f, 3.09752077e-02f, -2.52639860e-01f, 6.44669458e-02f, 1.59117341e-01f, -2.52628654e-01f, 1.34836003e-01f, 1.96950529e-02f, 1.16911799e-01f,
  -1.11168049e-01f, -1.83232263e-01f, -1.46574616e-01f, -1.30750211e-02f, 6.95487764e-03f, 1.24982566e-01f, -2.43429262e-02f, -2.51928177e-02f, 1.65430278e-01f, -1.65527090e-01f,
  1.93424627e-01f, 5.41220568e-02f, -5.75747713e-03f, 1.04854636e-01f, 1.13140509e-01f, -1.34557217e-01f, 3.82656418e-02f, 2.81038415e-03f, -1.02774927e-03f, 5.71639203e-02f,
  -1.29734024e-01f, 4.50330414e-02f, -6.50468618e-02f, 9.96048450e-02f, 9.90738049e-02f, 1.71693172e-02f, -9.52571854e-02f, -9.08660702e-03f, 4.08222079e-02f, 4.75858571e-03f,
  -1.90138984e-02f, 4.66904640e-02f, 2.18280345e-01f, -1.20183915e-01f, -9.18180346e-02f, 2.96678976e-03f, -1.34841368e-01f, -8.14150125e-02f, -1.93021707e-02f, 1.30090028e-01f,
  1.29832447e-01f, -3.27007473e-01f, -1.56590208e-01f, -6.39930600e-04f, 5.12358360e-03f, 2.55848557e-01f, 9.33864936e-02f, -1.17169447e-01f, 9.90279913e-02f, -3.43054160e-02f,
  -7.35061690e-02f, 6.11566938e-02f, 4.26602922e-02f, 5.90532236e-02f, -8.96795988e-02f, 9.79687721e-02f, 3.90133448e-02f, -2.54867524e-01f, -7.58570060e-02f, 1.13170885e-01f,
  -2.95418203e-01f, 9.29686874e-02f, 2.30924245e-02f, -3.83217782e-02f, 8.74517635e-02f, -5.95970377e-02f, -9.35007110e-02f, -9.70709100e-02f, 5.88610247e-02f, 1.22983363e-02f,
  1.32443696e-01f, 4.12459075e-02f, 1.87753066e-01f, -2.61384845e-01f, -2.32742224e-02f, -2.89333239e-02f, 1.02141485e-01f, 1.66817665e-01f, -3.30109298e-02f, 5.12597822e-02f,
  -3.53466673e-03f, 1.32497594e-01f, -7.77453482e-02f, 1.21061973e-01f, -1.97666153e-01f, -1.69946011e-02f, -1.84925705e-01f, 2.00861264e-02f, 2.05670670e-01f, -3.69565003e-02f,
  -1.96590453e-01f, 8.25481862e-02f, -1.28230616e-01f, 1.89599618e-01f, 1.60971209e-01f, 9.29342955e-03f, 5.10176495e-02f, -6.43880516e-02f, -1.91587470e-02f, 1.34681975e-02f,
  -8.92886370e-02f, -4.23389208e-03f, -1.40537191e-02f, 1.02690898e-01f, 2.69653022e-01f, -1.79613233e-02f, -7.34046847e-02f, -2.68395960e-01f, 3.55381742e-02f, 1.02888137e-01f,
  2.30032340e-01f, 1.02127351e-01f, -5.52364998e-02f, 6.37304271e-03f, -2.22593561e-01f, -1.81896642e-01f, 7.60406852e-02f, -3.87329049e-02f, -1.47426099e-01f, -1.24946386e-01f,
  -1.51939183e-01f, 2.65972987e-02f, 2.72939131e-02f, 3.09485663e-02f, -2.16857508e-01f, 1.02672823e-01f, 6.80235550e-02f, 2.87667125e-01f, -1.05933949e-01f, -3.33243259e-03f,
  -2.13305112e-02f, 8.58910456e-02f, 8.02285150e-02f, -1.13671914e-01f, 1.75281968e-02f, 4.77463305e-02f, -4.18731617e-03f, -1.48399577e-01f, 1.12919332e-02f, 2.56207913e-01f,
  -6.80982322e-02f, 1.22520201e-01f, -1.17268071e-01f, 9.44838449e-02f, -6.86762184e-02f, -3.58479433e-02f, -1.37746081e-01f, 2.72831675e-02f, -9.37966704e-02f, -5.58792092e-02f,
  -2.38865800e-02f, -1.88713253e-01f, -2.39330493e-02f, 1.32083848e-01f, 1.54811540e-03f, -1.98247060e-02f, -3.11037619e-02f, -3.58104184e-02f, 8.92541707e-02f, -1.06472291e-01f,
  -8.70092958e-02f, 4.82928790e-02f, -1.70343161e-01f, 4.15035002e-02f, -1.81013346e-01f, -2.01233122e-02f, -1.52201831e-01f, 7.46792480e-02f, -5.30430451e-02f, -1.05451876e-02f,
  1.26956210e-01f, -1.93769485e-01f, -1.47263750e-01f, -1.47020236e-01f, -1.12078540e-01f, 3.07212263e-01f, -2.69131541e-01f, -1.10527379e-02f, -1.02874532e-01f, -3.27896178e-01f,
  -6.04854152e-02f, -2.45445609e-01f, -3.28297471e-03f, -8.31108019e-02f, -3.76569360e-01f, 1.03497006e-01f, 6.34226277e-02f, 1.54965729e-01f, 1.20133206e-01f, -2.51445472e-01f,
  1.71372086e-01f, 6.94930032e-02f, -9.19509381e-02f, -3.23754698e-02f, 8.40338394e-02f, -9.88413487e-03f, 1.21330112e-01f, -7.80732036e-02f, 7.04416633e-02f, -7.53131583e-02f,
  -8.86676684e-02f, -3.32975946e-02f, -1.84808761e-01f, 1.44694122e-02f, 1.41934097e-01f, 5.47950566e-02f, 1.54754236e-01f, -8.15859288e-02f, -1.54157439e-02f, -1.46833733e-02f,
  1.16000876e-01f, 8.48338977e-02f, -8.85782242e-02f, -1.66696217e-02f, -1.29079133e-01f, 1.27213076e-01f, -1.17042445e-01f, -4.67393808e-02f, -1.97611060e-02f, -1.10430340e-03f,
  1.88954622e-01f, -1.85816046e-02f, -1.17711820e-01f, -5.90506569e-02f, -1.16216287e-01f, -1.39745921e-01f, 4.66698557e-02f, -9.82720256e-02f, 1.12407237e-01f, -6.84728920e-02f,
  1.65661544e-01f, -1.27850518e-01f, 8.43835846e-02f, -1.28603294e-01f, 5.58919087e-02f, -6.51085563e-03f, -1.79373518e-01f, 8.72218460e-02f, 1.05259642e-02f, -2.44381785e-01f,
  2.03697383e-01f, -1.55820400e-01f, 2.03790694e-01f, 6.83529302e-02f, -3.06917410e-02f, 3.70788425e-01f, 1.98085859e-01f, 3.99719961e-02f, 2.92447627e-01f, -1.24742128e-01f,
  -2.36380119e-02f, -1.87038302e-01f, 1.77466750e-01f, 3.19786936e-01f, -3.54693651e-01f, -4.48055342e-02f, 9.87441763e-02f, 7.70131126e-02f, -6.97097555e-02f, 6.69325143e-02f,
  -8.50288346e-02f, -5.71237467e-02f, -2.93124039e-02f, 8.93321559e-02f, 2.92854644e-02f, 8.33242312e-02f, 8.55478719e-02f, -2.66971439e-01f, 1.37283411e-02f, 5.63488416e-02f,
  -9.42083448e-02f, 1.05043268e-02f, 7.55632762e-03f, 5.48049584e-02f, 7.43440092e-02f, 6.69751316e-02f, -3.46343890e-02f, -1.32220790e-01f, 4.62830216e-02f, 5.26634604e-02f,
  3.03458590e-02f, 2.12842152e-02f, 7.56119937e-02f, 5.05144559e-02f, -9.33576971e-02f, 4.28577214e-02f, 1.43106252e-01f, 9.96559933e-02f, 2.89830398e-02f, -6.98679984e-02f,
  -3.78358588e-02f, 6.41467869e-02f, -1.11359414e-02f, -7.36851692e-02f, -8.89601465e-03f, 7.26897642e-02f, 3.48000079e-02f, 1.28575683e-01f, -9.82084963e-03f, -1.33449554e-01f,
  -3.37460786e-02f, -1.39843643e-01f, -1.39000282e-01f, 1.93749070e-01f, -2.35590965e-01f, 1.64005429e-01f, -5.57276942e-02f, -2.59053588e-01f, 8.52142572e-02f, -2.93454945e-01f,
  -7.12728053e-02f, 5.65707944e-02f, -2.69055575e-01f, 2.96617654e-04f, -2.53965557e-02f, 4.06693220e-02f, -4.67419401e-02f, -2.59072751e-01f, 2.44008318e-01f, 9.20083001e-02f,
  -9.46861655e-02f, -3.80362794e-02f, -1.44500792e-01f, 3.80607210e-02f, 4.31201328e-03f, -1.00963838e-01f, -2.90299822e-02f, -1.12029739e-01f, -3.52156758e-02f, 8.78030434e-02f,
  -5.92765100e-02f, 1.93469763e-01f, 6.37945309e-02f, 9.32535157e-02f, -3.82915251e-02f, -1.14487426e-03f, -5.92100769e-02f, -9.10783187e-02f, -1.96975265e-02f, 8.13139323e-03f,
  1.36705011e-01f, -7.90029839e-02f, -4.43690754e-02f, -5.27284108e-02f, -8.00343081e-02f, 8.17613825e-02f, -1.16767585e-01f, 2.27729455e-02f, 8.80711079e-02f, 6.03384664e-03f,
  7.67573044e-02f, -1.48333907e-01f, -6.44570366e-02f, 9.02996436e-02f, -1.31367929e-02f, 5.78112714e-02f, -8.47015902e-02f, 5.17896339e-02f, 1.14450678e-01f, -1.77205592e-01f,
  -5.58149144e-02f, 1.20793156e-01f, 1.09926164e-01f, -1.30715117e-01f, -1.12446092e-01f, -9.96397287e-02f, -1.18964352e-01f, 8.04120973e-02f, -5.97087257e-02f, 2.69503687e-02f,
  1.02501534e-01f, -2.20966488e-01f, 1.18558683e-01f, 1.86825082e-01f, 2.46934205e-01f, -1.37936994e-01f, 5.12685739e-02f, 3.05121571e-01f, 1.26496375e-01f, -1.45237803e-01f,
  2.32840523e-01f, -8.03620294e-02f, -3.37831192e-02f, 1.82653636e-01f, 2.64618546e-02f, -7.29716895e-03f, 5.82768284e-02f, -9.33309868e-02f, 1.04245216e-01f, -1.64579779e-01f,
  -1.19633265e-01f, -1.92784816e-02f, -7.85492361e-02f, -9.25057232e-02f, -1.42475829e-01f, 2.01671243e-01f, 1.13378987e-01f, -3.11408322e-02f, 3.32676172e-02f, 1.18622929e-01f,
  1.49775907e-01f, -8.29336867e-02f, 2.09277216e-02f, -1.43398926e-01f, -2.34674454e-01f, 5.50445765e-02f, 1.02734871e-01f, 3.87138091e-02f, 9.30272415e-02f, -6.34268671e-02f,
  -7.10492507e-02f, -1.08759277e-01f, 2.71331724e-02f, 1.59209233e-03f, -7.10192928e-03f, 9.31858644e-02f, 1.28084034e-01f, 6.32124543e-02f, -1.34353518e-01f, 1.01475589e-01f,
  -1.02732651e-01f, -3.43501684e-03f, 1.22968532e-01f, -9.08009857e-02f, 8.37020129e-02f, -2.20005825e-01f, -3.10691446e-01f, 2.68135592e-02f, 4.65080515e-02f, 2.38751397e-01f,
  7.75832757e-02f, -1.56609520e-01f, 2.06866205e-01f, -7.66756237e-02f, -8.20886716e-02f, 1.77757263e-01f, -1.82525907e-02f, -3.36170606e-02f, -1.66555941e-01f, 1.29535317e-01f,
  1.51339337e-01f, -1.68819696e-01f, -1.16963066e-01f, 1.09232791e-01f, -1.41531095e-01f, 1.86730534e-01f, -2.00203076e-01f, -1.18697867e-01f, 2.11539883e-02f, 1.66863725e-02f,
  9.01256800e-02f, -1.63446352e-01f, -1.79633737e-01f, 3.27388905e-02f, -4.92360033e-02f, -1.36719614e-01f, 2.12339133e-01f, -2.75618315e-01f, -1.79573912e-02f, -1.45036295e-01f,
  6.72630444e-02f, 1.01140901e-01f, -1.73036963e-01f, -1.03348166e-01f, -4.44877446e-02f, -7.59533271e-02f, 9.98708420e-03f, 9.99054685e-02f, 2.00871989e-01f, -1.29077941e-01f,
  -7.88179412e-02f, -2.27794866e-03f, 1.13530578e-02f, -2.00335696e-01f, 6.58402145e-02f, -6.58268109e-02f, -1.99156016e-01f, -2.67231166e-02f, 2.36652675e-03f, -1.01104766e-01f,
  -2.92587467e-02f, -4.42330493e-03f, -4.73947302e-02f, -1.13610774e-01f, 5.47420047e-02f, 3.61290760e-02f, -1.40544429e-01f, 1.08529478e-01f, -2.50654429e-01f, 2.18717441e-01f,
  8.06461871e-02f, -1.07914701e-01f, 2.30793074e-01f, -6.61704764e-02f, -2.41446555e-01f, 1.15006857e-01f, -1.72337890e-01f, 7.40088001e-02f, -6.92043081e-02f, -4.63683382e-02f,
  5.59039488e-02f, -1.29534721e-01f, 3.74255180e-02f, -1.23947948e-01f, -2.73678035e-01f, 2.06146032e-01f, 4.16245423e-02f, -9.17201936e-02f, 4.12182063e-02f, -2.61800468e-01f,
  8.41530971e-03f, -3.12107980e-01f, 7.58043304e-02f, 9.78685394e-02f, -6.74925093e-03f, 1.19360067e-01f, 1.48958132e-01f, -4.48646732e-02f, 6.77338317e-02f, 1.26361772e-01f,
  -2.04768807e-01f, 2.63510108e-01f, -1.39927372e-01f, 1.02699719e-01f, -3.89231257e-02f, -1.46842271e-01f, -7.94895962e-02f, -5.02563827e-02f, 6.36961684e-02f, 1.66859075e-01f,
  1.29505768e-01f, 1.69875935e-01f, -1.13582417e-01f, 2.14188054e-01f, 1.07070491e-01f, 5.63479774e-02f, 2.08731204e-01f, -3.34742665e-02f, 5.45091406e-02f, -4.31711897e-02f,
  -2.67819520e-02f, 1.73308298e-01f, 2.96473317e-02f, 1.36538386e-01f, 4.64299805e-02f, 8.81850570e-02f, 6.39592782e-02f, 1.57693118e-01f, 3.61730456e-02f, 1.75949201e-01f,
  1.14967395e-02f, -1.59525797e-01f, -1.44230491e-02f, -2.76411176e-01f, -1.18874677e-01f, 1.02790862e-01f, -9.90322679e-02f, 1.66364700e-01f, 2.65278220e-02f, -1.99081212e-01f,
  -3.55397612e-02f, -8.70051607e-02f, 1.58797413e-01f, 6.77829906e-02f, -4.32491899e-02f, 1.01378843e-01f, 2.82207057e-02f, 2.81407118e-01f, 3.17156464e-01f, 3.43242921e-02f,
  1.39611840e-01f, 1.30897671e-01f, -2.21522197e-01f, 4.64610308e-02f, 1.63590442e-02f, -7.03289881e-02f, -1.38453469e-02f, 2.78720986e-02f, -7.80323520e-02f, -1.54723212e-01f,
  -1.76349670e-01f, 9.55335274e-02f, 5.72539568e-02f, -1.68694139e-01f, -7.31184930e-02f, -2.61376113e-01f, 7.86373913e-02f, 7.06211105e-02f, -2.54245605e-02f, 1.48035049e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  8.99221376e-02f, -8.50000158e-02f, 3.52158435e-02f, 8.70703161e-02f, -4.88858223e-02f, -1.19922929e-01f, -1.44139919e-02f, -3.01286019e-02f, -4.21827473e-02f, -2.88061481e-02f,
  6.26491681e-02f, 9.66469347e-02f, 1.72415730e-02f, -1.87811963e-02f, 7.76662782e-04f, 1.13101259e-01f, 8.04025605e-02f, 3.80677693e-02f, -7.91667178e-02f, -4.67080399e-02f,
  7.40767792e-02f, 5.83540313e-02f, 5.11994325e-02f, 1.12240486e-01f, 4.28690612e-02f, -4.33283634e-02f, 4.65581343e-02f, 3.94301899e-02f, -1.14256874e-01f, 5.19596599e-02f,
  4.66057099e-02f, 1.04193099e-01f, 8.40642005e-02f, 1.15762539e-01f, 5.09648435e-02f, -9.92531925e-02f, -1.27587900e-01f, 1.98355783e-02f, 8.61634612e-02f, 1.11600846e-01f,
  4.16819006e-02f, -8.76903310e-02f, 1.09642774e-01f, -6.64902478e-02f, 8.23910311e-02f, 1.35772958e-01f, -6.86347485e-02f, 1.11939736e-01f, 1.00911804e-01f, 1.10921532e-01f,
  4.88084145e-02f, 1.38851963e-02f, -2.92367972e-02f, -6.15568571e-02f, -1.89479422e-02f, 1.39866337e-01f, 4.98947836e-02f, 3.05243712e-02f, 6.33906871e-02f, -1.13851778e-01f,
  -3.79585549e-02f, -1.94733078e-03f, 5.78454398e-02f, -7.42126182e-02f, 4.51103896e-02f, 2.35041175e-02f, 2.91185230e-01f, 7.85930604e-02f, 3.90862860e-02f, 2.95279592e-01f,
  8.63682777e-02f, 1.76670074e-01f, 4.27024141e-02f, 8.06908384e-02f, 2.44160593e-01f, 2.27940112e-01f, 7.22275153e-02f, 1.24272436e-01f, 1.76807106e-01f, 1.86437264e-01f,
  2.06106380e-01f, 4.93164584e-02f, 1.28164818e-03f, 2.12052837e-02f, 2.49339461e-01f, 1.64642006e-01f, 3.57034914e-02f, 9.15820003e-02f, 6.41271397e-02f, -4.19388302e-02f,
  -7.19045922e-02f, -1.00329891e-01f, -1.65203631e-01f, -9.34361368e-02f, 2.82553792e-01f, 3.01316809e-02f, -1.08105792e-02f, -2.75777429e-01f, 3.07101328e-02f, 2.86466241e-01f,
  -3.07153523e-01f, 5.56208231e-02f, -8.29148814e-02f, 3.93050760e-02f, -7.71446750e-02f, 1.14287890e-01f, 2.26336122e-01f, 2.38865986e-01f, -7.10593984e-02f, -4.51307222e-02f,
  -1.99072137e-01f, -1.01055652e-02f, 8.26576576e-02f, 3.55185866e-02f, -1.28504619e-01f, 7.75795281e-02f, -1.06651992e-01f, -8.48348439e-02f, -2.35241023e-03f, -1.39020607e-01f,
  1.14851274e-01f, 1.04446627e-01f, 2.90160328e-01f, -1.81072220e-01f, 2.72149265e-01f, 1.20844558e-01f, -7.00618029e-02f, -5.23576736e-02f, 5.86649477e-02f, 5.86712621e-02f,
  8.47831368e-02f, 2.32683569e-02f, -3.38738598e-02f, 9.07335132e-02f, 1.35552585e-02f, 3.16327880e-03f, 1.95477232e-01f, 5.31285815e-02f, 2.03378305e-01f, 8.05604309e-02f,
  -4.81835082e-02f, -5.08120237e-03f, -4.13006954e-02f, 3.98185104e-03f, 1.68145731e-01f, 1.01376034e-01f, 4.93520685e-02f, 1.86716735e-01f, -7.62452260e-02f, 1.46756008e-01f,
  3.50387618e-02f, -5.19249216e-02f, 1.53466776e-01f, 9.76234153e-02f, -9.24333483e-02f, 3.01829949e-02f, 1.28498435e-01f, -8.17840844e-02f, -1.49297968e-01f, 2.35824771e-02f,
  -5.22034094e-02f, 1.72011808e-01f, 3.72621343e-02f, -2.13464364e-01f, 1.22776277e-01f, -2.56767690e-01f, -9.68106166e-02f, -1.10090338e-01f, 1.65632308e-01f, -3.90275158e-02f,
  -1.88258961e-01f, 4.70273793e-02f, -5.06091416e-02f, -1.21497987e-02f, -6.96326271e-02f, 4.81109768e-02f, -2.29436997e-02f, 1.09952740e-01f, -6.50473312e-02f, 1.35002837e-01f,
  -9.44987684e-02f, -9.20635164e-02f, 9.21906251e-03f, 1.36012986e-01f, 2.68037729e-02f, 6.35819361e-02f, 5.82809448e-02f, 9.33638662e-02f, -7.86431134e-02f, 5.51340282e-02f,
  8.28943029e-03f, 8.07146057e-02f, -1.38136232e-02f, 1.71159618e-02f, -6.48017079e-02f, -2.62037739e-02f, -7.77153745e-02f, -1.14143416e-01f, -7.47566596e-02f, -5.11856936e-02f,
  1.36932526e-02f, 1.17719300e-01f, -1.02890097e-01f, -8.27855393e-02f, 9.47486684e-02f, 2.52804980e-02f, 5.60634658e-02f, 3.62217948e-02f, -1.05082013e-01f, 9.77435149e-03f,
  4.28339802e-02f, -1.86186396e-02f, -1.75955556e-02f, -4.20991555e-02f, -1.74834859e-02f, 1.83095168e-02f, -3.81804034e-02f, -1.81367919e-02f, 2.31086668e-02f, -1.43672138e-01f,
  -2.93866228e-02f, -8.43144134e-02f, -1.07044958e-01f, 1.26801506e-01f, 1.85823522e-03f, 3.71416695e-02f, -1.10981293e-01f, -8.72514173e-02f, 9.32324678e-02f, -1.16493464e-01f,
  -7.87906174e-05f, 1.28426999e-01f, 3.45855244e-02f, 4.84980009e-02f, 1.35791659e-01f, -3.03304233e-02f, -3.54329124e-02f, 1.71255693e-01f, -1.13991141e-01f, 6.21541813e-02f,
  -7.18793273e-02f, 4.35135290e-02f, 7.36916959e-02f, 1.95510630e-02f, -9.52906068e-03f, 1.39184982e-01f, -1.32935464e-01f, 1.23053372e-01f, -5.33544044e-05f, 2.75025275e-02f,
  -9.51118767e-02f, 1.05956197e-01f, -8.47093612e-02f, 4.35160249e-02f, 2.60679852e-02f, -2.13222150e-02f, 5.15411049e-02f, -4.45606075e-02f, 9.98457074e-02f, -7.52924979e-02f,
  -1.27330422e-01f, 9.61601958e-02f, -2.24383902e-02f, 6.78053796e-02f, -1.41649898e-02f, -6.33627176e-02f, 2.00412385e-02f, -1.09902084e-01f, 8.84328783e-02f, -1.24745198e-01f,
  6.45776317e-02f, -2.69610062e-02f, -9.81132593e-03f, 6.48086239e-03f, 2.04217783e-03f, 1.26285106e-01f, -3.26702669e-02f, 5.92306219e-02f, -1.18901424e-01f, 2.59122923e-02f,
  -3.92948315e-02f, 4.42127138e-02f, 5.37588669e-04f, -8.94046649e-02f, 8.87218863e-02f, 6.99843094e-02f, 3.88156623e-02f, 2.40513589e-02f, 1.50253363e-02f, 1.23655654e-01f,
  8.80659372e-03f, 6.99663088e-02f, 6.45241886e-02f, -2.32629795e-02f, 2.05016043e-02f, -1.24556078e-02f, -8.93683508e-02f, 6.20724633e-02f, 1.10658720e-01f, 3.80708016e-02f,
  -4.64295335e-02f, -1.02868259e-01f, 4.17518802e-02f, -1.29854195e-02f, -7.15095475e-02f, 1.20085984e-01f, -4.36325651e-03f, -1.24082407e-02f, -7.92034566e-02f, 1.69786308e-02f,
  -5.59598207e-02f, -4.85775396e-02f, -1.08434379e-01f, -9.58765112e-03f, -9.56904218e-02f, -6.04370609e-03f, 6.97227716e-02f, -7.88126960e-02f, -8.12399536e-02f, 1.85663924e-02f,
  9.72910747e-02f, 7.05303326e-02f, 1.62447259e-01f, -5.98842502e-02f, 2.21185777e-02f, -1.14475787e-01f, 1.45556822e-01f, -7.19316080e-02f, -6.01319633e-02f, 3.68012972e-02f,
  -3.95496748e-02f, 8.23899955e-02f, 1.30156130e-01f, 3.47571932e-02f, -1.64664790e-01f, 1.07299574e-01f, 3.28613855e-02f, 8.43505710e-02f, -5.67382760e-03f, 1.09979488e-01f,
  -8.83293673e-02f, 5.99401332e-02f, 2.26873290e-02f, 7.25521967e-02f, 1.20945998e-01f, 1.23665385e-01f, -2.45726615e-01f, -1.71009190e-02f, -2.14360163e-01f, 1.02140851e-01f,
  2.15407491e-01f, 1.35057062e-01f, 3.10159624e-02f, 5.57497032e-02f, -2.08089590e-01f, 3.52323800e-01f, -3.38111162e-01f, -1.19888566e-01f, 6.71516359e-03f, -2.59281814e-01f,
  -1.57308549e-01f, -2.50392742e-02f, -1.46364123e-01f, -2.19639633e-02f, -6.25391155e-02f, 2.68143624e-01f, -1.02782808e-01f, -3.01983356e-01f, 2.12564901e-01f, -2.50705749e-01f,
  -5.16044535e-02f, 8.10421631e-02f, 1.94587801e-02f, -1.02561824e-01f, 2.33158782e-01f, 3.50289233e-02f, -4.57174517e-02f, -1.85100302e-01f, 5.61853573e-02f, 8.54500756e-02f,
  -1.61801931e-03f, 2.04362750e-01f, 1.08133391e-01f, -2.59730723e-02f, 1.10093065e-01f, 1.42959222e-01f, 1.89811051e-01f, -7.45203793e-02f, 7.71522596e-02f, 5.02861030e-02f,
  -1.01478226e-01f, 6.23394921e-02f, 8.13470408e-02f, 3.09561216e-03f, 9.58063006e-02f, 2.15329856e-01f, 1.69853821e-01f, 7.73846954e-02f, 1.25922322e-01f, 9.76654589e-02f,
  9.45219919e-02f, 4.23294120e-02f, 8.09794664e-02f, 1.02322258e-01f, 2.81307787e-01f, 7.19080418e-02f, 1.16929524e-01f, 2.70147226e-03f, 1.41942814e-01f, -1.81972116e-01f,
  -1.97045982e-01f, 1.89127803e-01f, 2.08205432e-01f, 4.09223363e-02f, 1.51241347e-01f, 3.00884414e-02f, -1.57459192e-02f, 4.20814119e-02f, -1.44496253e-02f, 8.72869715e-02f,
  -1.01687104e-01f, -1.12430058e-01f, -2.06156448e-03f, -1.82818577e-01f, 8.12637955e-02f, 1.81218967e-01f, 1.33676678e-01f, 2.58676440e-01f, -5.60613200e-02f, 2.19118479e-03f,
  1.15194626e-01f, -2.14036852e-01f, 6.11264668e-02f, -1.85050011e-01f, -9.62880149e-04f, 1.78331345e-01f, 9.66686103e-03f, -1.15251541e-01f, 1.13861769e-01f, -6.13795081e-03f,
  4.27931473e-02f, 1.68782741e-01f, -1.01393722e-01f, 2.83024311e-01f, -1.10445425e-01f, 1.73129156e-01f, 5.49903587e-02f, -2.00996757e-04f, 7.06388196e-03f, 1.01128310e-01f,
  1.32147431e-01f, 7.38295391e-02f, 1.63251068e-02f, 8.63873735e-02f, 1.09671883e-01f, 1.17934808e-01f, -9.62510929e-02f, 1.35174081e-01f, 5.37754558e-02f, 6.80895895e-02f,
  7.95301571e-02f, 5.58204576e-03f, 6.58830181e-02f, 3.94042395e-02f, 1.76029801e-01f, -4.67126295e-02f, -9.16001499e-02f, 1.32298380e-01f, 1.85180560e-01f, -7.54218698e-02f,
  1.32639706e-01f, -1.85113251e-02f, -2.26189476e-02f, -1.07181966e-01f, 1.67332664e-01f, 1.42541766e-01f, 6.59906045e-02f, -6.16355054e-02f, -3.72513123e-02f, 1.48742869e-01f,
  5.17441146e-02f, -9.54951048e-02f, 1.46867573e-01f, 1.48647040e-01f, 8.37244242e-02f, 6.88710064e-02f, 2.30193604e-02f, 7.65948296e-02f, 7.79653192e-02f, -1.38073951e-01f,
  1.28317326e-01f, 1.68429956e-01f, 3.07175480e-02f, 1.02326246e-02f, -5.62414601e-02f, 3.13117988e-02f, -3.00729554e-02f, 1.51913390e-01f, 1.02099985e-01f, -8.45253319e-02f,
  -8.40853825e-02f, -2.25717127e-02f, -1.13262363e-01f, -9.05250758e-02f, -6.50869682e-02f, 1.72498271e-01f, 5.37138283e-02f, 8.01183924e-04f, -3.23721990e-02f, -2.76365457e-03f,
  -1.73593462e-02f, -6.64750636e-02f, 9.25354809e-02f, 8.02121386e-02f, -4.50858660e-02f, 9.03903618e-02f, 1.61929905e-01f, 1.03221983e-01f, -1.31293103e-01f, 1.45667633e-02f,
  1.63313612e-01f, 1.21884741e-01f, 9.43636801e-03f, -3.85548919e-02f, 9.14917961e-02f, 9.70139876e-02f, -2.22883211e-03f, 8.68119821e-02f, -4.30187657e-02f, 1.28912330e-01f,
  2.01895967e-01f, 1.66847363e-01f, 5.87827712e-02f, 1.00546867e-01f, 1.95705280e-01f, 1.95275899e-02f, 1.51255965e-01f, 9.05020609e-02f, -1.70164376e-01f, -2.12047800e-01f,
  -1.93321079e-01f, 1.10936366e-01f, 1.38697833e-01f, -4.02400605e-02f, -9.47344303e-02f, -1.44297943e-01f, 2.67649926e-02f, 4.14208621e-02f, -8.58563185e-02f, -4.58837673e-02f,
  9.74256080e-03f, -1.61419630e-01f, -6.24434166e-02f, 1.84656382e-02f, -1.64060425e-02f, -1.07342355e-01f, 2.67809629e-02f, 2.50671327e-01f, -1.07895516e-01f, 8.66148323e-02f,
  -3.94498371e-02f, -2.03967318e-01f, -4.33780365e-02f, -3.51707935e-02f, -6.48563579e-02f, 1.06644407e-01f, 4.81889062e-02f, 9.96700302e-02f, -7.64325485e-02f, -6.94106817e-02f,
  1.07906453e-01f, -3.19915381e-03f, 1.28443584e-01f, 1.18625566e-01f, 2.16503558e-03f, 3.93990101e-03f, 6.53273985e-02f, 6.40334859e-02f, 9.37455148e-02f, 7.40065053e-02f,
  1.41801924e-01f, -3.04191578e-02f, -1.02010690e-01f, 9.85485241e-02f, 9.01419595e-02f, 1.48127601e-01f, 2.26236451e-02f, 2.56043971e-01f, -1.12847440e-01f, 5.84823526e-02f,
  -2.68996302e-02f, 1.74255759e-01f, 2.18203902e-01f, 1.39798492e-01f, -3.50971916e-03f, -3.87739353e-02f, 7.43369758e-02f, 5.59167974e-02f, 4.96582575e-02f, 1.74935281e-01f,
  4.64169495e-03f, 1.21304035e-01f, 5.63465394e-02f, 7.30785429e-02f, -6.02101125e-02f, -1.47270694e-01f, 6.56920373e-02f, -4.10875725e-03f, 7.03224987e-02f, 1.46587640e-01f,
  1.19233327e-02f, 2.91276854e-02f, -3.30388248e-02f, -2.49973342e-01f, 1.23144291e-01f, -1.27895892e-01f, -3.02178897e-02f, -1.40987903e-01f, -2.03389861e-02f, 8.89833719e-02f,
  -3.66118811e-02f, 1.05549514e-01f, -8.10200125e-02f, -1.83770612e-01f, 6.75302520e-02f, 1.83024436e-01f, -1.44164175e-01f, -2.33543850e-02f, -9.53206643e-02f, 1.04584850e-01f,
  1.50160208e-01f, 5.69802709e-02f, -1.09097116e-01f, 3.76713066e-03f, 1.19618839e-02f, 9.01804268e-02f, -1.10987924e-01f, 1.93041772e-01f, 8.58201534e-02f, 6.48624450e-02f,
  1.06003910e-01f, -1.09577462e-01f, 7.04691112e-02f, -1.12069231e-02f, 1.67395268e-02f, 1.33130401e-01f, 1.13673948e-01f, -7.96658546e-02f, -5.95614500e-02f, -2.16606464e-02f,
  -3.09155192e-02f, 9.14754346e-02f, 9.71784592e-02f, 7.15932027e-02f, 2.03122683e-02f, 1.89616188e-01f, 5.90434670e-02f, 1.22610494e-01f, 2.96576843e-02f, -5.89155182e-02f,
  5.06379418e-02f, 9.18839201e-02f, -6.87190816e-02f, -1.01988912e-01f, -3.81331146e-02f, 1.46284133e-01f, -8.47202018e-02f, -3.74378040e-02f, 1.40176564e-01f, 1.03442945e-01f,
  8.31093341e-02f, -2.74076685e-02f, -1.04526103e-01f, 9.12629738e-02f, -1.10123709e-01f, 2.64215082e-01f, -2.30565593e-01f, -7.37511665e-02f, -1.25242248e-01f, -1.00282371e-01f,
  -3.83977853e-02f, -5.25772630e-04f, -1.60527200e-01f, 4.83230874e-02f, -1.03257960e-02f, 7.89542537e-05f, 8.84190574e-02f, -2.25835949e-01f, 2.07154661e-01f, -1.60540208e-01f,
  8.70600641e-02f, -7.14599565e-02f, -1.17269807e-01f, 2.97783688e-03f, 8.67964849e-02f, -1.15887565e-03f, -7.26944879e-02f, 5.83570674e-02f, 9.04328153e-02f, 2.35981256e-01f,
  7.98680186e-02f, -1.01985559e-02f, 1.32072136e-01f, -9.18416604e-02f, 7.31234029e-02f, -5.69016971e-02f, 1.15188003e-01f, 4.12922874e-02f, 1.54750988e-01f, 2.16515049e-01f,
  1.51351064e-01f, 8.71807188e-02f, -8.01375359e-02f, 1.71128184e-01f, -7.87009299e-03f, 2.18593106e-01f, -1.78514924e-02f, 1.55052453e-01f, 1.48655757e-01f, -8.00142437e-03f,
  1.47955686e-01f, -1.18177913e-01f, 1.99202001e-02f, -1.83300339e-02f, 1.54143944e-01f, -1.28526939e-02f, 6.00138446e-03f, 7.23767728e-02f, 1.91203222e-01f, -1.79801509e-01f,
  8.35466534e-02f, 8.29681158e-02f, 2.01520264e-01f, -7.02332035e-02f, 1.46437570e-01f, 1.65753346e-02f, -1.01096064e-01f, -1.23092338e-01f, 9.21042487e-02f, 9.63492393e-02f,
  -4.47553247e-02f, -8.17687511e-02f, -3.38292830e-02f, 1.40837371e-01f, 1.04284585e-01f, 1.00618936e-02f, 1.90403283e-01f, 8.91076401e-02f, -1.18416943e-01f, -1.96467012e-01f,
  -1.60119087e-02f, 1.86260026e-02f, -3.98779847e-02f, 6.92498982e-02f, 1.13567293e-01f, 3.35718393e-02f, 1.29723057e-01f, -1.70510300e-02f, -6.93209171e-02f, -1.17069118e-01f,
  -6.75817654e-02f, 6.92947134e-02f, 1.47239521e-01f, 6.68216497e-02f, 1.49608962e-03f, -2.61977818e-02f, 8.75781626e-02f, 1.18163168e-01f, 4.06294018e-02f, 2.58751102e-02f,
  6.56686202e-02f, 4.25358601e-02f, -4.62250300e-02f, 5.40453196e-02f, 8.98579732e-02f, 2.30928168e-01f, 1.42373219e-01f, 1.59021065e-01f, -4.24450934e-02f, -1.12000585e-01f,
  -1.67693924e-02f, 9.23951194e-02f, 1.55237481e-01f, -1.13675326e-01f, 1.81343809e-01f, 1.91483542e-01f, 1.25644013e-01f, 9.98795331e-02f, -9.34860483e-02f, -4.23482945e-03f,
  6.56938329e-02f, 1.64369240e-01f, 2.21031696e-01f, 2.35908091e-01f, -1.52175084e-01f, -2.29054719e-01f, -7.66638375e-04f, -2.17001960e-01f, -2.43064195e-01f, 4.45497632e-02f,
  5.65505289e-02f, 1.81191400e-01f, -8.76038894e-02f, -2.93216288e-01f, 1.68915302e-01f, -1.79045215e-01f, 7.38824978e-02f, -1.21672161e-01f, 6.07738197e-02f, -2.66570542e-02f,
  -3.26460719e-01f, -2.68215805e-01f, -2.12706715e-01f, 1.70375451e-01f, 2.40784381e-02f, -2.09363252e-01f, -1.15269534e-01f, 1.89509034e-01f, -6.39968961e-02f, -1.48877189e-01f,
  -1.55903801e-01f, 6.92649856e-02f, -1.20460637e-01f, 3.09306026e-01f, 4.53216443e-03f, 1.49230599e-01f, -1.40223742e-01f, 3.84076566e-01f, -1.27147108e-01f, 1.47166282e-01f,
  7.60964528e-02f, -2.07468476e-02f, 6.75501004e-02f, 6.53296709e-02f, -6.76063299e-02f, 1.03359580e-01f, 6.62421063e-03f, -2.42012031e-02f, -6.63308278e-02f, 4.70844321e-02f,
  3.35689746e-02f, 8.31872001e-02f, 1.07034519e-01f, -4.74090800e-02f, 6.89574890e-03f, -5.73273450e-02f, -8.48253444e-02f, 1.00136578e-01f, 1.84055101e-02f, 1.20958947e-01f,
  1.12246044e-01f, -7.12651312e-02f, 1.08081505e-01f, 3.17486227e-02f, 1.28753833e-03f, -3.71169858e-02f, -1.17502015e-04f, 2.02987175e-02f, 1.02958828e-01f, -3.88055257e-02f,
  4.63768467e-02f, 1.95306819e-02f, -1.11997426e-01f, 2.02450715e-02f, -8.14176425e-02f, -7.55232424e-02f, 1.10044129e-01f, -1.50405597e-02f, -1.19514596e-02f, 1.37966650e-03f,
  -1.39032483e-01f, 1.23749867e-01f, -8.98403972e-02f, 1.31752163e-01f, 2.13596746e-02f, -5.57589717e-03f, -1.46809861e-01f, 1.87501200e-02f, -9.69853476e-02f, -3.26325558e-02f,
  1.02671124e-01f, 1.24944299e-01f, -2.26169229e-02f, -1.36930436e-01f, 8.90467986e-02f, -1.01057507e-01f, -6.50037676e-02f, 4.54928689e-02f, -7.93876648e-02f, 8.16260129e-02f,
  1.04202228e-02f, -1.15714513e-01f, -5.41747846e-02f, -1.03962444e-01f, 1.01786442e-01f, 1.42995015e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  -7.21883178e-02f, 2.36353874e-02f, 5.78202941e-02f, 8.72262046e-02f, -2.95730010e-02f, 6.86598495e-02f, 1.73623055e-01f, 2.01130584e-02f, -7.24623129e-02f, -2.83300374e-02f,
  -1.41289588e-02f, 1.40702352e-02f, 3.02336942e-02f, 1.20844468e-01f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  2.28647277e-01f, 1.03619978e-01f, -2.12616026e-01f, -4.05368418e-01f, 2.54159957e-01f, -7.11319745e-02f, -1.67255655e-01f, -1.72511920e-01f, 1.52196154e-01f, 1.82183623e-01f,
  1.73646301e-01f, 3.64313364e-01f, 4.89765257e-02f, -3.82903852e-02f, 2.67609715e-01f, 3.94483387e-01f, 7.49545470e-02f, 7.94357434e-02f, -9.81302559e-02f, -7.60070458e-02f,
  8.50449502e-02f, 1.39057711e-01f, 2.79542327e-01f, 2.51467913e-01f, 6.86937198e-02f, 8.44254494e-02f, 3.37112159e-01f, -4.91395772e-01f, -4.40139562e-01f, -8.76133963e-02f,
  3.06234777e-01f, -1.91044405e-01f, 4.08315688e-01f, 1.22918755e-01f, -4.80814837e-02f, 2.86674798e-01f, 1.57820046e-01f, -3.00530165e-01f, 1.45373821e-01f, -1.10167824e-01f,
  -4.15811576e-02f, -2.07530081e-01f, -2.46717244e-01f, -2.65211880e-01f, 4.05279368e-01f, -4.87773567e-01f, 2.81649292e-01f, -4.75582518e-02f, -7.30069503e-02f, 1.62530184e-01f,
  -1.31853819e-01f, 9.10989046e-02f, 1.61969274e-01f, -1.29174009e-01f, 8.33073854e-02f, -3.24680239e-01f, 5.12756221e-02f, 2.00834081e-01f, -1.81490585e-01f, -2.18415648e-01f,
  -2.89537311e-01f, 1.80011094e-01f, -3.85053128e-01f, -7.26076588e-02f, -1.80494949e-01f, 1.69582665e-01f, 3.29952687e-01f, 1.70705706e-01f, 7.97640011e-02f, 1.01439342e-01f,
  6.93657026e-02f, -4.66679603e-01f, -2.00722918e-01f, 2.83330642e-02f, 1.74737111e-01f, 1.38147637e-01f, 1.75932750e-01f, -2.49796569e-01f, -1.32287592e-01f, 1.85812041e-01f,
  -3.25342506e-01f, -8.98262560e-02f, 3.17535666e-03f, 2.91449189e-01f, 3.00887525e-01f, -1.08992465e-01f, -2.11847439e-01f, 1.25355825e-01f, 4.21507776e-01f, 4.47937071e-01f,
  -2.78502226e-01f, 4.43886667e-01f, -1.27696440e-01f, -3.74244541e-01f, -1.80656880e-01f, -1.21027283e-01f, 1.17195733e-01f, 2.95462817e-01f, 2.60033667e-01f, -3.09358507e-01f,
  4.54059601e-01f, 1.05248421e-01f, 2.46982813e-01f, -1.78239122e-01f, -2.41525665e-01f, -3.03594112e-01f, -4.05756891e-01f, -3.16497207e-01f, 2.14127153e-01f, -1.51017429e-02f,
  2.83651054e-01f, -4.55708861e-01f, 3.79453778e-01f, -3.19740802e-01f, -8.40649307e-02f, 2.38594655e-02f, -8.02179202e-02f, -5.76781966e-02f, -6.65249005e-02f, -9.35871825e-02f,
  2.66459972e-01f, 6.49578199e-02f, -2.80525181e-02f, -3.21482271e-02f, 1.01369282e-03f, 3.17104727e-01f, -2.73196250e-01f, -1.21311642e-01f, -9.80390087e-02f, -7.65611827e-02f,
  -3.50994229e-01f, 1.55398965e-01f, 1.62900835e-01f, -2.64598519e-01f, -5.73871769e-02f, -1.06977262e-02f, 4.42720726e-02f, -1.36743188e-01f, 1.18936941e-01f, 6.95818802e-03f,
  -2.66835187e-02f, -5.71056008e-02f, -1.81764111e-01f, 2.01971635e-01f, -2.50132978e-01f, -4.17232439e-02f, 5.76505959e-02f, -3.37586969e-01f, -3.99522632e-01f, -2.37000044e-02f,
  -3.15314800e-01f, -2.97333211e-01f, -5.32699116e-02f, 4.02510226e-01f, -5.27759679e-02f, 2.73477644e-01f, 1.02634609e-01f, -3.20586056e-01f, -2.88381964e-01f, 3.58306915e-01f,
  1.99027285e-01f, -1.01116218e-01f, 2.49456570e-01f, -1.35753900e-01f, 1.72472507e-01f, 2.25158557e-01f, 1.94635205e-02f, -1.48059368e-01f, -3.43239427e-01f, -1.96230620e-01f,
  -2.44697168e-01f, 4.09892678e-01f, -4.54358608e-01f, 3.05839300e-01f, -2.99604572e-02f, -1.17297053e-01f, 1.07447818e-01f, -4.35554326e-01f, -1.71259865e-01f, -1.76492780e-01f,
  -2.69419351e-03f, -4.47439477e-02f, 7.10816532e-02f, 3.43986511e-01f, 2.82843739e-01f, -1.45497262e-01f, -2.80262493e-02f, 8.47546309e-02f, 5.25759757e-01f, -1.25696093e-01f,
  -9.70542952e-02f, 3.69457691e-03f, 8.99389982e-02f, -1.01693325e-01f, -2.73378611e-01f, 1.53400302e-01f, 2.03361288e-01f, -1.80137485e-01f, -2.08455577e-01f, 4.03691921e-03f,
  7.58021325e-02f, 1.44311473e-01f, -4.44336981e-01f, -3.84900779e-01f, -3.27911705e-01f, 1.21740706e-01f, -1.45628557e-01f, -2.32917577e-01f, 2.68845866e-03f, 3.91715094e-02f,
  -1.95766315e-01f, -3.84779453e-01f, -1.76378176e-01f, 6.38002977e-02f, -2.07498655e-01f, -4.91012007e-01f, -3.23374242e-01f, -9.65605229e-02f, 1.52930275e-01f, -2.45393261e-01f,
  -2.05085009e-01f, 1.90034077e-01f, 3.05509984e-01f, -1.87591001e-01f, -2.21688420e-01f, -2.43126243e-01f, -5.07765636e-02f, 3.13084543e-01f, -2.99667865e-01f, -3.76206845e-01f,
  -2.10981801e-01f, 5.06238997e-01f, 1.97006226e-01f, 4.07959104e-01f, -1.50485054e-01f, -4.40785661e-02f, 2.47262016e-01f, -4.09198105e-01f, -1.17088303e-01f, 2.49327078e-01f,
  5.32614663e-02f, 1.69243291e-01f, 1.78766578e-01f, -3.41201156e-01f, -7.73755014e-02f, 2.78234452e-01f, -3.38523164e-02f, -1.56852916e-01f, -4.74462330e-01f, -6.56098267e-03f,
  2.48397030e-02f, -2.73918957e-01f, -1.47691980e-01f, -1.24236479e-01f, 9.43620577e-02f, 1.55675590e-01f, -1.09380506e-01f, 2.75143772e-01f, 1.28126359e-02f, 1.23616233e-01f,
  -5.07732868e-01f, 1.37562975e-01f, 1.05367072e-01f, 8.63051601e-03f, 2.05036804e-01f, 6.88135698e-02f, 2.66917318e-01f, -2.82191873e-01f, 3.66540760e-01f, -3.26623730e-02f,
  2.82268375e-01f, -3.52739245e-01f, -7.02137724e-02f, 1.95603818e-01f, 1.39726087e-01f, 4.98302996e-01f, 1.77844122e-01f, 1.01013042e-01f, -6.48985505e-02f, -3.47342074e-01f,
  -3.34437579e-01f, -2.05115363e-01f, 5.73984459e-02f, -4.20498192e-01f, -3.24812412e-01f, 3.19819272e-01f, 1.45759270e-01f, -4.42701988e-02f, -1.37265280e-01f, 7.89156035e-02f,
  -3.33499849e-01f, 4.25546438e-01f, -2.50845432e-01f, -2.69082636e-01f, -2.08612785e-01f, 2.66272992e-01f, -5.58616593e-02f, 2.66052604e-01f, 2.50156313e-01f, -2.75817990e-01f,
  1.52165174e-01f, 7.88130760e-02f, -3.03423673e-01f, 3.66200507e-01f, -3.46262187e-01f, 4.37320545e-02f, -2.47157831e-02f, 1.67224377e-01f, 1.52330354e-01f, -8.52515921e-02f,
  -5.14164828e-02f, -4.87742461e-02f, 1.29675061e-01f, -1.14551306e-01f, 3.08214575e-01f, 1.40254229e-01f, -5.74650951e-02f, 3.99831161e-02f, 1.21172285e-02f, 1.15963988e-01f,
  -4.37743543e-03f, 2.47310162e-01f, 1.10891676e-02f, -1.31353363e-01f, 1.22941919e-01f, 8.19814578e-02f, 2.52785891e-01f, 2.83716768e-01f, -2.08899796e-01f, 1.87795803e-01f,
  -6.73399642e-02f, 5.77982329e-02f, 8.08829442e-02f, 1.68936560e-03f, 2.38531098e-01f, 2.27805093e-01f, 2.05252543e-01f, 1.79665722e-02f, 1.19516887e-01f, 9.39084664e-02f,
  -9.99026746e-03f, 1.61193684e-02f, 8.67756307e-02f, 8.27172548e-02f, -4.40814197e-02f, -4.04719532e-01f, -5.66542186e-02f, -2.63683200e-01f, -1.54550791e-01f, 2.21323684e-01f,
  -9.52965990e-02f, -1.66249365e-01f, 1.66485891e-01f, 1.85688332e-01f, -1.04257494e-01f, -4.22496676e-01f, -2.95423288e-02f, 3.65225047e-01f, 1.40156299e-01f, -6.19411767e-02f,
  2.45152071e-01f, -2.44813278e-01f, 4.24042672e-01f, 6.41769916e-02f, -4.19162214e-01f, 3.07040691e-01f, 4.52048242e-01f, -2.55092144e-01f, -1.80376813e-01f, 1.74309626e-01f,
  1.28418282e-01f, 3.23588401e-01f, 6.09167404e-02f, 9.13699418e-02f, 1.25050902e-01f, -9.53139067e-02f, 2.71083921e-01f, 2.00540960e-01f, -1.80256486e-01f, 3.26773852e-01f,
  -1.95333902e-02f, 8.78407210e-02f, -5.58482967e-02f, -3.53593230e-02f, 1.28634498e-01f, -2.20968023e-01f, 4.07228060e-03f, -8.98020156e-03f, 1.29568443e-01f, -1.91971916e-03f,
  -1.07236654e-01f, -1.26013786e-01f, 1.00425161e-01f, 8.35983157e-02f, -7.84559362e-03f, 1.69322968e-01f, -2.50274032e-01f, -2.03065574e-02f, -6.33855164e-02f, -1.20803975e-01f,
  1.01695463e-01f, -1.76786274e-01f, 1.63574681e-01f, -4.71679598e-01f, -2.92466402e-01f, 1.34600982e-01f, 1.87166765e-01f, -1.31129026e-01f, 2.07211241e-01f, -4.81034487e-01f,
  -1.26288041e-01f, 4.48986381e-01f, 2.70854235e-01f, 1.34897083e-01f, -1.60749257e-01f, 3.88882220e-01f, -4.10356224e-01f, 2.38838375e-01f, 7.75820613e-02f, -9.84074473e-02f,
  1.57206714e-01f, 1.58312738e-01f, -3.29226613e-01f, -3.45970213e-01f, 2.53510326e-01f, 1.12212069e-01f, 2.98800200e-01f, 5.01156747e-01f, -5.16718440e-02f, 2.55778670e-01f,
  -6.17714226e-02f, -1.84492573e-01f, 4.93476957e-01f, -1.57573950e-02f, 9.09871459e-02f, -8.84813815e-02f, 7.99041167e-02f, 3.50023694e-02f, 3.34717706e-02f, 5.71546435e-01f,
  -1.30364329e-01f, -2.14324117e-01f, 7.98711330e-02f, 1.63453668e-01f, 1.51767656e-01f, -1.35233983e-01f, 6.19420372e-02f, -5.01791276e-02f, 9.42230746e-02f, -1.66718736e-01f,
  -4.56167728e-01f, -4.70157772e-01f, -2.48681828e-01f, -5.13023622e-02f, -1.05863810e-02f, 8.32904130e-02f, 7.94952065e-02f, -4.22055155e-01f, -1.98471230e-02f, 1.65721327e-01f,
  1.48450837e-01f, -1.17492964e-02f, -4.90074575e-01f, -1.64229274e-01f, -2.19327882e-01f, -1.23897128e-01f, -3.01605880e-01f, -7.73503631e-02f, -1.09246671e-01f, 5.97945228e-02f,
  -3.03401891e-02f, -2.97892362e-01f, 1.78303599e-01f, 1.61520336e-02f, -3.84336919e-01f, -1.27389610e-01f, -2.04583436e-01f, -1.35526741e-02f, -2.22879529e-01f, -1.22366630e-01f,
  1.22065358e-01f, 7.36598521e-02f, -2.47875586e-01f, -3.59269291e-01f, 1.03253305e-01f, 2.68799573e-01f, -2.33848140e-01f, 2.28265882e-01f, 1.09331965e-01f, 3.01277339e-01f,
  4.42459077e-01f, -1.50910825e-01f, 4.03021842e-01f, -2.24096447e-01f, -2.08246306e-01f, 1.81283802e-01f, -1.52146906e-01f, 6.89928532e-02f, 6.59060851e-02f, 4.80650365e-01f,
  -2.15605125e-01f, -1.49201229e-01f, 3.23695838e-02f, -1.93356156e-01f, -3.44788015e-01f, 2.85754651e-01f, -1.09065346e-01f, 3.23839001e-02f, -7.77141983e-03f, 2.37427190e-01f,
  -3.50391656e-01f, 1.07434697e-01f, -5.33121347e-01f, -4.95481025e-03f, 2.83469073e-02f, 1.17137572e-02f, -2.19672602e-02f, 7.83362836e-02f, -2.51101881e-01f, -1.58596765e-02f,
  -2.91046612e-02f, -9.07811075e-02f, -2.47966349e-01f, 8.95516053e-02f, 1.66491400e-02f, -5.37915267e-02f, -1.79329496e-02f, 1.78033710e-01f, -1.44680962e-01f, 1.04141664e-02f,
  5.93546294e-02f, 1.58277020e-01f, 1.61664054e-01f, -3.18406746e-02f, -1.40355796e-01f, 3.40522081e-02f, -7.43392948e-03f, 1.22918949e-01f, 4.65993494e-01f, 3.55603307e-01f,
  4.71347779e-01f, -3.62381667e-01f, 7.85195157e-02f, -2.45406702e-01f, 2.43450820e-01f, -3.52622420e-01f, -1.40541762e-01f, 3.14536303e-01f, 2.39552841e-01f, 1.87550440e-01f,
  1.39371991e-01f, -1.61773153e-02f, -4.51395184e-01f, -1.81000307e-01f, -2.73078024e-01f, 7.07496777e-02f, 2.30368048e-01f, 7.15489835e-02f, 1.15378965e-02f, -1.07026637e-01f,
  3.74583960e-01f, -5.27614474e-01f, 2.11236794e-02f, -4.49040711e-01f, 1.95711896e-01f, 6.25590160e-02f, -2.95058396e-02f, -3.01651120e-01f, 1.30776703e-01f, 1.59117021e-02f,
  -2.68512905e-01f, -4.25327457e-02f, -5.52627742e-02f, -6.09438494e-02f, 6.74455345e-01f, -8.11526477e-02f, -2.24681586e-01f, -4.51280296e-01f, 2.53274292e-01f, 2.47120798e-01f,
  -4.86024588e-01f, -1.71223432e-01f, -7.54443631e-02f, 1.05201043e-02f, -5.53609669e-01f, 2.51079574e-02f, 4.79460023e-02f, 1.35913745e-01f, -1.04489096e-01f, -1.95319448e-02f,
  7.02803582e-02f, -3.27826440e-01f, -6.15036115e-03f, 9.82004926e-02f, -1.71729103e-01f, -7.03182966e-02f, 1.37246415e-01f, -2.31618479e-01f, -2.28213426e-02f, 3.28934342e-01f,
  -5.04098162e-02f, -1.50911853e-01f, -1.73146993e-01f, 6.90651760e-02f, -6.05325513e-02f, 7.60707930e-02f, -2.19269127e-01f, 4.15351450e-01f, -3.53969894e-02f, 2.50590980e-01f,
  -2.53212512e-01f, -3.66499424e-01f, -1.39345318e-01f, 3.55399460e-01f, -1.03847109e-01f, -1.85621098e-01f, -1.58770103e-02f, 1.57514423e-01f, -2.98295952e-02f, -3.34093750e-01f,
  -3.07072788e-01f, 3.85315195e-02f, -3.56318682e-01f, 3.88725698e-01f, -1.12575389e-01f, 1.74136177e-01f, 3.69577035e-02f, 4.06192511e-01f, -3.77685636e-01f, -1.45825505e-01f,
  -3.36550996e-02f, 4.32841480e-01f, -9.41467006e-03f, -1.14748642e-01f, 3.24081242e-01f, -8.81980881e-02f, 3.85086574e-02f, -2.77850360e-01f, -1.59182921e-01f, -1.04319476e-01f,
  2.22673386e-01f, 2.61162400e-01f, 4.54728127e-01f, 2.41996408e-01f, 3.40916634e-01f, 4.07826789e-02f, 1.25428826e-01f, 5.33874817e-02f, 8.05381984e-02f, -2.14380100e-01f,
  -2.67850339e-01f, -1.50760770e-01f, -2.20680684e-01f, -1.13286152e-01f, 1.32938892e-01f, -1.23076230e-01f, 1.56332716e-01f, -2.40734950e-01f, -8.82345587e-02f, 1.46637429e-02f,
  1.87374458e-01f, 1.34704979e-02f, 1.46436706e-01f, 2.42350787e-01f, -2.61432976e-01f, 2.28452429e-01f, -1.60404190e-01f, 2.78315008e-01f, 5.10704577e-01f, 5.68776913e-02f,
  2.12347254e-01f, -1.36484161e-01f, 3.48585933e-01f, -2.80009350e-04f, 5.17889023e-01f, 3.89302552e-01f, -4.37326133e-01f, -4.54395175e-01f, 3.36171269e-01f, -3.44237626e-01f,
  1.84964478e-01f, 1.24257058e-01f, -4.72846180e-01f, -2.50518948e-01f, 2.33482555e-01f, -2.19927803e-01f, -2.01404110e-01f, 1.00715093e-01f, -2.42913723e-01f, 2.82531828e-01f,
  -6.87860996e-02f, 1.10681485e-02f, -1.28682395e-02f, 1.25092819e-01f, 1.01718947e-01f, -8.43014866e-02f, -5.98442368e-02f, -6.36611432e-02f, 2.18361378e-01f, -1.94177881e-01f,
  -9.51527953e-02f, -1.51422787e-02f, 1.63919240e-01f, 8.50598067e-02f, 2.36057401e-01f, 8.27590823e-02f, 1.80090427e-01f, -2.94512585e-02f, 2.45423898e-01f, 1.16050534e-01f,
  4.25348058e-02f, -9.67656001e-02f, 6.92820102e-02f, -4.00990583e-02f, 3.50614786e-02f, 2.79961992e-02f, 1.34767354e-01f, -8.96108821e-02f, 1.85571671e-01f, -1.11936696e-01f,
  9.16132107e-02f, 2.64708623e-02f, 3.09768111e-01f, 6.08081780e-02f, -8.02639201e-02f, -1.39409844e-02f, 1.04066759e-01f, 2.83845842e-01f, 2.31696144e-01f, 3.03703845e-01f,
  3.22414219e-01f, 7.12278634e-02f, 3.45320344e-01f, -1.40088350e-01f, 1.21327482e-01f, -1.54377788e-01f, -4.90943819e-01f, -5.00389636e-01f, 2.34163150e-01f, 1.56748667e-01f,
  -1.27367929e-01f, -1.19147532e-01f, -2.86127269e-01f, 1.77074075e-01f, 2.61143118e-01f, 4.37111109e-02f, 3.06489229e-01f, 4.73258644e-01f, -3.31654757e-01f, 3.39208782e-01f,
  -6.81527779e-02f, -1.45770296e-01f, -1.35705262e-01f, -2.27037463e-02f, -7.38781542e-02f, -3.44178915e-01f, 2.54336238e-01f, 1.17082462e-01f, -2.19776388e-02f, 8.81160945e-02f,
  -3.88213754e-01f, -1.82846058e-02f, 1.20911431e-02f, 2.63639897e-01f, -1.02095313e-01f, -2.43393704e-01f, 5.53927362e-01f, 5.01961857e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -9.07077175e-03f, -7.69010112e-02f, -8.93585756e-02f, 1.61644951e-01f, -6.05909564e-02f, -1.69185232e-02f, -3.04505136e-02f, -2.43400596e-02f, 8.15434530e-02f, -3.95329148e-02f,
  1.38098836e-01f, 1.28798798e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    