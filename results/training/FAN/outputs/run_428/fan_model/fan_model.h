/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.21907413e-01f, -1.32456735e-01f, -1.38794020e-01f, -2.17094302e-01f, 3.45873982e-02f, -2.62141079e-01f, -3.77048999e-01f, 2.74801999e-02f, -2.91576207e-01f, 1.92017090e-02f,
  6.67574555e-02f, -7.98107237e-02f, 1.41198829e-01f, -3.06849986e-01f, -1.41661957e-01f, -4.39419448e-02f, -2.51190603e-01f, -1.20412320e-01f, -2.16173697e-02f, 5.71356853e-03f,
  1.59616861e-03f, -8.82520452e-02f, -8.71683657e-02f, 1.29512817e-01f, -1.28457546e-01f, 9.39287320e-02f, 3.23989987e-01f, 3.29103172e-02f, 1.28890157e-01f, -3.53618637e-02f,
  -2.63216905e-02f, 7.79724419e-02f, -9.23163537e-03f, 2.04846337e-02f, 1.95327532e-02f, 1.41689703e-02f, -3.23102660e-02f, 2.33601662e-03f, 2.81402357e-02f, 3.46249864e-02f,
  1.94883347e-02f, -2.63711102e-02f, -5.28586656e-02f, 4.58911099e-02f, -8.19247141e-02f, 2.73335557e-02f, -7.69317849e-03f, -4.45327424e-02f, 5.44175319e-02f, -7.39844963e-02f,
  -1.26748398e-01f, -2.69075669e-02f, -7.32387742e-03f, 1.33697158e-02f, 2.16280520e-02f, -2.40927320e-02f, 2.53150575e-02f, 1.14990264e-01f, 2.62008347e-02f, -4.88735810e-02f,
  -4.36055325e-02f, -3.96060273e-02f, -2.56383279e-03f, 5.85018285e-02f, -5.75623363e-02f, 4.92555425e-02f, -2.92012412e-02f, 4.67495210e-02f, -2.26585940e-02f, -6.42222464e-02f,
  3.59482169e-02f, 5.16752247e-03f, -6.70905085e-03f, -7.07732737e-02f, 3.20545100e-02f, -4.58760671e-02f, 1.47614554e-02f, -4.62204479e-02f, -6.11118488e-02f, -6.72036633e-02f,
  3.95278223e-02f, -2.89585665e-02f, 2.07058843e-02f, 1.04607061e-01f, 1.37100315e-05f, 5.47703393e-02f, -8.56971554e-03f, 2.97031961e-02f, 4.45255637e-02f, 1.40299695e-02f,
  4.94252890e-02f, 2.70596612e-02f, 3.59713435e-02f, -6.23498075e-02f, -3.86993550e-02f, -2.28727516e-02f, -2.09578276e-02f, -9.52350441e-03f, -4.76960838e-02f, -5.03252447e-02f,
  -8.22372269e-04f, -1.21004796e-02f, -1.44105749e-02f, -5.21596372e-02f, -9.33459305e-05f, -3.55448984e-02f, 2.70787980e-02f, 4.63787019e-02f, -4.45922129e-02f, 1.06505014e-01f,
  1.43378070e-02f, 5.80955222e-02f, 1.14919711e-03f, 1.53633431e-02f, -1.79331135e-02f, 4.15821560e-02f, -5.48298545e-02f, -3.63322943e-02f, -5.23741823e-03f, -5.86588634e-03f,
  2.50504106e-01f, 2.14739397e-01f, 3.99731308e-01f, 2.86162585e-01f, 1.11749373e-01f, -1.05596758e-01f, -1.54227346e-01f, 1.38067424e-01f, 3.92373085e-01f, -2.83995181e-01f,
  -8.97882432e-02f, 8.62904266e-02f, 1.29788518e-02f, 2.18162164e-02f, 1.81552738e-01f, 4.78406586e-02f, 2.39414591e-02f, 1.39959797e-01f, 2.47705236e-01f, 1.09273046e-01f,
  1.73376217e-01f, -2.96153277e-01f, 1.10489152e-01f, -6.84843166e-03f, -1.65981497e-03f, 1.09473385e-01f, -1.27159521e-01f, 4.44764085e-02f, -2.13259086e-01f, -4.93721254e-02f,
  -5.48337102e-02f, 1.71711430e-01f, 5.82737178e-02f, 2.10915953e-02f, 8.01703148e-03f, -3.95639166e-02f, -7.55371749e-02f, -7.66217485e-02f, 1.19030938e-01f, 4.13731188e-02f,
  -3.69556025e-02f, -7.90534392e-02f, 3.20590213e-02f, 3.90483104e-02f, -1.91743691e-02f, 6.99286833e-02f, -5.70716895e-02f, 1.02774147e-02f, 7.31257498e-02f, 2.39043985e-03f,
  9.90075544e-02f, 5.73605895e-02f, -9.41300914e-02f, -3.14679295e-02f, 1.12357832e-01f, -2.57907230e-02f, -7.61391642e-03f, -4.79250550e-02f, 6.61506969e-03f, -6.76768459e-03f,
  -3.71238329e-02f, 1.13923766e-01f, -1.40930548e-01f, 1.15621865e-01f, -5.40108345e-02f, -3.55896205e-02f, 3.91372256e-02f, -7.25395083e-02f, 6.74437657e-02f, -3.90099585e-02f,
  -4.00931537e-02f, 4.70292792e-02f, 2.35893205e-02f, 9.05829966e-02f, 7.04421848e-02f, 3.33810374e-02f, 1.28186671e-02f, -4.02583107e-02f, 6.79698810e-02f, 5.65734133e-02f,
  -1.33365253e-02f, -1.02534816e-02f, 8.09925869e-02f, -6.53381646e-02f, -4.88804746e-03f, 4.11831737e-02f, 5.01986183e-02f, 1.27735557e-02f, 9.74971652e-02f, 6.86719955e-04f,
  -1.42967328e-01f, 1.03271164e-01f, 2.74208235e-03f, -6.18264899e-02f, -5.23385219e-03f, 4.43734191e-02f, 1.10932313e-01f, 2.67466027e-02f, 2.02442482e-02f, -1.39245056e-02f,
  -8.53882059e-02f, -7.56845158e-03f, -1.10425971e-01f, -2.06119083e-02f, 1.28196869e-02f, -1.31068453e-01f, -1.80431940e-02f, 3.82497944e-02f, -1.09632534e-03f, -4.48149256e-03f,
  -9.99345332e-02f, 7.83156417e-03f, 4.09994647e-02f, 1.28678745e-02f, -7.78705254e-02f, -8.31142068e-02f, 8.55517834e-02f, 1.99588155e-03f, -4.18091528e-02f, 4.66924496e-02f,
  3.80270600e-01f, 2.74045736e-01f, -1.35488972e-01f, 3.19918408e-03f, -2.53513098e-01f, 5.94790317e-02f, 3.06403567e-03f, -6.20818324e-02f, 4.62250737e-03f, 6.07684404e-02f,
  -1.47363350e-01f, 1.03410035e-01f, 1.62699908e-01f, -1.61580190e-01f, -3.55924934e-01f, -4.09296602e-02f, 1.69461146e-02f, -1.26183238e-02f, 6.45573959e-02f, 9.03147310e-02f,
  1.23526761e-02f, -1.12865530e-01f, -4.28773239e-02f, 6.06479384e-02f, 9.87880453e-02f, 1.10717714e-01f, -2.61798195e-05f, 4.97158282e-02f, -7.80009851e-02f, -7.81128928e-02f,
  1.04660176e-01f, 3.52422819e-02f, -1.34346643e-02f, 5.64069375e-02f, 4.88710329e-02f, -1.77888293e-02f, 2.97412369e-02f, -1.24391593e-01f, 2.44732872e-02f, -3.57686840e-02f,
  6.95816800e-02f, -2.68376693e-02f, -4.06716093e-02f, 3.27518256e-03f, 9.66891572e-02f, -8.65486450e-03f, 6.84649264e-03f, -1.72677021e-02f, 7.08656013e-03f, 1.70109253e-02f,
  -1.26146033e-01f, -8.93497020e-02f, 5.06241545e-02f, -4.76260595e-02f, -1.05740264e-01f, -4.20410261e-02f, 8.18547532e-02f, -1.87209365e-03f, -1.02789011e-02f, 7.03426003e-02f,
  7.13795796e-02f, 5.98123781e-02f, -4.49199602e-03f, 3.49043906e-02f, 2.29521263e-02f, -7.18879700e-02f, 7.54751712e-02f, 3.55470576e-03f, 6.18835948e-02f, 1.18226316e-02f,
  9.75888502e-03f, -6.68233782e-02f, -5.24563901e-02f, -7.57815614e-02f, 4.02191654e-02f, 1.84577005e-03f, 1.31380871e-01f, -6.93146326e-03f, -1.92143712e-02f, -1.09720215e-01f,
  -5.70822060e-02f, 2.85868049e-02f, -6.09646104e-02f, 4.52829190e-02f, -5.23089767e-02f, 4.78006899e-02f, -4.55653667e-02f, -4.69624698e-02f, -7.91583434e-02f, 6.09046295e-02f,
  3.29868436e-01f, 1.53275758e-01f, 4.15437743e-02f, -2.01092530e-02f, -4.28005541e-03f, -8.31058547e-02f, 2.38146223e-02f, -9.86766368e-02f, 1.01668134e-01f, 6.10499550e-03f,
  -1.04210060e-02f, -1.60376821e-02f, 8.50775018e-02f, 4.12257127e-02f, 6.32685497e-02f, -3.21948901e-02f, -1.68582745e-04f, 4.65470776e-02f, -5.31601831e-02f, 4.51473929e-02f,
  5.56113645e-02f, 3.40960324e-02f, 2.02502366e-02f, 3.21266316e-02f, 5.80905154e-02f, 3.46627571e-02f, 1.43414279e-02f, 5.49154496e-03f, -6.49631172e-02f, -1.36902742e-02f,
  -2.63955504e-01f, -1.16866149e-01f, 8.99205580e-02f, 3.43500152e-02f, 3.67498361e-02f, -2.62824595e-01f, -2.01335624e-01f, -1.24237686e-01f, -2.04473093e-01f, -1.02889471e-01f,
  3.99282761e-02f, -1.79378569e-01f, 1.18974030e-01f, 4.32502888e-02f, 2.83430368e-01f, 4.38071229e-02f, 8.36828947e-02f, -5.19975722e-02f, -9.45030991e-03f, 7.21700042e-02f,
  1.49266377e-01f, 1.61327571e-01f, 3.12477171e-01f, 1.04752980e-01f, 2.30612773e-02f, -6.42616972e-02f, 2.30882421e-01f, 5.69102168e-02f, -9.92257614e-03f, -3.31376642e-02f,
  -2.32161209e-02f, -8.64931867e-02f, 6.05822131e-02f, -1.13153279e-01f, 7.95819759e-02f, -6.63681477e-02f, -2.59876568e-02f, 9.31379870e-02f, -1.64512426e-01f, -5.68883531e-02f,
  1.53065156e-02f, -1.67379640e-02f, -7.00094029e-02f, 5.33742569e-02f, -1.95472628e-01f, -3.97280492e-02f, -2.07393151e-02f, -1.21773683e-01f, -2.19060797e-02f, -2.25167926e-02f,
  8.75572711e-02f, -3.39565910e-02f, -4.00443189e-02f, -4.80596572e-02f, 1.77490320e-02f, -9.51560065e-02f, -3.04864552e-02f, 1.57766398e-02f, 1.43276220e-02f, 6.68544993e-02f,
  8.93452764e-02f, 9.18639228e-02f, 1.73050016e-02f, -6.00072881e-03f, -3.33654741e-03f, -9.49881524e-02f, 4.31478508e-02f, -2.11221464e-02f, -2.68168468e-02f, 6.28396636e-03f,
  -2.44316012e-02f, -2.46802866e-02f, -5.87296188e-02f, -1.00083977e-01f, 9.27478075e-02f, -4.26014587e-02f, 9.96664241e-02f, -2.16723792e-02f, -4.60566729e-02f, 2.25209426e-02f,
  -6.33635372e-02f, 4.77739796e-03f, 2.37955432e-02f, 1.17513202e-02f, 4.39772904e-02f, 8.87050061e-04f, -3.41531523e-02f, -4.77455631e-02f, 1.27165437e-01f, 7.23685250e-02f,
  1.03604756e-01f, 2.09747061e-01f, 5.11405058e-02f, -6.27488866e-02f, -3.05039692e-03f, 6.26353621e-02f, 8.90947282e-02f, -1.18415561e-02f, 7.62580335e-02f, 6.01308905e-02f,
  3.57127711e-02f, 1.45552503e-02f, 1.76647995e-02f, -3.63186304e-03f, 8.29056352e-02f, 1.69540029e-02f, 3.74636725e-02f, -5.96832857e-03f, 6.53681383e-02f, 1.85126029e-02f,
  2.53726952e-02f, 2.05553491e-02f, -3.01496610e-02f, -3.02796811e-02f, -3.28205638e-02f, 1.92636605e-02f, 5.46843447e-02f, -1.66936405e-02f, 1.10270947e-01f, -5.30511215e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.34124994e-01f, 4.49264824e-01f, 4.06012638e-03f, -6.32712021e-02f, -4.15075868e-02f, -5.79485595e-01f, -4.47624236e-01f, -4.30568680e-02f, 1.36784419e-01f, 8.87390226e-02f,
  -2.00520411e-01f, 4.80297178e-01f, -1.69242755e-01f, -7.04770386e-02f, -4.77735460e-01f, -1.70764685e-01f, -5.04698575e-01f, -2.29318112e-01f, -6.13051429e-02f, -1.51570201e-01f,
  -1.50318220e-01f, -2.57661194e-01f, -2.61071086e-01f, -3.39092198e-03f, -1.06744863e-01f, 1.69912919e-01f, -2.05959022e-01f, -4.71296385e-02f, -2.37398241e-02f, -5.95965311e-02f,
  -1.87840432e-01f, 1.84839800e-01f, 1.66909263e-01f, -3.25659327e-02f, -3.05099607e-01f, 1.97116658e-03f, 3.41687202e-02f, 2.05965787e-02f, -4.65763323e-02f, 3.69049869e-02f,
  1.65023521e-01f, -4.16201241e-02f, 7.49508217e-02f, 5.74736446e-02f, -6.78306296e-02f, 7.55638555e-02f, 1.22546174e-01f, 1.09787341e-02f, 1.13100357e-01f, -4.51245755e-02f,
  1.17715478e-01f, -4.18873504e-02f, -1.00265360e-02f, -6.27815574e-02f, 4.93403012e-03f, 1.17725037e-01f, -1.79086607e-02f, -2.05758587e-02f, 7.65264481e-02f, 2.88148019e-02f,
  6.81901649e-02f, -1.06837280e-01f, -3.78627633e-03f, -3.96441258e-02f, -4.61014360e-02f, -8.70426372e-02f, -4.03810441e-02f, -7.63097778e-02f, 7.68403709e-02f, -2.99866814e-02f,
  7.10242288e-03f, -4.11603823e-02f, -5.08628897e-02f, -9.24029015e-03f, -9.54994708e-02f, 5.30004650e-02f, -5.75878359e-02f, 6.17686808e-02f, 1.93234049e-02f, 1.50980400e-02f,
  -3.79977785e-02f, -9.56882238e-02f, 1.22624271e-01f, -4.83272411e-02f, -5.53171523e-02f, 1.25277489e-02f, 5.33563830e-02f, -3.61892651e-03f, 3.11353952e-02f, -1.78504251e-02f,
  -4.30625200e-01f, -3.70581508e-01f, -6.97181240e-05f, 1.25621893e-02f, 5.40803187e-02f, 6.34894148e-02f, -3.37850861e-02f, 6.05914295e-02f, -7.39978105e-02f, -2.38782503e-02f,
  -7.85302296e-02f, 1.15240756e-02f, -1.10966966e-01f, -1.06992222e-01f, 1.27350083e-02f, -5.79932444e-02f, -1.60053417e-01f, -1.45990998e-01f, -4.37886715e-02f, -6.19202740e-02f,
  4.81495857e-02f, -7.39967823e-02f, -2.89620901e-03f, -1.93892699e-03f, -2.21874360e-02f, -1.47857442e-01f, 7.34908953e-02f, 8.43677074e-02f, 3.55522819e-02f, -9.22033414e-02f,
  4.98256713e-01f, -4.93675955e-02f, -1.96086586e-01f, -1.59575790e-01f, 8.61344635e-02f, -2.10078910e-01f, -6.56996906e-01f, -1.78726211e-01f, -4.68875654e-02f, -2.89205939e-01f,
  2.79399231e-02f, -1.54217064e-01f, -5.01788966e-02f, -2.74137497e-01f, 6.79459691e-01f, 4.15986031e-01f, -2.04785407e-01f, -2.10194699e-02f, -1.82957780e-02f, -2.19681993e-01f,
  2.74327070e-01f, -2.38955811e-01f, -1.11824475e-01f, -1.39866635e-01f, -4.23339754e-01f, -2.61867698e-02f, 2.43452072e-01f, -2.36026183e-01f, -3.23808879e-01f, 1.05938073e-02f,
  1.42705768e-01f, -1.37980148e-01f, 1.17864236e-01f, -9.43364501e-02f, -1.55049175e-01f, -1.37067633e-02f, -1.14377424e-01f, 6.24824315e-02f, -6.55406490e-02f, -1.23503536e-01f,
  -1.67288855e-02f, 1.61637396e-01f, -8.46817866e-02f, 1.10587306e-01f, -8.38744417e-02f, 9.81023237e-02f, -1.49965426e-02f, -6.46136478e-02f, -2.04063818e-01f, -3.71893272e-02f,
  -1.78992236e-03f, -1.27766252e-01f, -9.45766717e-02f, -8.05510581e-02f, -6.91807643e-02f, -5.64805157e-02f, -6.02287985e-02f, -1.70355961e-01f, -7.01246783e-02f, 7.19250962e-02f,
  -2.89769098e-02f, -1.05130151e-01f, 1.18228883e-01f, -1.96726918e-02f, 1.17089316e-01f, 4.43410389e-02f, -1.38479024e-01f, -1.90964974e-02f, 3.43964845e-02f, 5.09738398e-04f,
  -1.79870855e-02f, -7.43454024e-02f, -4.45760712e-02f, 5.74085638e-02f, 7.39492401e-02f, 1.57313257e-01f, -4.47137021e-02f, 1.97143853e-01f, -1.46686628e-01f, -6.18336536e-02f,
  1.95684999e-01f, 3.66236977e-02f, -1.81215808e-01f, -1.73994407e-01f, -1.22366816e-01f, 1.03043482e-01f, 1.05873756e-01f, 1.15137801e-01f, 1.34780919e-02f, -9.85194966e-02f,
  4.49759187e-03f, -1.40776932e-01f, -8.09579119e-02f, -1.10605173e-01f, 1.97664127e-02f, 1.51431620e-01f, 3.96180749e-02f, 8.25870335e-02f, -3.64081375e-02f, -1.58857748e-01f,
  8.31624418e-02f, -1.95469230e-01f, -2.97628641e-02f, 9.75873843e-02f, -1.78619727e-01f, 1.88498154e-01f, -6.08169893e-03f, 9.16730911e-02f, 8.19171071e-02f, 8.88211951e-02f,
  1.18429959e-01f, 2.69621536e-02f, -1.34116933e-01f, -2.19939366e-01f, -3.83252092e-02f, -1.94118142e-01f, 1.71689451e-01f, 3.35200205e-02f, -1.05759045e-02f, -1.50379807e-01f,
  8.55882466e-01f, -1.80773959e-01f, 4.16927934e-02f, 3.47650021e-01f, 2.87432224e-01f, -1.15218133e-01f, -2.83066064e-01f, 3.23494345e-01f, 8.11735019e-02f, -2.49344587e-01f,
  9.08956379e-02f, -1.59232751e-01f, -4.25124764e-01f, 4.10235316e-01f, 2.70410836e-01f, -3.70196342e-01f, 3.85676533e-01f, -7.78696761e-02f, 2.22070562e-03f, 1.75252110e-01f,
  3.55839878e-01f, 4.42479610e-01f, 6.64996281e-02f, 4.22116846e-01f, 3.32415342e-01f, 2.37294510e-01f, 2.41167158e-01f, -2.09340945e-01f, 3.20663482e-01f, 9.30963680e-02f,
  1.85941190e-01f, 2.56597772e-02f, 5.38991764e-02f, -2.44863536e-02f, -1.14027504e-02f, -6.12346381e-02f, -1.51372731e-01f, -1.44431949e-01f, 2.96671875e-02f, -4.21853811e-02f,
  -1.16212144e-01f, 8.66807066e-03f, 1.19066365e-01f, -3.65454145e-02f, 2.37674206e-01f, 7.60528743e-02f, 1.39235854e-02f, -5.55659458e-02f, -9.53928679e-02f, -2.58320291e-02f,
  -1.12217307e-01f, -4.20726463e-02f, 2.95062847e-02f, -6.16499186e-02f, 1.21162338e-02f, 6.42312989e-02f, -1.01128511e-01f, -1.09346338e-01f, -2.65241507e-02f, -4.66044806e-03f,
  7.92431366e-03f, -7.67168701e-02f, 3.05288844e-02f, 4.46516126e-02f, 4.14318778e-02f, 3.56027819e-02f, 3.91299017e-02f, -2.26501562e-02f, 6.54792488e-02f, -4.82709780e-02f,
  9.35366098e-03f, 3.22528929e-02f, -3.17863151e-02f, -2.49046087e-02f, -4.40116227e-02f, -5.84393181e-02f, -6.06262311e-02f, -1.78713687e-02f, 2.69661322e-02f, 1.35147711e-02f,
  -8.02255422e-02f, 1.48817241e-01f, -1.08467512e-01f, -2.44704820e-03f, 1.43453283e-02f, -6.89135343e-02f, 8.23550150e-02f, -1.33934334e-01f, 2.92733032e-02f, -1.21385008e-02f,
  -2.54428923e-01f, -2.38862708e-01f, -1.25656903e-01f, 1.39301140e-02f, 1.39751052e-02f, 5.84667996e-02f, -7.09783956e-02f, 2.63133403e-02f, -1.31441187e-02f, 4.05272990e-02f,
  3.64429876e-02f, 9.94439423e-02f, 1.90226473e-02f, 1.09292589e-01f, 5.70494607e-02f, -3.56802046e-02f, -7.20143169e-02f, 3.50596309e-02f, 2.71761380e-02f, 7.87331897e-04f,
  -1.50157046e-02f, -6.23511486e-02f, 1.42915221e-02f, 1.05424002e-01f, 2.36914512e-02f, 2.03213119e-03f, 1.54058756e-02f, 4.89928387e-02f, -6.99312761e-02f, 1.20583018e-02f,
  2.94671208e-01f, 1.15762819e-02f, -3.72492373e-01f, -5.08279633e-03f, 3.44542563e-01f, 6.39914513e-01f, 3.18245173e-01f, 3.18679214e-01f, 2.49120682e-01f, 2.40254030e-01f,
  2.92605668e-01f, -3.84775177e-02f, -2.67656624e-01f, 3.36871058e-01f, 2.28447989e-01f, 4.08359207e-02f, 3.40067804e-01f, 1.67008817e-01f, 1.45696439e-02f, 1.26443639e-01f,
  1.43489912e-01f, 3.52422327e-01f, -2.53382564e-01f, 5.35046346e-02f, 8.68565589e-02f, -2.39425182e-01f, -1.86092898e-01f, -2.13495910e-01f, 9.21237394e-02f, 3.74466181e-02f,
  5.57710789e-02f, -1.17483243e-01f, -1.62302569e-01f, -7.19123110e-02f, 1.49448561e-02f, 1.97791066e-02f, -2.63356771e-02f, -9.35451761e-02f, 2.76908576e-02f, 5.97700402e-02f,
  3.12245190e-02f, -5.44607751e-02f, 7.88572282e-02f, 4.61517684e-02f, 6.84071109e-02f, 4.86503728e-02f, -1.20559838e-02f, -5.35705499e-02f, -2.29055658e-02f, -2.35427506e-02f,
  -2.81080836e-04f, 4.04542536e-02f, 4.41873632e-02f, -5.48332594e-02f, -5.28211743e-02f, 8.66801944e-03f, -5.55951893e-02f, -1.16250344e-01f, 7.61921108e-02f, 1.99883222e-03f,
  -3.86838429e-03f, -8.21376294e-02f, -8.50994512e-02f, -5.04150540e-02f, 5.46883270e-02f, -5.98876588e-02f, 1.57649502e-01f, -6.26218095e-02f, 5.34326595e-04f, 1.66575499e-02f,
  9.01752859e-02f, 7.48381987e-02f, 6.99740723e-02f, 3.39966714e-02f, 1.05593182e-01f, 1.68377124e-02f, 6.98692277e-02f, 9.94425733e-03f, -5.24003943e-03f, 9.19058770e-02f,
  -4.05946597e-02f, 1.74024031e-02f, -1.76613790e-03f, 4.31169244e-03f, 4.74742763e-02f, 4.45488282e-02f, 1.46065667e-01f, 3.78133543e-02f, -1.62299685e-02f, 5.71796612e-04f,
  2.65357763e-01f, 4.95960340e-02f, -6.32940829e-02f, 5.74057642e-03f, -8.44987556e-02f, 1.71341468e-02f, 1.52464742e-02f, 7.42117390e-02f, 6.93605170e-02f, -2.45884079e-02f,
  -8.68656635e-02f, 5.75276418e-03f, -8.05634409e-02f, 2.19133850e-02f, -6.50193542e-02f, -2.23616920e-02f, -3.58057320e-02f, 6.53765202e-02f, 3.82360518e-02f, -2.55625546e-02f,
  -1.29882079e-02f, 7.35008344e-02f, -1.00555912e-01f, -4.18047607e-02f, 1.81073695e-02f, -9.16461572e-02f, 5.45654371e-02f, -6.65521845e-02f, 1.61559973e-03f, -4.50411439e-02f,
  -7.38035500e-01f, 3.27495307e-01f, 1.50584066e-02f, 8.84898528e-02f, -1.42576501e-01f, -6.96354210e-01f, -2.90173709e-01f, 2.18179926e-01f, -4.14341167e-02f, 8.99237245e-02f,
  -2.15963628e-02f, -1.40704677e-01f, 2.35128909e-01f, 1.37789473e-01f, -1.41295925e-01f, 7.27268979e-02f, -1.10125616e-01f, -1.30894572e-01f, 1.48424268e-01f, 2.17872009e-01f,
  8.31726491e-02f, 2.08207622e-01f, 1.31598741e-01f, 2.73765802e-01f, -1.25974923e-01f, 1.17210008e-01f, 2.90762663e-01f, 2.51089126e-01f, -2.32014377e-02f, 4.67506461e-02f,
  -3.06851238e-01f, 2.59207249e-01f, 1.50985103e-02f, -7.03863725e-02f, -1.64242983e-01f, -1.56211600e-01f, -6.41967505e-02f, -7.94074461e-02f, 3.31179276e-02f, -9.36726555e-02f,
  -9.99872535e-02f, 3.29020619e-02f, -2.24903878e-02f, 1.16409697e-01f, -1.21824846e-01f, 1.19087972e-01f, 7.72835463e-02f, -5.13810888e-02f, 9.35688764e-02f, -1.07513152e-01f,
  3.73206139e-02f, -9.07680914e-02f, 4.89451885e-02f, 1.44461691e-02f, 4.85606156e-02f, -4.48090658e-02f, -1.00433178e-01f, -7.88713768e-02f, -1.25583202e-01f, -4.68281284e-02f,
  -1.33438766e-01f, -9.98059586e-02f, -2.34507341e-02f, -8.99663754e-03f, 8.45443644e-03f, 4.86689247e-02f, 8.83371830e-02f, -1.01978682e-01f, -2.65557356e-02f, 6.16662055e-02f,
  -5.93244769e-02f, 7.98884705e-02f, -2.66522262e-02f, -3.26651847e-03f, 1.02861533e-02f, -3.28066759e-02f, 1.10323746e-02f, 4.06723209e-02f, -5.06566241e-02f, -4.45080921e-03f,
  1.31655738e-01f, 4.75518107e-02f, -9.87202302e-03f, -1.43603966e-01f, -5.09635508e-02f, 1.12828976e-02f, 1.11242220e-01f, -4.18000147e-02f, 9.88402143e-02f, -1.97019968e-02f,
  -1.04119934e-01f, 2.75586218e-01f, -8.32495932e-03f, -1.29590228e-01f, 7.14866593e-02f, -6.72447234e-02f, 1.07471859e-02f, -1.02017753e-01f, 7.00356141e-02f, 3.56963091e-02f,
  -1.91196203e-02f, 5.72819961e-03f, -1.36810645e-01f, 3.97494510e-02f, 1.08436324e-01f, 1.11897662e-02f, 1.04009643e-01f, -9.09041911e-02f, -6.34663850e-02f, 1.07320368e-01f,
  4.41903770e-02f, -1.99192595e-02f, 2.56221239e-02f, -1.02820709e-01f, -1.57478645e-01f, 1.21527435e-02f, -7.84508735e-02f, -4.49316129e-02f, -4.81285974e-02f, -5.30066118e-02f,
  -3.26828152e-01f, -3.55302662e-01f, -9.16095898e-02f, -4.18118052e-02f, -8.40278864e-02f, 2.08294198e-01f, 4.02237803e-01f, -3.32608640e-01f, -3.43000025e-01f, -3.74287106e-02f,
  2.29163662e-01f, 4.82703783e-02f, 1.43860623e-01f, 4.41853762e-01f, 5.03174663e-01f, 2.60541469e-01f, 3.32579017e-01f, 2.79109389e-01f, -5.54645695e-02f, -1.52972281e-01f,
  -7.88152665e-02f, 3.03025484e-01f, 2.80103654e-01f, -1.25344381e-01f, 1.33737475e-01f, -1.46848351e-01f, -1.26908608e-02f, 1.26860201e-01f, -2.38622129e-02f, 2.23005235e-01f,
  1.19310319e-01f, -3.76749575e-01f, 9.52471569e-02f, -2.51131365e-04f, -1.10122994e-01f, -6.16034195e-02f, 1.46799386e-01f, 1.11685522e-01f, 5.76827563e-02f, -1.09941773e-01f,
  -5.61970249e-02f, -8.73390585e-02f, 5.06634749e-02f, 4.29633781e-02f, -8.47415030e-02f, -1.27448052e-01f, -9.35223177e-02f, -2.92012505e-02f, -3.06886286e-02f, 1.50155853e-02f,
  1.94142982e-02f, -4.89437096e-02f, 4.00213972e-02f, -1.81886591e-02f, -7.02561624e-03f, -9.49582309e-02f, 1.24523498e-01f, -3.75968358e-03f, -1.67514816e-01f, 7.13100731e-02f,
  -2.76402179e-02f, 1.60066225e-02f, -1.03272706e-01f, 1.18985981e-01f, 3.76646705e-02f, -5.62979048e-03f, 3.41457911e-02f, 7.14927018e-02f, -1.46037247e-02f, 4.58933637e-02f,
  -4.66772765e-02f, -2.85901856e-02f, -7.24611385e-03f, 3.19848545e-02f, -1.16448542e-02f, 9.40810665e-02f, 7.62652159e-02f, 1.32180043e-02f, 9.85115618e-02f, 7.75565282e-02f,
  1.46910017e-02f, -3.83103751e-02f, 3.20929699e-02f, 2.75388896e-03f, -2.96987910e-02f, 1.25706702e-01f, 1.42156733e-02f, -2.21925005e-02f, -4.53764573e-02f, 1.30822137e-01f,
  -3.63241613e-01f, -5.10207236e-01f, -6.05842099e-02f, 6.07821196e-02f, -3.95899601e-02f, 1.80494934e-02f, -4.47078310e-02f, -4.26243339e-03f, -4.36969101e-02f, 3.12672257e-02f,
  -1.27800032e-02f, -9.61202953e-04f, -8.84297565e-02f, 4.26760577e-02f, 2.07830537e-02f, -9.81672555e-02f, -4.85104248e-02f, 5.05452044e-02f, -5.83806224e-02f, -3.41767780e-02f,
  -4.04503755e-02f, -1.08410232e-01f, 2.92475745e-02f, -2.94549242e-02f, 8.86678472e-02f, -4.74682413e-02f, -1.69999078e-01f, -7.93364570e-02f, -1.28098326e-02f, -8.53625536e-02f,
  6.50900841e-01f, -2.13817373e-01f, 5.92041731e-01f, 2.69486606e-01f, 2.24822760e-01f, 2.15284675e-01f, 2.16345787e-01f, 3.73803936e-02f, 1.04712784e-01f, -3.56387764e-01f,
  -4.43101376e-02f, 2.27767631e-01f, -2.11571604e-01f, -4.93072718e-02f, 1.58150747e-01f, -1.29116684e-01f, 4.87601645e-02f, -7.30755255e-02f, -3.60933854e-03f, -4.59994422e-03f,
  1.88457444e-01f, -9.53986272e-02f, 1.66737050e-01f, -1.78507268e-01f, 2.21606001e-01f, 6.40418679e-02f, -2.43322119e-01f, 9.32694972e-02f, 1.02026932e-01f, 6.38034120e-02f,
  2.51607411e-02f, -6.42969161e-02f, 3.29773501e-02f, 1.07535265e-01f, 5.15935272e-02f, -2.62741968e-02f, 6.46664724e-02f, 9.81124938e-02f, 6.09526299e-02f, 5.66088222e-02f,
  4.40325066e-02f, -2.41844151e-02f, -2.91358102e-02f, 7.84950778e-02f, -6.09054342e-02f, 1.21609055e-01f, 1.31386995e-01f, 4.34293821e-02f, 2.43690759e-02f, 1.03542358e-01f,
  5.36442585e-02f, 1.48308694e-01f, 1.65412173e-01f, -1.19816333e-01f, 1.33525550e-01f, -2.63681021e-02f, 5.68500943e-02f, 8.16185996e-02f, 2.32600179e-02f, 3.29128467e-02f,
  -8.57606679e-02f, -1.05780669e-01f, 5.75520145e-03f, -6.94826692e-02f, 4.34455313e-02f, 4.29467447e-02f, 7.72962440e-03f, -6.96316734e-03f, -2.66930666e-02f, -1.96950138e-02f,
  3.15162800e-02f, 7.44214281e-02f, -5.02762198e-02f, -6.58698902e-02f, -6.85198158e-02f, 3.07619572e-02f, 2.69240420e-02f, -4.51126136e-03f, -2.41262801e-02f, -1.14428503e-02f,
  2.12286841e-02f, -2.88378801e-02f, -1.40242100e-01f, 1.08750626e-01f, -2.18010191e-02f, 9.20137614e-02f, -5.15129231e-02f, 1.04842328e-01f, -4.65962701e-02f, 9.50831845e-02f,
  -9.07972097e-01f, -6.20158732e-01f, -9.64378417e-02f, 6.08530967e-03f, -1.10351391e-01f, -3.17261852e-02f, -3.24693657e-02f, 7.07208412e-03f, -1.11330308e-01f, -5.69201214e-03f,
  5.75366132e-02f, 4.57895622e-02f, -5.60642965e-02f, 7.80418096e-03f, -5.71316481e-02f, -5.75652160e-02f, -5.88695332e-02f, -2.06482589e-01f, -1.05807550e-01f, -1.06297601e-02f,
  -6.74839094e-02f, -7.86447003e-02f, 1.86829397e-03f, -2.99871601e-02f, -8.32939669e-02f, 8.28999355e-02f, -4.89895567e-02f, -3.30478549e-02f, -3.76331434e-02f, -8.78971741e-02f,
  -1.05986249e+00f, 2.73001879e-01f, 3.57863247e-01f, -6.15727961e-01f, 1.55635670e-01f, 5.66006303e-01f, 7.19678998e-02f, 1.18116058e-01f, -1.02614924e-01f, -9.88307819e-02f,
  -1.06520817e-01f, -1.02941766e-01f, -4.03619409e-02f, -2.56985798e-02f, 3.29803638e-02f, 1.49808839e-01f, -1.55733988e-01f, -1.82231694e-01f, 1.80086687e-01f, -1.42005637e-01f,
  4.29669470e-02f, -1.46685630e-01f, 1.64015815e-01f, 1.53194487e-01f, 1.30454555e-01f, -9.00911093e-02f, -3.16615731e-01f, 7.85820708e-02f, -7.82045051e-02f, 1.66110352e-01f,
  -1.13012329e-01f, -3.81372780e-01f, 6.15214668e-02f, 2.82194149e-02f, -1.51356831e-02f, 9.82641801e-02f, -3.99181768e-02f, -3.26386169e-02f, -7.62714893e-02f, 2.83818180e-03f,
  -9.73159075e-03f, 7.91669637e-03f, 3.70911099e-02f, 3.47558782e-02f, 7.26184770e-02f, 7.70371854e-02f, 1.09464668e-01f, 9.06926170e-02f, 4.57211994e-02f, 3.13294306e-02f,
  1.09726675e-01f, 1.29391253e-01f, -3.87678705e-02f, -7.79705942e-02f, 3.43303271e-02f, -5.40945679e-02f, -2.13500694e-03f, -6.64340481e-02f, 4.76553477e-02f, -5.99146150e-02f,
  1.04238316e-01f, -1.47225168e-02f, 9.50598866e-02f, -2.62313969e-02f, 5.39526343e-02f, -3.60515639e-02f, 8.24159384e-02f, -3.77272591e-02f, -2.33650059e-02f, -8.19685161e-02f,
  -7.71988109e-02f, -4.24488448e-02f, -6.07416295e-02f, -6.45880401e-02f, -6.21786565e-02f, -5.56832217e-02f, 1.25434836e-02f, -4.92919460e-02f, 3.29563208e-02f, 7.65595492e-03f,
  -1.02129966e-01f, 5.62848598e-02f, -4.01413217e-02f, -1.02249775e-02f, 6.68854639e-02f, 3.02075688e-02f, -1.23173939e-02f, 5.21295927e-02f, 2.34399270e-03f, 2.74868198e-02f,
  -2.63077080e-01f, -5.74812233e-01f, -7.09856004e-02f, -4.84132096e-02f, 1.18246404e-02f, 5.48387617e-02f, 2.65953559e-02f, -2.08308119e-02f, -4.22381833e-02f, -4.39398438e-02f,
  -5.71353622e-02f, 2.05882210e-02f, -1.59282435e-03f, 6.26975596e-02f, 1.01497136e-01f, -1.94458030e-02f, -1.87617436e-01f, -6.63887262e-02f, -9.60685313e-02f, -9.93739814e-03f,
  -6.54133037e-02f, -3.31240483e-02f, -3.21275555e-02f, -2.10495405e-02f, -5.25595509e-02f, -1.11229114e-01f, -6.42919391e-02f, -3.02815139e-02f, -3.07279415e-02f, 1.11705856e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  2.57364631e-01f, 7.50766993e-02f, 2.66031504e-01f, 2.49194115e-01f, 2.48006910e-01f, 2.56740481e-01f, 5.63887894e-01f, 3.40491354e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -2.57281780e-01f, 1.07831508e-02f, 1.39812961e-01f, -4.62154508e-01f, 3.22136223e-01f, 3.31747055e-01f, 3.27102602e-01f, -1.06107004e-01f, 2.09721208e-01f, 1.11669928e-01f,
  7.32875913e-02f, -2.20579028e-01f, 2.92072028e-01f, -5.19991875e-01f, -1.29490256e-01f, -2.54632294e-01f, -3.50349039e-01f, -9.20682773e-02f, 6.95417896e-02f, 3.80735874e-01f,
  3.79927069e-01f, -3.22100013e-01f, 2.31525884e-03f, -3.00167918e-01f, 3.36775035e-02f, -4.69137192e-01f, -3.90114248e-01f, 2.68455178e-01f, 8.70357677e-02f, 1.51956707e-01f,
  -3.13756794e-01f, 1.42422363e-01f, 3.23731661e-01f, 5.95787028e-03f, -1.08111780e-02f, -2.27855876e-01f, 2.26355314e-01f, 4.19747233e-01f, -3.47945511e-01f, 6.03760034e-02f,
  1.47795692e-01f, -3.55584234e-01f, 3.08425575e-01f, -5.50408661e-01f, -1.25096396e-01f, 2.00033396e-01f, 6.62962437e-01f, 1.81934610e-01f, 1.72380969e-01f, -5.48438169e-02f,
  8.36256444e-02f, -5.22909820e-01f, 1.42007917e-01f, 1.19169094e-02f, -4.42175001e-01f, 1.12430729e-01f, -2.40931138e-01f, 2.01923609e-01f, 1.86076596e-01f, -3.33406895e-01f,
  -5.15632192e-03f, 1.16091765e-01f, 1.82657197e-01f, 4.24452184e-04f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  1.68934837e-01f, 1.18110791e-01f, -1.61573797e-01f, 1.07698679e-01f, -4.64403659e-01f, 3.12717289e-01f, 2.43561342e-01f, -2.55862862e-01f, 2.08845183e-01f, -2.22040072e-01f,
  4.97615010e-01f, 3.51711303e-01f, -6.59230173e-01f, 1.10987924e-01f, 4.64198023e-01f, -3.39215398e-01f, 1.40827177e-02f, -3.75905260e-02f, 4.90166485e-01f, 6.56191230e-01f,
  2.03875229e-01f, -8.12078774e-01f, 1.77074745e-01f, 1.04364313e-01f, 2.94799179e-01f, 2.53538847e-01f, 2.32939333e-01f, 5.47186673e-01f, -1.04351997e-01f, -1.09536543e-01f,
  -6.43221736e-01f, -8.98998976e-02f, 6.01509631e-01f, 6.94059253e-01f, 3.76543730e-01f, 5.91413490e-02f, 5.09778857e-01f, 4.30588156e-01f, 1.11690247e-02f, -2.33975619e-01f,
  9.06970203e-01f, 3.64379406e-01f, 1.62935615e-01f, -6.99225441e-02f, 5.36333382e-01f, 1.81184381e-01f, 5.24607003e-01f, 9.27455306e-01f, 5.58314860e-01f, 4.70637172e-01f,
  5.20597637e-01f, 3.78715426e-01f, -2.20618188e-01f, -4.10461009e-01f, -4.38745737e-01f, 2.89889220e-02f, -3.42861384e-01f, -1.88242897e-01f, -6.41952813e-01f, -7.69277848e-03f,
  5.60187884e-02f, 4.95428383e-01f, 1.89192206e-01f, 6.41895175e-01f, 4.91949081e-01f, 4.14180428e-01f, -3.30410302e-01f, 4.55661029e-01f, -2.03381762e-01f, -8.75036716e-01f,
  -3.41114104e-01f, 1.67064115e-01f, -3.59294862e-01f, 4.82984215e-01f, 6.34601414e-01f, 4.39005941e-01f, -3.62803489e-01f, 3.86165202e-01f, 1.58265710e-01f, -1.82368740e-01f,
  4.28218305e-01f, -1.17008112e-01f, 4.71538991e-01f, -8.28413945e-03f, 8.12459737e-02f, -2.39851445e-01f, 1.65580451e-01f, 6.65066719e-01f, -4.87448841e-01f, -1.45141438e-01f,
  3.14686030e-01f, 1.65007815e-01f, 6.38490558e-01f, 5.76282918e-01f, 5.86655214e-02f, -2.74455011e-01f, 1.49989650e-01f, 2.68869638e-01f, 2.11448953e-01f, 7.27412045e-01f,
  -8.94857526e-01f, 3.23341638e-01f, 6.12208396e-02f, -4.02636230e-01f, 1.04681619e-01f, 1.06712179e-02f, 3.26951176e-01f, 6.16453469e-01f, -4.86574799e-01f, 2.88682550e-01f,
  6.24357045e-01f, -1.13599718e-01f, -2.90907264e-01f, 5.54541312e-02f, 4.38144505e-01f, 2.18769059e-01f, -3.30152392e-01f, 6.01619661e-01f, 6.47236049e-01f, -5.03838480e-01f,
  4.21708256e-01f, 4.41748470e-01f, -2.89242156e-02f, 3.07355314e-01f, -3.88947129e-01f, 7.79948533e-02f, 4.46851194e-01f, -3.67847800e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  2.94937015e-01f, 1.12349145e-01f, 4.50879842e-01f, 3.95968944e-01f, -2.10293885e-02f, 3.85789335e-01f, 5.15854299e-01f, 4.87502337e-01f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -1.36534916e-02f, 3.58584702e-01f, -7.88475797e-02f, -1.49760291e-01f, 2.41318449e-01f, -4.96739477e-01f, 4.64730740e-01f, 3.09216946e-01f, 2.90699601e-01f, -3.28609437e-01f,
  1.67326644e-01f, -2.01403543e-01f, -2.20489070e-01f, 2.17142135e-01f, -1.39748245e-01f, 1.13347426e-01f, -2.10502565e-01f, 1.82438105e-01f, -1.04866782e-02f, -5.49136922e-02f,
  9.82356630e-03f, 6.28990233e-02f, 5.54204345e-01f, 6.01417601e-01f, 1.18362263e-01f, -5.29598296e-01f, 1.43859908e-02f, 1.74170882e-02f, 3.14150423e-01f, 4.38034028e-01f,
  -1.19976312e-01f, -1.54879183e-01f, -5.78503795e-02f, 1.06461316e-01f, -1.65846393e-01f, 4.21394035e-02f, 5.34575701e-01f, -1.83610618e-01f, 1.63028792e-01f, 4.53820705e-01f,
  -3.04036349e-01f, -1.59729600e-01f, 3.31650525e-01f, 1.65058032e-01f, -1.39479697e-01f, -3.78917217e-01f, -4.71999973e-01f, 3.89194041e-01f, -5.12202799e-01f, -3.11715364e-01f,
  2.60479152e-01f, 1.15694590e-02f, 2.94409901e-01f, 2.13489205e-01f, -3.07776242e-01f, 3.44704837e-01f, -2.05654636e-01f, 3.83575141e-01f, -1.01464592e-01f, -1.80344760e-01f,
  4.09178406e-01f, 3.49261671e-01f, -3.40253472e-01f, 9.39784795e-02f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  1.48480341e-01f, 5.39961398e-01f, -1.85205027e-01f, -1.53908571e-02f, -6.74991608e-02f, 7.06534207e-01f, 5.85004926e-01f, -9.23107713e-02f, -7.43857443e-01f, -3.64609808e-01f,
  6.23940289e-01f, 4.92255598e-01f, -4.57577825e-01f, -4.73784238e-01f, -5.39906442e-01f, -5.95046699e-01f, -3.15819293e-01f, -2.10580051e-01f, 3.66776228e-01f, 4.83691275e-01f,
  5.95898271e-01f, 1.34397194e-01f, 3.80667776e-01f, 7.98238337e-01f, -6.21205151e-01f, -4.84389067e-02f, 3.39321911e-01f, 5.49660444e-01f, 1.01346269e-01f, 7.71964014e-01f,
  -6.30476475e-02f, -1.84936762e-01f, 3.22870493e-01f, 1.56081140e-01f, 3.50150578e-02f, 1.41926154e-01f, -2.30134696e-01f, -4.62530434e-01f, 5.36362290e-01f, -1.94006369e-01f,
  4.14716810e-01f, -5.02600312e-01f, 3.02573800e-01f, -1.76599875e-01f, -2.20113188e-01f, -2.52610922e-01f, 5.88602424e-01f, 8.28870893e-01f, 4.00115669e-01f, 9.88093078e-01f,
  -4.29867804e-01f, 8.47019434e-01f, -1.05989289e+00f, -8.45545948e-01f, 2.24054784e-01f, 3.83443683e-01f, 5.18241227e-01f, -3.28041673e-01f, 6.34267271e-01f, 7.32282281e-01f,
  6.85506344e-01f, 3.18688780e-01f, 6.75279856e-01f, 7.27457225e-01f, -3.45820159e-01f, 1.49231963e-02f, -3.01660210e-01f, 2.25430831e-01f, -8.19754183e-01f, -3.92061360e-02f,
  2.78122365e-01f, 6.48139060e-01f, -7.38057215e-03f, 4.81826961e-02f, 6.95903599e-02f, 7.95218110e-01f, 8.97325873e-01f, 4.84226018e-01f, 3.14108700e-01f, -4.86169130e-01f,
  3.09476376e-01f, 4.93870042e-02f, 5.12471378e-01f, 6.33943379e-01f, 1.01068723e+00f, 4.83208716e-01f, 1.22157246e-01f, -1.87480599e-01f, -4.17218715e-01f, 3.76092315e-01f,
  9.41197395e-01f, 5.89524508e-02f, -1.15042388e-01f, 1.26096338e-01f, -4.29043710e-01f, 3.37211549e-01f, 4.95643109e-01f, 7.52974451e-01f, 9.20776486e-01f, 2.58785397e-01f,
  -4.32197750e-01f, 1.05350518e+00f, -7.48421729e-01f, -5.22820055e-01f, -2.77882516e-01f, 5.96023917e-01f, -2.34333023e-01f, 6.99201465e-01f, -1.47447572e-03f, 3.06139022e-01f,
  2.69133687e-01f, 1.70177206e-01f, 1.02470452e-02f, -3.36947143e-01f, -3.01206112e-02f, 7.47853070e-02f, -3.09236676e-01f, -3.46273512e-01f, -2.16501012e-01f, -1.40297279e-01f,
  4.57679868e-01f, 2.58979887e-01f, -1.69063687e-01f, -7.81109869e-01f, 8.08157742e-01f, 2.79364407e-01f, 3.36801916e-01f, -8.00354332e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  1.74146727e-01f, 2.97077268e-01f, 2.44980022e-01f, 6.65513813e-01f, 6.81225881e-02f, 4.94998753e-01f, 4.17927802e-01f, -3.47145796e-01f
};

// L3_fan_Wp (Shape: 4 x 16)
const int L3_fan_Wp_rows = 4;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  1.92468852e-01f, 7.86003917e-02f, -1.18967846e-01f, -5.14326338e-03f, 3.07861596e-01f, -1.95313245e-02f, 4.96838689e-02f, 1.47985652e-01f, 1.34508044e-01f, 2.30401848e-02f,
  3.02826375e-01f, -5.67258857e-02f, -2.14696258e-01f, 3.56866837e-01f, -2.83513933e-01f, 3.94870993e-03f, -6.93519935e-02f, -9.13723782e-02f, 2.52785534e-01f, 4.33540083e-02f,
  -2.11066008e-01f, 2.25897565e-01f, -1.18591785e-01f, 3.20312474e-03f, 5.17172456e-01f, 2.09569782e-01f, 8.33481103e-02f, -2.46831015e-01f, 2.85386518e-02f, -5.86507563e-03f,
  3.11459571e-01f, -2.50015318e-01f, 3.16040739e-02f, -3.37584764e-01f, 5.94274819e-01f, 3.12679380e-01f, 1.47073179e-01f, -1.17362529e-01f, -7.95290887e-01f, 1.32079318e-01f,
  -3.92852187e-01f, 1.97903007e-01f, 3.32531959e-01f, 1.13338128e-01f, -3.32668841e-01f, -1.53792769e-01f, 1.02097020e-01f, -2.60923594e-01f, 3.45832169e-01f, -4.04508919e-01f,
  -1.81206793e-01f, 1.69027179e-01f, -3.91125441e-01f, -8.01292717e-01f, -4.56783563e-01f, 6.80763483e-01f, -1.85047522e-01f, -3.16066325e-01f, -1.58022970e-01f, 7.42314383e-02f,
  -1.44573942e-01f, 2.23353133e-02f, 5.62797152e-02f, 3.50835115e-01f
};

// L3_fan_Wp_bar (Shape: 8 x 16)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -6.65154099e-01f, 6.11493707e-01f, -1.46580130e-01f, -5.71971118e-01f, -5.35863221e-01f, 8.92750800e-01f, 3.35149094e-02f, 9.34492290e-01f, 2.59100556e-01f, 1.33437559e-01f,
  -1.84015378e-01f, 3.47975135e-01f, 5.45226395e-01f, -2.87779689e-01f, 4.59893584e-01f, 1.10188115e+00f, 6.74460173e-01f, 1.43903792e-01f, -4.20459360e-02f, 6.24003075e-02f,
  -2.42416903e-01f, -5.20273268e-01f, -9.59824860e-01f, -5.25313020e-01f, -1.13938749e+00f, -4.01775122e-01f, 1.05710459e+00f, 4.12642658e-01f, -5.85800290e-01f, 2.01076433e-01f,
  5.09759009e-01f, -2.25084215e-01f, 8.46556872e-02f, -6.85455024e-01f, 1.55145615e-01f, 3.18462104e-01f, 8.68396103e-01f, -1.70243979e-01f, 7.97420800e-01f, 1.19248927e+00f,
  -8.47162545e-01f, 8.92369449e-01f, 2.37955436e-01f, 4.86383110e-01f, 1.93547711e-01f, 4.87003356e-01f, -1.05623949e+00f, -5.53533547e-02f, 3.74064893e-01f, 4.66059893e-01f,
  -3.90485168e-01f, 5.59448957e-01f, -2.54454494e-01f, -1.09924865e+00f, 5.07152021e-01f, -3.35144438e-02f, 8.44037652e-01f, 1.06122509e-01f, 4.26027551e-02f, 1.70327574e-01f,
  -5.12858927e-01f, 1.30976295e+00f, 4.19008702e-01f, -5.67446351e-01f, 8.10316622e-01f, -3.76581460e-01f, -2.40200102e-01f, 5.14770448e-01f, 1.73138473e-02f, 1.77928045e-01f,
  -6.94380775e-02f, -7.14132130e-01f, 3.49377602e-01f, -1.67604849e-01f, -2.06256732e-01f, 8.46370995e-01f, 8.35679352e-01f, -6.01525486e-01f, 3.58595736e-02f, 4.09732044e-01f,
  1.54117942e-01f, 5.86443901e-01f, 5.43913066e-01f, -1.87839314e-01f, 3.28312635e-01f, 4.10747856e-01f, 3.50190341e-01f, -1.25468802e+00f, 1.26303941e-01f, -4.27902818e-01f,
  9.28611934e-01f, 9.36281323e-01f, 3.26331079e-01f, -5.20224333e-01f, -3.07385385e-01f, 2.50682473e-01f, 2.27944925e-01f, 2.99349129e-01f, 8.63933623e-01f, 6.79579079e-01f,
  -7.77303398e-01f, 5.51654696e-01f, -6.30243659e-01f, 7.78316081e-01f, 3.42262626e-01f, 1.00025725e+00f, -6.11025870e-01f, 3.55140775e-01f, 2.54666716e-01f, 6.27957940e-01f,
  8.76068711e-01f, -6.28856719e-01f, 2.70078424e-02f, 4.13910346e-03f, 6.69270873e-01f, 3.36317748e-01f, -8.79485786e-01f, -3.31796080e-01f, -7.85068333e-01f, 2.40051508e-01f,
  -7.41074800e-01f, 1.83373332e-01f, -3.81708950e-01f, 7.41138682e-02f, 6.52140319e-01f, -2.55758733e-01f, 1.23396444e+00f, -1.54319435e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  2.75103841e-02f, 5.10956407e-01f, 2.33149320e-01f, 6.46741688e-01f, -7.30693936e-02f, 2.53684223e-01f, 3.85497123e-01f, 4.25920695e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -1.97275788e-01f, -1.43551752e-01f, 4.24097925e-01f, -3.11167836e-01f, -5.53248405e-01f, 7.49297440e-01f, -4.51908499e-01f, -7.26749122e-01f, 2.81894565e-01f, -3.91442299e-01f,
  -4.07830924e-01f, -5.01355827e-01f, -1.00883178e-01f, -6.88252747e-01f, 5.62820554e-01f, 5.36665797e-01f, 8.61519277e-02f, -3.90897423e-01f, -5.72168231e-01f, 4.08121705e-01f,
  -1.41218305e-01f, -8.59960973e-01f, -1.09750307e+00f, 1.00547850e+00f, 5.73066831e-01f, -4.30850208e-01f, -8.28736365e-01f, -1.05023241e+00f, 1.43818185e-01f, 1.20802447e-01f,
  1.03336878e-01f, 2.36606628e-01f, -2.68140852e-01f, 2.25548893e-01f, 1.89404830e-01f, -4.61339861e-01f, -4.24443930e-01f, 4.43084300e-01f, -6.20459914e-01f, 6.43906653e-01f,
  1.06508851e-01f, -9.64105964e-01f, 4.01157916e-01f, -7.73330808e-01f, 5.31312823e-01f, 2.57947773e-01f, -1.07780683e+00f, -7.21718445e-02f, -3.73700231e-01f, -1.26483753e-01f,
  -3.85729223e-01f, 4.64376539e-01f, -2.29455307e-02f, 5.06271660e-01f, -6.67175472e-01f, -2.74717391e-01f, -1.20164180e+00f, -7.21057236e-01f, -2.40915760e-01f, 7.54212081e-01f,
  -6.86248064e-01f, -8.05430770e-01f, 4.28718895e-01f, -7.98012197e-01f, 4.25445825e-01f, 5.99266142e-02f, -5.24207294e-01f, -1.92310959e-01f, 3.71073455e-01f, 2.35088035e-01f,
  -5.42048752e-01f, -1.23280965e-01f, 2.66756862e-02f, -5.68251848e-01f, -2.02977657e-01f, 2.52851933e-01f, 3.37763041e-01f, 1.16575316e-01f, 2.54814953e-01f, -5.37508249e-01f,
  2.54702389e-01f, 4.28109914e-01f, -1.48535356e-01f, 3.74460638e-01f, -3.34874690e-01f, -5.16772866e-01f, 5.58482349e-01f, 3.89373600e-01f, -5.85178614e-01f, 8.41921926e-01f,
  -1.30959773e+00f, -1.15559638e-01f, 3.02727401e-01f, 1.86907977e-01f, -4.69396263e-02f, 3.01817566e-01f, 4.55624551e-01f, -2.81701475e-01f, -2.54448235e-01f, 3.97532046e-01f,
  8.14340949e-01f, -3.55457030e-02f, 3.69339943e-01f, -4.03611213e-01f, 2.45742157e-01f, 3.14692467e-01f, -4.20777619e-01f, -8.94114017e-01f, 2.67281950e-01f, 5.57892025e-01f,
  -1.07793438e+00f, -9.77101743e-01f, -2.19576478e-01f, -1.69808164e-01f, 1.19835496e-01f, 2.80331612e-01f, 1.50813252e-01f, -5.24016619e-01f, 9.19228494e-02f, 1.18363035e+00f,
  -2.26161405e-01f, 5.88472068e-01f, 7.36678064e-01f, 3.65515441e-01f, -4.34492111e-01f, -8.39800239e-01f, -3.93424541e-01f, -7.84339726e-01f, 1.20998628e-01f, 6.52475655e-01f,
  4.73831028e-01f, -2.98096985e-01f, 6.51761949e-01f, 5.94731987e-01f, 2.31544465e-01f, -6.31862462e-01f, -1.97949126e-01f, -6.74001753e-01f, 9.12652194e-01f, -2.21975893e-01f,
  -5.29656410e-01f, -5.57543099e-01f, 4.41442579e-01f, -4.62502867e-01f, 3.78324091e-01f, -1.17638916e-01f, 2.93407924e-02f, -4.64711905e-01f, -3.05022180e-01f, -4.71763521e-01f,
  8.98736596e-01f, -5.89020133e-01f, -4.19831336e-01f, -1.39436871e-01f, 7.06682876e-02f, -9.50522900e-01f, 3.01378369e-01f, 4.20589983e-01f, 2.29221255e-01f, 9.83784348e-02f,
  6.44063115e-01f, 1.36525735e-01f, 6.45760670e-02f, 1.82723820e-01f, -2.92176753e-01f, 8.93024087e-01f, 6.70452714e-01f, 7.30360568e-01f, -4.27069277e-01f, 5.42598307e-01f,
  -8.72393727e-01f, 2.86733419e-01f, -1.17726910e+00f, -1.31391060e+00f, 3.17595124e-01f, 7.99664378e-01f, -1.80474192e-01f, -1.56272992e-01f, 2.20673174e-01f, -7.63791800e-02f,
  1.58235535e-01f, -2.22652823e-01f, 3.41418475e-01f, -8.73710811e-01f, -5.79114854e-01f, 3.79546583e-01f, 1.45944417e-01f, 3.15580785e-01f, -4.61974591e-01f, 5.90310872e-01f,
  -1.06077206e+00f, -4.86422777e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -8.51960257e-02f, 1.69739559e-01f, 1.95694510e-02f, -9.22552422e-02f, 1.14604779e-01f, -6.12961501e-02f, -1.13379084e-01f, 1.07216224e-01f, -4.25689146e-02f, 4.51617986e-02f,
  1.81470081e-01f, -6.34301305e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    