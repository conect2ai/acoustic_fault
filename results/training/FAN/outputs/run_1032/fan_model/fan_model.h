/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.61308885e-01f, -8.94911811e-02f, 9.76521336e-03f, -6.97295144e-02f, 1.72767609e-01f, -5.07175401e-02f, -5.23652881e-02f, -1.15339383e-01f, -6.05542921e-02f, -1.14936367e-01f,
  1.23374246e-01f, 1.98289275e-01f, -6.16816916e-02f, 1.37223944e-01f, -3.60002033e-02f, -1.94770604e-01f, 1.15184300e-02f, -1.55723155e-01f, -6.90661073e-02f, 5.81740625e-02f,
  1.72599792e-01f, -1.67640205e-02f, -7.56501406e-02f, 6.07165694e-02f, 3.04040220e-03f, 1.23829775e-01f, -5.01274280e-02f, 1.02703311e-01f, 1.67270139e-01f, 1.75567910e-01f,
  -2.82354224e-02f, -1.60961989e-02f, 5.47865666e-02f, 1.07839018e-01f, 5.70913441e-02f, -5.19316308e-02f, -2.41357759e-02f, -4.04095091e-02f, -3.76340561e-02f, 1.02654183e-02f,
  6.38411567e-02f, 5.71554936e-02f, 8.62720385e-02f, 6.19637221e-02f, -2.28831358e-03f, 4.21144143e-02f, -8.48532934e-03f, 1.51122240e-02f, 1.30673898e-02f, -3.70251164e-02f,
  1.12511471e-01f, 9.59171355e-02f, -3.58423330e-02f, 5.80278486e-02f, 7.76663944e-02f, 1.60724986e-02f, 9.75638479e-02f, 1.02799267e-01f, 1.62375357e-03f, -2.33843829e-02f,
  -1.02462761e-01f, -6.75949827e-02f, 4.25393060e-02f, -6.63672388e-02f, -1.09827027e-01f, -1.72711194e-01f, -3.15273320e-03f, -1.81129724e-02f, -3.60223316e-02f, -7.66805708e-02f,
  -1.89375523e-02f, -1.10478625e-01f, -2.55926177e-02f, -7.82702416e-02f, 1.50296809e-02f, 1.06272614e-02f, -2.09441092e-02f, 3.21885832e-02f, 2.96011399e-02f, -1.99189354e-02f,
  4.73741628e-02f, -4.14722152e-02f, -3.27015156e-03f, 2.80423816e-02f, -6.97000138e-03f, -1.03823178e-01f, 6.28853515e-02f, -5.30938525e-03f, -5.64585030e-02f, 1.98686123e-02f,
  -5.50789870e-02f, 1.90896869e-01f, -2.44176183e-02f, 1.95430219e-02f, 1.25595599e-01f, 2.66350508e-02f, 8.92801732e-02f, 1.88371480e-01f, 1.82989269e-01f, 4.13550586e-02f,
  1.46793813e-01f, 3.08834668e-02f, 2.26702932e-02f, 1.14107609e-01f, 7.75027871e-02f, 8.64996240e-02f, 1.00565672e-01f, -1.34015763e-02f, 1.69304684e-02f, 1.14962362e-01f,
  6.73709214e-02f, -3.68469618e-02f, -2.00949207e-01f, -5.29291295e-02f, 3.84259783e-02f, 5.43207955e-03f, -1.42337009e-02f, -2.00748798e-02f, -7.39026517e-02f, -2.65596569e-01f,
  -1.33096829e-01f, -1.40574679e-01f, -1.86107650e-01f, -2.52357930e-01f, -7.14471787e-02f, -3.10069695e-02f, 4.13827077e-02f, 8.66794214e-02f, 3.47794802e-03f, -1.36523440e-01f,
  1.52416239e-02f, 5.33792004e-02f, -4.97259386e-02f, -6.95474520e-02f, 5.89225814e-02f, -2.89371222e-01f, -3.11560690e-01f, -2.05166906e-01f, -3.10623609e-02f, -2.52121110e-02f,
  6.86020330e-02f, -1.16006941e-01f, -1.93489832e-03f, 1.06160669e-02f, -1.35111645e-01f, -6.74939826e-02f, -1.67668402e-01f, -6.14694804e-02f, -6.94656372e-02f, -2.74345309e-01f,
  -3.15781444e-01f, 1.35702014e-01f, 1.04316369e-01f, 1.09954566e-01f, -5.37912212e-02f, 4.16945890e-02f, 8.06769952e-02f, 8.44982173e-03f, 6.91903606e-02f, 5.60267568e-02f,
  -5.04252827e-03f, 2.44175103e-02f, -1.18945450e-01f, 1.09698109e-01f, -1.09264748e-02f, 1.10744826e-01f, 2.38824710e-02f, -6.69637248e-02f, -1.27585158e-02f, -1.71125885e-02f,
  7.71791190e-02f, 9.54322238e-03f, 6.33656904e-02f, 1.85561806e-01f, 1.37825593e-01f, 5.87892532e-02f, 7.66737536e-02f, 2.17933044e-01f, 9.40563157e-02f, 8.86380970e-02f,
  -5.83738536e-02f, -4.53101024e-02f, -5.91564272e-03f, 1.45275313e-02f, 9.76047739e-02f, 5.18909469e-02f, -9.10388380e-02f, 2.00659297e-02f, -9.78619978e-03f, 3.52820233e-02f,
  -2.34477315e-02f, 6.15937868e-03f, -2.55918652e-02f, -1.44654214e-01f, -9.80992094e-02f, -1.50039475e-02f, 8.26313272e-02f, -1.14329029e-02f, 1.48960277e-01f, 6.16676547e-02f,
  4.96623069e-02f, 2.47511901e-02f, -1.45423012e-02f, 2.42056064e-02f, -2.22390909e-02f, 1.96063495e-03f, 4.41689976e-02f, 3.30177918e-02f, -7.92201050e-03f, 6.94507062e-02f,
  -1.45928741e-01f, 2.31060311e-01f, -2.04703193e-02f, 4.87545356e-02f, -1.91254579e-02f, 7.20443130e-02f, -6.82736188e-02f, -2.02198862e-03f, 4.21317928e-02f, 4.29255981e-03f,
  9.96011049e-02f, -7.00400844e-02f, 7.95570947e-03f, 3.16300914e-02f, -1.72368682e-03f, 4.98567373e-02f, 2.78168637e-02f, -1.08785033e-01f, -8.84463917e-03f, 7.32809678e-02f,
  -1.01778477e-01f, -4.03077379e-02f, -9.26010907e-02f, 2.89315078e-02f, 1.12165660e-01f, -8.82514380e-03f, 4.27470319e-02f, -4.32186611e-02f, 6.19951114e-02f, -4.89352569e-02f,
  -1.35342106e-01f, -2.62356997e-01f, -7.33283013e-02f, -1.48568362e-01f, 4.20481013e-03f, 2.27995127e-01f, 1.88817009e-02f, 2.21549682e-02f, 6.19734377e-02f, -1.87958315e-01f,
  -7.52445012e-02f, 2.75052395e-02f, -6.21198565e-02f, 6.92112818e-02f, 1.60168245e-01f, -2.37761121e-02f, -7.19843805e-03f, 8.64124577e-03f, 3.82647663e-01f, 2.85261780e-01f,
  1.01648346e-01f, -5.61148301e-02f, 1.01592660e-01f, 3.36141922e-02f, -1.97790921e-01f, -1.60288550e-02f, -2.26420715e-01f, -1.95008963e-01f, -8.74985605e-02f, -3.53469580e-01f,
  -2.90506482e-01f, -1.19658820e-01f, 5.82849681e-02f, 1.37246074e-02f, -7.68029764e-02f, -1.78373680e-02f, 4.17239442e-02f, -4.43469733e-02f, -4.01706249e-02f, -8.32457766e-02f,
  -9.52344984e-02f, 7.23393634e-02f, -5.64282313e-02f, -2.55618058e-02f, -8.50749612e-02f, -2.49291621e-02f, -4.76041846e-02f, -4.63204235e-02f, -9.03950557e-02f, 1.51267117e-02f,
  -2.37547816e-03f, -6.29425347e-02f, -1.55972794e-01f, -2.69449688e-02f, -6.44120201e-03f, 1.61041915e-01f, -5.95272109e-02f, -7.71267563e-02f, -2.19658054e-02f, -2.92871654e-01f,
  6.19885232e-03f, 2.25296710e-02f, -3.19603048e-02f, -1.14447856e-02f, -4.91769810e-04f, -7.76959881e-02f, -4.32470962e-02f, -4.83208746e-02f, 2.66737770e-02f, -5.65241463e-02f,
  5.75023219e-02f, 9.41310301e-02f, 2.59803068e-02f, -4.65636961e-02f, -6.13885671e-02f, -2.42803283e-02f, 1.15512554e-02f, -6.27095345e-03f, -2.43024863e-02f, -1.36341348e-01f,
  1.36474725e-02f, 1.89677812e-02f, -6.18871190e-02f, -1.70052852e-02f, 1.10538928e-02f, -8.41101818e-03f, -3.92505601e-02f, 7.61581659e-02f, 3.53495292e-02f, 3.56438942e-02f,
  -1.34687632e-01f, 1.90934762e-01f, -9.78915095e-02f, 4.81377877e-02f, 3.55285518e-02f, 8.30021426e-02f, 2.58994531e-02f, 4.35243845e-02f, -4.18525226e-02f, -7.28434883e-03f,
  8.53043515e-03f, -6.87337443e-02f, -2.16420204e-03f, -8.29611644e-02f, 1.49197608e-01f, 7.71337152e-02f, -2.08293591e-02f, -5.16256876e-03f, 6.91393986e-02f, -2.84185018e-02f,
  3.71744223e-02f, 1.52834609e-01f, 1.13509305e-01f, -6.90181777e-02f, -3.33593339e-02f, 7.48087168e-02f, 4.58125621e-02f, 4.06667404e-02f, 1.22619480e-01f, 3.89071591e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  8.70281100e-01f, 6.03233457e-01f, -2.21974909e-01f, 5.44843115e-02f, -3.47298205e-01f, -2.08638430e-01f, 2.88612694e-01f, 2.77116269e-01f, 4.24945056e-02f, 2.26013184e-01f,
  -1.33805737e-01f, -2.63374656e-01f, -7.17964023e-02f, 2.90906262e-02f, 1.76709384e-01f, 1.54959366e-01f, -9.62420106e-02f, -1.01601936e-01f, -1.85630232e-01f, -1.49684250e-01f,
  9.20890868e-02f, 3.23938668e-01f, 3.30573112e-01f, 3.74721512e-02f, -1.96229443e-02f, -7.97675848e-02f, -6.91070361e-03f, -2.70445012e-02f, -1.57203432e-02f, 2.76243519e-02f,
  -4.27303702e-01f, 1.01114497e-01f, -2.12560788e-01f, 5.57803623e-02f, -1.46008909e-01f, 2.30192602e-01f, -1.68534853e-02f, 8.30981731e-02f, 1.31666183e-01f, 9.37895849e-02f,
  -2.79841740e-02f, 4.46585231e-02f, -2.65612938e-02f, 1.38408493e-03f, -1.20286711e-01f, -8.24570656e-03f, 1.20315120e-01f, 7.25626573e-02f, -8.57183561e-02f, 5.83802462e-02f,
  -1.46476656e-01f, -1.41354308e-01f, -2.08242327e-01f, -7.30883852e-02f, -5.70892394e-02f, -2.91829944e-01f, -8.64558145e-02f, -1.86337963e-01f, -2.39242047e-01f, 1.72268227e-01f,
  -6.36254065e-03f, 3.68959755e-02f, -8.94155875e-02f, -1.53128266e-01f, 4.42805998e-02f, -8.36906880e-02f, -3.60499881e-02f, 1.07942475e-02f, 1.19543798e-01f, 1.81289911e-01f,
  -8.55013281e-02f, -9.43390876e-02f, -1.39280617e-01f, 7.09304586e-02f, -1.74697101e-01f, -2.97929794e-02f, 6.18925616e-02f, 2.56404914e-02f, -8.43302682e-02f, 3.85404229e-02f,
  -3.56834419e-02f, -4.90853190e-02f, -8.43114108e-02f, -9.29896832e-02f, -2.23408192e-01f, -1.92023143e-01f, -1.22726254e-01f, -1.06127411e-01f, 1.37828812e-01f, 1.43788263e-01f,
  -6.56489134e-02f, -5.32127500e-01f, 1.21685341e-01f, 2.31643751e-01f, -1.30707743e-02f, 1.42484352e-01f, -7.73063824e-02f, -6.59632012e-02f, -4.21923323e-04f, -3.01704705e-02f,
  -5.33801652e-02f, -2.94671021e-02f, 1.86616872e-02f, 1.28838673e-01f, 2.36413702e-02f, -4.24924009e-02f, 8.17177147e-02f, -2.88652368e-02f, 3.00876610e-02f, -6.31922260e-02f,
  1.77571163e-01f, 6.28594458e-02f, 4.43027690e-02f, 6.67730160e-03f, -5.04639447e-02f, 9.14067496e-03f, -3.24173160e-02f, -7.06053451e-02f, -1.18730456e-01f, 3.73460919e-01f,
  2.49709621e-01f, -2.65376031e-01f, -2.22032949e-01f, -2.93808222e-01f, -3.18700254e-01f, -2.69113451e-01f, -5.05187809e-01f, -2.84647867e-02f, 5.20454049e-02f, -4.06758994e-01f,
  -2.97488749e-01f, 1.11807980e-01f, 3.99436690e-02f, 2.12714821e-01f, 1.71160743e-01f, -3.40500772e-01f, -2.86611736e-01f, 2.34156117e-01f, 3.15385669e-01f, -1.16502419e-02f,
  -1.84905410e-01f, 6.13388456e-02f, 3.07095945e-01f, 2.21972764e-01f, -4.24527138e-01f, -6.71421513e-02f, -2.49676257e-01f, -6.95397258e-02f, -1.56006351e-01f, -5.24553120e-01f,
  -3.96748364e-01f, -1.46081328e-01f, 8.29626899e-03f, 4.44036303e-03f, -2.55558580e-01f, 2.35702321e-02f, -2.68202752e-01f, -8.24545994e-02f, -5.33649400e-02f, -1.45311221e-01f,
  -1.66529492e-01f, -3.96971926e-02f, 8.04181099e-02f, -4.32722718e-02f, -1.75178677e-01f, -3.46303508e-02f, 1.33300930e-01f, 1.73973858e-01f, 9.50318277e-02f, -4.11675200e-02f,
  -8.82362500e-02f, -4.14340012e-02f, -4.12927866e-02f, 1.07334904e-01f, 6.47572353e-02f, 1.82090685e-01f, -2.12628320e-02f, 1.20382473e-01f, 2.48934016e-01f, -1.20983861e-01f,
  8.85881335e-02f, -1.50568753e-01f, -1.01625547e-01f, 4.33062576e-02f, 4.29777130e-02f, 8.81097764e-02f, -2.44334172e-02f, -7.97823668e-02f, 1.22796848e-01f, -1.55756110e-03f,
  5.61916381e-02f, 7.76487365e-02f, -5.96522586e-05f, -3.78330462e-02f, -5.09285331e-02f, 9.03808698e-02f, 1.03514373e-01f, -7.48207122e-02f, 2.10183300e-02f, 3.33278701e-02f,
  1.93724036e-02f, 2.82674469e-02f, 8.19217972e-03f, -5.43565862e-03f, 2.95772608e-02f, -8.21573585e-02f, 2.58167759e-02f, 1.23010263e-01f, 7.83414617e-02f, 1.37827871e-02f,
  -2.32435256e-01f, 1.97645098e-01f, -2.96520084e-01f, 8.95998999e-02f, -1.78788602e-02f, -4.57980447e-02f, -2.90449768e-01f, 1.60434097e-02f, -2.10853741e-02f, -1.48468807e-01f,
  2.21022367e-02f, 8.43815729e-02f, -9.99391377e-02f, -7.52562284e-02f, 1.86290331e-02f, 3.54910344e-02f, 5.33712693e-02f, -7.30724409e-02f, 1.27210662e-01f, 5.86837418e-02f,
  2.10840985e-01f, -1.67482272e-02f, 8.71047974e-02f, 4.04463746e-02f, 7.64617976e-03f, 9.32384431e-02f, -5.56922937e-03f, 5.16971387e-02f, 2.50029147e-01f, -1.00166649e-01f,
  -6.78448021e-01f, -3.64447147e-01f, 1.65784568e-01f, -2.36715630e-01f, -3.33297513e-02f, 1.48231477e-01f, 1.37289569e-01f, 1.72417387e-02f, -8.28617662e-02f, -7.31836781e-02f,
  -1.49290571e-02f, 4.05387990e-02f, -6.11670427e-02f, -2.89013404e-02f, -1.02400549e-01f, 2.26525939e-03f, -3.85188572e-02f, -1.87059566e-02f, 2.72920877e-01f, 2.12017268e-01f,
  -7.67912949e-03f, -1.65706992e-01f, -3.54772449e-01f, -1.10736378e-01f, -7.51474276e-02f, 7.99506307e-02f, 1.29395738e-01f, 1.13394121e-02f, 1.39716983e-01f, 6.99610487e-02f,
  3.44651401e-01f, -6.50398955e-02f, 8.24578553e-02f, -1.88153327e-01f, -8.33336040e-02f, -7.86651671e-02f, -2.10573673e-02f, -1.11941874e-01f, 3.24375159e-03f, 1.52705431e-01f,
  -5.87241165e-03f, -9.23833475e-02f, -8.28806832e-02f, 1.31542340e-01f, 7.19211251e-02f, 2.32649986e-02f, 7.25066289e-02f, 2.14282706e-01f, 1.29782632e-01f, 4.08396572e-02f,
  -5.70185110e-02f, 8.24788362e-02f, 2.51298577e-01f, 2.47337535e-01f, 9.03654024e-02f, 1.11346580e-01f, 2.37692580e-01f, 5.44995070e-02f, 2.10052356e-01f, 2.49921873e-01f,
  3.03104389e-02f, 7.33325304e-03f, -7.66324326e-02f, 1.93622500e-01f, 1.68435031e-03f, 8.65716860e-02f, -4.85290326e-02f, 1.47433445e-01f, 2.01602206e-02f, -4.13839966e-02f,
  4.18582708e-02f, 8.73201713e-02f, 9.27316546e-02f, -7.00970516e-02f, -7.48373643e-02f, -1.27427608e-01f, -6.33093789e-02f, -3.47650498e-02f, 4.96171042e-02f, 6.08229078e-03f,
  1.95052121e-02f, -6.58849301e-03f, -9.94309336e-02f, -2.99637020e-02f, 5.72561137e-02f, 1.36122443e-02f, -5.08658513e-02f, -3.30617931e-03f, -8.19880441e-02f, -1.01510018e-01f,
  2.79701412e-01f, -2.24393934e-01f, 5.51875532e-02f, -6.51595071e-02f, -1.26222357e-01f, -2.34094828e-01f, -1.35752067e-01f, -1.43269643e-01f, -9.93983075e-02f, 3.91559824e-02f,
  -5.40390909e-02f, -1.53303787e-01f, -1.75739408e-01f, -6.57518953e-02f, 7.75355473e-02f, -7.33995438e-02f, -1.60285592e-01f, 1.82373710e-02f, 4.25002500e-02f, 2.89621297e-02f,
  -1.48898005e-01f, 1.57891169e-01f, 2.59074420e-01f, 1.87762320e-01f, 1.88942198e-02f, 1.49821058e-01f, 1.67819306e-01f, 1.05765998e-01f, 1.38283119e-01f, 2.76702881e-01f,
  -9.61658120e-01f, 5.84912263e-02f, 3.00967425e-01f, -5.55965483e-01f, -8.91549364e-02f, 8.84535983e-02f, 6.35816529e-02f, -8.29604119e-02f, -1.27652720e-01f, 1.30502701e-01f,
  1.08456798e-01f, -6.08469471e-02f, -8.15765932e-02f, 1.16785087e-01f, -1.49548069e-01f, 1.44875094e-01f, -5.35330214e-02f, -1.88547581e-01f, -2.63902873e-01f, -7.26854429e-02f,
  -1.49786457e-01f, -4.26787496e-01f, -5.92546523e-01f, -2.27636665e-01f, -1.41850248e-01f, -2.85962939e-01f, -1.16606057e-02f, -2.74290562e-01f, -1.01508304e-01f, -1.65707678e-01f,
  3.55478972e-01f, -2.06593901e-01f, -7.26332068e-02f, -2.84943700e-01f, 1.56056962e-03f, 1.23440335e-02f, -4.28811349e-02f, 1.03646088e-02f, 5.52346446e-02f, 9.67566855e-03f,
  -1.07162200e-01f, 2.88535822e-02f, -1.49719492e-01f, 7.08050057e-02f, 8.07627887e-02f, 2.78544636e-03f, 5.73026016e-02f, -4.71860245e-02f, 7.33855460e-03f, 3.61546874e-01f,
  7.72900507e-02f, -1.76176075e-02f, 1.51327783e-02f, 1.46224603e-01f, 9.18897986e-02f, -5.30960262e-02f, 1.79184556e-01f, 6.48239553e-02f, -4.19735126e-02f, -1.01555750e-01f,
  -1.97961018e-03f, -1.32639315e-02f, 8.58494863e-02f, -1.07498191e-01f, 7.00244531e-02f, -4.56542410e-02f, -6.24288712e-03f, -5.90067655e-02f, 2.73646899e-02f, 5.05407900e-03f,
  -2.53161918e-02f, 6.03409819e-02f, 1.07745178e-01f, -1.63855076e-01f, 1.73083022e-02f, -6.41992316e-02f, -9.20303240e-02f, -2.16272455e-02f, -5.99005967e-02f, -7.39835724e-02f,
  -6.30866364e-02f, 1.62421510e-01f, -3.30128125e-03f, -3.52008939e-02f, 7.91829079e-02f, -6.98277131e-02f, 1.13471024e-01f, 6.28523752e-02f, 1.00019984e-01f, 4.14350666e-02f,
  -1.32987291e-01f, -9.37762037e-02f, -1.03775367e-01f, -1.06117181e-01f, -8.22813362e-02f, 1.53223947e-01f, -3.28933522e-02f, 3.88020836e-02f, -1.01531573e-01f, 1.90981440e-02f,
  5.90860322e-02f, 8.02716464e-02f, -2.13564262e-02f, 5.25553487e-02f, 2.64434721e-02f, -1.27113685e-01f, -8.64166126e-04f, -5.92676699e-02f, 9.88769308e-02f, 2.97221035e-01f,
  1.20182723e-01f, -1.53743401e-01f, -1.33993044e-01f, 1.69017702e-01f, 6.65873662e-02f, -2.05960125e-01f, 8.13626722e-02f, 5.96499704e-02f, 7.70897558e-03f, -1.41494527e-01f,
  5.01797080e-01f, 2.34878972e-01f, 2.95891851e-01f, 1.30188406e-01f, -2.54211128e-01f, -1.58770218e-01f, -7.32129812e-02f, -4.43871552e-03f, -1.36927262e-01f, -2.10689139e-02f,
  -6.26674369e-02f, 3.75435129e-02f, 2.94245444e-02f, 1.70935556e-01f, 2.61442930e-01f, 6.85135499e-02f, 9.25137028e-02f, 3.23205620e-01f, 2.71574557e-01f, 1.26364604e-01f,
  -1.21324755e-01f, -3.78459617e-02f, 2.09609255e-01f, 1.01398103e-01f, 2.10193042e-02f, -8.30185264e-02f, 7.20534250e-02f, 1.65144324e-01f, 9.41383466e-02f, 6.60692528e-02f,
  1.29544348e-01f, 2.72717148e-01f, -1.38801083e-01f, 2.58944277e-02f, 9.23543423e-02f, -5.25941998e-02f, -1.03036843e-01f, 9.78379324e-02f, 4.82245237e-02f, -3.23175155e-02f,
  -7.04247952e-02f, 6.34664446e-02f, -5.82528524e-02f, -6.17668144e-02f, 1.22747514e-02f, -8.39432850e-02f, 1.77302942e-01f, 1.30017251e-01f, -2.34344993e-02f, 5.51334508e-02f,
  -3.83797325e-02f, -1.22459412e-01f, -4.48426642e-02f, -5.31794801e-02f, -2.51629087e-03f, 5.74426167e-02f, -1.52623672e-02f, -1.10749537e-02f, -1.01459995e-01f, 2.39279233e-02f,
  1.65931240e-01f, 7.72365183e-02f, 4.18508500e-02f, 1.56224340e-01f, 1.23047151e-01f, -3.17126326e-02f, -5.77606820e-02f, 6.67159632e-02f, 8.10533315e-02f, 6.59103459e-03f,
  6.43676966e-02f, -9.46651492e-03f, -8.78103357e-03f, -5.61154634e-02f, -1.59937575e-01f, -1.30002260e-01f, -1.00509249e-01f, 1.08391821e-01f, 3.95121761e-02f, -7.68125877e-02f,
  1.03235744e-01f, 6.57160357e-02f, -3.20931636e-02f, 5.91421425e-02f, 1.98481660e-02f, 1.70952410e-01f, -5.68964928e-02f, -3.74199660e-03f, -5.04318140e-02f, 1.40286997e-01f,
  -5.50311446e-01f, -1.28048845e-02f, 4.14548740e-02f, -1.31644113e-02f, 5.00949807e-02f, -6.69853901e-03f, -2.78860647e-02f, -1.11951150e-01f, -8.45469609e-02f, -1.31123006e-01f,
  -1.76271379e-01f, 4.89312224e-02f, 1.79789879e-03f, -2.65508909e-02f, -1.44551620e-02f, -4.32690307e-02f, 9.85620990e-02f, -5.53940162e-02f, -5.56341596e-02f, -1.56942248e-01f,
  -1.21816054e-01f, -1.73292384e-01f, -1.35820404e-01f, -1.19672984e-01f, -1.78625911e-01f, -2.43716881e-01f, -2.01212853e-01f, -9.17243585e-02f, -1.74680471e-01f, -2.23823577e-01f,
  -9.50222486e-04f, -5.12736797e-01f, 1.20213199e-02f, -8.46744254e-02f, -1.29127041e-01f, -8.07368755e-02f, -5.42732239e-01f, -5.27854601e-04f, 8.33279267e-02f, -4.53412414e-01f,
  -2.32396603e-01f, 1.58819571e-01f, 1.65916920e-01f, 2.48700031e-03f, 7.55257383e-02f, -4.75205958e-01f, -3.13277215e-01f, 1.59870729e-01f, 4.63406384e-01f, 9.95070264e-02f,
  -2.66140699e-01f, 8.83123055e-02f, 3.41873854e-01f, 1.59863964e-01f, -2.96244591e-01f, 2.64246279e-04f, -2.46074200e-01f, -1.05934292e-01f, -3.03263187e-01f, -5.18137217e-01f,
  -1.64647803e-01f, -1.15438655e-01f, 1.32463738e-01f, -6.07296377e-02f, -3.57568599e-02f, 6.76941425e-02f, -3.04177552e-02f, 4.56223823e-02f, 1.18126661e-01f, -1.63886175e-02f,
  3.43471542e-02f, -2.04252794e-01f, 1.00239314e-01f, 1.36977518e-02f, 8.54536444e-02f, 2.20370442e-02f, 7.66637996e-02f, 2.15583771e-01f, 3.18756141e-02f, -1.03107594e-01f,
  -3.89523983e-01f, -2.36800611e-01f, 8.89536168e-04f, 9.23081860e-02f, 5.86592965e-02f, 7.73099959e-02f, -1.29975900e-01f, -9.91524607e-02f, 2.01119129e-02f, -6.19572222e-01f,
  3.25069763e-02f, 7.77463838e-02f, 1.41827628e-01f, 7.07886815e-02f, 7.49833975e-03f, 1.18608950e-02f, 1.39570450e-02f, -1.05106689e-01f, 9.76427551e-03f, -3.66986878e-02f,
  1.08125351e-01f, -1.34662345e-01f, 1.20822616e-01f, 5.32236733e-02f, -9.52565372e-02f, 3.40928063e-02f, 3.33441049e-02f, -6.73022121e-02f, 3.93023156e-02f, 3.04075591e-02f,
  -7.22873537e-03f, 2.81275492e-02f, 1.07476532e-01f, 9.05865058e-02f, -1.13077201e-01f, 6.74239025e-02f, -9.33059081e-02f, 4.70284298e-02f, 6.95255548e-02f, -3.31243165e-02f,
  1.01242460e-01f, 1.53092906e-01f, -3.10337573e-01f, 1.33393154e-01f, -5.75740933e-02f, 3.17239650e-02f, -8.97781551e-02f, 1.44499153e-01f, 9.11711305e-02f, -3.26839350e-02f,
  -1.45095453e-01f, -1.29439563e-01f, -5.29049411e-02f, 2.33630016e-02f, 1.68893468e-02f, -4.54212679e-03f, -1.97241679e-01f, -4.94322367e-02f, -1.13700144e-01f, -1.17088761e-03f,
  -7.29741156e-02f, -2.09736973e-01f, -1.03156760e-01f, -6.48444891e-02f, -8.06331933e-02f, -8.63898546e-02f, -1.59801096e-01f, -5.23726158e-02f, -1.64194882e-01f, -4.36876267e-01f,
  2.23934576e-01f, -1.81595489e-01f, -6.16299435e-02f, 3.78923267e-01f, 2.89222077e-02f, -1.99895427e-01f, -5.57483733e-01f, -3.12689483e-01f, 1.14722162e-01f, -1.05705462e-01f,
  9.06521752e-02f, 2.29199111e-01f, 1.87653318e-01f, 1.94924742e-01f, -1.06488481e-01f, -1.98151767e-01f, 1.89970717e-01f, 2.10527569e-01f, 1.54414386e-01f, 1.56422064e-01f,
  2.18425274e-01f, 2.45261714e-01f, 2.68897712e-01f, 2.07422644e-01f, 9.33755189e-02f, 1.64325073e-01f, 4.00684308e-03f, 1.41493380e-01f, -3.03319748e-02f, 2.35625014e-01f,
  1.61776662e-01f, -1.99797720e-01f, -1.62729755e-01f, 1.58070222e-01f, -1.18861355e-01f, -2.07616597e-01f, -4.23855186e-02f, -6.32371902e-02f, -2.49486327e-01f, -1.45599380e-01f,
  -7.54490029e-03f, -2.89614145e-02f, 4.06205058e-02f, 1.79891780e-01f, 6.47295415e-02f, -5.16020134e-02f, -1.24991804e-01f, -1.80300087e-01f, -2.78171718e-01f, -1.14700757e-01f,
  1.85355991e-01f, -1.61427949e-02f, -2.94194043e-01f, -3.44082266e-01f, -3.35837722e-01f, 6.23542741e-02f, -2.21180201e-01f, -2.39752591e-01f, -3.62661153e-01f, -1.98437810e-01f,
  -5.22208400e-02f, -5.44889756e-02f, -1.71240255e-01f, -1.92785293e-01f, 1.45128006e-02f, -1.15632556e-01f, 4.67312858e-02f, 1.48184925e-01f, 1.53253734e-01f, -1.66239664e-01f,
  1.28732771e-02f, 8.26449879e-03f, 1.77831650e-01f, -3.26883830e-02f, 2.13910509e-02f, -1.17533118e-01f, 9.79408156e-03f, -7.18144998e-02f, 1.05521074e-02f, -2.33696118e-01f,
  2.40050368e-02f, 1.34169534e-02f, -1.25430867e-01f, 6.56720847e-02f, -9.33528021e-02f, 1.77270342e-02f, -8.97037014e-02f, -9.71863046e-02f, -8.64699110e-02f, -9.43038389e-02f,
  1.13325259e-02f, -2.33176380e-01f, -5.95450290e-02f, 1.49841741e-01f, 3.82506400e-02f, 6.54845089e-02f, -4.61212397e-02f, 9.83189195e-02f, 7.64381513e-02f, -5.91636971e-02f,
  -1.77288190e-01f, 5.24835289e-02f, -1.05453238e-01f, -1.52365342e-02f, 7.50845484e-03f, -4.78715338e-02f, 1.54260635e-01f, -6.01632558e-02f, -1.33653939e-01f, 2.26462670e-02f,
  7.97352259e-05f, -2.36255988e-01f, -2.31808558e-01f, -3.66305143e-01f, -2.14250058e-01f, 3.72914560e-02f, -2.58905679e-01f, -2.80223072e-01f, -3.80849153e-01f, -5.31896234e-01f,
  9.09765720e-01f, -2.17394620e-01f, 3.25506985e-01f, 2.52751075e-03f, -3.24816912e-01f, -1.62330136e-01f, -3.30593467e-01f, -1.76270589e-01f, 1.22305393e-01f, 1.37674287e-02f,
  1.16584294e-01f, 1.77789792e-01f, 1.16665646e-01f, 2.93726444e-01f, 2.57850528e-01f, -1.88680544e-01f, -4.33487929e-02f, 3.11271429e-01f, 2.93814987e-01f, -1.12079084e-01f,
  -1.82278961e-01f, -1.70810118e-01f, 1.89305350e-01f, 9.91298556e-02f, -1.74093053e-01f, 1.69483796e-02f, -1.00114614e-01f, -1.08966507e-01f, -1.60760969e-01f, -9.27717909e-02f,
  2.08273619e-01f, 2.25816295e-01f, 1.36044770e-01f, 2.91513037e-02f, 2.73401178e-02f, 1.26541406e-01f, 2.11091414e-01f, -1.40683837e-02f, -1.34291217e-01f, -4.68081236e-02f,
  5.82940783e-03f, -1.23658232e-01f, -1.53180987e-01f, -1.65308304e-02f, -1.18082345e-01f, -1.70843862e-02f, -6.28557429e-02f, 1.10063136e-01f, 5.68057820e-02f, -5.46605475e-02f,
  -2.70784460e-02f, -2.44347975e-02f, -8.52482840e-02f, -7.55874664e-02f, 2.01578245e-01f, 2.09138051e-01f, 1.76228455e-03f, 1.69856533e-01f, 2.18933985e-01f, 8.94183218e-02f,
  7.53649473e-02f, 8.20509642e-02f, -1.33728189e-02f, 6.21349514e-02f, 2.23090164e-02f, -5.23317605e-02f, -1.06053300e-01f, -6.98719500e-03f, 9.63077471e-02f, 6.15012646e-03f,
  -1.69124976e-01f, 1.03134781e-01f, 2.42496729e-02f, -1.00969896e-02f, 7.05809221e-02f, -8.34195986e-02f, -1.82181888e-03f, 1.32632982e-02f, 5.41575402e-02f, -6.04705960e-02f,
  2.85293218e-02f, -1.49565354e-01f, -6.78143203e-02f, -5.62436841e-02f, -3.51477340e-02f, 1.43752456e-01f, 1.04543075e-01f, 1.84158478e-02f, -2.84291394e-02f, -1.20840870e-01f,
  -3.04212779e-01f, 2.28688911e-01f, 9.51257125e-02f, 1.60695799e-02f, -1.50318751e-02f, 1.32508529e-02f, 8.84777904e-02f, -1.94342867e-01f, -2.21275508e-01f, 4.17615399e-02f,
  5.91535978e-02f, 7.90249333e-02f, 2.69479919e-02f, -3.34483348e-02f, -6.72805384e-02f, 6.48285449e-02f, 9.99920443e-02f, 1.30231425e-01f, -7.63190305e-03f, 9.46962088e-03f,
  -8.81150067e-02f, 3.20863612e-02f, 1.77835464e-01f, -2.94852406e-02f, 6.26752377e-02f, 2.43624616e-02f, -2.23792773e-02f, -5.68029918e-02f, 4.26996686e-02f, -1.15081690e-01f,
  7.30900317e-02f, 1.36479571e-01f, 2.74249226e-01f, 1.81885004e-01f, -8.80512819e-02f, -2.72203147e-01f, -6.49164855e-01f, -3.50655645e-01f, 4.25888151e-02f, -1.06241576e-01f,
  -3.01231205e-01f, -1.81134090e-01f, 4.43154126e-02f, -1.44823030e-01f, -2.07799658e-01f, 4.16588522e-02f, 2.52270192e-01f, 3.08069766e-01f, -1.79302141e-01f, -1.92127034e-01f,
  -2.32726373e-02f, 2.62720525e-01f, 3.53140295e-01f, 6.39743060e-02f, 1.43081993e-01f, -6.77491501e-02f, 2.75334299e-01f, 3.55382621e-01f, 2.28937089e-01f, 4.11061287e-01f,
  2.18510255e-01f, 2.75035556e-02f, -2.09726989e-01f, -1.67572901e-01f, 7.28235543e-02f, -1.12444364e-01f, -1.53272361e-01f, 2.19206706e-01f, 5.87192029e-02f, 1.89541250e-01f,
  7.03742057e-02f, -5.30566350e-02f, -9.44025889e-02f, 1.65781602e-02f, -2.51157880e-01f, -2.15879187e-01f, 7.68237859e-02f, 2.13321477e-01f, 1.56798482e-01f, -2.09466442e-01f,
  -1.80932447e-01f, 9.35070738e-02f, -1.42826617e-01f, -8.77554268e-02f, -1.24631971e-01f, -5.38221486e-02f, -6.26150577e-04f, 7.38171441e-03f, 5.61055951e-02f, -2.73943879e-02f,
  2.61431728e-02f, 1.43406624e-02f, 6.29708916e-02f, 6.53978512e-02f, -2.12305158e-01f, -1.20981231e-01f, 6.81486130e-02f, -3.70958336e-02f, 5.89445122e-02f, -1.45057797e-01f,
  -1.48044601e-01f, -1.07831120e-01f, -7.45231286e-02f, -9.51816663e-02f, 2.36091502e-02f, 1.40782803e-01f, -1.25806227e-01f, 3.28165889e-02f, 3.49156037e-02f, 1.50080724e-02f,
  6.28574044e-02f, -9.26611200e-03f, 8.29098597e-02f, -1.31556429e-02f, 1.15552535e-02f, 1.42122477e-01f, 1.04296636e-02f, -1.08951464e-01f, 6.77164737e-03f, 6.72225282e-02f,
  -1.45173177e-01f, -1.18141726e-01f, -1.87811777e-01f, -9.93714784e-04f, 3.82180698e-02f, -6.33002892e-02f, -8.48962665e-02f, 1.11671545e-01f, 1.74436063e-01f, 4.15033735e-02f,
  -1.61909997e-01f, -1.91640094e-01f, -1.40081897e-01f, -7.07542375e-02f, -2.61251897e-01f, -6.81044161e-02f, -2.06754040e-02f, -1.59707263e-01f, -9.04303342e-02f, -3.17972302e-01f,
  -9.04880539e-02f, -2.37176239e-01f, -4.56713498e-01f, -2.60549605e-01f, 7.35633075e-02f, -3.50882709e-01f, -2.13739112e-01f, -3.37609589e-01f, -2.69840956e-01f, -5.58499396e-01f,
  5.81692398e-01f, -2.23720148e-01f, 4.77848828e-01f, 3.89855921e-01f, -2.15411615e-02f, 1.02445722e-01f, -2.26740256e-01f, 1.51550740e-01f, 2.51871943e-01f, 1.14418477e-01f,
  1.44073948e-01f, 3.73383135e-01f, 2.27722675e-01f, 2.08770111e-01f, 1.78250492e-01f, 4.03908044e-02f, 4.44104560e-02f, 2.73912668e-01f, 2.90034533e-01f, 2.21989363e-01f,
  3.47420340e-03f, -3.41152735e-02f, 1.33039489e-01f, 4.08840664e-02f, -4.94289659e-02f, 7.33712167e-02f, 9.51397344e-02f, 3.05809937e-02f, -5.27068675e-02f, 3.48639265e-02f,
  2.24483460e-01f, -3.59606855e-02f, 6.99324086e-02f, 4.76607159e-02f, -1.45129085e-01f, -1.08103670e-01f, 4.04626247e-04f, -3.19860093e-02f, -1.46613851e-01f, -1.40822217e-01f,
  9.09028295e-03f, -1.12637796e-01f, -5.44647649e-02f, -6.81321397e-02f, -1.63806930e-01f, -6.09118864e-02f, -3.15527506e-02f, 1.10451333e-01f, 7.77297840e-02f, 7.01122656e-02f,
  -6.12205267e-02f, 5.58627695e-02f, 7.07759485e-02f, 4.28098254e-02f, 8.69014207e-03f, 1.64227411e-01f, -4.87078540e-02f, -6.42934442e-03f, 1.54838383e-01f, 7.91438967e-02f,
  2.71166086e-01f, 1.86051473e-01f, 9.70963314e-02f, 7.61471242e-02f, 9.06665996e-02f, 4.13281284e-03f, -3.34081203e-02f, 2.22889390e-02f, 1.06512517e-01f, -7.92331100e-02f,
  8.44533965e-02f, 1.34674311e-01f, 2.65983313e-01f, 1.87986344e-02f, 3.97581980e-02f, 7.22920969e-02f, -3.12005524e-02f, 1.01738162e-02f, 5.29756621e-02f, -4.33502607e-02f,
  -9.09202397e-02f, 2.15278063e-02f, -1.31810337e-01f, 3.70130525e-03f, -9.53895077e-02f, 2.23459125e-01f, 1.07696533e-01f, -5.02792150e-02f, 7.32569322e-02f, -1.23857655e-01f,
  -1.35110170e-01f, 2.70436734e-01f, 7.88406879e-02f, -3.83454487e-02f, -7.53770620e-02f, -1.40684664e-01f, 7.53256753e-02f, -3.56831662e-02f, -3.04084778e-01f, -6.27068356e-02f,
  -7.93565586e-02f, 5.06026484e-02f, -1.27893284e-01f, -3.98527607e-02f, -6.12020940e-02f, -1.37879863e-01f, -2.31812033e-03f, 1.14520736e-01f, 8.51770267e-02f, 1.49174295e-02f,
  -1.00340368e-03f, 1.20667726e-01f, 7.24298581e-02f, 1.37838572e-01f, 5.52446917e-02f, 9.70683992e-02f, 1.45834973e-02f, -4.65883836e-02f, 1.60765767e-01f, -1.48092017e-01f,
  -4.92819339e-01f, -2.26321787e-01f, -2.05642417e-01f, 3.13927650e-01f, 4.98827934e-01f, 2.55600333e-01f, 2.73897529e-01f, 1.91132277e-01f, 2.91704953e-01f, 1.47877201e-01f,
  -6.75680339e-02f, 7.42413178e-02f, 9.46776420e-02f, 2.15439182e-02f, 9.44551304e-02f, 3.39596987e-01f, 2.55419493e-01f, -6.27635196e-02f, -7.04307156e-03f, 1.81101665e-01f,
  2.90439963e-01f, 4.72784080e-02f, -2.14885622e-01f, 4.03862707e-02f, 2.78964341e-01f, 3.22745711e-01f, 7.77684152e-02f, 2.95750294e-02f, 2.11648926e-01f, 3.07081848e-01f,
  -1.28175035e-01f, -1.07837118e-01f, 1.85821399e-01f, 5.43464310e-02f, -1.95537329e-01f, -1.59390062e-01f, 7.03969076e-02f, -1.73420593e-01f, -2.36579105e-02f, 5.13931923e-02f,
  -5.61397858e-02f, -1.75699383e-01f, 6.47937432e-02f, -1.99402105e-02f, -1.45938918e-01f, -1.97462142e-01f, -1.39885038e-01f, 1.18326936e-02f, 7.61418417e-02f, 2.86344532e-02f,
  9.11749825e-02f, -1.30283292e-02f, 8.58755782e-02f, 9.91036296e-02f, 1.31479755e-01f, 2.00025551e-02f, -4.89936136e-02f, -7.99091980e-02f, -7.56323114e-02f, -9.61003006e-02f,
  1.95330650e-01f, -1.21234111e-01f, -4.20064703e-02f, -8.68901610e-02f, -6.02741772e-03f, -1.44562982e-02f, -6.53568953e-02f, -1.33011956e-02f, 6.79720938e-02f, -5.82844540e-02f,
  5.93754463e-02f, 2.30736166e-01f, -1.79700721e-02f, 1.08114451e-01f, 8.29495788e-02f, -7.16229305e-02f, -4.30120267e-02f, -4.67304252e-02f, -2.06514433e-05f, 1.53810075e-02f,
  -2.22029425e-02f, 5.72502837e-02f, -1.52616709e-01f, -2.92455647e-02f, -4.73295152e-02f, 1.02025673e-01f, 1.45362496e-01f, 4.85106893e-02f, -1.12540297e-01f, 4.59512621e-02f,
  1.17816336e-01f, 1.83125198e-01f, 5.40742874e-02f, 1.09486908e-01f, 4.57654754e-03f, -1.86535552e-01f, 7.38932267e-02f, -6.61955923e-02f, 1.73098706e-02f, 6.12180904e-02f,
  -1.71599686e-01f, -1.80111557e-01f, -1.98572755e-01f, -8.86173844e-02f, -1.49145976e-01f, -7.98569694e-02f, -2.02497929e-01f, 2.56568100e-02f, 8.69079307e-03f, -8.82113278e-02f,
  -4.80458587e-02f, 8.91623199e-02f, 6.94074780e-02f, 3.98815572e-02f, 1.99448466e-01f, 9.76390019e-02f, -1.30356640e-01f, -4.54830974e-02f, -7.58140087e-02f, -7.13895634e-02f,
  -4.16912474e-02f, 1.97705120e-01f, -4.66463447e-01f, -1.05164826e-01f, -2.57914424e-01f, -1.48901477e-01f, 3.05243045e-01f, 1.78749576e-01f, 1.87720746e-01f, 2.22336382e-01f,
  6.62105829e-02f, -1.39792994e-01f, -4.50919569e-02f, -1.74263656e-01f, 6.37231246e-02f, 8.14870298e-02f, -7.76719600e-02f, -3.57259065e-01f, -2.22465023e-01f, -7.01383501e-02f,
  1.35130435e-01f, 6.49009570e-02f, 2.00817883e-02f, 8.35226923e-02f, -1.64710879e-02f, -7.16721639e-02f, 1.30385295e-01f, -9.26924646e-02f, -1.36637598e-01f, -8.11570585e-02f,
  -1.32620245e-01f, -3.68225515e-01f, -2.53359182e-03f, -1.81328565e-01f, -2.05836371e-01f, -7.06638470e-02f, -1.15934253e-01f, -2.62062609e-01f, -1.87890783e-01f, -1.15165282e-02f,
  -2.68879056e-01f, -2.25665763e-01f, -4.32155281e-01f, -2.29963765e-01f, -1.95705399e-01f, -9.01433378e-02f, 5.23796752e-02f, -2.96904743e-01f, -1.00962564e-01f, -7.49925226e-02f,
  -8.53454247e-02f, -2.42446855e-01f, -3.85569662e-01f, -1.23340897e-01f, -4.08886552e-01f, -2.82874465e-01f, -1.18747085e-01f, -2.13820726e-01f, -1.71942249e-01f, 1.42920479e-01f,
  5.59690855e-02f, 6.14638366e-02f, 3.11723743e-02f, 7.56061003e-02f, 1.16955087e-01f, -1.71465471e-01f, -1.41324028e-01f, -1.36636160e-02f, 1.30565286e-01f, 9.74048749e-02f,
  -7.94702247e-02f, -7.97844186e-05f, -2.17134692e-02f, -7.04267249e-02f, -9.19618607e-02f, -6.77875578e-02f, -3.00298519e-02f, 1.25852659e-01f, -4.16245218e-03f, 1.40136182e-01f,
  -8.29628855e-03f, -7.36298636e-02f, 6.06435090e-02f, 1.65147018e-02f, -8.44420493e-02f, 1.00158043e-01f, 1.05718672e-01f, 1.16327047e-01f, 1.69229105e-01f, 8.67234394e-02f,
  3.53575468e-01f, -4.61006816e-03f, 2.09905654e-01f, -3.53699224e-03f, -9.58023071e-02f, 6.22771718e-02f, 2.93194912e-02f, 3.62847149e-02f, -2.05226764e-01f, 1.40950248e-01f,
  3.12933279e-03f, -1.79167047e-01f, -2.20083624e-01f, -1.93827543e-02f, -4.85370494e-03f, 1.25324249e-01f, 1.80698916e-01f, -3.21424991e-01f, 1.06060706e-01f, 9.96415243e-02f,
  1.94982722e-01f, 3.99120808e-01f, 1.73876658e-01f, 6.98532090e-02f, 2.67565884e-02f, -3.08824740e-02f, 1.84453249e-01f, 1.02589481e-01f, 1.52183533e-01f, 6.66400552e-01f,
  -3.97535622e-01f, 6.92044795e-01f, 6.10392578e-02f, -3.87849778e-01f, 1.92285269e-01f, 3.15235406e-01f, 5.24635017e-01f, 2.59932816e-01f, -7.25092739e-02f, 3.44706148e-01f,
  2.11140484e-01f, -1.46736920e-01f, -9.43617746e-02f, -4.64097932e-02f, -1.25394046e-01f, 1.43137991e-01f, 4.63081114e-02f, -2.92936176e-01f, -3.39522421e-01f, -3.25350128e-02f,
  1.61372468e-01f, -1.28427386e-01f, -2.01158538e-01f, -8.20482895e-03f, -3.06459572e-02f, -1.92686275e-01f, -6.36594072e-02f, -1.02916516e-01f, -2.36169565e-02f, -2.14815870e-01f,
  -3.37473184e-01f, -8.81901905e-02f, -1.54548556e-01f, -1.36812076e-01f, -1.34608090e-01f, -1.06915534e-01f, 2.47167647e-02f, -7.79069588e-02f, 9.30834711e-02f, 7.03243390e-02f,
  2.82531213e-02f, 1.48361564e-01f, -3.47838388e-03f, -3.86707969e-02f, -5.69258183e-02f, -1.65005311e-01f, 4.14755195e-02f, -1.06161669e-01f, 3.11378725e-02f, 9.22891721e-02f,
  3.80119294e-01f, 1.09890051e-01f, -1.18527547e-01f, 1.98655635e-01f, 1.22741118e-01f, -3.81206386e-02f, 5.65387420e-02f, -9.26351324e-02f, -2.13963222e-02f, -1.33183450e-01f,
  1.17021106e-01f, 1.20580979e-01f, 1.08561985e-01f, -7.96399824e-03f, 7.61789382e-02f, 4.65387441e-02f, -2.46464554e-02f, -1.12267677e-02f, -4.30241833e-03f, 1.14891874e-02f,
  -3.39907221e-02f, 1.39533743e-01f, 2.50768336e-03f, -2.83251014e-02f, -9.73871052e-02f, -7.88460746e-02f, -1.22745968e-01f, -1.81607932e-01f, -8.98834988e-02f, 2.79478589e-03f,
  -1.22959481e-03f, 8.37343335e-02f, -2.10507121e-02f, -1.24327585e-01f, -2.12774053e-01f, -1.71737567e-01f, 5.01844361e-02f, -1.43359676e-01f, -3.66036110e-02f, -7.14071691e-02f,
  -3.31453055e-01f, 2.09627226e-01f, -3.09267074e-01f, -1.13987951e-02f, -9.63554904e-02f, -1.22170381e-01f, 2.73675043e-02f, -1.49060085e-01f, 9.14093480e-03f, -1.54504433e-01f,
  9.74658877e-02f, 4.91010733e-02f, 8.08315501e-02f, 7.76916295e-02f, -9.16925296e-02f, -1.67256132e-01f, -1.94513723e-02f, -1.20983817e-01f, 1.07428871e-01f, 8.34739953e-02f,
  -1.20693669e-02f, -9.99697745e-02f, -1.72629431e-01f, 1.00932658e-01f, -4.20573279e-02f, -2.64703840e-01f, -2.05553353e-01f, -1.95548788e-01f, -1.21029884e-01f, -1.81443825e-01f,
  -3.42440754e-01f, -6.20470531e-02f, 1.36442240e-02f, -6.60543889e-02f, 2.55091459e-01f, -7.29138032e-02f, -4.82512832e-01f, -3.84899169e-01f, 2.75835469e-02f, -1.68614879e-01f,
  7.35940561e-02f, 9.18450579e-02f, 6.49302602e-02f, -1.81558028e-01f, -7.96222150e-01f, -4.44880664e-01f, -3.97380859e-01f, -4.35418665e-01f, -3.54234785e-01f, -1.38897911e-01f,
  -4.97023202e-02f, -1.00259893e-01f, -2.08915845e-01f, -1.85383596e-02f, 3.40254307e-01f, 1.85101986e-01f, 2.88553476e-01f, 1.56627193e-01f, 2.40098804e-01f, 1.57326475e-01f,
  -5.01043461e-02f, 2.43801288e-02f, 2.16758475e-02f, -5.43810800e-03f, 1.82038233e-01f, 1.43877966e-02f, -3.21919806e-02f, -4.24935929e-02f, 1.18343763e-01f, -5.70441261e-02f,
  1.19696036e-01f, 1.01114251e-01f, 1.26556456e-01f, 5.98740950e-02f, 5.05893379e-02f, -1.75532728e-01f, -1.24300770e-01f, -2.47370109e-01f, -3.90595973e-01f, -2.00133666e-01f,
  -1.11369468e-01f, 3.36514227e-02f, -1.36568457e-01f, -8.53940099e-03f, -9.81035456e-02f, 2.11590957e-02f, 1.79442748e-01f, 9.77005884e-02f, 2.12010788e-03f, -2.51631299e-03f,
  1.12605132e-02f, 9.37710330e-02f, 7.37408325e-02f, -3.24405171e-02f, -9.29599926e-02f, 1.90042034e-01f, 3.50866467e-02f, -1.70604158e-02f, -2.58024801e-02f, 5.92585802e-02f,
  -2.86194924e-02f, 5.96008785e-02f, 1.30538773e-02f, 2.68116314e-02f, -5.56552932e-02f, 1.35466009e-02f, 8.79741162e-02f, -1.00349121e-01f, -9.99851823e-02f, -1.16291959e-02f,
  -1.18336603e-01f, 5.06881960e-02f, 3.84043157e-02f, -8.90953168e-02f, -1.05930999e-01f, -1.47833273e-01f, 4.11308669e-02f, 3.72571498e-02f, 3.63412462e-02f, 1.70243122e-02f,
  -1.24773584e-01f, -2.26781610e-02f, -3.24444473e-02f, -6.93826936e-03f, -1.42085664e-02f, 1.55059323e-01f, 7.40719959e-02f, -4.63900343e-02f, 1.59637794e-01f, -1.02215521e-01f,
  -2.54701246e-02f, -1.62887946e-01f, 8.20571370e-03f, 5.83494455e-02f, -1.13549106e-01f, 1.70863897e-03f, -1.77722916e-01f, 1.07632894e-02f, -7.42976069e-02f, 2.00950559e-02f,
  -2.40278631e-01f, -2.60832995e-01f, -4.10297215e-01f, -4.80129868e-02f, -4.25594188e-02f, -1.39190346e-01f, -3.30492668e-03f, 3.60589176e-02f, -2.51070470e-01f, -3.31584960e-01f,
  1.62114009e-01f, -3.40184793e-02f, 2.34620556e-01f, 2.73680747e-01f, 1.69098273e-01f, 2.03919008e-01f, 7.31922686e-02f, 2.19400808e-01f, 1.95712537e-01f, 1.48947313e-01f,
  7.96973482e-02f, 1.77121386e-01f, 1.34176895e-01f, 1.54409736e-01f, 6.07757270e-02f, 1.50451690e-01f, 1.93730891e-01f, 2.30283394e-01f, 1.12912633e-01f, 1.16064020e-01f,
  1.58002481e-01f, 1.30973488e-01f, 1.08086273e-01f, 1.60040557e-01f, 6.26614615e-02f, 1.00034311e-01f, 1.75370157e-01f, 9.75505710e-02f, 5.30706085e-02f, -1.38881832e-01f,
  -3.74548465e-01f, 9.09676403e-03f, 1.88316014e-02f, 1.86342821e-02f, -4.38473374e-02f, -1.23142630e-01f, 2.82855574e-02f, 2.97969673e-02f, 6.15185350e-02f, -7.61070335e-03f,
  -1.79136753e-01f, 2.57101320e-02f, -3.71349137e-03f, 1.81019679e-02f, -8.73749238e-03f, -6.49912283e-02f, -1.86669324e-02f, 7.34076872e-02f, 7.34138340e-02f, -7.16980919e-02f,
  -4.72365990e-02f, -1.49615139e-01f, -1.88166797e-01f, 6.65101828e-03f, 9.14504677e-02f, 3.27661596e-02f, -3.40856202e-02f, -3.01019121e-02f, 1.02316216e-01f, -1.68023482e-01f,
  -9.05133039e-02f, 4.82586883e-02f, 2.25948766e-01f, 7.84295574e-02f, 2.97508150e-01f, 8.50644782e-02f, 7.58887306e-02f, -6.18240982e-02f, 1.98616192e-01f, 1.02831297e-01f,
  5.24980854e-03f, 9.15987603e-03f, -1.51990891e-01f, -6.10044412e-02f, 9.51933488e-02f, 7.19636679e-02f, -1.50250599e-01f, -1.25100508e-01f, 1.06834769e-01f, -2.89713908e-02f,
  -3.34570110e-02f, -1.36955827e-01f, -1.95506196e-02f, -1.07920110e-01f, -4.25991118e-02f, 9.76779759e-02f, -4.55215834e-02f, 4.58026901e-02f, 7.35360309e-02f, 1.48061253e-02f,
  -3.15050960e-01f, 4.44249779e-01f, 4.18915646e-03f, -1.84021294e-02f, -1.04336403e-01f, -8.44209716e-02f, 3.14171016e-02f, -5.42874411e-02f, -1.54995039e-01f, -1.67642191e-01f,
  -1.10481903e-01f, -7.51211792e-02f, 2.53061932e-02f, 4.79593910e-02f, -9.02353823e-02f, -1.90772757e-01f, -3.77314314e-02f, -2.11758927e-01f, -7.04929754e-02f, -2.59140730e-01f,
  1.16290757e-02f, -2.03929156e-01f, -4.41312999e-01f, -1.40717924e-01f, -1.30894691e-01f, -1.02875568e-01f, -8.12660083e-02f, -1.01953484e-01f, -1.26464888e-01f, -7.99831375e-02f,
  5.23437083e-01f, -1.01850908e-02f, -1.63964495e-01f, 2.25485772e-01f, 5.54786883e-02f, -1.80804938e-01f, -4.01180685e-01f, -3.60851526e-01f, 6.06955662e-02f, 9.81386155e-02f,
  2.08232000e-01f, 3.26695561e-01f, 1.09314069e-01f, 1.97603673e-01f, -9.57006589e-02f, -8.40152353e-02f, 9.16002542e-02f, 1.27029056e-02f, 1.49872545e-02f, 1.05085522e-01f,
  2.48131499e-01f, 3.02714016e-02f, 1.17247574e-01f, -7.45263174e-02f, 1.82778388e-01f, 9.58841741e-02f, 3.38810869e-02f, 1.36147916e-01f, 1.67556964e-02f, 4.03895855e-01f,
  2.65913427e-01f, 1.04686460e-02f, -6.04905151e-02f, 1.84149429e-01f, 6.16246797e-02f, 7.82498121e-02f, 1.46517962e-01f, -1.11279748e-01f, -3.57179679e-02f, -2.28931028e-02f,
  1.21358745e-01f, 2.07503632e-01f, -2.99439803e-02f, -9.98853967e-02f, 5.38036637e-02f, 7.35562444e-02f, -7.66530447e-03f, -1.07044697e-01f, -4.78790812e-02f, 1.36796296e-01f,
  2.04401478e-01f, 1.08432204e-01f, -3.56427766e-02f, -3.41613382e-01f, 7.20487349e-03f, 1.22017540e-01f, 1.46465946e-03f, 2.16433890e-02f, -1.62464827e-01f, 1.14916429e-01f,
  1.44000813e-01f, 1.86589092e-01f, 3.96821760e-02f, 1.42084062e-01f, 1.53827429e-01f, 9.81748551e-02f, 1.23990290e-01f, 9.52429920e-02f, 5.57277165e-02f, 9.06383619e-02f,
  -5.19602327e-03f, -5.45113981e-02f, -1.74076315e-02f, 2.31947899e-02f, 5.31466901e-02f, 1.11356191e-01f, 5.90428077e-02f, 4.91396524e-02f, 3.59999351e-02f, 1.85247920e-02f,
  -3.62410843e-02f, 5.20497188e-02f, 3.57348733e-02f, -2.85142474e-02f, -9.00042523e-03f, 9.72550884e-02f, 1.46836966e-01f, 7.65948668e-02f, 1.15410469e-01f, 1.21343434e-01f,
  -3.78109336e-01f, -4.18421984e-01f, 1.61884487e-01f, -8.98750424e-02f, -2.09655222e-02f, -3.56374159e-02f, 3.86166833e-02f, -5.11089824e-02f, 5.80984391e-02f, -8.62162486e-02f,
  -1.67377032e-02f, 3.65417800e-03f, -9.56333354e-02f, -1.44146711e-01f, -6.11774065e-02f, 7.53797144e-02f, 1.55357078e-01f, -4.11513756e-05f, -1.71658427e-01f, 1.30677611e-01f,
  -1.76866222e-02f, -1.59039021e-01f, -1.22427650e-01f, -2.99060971e-01f, -5.98743223e-02f, 5.06247813e-03f, -1.92496806e-01f, -5.62147498e-02f, -2.75779605e-01f, -1.66847199e-01f,
  2.13514999e-01f, 3.71062160e-01f, 9.88881290e-02f, -5.88117018e-02f, -1.25102460e-01f, -1.96658000e-01f, -4.92381118e-02f, -7.93989748e-02f, -1.01569623e-01f, 5.48029914e-02f,
  1.24503821e-01f, 7.24940747e-02f, 6.63959160e-02f, -5.31746540e-03f, 4.89301533e-02f, -9.98494588e-03f, 1.54221356e-02f, -8.52751210e-02f, -5.89817837e-02f, -7.84599707e-02f,
  5.25491163e-02f, 2.49276012e-02f, 5.36017828e-02f, 2.38283630e-02f, 1.73374832e-01f, 1.14932805e-01f, 6.41496703e-02f, 9.80694145e-02f, 2.76438445e-01f, 4.47712719e-01f,
  3.19835007e-01f, 3.16855371e-01f, -1.39587790e-01f, 1.05551146e-02f, 1.07689999e-01f, 1.11339882e-01f, -8.62041786e-02f, 5.20852245e-02f, 1.55841159e-02f, -7.39748105e-02f,
  1.21218646e-02f, 1.27183869e-01f, -1.10660985e-01f, -6.56737089e-02f, 6.38961121e-02f, -2.51434911e-02f, 7.78203830e-02f, 8.46742913e-02f, -8.73205587e-02f, 1.71238855e-01f,
  -6.43396378e-02f, -5.18232696e-02f, -5.42149805e-02f, -2.17959478e-01f, -7.78701752e-02f, -1.03267580e-01f, 4.24092524e-02f, 1.49962038e-01f, 9.60435644e-02f, 1.89571038e-01f,
  -8.21108446e-02f, 5.73333912e-02f, -3.97461131e-02f, 4.40965127e-03f, -3.88579667e-02f, -2.87224084e-01f, -1.03956476e-01f, -1.29910812e-01f, -1.20630324e-01f, 2.87246276e-02f,
  -1.81307085e-02f, 1.26011267e-01f, -3.60798538e-02f, 5.56596667e-02f, -2.51685511e-02f, 5.41693829e-02f, 3.67404036e-02f, 7.71541446e-02f, -6.86731562e-02f, 9.21953991e-02f,
  -7.59186829e-03f, 7.24849179e-02f, 1.69209704e-01f, -5.75691182e-03f, 5.57664484e-02f, 3.70297618e-02f, 3.55716497e-02f, 6.28810450e-02f, 5.69044165e-02f, 9.85439643e-02f,
  4.92803520e-03f, -2.94575691e-01f, 1.00773042e-02f, 9.99750569e-02f, 1.49130240e-01f, 1.89676031e-01f, 1.72320336e-01f, 1.89013004e-01f, 4.31115627e-02f, 7.79832974e-02f,
  1.11290768e-01f, 4.85329516e-02f, -5.27787814e-03f, -1.61274383e-03f, -2.06124023e-01f, 3.56654078e-02f, 2.02997178e-01f, 1.29014477e-01f, -1.34520438e-02f, 1.36273459e-01f,
  -5.19630015e-02f, -1.01792537e-01f, -1.78154647e-01f, -2.28288069e-01f, -1.29840210e-01f, -1.42521098e-01f, -7.93492272e-02f, 9.55910310e-02f, 2.20590476e-02f, -3.62202488e-02f,
  -5.93339384e-01f, 1.34218737e-01f, 4.54837875e-03f, -9.26492736e-02f, 3.49368781e-01f, 3.99317801e-01f, 6.26774371e-01f, 1.31915629e-01f, -1.45266488e-01f, 1.18687682e-01f,
  -2.66555604e-02f, -1.71397164e-01f, -2.09739119e-01f, 2.62970366e-02f, 8.52127224e-02f, 3.58775169e-01f, 3.67075890e-01f, -2.30752397e-02f, -3.56974043e-02f, 1.26657650e-01f,
  1.48786098e-01f, -1.13605648e-01f, -4.54509407e-01f, -8.35348591e-02f, -1.93622131e-02f, -3.71471271e-02f, -3.41927931e-02f, -1.06607944e-01f, 5.37913628e-02f, 8.05708542e-02f,
  -3.54687542e-01f, -2.24845156e-01f, 1.48154944e-01f, -2.26156816e-01f, -1.81580707e-01f, -1.49516538e-01f, -2.34645829e-02f, -1.03343785e-01f, -1.56091340e-03f, 6.54836819e-02f,
  -2.13244893e-02f, -9.34847072e-03f, -3.81444395e-02f, -4.92787100e-02f, -7.82297179e-02f, -6.07543625e-03f, -5.91950044e-02f, -1.91715240e-01f, -1.74222961e-01f, -2.08669886e-01f,
  2.27877587e-01f, 9.85253304e-02f, -1.52128682e-01f, 1.38961509e-01f, -3.47507522e-02f, -1.43515587e-01f, 6.83456892e-03f, -8.72663632e-02f, -1.54999688e-01f, -2.45646521e-01f,
  4.33559380e-02f, 2.55474485e-02f, 7.98629522e-02f, 3.95311899e-02f, -1.83831733e-02f, 6.31607100e-02f, -1.39177649e-03f, 1.77896410e-01f, 1.80551806e-03f, -6.26490824e-03f,
  -3.79273482e-02f, 1.37811020e-01f, -9.68899876e-02f, -8.11277516e-03f, -1.35520902e-02f, 5.90425767e-02f, 1.49223432e-01f, 1.15101688e-01f, -1.28425449e-01f, -3.56139503e-02f,
  -1.50990903e-01f, -5.04634082e-02f, -9.25336182e-02f, 2.25322582e-02f, 4.59672697e-02f, -3.23817320e-02f, -6.34957179e-02f, -1.30842119e-01f, -1.70366004e-01f, 1.67818498e-02f,
  -4.17589843e-01f, 1.34887099e-01f, -1.96340263e-01f, -1.34670049e-01f, -1.00895435e-01f, -7.47559592e-02f, 1.90687366e-02f, -4.56413217e-02f, -5.82129396e-02f, -1.95274446e-02f,
  1.14526413e-01f, 6.71417937e-02f, -5.16269542e-02f, 5.57766221e-02f, 1.60229355e-02f, -9.37605277e-03f, 2.39000186e-01f, 1.28081486e-01f, 1.35067478e-01f, -1.64779752e-01f,
  -3.80654372e-02f, 1.62847444e-01f, -1.13727614e-01f, 9.67256054e-02f, -1.01206452e-01f, -6.88828006e-02f, 2.38741953e-02f, 2.78559495e-02f, 5.20596132e-02f, -4.92528416e-02f,
  -8.89180694e-03f, -8.04273635e-02f, -4.96247500e-01f, -4.16126996e-01f, -3.10565650e-01f, 3.77132487e-03f, 2.18887672e-01f, 3.97755653e-02f, -5.68323880e-02f, -9.89193469e-02f,
  -1.53375072e-02f, 4.59496379e-02f, -2.34202649e-02f, -3.03715598e-02f, 1.42151773e-01f, 3.43577452e-02f, -2.65553623e-01f, 1.14274630e-03f, 2.10574448e-01f, 1.32090777e-01f,
  1.92390084e-01f, 1.24588490e-01f, -1.64271761e-02f, -3.66283604e-03f, -4.67342511e-02f, -4.10448238e-02f, -1.65526778e-01f, -1.89283341e-01f, -7.36239925e-02f, -1.95788667e-01f,
  -3.54171395e-02f, -4.05345529e-01f, -1.82143688e-01f, -7.69251511e-02f, -2.22479366e-02f, 8.43872800e-02f, 1.13434546e-01f, -1.16514578e-01f, 1.03461593e-01f, -8.15796033e-02f,
  -1.90344959e-01f, -8.42326134e-02f, -9.07303691e-02f, -8.19411203e-02f, 1.38831371e-02f, -3.86806726e-02f, -1.87906533e-01f, -2.89559066e-02f, 1.81255694e-02f, -1.16155602e-01f,
  -6.69896603e-02f, -9.47407186e-02f, 4.23467606e-02f, 2.76441444e-02f, -1.06941134e-01f, -1.12494409e-01f, -6.93501253e-03f, -2.31652737e-01f, -3.33413370e-02f, 1.93937065e-03f,
  -9.29857641e-02f, 8.46669544e-03f, 1.87737029e-02f, 4.39316221e-02f, 2.19643936e-02f, 8.68113339e-03f, -5.52914180e-02f, 8.02049860e-02f, 1.27690569e-01f, 1.75628453e-01f,
  7.42038116e-02f, -2.97186542e-02f, 1.80271819e-01f, 6.85642809e-02f, 3.59393028e-03f, 9.91407409e-03f, -9.19179618e-03f, 3.58439088e-02f, 5.74598135e-03f, 1.31182373e-01f,
  9.54621360e-02f, 1.20054625e-01f, -2.06428231e-03f, 2.23753080e-01f, 4.32823598e-02f, 6.11085221e-02f, -7.48636127e-02f, 1.10242762e-01f, -2.45179571e-02f, 1.47565613e-02f,
  4.15177226e-01f, -1.30078942e-01f, -4.52019908e-02f, 1.16134584e-01f, 5.68103381e-02f, 9.69185773e-03f, -5.87615483e-02f, 2.23599598e-01f, 1.12187944e-01f, 7.08431005e-02f,
  9.69641879e-02f, 1.31511256e-01f, 8.29859003e-02f, 5.60747720e-02f, 1.78324580e-01f, 7.99004808e-02f, -2.26210151e-02f, -6.96098199e-03f, 9.73868221e-02f, -1.51151875e-02f,
  -6.65568921e-04f, 1.86161250e-01f, 4.12873983e-01f, 1.88926995e-01f, 1.32245943e-01f, 1.96453705e-01f, 4.89007868e-02f, 7.81870484e-02f, 2.35963717e-01f, 4.39010620e-01f,
  -1.58935875e-01f, 3.98069024e-01f, 3.35493147e-01f, -6.86345547e-02f, 2.88430989e-01f, 1.99819639e-01f, 5.65427780e-01f, 3.24100889e-02f, -3.57702345e-01f, 3.46806705e-01f,
  1.60232246e-01f, -2.96951443e-01f, -2.96860904e-01f, -2.01050624e-01f, 1.18458401e-02f, 4.00774121e-01f, 1.89931974e-01f, -2.49013975e-01f, -3.91520858e-01f, -2.53657848e-01f,
  -6.62180036e-02f, -2.28985503e-01f, -2.59138227e-01f, -1.96634024e-01f, -1.40861347e-02f, -2.56793648e-01f, 2.08078071e-01f, 1.42764330e-01f, 2.34767096e-03f, 5.28675329e-04f,
  -2.57172203e-03f, 2.94019938e-01f, -1.56595021e-01f, 6.43410394e-03f, 1.19980820e-01f, -1.60732076e-01f, -6.68868944e-02f, -1.34627134e-01f, -3.36819887e-02f, -1.28168717e-01f,
  2.85784099e-02f, -1.01016819e-01f, -6.22539893e-02f, -5.86891770e-02f, -3.27280723e-02f, -8.48153085e-02f, 2.53758375e-02f, -2.27184966e-01f, -4.85181957e-02f, -1.80013776e-02f,
  -4.52100821e-02f, 1.30065352e-01f, 1.94136024e-01f, 1.78609625e-01f, -2.37967316e-02f, -2.35866815e-01f, 1.03623979e-01f, -7.30289444e-02f, 1.25811277e-02f, 1.23133555e-01f,
  3.70364971e-02f, -1.56368781e-02f, -3.73978838e-02f, 4.85792989e-03f, 3.02922707e-02f, 1.45894280e-02f, -8.66079852e-02f, -6.70435205e-02f, 3.60499136e-02f, 8.11694190e-02f,
  2.56909942e-03f, 6.79479539e-02f, 4.31618132e-02f, -1.91852301e-02f, 2.86987014e-02f, -7.96695333e-03f, 8.22928101e-02f, 6.00177385e-02f, 5.03925234e-02f, 8.34744982e-03f,
  -6.31498247e-02f, 9.96627137e-02f, 8.82515535e-02f, -6.94916248e-02f, 1.01160251e-01f, -4.87605631e-02f, 4.82193604e-02f, -1.00995854e-01f, 6.24817722e-02f, 9.50373784e-02f,
  -1.47145599e-01f, 3.77288789e-01f, -4.09386829e-02f, 3.78316902e-02f, 1.54263526e-01f, -4.91566360e-02f, -2.59785447e-02f, -6.41280264e-02f, 2.86822524e-02f, -4.55281585e-02f,
  5.54825291e-02f, 9.99767184e-02f, 1.05629317e-01f, -1.86335310e-01f, -7.71706030e-02f, -1.39950871e-01f, 2.34719887e-01f, -1.09493718e-01f, -9.77567807e-02f, 3.36191207e-02f,
  7.92353153e-02f, 4.39929124e-03f, -1.14856765e-01f, 7.81279057e-02f, -1.25765085e-01f, -2.51968056e-01f, 1.50998324e-01f, -1.42886594e-01f, -4.64334823e-02f, 5.16931228e-02f,
  2.85104185e-01f, -4.97998416e-01f, -3.42009634e-01f, 9.93833393e-02f, -1.90882802e-01f, -1.55756921e-01f, -4.25735146e-01f, -1.88405607e-02f, 1.19569935e-01f, -3.71351272e-01f,
  -2.02473179e-01f, 2.84578770e-01f, 2.23913550e-01f, 1.15781717e-01f, -2.48731915e-02f, -3.53304356e-01f, -4.39675897e-01f, -9.98109877e-02f, 3.58577728e-01f, 3.76439728e-02f,
  -1.96416438e-01f, -4.62302491e-02f, 1.33446872e-01f, -9.14253369e-02f, -2.66374975e-01f, -1.11458683e-02f, -4.62357312e-01f, -2.14034840e-01f, -2.40259513e-01f, -5.00475645e-01f,
  4.17866409e-01f, -6.80738389e-02f, -9.84324049e-03f, -2.18999069e-02f, -2.78094053e-01f, 6.94288965e-03f, 3.77901569e-02f, -1.74780697e-01f, 6.09445497e-02f, -3.82415913e-02f,
  -5.22115529e-02f, -7.32209608e-02f, 2.55375385e-01f, 1.38334125e-01f, 4.89917882e-02f, 1.44148208e-02f, -2.35960394e-01f, -7.23575130e-02f, -2.72864729e-01f, -1.67957783e-01f,
  -1.26689389e-01f, -1.29658595e-01f, 1.61517307e-01f, 4.59084585e-02f, 4.85073365e-02f, -6.73163123e-03f, -1.81552857e-01f, -9.28940251e-02f, -1.76310644e-01f, -2.13125780e-01f,
  -2.39226688e-02f, 1.81114487e-02f, 3.32989059e-02f, -4.80559207e-02f, 2.24480294e-02f, 4.94933538e-02f, 7.47051686e-02f, -7.89805949e-02f, -1.29196541e-02f, -5.29821664e-02f,
  3.40011343e-02f, -1.01788707e-01f, -4.42524068e-02f, 5.79365343e-02f, -1.61821842e-01f, -1.33891597e-01f, -4.01353613e-02f, 7.85429310e-03f, -5.96455745e-02f, -1.45504951e-01f,
  2.77589653e-02f, -5.03637046e-02f, -1.51302829e-01f, -7.62067288e-02f, -1.93057731e-01f, -1.79096118e-01f, -9.91846398e-02f, -6.62646964e-02f, 1.71977967e-01f, -8.06980059e-02f,
  4.17580158e-01f, -1.05135433e-01f, 7.36027658e-02f, -2.37814542e-02f, -1.10269420e-01f, -2.25120112e-01f, -7.75856674e-02f, -4.02192436e-02f, -2.83161160e-02f, 7.68144205e-02f,
  2.13188119e-02f, 3.57169099e-02f, 2.92035770e-02f, 4.40169349e-02f, 2.51302384e-02f, 5.55203073e-02f, -2.26665586e-01f, 3.29168811e-02f, -2.28374541e-01f, -8.46106037e-02f,
  -2.55115747e-01f, -3.74250486e-02f, 3.89611781e-01f, 1.81485876e-01f, 1.63961023e-01f, 2.45450765e-01f, 2.33985052e-01f, 1.10257737e-01f, 1.58448353e-01f, 1.29225299e-01f,
  -8.36569965e-01f, 2.61250082e-02f, 2.73298681e-01f, -4.62685287e-01f, -1.03682339e-01f, -1.16100572e-01f, 2.80825466e-01f, -1.24583736e-01f, -3.50703061e-01f, 1.50329426e-01f,
  4.88119386e-02f, -9.19063762e-02f, -2.44630426e-02f, 4.50404594e-03f, 1.20011810e-02f, 3.05544138e-01f, 1.23589166e-01f, -1.11749545e-01f, -1.09095894e-01f, -1.91361800e-01f,
  -1.22094832e-01f, -1.70650676e-01f, -4.38786924e-01f, -1.62252247e-01f, 1.35709956e-01f, 6.53101131e-02f, 2.48962730e-01f, -1.72716200e-01f, 3.80826294e-02f, 8.80131871e-02f,
  4.51999336e-01f, -3.16215187e-01f, 3.61749083e-02f, -2.55552381e-01f, 1.38506025e-01f, -1.00925770e-02f, 9.49983671e-02f, 1.87499389e-01f, -2.10646927e-01f, -1.47901863e-01f,
  -1.60956129e-01f, -1.98804066e-02f, -1.18679389e-01f, -6.71435287e-03f, -1.08039156e-01f, -3.63984108e-02f, -5.90824708e-03f, -9.53078642e-02f, 4.73008007e-02f, 1.22301474e-01f,
  5.92867211e-02f, -1.31808445e-01f, -1.47577301e-01f, 7.83221573e-02f, -4.08184119e-02f, -1.77961782e-01f, 1.71585560e-01f, -1.23532102e-01f, -9.51589718e-02f, 1.18376881e-01f,
  2.89915204e-02f, 3.61339264e-02f, 6.69929013e-02f, 3.10399793e-02f, -1.32049635e-01f, -1.49751613e-02f, 4.54533659e-02f, 1.23680852e-01f, 1.92820914e-02f, -3.12714204e-02f,
  1.01514034e-01f, 1.23092681e-01f, 8.76588151e-02f, -2.10407749e-02f, 1.50282457e-01f, -3.69664431e-02f, 2.91268621e-02f, 1.41749591e-01f, -2.21340749e-02f, -4.92236689e-02f,
  -1.73422638e-02f, -7.72162899e-02f, -3.54747251e-02f, -2.76373303e-03f, 1.58668738e-02f, 6.79963976e-02f, 3.29062678e-02f, -2.34288126e-02f, -2.61513907e-02f, -1.19507834e-01f,
  1.85824960e-01f, -3.74452733e-02f, 5.00652902e-02f, -1.32111818e-01f, -7.03048334e-02f, -1.47721507e-02f, 5.14132231e-02f, 2.70548686e-02f, -1.18108034e-01f, -5.76483980e-02f,
  -1.95892468e-01f, -1.30837364e-03f, 1.37554571e-01f, 1.18737303e-01f, -6.07621297e-02f, -3.98045927e-02f, -4.55524735e-02f, 6.37620017e-02f, -6.07269481e-02f, -9.67793688e-02f,
  -5.86915053e-02f, -3.61305028e-02f, 1.35118952e-02f, 6.22591861e-02f, -2.64167935e-02f, -8.48600864e-02f, 2.41525635e-01f, 7.33878836e-02f, 1.39619797e-01f, 2.27928981e-01f,
  4.45125699e-01f, 1.93802491e-02f, 4.50222731e-01f, 4.29041423e-02f, 1.32039219e-01f, 2.58487940e-01f, 2.36941278e-01f, 3.18852812e-02f, -8.23881403e-02f, 3.48750986e-02f,
  -1.66935667e-01f, -4.11454350e-01f, -1.74121439e-01f, -1.61929369e-01f, 2.22113803e-02f, 2.79875044e-02f, 4.68080454e-02f, 1.43575445e-01f, 2.41738096e-01f, 1.27545744e-01f,
  -1.79267064e-01f, 3.28166664e-01f, 4.41730469e-01f, 7.38814026e-02f, -1.79779410e-01f, -2.56576389e-01f, 1.15147665e-01f, 2.31480464e-01f, -5.52343018e-02f, -3.01524729e-01f,
  9.51466188e-02f, 3.10099006e-01f, -6.40406609e-02f, -1.78712934e-01f, 1.82941124e-01f, 5.79906814e-03f, 8.64430517e-02f, 1.54639836e-02f, -1.89213874e-03f, -9.80223492e-02f,
  4.37231921e-02f, 7.42427185e-02f, 4.73114699e-02f, 1.23793177e-01f, 2.31234357e-01f, 7.39217773e-02f, 1.63518742e-01f, 4.76302989e-02f, 6.91986829e-02f, -7.73554593e-02f,
  -8.12224597e-02f, 1.00398958e-01f, 1.17074601e-01f, 8.52869824e-02f, 7.80695155e-02f, 1.59851823e-03f, 8.92492235e-02f, -3.55267860e-02f, 1.12165734e-01f, -7.63789862e-02f,
  3.18550714e-03f, 5.82706854e-02f, 1.17452823e-01f, -9.94576961e-02f, 4.63620052e-02f, 4.28830273e-02f, -4.36388738e-02f, -4.84867766e-02f, 8.48449394e-02f, 2.26021349e-01f,
  1.56994760e-02f, 1.08833738e-01f, 1.09096184e-01f, 8.96870270e-02f, 1.55407846e-01f, 9.85425785e-02f, 6.57535046e-02f, 6.11599162e-02f, 1.27272025e-01f, -1.13019906e-02f,
  5.28290346e-02f, 4.37012352e-02f, 1.62264869e-01f, 1.14913568e-01f, 3.44526507e-02f, 9.73505825e-02f, 1.50768027e-01f, 1.02951750e-01f, 1.37700304e-01f, 1.16135441e-01f,
  -8.43695998e-02f, 2.87881136e-01f, -2.68825620e-01f, -1.81764945e-01f, 8.78533162e-03f, 3.02347634e-02f, -4.41695899e-02f, -1.73394069e-01f, -1.30799562e-01f, -6.57985955e-02f,
  -4.69651669e-02f, 2.43834797e-02f, 5.60741201e-02f, 1.54266894e-01f, 1.21735856e-01f, 5.38840108e-02f, -1.48802161e-01f, -1.12485372e-01f, -1.37567982e-01f, -9.51711759e-02f,
  -2.16292724e-01f, -4.22581956e-02f, -3.69664766e-02f, -1.27821565e-01f, -1.05301708e-01f, -1.78755417e-01f, -6.56254813e-02f, 8.32691938e-02f, 1.91989765e-01f, 3.07914000e-02f,
  4.84297842e-01f, -3.74988019e-02f, 5.62423408e-01f, 2.97928452e-01f, 4.18626696e-01f, 4.42252696e-01f, 5.79849660e-01f, 3.17851782e-01f, 2.95689572e-02f, 1.45160407e-01f,
  -2.70200461e-01f, -3.84393424e-01f, -3.29808384e-01f, -2.32654944e-01f, 9.94491801e-02f, 3.54263842e-01f, 3.46231192e-01f, 2.72980034e-01f, 3.84397298e-01f, 4.00352448e-01f,
  5.44228368e-02f, 1.86377525e-01f, 2.57601351e-01f, 1.67411491e-01f, 1.73764393e-01f, -6.76672682e-02f, 1.40644923e-01f, 3.26988995e-01f, 1.33851692e-01f, 1.68569043e-01f,
  6.42790198e-02f, 1.37788042e-01f, -1.11028455e-01f, -1.88029796e-01f, -1.89072996e-01f, -1.63705885e-01f, -1.15870737e-01f, -1.17377050e-01f, -1.03743583e-01f, -6.73813969e-02f,
  -1.13611758e-01f, 6.55763745e-02f, -1.38938189e-01f, 9.08915943e-04f, 1.13690449e-02f, -5.31905070e-02f, -1.75482482e-01f, 6.02160990e-02f, 6.77908435e-02f, -1.58385515e-01f,
  -2.19373301e-01f, -2.47291401e-02f, -5.45169180e-03f, -2.69494168e-02f, -4.16153483e-02f, -4.69530225e-02f, -1.18905216e-01f, -3.41444761e-02f, -1.23997210e-02f, -1.81863401e-02f,
  -1.73601341e-02f, 1.02983490e-01f, 2.99178176e-02f, -1.26245208e-02f, -1.26875592e-02f, -1.66052897e-02f, -4.73205596e-02f, 1.43945944e-02f, -3.05263959e-02f, 7.17449114e-02f,
  -1.45337239e-01f, -1.10764854e-01f, 4.85941432e-02f, 2.00659521e-02f, -1.24462679e-01f, -3.94778512e-02f, 1.01694465e-01f, -1.43655449e-01f, -1.90683737e-01f, -7.60812610e-02f,
  -6.63599148e-02f, 8.78663287e-02f, 7.90102314e-03f, -1.07824355e-01f, -6.13060966e-02f, -9.38104987e-02f, 5.61404647e-03f, -1.30971029e-01f, 6.11658245e-02f, 3.75589132e-02f,
  -2.74945199e-01f, -2.20062435e-01f, -3.41093615e-02f, 1.84784830e-02f, 9.07942653e-02f, -3.35550793e-02f, -7.35997260e-02f, 6.55460432e-02f, 5.51851541e-02f, 7.67012462e-02f,
  -4.03211899e-02f, 6.52668625e-02f, -7.39475414e-02f, -8.02726448e-02f, 8.35583881e-02f, 6.94627315e-02f, -2.14084908e-01f, 9.38226506e-02f, -2.83582639e-02f, -3.99268232e-02f,
  4.51382026e-02f, 6.63760975e-02f, 1.15597971e-01f, 4.90617007e-02f, -4.70462218e-02f, 9.15002376e-02f, 3.57999769e-03f, 9.54022333e-02f, 1.19339265e-01f, 8.52950513e-02f,
  4.80890095e-01f, 2.43378192e-01f, 1.73084632e-01f, 2.58966267e-01f, -3.89660262e-02f, -1.50606841e-01f, -4.73476797e-02f, -1.26804009e-01f, -1.14156291e-01f, 1.87746421e-01f,
  5.71057841e-04f, -3.53685021e-01f, -8.47044960e-02f, -2.88319945e-01f, -2.53878355e-01f, 1.30712003e-01f, 8.38036984e-02f, -8.02011713e-02f, -5.32768130e-01f, -3.52062762e-01f,
  -3.67168099e-01f, -7.50803724e-02f, 7.70397335e-02f, -7.75303468e-02f, 2.63006389e-01f, -1.92840338e-01f, 3.10758322e-01f, 1.02602534e-01f, -8.28520283e-02f, 1.84791937e-01f,
  1.12415768e-01f, 2.21280694e-01f, -4.08556819e-01f, -1.92617372e-01f, 6.04404546e-02f, 1.21374484e-02f, -4.75855209e-02f, 1.32033899e-01f, 2.89726872e-02f, 9.84301232e-03f,
  -8.79164711e-02f, -8.92325565e-02f, -4.68101986e-02f, -1.10867415e-02f, -5.80405705e-02f, -1.68663815e-01f, 3.12382840e-02f, 1.75633114e-02f, -6.65804222e-02f, 5.68436198e-02f,
  -2.71209359e-01f, -5.47521561e-02f, 1.15861125e-01f, -1.07278489e-01f, 9.17665288e-02f, -5.88314272e-02f, 1.21728487e-01f, 5.38355410e-02f, 5.81021747e-03f, 2.30748758e-01f,
  3.99075300e-02f, 1.24737117e-02f, 1.18631602e-03f, 8.83807391e-02f, -1.92279089e-02f, 6.64603561e-02f, 5.43049127e-02f, 5.17933555e-02f, -1.12247951e-01f, -2.27991045e-02f,
  4.42909524e-02f, 5.09742089e-02f, 6.50365255e-04f, 1.59437612e-01f, 4.91859578e-02f, 8.85254983e-03f, -7.60167167e-02f, -8.96389335e-02f, -4.77570668e-02f, -2.38294210e-02f,
  -1.68679118e-01f, -9.67502519e-02f, 1.01239784e-02f, -1.17006436e-01f, 6.76331744e-02f, -5.05810343e-02f, -1.17402419e-01f, -5.47817983e-02f, -2.53298674e-02f, 3.46955284e-02f,
  -1.37365356e-01f, -2.77217031e-01f, 1.46013677e-01f, -1.49061382e-01f, 5.07469364e-02f, 4.25590612e-02f, 2.24703513e-02f, 6.25193492e-02f, 1.21603750e-01f, -7.15532282e-04f,
  1.69610009e-02f, 4.98955213e-02f, 5.46477139e-02f, -1.54265285e-01f, -5.07694259e-02f, -4.01666835e-02f, 1.08509068e-03f, -4.98670675e-02f, -1.48907065e-01f, 9.06513713e-04f,
  8.48745480e-02f, -9.02680829e-02f, -3.86733375e-02f, -4.34141234e-02f, 9.50921401e-02f, -1.04302414e-01f, -1.25242518e-02f, -9.12659541e-02f, -2.52548724e-01f, 5.97137697e-02f,
  -4.86055017e-02f, -2.53627479e-01f, 3.72513473e-01f, 4.19000089e-02f, 3.62982959e-01f, 3.34389001e-01f, 3.21236461e-01f, 6.23704679e-02f, -9.55184698e-02f, -5.02835633e-03f,
  -3.68009776e-01f, -3.94334286e-01f, -3.94497722e-01f, -3.97631198e-01f, -2.45928615e-01f, 2.20318019e-01f, 3.69775623e-01f, 1.59278065e-01f, 2.40617901e-01f, 1.85522467e-01f,
  2.67049335e-02f, 6.30091280e-02f, -1.61843881e-01f, -1.30580053e-01f, -1.15919001e-01f, -4.25534956e-02f, 6.24132641e-02f, 9.62890685e-02f, -8.63756984e-02f, -9.82732419e-03f,
  -7.12284297e-02f, -8.12206790e-02f, 4.41360381e-03f, -1.38056725e-01f, 3.38722989e-02f, -9.28847194e-02f, 1.33373039e-02f, -7.88857192e-02f, -2.26321161e-01f, -4.98721562e-02f,
  1.04012340e-02f, -1.82586193e-01f, -4.92998324e-02f, -6.22185469e-02f, 3.74118835e-02f, -3.43287513e-02f, -1.29109129e-01f, -1.82644218e-01f, -1.20888539e-02f, -1.26553908e-01f,
  -8.26036409e-02f, 2.17255786e-01f, 1.14127859e-01f, 6.33137077e-02f, -1.02002308e-01f, 1.92300249e-02f, 7.22110718e-02f, 6.00045407e-03f, -2.39565093e-02f, -1.15249276e-01f,
  1.18634263e-02f, 3.09578367e-02f, 4.47934791e-02f, 2.46325303e-02f, 9.54460725e-02f, 9.99449473e-03f, -5.88801354e-02f, -4.91442792e-02f, 7.53809363e-02f, 2.53583752e-02f,
  -3.55494395e-02f, 9.88267958e-02f, -7.03611895e-02f, -4.65073958e-02f, 1.43806078e-02f, 1.67014301e-01f, 1.14506464e-02f, -1.20354444e-01f, -9.36047882e-02f, 2.66843047e-02f,
  -5.30115776e-02f, -8.05338286e-03f, 9.38137528e-04f, -9.34555829e-02f, 5.30741140e-02f, 5.88954985e-02f, 7.70310089e-02f, -6.40072627e-03f, -6.87164739e-02f, 2.08320811e-01f,
  -3.01985621e-01f, 3.37714255e-02f, -1.37344375e-01f, 2.70187277e-02f, 3.59836668e-02f, -1.47622257e-01f, -1.30819649e-01f, -1.28085226e-01f, -4.26728866e-06f, -8.96234289e-02f,
  -1.32460803e-01f, -1.95195556e-01f, -1.56647652e-01f, -4.16092481e-03f, 1.41535059e-01f, 8.98204148e-02f, -2.31131226e-01f, 4.87407781e-02f, -5.94973303e-02f, 6.24163775e-04f,
  2.43095327e-02f, 2.13879526e-01f, 1.59827054e-01f, -7.71171376e-02f, -5.12527414e-02f, 1.85312271e-01f, 9.07533392e-02f, 8.50069057e-03f, 1.41842484e-01f, 6.64620772e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  4.99892503e-01f, 1.76981673e-01f, -1.95107713e-01f, 8.57199952e-02f, 2.48397943e-02f, 3.60103935e-01f, 3.31163496e-01f, 2.03020841e-01f, 4.60934490e-01f, 1.44025251e-01f,
  3.91108155e-01f, 5.29019237e-01f, 3.64223272e-01f, 1.99405551e-01f, 7.16193020e-01f, 1.67223230e-01f, -1.15710557e-01f, 2.90551692e-01f, 3.98504615e-01f, 3.24314415e-01f,
  4.52982187e-01f, 1.39914751e-01f, 3.19481432e-01f, 1.79638728e-01f, 3.64183336e-01f, 2.11285204e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -8.91234353e-03f, -1.02075450e-01f, -1.89603344e-02f, -1.05042709e-02f, 7.17728585e-02f, -1.22485995e-01f, 2.37335593e-01f, -2.16113195e-01f, 6.32985681e-02f, 3.60569134e-02f,
  1.31045923e-01f, -2.53692329e-01f, -2.08907411e-01f, -2.32869461e-01f, 2.46657550e-01f, -2.96042766e-02f, 1.57059699e-01f, 1.29345953e-01f, 9.63564441e-02f, 6.66835671e-03f,
  -2.57393420e-01f, 1.59486696e-01f, 9.95184109e-03f, -2.76246250e-01f, -1.63912266e-01f, 2.80808896e-01f, -1.48241401e-01f, 1.97246745e-01f, -4.72438615e-03f, 2.11848408e-01f,
  4.80389357e-01f, 7.05991015e-02f, 2.75939822e-01f, -2.96319481e-02f, 1.29677594e-01f, -6.15830794e-02f, -1.25522941e-01f, 1.04236864e-01f, -4.00813401e-01f, -1.77620798e-01f,
  4.46713082e-02f, -2.15577718e-04f, -1.67235225e-01f, -1.70364484e-01f, 3.31664592e-01f, -2.67606135e-02f, -1.63668931e-01f, -1.79323047e-01f, 2.78297842e-01f, 8.72424692e-02f,
  -3.06329578e-02f, 1.76885992e-01f, -1.09572940e-01f, 2.24124297e-01f, 3.16624530e-02f, 4.64528531e-01f, 3.10555100e-02f, -5.52782193e-02f, 2.96534210e-01f, 3.13406080e-01f,
  -1.37740120e-01f, 1.73239354e-02f, -4.39245701e-01f, 1.86652049e-01f, -9.83051136e-02f, -8.69148448e-02f, 2.05068178e-02f, -4.94546518e-02f, -5.86959310e-02f, 4.94201528e-03f,
  -8.69654343e-02f, 1.40895724e-01f, -6.60058297e-03f, -1.02435134e-01f, 2.17135534e-01f, 4.37088549e-01f, 1.95883512e-01f, 1.36016950e-01f, 2.03108732e-02f, 1.35450900e-01f,
  6.14973605e-02f, -1.43649414e-01f, -1.89849705e-01f, 1.95331246e-01f, -1.52901068e-01f, 1.39362246e-01f, 1.16601169e-01f, -5.09899378e-01f, -8.99456367e-02f, -4.27432775e-01f,
  8.40518028e-02f, -1.80275992e-01f, 1.85800567e-02f, -8.72819573e-02f, -6.48569316e-02f, -2.86055505e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.30710080e-01f, -2.20521823e-01f, -1.08733043e-01f, 6.01850629e-01f, -1.03145860e-01f, 2.54632890e-01f, -2.60330021e-01f, 2.24612698e-01f, -1.08018294e-01f, 2.82191843e-01f,
  1.09844565e-01f, 2.72064209e-01f, 2.68649012e-01f, -4.38850105e-01f, 2.79518604e-01f, -3.34779769e-01f, 2.46573180e-01f, -3.88091579e-02f, 3.98354620e-01f, 3.02178353e-01f,
  2.91370958e-01f, 1.21616825e-01f, -1.58282951e-01f, 5.13414979e-01f, -1.70166135e-01f, 2.93908060e-01f, -1.50263101e-01f, -1.26975507e-01f, -3.15888226e-01f, -3.22919607e-01f,
  -3.86235476e-01f, -2.03315821e-03f, 4.26675797e-01f, 1.57138526e-01f, 3.44572246e-01f, 5.98028004e-02f, 2.34809890e-02f, -3.60972673e-01f, 4.11492616e-01f, 1.97880581e-01f,
  -6.74029589e-01f, -1.69576108e-01f, 1.75206915e-01f, 9.05540660e-02f, 5.19222617e-01f, -2.32833456e-02f, 5.97659647e-01f, 1.02733366e-01f, -2.04617977e-01f, 2.17847705e-01f,
  -3.40473317e-02f, 7.08767101e-02f, -1.44274041e-01f, 4.53021020e-01f, -1.07566826e-02f, -6.76236570e-01f, 1.41325921e-01f, -2.53107339e-01f, 4.08212364e-01f, -3.73812050e-01f,
  -4.95813787e-04f, -2.21961930e-01f, 3.56925488e-01f, -1.33849084e-01f, 1.73521236e-01f, -7.32295066e-02f, -6.68841526e-02f, 8.39257520e-03f, -1.31444335e-01f, -2.12933242e-01f,
  2.39702880e-01f, -4.14577216e-01f, -2.10443169e-01f, -1.60716534e-01f, 4.56913501e-01f, -4.59613681e-01f, -2.30747446e-01f, 1.51134953e-01f, 2.19306931e-01f, 1.39028192e-01f,
  -5.55331297e-02f, -6.00773692e-01f, 2.59819120e-01f, -5.98232746e-01f, 1.90451264e-01f, -1.37300119e-01f, -3.28778327e-02f, 3.71544778e-01f, -4.01874065e-01f, 4.47684884e-01f,
  -1.32619768e-01f, 3.21201861e-01f, 1.55661941e-01f, 1.65452346e-01f, 3.60675126e-01f, -1.94743842e-01f, 2.49921992e-01f, 2.96635091e-01f, 1.41322300e-01f, -1.28674597e-01f,
  -3.57394189e-01f, 5.68358554e-03f, -8.07055831e-03f, -1.93598434e-01f, 7.73042515e-02f, 1.65930539e-01f, 3.84670831e-02f, -8.44973326e-02f, -2.58512944e-02f, -1.94054917e-01f,
  2.12161914e-01f, -3.41726959e-01f, 4.06396389e-03f, 4.65076379e-02f, 1.55539140e-01f, -2.85173118e-01f, 1.81201193e-02f, -3.10057610e-01f, -2.71933675e-01f, 2.32061177e-01f,
  -5.36156856e-02f, 4.56806511e-01f, 2.99678773e-01f, 4.12481755e-01f, 3.33681136e-01f, 3.18459839e-01f, 2.21163094e-01f, 5.72866857e-01f, 1.94157451e-01f, -1.59901500e-01f,
  -2.59016939e-02f, 2.24934250e-01f, -1.17798373e-01f, 3.53370696e-01f, -5.07628322e-01f, 2.53885388e-01f, -3.46351415e-01f, -1.48066580e-01f, 3.36826555e-02f, 2.27639139e-01f,
  1.88030913e-01f, 1.96324676e-01f, 1.60622984e-01f, 5.97485937e-02f, -2.59622663e-01f, 1.61309645e-01f, 3.36644314e-02f, -8.68890807e-02f, 1.23890042e-01f, -1.42228603e-01f,
  -3.59383136e-01f, -3.29036087e-01f, 4.44432981e-02f, -5.20954072e-01f, 4.08398032e-01f, -5.02391458e-01f, 1.59592062e-01f, -2.29343534e-01f, -2.80950695e-01f, -3.45995963e-01f,
  -3.93871889e-02f, -4.54967245e-02f, 5.64416461e-02f, 5.09444475e-01f, 1.14408627e-01f, -7.71168768e-02f, -7.57991150e-03f, -1.80424124e-01f, -2.69508004e-01f, 7.09849782e-03f,
  1.40491631e-02f, -1.17073976e-01f, 3.18951964e-01f, -2.05877751e-01f, -5.74663514e-03f, -3.67320627e-01f, 3.10426801e-01f, -4.59493101e-02f, 2.07517296e-01f, 1.48369491e-01f,
  2.66497731e-01f, 6.06101230e-02f, -2.28468835e-01f, 5.10079026e-01f, 5.89775369e-02f, 3.06204617e-01f, -3.58158886e-01f, 2.32478335e-01f, -2.42642373e-01f, -3.61560166e-01f,
  -3.93066883e-01f, 4.93887216e-02f, -2.27989089e-02f, 4.64109294e-02f, 1.03128001e-01f, 1.89569965e-02f, -3.39299500e-01f, -2.00695544e-01f, 1.21192425e-01f, -6.91202343e-01f,
  1.32550344e-01f, 2.61831373e-01f, 3.13432515e-01f, -5.12642026e-01f, 2.53856957e-01f, 2.27252573e-01f, 7.62741566e-02f, 2.36997604e-01f, 1.74596354e-01f, -1.20702848e-01f,
  9.05070454e-03f, 1.34964213e-01f, 3.23012501e-01f, 4.09674436e-01f, 1.24342516e-01f, -1.23879015e-02f, -2.32622921e-01f, -7.51657188e-01f, -5.26664913e-01f, 1.96696728e-01f,
  -3.07689518e-01f, 6.35337085e-02f, 7.48190954e-02f, -1.01939425e-01f, -1.22176811e-01f, 6.69052154e-02f, -1.22671835e-01f, -4.14296329e-01f, -4.43961248e-02f, 2.89509565e-01f,
  -4.92312014e-02f, -2.37066671e-01f, 9.73558575e-02f, -1.63146064e-01f, -3.11233997e-01f, -3.44978601e-01f, -5.52901849e-02f, 1.67957887e-01f, 1.52745143e-01f, 8.68784711e-02f,
  -8.19545686e-02f, 6.05314691e-03f, -2.80339628e-01f, -6.14459328e-02f, -4.27411735e-01f, -4.04810607e-01f, 1.33181363e-01f, 1.11776805e-02f, 9.48193669e-02f, -1.07854001e-01f,
  2.01382395e-02f, -4.17534076e-02f, -1.06943138e-01f, 1.73116758e-01f, 2.06675842e-01f, 2.57753521e-01f, -8.38959739e-02f, -1.17115535e-01f, -2.13598788e-01f, -1.76050544e-01f,
  -1.97071686e-01f, 3.28744709e-01f, -1.31792367e-01f, 3.53707552e-01f, -3.28222454e-01f, 1.36582628e-02f, -1.15136974e-01f, 3.86075974e-01f, 1.73554257e-01f, 1.97761521e-01f,
  -4.39791143e-01f, 2.35635474e-01f, 1.22322269e-01f, -9.39072073e-02f, 1.10548370e-01f, -1.53732762e-01f, 3.51436436e-02f, 2.89954413e-02f, -3.15102279e-01f, 9.12386999e-02f,
  1.60282150e-01f, -4.01458025e-01f, 3.14870775e-01f, -5.36301494e-01f, -4.72360514e-02f, 8.16713646e-02f, -5.87897897e-01f, -2.54187316e-01f, 1.24080092e-01f, -2.27425158e-01f,
  1.21124379e-01f, 1.96860805e-01f, 1.99859917e-01f, 2.59548843e-01f, -6.46410808e-02f, 5.27729578e-02f, -1.40230179e-01f, 1.44740209e-01f, -3.94626372e-02f, 3.64029855e-01f,
  3.83367538e-02f, -2.05425829e-01f, 3.02546889e-01f, 1.29839361e-01f, 8.40220824e-02f, -6.61932817e-03f, 4.15111691e-01f, 4.50483561e-01f, 1.06850162e-01f, 2.52976064e-02f,
  3.44046690e-02f, 4.61339615e-02f, -2.64793128e-01f, 4.00570899e-01f, -1.92847505e-01f, -5.30082323e-02f, -1.40589446e-01f, -3.65438521e-01f, -2.27793217e-01f, -2.86588762e-02f,
  1.46615654e-01f, 2.48649985e-01f, 1.64463565e-01f, 2.63919502e-01f, -1.74054191e-01f, 2.53814131e-01f, -4.19442594e-01f, 2.02136394e-02f, 1.12963103e-01f, 5.41059852e-01f,
  -3.11062764e-02f, 3.99978608e-01f, -9.46291909e-02f, -9.36155394e-02f, 3.42392683e-01f, -1.23788573e-01f, -2.01469541e-01f, -2.77273893e-01f, 2.49582514e-01f, 5.40515363e-01f,
  2.16179546e-02f, -1.03599779e-01f, 1.90103397e-01f, -2.52032280e-01f, -2.51475662e-01f, 4.08954501e-01f, -1.27436325e-01f, 1.90460920e-01f, 1.65568799e-01f, -3.78511041e-01f,
  1.44094720e-01f, 1.72770813e-01f, 3.07871133e-01f, -2.44485140e-01f, -2.06345826e-01f, 3.43908936e-01f, 6.34717122e-02f, 3.45520914e-01f, -2.69418716e-01f, 3.78097475e-01f,
  8.23810250e-02f, 1.05360292e-01f, -1.08604476e-01f, 2.00577915e-01f, 1.98119447e-01f, -1.95619419e-01f, 1.10423811e-01f, 4.55553569e-02f, 3.70299309e-01f, -3.51130888e-02f,
  1.09509185e-01f, 1.84175675e-03f, 7.77941868e-02f, -2.14302801e-02f, -2.84860551e-01f, 5.35812020e-01f, 6.04688078e-02f, -6.85991272e-02f, -9.62578654e-02f, -1.11004703e-01f,
  -2.59029984e-01f, 7.09996819e-02f, -4.67027456e-01f, 2.29099184e-01f, 2.72087365e-01f, 2.31250241e-01f, 2.96986073e-01f, -2.53402472e-01f, 1.29250944e-01f, 7.56572336e-02f,
  6.88592732e-01f, 1.85221940e-01f, -7.06008375e-02f, -4.36758101e-02f, -1.38971373e-01f, 6.51527792e-02f, -3.55980657e-02f, 3.39429788e-02f, 4.08866316e-01f, -2.14315057e-01f,
  -2.06281975e-01f, 4.78886694e-01f, 1.26911566e-01f, -3.42861265e-01f, 2.57549852e-01f, -4.57969218e-01f, 1.17422398e-02f, -1.86281390e-02f, 2.43043706e-01f, 5.97448528e-01f,
  -1.68886319e-01f, 9.20757055e-02f, 4.71699357e-01f, 1.25790462e-01f, 4.47417945e-01f, 1.66534349e-01f, 8.39890391e-02f, 1.57142639e-01f, 1.54920623e-01f, 4.43154663e-01f,
  -2.16031313e-01f, -3.82649988e-01f, 4.54581738e-01f, -1.61516979e-01f, -3.31430316e-01f, -1.17481597e-01f, 3.32068264e-01f, 3.07323430e-02f, 2.64370948e-01f, 7.80978566e-03f,
  4.99444604e-01f, -1.32057369e-01f, 5.70261218e-02f, -3.45961750e-01f, 1.73482820e-01f, 7.23874122e-02f, 2.19472989e-01f, 4.11820680e-01f, 2.55247712e-01f, 6.30941056e-03f,
  -3.33048880e-01f, 2.38001615e-01f, -4.02491336e-04f, -2.65704960e-01f, -6.86315596e-02f, 2.77502418e-01f, 6.16924644e-01f, 2.35456657e-02f, 3.90763223e-01f, 1.56743646e-01f,
  3.96737218e-01f, -2.98529983e-01f, -1.19835690e-01f, -1.31681755e-01f, 5.63110530e-01f, -5.30583039e-03f, 9.79798287e-02f, 2.45140910e-01f, -5.52793086e-01f, -5.61911054e-02f,
  -1.21532150e-01f, -4.23258066e-01f, -1.39260426e-01f, -3.53082836e-01f, 1.73016861e-02f, 5.85332930e-01f, 1.81099907e-01f, 3.25450808e-01f, 2.68484086e-01f, 2.57852286e-01f,
  -3.83294791e-01f, -3.92487675e-01f, 2.09332839e-01f, 1.50641993e-01f, 2.83478707e-01f, 3.75362813e-01f, -6.20271079e-02f, -1.43392876e-01f, 2.07194343e-01f, -4.61025625e-01f,
  3.30628872e-01f, 1.97758287e-01f, 2.44854778e-01f, -8.10441449e-02f, 2.44533241e-01f, 7.55421817e-02f, 1.31721511e-01f, -9.42824855e-02f, 2.60787398e-01f, 4.00471777e-01f,
  -4.30725366e-01f, 2.68400341e-01f, -3.37240070e-01f, -4.09240216e-01f, -1.14139035e-01f, -2.55255282e-01f, 8.85311365e-02f, 3.39154303e-01f, -3.17063071e-02f, 3.59751910e-01f,
  -4.91405398e-01f, -1.91975355e-01f, -2.97461450e-01f, -2.60675661e-02f, 3.18814725e-01f, -4.47285175e-02f, 3.30756962e-01f, 3.24102819e-01f, -3.62850726e-01f, -1.94044337e-01f,
  7.84765258e-02f, -8.88481289e-02f, 4.21817154e-01f, 4.79986578e-01f, 3.42812538e-01f, -1.51001111e-01f, -1.79155663e-01f, 8.22551548e-02f, 1.63433671e-01f, 5.31045079e-01f,
  -6.89585745e-01f, -3.05797726e-01f, -2.22550750e-01f, 2.17960462e-01f, 1.86923429e-01f, 1.72671318e-01f, 8.55282843e-02f, 4.17688563e-02f, 2.23050863e-02f, 1.71775371e-01f,
  1.59989104e-01f, -8.19904506e-02f, 4.43901062e-01f, -3.40997577e-01f, -4.54063177e-01f, -2.94076324e-01f, 1.86422825e-01f, -1.65881202e-01f, 2.39754185e-01f, -4.36898768e-01f,
  2.01861620e-01f, -4.08124685e-01f, -1.12864692e-02f, -5.23551226e-01f, -1.14587776e-01f, 1.88171491e-01f, 7.42372200e-02f, -1.29137725e-01f, 1.03925709e-02f, 2.19026744e-01f,
  -1.28219977e-01f, 2.76832320e-02f, 3.51854265e-01f, -2.45992154e-01f, -1.41650215e-01f, 2.08012775e-01f, 4.87249903e-02f, 1.86445236e-01f, -4.85617340e-01f, 4.20668840e-01f,
  2.17505470e-01f, -1.80746436e-01f, -5.11755645e-01f, -1.20991766e-01f, -2.57105917e-01f, -4.25979830e-02f, -1.48454696e-01f, 1.14431381e-01f, 5.39745837e-02f, -3.14290971e-01f,
  2.27353543e-01f, -3.89357030e-01f, -3.21193859e-02f, 3.26256216e-01f, -3.57694417e-01f, 4.69087511e-01f, -1.85437903e-01f, -1.96213603e-01f, -1.35946631e-01f, 3.17997277e-01f,
  -1.72559127e-01f, 2.29732960e-01f, -1.28361210e-01f, 1.58841982e-01f, -2.85211265e-01f, -6.64347708e-02f, -1.53813928e-01f, -3.54401767e-02f, 6.89436048e-02f, -3.45119208e-01f,
  3.96107472e-02f, -2.93241799e-01f, 2.63183951e-01f, 1.00611500e-01f, 1.75769418e-01f, 4.03797068e-02f, -4.17801067e-02f, 1.28987625e-01f, -2.56974071e-01f, 6.18955672e-01f,
  3.82581085e-01f, 1.20855622e-01f, 9.61443335e-02f, -1.59500595e-02f, -4.60916162e-02f, 2.34998584e-01f, -2.49605820e-01f, 3.17558616e-01f, 3.78813297e-01f, -3.00620180e-02f,
  -3.99585739e-02f, 7.93131217e-02f, -4.58380580e-02f, -1.44116938e-01f, -2.04993755e-01f, -2.24031806e-01f, 1.25647604e-01f, 1.91375494e-01f, -1.65719360e-01f, -1.21354841e-01f,
  1.08988985e-01f, 3.61761414e-02f, 4.41851914e-02f, -2.18801558e-01f, 5.09658456e-01f, 2.33682260e-01f, 2.82571942e-01f, 3.97304177e-01f, -1.77052096e-01f, 3.90612453e-01f,
  4.39227149e-02f, 5.01270257e-02f, 3.76138031e-01f, -1.67127609e-01f, 2.13422272e-02f, 2.90991157e-01f, -4.18920785e-01f, -2.17992827e-01f, -2.07271487e-01f, -4.43906665e-01f,
  -1.24069536e-02f, 5.13194799e-02f, 1.16813257e-01f, 9.36428756e-02f, -7.57862628e-02f, -9.75394920e-02f, 1.18964702e-01f, 3.16083431e-01f, 1.31117836e-01f, -1.11686543e-01f,
  2.77544141e-01f, 3.57048750e-01f, -4.77476865e-02f, 3.64479750e-01f, 1.29880920e-01f, 1.07171517e-02f, -3.46468925e-01f, 4.39987704e-02f, -1.48853987e-01f, 1.04359284e-01f,
  2.55295753e-01f, 7.67932013e-02f, -6.23590797e-02f, -2.52433062e-01f, -1.36160031e-01f, -4.40345436e-01f, 3.59651595e-01f, -2.92045683e-01f, 2.82364964e-01f, -1.68914661e-01f,
  1.07573234e-01f, 3.51628393e-01f, 1.59436539e-01f, 7.40557015e-02f, 3.01233202e-01f, -1.80379331e-01f, -1.52369782e-01f, -2.20007211e-01f, 6.30183592e-02f, -5.32446623e-01f,
  -1.82420444e-02f, -2.84642756e-01f, 9.31079611e-02f, -3.58255148e-01f, 1.55393317e-01f, -1.26090527e-01f, 2.78000552e-02f, 2.53524214e-01f, 2.51312196e-01f, 4.99665290e-02f,
  2.00195312e-01f, 2.10610762e-01f, 1.16215441e-02f, 3.22570860e-01f, 3.33063938e-02f, 9.68002677e-02f, 1.88932508e-01f, 4.46481928e-02f, 1.24094434e-01f, 1.82395987e-02f,
  2.99251169e-01f, 1.76003829e-01f, 2.91728348e-01f, 1.19098350e-01f, -8.85440409e-02f, 4.43708599e-01f, 1.88850448e-01f, 2.43950129e-01f, 2.56613255e-01f, 1.93092689e-01f,
  -2.65634388e-01f, -1.10889435e-01f, -9.43176001e-02f, 3.86972100e-01f, 1.66250378e-01f, 3.01302522e-01f, 2.01965883e-01f, 1.57421753e-01f, 5.09196818e-01f, 1.38189360e-01f,
  -2.10786819e-01f, -8.93360972e-02f, 1.46194890e-01f, 4.27472204e-01f, 2.51843799e-02f, 1.04562286e-02f, 2.90596131e-02f, -2.27867842e-01f, -3.31918508e-01f, 4.22914177e-01f,
  -3.83463919e-01f, -9.88573879e-02f, 3.63512367e-01f, 6.75113425e-02f, 4.86737967e-01f, -3.75806727e-02f, 2.77610540e-01f, 2.89485335e-01f, 4.49508309e-01f, 4.66196686e-01f,
  -1.16587535e-01f, -6.32683218e-01f, -4.82209846e-02f, -3.81599814e-01f, -1.31438538e-01f, 1.17237076e-01f, -3.88439149e-02f, -2.55609304e-01f, 9.01577398e-02f, -1.65843278e-01f,
  3.02425504e-01f, -1.11441843e-01f, -2.20479056e-01f, -2.78857350e-03f, 1.14045620e-01f, 2.26472944e-01f, 2.94960383e-02f, 3.24649125e-01f, 8.54509100e-02f, 2.25027516e-01f,
  1.60580024e-01f, 4.01127040e-01f, 1.27709612e-01f, 4.31178391e-01f, 3.44010860e-01f, -1.75646618e-01f, 4.82225031e-01f, 3.91622633e-02f, 3.13998371e-01f, 2.05155045e-01f,
  2.56717354e-01f, -2.06855357e-01f, -1.23162642e-02f, 1.70784786e-01f, -1.24960929e-01f, 3.75006318e-01f, -1.86283365e-01f, -1.76229611e-01f, 1.68383405e-01f, 1.93178251e-01f,
  -9.60711017e-02f, 6.81950664e-03f, -3.95909905e-01f, 2.15705320e-01f, 3.50123256e-01f, 1.03373051e-01f, -6.21946482e-03f, -1.76033497e-01f, 3.95728290e-01f, 4.03917395e-03f,
  -1.88169181e-01f, 2.96631038e-01f, 3.65917981e-01f, 2.26157576e-01f, 4.50406820e-01f, -1.69180706e-01f, 3.09579879e-01f, 2.14033812e-01f, -1.79764450e-01f, 3.53291988e-01f,
  7.17830881e-02f, -3.74942124e-02f, 1.68795720e-01f, 2.02317927e-02f, 1.93429843e-01f, 5.15728630e-02f, 4.03650939e-01f, 3.49978328e-01f, 6.15428761e-02f, 2.82956004e-01f,
  -1.92743078e-01f, 1.64456487e-01f, -7.96698853e-02f, -1.96387261e-01f, -1.77012105e-02f, -4.17176872e-01f, 1.72988757e-01f, 4.36957181e-01f, 2.50844836e-01f, 3.18022639e-01f,
  -1.00109123e-01f, 5.78318052e-02f, 1.28468111e-01f, 8.90009925e-02f, 3.22171003e-01f, 1.68866441e-01f, 1.63450167e-01f, 3.05509299e-01f, -3.14116687e-01f, -5.19617200e-01f,
  2.32443050e-01f, -3.11287671e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.09416932e-01f, 4.28985566e-01f, -5.40017076e-02f, 2.03802779e-01f, 1.02150068e-01f, 5.53517714e-02f, 1.38751596e-01f, -3.21526408e-01f, 5.05519696e-02f, 3.97504240e-01f,
  4.11227167e-01f, -2.61694007e-02f, 4.26086038e-01f, 3.43459427e-01f, 3.18087697e-01f, 2.33743057e-01f, 4.79972839e-01f, -5.95360734e-02f, 2.42342919e-01f, 4.17101145e-01f,
  6.65258318e-02f, 2.77508348e-01f, 3.26578379e-01f, 3.39819402e-01f, 4.77750301e-01f, 1.03930727e-01f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  1.21340632e-01f, 1.89844266e-01f, 1.18936822e-01f, 1.21213188e-02f, 3.07525814e-01f, 4.46822792e-01f, -3.32483388e-02f, 2.79737949e-01f, 9.95441750e-02f, -2.39291489e-01f,
  3.09726018e-02f, -1.89609036e-01f, 1.66678913e-02f, 8.47152323e-02f, 9.56442505e-02f, -6.41679317e-02f, -9.70232710e-02f, -1.11247800e-01f, -3.53765823e-02f, 1.30191267e-01f,
  -3.03068846e-01f, -2.58768737e-01f, -2.45076925e-01f, -1.97009012e-01f, -2.53871590e-01f, -4.27920651e-03f, 1.07914984e-01f, 1.03343707e-02f, -2.20700074e-02f, 1.79450866e-03f,
  -1.98537573e-01f, -1.29216403e-01f, -2.41856992e-01f, -2.04044253e-01f, -1.54736757e-01f, -3.27431828e-01f, 1.89988300e-01f, 4.01248455e-01f, 1.29280835e-01f, 1.21498108e-01f,
  -3.14158112e-01f, -1.42214045e-01f, 1.64643124e-01f, 1.06078334e-01f, 1.60761580e-01f, 3.82265560e-02f, 5.86613715e-02f, 1.00673430e-01f, -5.32117076e-02f, 1.63322553e-01f,
  1.76319420e-01f, 1.30730495e-01f, 1.77755415e-01f, -4.90472950e-02f, 3.31283092e-01f, -8.32793936e-02f, -1.12116247e-01f, 1.32741779e-01f, 3.32080543e-01f, -9.52145532e-02f,
  1.20553095e-02f, 3.63880247e-02f, -2.63145775e-01f, 1.50327399e-01f, 5.61354235e-02f, -9.44161937e-02f, -5.61891869e-02f, -6.42466769e-02f, -6.40248284e-02f, 2.83987559e-02f,
  -4.16557193e-02f, 1.35544345e-01f, -1.50223568e-01f, -2.34006330e-01f, 3.10896695e-01f, -4.13929634e-02f, 9.22374278e-02f, -1.23726867e-01f, 1.66390955e-01f, 7.90656433e-02f,
  -1.02121361e-01f, 1.08585596e-01f, -2.39417389e-01f, -2.30819002e-01f, -1.77148096e-02f, -2.15557009e-01f, 2.43080243e-01f, 2.53769904e-01f, 5.08180149e-02f, -8.69083777e-02f,
  1.26246708e-02f, 1.63341627e-01f, 2.79652867e-02f, -5.40576130e-02f, 4.77009192e-02f, 5.49096987e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -1.12693116e-01f, 1.20145261e-01f, 2.30616555e-02f, -2.16842771e-01f, 3.54506522e-01f, 9.60385948e-02f, 2.33675480e-01f, -2.02599317e-01f, 1.90014690e-02f, -5.26524067e-01f,
  3.95413190e-01f, 3.26709002e-01f, 2.79685944e-01f, -3.09522767e-02f, 4.75184351e-01f, 3.62240881e-01f, 3.90986949e-01f, 1.55309290e-01f, -4.09234315e-01f, 1.55807540e-01f,
  -7.50965253e-02f, 1.03231989e-01f, -6.60145134e-02f, -9.38075408e-02f, 3.05173367e-01f, 3.21244329e-01f, 2.07210138e-01f, -2.86505390e-02f, 2.60608763e-01f, -8.15624669e-02f,
  3.66234034e-01f, 1.43067017e-01f, 3.09960395e-01f, 1.21326512e-02f, 3.26933950e-01f, 1.21614151e-01f, 4.05884624e-01f, -9.08835888e-01f, -1.02448776e-01f, 3.33074443e-02f,
  -1.73993930e-01f, 1.84568211e-01f, -2.87694484e-01f, -4.06546086e-01f, 1.76492892e-02f, 1.78344380e-02f, -1.50952414e-01f, 2.63163775e-01f, 1.19186662e-01f, -7.48620257e-02f,
  7.22715333e-02f, -1.64338127e-01f, 3.05112362e-01f, 4.41956282e-01f, -1.32904753e-01f, 9.83462334e-02f, 4.66695011e-01f, 1.20010041e-01f, 2.64486279e-02f, 5.38779497e-02f,
  7.68260658e-02f, 2.59608418e-01f, 3.92708242e-01f, 2.59014666e-01f, 2.35577509e-01f, 2.19662562e-01f, 9.50333923e-02f, 2.44395480e-01f, -6.70489430e-01f, -4.14230116e-02f,
  6.61865056e-01f, 2.52017736e-01f, 1.73490271e-01f, 2.86902010e-01f, 1.74255729e-01f, 1.62504688e-01f, -1.12253197e-01f, 6.70653433e-02f, -3.90866756e-01f, 3.54796290e-01f,
  5.22518396e-01f, 2.03490034e-01f, 3.89084488e-01f, 2.92153090e-01f, -1.32834986e-02f, -2.19209358e-01f, 1.08804353e-01f, -4.21541095e-01f, 2.87154287e-01f, -3.30636114e-01f,
  -1.78650767e-02f, -2.36741006e-01f, 4.87700582e-01f, 5.52508533e-01f, -5.73096462e-02f, -1.38925165e-01f, 4.78733405e-02f, 4.47511710e-02f, 3.60545009e-01f, 2.34099478e-01f,
  3.59988287e-02f, 2.90904760e-01f, -4.34846357e-02f, 2.76168436e-01f, 2.30998442e-01f, -2.02109799e-01f, -1.67530328e-01f, 1.24097578e-01f, 2.94303626e-01f, -2.14626387e-01f,
  1.47798121e-01f, -3.82012039e-01f, -4.21311110e-01f, 4.75237966e-02f, 1.48654580e-01f, 2.52238512e-01f, 7.07773939e-02f, 5.11951223e-02f, 2.09947601e-01f, -1.61809266e-01f,
  2.91818112e-01f, 2.13282943e-01f, -7.48862475e-02f, 2.50340462e-01f, -3.61658692e-01f, 3.70754041e-02f, 5.37622580e-03f, -3.16865444e-02f, 2.95377702e-01f, 8.70962888e-02f,
  1.93804666e-01f, -3.95297669e-02f, 4.26583737e-01f, -1.46182567e-01f, 9.31610242e-02f, -5.00033557e-01f, 1.20475397e-01f, 4.75169599e-01f, 1.15053654e-01f, 4.34825957e-01f,
  -1.69014335e-01f, -3.72250825e-01f, 3.73456270e-01f, -2.64066488e-01f, -2.03813851e-01f, 2.80474693e-01f, 2.75377065e-01f, -2.55657077e-01f, 5.23345396e-02f, 1.34728193e-01f,
  2.53897365e-02f, 5.86634874e-02f, 6.31250858e-01f, 2.61509806e-01f, 5.03627323e-02f, 2.74724811e-01f, -4.63103056e-01f, 1.12045839e-01f, 4.55992877e-01f, -2.80734114e-02f,
  1.04993895e-01f, 1.71910360e-01f, 3.04784715e-01f, 8.72761756e-02f, -8.29274952e-02f, 5.99379987e-02f, 5.01209795e-01f, -5.31275831e-02f, 5.15454859e-02f, -5.47562689e-02f,
  -2.82385379e-01f, -1.05285309e-01f, -5.50462529e-02f, 6.64102659e-02f, -2.96420664e-01f, 2.52164364e-01f, 6.02829218e-01f, 1.80418938e-01f, 3.30752820e-01f, 3.14241081e-01f,
  2.41670117e-01f, 1.32682115e-01f, 2.50239730e-01f, 2.84054689e-02f, -4.55291718e-01f, -1.42357633e-01f, -1.19241066e-01f, 2.84205526e-02f, 4.39755291e-01f, 3.91238093e-01f,
  -2.82857090e-01f, 2.44676322e-01f, 5.72433293e-01f, 5.08854568e-01f, -1.57259598e-01f, -4.36869800e-01f, 1.83834791e-01f, 3.59049767e-01f, 1.61683917e-01f, 2.81171724e-02f,
  -1.82468325e-01f, -4.60618436e-01f, 2.34012589e-01f, 4.69463676e-01f, 1.93875674e-02f, -2.23718897e-01f, 3.57832849e-01f, 1.81500167e-01f, 4.15048525e-02f, 3.50972235e-01f,
  -3.73409502e-02f, 2.44224686e-02f, -1.58834949e-01f, -6.18882813e-02f, 3.27344984e-01f, -1.80476196e-02f, 9.52043310e-02f, 2.22082347e-01f, 1.66984573e-01f, -1.38960391e-01f,
  4.68384773e-01f, -1.92234173e-01f, 3.10019076e-01f, 1.85287133e-01f, -1.48329541e-01f, 3.95897478e-02f, -8.55953172e-02f, -4.61389065e-01f, 4.33167905e-01f, -2.12244213e-01f,
  -2.68659413e-01f, 6.56506866e-02f, -4.90163304e-02f, -5.15605062e-02f, 4.05936480e-01f, 1.10382758e-01f, 4.87698615e-02f, -5.87374687e-01f, 4.88207936e-01f, -1.63626269e-01f,
  -2.23295644e-01f, 1.51682973e-01f, -7.51726106e-02f, -2.14263082e-01f, 2.81932622e-01f, 2.65683293e-01f, 2.63158798e-01f, -3.57358903e-01f, 2.06715912e-01f, 2.10431248e-01f,
  -1.48143232e-01f, -3.32954014e-03f, -3.54980141e-01f, -7.69213438e-02f, 2.50672460e-01f, 3.08951020e-01f, 6.52989805e-01f, 1.36207730e-01f, 4.27337795e-01f, 1.90784559e-01f,
  4.63072419e-01f, -6.94874823e-01f, 4.04206738e-02f, -4.92683835e-02f, -5.33198118e-01f, 4.10313755e-01f, -4.88549650e-01f, 6.28797933e-02f, -1.50600031e-01f, 6.04325766e-03f,
  -3.91408443e-01f, 1.95568159e-01f, -5.62775172e-02f, 1.13975778e-01f, 3.80573243e-01f, -1.25386193e-01f, 1.83284029e-01f, 1.06086075e-01f, -1.28973080e-02f, -1.27595693e-01f,
  7.80791044e-02f, 2.00113758e-01f, -7.03302473e-02f, 9.81747359e-02f, 1.37616202e-01f, 1.22087933e-01f, 1.04946449e-01f, 3.75458449e-02f, 4.38522369e-01f, 2.47911975e-01f,
  3.23877931e-01f, -2.41025120e-01f, 1.12414643e-01f, -5.75957894e-01f, 4.28275704e-01f, -7.05379695e-02f, -1.34579346e-01f, -1.08688809e-01f, -1.80099174e-01f, 1.74543858e-01f,
  -1.69469848e-01f, -9.10624415e-02f, 1.80745800e-03f, 2.19476208e-01f, 1.72238857e-01f, 2.43479595e-01f, 4.26549673e-01f, -2.71324217e-01f, 4.77111667e-01f, 4.42750484e-01f,
  1.83398753e-01f, -4.16705638e-01f, 2.35049605e-01f, 2.42036894e-01f, -3.17237824e-01f, -7.84647018e-02f, 8.03007707e-02f, -9.20128301e-02f, -5.62939718e-02f, 3.15078229e-01f,
  1.10465609e-01f, 1.28085628e-01f, 1.21820949e-01f, 1.54666558e-01f, -4.52862263e-01f, -6.97249398e-02f, -2.49735802e-01f, 6.17800891e-01f, -5.43268099e-02f, 4.40925807e-01f,
  -2.87383012e-02f, -2.19826952e-01f, -2.36493558e-01f, -5.00522971e-01f, -5.55418730e-01f, -2.27078468e-01f, -1.09734990e-01f, -3.58817607e-01f, 4.14544702e-01f, 2.87097335e-01f,
  3.16514969e-01f, 8.66502672e-02f, 5.43615259e-02f, -3.37127119e-01f, -3.02182853e-01f, -2.23522499e-01f, -6.59968257e-02f, 2.04762161e-01f, 3.56329352e-01f, 4.46387738e-01f,
  -3.43017653e-02f, -1.74808905e-01f, -4.68487851e-02f, 2.74110109e-01f, 9.72036272e-02f, -9.27033275e-02f, -1.33386746e-01f, 3.15828770e-02f, 3.16612184e-01f, 2.33078878e-02f,
  -4.76899976e-03f, -5.42465329e-01f, 5.24740100e-01f, -1.91715695e-02f, 6.48785904e-02f, 8.60316306e-02f, 4.23386365e-01f, 3.56860071e-01f, 2.78636843e-01f, 3.11202705e-01f,
  1.08949482e-01f, 6.14114963e-02f, -7.77860209e-02f, 1.94896325e-01f, 4.44288909e-01f, 3.18358600e-01f, -2.14930438e-03f, 6.72141090e-02f, 3.36501375e-02f, -8.88595730e-02f,
  2.36964330e-01f, -3.50756794e-01f, 1.29187971e-01f, 2.33775198e-01f, 5.04472852e-02f, 2.01060593e-01f, -9.75806639e-02f, -7.25581467e-01f, -3.85384053e-01f, 4.39987630e-01f,
  -2.65355706e-02f, 2.55641609e-01f, 1.17085211e-01f, -5.03512425e-03f, 5.33143997e-01f, -2.55344301e-01f, 1.23885147e-01f, 3.44371330e-03f, 5.38903534e-01f, -1.04483850e-01f,
  2.05791205e-01f, -1.25944182e-01f, 1.46741718e-01f, -3.10070645e-02f, -9.72978324e-02f, 1.72858350e-02f, 5.25057673e-01f, -3.27470116e-02f, -2.37030432e-01f, -9.73318368e-02f,
  5.40172994e-01f, -1.83697179e-01f, 2.16833562e-01f, -2.63726503e-01f, 2.23154142e-01f, 9.95380729e-02f, 3.32055718e-01f, 3.35520983e-01f, 6.67057112e-02f, -3.07211396e-03f,
  1.14131697e-01f, -5.55989683e-01f, -6.42713672e-03f, -1.25900671e-01f, -2.05368504e-01f, -1.74917534e-01f, -4.78174001e-01f, 3.85524817e-02f, -1.30393729e-01f, -7.75754303e-02f,
  -2.56247967e-01f, 8.40395465e-02f, 2.06523359e-01f, -9.22431797e-02f, 4.25158501e-01f, -3.19455236e-01f, 3.67776155e-01f, 2.40132466e-01f, 2.06775695e-01f, -1.18981443e-01f,
  -1.90367684e-01f, 6.26443624e-02f, -5.32276332e-01f, -2.33815432e-01f, 1.80644855e-01f, 6.94882721e-02f, 7.45479017e-02f, 3.46006185e-01f, 4.28142488e-01f, 3.15347761e-01f,
  3.25343102e-01f, 5.29219568e-01f, -1.60675794e-01f, 3.59780014e-01f, 1.26155809e-01f, 4.14841920e-01f, 5.31094074e-02f, -3.50097775e-01f, -2.00649172e-01f, 1.94324146e-03f,
  2.92751104e-01f, -7.51025304e-02f, -5.35979152e-01f, 3.99785973e-02f, -1.18471282e-02f, -1.80596396e-01f, -4.31513727e-01f, 2.82753915e-01f, -5.62999137e-02f, -5.63356094e-03f,
  -2.52168775e-01f, 2.82306992e-03f, -2.25510493e-01f, 1.72661290e-01f, -2.63766766e-01f, 3.94258410e-01f, 3.27824026e-01f, 4.84589130e-01f, -1.77361593e-02f, 1.72705829e-01f,
  2.81521469e-01f, 2.72847027e-01f, 5.24536930e-02f, 3.38335395e-01f, 4.15519103e-02f, -4.50770050e-01f, 3.13591808e-01f, 9.04594883e-02f, -2.44096383e-01f, -2.22051114e-01f,
  -1.37391612e-01f, 6.99138165e-01f, -2.43815482e-01f, -3.84254754e-01f, 7.97967985e-02f, 9.64797586e-02f, 1.04357712e-01f, 3.61870050e-01f, 2.96091616e-01f, -6.95203692e-02f,
  9.67922360e-02f, -2.72646815e-01f, 4.10681486e-01f, -7.11643219e-01f, 4.10245925e-01f, 5.28912954e-02f, -3.06669533e-01f, 1.10453822e-01f, -1.05610102e-01f, 2.18087569e-01f,
  2.14752823e-01f, -9.62112620e-02f, 2.41883770e-01f, 2.30342820e-01f, 1.15429588e-01f, 1.86443739e-02f, -4.04161781e-01f, 5.29406786e-01f, -3.80729645e-01f, 4.18881983e-01f,
  4.83618349e-01f, -6.15474954e-02f, 1.54195085e-01f, -5.01672983e-01f, 3.71254720e-02f, -1.88752443e-01f, -1.85872361e-01f, -1.47640288e-01f, 2.38567874e-01f, -4.46052849e-01f,
  1.97964534e-01f, 3.71760607e-01f, 1.52989164e-01f, 1.57738373e-01f, 1.71767816e-01f, -4.63735878e-01f, -6.13588631e-01f, 1.38341933e-01f, 1.50517821e-01f, 6.98629320e-02f,
  3.52807269e-02f, 2.93693483e-01f, 1.71400413e-01f, -4.85678017e-02f, 4.46481675e-01f, 8.42437148e-02f, 2.08365783e-01f, 1.58503326e-03f, 3.98371190e-01f, -9.04660404e-01f,
  -2.64660090e-01f, -8.23873639e-01f, 9.53064710e-02f, 6.03020668e-01f, -5.45554221e-01f, -8.83240625e-02f, -4.11881834e-01f, -2.38509849e-01f, -2.99363527e-02f, 7.39656091e-02f,
  3.85583311e-01f, -1.44413635e-01f, 3.76920849e-01f, -9.98877510e-02f, 2.55865693e-01f, 2.69943237e-01f, -3.27631712e-01f, -1.31957035e-03f, 5.67687862e-02f, 5.59386052e-02f,
  1.69114754e-01f, 3.10674787e-01f, 4.17982966e-01f, 2.99010783e-01f, 4.54697549e-01f, -6.38810322e-02f, -2.22703367e-01f, 4.09001172e-01f, -4.84209135e-02f, -4.69206661e-01f,
  -2.94995934e-01f, 5.80093563e-01f, -1.16999494e-02f, 8.89798820e-01f, -1.33341253e-01f, -4.02470738e-01f, 5.02746046e-01f, 1.78295858e-02f, 2.80215532e-01f, 7.98561871e-02f,
  5.60630202e-01f, 1.67913437e-01f, -3.38383205e-02f, 1.55569300e-01f, 7.93441162e-02f, 2.31735393e-01f, 1.75094873e-01f, 6.60807863e-02f, 3.61976892e-01f, -1.58804014e-01f,
  -8.08012560e-02f, 1.00620598e-01f, 4.06881094e-01f, -1.12004109e-01f, -1.48379225e-02f, -2.10227028e-01f, -2.16048304e-02f, 1.35879159e-01f, 3.04295924e-02f, 2.73678273e-01f,
  2.33515799e-01f, -8.45963731e-02f, -4.50221539e-01f, 6.70337200e-01f, -5.53411722e-01f, 7.21289039e-01f, 4.93466705e-01f, -1.30277053e-01f, -1.01953387e-01f, -2.22750679e-01f,
  3.27563673e-01f, -2.87172526e-01f, 1.75365284e-01f, -2.74458230e-01f, -2.42335588e-01f, -3.79158407e-01f, 3.66390914e-01f, 3.72291505e-01f, 1.80892870e-01f, 1.87605232e-01f,
  5.37514329e-01f, -2.36987278e-01f, -6.70438886e-01f, -1.11187406e-01f, 2.24479645e-01f, 2.65055299e-01f, 8.98693427e-02f, 2.68584818e-01f, 1.43795148e-01f, 2.36667648e-01f,
  -7.92176872e-02f, 2.33011827e-01f, -6.63293758e-03f, -1.18285753e-01f, -2.78475672e-01f, 8.52731615e-02f, -2.37525925e-01f, -5.90706803e-02f, 2.39164427e-01f, 9.77119729e-02f,
  2.55781502e-01f, 2.42280498e-01f, 3.22386399e-02f, -2.31778651e-01f, 3.66296083e-01f, -2.55890489e-01f, -1.22713178e-01f, -4.72078063e-02f, -4.16731536e-02f, 1.74296424e-01f,
  -2.77709633e-01f, -2.86745846e-01f, 7.61749297e-02f, -1.91328198e-01f, -1.15627207e-01f, 8.65973756e-02f, 1.10537708e-01f, 2.40346387e-01f, 5.52999824e-02f, 1.79269001e-01f,
  2.29473487e-01f, 1.16254330e-01f, 2.37834066e-01f, -2.04711676e-01f, 4.96144742e-02f, 3.32855880e-01f, 5.36295295e-01f, 2.78740585e-01f, 4.63432491e-01f, 1.67506978e-01f,
  -9.37366709e-02f, -1.07572548e-01f, -1.23571634e-01f, 4.70914751e-01f, 1.86180323e-01f, -1.69844814e-02f, 3.63559946e-02f, -4.27659117e-02f, 3.80342215e-01f, 1.40656322e-01f,
  -5.17706573e-01f, 1.47098936e-02f, 3.17307532e-01f, 1.73697934e-01f, -3.72286290e-01f, 8.67790058e-02f, 1.74447045e-01f, 6.28693998e-01f, -1.48607820e-01f, 2.36788411e-02f,
  -1.86538413e-01f, 4.18464839e-01f, 6.37865737e-02f, 2.68558592e-01f, 1.76265091e-01f, 1.37739182e-01f, 1.94587745e-02f, -4.47470546e-01f, 9.22604278e-02f, 1.10866025e-01f,
  4.47190642e-01f, -1.89587489e-01f, -7.30868205e-02f, 3.06902796e-01f, 6.78649247e-01f, 2.85835624e-01f, 1.54060528e-01f, -3.99395302e-02f, 5.34591436e-01f, 2.30605260e-01f,
  -4.78194803e-02f, 6.15771890e-01f, 1.22518264e-01f, -1.70523241e-01f, -1.32550448e-01f, -5.42679653e-02f, 3.49964678e-01f, 3.66610736e-02f, 3.09340328e-01f, 1.07117184e-02f,
  1.62802681e-01f, 5.08461632e-02f, -5.38161322e-02f, -4.11422640e-01f, 4.72004712e-01f, 1.65447414e-01f, -6.88881204e-02f, -2.63981372e-01f, -1.81826130e-01f, -9.98505950e-03f,
  1.47249579e-01f, -7.74927020e-01f, 4.06370133e-01f, -7.65472114e-01f, 4.27836090e-01f, 4.30162847e-01f, -3.85146081e-01f, 4.91677403e-01f, 1.88949406e-02f, -2.42319718e-01f,
  -3.59099030e-01f, -7.35109299e-02f, 6.92413226e-02f, 2.20090017e-01f, 8.44122726e-04f, 2.14626804e-01f, -1.27809808e-01f, 4.68862988e-02f, -3.14954072e-02f, -3.45447630e-01f,
  3.18655968e-01f, -9.82861370e-02f, -4.87249702e-01f, -6.19446337e-02f, -1.12974569e-01f, 2.67671704e-01f, 3.07908598e-02f, 1.63477033e-01f, 4.72540617e-01f, 1.53018788e-01f,
  2.13066921e-01f, 8.26046392e-02f, 4.32935596e-01f, -1.16999209e-01f, 2.06747323e-01f, -6.54200241e-02f, -3.74446601e-01f, 2.10780561e-01f, -6.38463438e-01f, 3.24830890e-01f,
  3.18493210e-02f, -4.08444911e-01f, -2.82700866e-01f, 1.50198177e-01f, 1.93933085e-01f, 2.65402198e-01f, -1.14340149e-01f, 1.11182854e-01f, 4.98068124e-01f, 4.09367681e-01f,
  -8.83376673e-02f, -1.52018189e-01f, 5.02200685e-02f, 4.57505345e-01f, -3.58938366e-01f, 1.36351421e-01f, 6.52961731e-02f, 4.07175779e-01f, -7.33795995e-03f, 2.94581175e-01f,
  1.97965682e-01f, 9.29699540e-02f, 4.00355458e-01f, 3.69208366e-01f, -3.10350865e-01f, -4.59519565e-01f, -3.38759661e-01f, -1.40407071e-01f, 1.60606310e-01f, 3.55558604e-01f,
  -1.22580834e-01f, 4.31295931e-02f, 1.45559967e-01f, 1.36799663e-01f, 4.85256650e-02f, -1.68515965e-01f, -6.85387373e-01f, -2.24786084e-02f, 3.98728818e-01f, 2.51191795e-01f,
  1.29192561e-01f, 1.62370801e-01f, 2.31332883e-01f, 2.94307083e-01f, 3.91095877e-01f, -1.87990203e-01f, 1.89394370e-01f, 3.71535927e-01f, -3.34920228e-01f, -5.49552999e-02f,
  4.01321858e-01f, -3.83983739e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  2.44584270e-02f, 2.87972633e-02f, 1.31822109e-01f, 3.38729471e-01f, 2.51585931e-01f, 5.69169670e-02f, 2.69685924e-01f, 1.78036541e-01f, 4.15015548e-01f, -1.11092310e-02f,
  -7.14401528e-03f, -9.82178524e-02f, 5.22685237e-02f, 1.60756931e-01f, 3.25715959e-01f, 1.08706146e-01f, 1.42004445e-01f, 1.05051704e-01f, 2.65524127e-02f, 2.96649784e-01f,
  2.35901311e-01f, 1.54587045e-01f, 1.28275929e-02f, -1.44778922e-01f, 3.01627845e-01f, 1.75103247e-02f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -6.21235296e-02f, -2.11538106e-01f, 3.60127985e-02f, -6.25919327e-02f, -9.02397037e-02f, 4.12093401e-01f, 3.46799552e-01f, -3.21781263e-02f, -9.52250585e-02f, -4.25556719e-01f,
  -6.08492419e-02f, 1.41394874e-02f, 1.00556433e-01f, 2.55739152e-01f, -4.19315875e-01f, 2.06452623e-01f, -4.46609557e-01f, 1.82032838e-01f, 2.13414595e-01f, -1.52417347e-01f,
  -6.02468491e-01f, 3.54551040e-02f, -3.18886787e-01f, -9.39421579e-02f, 4.05600429e-01f, -3.33515376e-01f, -5.28969109e-01f, 2.20715284e-01f, 2.49826729e-01f, -2.87768602e-01f,
  -3.26641239e-02f, -5.29008567e-01f, -4.47782390e-02f, -1.35535389e-01f, -3.72688562e-01f, -4.50578690e-01f, 2.02501789e-02f, 2.12698296e-01f, 1.04443416e-01f, -1.37323439e-01f,
  -7.98080087e-01f, 6.21832311e-02f, 2.05631644e-01f, -3.81952554e-01f, 3.05516601e-01f, 3.00200284e-01f, -7.20166743e-01f, -2.68308848e-01f, -3.99281502e-01f, 1.59593135e-01f,
  2.76750118e-01f, -2.55174994e-01f, -2.91609466e-02f, -2.61419743e-01f, 2.01342359e-01f, 2.80164350e-02f, 2.23794952e-01f, 2.95643121e-01f, 2.23881662e-01f, -2.65760094e-01f,
  2.10371256e-01f, -2.34733194e-01f, -3.76431495e-01f, -5.07184712e-04f, 3.35475117e-01f, -1.33153424e-01f, 3.60601693e-01f, -1.46106899e-01f, 3.96035880e-01f, 3.73649120e-01f,
  -1.38957515e-01f, -5.79512358e-01f, 3.76617998e-01f, -4.98536676e-01f, -2.14127168e-01f, 2.84597516e-01f, 4.30194736e-01f, -8.84709597e-01f, -3.44802469e-01f, -2.83655018e-01f,
  -1.06531000e-02f, 2.41498262e-01f, 4.44979548e-01f, -5.79064608e-01f, -3.23818445e-01f, 2.59806156e-01f, 2.15331182e-01f, -5.86057268e-02f, 1.81156024e-01f, 4.00651172e-02f,
  -2.14196727e-01f, -4.32781428e-01f, 2.63360262e-01f, -1.50769502e-01f, -4.54182178e-01f, -5.06509006e-01f, -1.76918611e-01f, -2.36792251e-01f, 5.49468249e-02f, 1.00291848e-01f,
  2.10602149e-01f, 8.39209855e-02f, 1.31619303e-02f, 4.51969877e-02f, -1.97536666e-02f, -5.26450932e-01f, 4.94601503e-02f, 1.81474388e-01f, 1.98838696e-01f, -9.19748563e-03f,
  1.91541493e-01f, 2.26531550e-01f, -5.32480776e-01f, 1.08889870e-01f, -4.87230390e-01f, 2.75574535e-01f, -2.97567397e-01f, 1.83016241e-01f, -7.40133405e-01f, 2.76168585e-01f,
  -2.98998833e-01f, -8.40376139e-01f, -2.80331224e-01f, 6.31935373e-02f, 1.15198139e-02f, 3.78439873e-01f, 2.21379876e-01f, -3.09701979e-01f, -1.50603026e-01f, -1.52163133e-01f,
  -2.03934282e-01f, -1.73460960e-01f, -1.93089649e-01f, -4.22675550e-01f, 8.75110254e-02f, 1.66752145e-01f, 1.25906363e-01f, -2.96439976e-01f, -5.39726734e-01f, 1.56138837e-01f,
  -1.14088960e-01f, -3.22777987e-01f, 6.54422939e-02f, 2.12364271e-01f, -3.32720354e-02f, 2.48340279e-01f, -1.45332575e-01f, 2.22081348e-01f, 3.65285218e-01f, -2.05252975e-01f,
  1.60531580e-01f, 1.09557658e-01f, -3.82300909e-03f, -1.81197047e-01f, -4.02862877e-01f, 7.64672309e-02f, -1.55464903e-01f, -4.31749493e-01f, 1.39008865e-01f, -2.39377134e-02f,
  1.25279389e-02f, 1.69889539e-01f, 5.55431545e-01f, -2.01348692e-01f, 3.26688290e-01f, 1.18540332e-01f, -5.30532956e-01f, -6.85147149e-03f, -2.84310549e-01f, 2.00281441e-01f,
  7.43123069e-02f, -2.23490782e-02f, -2.01553524e-01f, 1.59516528e-01f, 3.44233930e-01f, 2.64460415e-01f, 4.08775844e-02f, -1.54787637e-02f, -7.99413472e-02f, 3.15577805e-01f,
  -1.31933972e-01f, 4.28344756e-01f, -2.87593179e-03f, -1.09718606e-01f, 1.75563529e-01f, 2.75957853e-01f, -2.07713306e-01f, -2.43744656e-01f, -1.06790014e-01f, -4.04120386e-01f,
  -8.79524648e-03f, 2.18711942e-01f, -4.55967605e-01f, 1.18577518e-01f, -2.64317125e-01f, 3.83484304e-01f, 7.83203319e-02f, -2.01445669e-01f, -5.02733767e-01f, -7.86199510e-01f,
  1.58782214e-01f, 2.10355759e-01f, -5.64096928e-01f, -5.75170070e-02f, -3.65551203e-01f, -2.45591283e-01f, -5.17970145e-01f, -1.42090589e-01f, 3.18433672e-01f, -4.28470880e-01f,
  9.90354791e-02f, -1.48662582e-01f, 1.97895855e-01f, -6.99162602e-01f, 3.80562484e-01f, -4.60699141e-01f, 1.05953634e-01f, 3.44824642e-01f, 1.29583627e-01f, -7.49127984e-01f,
  -5.25847673e-01f, -2.62932122e-01f, -8.31890881e-01f, 2.83775888e-02f, 1.80312261e-01f, 2.88506567e-01f, -2.71352883e-02f, -4.91727777e-02f, -3.44285578e-01f, 1.19070373e-01f,
  1.04628429e-01f, -8.46593976e-02f, 3.12879473e-01f, 1.62441850e-01f, 2.78627813e-01f, -3.76933932e-01f, 2.07546912e-02f, -2.05213100e-01f, -1.91879675e-01f, -1.42527014e-01f,
  -3.67431492e-01f, 2.42946036e-02f, -4.52482402e-01f, -7.49110878e-01f, 1.24444649e-01f, 2.58361250e-01f, -3.56259495e-01f, -3.89954031e-01f, -2.41336286e-01f, -4.26893085e-01f,
  9.81357843e-02f, 5.13328969e-01f, 2.25099608e-01f, 4.68215197e-01f, 3.18185613e-02f, 3.03727463e-02f, -3.25958133e-02f, -6.73947260e-02f, 5.35577655e-01f, -1.11625701e-01f,
  -2.55213201e-01f, -3.77432287e-01f, -2.96969891e-01f, 3.39682519e-01f, 3.62168737e-02f, -6.56818524e-02f, 4.50723469e-01f, -5.89057565e-01f, -2.02173978e-01f, -3.38938832e-01f,
  4.25582319e-01f, -4.42337930e-01f, 1.29814476e-01f, -4.12730753e-01f, -1.17497273e-01f, -6.47664011e-01f, -3.64271969e-01f, -8.77315328e-02f, -4.06428218e-01f, 4.58071291e-01f,
  -3.88780653e-01f, -4.14089233e-01f, -2.68241065e-03f, -3.74355048e-01f, 1.81666896e-01f, -8.25025290e-02f, -1.44817010e-01f, 2.87056059e-01f, 3.31220508e-01f, 3.85549426e-01f,
  5.97805977e-01f, 9.08624887e-01f, 4.12244469e-01f, -6.33498207e-02f, 1.76975623e-01f, -3.79027754e-01f, 1.84689954e-01f, 1.55543517e-02f, -2.20279366e-01f, 1.03067912e-01f,
  3.10305327e-01f, -4.66123462e-01f, -1.03371590e-01f, -8.58274579e-01f, 1.05621383e-01f, -2.06890270e-01f, -2.94633061e-01f, -6.23958349e-01f, 4.68047380e-01f, 8.72636065e-02f,
  5.01591265e-02f, -3.75432163e-01f, 1.30317912e-01f, 1.21988960e-01f, -2.41333898e-02f, 4.31589842e-01f, -4.88175482e-01f, -2.67925054e-01f, 2.90226579e-01f, -4.65501219e-01f,
  -1.72763750e-01f, 8.66628662e-02f, -1.11085691e-01f, 9.63247344e-02f, -6.35117218e-02f, -2.05129117e-01f, -2.08876774e-01f, 1.94900826e-01f, -7.17263341e-01f, -3.42119902e-01f,
  2.00872093e-01f, -5.31003363e-02f, -8.97968590e-01f, 4.05310899e-01f, 1.64427355e-01f, 1.58330902e-01f, -1.01363778e-01f, -6.38536990e-01f, -6.21331394e-01f, 3.03023830e-02f,
  -2.16618612e-01f, -4.73137081e-01f, 1.07414529e-01f, 3.45502913e-01f, -6.26853466e-01f, -1.33748576e-01f, -3.98993015e-01f, 4.65303570e-01f, -6.30645692e-01f, 2.61470735e-01f,
  3.65369946e-01f, -2.44277507e-01f, 3.18335772e-01f, 1.99735574e-02f, -3.95592928e-01f, -4.65107143e-01f, -2.17256770e-01f, -4.58839983e-02f, -1.72828034e-01f, -1.64275125e-01f,
  4.11911696e-01f, -1.39759719e-01f, 1.27570972e-01f, 7.19969645e-02f, -2.34495774e-01f, -6.82143152e-01f, -6.13368489e-02f, -4.21505034e-01f, 3.76365721e-01f, -4.48985547e-01f,
  -2.24612474e-01f, -1.55527651e-01f, -2.42566913e-01f, 4.98292670e-02f, 3.82549942e-01f, 3.76817584e-01f, -4.69491869e-01f, 1.53352857e-01f, 1.92973331e-01f, -3.31804305e-01f,
  -2.06299111e-01f, 2.63887793e-01f, -1.68598399e-01f, 8.60348418e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.02973543e-01f, 1.57857537e-01f, -5.82516054e-03f, -6.84361951e-03f, 7.77864875e-03f, -4.74874377e-02f, 4.51802574e-02f, -1.68205336e-01f, 1.62153617e-02f, 2.98051119e-01f,
  1.03553468e-02f, -2.17745584e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    