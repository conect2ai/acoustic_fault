/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -7.89527953e-01f, 3.22818458e-01f, -4.25718911e-02f, 8.54632482e-02f, -4.06515934e-02f, -2.92462379e-01f, -5.97734638e-02f, 9.72654745e-02f, -1.18374145e-02f, 1.33448616e-01f,
  -4.87064458e-02f, -1.31807670e-01f, -1.02530785e-01f, 2.63056788e-03f, -1.66433990e-01f, 5.31188808e-02f, 1.30591944e-01f, -1.59505576e-01f, -4.73714143e-01f, -1.22959502e-01f,
  1.10021092e-01f, 1.44840598e-01f, 1.56980529e-01f, 4.78683561e-02f, 2.81097919e-01f, -8.50710422e-02f, 3.18685681e-01f, 1.01981908e-01f, -3.59414034e-02f, 3.54456872e-01f,
  -1.03336491e-01f, -1.44138753e-01f, -1.87367111e-01f, -4.86137271e-02f, 9.81149003e-02f, -9.01134126e-03f, -1.59765482e-02f, 4.76745814e-02f, -4.39124405e-02f, 9.06253159e-02f,
  1.61931030e-02f, -2.17223503e-02f, -1.82937272e-02f, 5.58239259e-02f, 3.08967829e-02f, 6.16211779e-02f, 8.41972008e-02f, 8.01816210e-03f, -5.00002019e-02f, 5.67212477e-02f,
  2.66035330e-02f, -1.13564380e-01f, -1.35416582e-01f, 4.71952781e-02f, -1.06029667e-01f, -7.43191168e-02f, 3.89702283e-02f, 3.77368294e-02f, -1.15251079e-01f, 2.18881801e-01f,
  7.91886938e-04f, 6.05467567e-03f, -5.31283021e-03f, -4.83368263e-02f, 3.43248732e-02f, -3.37844342e-02f, -1.52000440e-02f, -3.22852135e-02f, 1.96178555e-02f, 5.71086910e-03f,
  2.34932583e-02f, -3.03496290e-02f, 4.54463139e-02f, 1.03717614e-02f, 2.47195996e-02f, -1.96983330e-02f, 4.77621891e-02f, 4.23379540e-02f, 8.19146167e-04f, 4.58687209e-02f,
  -2.39565596e-02f, -4.97572422e-02f, -2.85702273e-02f, 8.70409906e-02f, -6.06184499e-03f, -4.18691821e-02f, -6.48503676e-02f, 4.79005389e-02f, 3.04005500e-02f, -5.84993698e-02f,
  1.85370818e-01f, -1.48415104e-01f, 1.47897974e-02f, -5.33246808e-02f, 6.13114908e-02f, 1.07798345e-01f, -2.63849869e-02f, 7.89068360e-03f, 2.45716013e-02f, 6.59567341e-02f,
  -6.13854602e-02f, -2.79810727e-02f, 5.41497506e-02f, 1.15008272e-01f, -3.19018699e-02f, -6.38894783e-03f, 7.28315264e-02f, -1.05569251e-01f, -1.03004482e-02f, 9.67564657e-02f,
  1.21507250e-01f, 3.81482877e-02f, -1.65852517e-01f, -1.41745396e-02f, -1.73588621e-03f, -2.08398521e-01f, 3.41857150e-02f, -1.03200916e-02f, -2.27515429e-01f, 2.35128149e-01f,
  -3.43799353e-01f, -1.94274783e-01f, 3.11377615e-01f, 4.83844914e-02f, -1.37800515e-01f, -1.54100075e-01f, -4.14098918e-01f, -2.01778024e-01f, -6.64812420e-03f, -2.00316697e-01f,
  -3.39677669e-02f, 1.20292157e-01f, -1.91809107e-02f, 4.69459547e-03f, -1.33220432e-03f, -2.41897747e-01f, 2.35357098e-02f, 3.21514487e-01f, 1.53934896e-01f, -1.46305025e-01f,
  -1.47323251e-01f, 1.87309280e-01f, 3.20382386e-01f, 1.72332048e-01f, 3.37885902e-03f, -2.63164304e-02f, 1.27911791e-01f, 2.21404731e-01f, 1.02946557e-01f, 1.36829093e-01f,
  5.09982891e-02f, -1.60625987e-02f, 7.55695719e-03f, 5.54923937e-02f, 1.37921721e-01f, 5.38277663e-02f, -3.17698494e-02f, 2.03603178e-01f, 1.03658959e-01f, 2.24696584e-02f,
  7.86881149e-02f, 1.03695549e-01f, 1.00362837e-01f, 4.00651768e-02f, 5.56005985e-02f, 9.02983844e-02f, 1.50991604e-01f, 1.65105805e-01f, 4.09180708e-02f, -7.28308177e-03f,
  2.32971348e-02f, 1.71590567e-01f, 1.38651311e-01f, 1.44640198e-02f, 6.53826818e-02f, 7.03409761e-02f, 1.06442347e-01f, 2.03118533e-01f, 1.66050136e-01f, 8.77043679e-02f,
  -1.95740256e-02f, -8.50003585e-03f, 4.63844948e-02f, -2.91039813e-02f, -9.87281203e-02f, 7.23148882e-03f, 2.27758400e-02f, -5.13980016e-02f, 3.06768287e-02f, -4.48018163e-02f,
  1.75001565e-02f, -2.89827678e-03f, 7.27074519e-02f, -1.16250701e-01f, 5.89125678e-02f, 4.64405566e-02f, -6.41794875e-02f, -3.09586129e-03f, -1.17201572e-02f, 5.31670544e-03f,
  7.41107762e-02f, -2.10787673e-02f, 6.43704236e-02f, 1.38780344e-02f, -2.05461099e-03f, -1.40928430e-02f, -1.01325668e-01f, 5.43298572e-02f, -2.97290497e-02f, -3.03591378e-02f,
  -9.48417485e-02f, 1.36366310e-02f, -1.27237380e-01f, -5.10452278e-02f, -1.62586309e-02f, 1.06487110e-04f, 4.49443497e-02f, -3.80242169e-02f, -3.17072705e-03f, -7.93646183e-03f,
  7.11404253e-03f, -4.03101034e-02f, -5.46492171e-03f, 1.03232354e-01f, -6.71525253e-04f, -6.56421110e-02f, -1.17982335e-01f, -1.52003318e-01f, 3.43980081e-02f, -3.80173735e-02f,
  -8.07661638e-02f, -1.63636193e-01f, -1.88498318e-01f, -1.61630005e-01f, -6.54229373e-02f, -1.38639718e-01f, -8.54350105e-02f, -1.35197073e-01f, -1.67021364e-01f, -4.95584369e-01f,
  8.45966101e-01f, 1.71018973e-01f, -3.52884114e-01f, 3.78648520e-01f, -3.11164051e-01f, -2.64343590e-01f, -4.71146286e-01f, 1.15714237e-01f, 1.11806743e-01f, 6.02014065e-02f,
  3.77823301e-02f, 1.32160231e-01f, 1.67183787e-01f, 1.50572181e-01f, -1.17682898e-02f, -2.73614317e-01f, -1.43542737e-01f, 1.15948487e-02f, -3.18670601e-01f, -2.77633667e-01f,
  -1.50525227e-01f, 2.29550943e-01f, 5.62661946e-01f, 1.82546616e-01f, 8.90841428e-03f, -2.06158504e-01f, -3.25121358e-02f, 1.42906427e-01f, -1.71664208e-01f, 1.05662249e-01f,
  -8.72211829e-02f, 1.55360550e-01f, -6.06857501e-02f, 9.13952515e-02f, -6.19633868e-02f, 7.03163669e-02f, -1.12611249e-01f, 8.33393484e-02f, 1.40984100e-03f, 8.32590461e-02f,
  1.87639371e-02f, 7.25975558e-02f, -3.79333273e-02f, 2.58038212e-02f, 3.84028777e-02f, 4.14344519e-02f, 9.23996121e-02f, 1.24119133e-01f, 5.20833507e-02f, -4.66205440e-02f,
  3.14209759e-02f, -1.56480484e-02f, -6.65386915e-02f, -6.94104731e-02f, -3.82426716e-02f, 1.08858775e-02f, -2.25167852e-02f, 4.39662077e-02f, 3.70895229e-02f, 1.22231022e-01f,
  2.99728569e-02f, 3.55341397e-02f, -5.53594865e-02f, -4.08998728e-02f, 1.46180894e-02f, -1.49803134e-02f, -3.46651487e-02f, -1.91142671e-02f, -3.45577747e-02f, -8.08078125e-02f,
  1.98370460e-02f, 1.46701010e-02f, 6.36699144e-03f, -5.25350031e-03f, -1.72267621e-03f, -2.33588996e-03f, -7.41327479e-02f, 6.75679892e-02f, 3.93312909e-02f, 8.96505415e-02f,
  6.74650595e-02f, -6.61819577e-02f, 2.88192239e-02f, -4.91034798e-02f, -2.03489866e-02f, 2.53258906e-02f, -2.87593640e-02f, -2.52857804e-02f, 2.37077326e-02f, 5.29607646e-02f,
  -4.55980636e-02f, 5.91339767e-02f, 4.61508147e-02f, 4.83253635e-02f, -2.36678235e-02f, 2.64452752e-02f, -1.32457120e-02f, 9.41139311e-02f, -3.82341966e-02f, 3.65872942e-02f,
  1.49119627e-02f, -1.75348409e-02f, -2.75880657e-02f, 1.40838716e-02f, -6.24210350e-02f, -3.46830077e-02f, 2.88149044e-02f, -9.56611633e-02f, 7.24040717e-02f, 5.01049459e-02f,
  4.47375476e-02f, -2.76142247e-02f, -7.04902932e-02f, -2.09324509e-02f, 2.75608082e-03f, -9.72348750e-02f, -1.75385639e-01f, -6.91868812e-02f, -1.34354338e-01f, -9.28152949e-02f,
  3.76989156e-01f, -4.14086223e-01f, 2.62835920e-01f, 4.34788436e-01f, 1.87073559e-01f, -3.79630434e-03f, -1.42716974e-01f, -8.56601596e-02f, -1.85777284e-02f, 1.25207335e-01f,
  -7.70112649e-02f, 1.29017934e-01f, 1.72724813e-01f, -1.19832791e-01f, -1.97148219e-01f, 1.48718253e-01f, 1.62353501e-01f, 1.76793873e-01f, 3.11213374e-01f, 4.37047854e-02f,
  7.16341138e-02f, 1.84445232e-01f, 6.97576702e-02f, -8.91999602e-02f, 8.86499658e-02f, 1.90087214e-01f, 3.20670451e-03f, 7.32600540e-02f, -2.81087518e-01f, 5.60577363e-02f,
  3.52396131e-01f, -2.93661684e-01f, 8.53692293e-02f, -3.46849635e-02f, -5.09423055e-02f, -3.95980105e-02f, -2.67932881e-02f, -1.67903714e-02f, -6.57538623e-02f, 4.09926921e-02f,
  4.32230122e-02f, -3.62976715e-02f, 6.32534698e-02f, 3.34656276e-02f, -3.79968697e-04f, 6.99568838e-02f, -8.68364573e-02f, 1.98521521e-02f, -5.75229004e-02f, 5.81413433e-02f,
  -9.23278406e-02f, 7.95393530e-03f, -1.10662738e-02f, -1.02880344e-01f, -8.83301720e-02f, -7.43209571e-02f, -1.94964081e-01f, -1.20866083e-01f, -6.20698966e-02f, -1.36481807e-01f,
  3.03262398e-02f, -1.13957012e-02f, 3.70108262e-02f, -2.45782696e-02f, 7.30583817e-02f, 5.65990731e-02f, -1.97870433e-02f, 6.99201301e-02f, -5.94398379e-02f, 1.16389103e-01f,
  6.11597439e-03f, -2.48776097e-02f, -8.98703374e-03f, -2.74259932e-02f, -5.67697622e-02f, 7.65985344e-03f, -3.78182046e-02f, 7.41379708e-02f, -1.31243855e-01f, 2.03644130e-02f,
  -4.31947857e-02f, -5.72894653e-03f, 4.75226715e-02f, -8.45561028e-02f, -5.71007580e-02f, -4.49773343e-03f, 8.95288885e-02f, -6.32153377e-02f, 4.60949987e-02f, 3.40019204e-02f,
  1.45000592e-01f, -2.84067124e-01f, 1.29133850e-01f, -5.36536332e-04f, 1.48401018e-02f, -2.88380049e-02f, -1.62921008e-02f, -3.52034196e-02f, -5.72030209e-02f, -7.78293284e-03f,
  -1.00492723e-02f, 1.17227072e-02f, -4.91359122e-02f, -5.64185642e-02f, 1.54735558e-02f, -3.77283469e-02f, 6.36440888e-02f, 8.41396078e-02f, -9.41074565e-02f, -9.18442905e-02f,
  6.44492730e-02f, 6.34940788e-02f, 1.16821773e-01f, 8.08236152e-02f, -2.12074071e-03f, 6.39336333e-02f, -3.58427782e-03f, 5.88187687e-02f, 6.44422919e-02f, 2.12742403e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  7.68674165e-02f, 1.62465915e-01f, 2.36633971e-01f, -7.36132637e-02f, 2.99419254e-01f, 1.66197434e-01f, 7.68998206e-01f, 9.63533521e-02f, -3.10634792e-01f, 1.89391777e-01f,
  1.02337360e-01f, -4.66266870e-01f, -3.04724246e-01f, -4.03343529e-01f, 8.31360593e-02f, 5.32841496e-02f, 8.91061947e-02f, -1.10722343e-02f, -3.46661180e-01f, -6.73983172e-02f,
  1.02049462e-01f, 1.79680765e-01f, -7.09544793e-02f, -3.94864768e-01f, -3.22150700e-02f, -4.65699673e-01f, -4.06906866e-02f, 2.64630169e-01f, 3.64882872e-02f, 3.28069963e-02f,
  1.35652602e-01f, 1.74325496e-01f, -2.92095602e-01f, -2.68955618e-01f, 5.52129447e-02f, -1.46959096e-01f, -7.61186555e-02f, -9.46114361e-02f, 1.43840350e-02f, -1.01563141e-01f,
  5.58203347e-02f, 1.04816593e-01f, 2.21182108e-01f, 1.84295937e-01f, 2.29106173e-01f, 1.04577139e-01f, 5.31754009e-02f, 5.80338910e-02f, 1.90293882e-02f, -2.24159472e-03f,
  1.22686140e-01f, 2.07398534e-01f, 3.20187539e-01f, 5.40742986e-02f, 2.96945751e-01f, -9.34612080e-02f, 1.51828140e-01f, 1.18307486e-01f, 6.81706145e-02f, -2.38332391e-01f,
  -6.54296055e-02f, -7.76070729e-02f, -4.46270294e-02f, 5.52975498e-02f, -3.00118998e-02f, -6.62948415e-02f, 3.26190367e-02f, 4.48217578e-02f, 1.16341226e-02f, -1.37338750e-02f,
  -6.64431974e-02f, 1.00299343e-01f, -9.12331138e-03f, 9.27564315e-03f, -1.17250398e-01f, 1.80337906e-01f, 6.86999932e-02f, 9.04292539e-02f, 1.07775554e-02f, -1.97223015e-02f,
  -1.50716469e-01f, 1.40750602e-01f, -1.95256900e-02f, 5.28226532e-02f, 1.37862191e-01f, -1.05806487e-02f, -4.42186370e-02f, 5.78430435e-03f, 2.26314794e-02f, -7.01253163e-03f,
  -2.50654250e-01f, 1.95334807e-01f, -2.13267133e-01f, -2.52683371e-01f, 3.77456360e-02f, -1.21715076e-01f, 3.50572839e-02f, 4.40646410e-02f, 1.08342975e-01f, 8.48892555e-02f,
  -2.21333280e-02f, -1.58392638e-01f, 1.69810936e-01f, 1.00462334e-02f, -1.67211089e-02f, 6.65560439e-02f, -7.49001428e-02f, -1.46185234e-01f, -5.40451966e-02f, 1.09355502e-01f,
  -8.09413046e-02f, -3.98656815e-01f, -4.65453774e-01f, -2.37676844e-01f, -2.51908511e-01f, -3.97045791e-01f, -5.31242564e-02f, -1.73561275e-01f, -6.73022792e-02f, -3.29687476e-01f,
  -3.48881841e-01f, -1.85172781e-01f, -9.94913187e-03f, -2.09413795e-03f, 4.93785739e-02f, 8.31082016e-02f, -5.91202140e-01f, 1.90648958e-01f, 2.58879483e-01f, -3.56446147e-01f,
  2.62690317e-02f, 1.92941889e-01f, -7.92601556e-02f, -2.22320687e-02f, -1.81823298e-01f, -3.41750205e-01f, -4.14103746e-01f, -1.82765990e-01f, 3.29270542e-01f, 4.54417914e-01f,
  -8.06340948e-03f, -3.14595997e-02f, 2.64100969e-01f, 1.82574823e-01f, -9.89077911e-02f, -1.28796941e-03f, -2.05602005e-01f, -4.35079634e-02f, -2.57011533e-01f, -6.39479220e-01f,
  -2.19283938e-01f, -9.82748047e-02f, 7.91666135e-02f, -1.19220302e-01f, -2.36460585e-02f, -1.07813455e-01f, -1.06533961e-02f, -6.56423271e-02f, 1.25985481e-02f, -2.78747864e-02f,
  -2.91913096e-02f, 6.88740686e-02f, 4.09494825e-02f, 1.23887789e-02f, 6.27798513e-02f, 8.55232552e-02f, 2.50067174e-01f, 1.84015781e-01f, 4.81465645e-03f, -1.76274002e-01f,
  -1.94056526e-01f, -5.20053059e-02f, 1.54060706e-01f, 9.55102891e-02f, 2.00430885e-01f, 6.59694150e-02f, 1.44562960e-01f, 1.98954210e-01f, 1.42809942e-01f, -1.35061190e-01f,
  1.88968778e-02f, 4.31268755e-03f, 8.95907208e-02f, -7.57033285e-03f, -6.33729994e-02f, -2.19847430e-02f, -5.12191989e-02f, -8.31559524e-02f, -8.38790312e-02f, 5.45450114e-02f,
  1.43333133e-02f, -7.91969709e-03f, 7.48715848e-02f, -1.20448805e-02f, -4.56706025e-02f, -1.30910929e-02f, -2.95602437e-02f, -1.52027393e-02f, -9.56814736e-02f, 4.48805355e-02f,
  1.89115349e-02f, 8.75058845e-02f, 9.29015875e-02f, 1.34772524e-01f, -1.10828079e-01f, 4.11954932e-02f, -8.02046955e-02f, 5.98533265e-03f, -3.57626863e-02f, -8.22509527e-02f,
  3.45282513e-03f, 1.78365350e-01f, -2.97469586e-01f, 2.74086613e-02f, -9.05928761e-02f, -3.11833853e-03f, -1.49457037e-01f, 2.05390863e-02f, -6.89582899e-02f, 8.36765394e-02f,
  -3.66533138e-02f, -1.02872578e-02f, -5.90986945e-02f, 4.86123264e-02f, 5.36521748e-02f, 1.11831222e-02f, -9.49970931e-02f, -1.50896683e-01f, 4.96716537e-02f, 5.16714267e-02f,
  4.69274670e-02f, -2.45298907e-01f, -2.30077296e-01f, -1.38728470e-01f, -4.23708446e-02f, -3.49849224e-01f, -3.04625958e-01f, -1.67151690e-01f, -2.21587911e-01f, -4.36973095e-01f,
  -3.31044078e-01f, -5.36180377e-01f, -1.64474308e-01f, -6.34247601e-01f, 1.58094049e-01f, 4.08580482e-01f, 4.14915048e-02f, 2.58305669e-01f, 1.26852080e-01f, -2.38803864e-01f,
  -2.67258644e-01f, -8.91855732e-02f, -4.66287583e-01f, -1.03999309e-01f, -3.42171267e-02f, -4.65513431e-02f, -3.07375729e-01f, -2.74048209e-01f, 4.98571366e-01f, 7.80649126e-01f,
  2.73780346e-01f, -3.47556561e-01f, -2.98790872e-01f, 5.83766121e-03f, -1.92155212e-01f, 6.45469800e-02f, -5.91097236e-01f, -3.92115265e-01f, 2.83700705e-01f, -6.74696445e-01f,
  -1.17935687e-02f, -1.81167111e-01f, 1.07341044e-01f, -1.10131398e-01f, -2.20337987e-01f, 1.50625929e-02f, 9.13108606e-03f, -1.70588732e-01f, 6.49439022e-02f, -1.41810244e-02f,
  -2.06859037e-01f, 1.20618507e-01f, -6.58728108e-02f, 3.63525786e-02f, -3.22616287e-02f, 1.87595692e-02f, -1.84988547e-02f, -3.48275229e-02f, -9.67908092e-03f, 5.12966029e-02f,
  -1.61260758e-02f, 8.99643824e-03f, 1.22542113e-01f, 1.30375326e-01f, 7.61632100e-02f, -8.28880295e-02f, 1.29720205e-02f, 1.41601458e-01f, 1.53339952e-01f, -9.42949876e-02f,
  -1.91067476e-02f, -1.18593574e-02f, 7.36042634e-02f, 3.30849849e-02f, 1.18902862e-01f, 4.01562750e-02f, -2.18614265e-02f, 2.36942954e-02f, 4.81302813e-02f, -6.40501082e-02f,
  2.68540028e-02f, -2.92118639e-02f, 2.67326599e-03f, 7.19725341e-03f, -5.67435250e-02f, -7.50393793e-02f, 4.21622619e-02f, 3.04321628e-02f, 1.44007914e-02f, -4.78101522e-02f,
  -4.22822610e-02f, 1.01184659e-01f, -1.78019688e-01f, 3.11638415e-03f, 2.43291315e-02f, -7.64567256e-02f, 6.17816625e-03f, -2.44126171e-02f, 1.54771274e-02f, 1.13839984e-01f,
  -1.54947519e-01f, -1.09446883e-01f, -2.34326452e-01f, -1.83817241e-02f, -1.78964110e-03f, 7.89992139e-03f, -1.81057453e-01f, 3.56938429e-02f, -1.56620860e-01f, 7.68132880e-02f,
  2.60587223e-02f, -7.98419714e-02f, -1.36686489e-01f, -4.94914502e-02f, 4.86793891e-02f, 1.45861775e-01f, -1.12638265e-01f, -6.33745864e-02f, -2.58840937e-02f, 7.90016204e-02f,
  -9.61702541e-02f, 1.28567070e-01f, 7.15918019e-02f, 1.26983970e-01f, 5.50870299e-02f, 1.82957873e-01f, 8.59284326e-02f, 7.72728622e-02f, 8.66313949e-02f, 1.17659412e-01f,
  1.94849044e-01f, -3.22835922e-01f, 6.64986372e-01f, 5.01343012e-01f, 5.55428743e-01f, 4.37797189e-01f, 4.73840982e-01f, 2.03471288e-01f, 2.04363719e-01f, 2.02649817e-01f,
  1.05078164e-02f, -1.41254172e-01f, -2.66777277e-01f, -2.64361084e-01f, -1.02446759e-02f, 3.06059867e-01f, 3.45939100e-01f, -2.62986659e-03f, 1.79744288e-01f, 2.35879570e-01f,
  -1.23338863e-01f, -1.07499383e-01f, -2.78647363e-01f, -6.90178201e-02f, 4.39672731e-02f, 7.74087384e-02f, -3.13261561e-02f, -9.91273522e-02f, -9.89990607e-02f, -1.12095125e-01f,
  4.25192621e-03f, 1.01990573e-01f, 1.11277722e-01f, -1.89379081e-02f, 4.09722403e-02f, -2.22512931e-01f, 3.07405218e-02f, -6.75569251e-02f, -2.27562543e-02f, 1.89099293e-02f,
  5.30105382e-02f, -5.62366620e-02f, 3.75768356e-02f, -7.91696161e-02f, 9.19889733e-02f, 9.82967690e-02f, -4.97196130e-02f, -4.96223085e-02f, 8.44837651e-02f, -1.84503850e-02f,
  -3.96791212e-02f, 1.30457059e-01f, 3.25503081e-01f, 1.87961802e-01f, 1.34902656e-01f, 3.57701257e-02f, 2.97389980e-02f, -3.40807959e-02f, 1.93827182e-01f, -1.77382492e-02f,
  1.16208792e-01f, -6.56661615e-02f, -2.49165716e-03f, 3.91884595e-02f, -1.09632850e-01f, -1.43326908e-01f, -3.96549925e-02f, -2.41474938e-02f, -7.32741132e-02f, 1.43396668e-02f,
  6.13142513e-02f, 1.49146002e-02f, -2.20236909e-02f, 1.40435174e-01f, -4.18169647e-02f, 2.05896925e-02f, 7.52252713e-02f, -3.30294445e-02f, 3.40915807e-02f, 8.96788388e-02f,
  -3.60579304e-02f, -3.50830629e-02f, -9.92830694e-02f, -7.25174248e-02f, -3.95546407e-02f, -1.18340366e-02f, 5.76600619e-02f, 5.20207314e-03f, -1.99180245e-02f, -7.86693096e-02f,
  -3.51333290e-01f, 8.39518607e-02f, 9.69032664e-03f, 1.62401237e-02f, 1.16704196e-01f, -1.24513954e-01f, 3.87325091e-03f, 1.19077405e-02f, -5.91046326e-02f, -1.70940086e-02f,
  -5.19681256e-03f, -2.36897916e-02f, -1.02528170e-01f, -3.92663963e-02f, 8.17140266e-02f, -4.97172028e-03f, 3.75179201e-02f, 1.14052184e-01f, -4.97292653e-02f, 1.64975878e-02f,
  -1.26473591e-01f, 1.07065447e-01f, 1.57430068e-01f, 6.46866783e-02f, -7.60536864e-02f, 5.47182858e-02f, -9.33635309e-02f, 1.88820865e-02f, 1.33917466e-01f, -7.97129124e-02f,
  -7.35351890e-02f, -2.09262967e-01f, -1.92615330e-01f, 4.18694019e-01f, 4.11450624e-01f, 1.07743375e-01f, -4.19126451e-01f, -9.73704532e-02f, 3.76610339e-01f, -1.89366743e-01f,
  2.93189716e-02f, 2.76951522e-01f, -1.18054919e-01f, -1.90493524e-01f, -6.08933926e-01f, -6.42238975e-01f, -5.37684619e-01f, -4.61246222e-01f, -4.00913179e-01f, 7.42235854e-02f,
  1.04175210e-01f, 8.28718469e-02f, -6.99453428e-02f, -1.26546234e-01f, 3.39569509e-01f, 2.94802874e-01f, -4.81199995e-02f, 4.16973114e-01f, 3.36516872e-02f, 1.51067749e-01f,
  -4.70546558e-02f, 1.66777104e-01f, 1.23823257e-02f, 3.57070006e-02f, 1.39885113e-01f, -1.90594077e-01f, -1.30500808e-01f, -1.21325374e-01f, 4.48970981e-02f, -1.10792994e-01f,
  1.54767111e-01f, 7.40194693e-03f, 1.68572709e-01f, 9.71338972e-02f, -1.37090739e-02f, 9.85743594e-04f, -2.23543659e-01f, -2.00180545e-01f, -1.02954097e-01f, -6.23392500e-02f,
  1.10398091e-01f, 2.31405243e-01f, 7.50992000e-02f, -9.23015997e-02f, -1.45754308e-01f, 8.83481726e-02f, 2.26887673e-01f, 2.96766847e-01f, 6.63590580e-02f, 1.13271341e-01f,
  7.19265193e-02f, -7.67789362e-03f, -1.02239676e-01f, 4.34556678e-02f, 7.39926770e-02f, -6.35265000e-03f, 2.17141211e-02f, -4.04288247e-02f, 5.96006177e-02f, -9.84788872e-03f,
  -6.09667338e-02f, 7.31221437e-02f, -1.29440516e-01f, -4.71039191e-02f, 6.11377619e-02f, 4.66273651e-02f, 1.27038300e-01f, 6.76736608e-02f, -1.21571952e-02f, -7.17429770e-03f,
  -5.63494414e-02f, 5.43126427e-02f, -6.91958293e-02f, -2.61167642e-02f, 2.61555891e-02f, 8.93538892e-02f, 1.09216437e-01f, 3.31218056e-02f, 9.13125463e-03f, 5.98610099e-03f,
  1.15950815e-01f, -9.40057933e-02f, -3.71715911e-02f, -4.66031916e-02f, -1.81237347e-02f, 9.07734409e-02f, 1.94127902e-01f, 3.24676707e-02f, 1.75177485e-01f, 2.62363534e-02f,
  2.33858135e-02f, -1.78768381e-01f, -5.07596089e-03f, -3.11755631e-02f, -9.21123922e-02f, -1.80195048e-02f, -1.32560790e-01f, 1.06635995e-01f, -5.80307208e-02f, 2.55121559e-01f,
  -8.34797099e-02f, -1.29634619e-01f, -2.99894869e-01f, -1.42249718e-01f, 1.59893408e-01f, -1.90823346e-01f, -1.61103591e-01f, -1.45204191e-03f, -1.64030641e-01f, -4.45116729e-01f,
  6.69794232e-02f, 6.73339248e-01f, 1.40042722e-01f, 1.78479284e-01f, 1.65474519e-01f, 1.16762400e-01f, 3.68837386e-01f, 2.23978579e-01f, -7.53257126e-02f, 8.76592398e-02f,
  -1.15522429e-01f, -3.64257991e-02f, -9.88002494e-02f, -1.13337196e-01f, 4.65707257e-02f, 3.67895097e-01f, 4.64785188e-01f, 1.66255727e-01f, -1.46746054e-01f, 2.40960182e-03f,
  3.70432198e-01f, 2.30526373e-01f, -9.07273144e-02f, -5.86639568e-02f, 4.61817354e-01f, -1.01244703e-01f, 7.83493444e-02f, 3.16461831e-01f, 5.43708950e-02f, 6.87079489e-01f,
  -2.18144342e-01f, 2.26556748e-01f, -1.80638582e-01f, -6.48789927e-02f, 5.99981919e-02f, -3.46755162e-02f, -4.35316488e-02f, -1.01419732e-01f, -8.23508948e-02f, -1.02788299e-01f,
  -3.58359627e-02f, -7.48811662e-02f, 1.92890614e-01f, 6.94113672e-02f, -8.30802973e-03f, 9.23035294e-02f, 1.47556156e-01f, 5.29445857e-02f, -1.91344202e-01f, -3.06865722e-02f,
  2.01577246e-01f, 5.89933991e-02f, -8.69263187e-02f, -1.71256475e-02f, 2.99023211e-01f, -6.85275346e-02f, 1.93528440e-02f, 3.55142578e-02f, -1.49104252e-01f, 7.81696439e-02f,
  -2.74396390e-01f, 1.13137327e-01f, 1.66803032e-01f, -1.73193179e-02f, 2.53845509e-02f, -3.81033123e-02f, 7.81069547e-02f, -5.59292212e-02f, 1.55319765e-01f, -5.31393522e-03f,
  -2.98675839e-02f, 2.29265913e-03f, -6.86940849e-02f, -8.84160250e-02f, -6.94039688e-02f, 2.12752800e-02f, 1.90761387e-02f, -3.46712396e-02f, -1.55872643e-01f, -1.34552315e-01f,
  -2.33018156e-02f, -2.42827572e-02f, -5.61336800e-02f, 1.52482882e-01f, -3.35052237e-02f, -1.02565857e-02f, 4.53008786e-02f, -3.39901191e-03f, -9.60259046e-03f, 7.32767805e-02f,
  -2.73499697e-01f, -5.27359962e-01f, 3.05811241e-02f, 1.69146091e-01f, 1.32677674e-01f, -3.90326791e-02f, 1.56273782e-01f, -1.79478168e-01f, -9.61567611e-02f, -4.15783515e-03f,
  -5.32277487e-02f, -5.11439033e-02f, 1.07364371e-01f, -8.83794874e-02f, -2.15409130e-01f, -1.27709687e-01f, 4.80514299e-03f, -5.77513836e-02f, -8.73502791e-02f, -1.30526543e-01f,
  1.21214002e-01f, -1.60289645e-01f, -3.89444500e-01f, -1.01580925e-01f, -1.73949618e-02f, -2.27899924e-01f, -1.47732452e-01f, -1.51021376e-01f, -3.37778538e-01f, -2.14699119e-01f,
  -6.26310050e-01f, -4.84092869e-02f, -5.23437321e-01f, -1.17165923e-01f, 2.67826319e-01f, 4.35925126e-01f, 2.62058467e-01f, 3.04162323e-01f, 3.25669020e-01f, -1.23916969e-01f,
  2.04516768e-01f, 3.42326880e-01f, 8.37379321e-02f, 1.84513301e-01f, 1.25838697e-01f, 9.68752056e-02f, -8.12513288e-03f, -2.20962510e-01f, 8.07468891e-02f, 3.13293755e-01f,
  4.17714089e-01f, 2.00847704e-02f, -3.41561139e-01f, 2.26338029e-01f, -3.15824896e-01f, 4.67830375e-02f, -5.40402770e-01f, -4.37813491e-01f, 1.53979082e-02f, -7.32538164e-01f,
  -6.97063327e-01f, -2.99198151e-01f, 2.40557358e-01f, -5.27307577e-02f, -2.80622635e-02f, -3.29439389e-03f, -4.95147519e-02f, -3.88121277e-01f, -3.89292911e-02f, -1.79838855e-02f,
  -1.46104377e-02f, 1.43119469e-01f, -1.82626843e-01f, 1.71156064e-01f, -1.59892008e-01f, 9.26989391e-02f, 2.44180635e-02f, -1.95448443e-01f, -1.08250447e-01f, -1.60751447e-01f,
  4.31565702e-01f, -2.06250131e-01f, -5.05103052e-01f, -3.69179919e-02f, 1.56718478e-01f, -1.50580794e-01f, -2.35781997e-01f, -4.34445530e-01f, -4.44356531e-01f, -9.18254375e-01f,
  9.19081569e-02f, -1.41321421e-01f, -1.29336059e-01f, -3.87871489e-02f, 5.61327375e-02f, -2.02379562e-02f, -9.85102206e-02f, 1.92717478e-01f, 2.73356028e-02f, 9.63285379e-03f,
  6.51608109e-02f, 2.71454621e-02f, 4.12498452e-02f, -5.70380054e-02f, 5.49271442e-02f, -1.65844083e-01f, 1.77402899e-01f, 6.66539222e-02f, -5.27693368e-02f, -1.22974493e-01f,
  -1.32822301e-02f, -2.56249547e-01f, -9.74143893e-02f, 9.58491191e-02f, 8.24966505e-02f, 6.76783621e-02f, -2.95184590e-02f, 1.25013411e-01f, -1.01968478e-02f, -1.20666489e-01f,
  6.46744817e-02f, 1.86322659e-01f, -8.71943086e-02f, 1.02219790e-01f, -1.31138591e-02f, -3.77482958e-02f, -3.94809060e-02f, 1.34307787e-01f, 3.12629119e-02f, 7.45756626e-02f,
  2.63418168e-01f, -1.75346788e-02f, -2.05806363e-02f, 7.87400976e-02f, 5.64168580e-02f, -1.37105975e-02f, -2.90279053e-02f, 4.96186130e-02f, 1.71803445e-01f, 6.22434579e-02f,
  2.48763442e-01f, 3.21852192e-02f, -1.34085938e-01f, -1.12127110e-01f, -1.02666602e-01f, -1.06184617e-01f, -2.32428268e-01f, -9.72548500e-02f, -1.02982871e-01f, -2.62920350e-01f,
  8.34277552e-03f, 2.26796657e-01f, -7.99617618e-02f, -1.20892413e-01f, 4.61151391e-01f, 1.79839566e-01f, -2.62022465e-01f, 7.85326585e-03f, 1.65297627e-01f, 3.71100642e-02f,
  5.61759710e-01f, 3.12376827e-01f, 4.45538275e-02f, -9.65345129e-02f, -2.98583806e-01f, -2.86683768e-01f, -5.07937908e-01f, -6.65848911e-01f, -3.28958452e-01f, 1.98826641e-01f,
  2.40338638e-01f, -5.08471206e-02f, -2.74714828e-01f, -1.74486056e-01f, 1.69407874e-01f, 1.79726584e-03f, -2.79698431e-01f, 2.49302804e-01f, 2.43700057e-01f, -2.18236968e-01f,
  1.57977909e-01f, 3.03916007e-01f, -2.36512884e-01f, 3.10457259e-01f, 1.96229629e-02f, -1.85215905e-01f, -2.58114636e-02f, -1.55717432e-01f, -5.96072488e-02f, -1.01044506e-01f,
  2.32872218e-01f, 2.75628388e-01f, 1.62608042e-01f, -3.86119857e-02f, -7.86360502e-02f, -1.88395157e-01f, -3.66360322e-03f, -3.08741152e-01f, -5.46942413e-01f, 1.13522574e-01f,
  2.91348189e-01f, 3.51347953e-01f, 4.83897217e-02f, -2.33627453e-01f, -2.95940787e-01f, -7.25265741e-02f, 8.02390873e-02f, -1.42256528e-01f, -3.35650414e-01f, -4.32280600e-01f,
  -7.49365240e-02f, -2.20436766e-03f, 7.38286227e-02f, -9.08105299e-02f, -1.51659116e-01f, 1.21513363e-02f, 1.61950231e-01f, 8.98398757e-02f, -2.05100961e-02f, 7.04390986e-04f,
  2.48033777e-02f, 1.31469414e-01f, -3.44038084e-02f, 4.05718526e-03f, -6.13610037e-02f, 6.65892810e-02f, -8.39148238e-02f, -2.20899701e-01f, -4.66143303e-02f, -2.92171910e-02f,
  5.41927852e-02f, -4.69262674e-02f, 1.41096497e-02f, -1.07591711e-01f, -1.09978449e-02f, -4.04565185e-02f, -3.19864117e-02f, -5.26963826e-03f, 6.14643395e-02f, 1.21289179e-01f,
  -1.91172585e-01f, -5.12906425e-02f, -3.08416598e-02f, -2.15220768e-02f, 1.06016941e-01f, -5.15747890e-02f, -3.22073884e-02f, 7.77600631e-02f, 3.61747369e-02f, -5.80088459e-02f,
  1.05564274e-01f, 3.75370914e-03f, 2.81055570e-02f, -5.21388985e-02f, 5.07821441e-02f, -7.45366216e-02f, 1.63223490e-01f, -6.22186847e-02f, -7.52478018e-02f, 6.27809018e-02f,
  -1.62190527e-01f, -3.54698837e-01f, -2.74732411e-01f, -2.64555782e-01f, -6.90206233e-03f, -4.89456579e-02f, -2.99866080e-01f, -2.40045205e-01f, -3.80714089e-01f, -7.29010403e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  7.48732835e-02f, -1.21786922e-01f, 5.42907655e-01f, -2.43982431e-02f, 2.23785248e-02f, 4.44479913e-01f, 5.05555212e-01f, 2.29850143e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  5.43399334e-01f, -2.98624486e-01f, -2.69019932e-01f, 3.57395232e-01f, 3.37280601e-01f, 1.66584268e-01f, -2.65539140e-01f, 1.18929751e-01f, 1.55784175e-01f, 2.26238921e-01f,
  7.12601319e-02f, -1.84411317e-01f, 1.90215767e-03f, 8.52545351e-02f, 2.08813801e-01f, 1.11655921e-01f, -3.44999403e-01f, 4.00481559e-02f, -3.83172482e-02f, 2.81529754e-01f,
  -5.45506299e-01f, -3.26151341e-01f, 5.40192962e-01f, -1.07288420e-01f, -5.12845814e-02f, 4.14791316e-01f, 9.76911560e-03f, -3.37950319e-01f, -7.25282803e-02f, 1.02339908e-01f,
  4.31508690e-01f, -1.31590739e-01f, -2.54854381e-01f, -4.73160297e-02f, 4.78788465e-01f, -6.33982802e-03f, -1.88548192e-01f, 6.22135460e-01f, 3.26377004e-01f, -2.35474139e-01f,
  -4.97202903e-01f, 4.11350369e-01f, 5.24038114e-02f, 1.66597679e-01f, 3.84205937e-01f, 7.79030100e-02f, -7.33393356e-02f, 6.38059676e-02f, -6.63428530e-02f, -8.90493095e-02f,
  -1.36078000e-01f, 3.67868394e-02f, -2.93044031e-01f, -1.29281789e-01f, 1.37355924e-01f, 2.30065271e-01f, 1.62634850e-01f, -2.07436964e-01f, -3.54464561e-01f, 1.97870806e-01f,
  -6.59241676e-02f, 1.25475356e-03f, 9.24854130e-02f, -2.78838240e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -8.05660561e-02f, -3.61510515e-02f, 2.41293281e-01f, 5.07245660e-01f, -7.71841854e-02f, 5.76911330e-01f, 3.45725805e-01f, 2.67500162e-01f, 3.38618129e-01f, 1.10955499e-01f,
  -5.68871737e-01f, 5.43653034e-02f, 5.25462091e-01f, 4.21033323e-01f, 1.33038715e-01f, 2.81181246e-01f, -8.92047361e-02f, 6.35928571e-01f, 1.82521924e-01f, 1.14907779e-01f,
  -6.36780381e-01f, -1.27853498e-01f, -3.67728502e-01f, 9.07732770e-02f, 4.94077891e-01f, -9.23599526e-02f, 2.32583463e-01f, 3.47000211e-01f, -1.62269518e-01f, 1.85940176e-01f,
  -1.67079329e-01f, -1.39118090e-01f, -1.49394162e-02f, 5.20474911e-01f, -2.13298649e-01f, -3.66887301e-01f, -2.70411044e-01f, -3.58330458e-01f, -6.69695258e-01f, 5.14610171e-01f,
  1.42993167e-01f, 1.06199887e-02f, 9.02561963e-01f, -6.98129006e-05f, 3.07511419e-01f, 1.81599081e-01f, 6.89716935e-01f, 6.93029940e-01f, -2.73683012e-01f, 6.72635496e-01f,
  2.96185553e-01f, -1.71158522e-01f, -7.41685152e-01f, -3.37888002e-01f, 1.42487407e-01f, -4.60249901e-01f, 5.64560115e-01f, 8.56947824e-02f, 2.52502143e-01f, 2.88409054e-01f,
  -2.42327839e-01f, 2.95749187e-01f, 1.34063020e-01f, -4.07266617e-03f, 1.87251747e-01f, -6.99131563e-02f, -9.69623998e-02f, 1.81716010e-01f, 1.17378473e-01f, 7.22519681e-02f,
  2.05296636e-01f, -1.94191739e-01f, 9.37998831e-01f, -2.64090598e-01f, -6.52739763e-01f, 1.02671117e-01f, 5.41637897e-01f, -2.82204729e-02f, -8.90214264e-01f, 9.74396944e-01f,
  3.03149313e-01f, -1.75865710e-01f, 8.92809749e-01f, -4.15164173e-01f, 8.63689929e-02f, -6.97192270e-04f, 5.25396943e-01f, -1.75413281e-01f, 1.33428974e-02f, 7.94721782e-01f,
  2.87891589e-02f, -3.77819270e-01f, 6.57884836e-01f, -4.63592678e-01f, 4.83686179e-01f, 4.43932265e-01f, -1.24134339e-01f, 3.33270311e-01f, 1.40342876e-01f, -5.70822954e-01f,
  1.04051843e-01f, 5.80127895e-01f, 2.67806530e-01f, -5.26610613e-01f, -2.71552145e-01f, 5.41699231e-01f, 4.30809885e-01f, 1.58871531e-01f, 6.60734117e-01f, -9.10817459e-02f,
  3.92452590e-02f, 5.89177310e-01f, -1.88829407e-01f, 8.61867741e-02f, -4.86650020e-02f, 3.44680458e-01f, -1.44591359e-02f, -2.36617208e-01f, 2.44775027e-01f, -2.37672806e-01f,
  8.70476544e-01f, -3.60488564e-01f, -8.53677914e-02f, -4.86858375e-02f, 2.24913925e-01f, 7.15700448e-01f, 4.23637480e-01f, 3.83889854e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  2.27745231e-02f, -1.18711285e-01f, 2.33012348e-01f, -1.99351028e-01f, 4.83451754e-01f, 6.17415845e-01f, -8.53740722e-02f, 3.17317396e-01f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  3.74880731e-01f, 4.46843445e-01f, -2.68153727e-01f, -4.21301991e-01f, 1.75862193e-01f, -5.55401027e-01f, -3.62527221e-02f, -2.22731248e-01f, -1.37696818e-01f, -1.54906260e-02f,
  2.13403776e-01f, -1.59794971e-01f, 6.09634407e-02f, -8.90028253e-02f, 3.57674867e-01f, -1.71510071e-01f, 1.49749741e-01f, -1.87673159e-02f, -2.07043774e-02f, -3.67882371e-01f,
  -3.11511010e-01f, 5.70432723e-01f, 1.02299660e-01f, -2.73903996e-01f, -1.35210559e-01f, -2.70584494e-01f, -1.40019387e-01f, 2.58599460e-01f, -5.66280186e-01f, 5.77260852e-01f,
  2.22511366e-01f, -6.07554577e-02f, -2.40466028e-01f, 4.31474239e-01f, -1.45000666e-01f, 3.21714208e-02f, 7.26196110e-01f, 1.28719568e-01f, 1.00046143e-01f, 6.71945093e-03f,
  3.71464252e-01f, -3.42848897e-01f, -6.24221489e-02f, -2.07917616e-01f, -3.92733008e-01f, 4.28813286e-02f, -3.20246696e-01f, 2.35308066e-01f, -3.28073770e-01f, 3.01399361e-03f,
  4.70843941e-01f, 4.72751886e-01f, -2.08664656e-01f, 2.81499356e-01f, -5.81922889e-01f, 2.03784093e-01f, -3.00409883e-01f, -1.05643198e-01f, 2.98276782e-01f, 4.35638521e-03f,
  -2.14416608e-01f, -2.50887454e-01f, -3.62215877e-01f, 1.19108796e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  3.53475630e-01f, -4.16773036e-02f, 5.71857333e-01f, 5.69792688e-01f, 2.01257780e-01f, 1.08607638e+00f, 2.36193091e-01f, -6.20341301e-01f, -1.60999566e-01f, -6.49167299e-01f,
  -6.95829839e-02f, -2.11816758e-01f, -2.76122928e-01f, 5.22097766e-01f, 1.86835587e-01f, -1.84510931e-01f, -1.65728018e-01f, -4.30092126e-01f, -5.28939627e-02f, 2.53477007e-01f,
  -4.89308000e-01f, 3.72643203e-01f, -4.20099348e-01f, -3.78505766e-01f, 7.59523734e-02f, 5.39995611e-01f, 8.54030788e-01f, 3.42425972e-01f, -5.80073833e-01f, -1.35481209e-01f,
  1.04598425e-01f, 1.41075224e-01f, 1.75000489e-01f, -4.80259538e-01f, 4.33185518e-01f, 2.15185165e-01f, -1.32112551e+00f, 8.19732621e-02f, 2.85945654e-01f, 3.96794587e-01f,
  7.38901719e-02f, 3.33954394e-01f, 6.00765526e-01f, 5.67572474e-01f, 3.19401771e-01f, 1.26934320e-01f, 4.07973170e-01f, 5.18491745e-01f, 6.85902834e-01f, 7.59774327e-01f,
  8.73099446e-01f, 5.81441700e-01f, 5.03288925e-01f, 4.77964014e-01f, -6.10749498e-02f, 2.93283518e-02f, 6.27185047e-01f, 3.63112599e-01f, 1.59757435e-01f, 7.52292573e-02f,
  1.10932386e+00f, 3.40442300e-01f, -3.57181042e-01f, 5.58220446e-01f, 5.73994339e-01f, 4.58995253e-01f, 4.66659456e-01f, 5.25965181e-04f, -2.04381302e-01f, 6.75453067e-01f,
  -1.20045948e+00f, -6.37927294e-01f, -4.47894633e-01f, -2.59709835e-01f, 5.04293144e-01f, -1.01159371e-01f, 4.44488637e-02f, 1.99614093e-01f, 5.21024093e-02f, 1.44019499e-01f,
  2.22975165e-01f, 5.28260469e-01f, -5.86958587e-01f, -2.83906668e-01f, 9.35134709e-01f, -1.81202814e-01f, 1.14060745e-01f, -6.25644505e-01f, 2.81088185e-02f, -4.64865744e-01f,
  6.13078833e-01f, -4.50355858e-01f, -2.27784016e-03f, 8.46360505e-01f, 7.26668000e-01f, -6.39642254e-02f, 1.23433352e-01f, 6.58076584e-01f, 4.89014596e-01f, 4.66608047e-01f,
  5.44215322e-01f, -5.13205111e-01f, -1.18014073e+00f, -7.18008399e-01f, -3.13690722e-01f, 1.56584561e-01f, 7.98154354e-01f, -1.06688350e-01f, -6.65620565e-01f, -1.60908982e-01f,
  -1.89822435e-01f, -5.71877928e-03f, -4.83485729e-01f, 9.27844703e-01f, 4.36701477e-01f, 5.83351135e-01f, 1.23129642e+00f, 2.19946235e-01f, 2.27834973e-02f, -1.42005846e-01f,
  6.80302680e-01f, -5.26612043e-01f, 1.09990902e-01f, -3.13230067e-01f, 5.89941919e-01f, -2.18931839e-01f, -2.70395782e-02f, 4.75747168e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  1.15510836e-01f, -1.36176080e-01f, -1.72828078e-01f, 4.57323492e-01f, 7.74807483e-02f, -1.17700519e-02f, 4.02827799e-01f, 5.80631733e-01f
};

// L3_fan_Wp (Shape: 4 x 16)
const int L3_fan_Wp_rows = 4;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  7.31995031e-02f, -1.75184488e-01f, -1.91179529e-01f, 3.93902183e-01f, -4.97977704e-01f, 4.36932176e-01f, 3.41752738e-01f, 5.90161443e-01f, 2.52475798e-01f, 7.27931187e-02f,
  -1.32815167e-01f, -9.27461833e-02f, 3.87036860e-01f, -1.01897404e-01f, -3.74546461e-02f, 7.89765939e-02f, 5.84369227e-02f, -6.78396583e-01f, -2.10004747e-01f, -5.48191331e-02f,
  -9.50363949e-02f, -5.03844380e-01f, -4.37876374e-01f, 5.81829965e-01f, -3.29950690e-01f, -6.93963375e-03f, 9.37778726e-02f, 1.55011714e-01f, 3.72900143e-02f, -1.99288025e-01f,
  2.14160904e-01f, -4.91790622e-02f, 9.14608985e-02f, -4.32811737e-01f, -3.98080945e-01f, 4.55317870e-02f, -5.09079695e-02f, -4.04049516e-01f, 7.58962035e-01f, 2.27494985e-01f,
  4.16084349e-01f, 1.29990190e-01f, -1.21530697e-01f, 2.97725916e-01f, -2.24547803e-01f, -3.01543266e-01f, 4.21429574e-02f, -4.30352390e-02f, 2.99234957e-01f, 1.44815326e-01f,
  1.80627272e-01f, 2.88304657e-01f, -4.98059690e-02f, 4.47886996e-02f, -1.00051773e+00f, 6.59860134e-01f, 4.77441251e-01f, -6.23884872e-02f, 1.74523622e-01f, 1.29279085e-02f,
  2.09130868e-01f, -4.89747763e-01f, 2.02964246e-01f, 6.11614883e-02f
};

// L3_fan_Wp_bar (Shape: 8 x 16)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -8.29463005e-02f, -1.86712459e-01f, 3.00720371e-02f, -1.21561170e-01f, -2.07699686e-01f, 6.60715625e-02f, 2.81321824e-01f, -1.59226000e-01f, -1.70308948e-02f, -3.18279684e-01f,
  1.47604436e-01f, -2.76285470e-01f, -1.88097090e-01f, -6.07341230e-02f, -1.65189087e-01f, -1.92524344e-01f, 5.97181432e-02f, 4.57916349e-01f, 5.89001954e-01f, -1.60242826e-01f,
  9.56345856e-01f, -6.57647967e-01f, -6.48934484e-01f, 8.41309428e-01f, -4.50796038e-01f, 4.78347689e-01f, 1.13058262e-01f, 1.69977382e-01f, 1.05716980e+00f, 7.81748652e-01f,
  1.20917809e+00f, -3.42642665e-02f, 5.42984605e-01f, 1.23826005e-01f, -1.29304891e-02f, 2.16834545e-01f, -3.58393669e-01f, -1.04721403e+00f, 1.51924741e+00f, -4.63127375e-01f,
  -1.58452779e-01f, -2.47636214e-01f, -2.19372183e-01f, 5.38866758e-01f, -9.99171287e-03f, 2.39335179e-01f, 4.31159884e-02f, 1.32721364e+00f, 7.58144677e-01f, 4.07285482e-01f,
  1.14080429e+00f, 1.23063600e+00f, -3.55195224e-01f, 8.29494536e-01f, 1.69258028e-01f, -3.25615317e-01f, 9.54265714e-01f, -3.40856701e-01f, -3.29195201e-01f, 6.01603448e-01f,
  4.18144524e-01f, -9.37383920e-02f, -1.19934224e-01f, 1.94747612e-01f, -1.65558457e-01f, -2.87972689e-02f, 1.15619242e-01f, -2.60617733e-02f, -2.19281793e-01f, 5.23697138e-02f,
  -5.19542396e-02f, 3.80767882e-02f, -9.42686200e-03f, -1.76679254e-01f, -7.15807676e-02f, -1.90936983e-01f, -4.92552519e-02f, -1.64589673e-01f, -1.77952051e-02f, 4.77905571e-02f,
  7.05512643e-01f, 7.84708381e-01f, -1.05938643e-01f, -3.59555423e-01f, 6.17854416e-01f, -8.29835415e-01f, 5.67826927e-01f, -4.34255414e-02f, -5.43613851e-01f, 5.67409098e-01f,
  2.79648900e-01f, -3.82720307e-02f, -5.85558534e-01f, -6.29173458e-01f, 1.46213189e-01f, -4.72505420e-01f, -1.02440923e-01f, 4.61906165e-01f, 5.47598124e-01f, -9.87005115e-01f,
  3.02716106e-01f, 1.32721245e+00f, -5.33384025e-01f, -8.90327454e-01f, 9.29113984e-01f, -7.00450642e-03f, 3.90740007e-01f, 3.68999898e-01f, -3.83661650e-02f, 9.45509553e-01f,
  -6.78611875e-01f, -3.30253214e-01f, -1.74306273e-01f, -4.69880581e-01f, -5.37318364e-02f, 1.69040397e-01f, -8.00940633e-01f, 2.64510304e-01f, -1.32044899e+00f, 2.39519715e-01f,
  1.81559533e-01f, 4.42014158e-01f, 7.11321533e-01f, 6.10545576e-01f, 3.09775472e-01f, -7.79892147e-01f, -3.82933289e-01f, 3.12046468e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  -1.86598867e-01f, -2.85252035e-01f, 3.88175070e-01f, 2.95554310e-01f, -2.49892473e-01f, 2.06994802e-01f, 3.52611899e-01f, -4.43400145e-02f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -2.31977999e-01f, 3.52137178e-01f, -3.04923564e-01f, -1.25850230e-01f, -8.90522301e-01f, -1.22189328e-01f, 5.56407511e-01f, -8.14838171e-01f, 1.47332549e-01f, 2.16318458e-01f,
  -9.48546469e-01f, -1.28788459e+00f, -8.66207778e-02f, 2.17097811e-02f, 5.65465510e-01f, -6.09780967e-01f, 1.90587565e-01f, 5.73067546e-01f, 9.79916453e-01f, -4.74351585e-01f,
  8.82209241e-01f, 8.73225152e-01f, 1.67620797e-02f, -4.47551310e-01f, -9.79148597e-02f, -1.62026659e-01f, -7.67939031e-01f, 6.46515191e-02f, 5.70912659e-02f, -2.77764112e-01f,
  1.04966618e-01f, 3.49136174e-01f, 1.54982448e+00f, -6.57088578e-01f, 7.38452256e-01f, 3.87072027e-01f, -9.64705124e-02f, -5.42936981e-01f, 8.21350813e-01f, -8.28402042e-01f,
  1.09082580e-01f, -1.06463480e+00f, 2.07320660e-01f, 3.92237276e-01f, 3.12333107e-02f, 3.91922176e-01f, 3.32018435e-01f, -6.08534992e-01f, 4.26303484e-02f, 1.20724827e-01f,
  -1.45825434e+00f, 7.99416900e-01f, 7.50537157e-01f, 3.47510934e-01f, -6.86037958e-01f, 5.71246445e-01f, -2.24346429e-01f, 5.44426143e-01f, -5.65827668e-01f, -4.80338991e-01f,
  1.50335759e-01f, -1.15409112e+00f, -1.71561748e-01f, -2.47642294e-01f, 1.64055392e-01f, -2.84720123e-01f, -4.54917639e-01f, 1.30621672e-01f, -9.46600139e-01f, -1.06998050e+00f,
  -1.52427876e+00f, -5.10863304e-01f, -5.13203293e-02f, 2.56767068e-02f, -1.48529634e-01f, -2.12790873e-02f, -2.20673859e-01f, -8.74776468e-02f, 3.69228333e-01f, -3.41652542e-01f,
  -6.38936579e-01f, 5.47245681e-01f, -3.15846615e-02f, -3.78443539e-01f, 1.33111107e+00f, -7.72041500e-01f, 4.86700922e-01f, 1.41996980e+00f, -2.22292989e-01f, -6.50550202e-02f,
  6.88074678e-02f, 7.09057093e-01f, 1.12926424e-01f, 4.82977599e-01f, -2.28043750e-01f, -4.35430139e-01f, 3.86474669e-01f, 1.03341840e-01f, -4.59458649e-01f, 8.13264191e-01f,
  -1.85614109e-01f, 7.58263886e-01f, -2.96084613e-01f, 1.91277951e-01f, -1.74601555e-01f, -8.88117194e-01f, 5.63689590e-01f, 3.47768217e-01f, -4.62450683e-02f, 1.93395838e-01f,
  -1.18856466e+00f, -4.67005521e-02f, 3.84791374e-01f, 2.76069820e-01f, -2.18451053e-01f, -3.75590436e-02f, -5.48374727e-02f, -1.77625105e-01f, -6.05559126e-02f, 9.17140007e-01f,
  1.46204963e-01f, -3.49007025e-02f, 3.16225350e-01f, -1.29833615e+00f, 1.74200505e-01f, -2.39262581e-01f, -9.05612707e-01f, 2.54101932e-01f, 1.57480881e-01f, -5.64951122e-01f,
  3.14263701e-01f, -8.81732166e-01f, -3.94038484e-02f, -8.03416014e-01f, 5.07682323e-01f, -7.68022001e-01f, -3.11063346e-03f, 4.01140541e-01f, -7.72765994e-01f, -6.57692313e-01f,
  -2.06378460e-01f, -1.29028801e-02f, -8.65328848e-01f, 1.08063832e-01f, -1.14872694e+00f, 7.27205217e-01f, 6.61991179e-01f, -2.62896158e-02f, -1.36999738e+00f, 9.64069605e-01f,
  3.83042216e-01f, -9.86036479e-01f, 1.25730544e-01f, -2.68203974e-01f, 6.41447186e-01f, -2.47962460e-01f, 1.84477121e-01f, -5.63949168e-01f, -1.43534660e-01f, -4.52523082e-01f,
  1.46229014e-01f, -3.36424494e-03f, 3.71341050e-01f, -1.88997701e-01f, 3.73329461e-01f, 6.05087399e-01f, -8.65136534e-02f, 4.42606956e-01f, -1.06726782e-02f, 6.83608711e-01f,
  1.17608719e-01f, -2.65303534e-02f, -1.08189881e-02f, -8.89993012e-01f, -1.28765512e+00f, -1.41664064e+00f, -4.94341731e-01f, -1.28512454e+00f, -1.11782563e+00f, -7.43710876e-01f,
  -7.46051550e-01f, -2.92522430e-01f, 1.13181882e-01f, 1.71742931e-01f, -1.11178130e-01f, -6.74152553e-01f, -1.34782288e-02f, 2.48584256e-01f, 2.31326610e-01f, -1.15810096e+00f,
  -7.73817077e-02f, 3.28017414e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  8.25593621e-02f, 7.29240254e-02f, 4.47316229e-01f, -3.20431918e-01f, 3.50636318e-02f, 1.00577913e-01f, 3.35186452e-01f, -7.37166032e-02f, 1.44574732e-01f, 9.20829177e-03f,
  -9.53184441e-02f, -7.84723759e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    