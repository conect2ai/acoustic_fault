
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000106350793707506*x_1 + 0.000205562817073109*x_10 + 0.000144620780229823*x_100 + 0.000103805940645079*x_101 - 2.70000777498123e-5*x_102 - 0.000218285471181533*x_103 - 0.000199045285050658*x_104 + 0.000252555367035829*x_105 - 1.02862455752157e-5*x_106 - 0.000339435828586278*x_107 - 2.19484981840457e-5*x_108 - 0.000103503405532485*x_109 - 2.94068998967773e-5*x_11 - 7.51063077231e-5*x_110 + 0.000153016318604523*x_111 - 0.00110595547314534*x_112 + 0.000184584864434366*x_113 + 7.69346245964351e-6*x_114 - 9.68281816247266e-5*x_115 - 4.60277332676119e-5*x_116 - 1.90024256881196e-5*x_117 - 4.50233646844607e-5*x_118 + 5.14780434534927e-5*x_119 - 4.6934187572435e-6*x_12 + 5.32023159956864e-5*x_120 + 0.000276015768123766*x_13 + 0.000132659153600365*x_14 + 0.000400171393806121*x_15 - 5.59763549412924e-6*x_16 + 1.35456364276627e-5*x_17 + 0.00014122451958382*x_18 + 0.000577872008708216*x_19 - 9.16549549085846e-5*x_2 + 0.000508271574756646*x_20 + 2.00333154564287e-5*x_21 + 0.000430912512679239*x_22 + 0.000121871641644237*x_23 - 0.000120824803531145*x_24 - 0.000337390747101638*x_25 - 0.000518792833738094*x_26 - 0.000944840493681576*x_27 - 0.000200781536978317*x_28 + 2.65465006551502e-5*x_29 + 5.76583403543138e-6*x_3 + 0.000546481831394046*x_30 - 3.0994787394856e-5*x_31 + 2.73193075049215e-5*x_32 + 0.000216180431622556*x_33 + 4.25211361409986e-5*x_34 - 4.58350978316633e-5*x_35 + 6.52296247929334e-5*x_36 - 9.0266761213647e-5*x_37 + 6.53643965123634e-5*x_38 + 0.00011659853711423*x_39 - 1.5529290050355e-6*x_4 + 0.000104702231082133*x_40 - 8.36384842307071e-5*x_41 + 0.000210542270864287*x_42 + 7.00254583677316e-5*x_43 - 0.000347070122338102*x_44 - 5.14321557957665e-5*x_45 + 3.52239574950979e-5*x_46 - 0.000523175422560311*x_47 - 0.0001835282934755*x_48 - 0.000167236523574856*x_49 + 5.97235870722357e-5*x_5 + 3.34515960567859e-5*x_50 + 5.10048418416927e-6*x_51 + 4.55122375434859e-5*x_52 + 5.15469892324883e-5*x_53 - 0.000246196261329333*x_54 - 0.000389694262686167*x_55 + 3.30456162350043e-6*x_56 - 0.000184269402580026*x_57 - 0.000258655672252707*x_58 - 0.000183658506573874*x_59 + 0.00024591680654169*x_6 - 0.000166207420983156*x_60 - 5.36580734018437e-5*x_61 + 3.68871713807258e-5*x_62 + 9.42322385406691e-7*x_63 + 3.26768760270342e-5*x_64 + 0.000109734867532768*x_65 + 6.19342924709346e-5*x_66 - 2.9274224371287e-5*x_67 - 0.000639830982032902*x_68 - 2.92559355898077e-6*x_69 - 5.24346431239491e-5*x_7 + 4.77588263528656e-5*x_70 - 3.61859045666627e-5*x_71 + 0.000121870134090069*x_72 - 0.00010705557143531*x_73 - 9.23566455687427e-5*x_74 - 7.66624693760792e-5*x_75 - 2.53257503990638e-5*x_76 - 2.15181251207527e-5*x_77 - 2.95913398881363e-5*x_78 + 1.08343758480603e-5*x_79 + 5.71360960131586e-5*x_8 + 7.0985516218704e-5*x_80 - 7.91574715281309e-5*x_81 + 1.12319617469847e-5*x_82 + 0.000111333933410322*x_83 - 6.3778575003656e-5*x_84 - 0.000150216685799562*x_85 - 2.05516652522067e-5*x_86 - 5.39881106594774e-5*x_87 - 2.97337748602176e-5*x_88 + 1.32984121852686e-5*x_89 + 9.90121202523984e-5*x_9 + 4.14071923093343e-5*x_90 + 1.63458235520407e-5*x_91 + 9.05505033142023e-6*x_92 - 1.1372357651666e-5*x_93 - 8.06956778419355e-5*x_94 - 4.24141415650424e-5*x_95 - 3.57815830048315e-5*x_96 + 0.000151437281537946*x_97 + 6.69549278284027e-5*x_98 + 0.000839067759775807*x_99 + 0.000151508128236547*std::sin(1.0998398065567*x_67 + 5.22312021255493) + 0.0107427267627032);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (9.02210625619975e-5*x_1 + 0.000231949162223916*x_10 - 9.18898102693901e-5*x_100 - 3.28980773153295e-5*x_101 - 0.00021827064102701*x_102 + 2.00373940156526e-5*x_103 + 1.17313985722059e-5*x_104 - 0.000161915359768368*x_105 - 0.000124406820637704*x_106 + 3.321776192441e-5*x_107 - 0.000123321662589965*x_108 - 1.7064346753084e-5*x_109 + 0.000119867668387074*x_11 + 6.57640947340507e-5*x_110 - 3.77822431025598e-5*x_111 + 3.22712053456638e-5*x_112 - 0.000146248546383922*x_113 - 0.000205868574164216*x_114 - 1.31753946592792e-5*x_115 - 0.000100855004624997*x_116 - 0.000107273405807479*x_117 - 6.02652322633974e-6*x_118 - 9.94925069038501e-5*x_119 + 0.000154279638891916*x_12 - 0.000104965566307415*x_120 + 0.00085313747288029*x_13 + 0.000114849867919911*x_14 - 1.86290343184817e-5*x_15 - 7.74473844796891e-5*x_16 - 0.000176905575782954*x_17 - 9.64111336598493e-5*x_18 - 0.000367555398211404*x_19 - 3.75723593950506e-5*x_2 - 5.04699771950477e-5*x_20 - 0.000149359688541086*x_21 - 0.00067449055398874*x_22 - 8.37739161017374e-5*x_23 + 5.59380068829994e-5*x_24 - 5.91951868047097e-5*x_25 + 0.000420571642883063*x_26 + 0.000545966993848143*x_27 - 8.34177391644601e-5*x_28 + 0.000253537628643054*x_29 + 4.31220465711487e-5*x_3 - 0.00220584902445733*x_30 + 3.92771491960621e-5*x_31 - 7.55986497343356e-5*x_32 - 7.32407889448586e-5*x_33 - 0.000231190250013601*x_34 - 0.000291143495790387*x_35 - 0.00101157708527884*x_36 - 8.31310999628776e-5*x_37 - 0.000342880552622084*x_38 - 0.000147456148674725*x_39 - 9.34529827558306e-5*x_4 - 0.000200018066222507*x_40 - 0.000246670490754273*x_41 - 0.000243116007199336*x_42 - 0.000225885781380119*x_43 - 0.000274332444699994*x_44 - 0.000261514731440189*x_45 - 0.000540096594089249*x_46 + 9.39925415759069e-5*x_47 + 0.000250583664920982*x_48 - 0.00016271178585936*x_49 - 8.6863230533526e-5*x_5 + 1.39092620108731e-5*x_50 + 0.000539392856667502*x_51 + 0.000164439682280528*x_52 + 3.45648650185273e-5*x_53 + 0.000244151359649412*x_54 + 7.92320771991722e-6*x_55 + 0.000585615070746836*x_56 - 5.11020642625575e-6*x_57 + 0.000324778980495119*x_58 + 0.000197482014490395*x_59 + 3.49879795096255e-5*x_6 + 0.000206519605871319*x_60 + 2.12974663812163e-5*x_61 + 5.37796726738233e-5*x_62 + 1.6406606864354e-5*x_63 + 9.65684272956152e-6*x_64 - 0.000190514439896389*x_65 + 1.37998113427726e-5*x_66 - 2.11967485757371e-6*x_67 + 6.94692895187667e-5*x_68 + 3.65061221354521e-5*x_69 - 7.35184035864154e-5*x_7 + 8.95488423164151e-5*x_70 + 1.62750256284664e-5*x_71 + 0.000154830560918164*x_72 + 7.99263310172016e-5*x_73 - 6.68021057526334e-6*x_74 + 9.41999100916578e-5*x_75 + 8.96080415190311e-5*x_76 + 3.01677939213585e-5*x_77 + 2.45955875810651e-5*x_78 - 5.01345245370224e-5*x_79 + 2.85026120628925e-6*x_8 - 5.48807732883212e-5*x_80 + 2.81045929401917e-5*x_81 + 3.05470419532237e-5*x_82 + 0.000239394576559979*x_83 + 4.59778818644096e-6*x_84 - 9.97369263411005e-6*x_85 + 2.37894748057229e-5*x_86 + 4.7611225777681e-5*x_87 - 6.95756372515235e-5*x_88 - 8.0565502034534e-6*x_89 - 0.000122811245406*x_9 - 4.94646551232737e-5*x_90 - 5.78318579798623e-5*x_91 - 1.68282851974385e-5*x_92 - 6.13443353093406e-5*x_93 - 5.52852854499518e-5*x_94 - 0.000237591191956607*x_95 - 0.000105009756300478*x_96 - 3.95853530427641e-5*x_97 - 4.73428362538255e-5*x_98 - 0.000285171290938294*x_99 - 2.77435291153615e-5*std::sin(1.0998398065567*x_67 + 5.22312021255493) + 0.0605525187323303);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-5.82585039365838e-7*x_1 + 0.000149680215829613*x_10 - 9.60929514605849e-5*x_100 + 3.72861108095784e-5*x_101 - 9.69909459505502e-5*x_102 - 4.09054930823072e-5*x_103 + 5.85228735653097e-6*x_104 - 0.00024452027837622*x_105 - 0.000307860523547664*x_106 + 0.000161161859736677*x_107 - 0.000114728911481632*x_108 - 0.000101087884501265*x_109 + 2.63905849438664e-5*x_11 - 2.59312154667159e-5*x_110 - 6.09529979944245e-5*x_111 + 0.000325520135720281*x_112 - 0.000179938616804939*x_113 - 9.77791149701714e-5*x_114 + 5.77354315367815e-5*x_115 - 0.000121902598743285*x_116 + 3.03635968801681e-6*x_117 + 3.81627646366142e-5*x_118 - 4.7811490036798e-5*x_119 + 5.56897553985088e-5*x_12 - 3.3863810436328e-5*x_120 - 0.00014702940586564*x_13 + 9.30445274254732e-5*x_14 + 2.88889380435191e-5*x_15 - 7.03379429075512e-5*x_16 - 6.33173218024937e-5*x_17 - 1.86978487329901e-5*x_18 + 3.54839663989034e-5*x_19 - 8.46504709687707e-5*x_2 + 0.00010115870501469*x_20 - 9.71309128478263e-5*x_21 - 0.00039711979471608*x_22 + 5.12377412223445e-6*x_23 + 0.000266999459955232*x_24 + 6.50801124703283e-5*x_25 + 0.000415206087120783*x_26 + 0.000400101961121832*x_27 + 0.000283611709694883*x_28 + 9.30635543654687e-5*x_29 - 1.46292966951177e-5*x_3 - 0.00114238582873574*x_30 + 8.87584848451833e-5*x_31 + 1.40817274322349e-5*x_32 - 3.16440118521542e-5*x_33 - 0.000201285046673528*x_34 - 0.000141960899026986*x_35 - 0.000367642179527952*x_36 - 0.000204805651816522*x_37 - 0.000234669489291702*x_38 - 0.000191322893664447*x_39 - 2.17717704188608e-5*x_4 - 0.000154307396035865*x_40 - 5.88754450560689e-5*x_41 - 0.000158792055848704*x_42 - 0.00016438121283146*x_43 - 0.00011591495250101*x_44 - 0.000131167081670468*x_45 - 0.000271799471254736*x_46 + 0.000119707460736166*x_47 - 0.000189607357635742*x_48 - 0.00029131359175912*x_49 - 1.21512398369724e-5*x_5 + 0.000101569214223479*x_50 + 7.40219900828633e-5*x_51 + 6.95783054113657e-5*x_52 + 4.20572191641537e-5*x_53 + 0.00032036276033734*x_54 + 0.000445543287276873*x_55 + 0.00096935671770907*x_56 + 4.36817960536022e-5*x_57 + 0.000313183066168035*x_58 + 0.000263947857533735*x_59 - 9.5820456200156e-5*x_6 - 7.70901873463857e-5*x_60 + 3.06880036663379e-5*x_61 - 2.29585497245959e-5*x_62 + 1.57503794769575e-5*x_63 - 4.28173316908912e-7*x_64 - 0.00010543710558699*x_65 - 0.000157912733359733*x_66 + 1.98793893957697e-5*x_67 + 0.00019055389795154*x_68 - 4.80516958679989e-5*x_69 - 4.3632337374315e-5*x_7 + 0.000107962235639214*x_70 - 9.14797573360524e-6*x_71 + 8.05194610049985e-5*x_72 + 2.04738508236418e-5*x_73 - 5.51665291148286e-6*x_74 + 6.47924327298619e-5*x_75 + 4.94759730671351e-5*x_76 - 3.25206413285768e-5*x_77 - 4.42355804392601e-5*x_78 - 3.60859930718302e-5*x_79 - 3.35390139255078e-5*x_8 - 1.33972197096343e-5*x_80 + 7.87296820379233e-6*x_81 - 5.54289390393794e-5*x_82 - 4.02787706834165e-5*x_83 - 4.12349683485413e-5*x_84 - 5.70462312616056e-5*x_85 + 1.13933412136812e-5*x_86 - 8.34584783125043e-6*x_87 - 6.61647801563147e-5*x_88 + 1.06093963790864e-5*x_89 - 0.000108769011948584*x_9 - 5.21473649889053e-6*x_90 - 6.83548538157072e-5*x_91 + 1.46073076208717e-5*x_92 - 2.67749049904274e-5*x_93 - 0.000117199902064022*x_94 - 5.43171681897284e-5*x_95 + 0.000132469671605994*x_96 - 0.000128585902140064*x_97 - 4.67800068328375e-5*x_98 - 0.000359764205367318*x_99 - 5.59370519896063e-5*std::sin(1.0998398065567*x_67 + 5.22312021255493) + 0.0102714674931369);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (4.99993539951037e-5*x_1 + 3.56523877212337e-5*x_10 + 5.09261976769037e-5*x_100 - 2.59826356774156e-5*x_101 + 2.90059149705288e-5*x_102 + 2.66088777024253e-5*x_103 - 2.76757899048551e-5*x_104 + 0.000123721733097992*x_105 + 0.000308349073692839*x_106 - 0.00012668654689786*x_107 + 0.000102798584079432*x_108 + 0.000103030203579759*x_109 + 5.44307617533433e-5*x_11 + 0.000107230453371743*x_110 + 9.7303494993035e-5*x_111 - 7.85915505154774e-5*x_112 + 0.000169259778560496*x_113 + 4.07298690432928e-5*x_114 - 5.03094013099041e-5*x_115 + 0.000130953355088365*x_116 - 6.21683092995216e-5*x_117 - 4.51892107567305e-5*x_118 + 2.77148874590035e-5*x_119 + 5.98380927050638e-5*x_12 - 1.99464735096286e-5*x_120 + 0.000821006208680236*x_13 + 1.53760889990578e-5*x_14 - 2.11280960663374e-5*x_15 + 8.65609671735923e-5*x_16 + 5.48928727315882e-5*x_17 + 0.000103531520477654*x_18 + 3.77115863072544e-5*x_19 + 0.000113983659894951*x_2 + 7.14418074708047e-5*x_20 + 7.3630383407222e-5*x_21 + 0.000387687411216825*x_22 + 1.32830986802398e-5*x_23 - 0.000156787660450066*x_24 - 6.98352653197738e-5*x_25 - 0.000240813046220825*x_26 + 0.000139598782966369*x_27 - 0.000228574777895315*x_28 - 5.89085849279378e-5*x_29 + 7.86466285718949e-5*x_3 + 0.000210937060325205*x_30 - 9.66356534850937e-5*x_31 - 4.08515847864496e-5*x_32 + 0.000166156278777525*x_33 + 0.000153191402965394*x_34 + 9.29808690388557e-5*x_35 - 4.25271023784852e-5*x_36 + 0.000211146266462821*x_37 + 0.00016250373360553*x_38 + 0.000181363819478762*x_39 + 2.32299914700775e-5*x_4 + 0.000146149419595823*x_40 - 3.15640984279767e-5*x_41 + 0.000220978550935775*x_42 + 0.000327564952417102*x_43 + 2.4488900455642e-5*x_44 + 9.43984689880516e-5*x_45 + 0.000273076077684143*x_46 - 1.86502579415665e-5*x_47 + 0.000431818658864047*x_48 + 0.000317194855423659*x_49 - 5.49949366945616e-6*x_5 - 4.25875559111035e-5*x_50 + 0.000201954190147086*x_51 + 4.36715715503892e-5*x_52 + 8.12011273875597e-6*x_53 - 0.00015604402520244*x_54 - 0.000336188330542189*x_55 - 0.000689094408486196*x_56 - 2.858841503762e-5*x_57 - 9.57471931788288e-5*x_58 - 0.000157031943082497*x_59 + 0.000176069996999738*x_6 + 0.000291317427208619*x_60 - 5.29195639819257e-5*x_61 + 4.67913561233507e-5*x_62 - 2.37153153548206e-5*x_63 - 2.73947633825833e-5*x_64 + 4.02925475152697e-5*x_65 + 0.000172987634066119*x_66 - 4.2507595280067e-5*x_67 - 2.96450147039659e-5*x_68 + 6.98143335163833e-5*x_69 + 2.28788073848135e-5*x_7 - 8.40680531987726e-5*x_70 + 1.84209561094626e-5*x_71 - 1.69312386066616e-5*x_72 + 3.24904079421219e-5*x_73 + 4.52717069077368e-6*x_74 - 6.86585555057614e-5*x_75 - 1.08085079488325e-5*x_76 + 4.67994337131992e-5*x_77 + 6.32057019031824e-5*x_78 + 1.92322451902112e-5*x_79 + 7.91997235569928e-5*x_8 - 1.35564635397742e-5*x_80 + 3.7526657725266e-7*x_81 + 8.37678800884697e-5*x_82 + 0.000189361693431391*x_83 + 4.70404344056248e-5*x_84 + 6.60321081003066e-5*x_85 - 4.30172745834715e-6*x_86 + 1.26622384385952e-5*x_87 + 3.58069132826812e-5*x_88 - 4.1388746141118e-5*x_89 + 7.26745719663516e-5*x_9 + 1.95025285840248e-6*x_90 + 4.15450819068591e-5*x_91 + 2.2334825353977e-5*x_92 + 4.54268652798539e-5*x_93 + 0.000155905176833759*x_94 - 2.58076120202655e-5*x_95 - 0.000245601420794716*x_96 + 0.000117886023240711*x_97 + 9.2314115163501e-5*x_98 + 0.000578741508869061*x_99 + 1.79318148046029e-5*std::sin(1.0998398065567*x_67 + 5.22312021255493) + 0.0652055611040583);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.74404919540107e-5*x_1 - 0.00013781644368925*x_10 - 0.000107510423075345*x_100 - 0.000138898719439561*x_101 - 0.000135954265348378*x_102 + 1.63081125535267e-5*x_103 + 5.72326522923669e-5*x_104 - 0.000171631942093631*x_105 - 0.000160004645373283*x_106 + 2.98692455477285e-6*x_107 - 7.44247339851777e-5*x_108 + 2.94301976427582e-5*x_109 + 1.3767949612454e-5*x_11 - 4.68764349619266e-5*x_110 - 0.000173741167069069*x_111 - 6.24398471770748e-5*x_112 - 0.000128663385301182*x_113 - 0.000126652283395399*x_114 - 1.60952213165219e-5*x_115 + 1.14116863508515e-5*x_116 + 9.75621297282102e-6*x_117 + 3.62171144275313e-5*x_118 - 5.22205046546351e-5*x_119 - 4.42750878626915e-5*x_12 - 9.67422834921174e-6*x_120 - 0.000134960511597436*x_13 - 0.000120555014904563*x_14 - 0.000109304387791313*x_15 - 7.02445032767407e-5*x_16 - 8.5797346429044e-5*x_17 - 0.000262420069368763*x_18 - 0.000609873088192959*x_19 - 5.96166685176527e-5*x_2 - 0.000361294329637441*x_20 - 0.000119128022069019*x_21 - 0.000852893521049243*x_22 - 0.000146516469645777*x_23 - 6.07906239001738e-5*x_24 + 3.03953776209122e-5*x_25 + 0.000255778772424872*x_26 + 5.37320469890201e-5*x_27 - 0.000125033080231941*x_28 + 0.000254755886092409*x_29 - 2.67435215778511e-5*x_3 - 0.00101778120808495*x_30 + 2.8623225561075e-5*x_31 - 0.000102894421966327*x_32 - 0.000414120122395255*x_33 - 0.000176046973722051*x_34 - 0.000207668660300198*x_35 - 0.000244136991139605*x_36 + 2.50077587443207e-5*x_37 - 0.000263917529025052*x_38 - 0.000152605899626869*x_39 - 7.30740393440257e-5*x_4 - 0.000209519214073326*x_40 - 0.000154643576789545*x_41 - 0.000436032868274761*x_42 - 0.000478430041272517*x_43 - 0.000121034508925362*x_44 - 8.18976903910423e-5*x_45 - 0.000546558946427042*x_46 + 3.17082222229758e-5*x_47 - 0.000102764885942574*x_48 - 5.10652098607298e-5*x_49 - 4.27517279520598e-5*x_5 - 0.000192945925598403*x_50 - 2.96333728616071e-5*x_51 - 8.25017887480105e-5*x_52 - 9.72832333908665e-5*x_53 + 0.000183695702725623*x_54 - 5.54415502833121e-5*x_55 - 9.17872677730097e-5*x_56 + 5.37502108060327e-5*x_57 + 0.000112521650818027*x_58 + 2.64571701254914e-5*x_59 - 4.53981125607289e-5*x_6 + 5.15315259213142e-6*x_60 + 0.000107793561229399*x_61 + 1.6831323901578e-5*x_62 + 1.3972654448343e-5*x_63 + 4.43328300577138e-5*x_64 - 0.000135001034221756*x_65 - 3.26730373362358e-5*x_66 + 4.9401857197857e-5*x_67 + 7.79381878549457e-6*x_68 - 8.3837650457525e-6*x_69 + 1.31872555437986e-6*x_7 + 1.76212216652847e-5*x_70 + 2.47180869372108e-5*x_71 - 2.29147028181432e-5*x_72 + 2.31110867924938e-6*x_73 + 2.48234458214089e-5*x_74 + 0.00011958391144268*x_75 + 8.88373455077614e-6*x_76 + 1.0720563437147e-7*x_77 + 1.50163904164978e-5*x_78 - 3.05701299075632e-5*x_79 - 7.59977176406966e-5*x_8 - 4.42985428834736e-5*x_80 + 3.13379910806162e-5*x_81 - 3.02012430906778e-5*x_82 + 1.45010509756538e-5*x_83 + 2.72139827054838e-5*x_84 + 4.18009412794586e-5*x_85 + 6.75988886226507e-6*x_86 + 7.67125441965701e-5*x_87 + 9.90485297045445e-6*x_88 + 1.89583411430222e-5*x_89 - 5.44430678996129e-5*x_9 - 3.3287421272405e-5*x_90 - 1.62912000437576e-5*x_91 - 0.00018217490923135*x_92 - 0.000135904714336682*x_93 - 0.000117622390738714*x_94 - 9.73484353322795e-5*x_95 + 3.39458362813733e-5*x_96 - 7.68654933200798e-5*x_97 - 0.000123415322730809*x_98 - 0.000945287856803872*x_99 - 1.26512623534743e-5*std::sin(1.0998398065567*x_67 + 5.22312021255493) + 0.0225601377497671);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-4.82868972829549e-5*x_1 - 0.000263899075127628*x_10 + 7.70657349235502e-5*x_100 - 3.08476744551837e-5*x_101 + 6.39525997892202e-5*x_102 + 0.000101592818623927*x_103 + 7.33823446892208e-5*x_104 + 0.000252717201791983*x_105 + 7.30011862915225e-5*x_106 - 4.65814028490154e-5*x_107 - 2.90592654933411e-6*x_108 + 2.56741436138992e-5*x_109 - 9.21476984794156e-5*x_11 - 8.7210270283686e-5*x_110 - 5.17110613166221e-5*x_111 - 0.000427567430718417*x_112 - 1.88747872415092e-5*x_113 + 3.91200343532522e-5*x_114 - 2.49512651131256e-5*x_115 - 6.07362339236744e-5*x_116 + 4.12620264258344e-5*x_117 - 9.74577788702724e-6*x_118 - 1.13140461499138e-5*x_119 - 0.000133770808641165*x_12 + 3.88880833641037e-5*x_120 - 0.00075666273829599*x_13 - 0.000160425842229507*x_14 - 7.66344996342573e-5*x_15 - 4.93627791666979e-5*x_16 - 7.96834129226112e-5*x_17 - 0.000192545501421703*x_18 - 0.000363423609828348*x_19 - 2.71323184577097e-5*x_2 - 0.000430267987816507*x_20 + 5.17219558979967e-6*x_21 - 0.000150387527231349*x_22 - 8.06734528032521e-5*x_23 - 0.000257685486216787*x_24 - 1.30896763453899e-5*x_25 - 0.000196374608212529*x_26 - 0.000762949805527963*x_27 - 0.000216095316718101*x_28 - 2.50611689089748e-6*x_29 - 9.53263037353769e-5*x_3 + 0.000967273958330461*x_30 + 1.39274976130588e-5*x_31 + 2.83136886775501e-5*x_32 - 0.000233476195983237*x_33 + 4.85299281986276e-5*x_34 + 5.88239001680921e-6*x_35 + 0.000287850295809698*x_36 - 5.03149646857316e-6*x_37 + 5.08708244856413e-5*x_38 + 5.86093785620382e-6*x_39 - 4.68252884173057e-5*x_4 - 3.23224392308146e-5*x_40 + 9.57489085515573e-5*x_41 - 0.000157571751477535*x_42 - 0.000330385580981239*x_43 + 0.000131622160299479*x_44 - 5.22933573041079e-5*x_45 - 0.000155759491672178*x_46 - 0.000108998916521305*x_47 - 0.000192947677552703*x_48 - 4.17214257872599e-5*x_49 - 2.4715978399686e-5*x_5 - 8.80516757582785e-5*x_50 - 0.000181726836137358*x_51 - 0.000118257955374762*x_52 - 7.09193980019463e-5*x_53 - 0.000315913314989562*x_54 - 0.000314946956152011*x_55 - 0.000457962993738954*x_56 - 4.29594742073495e-5*x_57 - 0.000333221639963156*x_58 - 0.000148326274098414*x_59 - 0.000148637618432465*x_6 - 0.000257510733014501*x_60 + 2.41138007987841e-5*x_61 - 1.36090813213808e-5*x_62 + 2.11141471634348e-5*x_63 + 4.84834226843344e-5*x_64 + 5.81865189649983e-5*x_65 + 3.77425873386356e-5*x_66 + 2.82497544197083e-5*x_67 - 0.00026381518109996*x_68 + 3.61330194567336e-6*x_69 + 9.15925034160159e-6*x_7 - 3.33483670836665e-5*x_70 - 7.21016323245909e-6*x_71 - 5.50717309836294e-5*x_72 - 4.05524102833725e-5*x_73 + 5.8520648238372e-6*x_74 + 3.2585628374304e-5*x_75 - 2.80841047504048e-5*x_76 + 9.66393934449257e-6*x_77 - 6.54301360550912e-6*x_78 + 1.91471718199863e-5*x_79 - 7.03247410079601e-5*x_8 + 2.41655937352119e-5*x_80 + 4.81349558781982e-6*x_81 - 7.76354632503176e-6*x_82 - 0.000148080586557738*x_83 + 6.78023646012861e-6*x_84 + 2.95038282488436e-6*x_85 + 1.4031456148935e-6*x_86 + 1.32738047499541e-5*x_87 + 3.53985738286358e-5*x_88 + 5.00310437376349e-5*x_89 + 1.9778616800179e-5*x_9 - 2.81752681299806e-5*x_90 + 4.04660071671288e-5*x_91 - 3.13255136609735e-5*x_92 - 2.82273567083869e-5*x_93 - 3.01631936810449e-5*x_94 + 4.59439690540816e-5*x_95 + 0.000113817261415213*x_96 + 4.09378048061541e-5*x_97 - 9.13963482325469e-5*x_98 - 0.000391892235355951*x_99 + 6.08414183363303e-5*std::sin(1.0998398065567*x_67 + 5.22312021255493) + 0.0422041714673465);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (7.14219850460425e-6*x_1 - 0.000233433008810225*x_10 + 0.00017123635339786*x_100 - 4.16621329581238e-6*x_101 + 4.87484784902873e-5*x_102 + 0.000184455024020769*x_103 + 8.78884426519944e-5*x_104 + 0.000525053030244898*x_105 + 0.000233491574378351*x_106 - 0.000141479208060501*x_107 - 2.17863465596154e-5*x_108 + 4.25502120958758e-5*x_109 - 8.50401574857554e-5*x_11 - 6.89643745509995e-5*x_110 + 1.50435061533869e-5*x_111 - 0.000895852701984152*x_112 + 3.03934578592815e-6*x_113 + 1.23558228656723e-5*x_114 - 7.3674879126196e-5*x_115 - 0.000156193574789549*x_116 - 2.31081866492955e-5*x_117 - 6.10516839601212e-5*x_118 - 4.89907776224176e-5*x_119 - 0.000104633707931928*x_12 + 5.07690940644603e-6*x_120 - 0.000486193950809486*x_13 - 0.000141515137334239*x_14 - 6.53347542495122e-5*x_15 - 8.37746929153652e-5*x_16 - 0.000210573616426066*x_17 - 0.000245438512002566*x_18 - 0.000548401357888501*x_19 - 1.9597634600573e-5*x_2 - 0.000584707126245085*x_20 - 5.26848111075147e-6*x_21 - 0.000132257204833959*x_22 - 0.000116375621552112*x_23 - 0.000479912992188552*x_24 - 0.000139215203405624*x_25 - 0.000346227235834493*x_26 - 0.00115304392926152*x_27 - 0.000494150086311856*x_28 + 1.9362551127663e-5*x_29 - 0.000111724749641423*x_3 + 0.000969916769960313*x_30 + 5.19041156864932e-6*x_31 + 4.66389615990176e-5*x_32 - 0.000197988031259359*x_33 + 7.78983699274688e-5*x_34 - 5.60162976402907e-5*x_35 - 3.43582822290837e-5*x_36 - 2.46276663219653e-5*x_37 + 5.69316528047223e-5*x_38 + 5.89943564982468e-5*x_39 - 0.000107956405074746*x_4 - 3.19352470487298e-5*x_40 + 7.47785977815816e-5*x_41 - 0.000143962877870105*x_42 - 0.000419171276683987*x_43 + 9.59722619811944e-5*x_44 - 0.000214076197395638*x_45 - 0.000290332091418437*x_46 - 0.000218476591794449*x_47 - 2.06618083064126e-5*x_48 - 8.38822122007236e-5*x_49 - 8.02967568525548e-5*x_5 - 6.35498153356383e-5*x_50 + 0.00011089443436029*x_51 - 4.72389865462894e-5*x_52 - 5.0460476338966e-5*x_53 - 0.00060377476281296*x_54 - 0.000709008505682853*x_55 - 0.000627254098856551*x_56 - 0.000142239967096629*x_57 - 0.000524363415485465*x_58 - 0.000226383603134432*x_59 - 0.000153731724206*x_6 - 0.000274710496594297*x_60 - 1.94335495235003e-5*x_61 + 2.10156016354994e-5*x_62 + 3.68205035374779e-5*x_63 + 6.99203425655915e-5*x_64 + 7.4253295061707e-5*x_65 + 0.000159482929443091*x_66 + 9.34466337653873e-6*x_67 - 0.000532844159011085*x_68 + 5.84219975921779e-5*x_69 - 3.29529750139578e-5*x_7 - 3.16792856448329e-5*x_70 - 1.36608561502974e-5*x_71 + 2.30866266172497e-5*x_72 - 2.34067343043339e-5*x_73 - 1.50201072937256e-5*x_74 + 3.4042932849289e-5*x_75 - 1.55579350742543e-6*x_76 + 5.18288149928813e-5*x_77 + 1.33191463023267e-5*x_78 + 2.50018219031647e-5*x_79 - 6.02518967651789e-5*x_8 + 3.46018176983397e-5*x_80 + 3.87767725469733e-6*x_81 + 5.01872093792e-5*x_82 - 5.17308180257377e-5*x_83 + 9.54786111832808e-6*x_84 - 1.87730181065527e-5*x_85 + 1.22053300564559e-5*x_86 + 1.55482551459764e-5*x_87 + 2.14847934550125e-5*x_88 + 6.78185277882854e-5*x_89 + 1.40012957194741e-5*x_9 - 6.53920730564377e-5*x_90 + 6.00182777992663e-5*x_91 + 3.48645917766969e-5*x_92 - 1.02539330551725e-5*x_93 + 7.77074702656922e-6*x_94 - 3.85788576210427e-5*x_95 + 4.45672812715567e-5*x_96 + 0.000144096482560343*x_97 - 0.000104766299025607*x_98 - 0.000168193436738125*x_99 + 0.000124414359236154*std::sin(1.0998398065567*x_67 + 5.22312021255493) - 0.00319932600892572);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000121532495641842*x_1 + 0.00029403140653123*x_10 + 0.000100625480220362*x_100 + 0.000109092828709948*x_101 - 5.28202992769527e-5*x_102 + 4.6386744499266e-5*x_103 - 3.97488539299325e-5*x_104 + 0.000241765445193209*x_105 + 0.000163726307016592*x_106 - 7.66435567351323e-5*x_107 - 3.70065103791024e-5*x_108 - 2.54052475895846e-5*x_109 + 7.30895459449886e-5*x_11 + 8.97667054146827e-5*x_110 + 0.000168314701736596*x_111 - 0.000350448473848834*x_112 + 3.48460741931921e-5*x_113 - 5.72925721055642e-5*x_114 - 4.0053235484179e-5*x_115 - 0.000143375835732141*x_116 - 0.000127664106076738*x_117 - 7.29586554506449e-5*x_118 - 4.88174273592191e-5*x_119 + 0.000157386503791239*x_12 - 8.30399907128671e-5*x_120 + 0.000902172902889414*x_13 + 0.000189962726552034*x_14 + 0.000105850475543173*x_15 - 2.0598587048975e-5*x_16 - 0.000143693277517474*x_17 + 0.000109463348788581*x_18 + 0.000126591551630042*x_19 + 2.27559254705919e-5*x_2 + 0.000165508646457517*x_20 - 1.21745288189882e-5*x_21 + 0.000255587862259945*x_22 + 3.86553491210145e-5*x_23 - 9.13617430295481e-5*x_24 - 0.000178870170778315*x_25 - 6.86985153669986e-5*x_26 - 2.61956630088565e-5*x_27 - 0.000182585938127984*x_28 - 9.81595698851065e-6*x_29 + 3.93981838530877e-5*x_3 - 0.000634746310334505*x_30 - 7.16187006131799e-6*x_31 + 4.19941866537161e-5*x_32 + 0.000310368484589158*x_33 + 9.79116011285058e-6*x_34 - 7.97926842527599e-5*x_35 - 0.0007105295121576*x_36 - 8.77716839102608e-5*x_37 - 1.22603878476187e-5*x_38 + 7.03486993494844e-5*x_39 - 4.99262144067863e-5*x_4 + 3.87099226188008e-5*x_40 - 6.73034551360359e-5*x_41 + 0.000200651898374502*x_42 + 0.000163172551560108*x_43 - 0.000138260238987502*x_44 - 0.000227994571207689*x_45 - 2.90985833253187e-5*x_46 - 7.85972938199496e-5*x_47 + 0.000367046932016353*x_48 - 0.000101204156627362*x_49 - 6.10423394886462e-5*x_5 + 0.000173685125289861*x_50 + 0.000595163954463729*x_51 + 0.000226298432827722*x_52 + 0.000114852870851859*x_53 - 0.00020858387175516*x_54 - 0.000275526080194632*x_55 + 0.000311422068306851*x_56 - 0.000129588461713623*x_57 - 3.08748901619955e-5*x_58 + 3.57850368171483e-5*x_59 + 7.6010013715528e-5*x_6 + 0.000116398422509072*x_60 - 0.000104271606392534*x_61 + 5.16776661455445e-5*x_62 + 1.09684294482098e-5*x_63 - 1.01367475284899e-5*x_64 - 2.75327808946798e-6*x_65 + 0.000131371749363642*x_66 - 5.57022862359027e-5*x_67 - 0.000200688787460068*x_68 + 7.18839233476467e-5*x_69 - 8.28037069008881e-5*x_7 + 4.76050570529056e-5*x_70 - 1.46277439504453e-5*x_71 + 0.000183694305684961*x_72 + 5.66798862213725e-5*x_73 - 4.45791586043316e-5*x_74 - 3.47426852210217e-5*x_75 + 6.93067649768405e-5*x_76 + 5.01659361363069e-5*x_77 + 1.90130627294818e-5*x_78 - 4.29541873177744e-6*x_79 + 7.29083583119445e-5*x_8 + 9.50625631364839e-6*x_80 - 1.1398409638323e-5*x_81 + 8.81240381141353e-5*x_82 + 0.000229568519099696*x_83 - 1.85929641877723e-5*x_84 - 6.24058720768845e-5*x_85 + 1.67887803415156e-5*x_86 - 2.83971305055394e-5*x_87 - 6.43042388207415e-5*x_88 - 7.02801020981382e-6*x_89 - 3.47060846628023e-5*x_9 - 3.13703721588526e-5*x_90 - 9.17170029755065e-6*x_91 + 0.0001757576609548*x_92 + 7.58902782177426e-5*x_93 + 7.89472878901414e-5*x_94 - 0.000147580397262043*x_95 - 0.000154589713287104*x_96 + 0.000120829110369868*x_97 + 5.98281867663399e-5*x_98 + 0.000764333868192462*x_99 + 4.84882757809385e-5*std::sin(1.0998398065567*x_67 + 5.22312021255493) + 0.0195122975996616);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-8.12836372782261e-5*x_1 - 0.000188975159392876*x_10 - 0.000194578013960015*x_100 - 0.000170548392138317*x_101 - 7.13272917345936e-5*x_102 + 2.07571498957983e-5*x_103 + 8.79757607901685e-5*x_104 - 0.000410044461756013*x_105 - 0.000161818999506934*x_106 + 0.000157035067582978*x_107 - 9.63263547427574e-7*x_108 + 7.34741725718046e-5*x_109 + 3.00544848241504e-5*x_11 + 5.82202658232263e-6*x_110 - 0.000210088273653465*x_111 + 0.000696769889945705*x_112 - 0.000124953572091589*x_113 - 6.217606345778e-5*x_114 + 4.63913109796171e-5*x_115 + 0.000146808381929591*x_116 + 5.07691389250084e-5*x_117 + 7.28490172984432e-5*x_118 - 1.51238485797967e-5*x_119 - 3.97298118971271e-5*x_12 - 1.24876634910345e-6*x_120 - 0.000180102373180359*x_13 - 0.000147491385191398*x_14 - 0.00023093858243009*x_15 + 5.0415431105885e-6*x_16 + 6.10307616784278e-5*x_17 - 0.000168094423923883*x_18 - 0.000480623106657266*x_19 + 1.34228577658713e-5*x_2 - 0.000286451066157457*x_20 - 6.48345756978744e-5*x_21 - 0.000683673142879891*x_22 - 0.000116156878765518*x_23 + 0.000137205770042607*x_24 + 0.000222007975862284*x_25 + 0.000418773916514068*x_26 + 0.000728656570456599*x_27 + 0.000141652559579417*x_28 + 0.000146678822526955*x_29 + 1.57773043090404e-5*x_3 - 0.000880007967520225*x_30 + 9.74085547595271e-6*x_31 - 0.00011512445318819*x_32 - 0.000365320125520356*x_33 - 0.000125113141737806*x_34 - 5.93721351945095e-5*x_35 + 6.32711793667366e-5*x_36 + 0.000130650344116068*x_37 - 0.000175874958391557*x_38 - 0.000144010232350528*x_39 + 5.33605276894032e-6*x_4 - 0.000148311228559956*x_40 - 8.02896021856332e-5*x_41 - 0.000343600066336861*x_42 - 0.000208633107273927*x_43 + 6.19413162388774e-5*x_44 + 0.000124570047232538*x_45 - 0.000224502585908937*x_46 + 0.000284684500834142*x_47 - 3.55873051712065e-5*x_48 + 0.000150504021965934*x_49 - 5.40889088851792e-6*x_5 - 0.000191891045471153*x_50 - 0.000217780483053669*x_51 - 0.000126465220683828*x_52 - 0.000106253508918518*x_53 + 0.000420221274471515*x_54 + 0.000323512094200106*x_55 - 0.000138422174570708*x_56 + 0.000178511073173537*x_57 + 0.00030476899342214*x_58 + 9.89340236758912e-5*x_59 - 5.73815636726829e-5*x_6 + 0.000161560628514837*x_60 + 0.000120884130156326*x_61 - 1.52053967506823e-5*x_62 - 1.05896655013793e-5*x_63 - 4.00524276976722e-6*x_64 - 0.000139306343201919*x_65 - 9.74804617277469e-5*x_66 + 5.05098841423435e-5*x_67 + 0.00043943123714038*x_68 - 3.15561423498752e-5*x_69 + 6.19930680232225e-5*x_7 - 2.9941441967742e-5*x_70 + 4.1820015822269e-5*x_71 - 0.000130976631136731*x_72 + 3.17354962151406e-5*x_73 + 6.8710029414908e-5*x_74 + 9.33799824848347e-5*x_75 - 1.15725714477681e-5*x_76 - 1.5074264194923e-5*x_77 + 2.32160773876881e-5*x_78 - 2.57173103136709e-5*x_79 - 6.10479430463962e-5*x_8 - 6.99154871668661e-5*x_80 + 5.0657144931922e-5*x_81 - 5.12114348458017e-5*x_82 - 5.21013091249876e-5*x_83 + 5.36557828377446e-5*x_84 + 0.000120227091396251*x_85 + 1.14123400593256e-6*x_86 + 7.77407781218811e-5*x_87 + 4.0633020614467e-5*x_88 - 1.79487887829207e-5*x_89 - 4.61331959688392e-5*x_9 - 5.9508611705718e-6*x_90 - 2.16427838192864e-5*x_91 - 0.000191651734130025*x_92 - 0.000100846872778079*x_93 - 4.75986733608063e-5*x_94 + 6.26336451171437e-6*x_95 + 2.27652663632203e-5*x_96 - 0.000161074710785111*x_97 - 7.58102402686285e-5*x_98 - 0.00100926543004887*x_99 - 0.000108757863063326*std::sin(1.0998398065567*x_67 + 5.22312021255493) + 0.0571261906872641);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (4.86181116786467e-5*x_1 + 0.000198065136818171*x_10 - 3.88559812739616e-5*x_100 + 1.49541443462773e-5*x_101 - 4.32428204756294e-5*x_102 - 0.000153041331025632*x_103 - 0.000112251876215013*x_104 - 0.000172992463642312*x_105 - 3.97707135920414e-5*x_106 - 7.17992817761829e-5*x_107 + 2.7727976536249e-5*x_108 - 1.91861914326854e-5*x_109 + 5.93144691173951e-5*x_11 + 4.75619762086791e-5*x_110 + 5.81914107724945e-5*x_111 + 9.39058977028396e-5*x_112 + 9.61104581812119e-5*x_113 - 8.48488720824023e-6*x_114 - 9.97217626725252e-6*x_115 + 0.000106285990934092*x_116 - 1.84601640825636e-5*x_117 + 5.11636970749974e-6*x_118 + 4.2588209608361e-5*x_119 + 7.65586542297543e-5*x_12 + 1.96971859491161e-6*x_120 + 0.000637695447481181*x_13 + 0.0001168496247764*x_14 + 0.000143106179202963*x_15 + 6.20635397333425e-5*x_16 + 0.000118064893899143*x_17 + 0.000183455976087113*x_18 + 0.000419337796909971*x_19 + 1.34581197222492e-5*x_2 + 0.00045880728361427*x_20 + 1.83792299807947e-5*x_21 + 0.000241926734350698*x_22 + 8.90661275089478e-5*x_23 + 0.000159002320792261*x_24 - 5.59258722025897e-5*x_25 - 2.39591130221968e-5*x_26 + 0.000380434773278984*x_27 + 0.000107355690436987*x_28 + 7.49097652210637e-6*x_29 + 8.58951456661934e-5*x_3 - 0.000433591654693601*x_30 - 4.03949410288517e-5*x_31 - 3.95967673554316e-5*x_32 + 0.000193360989041917*x_33 + 7.11013580049236e-7*x_34 + 1.83093399489249e-5*x_35 - 3.77561705681526e-5*x_36 + 5.21667731084154e-5*x_37 + 1.07992652072066e-5*x_38 + 4.81694933394362e-5*x_39 + 5.41720271219977e-5*x_4 + 7.39844035247515e-5*x_40 - 9.68409187099009e-5*x_41 + 0.000172422216676565*x_42 + 0.000304898068649466*x_43 - 0.000170236467361802*x_44 + 0.000109163720284449*x_45 + 0.000190422844880623*x_46 - 4.86239324385134e-5*x_47 + 9.99355868529867e-5*x_48 + 8.5212444230946e-5*x_49 + 5.17295249124149e-5*x_5 + 1.69568114157909e-5*x_50 + 3.24236492153637e-5*x_51 + 5.48316380659025e-5*x_52 + 3.98715972913607e-5*x_53 + 0.000209807613922362*x_54 + 0.000133908073267278*x_55 + 0.000120844207096802*x_56 + 1.079211913092e-5*x_57 + 0.000183209761056482*x_58 + 1.97545866552312e-5*x_59 + 0.000212760266708691*x_6 + 0.000196682695904899*x_60 - 1.5670521000568e-5*x_61 + 1.94624504570983e-5*x_62 - 2.49779196559519e-5*x_63 - 3.17885185606182e-5*x_64 - 9.01405728415867e-6*x_65 - 8.47431845700165e-6*x_66 - 2.46670878543104e-5*x_67 + 7.2370928990742e-5*x_68 - 7.29030265688774e-6*x_69 + 5.17474150256e-6*x_7 + 8.89237167460135e-6*x_70 + 4.33265849923996e-6*x_71 + 2.56599741989292e-5*x_72 - 6.66158432738272e-6*x_73 - 1.80002351930199e-5*x_74 - 5.17504787080621e-5*x_75 - 5.994173439512e-6*x_76 - 1.69089380137401e-5*x_77 + 6.77942284055124e-6*x_78 - 7.64549936598818e-6*x_79 + 7.00991627699084e-5*x_8 - 5.87931426947018e-6*x_80 - 2.30965257476513e-5*x_81 + 4.22957116452324e-6*x_82 + 0.000135473144673689*x_83 - 7.26028803745019e-6*x_84 - 1.27951154655663e-5*x_85 - 1.26247991861857e-5*x_86 - 1.33496180587862e-5*x_87 - 1.10875288058624e-5*x_88 - 4.3835711794719e-5*x_89 + 3.81647390897465e-5*x_9 + 4.30517016792006e-5*x_90 - 1.61912657774719e-5*x_91 - 2.1131086964246e-5*x_92 + 4.74488293641075e-6*x_93 + 1.16655660171351e-5*x_94 - 1.88523203805171e-5*x_95 - 0.000117447979116099*x_96 + 3.82559554738195e-6*x_97 + 9.51501056797972e-5*x_98 + 0.00046139885118883*x_99 - 1.38745841805798e-5*std::sin(1.0998398065567*x_67 + 5.22312021255493) + 0.0583044601425234);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-8.05836947067201e-5*x_1 - 0.000215246397393059*x_10 - 0.000152805630373692*x_100 - 0.000143354920537419*x_101 - 9.77763883951565e-5*x_102 - 0.000202776289801448*x_103 - 4.21055368415199e-5*x_104 - 0.00037790568914207*x_105 - 0.000430635579114457*x_106 - 4.63893929423188e-5*x_107 - 6.46990064375797e-5*x_108 - 5.23825158879873e-5*x_109 - 6.69073843324775e-5*x_11 - 0.00017608651761198*x_110 - 0.000238808351154514*x_111 - 0.000114717925078582*x_112 - 8.3550095600828e-5*x_113 - 6.16405896197547e-5*x_114 + 1.68609739162264e-6*x_115 + 0.000110553693312265*x_116 + 0.000136184549328187*x_117 + 9.78623260580365e-5*x_118 + 3.39300533135391e-5*x_119 - 0.0001726202806057*x_12 + 0.000101307050547227*x_120 - 0.00089501809902853*x_13 - 0.000164521100098589*x_14 + 6.22822171988668e-5*x_15 - 4.71732064865101e-5*x_16 + 0.000101541138450112*x_17 - 0.000203404187221244*x_18 - 0.000162768111527607*x_19 - 0.000149282019670591*x_2 - 3.73760952103094e-5*x_20 - 9.48556464760166e-5*x_21 - 0.000761932357939518*x_22 - 6.09451455355158e-5*x_23 + 0.000127820745225062*x_24 + 5.11396002580892e-5*x_25 + 0.000133727156238819*x_26 - 0.000226001464491983*x_27 + 0.000138222489129111*x_28 + 0.000242323031779819*x_29 - 5.0536626030186e-5*x_3 - 0.000242041177333262*x_30 + 3.9971864064477e-5*x_31 - 0.000104473293074101*x_32 - 0.000494702758927426*x_33 - 0.000191821950899424*x_34 - 0.000135986820449514*x_35 + 0.000498895106824817*x_36 - 8.81892282363689e-6*x_37 - 0.000227930743308394*x_38 - 0.000189839942211182*x_39 + 3.96827547879363e-6*x_4 - 0.000181592248811659*x_40 - 0.000119572518069241*x_41 - 0.000446371494222863*x_42 - 0.000491318112035382*x_43 - 0.000197785879009254*x_44 + 0.000133124407483884*x_45 - 0.000407570609313173*x_46 - 0.000138042920936302*x_47 - 0.00063995317998276*x_48 - 0.000118753709167501*x_49 + 7.46514066441132e-5*x_5 - 0.000265095004146098*x_50 - 0.00064313594867732*x_51 - 0.000246283902597983*x_52 - 0.000143253743504477*x_53 + 0.000389983883282595*x_54 + 0.000256250169928562*x_55 + 5.3147397829353e-6*x_56 + 9.96155393255414e-5*x_57 + 0.000128709387137686*x_58 - 1.19354390795403e-5*x_59 + 1.65498222136727e-5*x_6 - 0.000214747949020839*x_60 + 0.000171278241400295*x_61 - 3.13286992573086e-5*x_62 + 2.21837827739243e-7*x_63 + 5.45817833459331e-5*x_64 - 7.51073265493721e-5*x_65 - 0.000200031082052413*x_66 + 8.4086786769832e-5*x_67 - 3.40156664861171e-5*x_68 - 0.000107978961626474*x_69 + 4.72248899033651e-5*x_7 + 3.09645881835243e-5*x_70 + 1.06316534848225e-5*x_71 - 0.000115937640855904*x_72 - 0.000113015969573625*x_73 + 1.07408508652117e-5*x_74 + 9.73397741194003e-5*x_75 - 6.56447320109288e-5*x_76 - 8.35080919060282e-5*x_77 - 4.36633660844896e-5*x_78 - 2.65381439670397e-5*x_79 - 0.000104232511263138*x_8 - 8.87888942859425e-6*x_80 - 9.73531025647639e-6*x_81 - 0.000134482606201793*x_82 - 0.000176777954821952*x_83 - 1.33698262883442e-5*x_84 - 9.41930461502384e-6*x_85 - 2.27544860646776e-5*x_86 + 4.9741548770012e-5*x_87 + 3.32627743355052e-5*x_88 + 2.51811766427476e-5*x_89 + 1.73965656658972e-5*x_9 + 3.9577280189931e-5*x_90 - 2.26552981957326e-5*x_91 - 0.00031501141112019*x_92 - 0.000195424528826531*x_93 - 0.000259628725569069*x_94 + 4.73488647576565e-5*x_95 + 0.00020931874388127*x_96 - 0.000155989193449392*x_97 - 0.000118512197266266*x_98 - 0.00111432201582329*x_99 - 4.38785240497479e-6*std::sin(1.0998398065567*x_67 + 5.22312021255493) + 0.0452804834597274);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-4.95021589183494e-5*x_1 + 5.8612649181566e-5*x_10 - 8.21458720166928e-5*x_100 + 1.73843175415232e-5*x_101 + 9.21095130598145e-5*x_102 + 2.40828714358223e-5*x_103 + 2.71369868876138e-5*x_104 - 0.000252553128687097*x_105 + 5.98616749075341e-5*x_106 + 0.000217151031298843*x_107 + 9.73232695273082e-5*x_108 + 4.43762116275821e-5*x_109 + 4.91318585047643e-5*x_11 + 0.000115475661414092*x_110 + 2.81742149943363e-5*x_111 + 0.00103683903066842*x_112 + 2.02852385468854e-5*x_113 + 8.73287183466467e-5*x_114 + 8.60853206397689e-5*x_115 + 0.000133251008537116*x_116 + 1.33096398297109e-5*x_117 + 2.4854247616037e-5*x_118 + 3.99281733227246e-5*x_119 + 7.36718453701097e-5*x_12 - 1.95629401470714e-5*x_120 + 0.000251772840510221*x_13 + 5.20822704689203e-5*x_14 - 0.000128687335535515*x_15 + 0.00010772095842164*x_16 + 0.000169693423900459*x_17 + 0.000213941482594465*x_18 + 0.000321910115952444*x_19 + 0.000119576318484854*x_2 + 0.000219908914978151*x_20 + 8.66870970832351e-5*x_21 + 0.00043967291568372*x_22 + 7.95523327799487e-5*x_23 + 0.000286765857909142*x_24 + 0.000222632117185847*x_25 + 0.000212555546358723*x_26 + 0.00100786870954612*x_27 + 0.000368966796184611*x_28 - 0.000197813487152772*x_29 + 7.7795596729803e-5*x_3 + 5.41572232653557e-5*x_30 - 2.65930561642668e-5*x_31 + 1.61266817631353e-5*x_32 + 0.000242846821951278*x_33 + 9.10179492051342e-5*x_34 + 0.000212291452731924*x_35 + 0.000205423844648995*x_36 + 0.000102758398186521*x_37 + 0.000148938047433356*x_38 + 4.55018193843725e-5*x_39 + 0.000106170695906111*x_4 + 0.000123252677584924*x_40 + 0.000109388619093059*x_41 + 0.000261277259677269*x_42 + 0.000513379371571069*x_43 + 0.000238404910620621*x_44 + 0.00022176687510675*x_45 + 0.000526551623918843*x_46 + 0.00035552321865856*x_47 + 0.00023359708398229*x_48 + 0.000244744672705299*x_49 + 3.67913402716693e-5*x_5 + 0.000103834463252284*x_50 - 5.07209052598038e-5*x_51 + 3.47390948002731e-5*x_52 + 4.63101189603724e-5*x_53 + 0.000264845510893438*x_54 + 0.000503370166145441*x_55 + 0.000133902662107478*x_56 + 0.000133006876644249*x_57 + 0.000276307309183066*x_58 + 0.000138021282387399*x_59 + 1.28032346821967e-6*x_6 + 0.000262203116614984*x_60 - 3.29453629927294e-5*x_61 - 3.39372196637193e-5*x_62 - 3.25607780174847e-5*x_63 - 8.17253517730867e-5*x_64 + 5.50253255322369e-6*x_65 - 5.53553293509153e-5*x_66 - 2.41890414333456e-5*x_67 + 0.000581860963647798*x_68 - 1.02045262857945e-5*x_69 + 5.59797537894185e-5*x_7 - 4.77850754835723e-5*x_70 + 1.5347544298994e-5*x_71 - 8.4177326029601e-5*x_72 + 6.65940349060874e-5*x_73 + 4.54105388230613e-5*x_74 - 6.35018680542348e-5*x_75 - 1.97715936312211e-6*x_76 - 6.02465834975628e-6*x_77 + 1.31291220891895e-5*x_78 + 7.82695962164191e-6*x_79 + 5.58428298289929e-5*x_8 - 2.86736819515414e-5*x_80 + 2.1285460484771e-5*x_81 + 1.42328080674486e-6*x_82 - 2.51216777285234e-5*x_83 + 2.53094631603192e-5*x_84 + 8.33844355986259e-5*x_85 - 1.79718034656699e-6*x_86 - 2.11628141037127e-5*x_87 + 1.55761766993529e-5*x_88 - 5.81476949529187e-5*x_89 - 2.25432431690978e-6*x_9 + 3.22843037875319e-5*x_90 - 1.37389902192746e-5*x_91 + 8.16604534186797e-5*x_92 + 9.95078888690517e-5*x_93 + 0.000142464838916146*x_94 + 0.000111607897550731*x_95 - 6.41167949889995e-5*x_96 - 7.94739310560855e-5*x_97 + 0.000105146936660382*x_98 + 0.000288967743088254*x_99 - 0.000127613409951069*std::sin(1.0998398065567*x_67 + 5.22312021255493) + 0.0365520489505568);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
