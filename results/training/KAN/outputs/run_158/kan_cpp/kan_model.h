
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (8.34859783246476e-5*x_1 + 3.48114751316842e-5*x_10 - 0.000337574258548328*x_100 + 0.00023196189162167*x_101 + 0.00053220842302715*x_102 + 0.000287634601523823*x_103 - 7.59632358646664e-5*x_104 - 0.000325007428931077*x_105 - 0.000548382741041742*x_106 + 0.000135703226915925*x_107 + 0.000669751372186247*x_108 + 0.000104469227169386*x_109 - 0.000493683464439612*x_11 - 0.000405885737838966*x_110 - 8.53637611739777e-5*x_111 + 0.000908272504680193*x_112 + 9.56773997724756e-5*x_113 + 0.000819275680963584*x_114 - 0.000910695518033698*x_115 + 0.000103016638531749*x_116 - 0.000555536351093557*x_117 - 0.000531658006639971*x_118 - 0.000628319310158848*x_119 + 6.74227072354045e-5*x_12 + 2.63647113610891e-5*x_120 + 7.42868143529617e-5*x_13 - 0.000127861998079878*x_14 + 2.6513736859101e-5*x_15 + 0.00033739703817393*x_16 - 3.47709618094639e-5*x_17 + 5.14539451979373e-5*x_18 - 7.38254293746337e-5*x_19 - 3.80639917962758e-5*x_2 - 0.000235620474563975*x_20 + 9.84619372967667e-5*x_21 - 0.000535786082650378*x_22 - 3.34992846948199e-5*x_23 - 6.16422412979761e-5*x_24 + 0.000671558757645217*x_25 + 3.61518355857976e-5*x_26 - 3.9846887818443e-6*x_27 - 0.000565514195428382*x_28 - 6.10948239310509e-5*x_29 - 0.000108942670896945*x_3 + 0.000506784742422096*x_30 - 5.66644194993683e-5*x_31 + 0.00012349510334774*x_32 - 0.00032008827494455*x_33 + 0.000933832891964096*x_34 + 0.000254748307877789*x_35 - 0.00020088710939324*x_36 - 0.000562003049864783*x_37 + 0.000487551456450676*x_38 + 0.000400841946663987*x_39 - 5.46863224229309e-5*x_4 + 0.00105057040165813*x_40 - 0.000714272174080882*x_41 - 0.000173951800394241*x_42 - 0.000176871783806217*x_43 + 0.000117701495509363*x_44 + 0.000800852877257147*x_45 + 0.000442672676114152*x_46 + 0.000801314926611096*x_47 - 2.15563245743686e-6*x_48 + 0.0019241963999545*x_49 + 0.000155525912354957*x_5 + 0.00184885042083938*x_50 + 0.000321555197270664*x_51 - 0.00190043476228156*x_52 - 0.000790770620720356*x_53 - 0.00202371572038093*x_54 - 0.000115953594371952*x_55 + 0.000655793602675848*x_56 + 0.000890218282984382*x_57 - 0.000387753756954912*x_58 - 0.000586482235827839*x_59 - 0.000106823079789939*x_6 - 3.1413018846512e-5*x_60 + 3.03064518240615e-6*x_61 - 1.7490933954387e-6*x_62 - 3.94112926452799e-5*x_63 - 3.08105444153596e-5*x_64 - 7.33186792798867e-6*x_65 - 1.40774620640003e-5*x_66 - 1.75694915767644e-5*x_67 + 1.1506362649889e-5*x_68 - 4.88060672763794e-5*x_69 - 9.69739026851155e-5*x_7 + 1.41124430568086e-5*x_70 + 3.47604390092989e-5*x_71 - 1.84558991536137e-5*x_72 - 2.49337215774641e-5*x_73 - 9.86849632129234e-6*x_74 + 1.18678820516038e-5*x_75 - 2.03275121961463e-5*x_76 + 8.72661708246324e-5*x_77 - 1.39403987597292e-5*x_78 - 1.43334529515854e-5*x_79 - 0.000253324146449763*x_8 + 2.50089972302739e-6*x_80 + 9.64120624261221e-6*x_81 - 3.1530606783909e-5*x_82 + 2.13417716301594e-5*x_83 + 5.67827243280193e-5*x_84 - 2.56540038760963e-5*x_85 + 2.93853501158483e-5*x_86 + 7.94854207463645e-5*x_87 - 7.42302772163463e-6*x_88 + 3.53825352988571e-5*x_89 + 4.31921156098288e-5*x_9 + 2.97307613144487e-5*x_90 + 0.000202728712624379*x_91 + 4.30724424480641e-5*x_92 - 0.000208367598619576*x_93 + 1.93205103832994e-5*x_94 + 1.01149608418985e-5*x_95 + 0.00019201307624842*x_96 + 0.000651998524184187*x_97 + 0.000463375883921168*x_98 - 0.000383936397918154*x_99 + 3.61786945029905e-8*std::pow(-6.62312030792236*x_10 - 9.87071990966797, 2) + 1.12672695918289e-9*std::pow(-7.36040019989014*x_44 - 6.54855966567993, 2) - 0.000623530481704378*std::sin(0.138000041246414*x_10 - 1.42351984977722) + 0.000131539897747332*std::sin(0.200960010290146*x_10 + 1.78887987136841) - 0.00246156292217586*std::sin(0.316079914569855*x_10 + 7.98695993423462) + 8.22668585792297e-5*std::sin(0.26335996389389*x_100 + 8.17239952087402) - 0.000157952436216762*std::sin(0.269679963588715*x_100 - 7.62152004241943) + 0.000570596238520566*std::sin(0.267759948968887*x_104 - 7.62703990936279) - 0.000257807424413554*std::sin(0.282559931278229*x_108 + 4.9696798324585) + 0.00111625571805275*std::sin(0.257279962301254*x_109 - 7.62152004241943) - 0.000162917626176567*std::sin(0.26063996553421*x_109 - 1.41407990455627) + 0.000294828278761011*std::sin(0.263759940862656*x_11 + 7.98880004882813) + 0.000122811066289936*std::sin(0.297439932823181*x_11 + 7.97616004943848) + 0.00151225865990403*std::sin(0.303839921951294*x_11 - 4.42399978637695) - 1.08368096238328e-5*std::sin(0.351279854774475*x_11 + 5.06895971298218) + 1.86907400078719e-5*std::sin(0.368719846010208*x_11 - 4.56192016601563) + 0.000202225208978618*std::sin(0.217519998550415*x_110 + 1.97559976577759) + 0.000608587557063384*std::sin(0.299279928207397*x_113 - 1.2027999162674) - 0.000185469596851112*std::sin(0.306559920310974*x_113 + 4.98847961425781) + 0.000232941903480205*std::sin(0.275919944047928*x_116 - 4.43304014205933) + 0.00567949196719962*std::sin(0.298799932003021*x_116 - 7.64735984802246) + 3.58168184062367e-5*std::sin(0.34079983830452*x_119 - 4.77639961242676) - 0.00101605292988672*std::sin(0.379839837551117*x_12 + 4.80951976776123) - 0.000204870613696482*std::sin(0.299279928207397*x_13 - 4.42256021499634) - 0.00106930055766541*std::sin(0.360239863395691*x_13 + 1.82303988933563) - 1.62562449500153e-6*std::sin(0.364799857139587*x_13 - 4.56383991241455) - 0.000202910533675935*std::sin(0.367439836263657*x_13 + 8.00944042205811) - 8.82428017073955e-5*std::sin(0.339519828557968*x_14 - 7.54960012435913) - 0.000270304988516415*std::sin(0.347119837999344*x_15 - 1.34447979927063) + 0.000194893128943893*std::sin(0.376879841089249*x_15 + 1.7986398935318) - 1.86052371267876e-6*std::sin(0.309759914875031*x_16 + 1.7869598865509) + 0.00304706564073201*std::sin(0.312959939241409*x_16 + 1.77959990501404) + 0.000202684430701454*std::sin(0.353839844465256*x_16 + 1.81879985332489) - 2.05324469088889e-7*std::sin(0.367599844932556*x_17 - 4.38447999954224) - 0.00108419476171147*std::sin(0.375999838113785*x_17 + 8.1940803527832) - 6.09114137080046e-5*std::sin(0.37967985868454*x_17 - 7.58376026153564) - 0.000786501394827874*std::sin(0.416159868240356*x_17 + 8.00039958953857) - 6.16223697515754e-5*std::sin(0.38663986325264*x_18 + 5.01535987854004) - 0.00109608691841933*std::sin(0.339519828557968*x_19 - 4.35431957244873) + 0.000709542886246978*std::sin(0.305999934673309*x_20 + 4.99823999404907) - 1.75515194166107e-5*std::sin(0.364079833030701*x_20 - 7.58983993530273) + 9.92659350133722e-6*std::sin(0.291439920663834*x_21 + 8.20351982116699) + 0.00300039427568219*std::sin(0.356879830360413*x_21 - 1.38127982616425) + 2.46758706838832e-6*std::sin(0.3713598549366*x_21 - 7.59679985046387) - 0.000162936376146093*std::sin(0.371759831905365*x_21 - 1.39455986022949) - 5.61178011530424e-5*std::sin(0.377679854631424*x_21 - 7.78287982940674) + 1.28398911607764e-5*std::sin(0.411999881267548*x_21 + 7.98016023635864) - 7.2469670363119e-5*std::sin(0.166400015354156*x_22 - 7.81447982788086) + 9.29952996433452e-7*std::sin(0.294319927692413*x_24 - 7.77375984191895) + 0.00145262409542242*std::sin(0.320479929447174*x_24 + 1.57775974273682) - 6.09631522784129e-5*std::sin(0.341279834508896*x_24 - 1.39759981632233) + 2.99805380261748e-5*std::sin(0.223199993371964*x_28 + 1.58655989170074) - 0.000171623668172576*std::sin(0.247759968042374*x_28 - 1.37271988391876) + 0.000148975458413313*std::sin(0.24967996776104*x_28 - 4.58311986923218) - 0.00273045263803105*std::sin(0.186240002512932*x_29 - 1.58527982234955) + 2.67671223020849e-6*std::sin(0.355439841747284*x_29 + 5.01103973388672) - 7.21424726162563e-6*std::sin(0.327199846506119*x_3 - 1.18575978279114) - 8.10200201101999e-5*std::sin(0.374479830265045*x_3 + 1.60391974449158) + 0.000252154193316965*std::sin(0.292399942874908*x_33 + 1.76831984519958) + 0.000376059436142278*std::sin(0.233039990067482*x_38 + 1.79367995262146) + 0.000165711615605592*std::sin(0.307439923286438*x_4 - 7.55136013031006) - 0.00178612636211968*std::sin(0.249119967222214*x_41 - 4.41247987747192) - 0.0101319627372828*std::sin(0.259039968252182*x_42 + 8.17671966552734) - 0.00163221156953533*std::sin(0.278879970312119*x_43 - 1.24959993362427) + 3.68036355937842e-5*std::sin(0.284799933433533*x_44 + 1.55623984336853) - 0.0011077651952034*std::sin(0.245679974555969*x_48 + 4.99599981307983) - 6.37144547938458e-5*std::sin(0.289359927177429*x_48 - 7.82352018356323) + 0.000109628449783603*std::sin(0.428159862756729*x_5 + 1.76775991916656) + 0.00109588336452542*std::sin(0.245119974017143*x_52 + 1.78615987300873) + 0.000402155701552678*std::sin(0.250079959630966*x_53 - 1.40391981601715) - 0.00031261692792162*std::sin(0.270319938659668*x_53 + 4.96719980239868) + 0.000235160513093679*std::sin(0.276479959487915*x_53 - 4.41447973251343) + 0.000451235954856053*std::sin(0.197279989719391*x_56 + 7.98432016372681) + 0.000369990852726718*std::sin(0.284719944000244*x_56 + 8.13599967956543) - 2.08012734358075e-6*std::sin(0.229599997401237*x_57 + 1.58239984512329) + 0.000223093722388546*std::sin(0.174960017204285*x_58 + 1.61359977722168) + 0.00193291067097883*std::sin(0.156480029225349*x_59 + 4.61399984359741) + 0.000141650121051214*std::sin(0.425759851932526*x_6 - 1.21807992458344) + 6.38241232785102e-5*std::sin(0.390319854021072*x_7 + 8.19863986968994) - 0.000131380109509088*std::sin(0.438399881124496*x_7 + 4.7912802696228) - 0.000124080504427069*std::sin(0.325519859790802*x_8 + 1.81727993488312) + 8.64813063025497e-5*std::sin(0.326719850301743*x_8 + 1.61639988422394) + 0.00101828469522318*std::sin(0.363439828157425*x_8 + 5.03832006454468) + 0.000111834831676143*std::sin(0.372399836778641*x_8 - 1.36783981323242) + 1.73776399023016e-6*std::sin(0.38351982831955*x_8 - 1.37175989151001) - 6.43964980553595e-5*std::sin(0.39711982011795*x_8 - 7.78391981124878) + 2.88066641909999e-7*std::sin(0.262079983949661*x_9 - 7.58767986297607) - 0.000118517666428066*std::sin(0.292239934206009*x_9 + 7.77375984191895) - 1.79374169615162e-5*std::sin(0.292479932308197*x_9 - 1.3971198797226) - 0.000412116383404283*std::sin(0.289119929075241*x_95 - 4.40375995635986) + 0.001148348656057*std::sin(0.297679930925369*x_95 - 7.603440284729) + 0.000313088157164628*std::sin(0.305999934673309*x_96 + 8.15655994415283) - 0.000491751151001233*std::sin(0.315039932727814*x_97 - 4.61624002456665) - 3.8181027407532e-5*std::sin(0.259039968252182*x_98 + 1.97967982292175) + 0.0807651388911175);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (5.27487278030309e-5*x_1 - 8.96709867334836e-5*x_10 + 6.19724662531686e-5*x_100 + 0.000301238671503393*x_101 - 0.000673023321889823*x_102 - 0.000831102991644744*x_103 - 0.000179459530862328*x_104 + 0.000255789369343649*x_105 + 0.000498363772137333*x_106 - 0.000727545623277481*x_107 - 7.98832347090746e-5*x_108 + 5.06995012786891e-5*x_109 - 0.000308855889670042*x_11 + 0.0002337344737849*x_110 - 0.0011506323616382*x_111 + 0.00014235313976222*x_112 - 0.000335891137540634*x_113 - 2.26847120074115e-5*x_114 - 0.000411911407652683*x_115 + 0.000222607427617219*x_116 + 0.00028891419514092*x_117 - 0.000156974064535417*x_118 + 0.000441738126383093*x_119 + 5.86172476386815e-5*x_12 + 4.57899802515254e-5*x_120 - 6.91195150773916e-6*x_13 - 4.17981209546594e-5*x_14 - 0.00100777027716284*x_15 + 2.63196351553237e-5*x_16 - 2.07998845325882e-5*x_17 + 4.79783701892426e-5*x_18 + 1.83926932414102e-5*x_19 - 1.99680365721644e-5*x_2 - 6.90224929014737e-5*x_20 + 9.06502409274029e-5*x_21 + 1.10861885033733e-6*x_22 - 6.54585178478869e-5*x_23 + 0.000493155234768485*x_24 - 5.33352782801927e-5*x_25 + 0.000419152626005329*x_26 - 0.000488806567379923*x_27 + 0.000710390796413615*x_28 - 8.15662451241089e-5*x_29 - 5.28210456153061e-5*x_3 - 4.3630240397393e-6*x_30 + 7.97733080760528e-5*x_31 + 6.91432341486837e-5*x_32 - 0.000148053716979463*x_33 + 0.00116910878334009*x_34 - 0.0001604068668579*x_35 + 0.000314425988817138*x_36 - 0.000277637054062317*x_37 + 5.92976248510476e-5*x_38 - 0.000122492273541749*x_39 - 4.86323407041431e-5*x_4 + 0.000134999944043072*x_40 - 0.000132156189338152*x_41 + 0.00046564923421727*x_42 + 0.000197919563403692*x_43 + 0.000140996423115314*x_44 - 6.30596878995354e-5*x_45 + 0.000310775955194461*x_46 - 0.00152736406244411*x_47 + 0.00105840614184748*x_48 + 0.000642812532963261*x_49 - 5.8559868270784e-5*x_5 + 3.58460969587532e-5*x_50 + 0.000859479547175403*x_51 + 0.000829909950216904*x_52 + 0.000637571092033942*x_53 + 0.000333042737229228*x_54 + 4.4010353585686e-5*x_55 + 0.000141890661046385*x_56 - 0.000236591935822138*x_57 - 0.00134860221667705*x_58 + 0.000193273167294079*x_59 + 0.000362039073874142*x_6 + 0.00119762389764618*x_60 - 9.82724794327883e-7*x_61 + 1.12274862379555e-5*x_62 + 8.55825913119732e-5*x_63 - 1.12926483884482e-5*x_64 + 6.41045699283711e-5*x_65 + 1.66675713193176e-5*x_66 - 1.51530657275535e-6*x_67 + 2.13439279237658e-5*x_68 + 5.25127440712055e-7*x_69 + 0.000732464297526296*x_7 - 1.10313683818428e-5*x_70 - 3.109132929491e-6*x_71 + 6.48859238458265e-6*x_72 + 1.39830851253329e-5*x_73 + 2.03705961986693e-5*x_74 - 3.96090036919039e-6*x_75 - 1.54298490837591e-6*x_76 - 0.000331959308521531*x_77 + 8.65806099390076e-6*x_78 + 1.39999187462934e-5*x_79 + 1.61878545475165e-5*x_8 - 1.07922575297063e-6*x_80 - 9.54754509380177e-6*x_81 - 6.53393026782328e-6*x_82 + 2.79048178717459e-5*x_83 + 2.97718343038183e-5*x_84 + 1.62671422084425e-5*x_85 - 1.66617521175068e-5*x_86 + 2.28807902642749e-5*x_87 + 2.83561154863184e-5*x_88 + 2.79534244553727e-5*x_89 - 6.48663791090912e-6*x_9 + 0.000120003765569629*x_90 + 3.07745578119706e-5*x_91 + 0.000175583965459112*x_92 - 6.14720470863198e-5*x_93 + 0.000360191734862435*x_94 + 3.15125393586191e-5*x_95 - 0.000106288782909283*x_96 + 5.4795685413519e-5*x_97 - 0.000554074454071109*x_98 + 0.000306936782653877*x_99 + 9.33749217249659e-9*std::pow(-6.62312030792236*x_10 - 9.87071990966797, 2) - 1.28643263735509e-7*std::pow(-7.36040019989014*x_44 - 6.54855966567993, 2) + 0.00144601631615645*std::sin(0.138000041246414*x_10 - 1.42351984977722) + 2.39405474609852e-5*std::sin(0.200960010290146*x_10 + 1.78887987136841) + 7.72153815199825e-5*std::sin(0.316079914569855*x_10 + 7.98695993423462) + 1.49727471741337e-5*std::sin(0.26335996389389*x_100 + 8.17239952087402) + 0.000366304144942166*std::sin(0.269679963588715*x_100 - 7.62152004241943) - 1.78987121776629e-5*std::sin(0.267759948968887*x_104 - 7.62703990936279) + 0.000597875730323983*std::sin(0.282559931278229*x_108 + 4.9696798324585) - 0.00531139185784403*std::sin(0.257279962301254*x_109 - 7.62152004241943) + 0.000367716260765897*std::sin(0.26063996553421*x_109 - 1.41407990455627) + 0.000285829523419389*std::sin(0.263759940862656*x_11 + 7.98880004882813) - 0.000284808539230347*std::sin(0.297439932823181*x_11 + 7.97616004943848) - 0.00719566153459901*std::sin(0.303839921951294*x_11 - 4.42399978637695) + 1.26346112501417e-6*std::sin(0.351279854774475*x_11 + 5.06895971298218) + 3.40175532977003e-6*std::sin(0.368719846010208*x_11 - 4.56192016601563) - 0.000962232319215837*std::sin(0.217519998550415*x_110 + 1.97559976577759) - 1.9090440461065e-5*std::sin(0.299279928207397*x_113 - 1.2027999162674) - 0.000179808689653247*std::sin(0.306559920310974*x_113 + 4.98847961425781) + 0.000225832045473913*std::sin(0.275919944047928*x_116 - 4.43304014205933) - 0.000178156786136245*std::sin(0.298799932003021*x_116 - 7.64735984802246) - 8.30620239553675e-5*std::sin(0.34079983830452*x_119 - 4.77639961242676) - 0.000949073242162496*std::sin(0.379839837551117*x_12 + 4.80951976776123) - 0.000175967733677916*std::sin(0.299279928207397*x_13 - 4.42256021499634) + 0.00508796880832974*std::sin(0.360239863395691*x_13 + 1.82303988933563) + 0.000185604541491617*std::sin(0.364799857139587*x_13 - 4.56383991241455) + 0.000470565515279051*std::sin(0.367439836263657*x_13 + 8.00944042205811) - 1.60603818198502e-5*std::sin(0.339519828557968*x_14 - 7.54960012435913) - 0.000262054733590053*std::sin(0.347119837999344*x_15 - 1.34447979927063) + 0.000167397859511774*std::sin(0.376879841089249*x_15 + 1.7986398935318) + 0.000212423995632336*std::sin(0.309759914875031*x_16 + 1.7869598865509) - 9.55816866779827e-5*std::sin(0.312959939241409*x_16 + 1.77959990501404) + 0.000196498091958431*std::sin(0.353839844465256*x_16 + 1.81879985332489) + 2.34427778736301e-5*std::sin(0.367599844932556*x_17 - 4.38447999954224) + 0.00515883872892225*std::sin(0.375999838113785*x_17 + 8.1940803527832) - 1.10860097640738e-5*std::sin(0.37967985868454*x_17 - 7.58376026153564) + 3.67863255746281e-6*std::sin(0.416159868240356*x_17 + 8.00039958953857) - 1.12154053101801e-5*std::sin(0.38663986325264*x_18 + 5.01535987854004) + 0.00521542424359313*std::sin(0.339519828557968*x_19 - 4.35431957244873) + 0.000662768786640706*std::sin(0.305999934673309*x_20 + 4.99823999404907) - 3.19441470460086e-6*std::sin(0.364079833030701*x_20 - 7.58983993530273) - 1.15733923803323e-6*std::sin(0.291439920663834*x_21 + 8.20351982116699) - 9.41176789023071e-5*std::sin(0.356879830360413*x_21 - 1.38127982616425) - 0.000281735030338865*std::sin(0.3713598549366*x_21 - 7.59679985046387) - 0.000157963228416334*std::sin(0.371759831905365*x_21 - 1.39455986022949) + 0.000126661727688301*std::sin(0.377679854631424*x_21 - 7.78287982940674) + 2.3368881152615e-6*std::sin(0.411999881267548*x_21 + 7.98016023635864) - 1.31896376120255e-5*std::sin(0.166400015354156*x_22 - 7.81447982788086) - 0.000106176733952095*std::sin(0.294319927692413*x_24 - 7.77375984191895) - 4.55665474657116e-5*std::sin(0.320479929447174*x_24 + 1.57775974273682) - 1.10954262964083e-5*std::sin(0.341279834508896*x_24 - 1.39759981632233) + 5.45652312198233e-6*std::sin(0.223199993371964*x_28 + 1.58655989170074) + 0.000398008809028561*std::sin(0.247759968042374*x_28 - 1.37271988391876) - 1.73690142043681e-5*std::sin(0.24967996776104*x_28 - 4.58311986923218) - 0.00255045722670785*std::sin(0.186240002512932*x_29 - 1.58527982234955) - 0.000305611749650944*std::sin(0.355439841747284*x_29 + 5.01103973388672) + 8.41107417930266e-7*std::sin(0.327199846506119*x_3 - 1.18575978279114) + 0.000385511194411941*std::sin(0.374479830265045*x_3 + 1.60391974449158) + 0.000216580607314944*std::sin(0.292399942874908*x_33 + 1.76831984519958) - 0.0008721114628108*std::sin(0.233039990067482*x_38 + 1.79367995262146) + 0.000160653761954761*std::sin(0.307439923286438*x_4 - 7.55136013031006) + 0.0084987846990762*std::sin(0.249119967222214*x_41 - 4.41247987747192) + 0.000317823835116107*std::sin(0.259039968252182*x_42 + 8.17671966552734) + 0.00776642403752426*std::sin(0.278879970312119*x_43 - 1.24959993362427) - 8.53505307663848e-5*std::sin(0.284799933433533*x_44 + 1.55623984336853) + 0.000347027926702936*std::sin(0.245679974555969*x_48 + 4.99599981307983) + 0.00014380789619497*std::sin(0.289359927177429*x_48 - 7.82352018356323) + 0.000106282367778751*std::sin(0.428159862756729*x_5 + 1.76775991916656) - 0.000343305723583113*std::sin(0.245119974017143*x_52 + 1.78615987300873) + 0.000345420097646206*std::sin(0.250079959630966*x_53 - 1.40391981601715) + 0.000724983287498187*std::sin(0.270319938659668*x_53 + 4.96719980239868) - 0.000530773413435817*std::sin(0.276479959487915*x_53 - 4.41447973251343) - 0.00104645173300067*std::sin(0.197279989719391*x_56 + 7.98432016372681) + 0.000358697983615528*std::sin(0.284719944000244*x_56 + 8.13599967956543) + 0.000237497086834385*std::sin(0.229599997401237*x_57 + 1.58239984512329) - 2.60104454407622e-5*std::sin(0.174960017204285*x_58 + 1.61359977722168) + 0.000498872015929376*std::sin(0.156480029225349*x_59 + 4.61399984359741) - 0.000328497791584635*std::sin(0.425759851932526*x_6 - 1.21807992458344) + 1.16161292404223e-5*std::sin(0.390319854021072*x_7 + 8.19863986968994) - 0.000112845174344628*std::sin(0.438399881124496*x_7 + 4.7912802696228) - 0.000120293316486019*std::sin(0.325519859790802*x_8 + 1.81727993488312) - 1.00828354789413e-5*std::sin(0.326719850301743*x_8 + 1.61639988422394) - 0.00484522403935404*std::sin(0.363439828157425*x_8 + 5.03832006454468) - 0.000259353786323767*std::sin(0.372399836778641*x_8 - 1.36783981323242) - 0.000198407990048777*std::sin(0.38351982831955*x_8 - 1.37175989151001) + 0.000145347314634155*std::sin(0.39711982011795*x_8 - 7.78391981124878) - 3.28898076739948e-5*std::sin(0.262079983949661*x_9 - 7.58767986297607) + 0.000563933297985538*std::sin(0.292239934206009*x_9 + 7.77375984191895) - 3.26464889701779e-6*std::sin(0.292479932308197*x_9 - 1.3971198797226) - 0.000353975539442805*std::sin(0.289119929075241*x_95 - 4.40375995635986) - 0.00546409716259929*std::sin(0.297679930925369*x_95 - 7.603440284729) - 0.000726076105241718*std::sin(0.305999934673309*x_96 + 8.15655994415283) + 0.00233986085560186*std::sin(0.315039932727814*x_97 - 4.61624002456665) + 1.78580701092673e-7*std::sin(0.259039968252182*x_98 + 1.97967982292175) + 0.0335088051007961);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-9.5681791703932e-5*x_1 - 0.000464612264889036*x_10 + 0.000630678836619785*x_100 + 0.00133394389176903*x_101 - 0.00404852213578327*x_102 - 0.0055378700074863*x_103 - 0.00258220342608486*x_104 + 0.00102875088613176*x_105 + 0.00269385584467742*x_106 - 0.00432248824322048*x_107 - 0.000611005038114618*x_108 + 5.08133759818458e-5*x_109 - 0.000180758017288957*x_11 - 0.000773885611103148*x_110 - 0.00692642714358109*x_111 + 0.000608766896229078*x_112 - 0.00228313822406806*x_113 - 0.00130717077062682*x_114 - 0.00331595928775505*x_115 + 0.000626890710395814*x_116 + 0.000197309561302906*x_117 - 0.00054761582453109*x_118 + 0.00239932685012646*x_119 - 0.000534398296021762*x_12 + 0.000138922415296249*x_120 - 6.77668525285576e-6*x_13 + 0.000343502144470457*x_14 - 0.00587567742758088*x_15 - 0.000136406770973286*x_16 - 0.000101504163049525*x_17 - 0.000481533672248156*x_18 + 7.28936507372314e-5*x_19 - 8.9347362123253e-5*x_2 - 0.000290799046965847*x_20 + 0.000186853023914153*x_21 - 0.000261859150136482*x_22 - 0.000381860271600055*x_23 + 0.00286585627590956*x_24 + 0.000248371813065959*x_25 + 0.00222559974832229*x_26 - 0.00217893989991819*x_27 + 0.00509374257391011*x_28 - 0.000888171022028615*x_29 + 5.28918539287003e-5*x_3 - 0.0004342707831567*x_30 + 0.000381134942482613*x_31 + 0.000142195417424241*x_32 - 0.000122705953820028*x_33 + 0.00681583093456161*x_34 - 0.00122661520554031*x_35 + 0.00249916093329357*x_36 + 0.000795348888747709*x_37 + 0.00130285470052863*x_38 - 0.00181096257227877*x_39 - 9.83545198521484e-5*x_4 - 5.22681394515377e-5*x_40 + 2.78895896578232e-5*x_41 + 0.00343254321422868*x_42 - 0.00031082452439747*x_43 - 5.96782602314085e-6*x_44 - 0.00106279302448052*x_45 - 0.000337177896284951*x_46 - 0.00727917261339918*x_47 + 0.00872973963537809*x_48 + 0.00234407118650325*x_49 - 0.000161720512798368*x_5 + 0.000535506242476015*x_50 + 0.00393080279469683*x_51 + 0.00720868579941627*x_52 + 0.00337705963709045*x_53 + 0.00355047844605777*x_54 - 0.00143278800491137*x_55 + 0.00350498872192957*x_56 - 0.000165156080867812*x_57 - 0.00747749441991567*x_58 + 0.00317859804981603*x_59 + 0.00193222882188274*x_6 + 0.00695494765221373*x_60 + 1.83971458813686e-5*x_61 - 1.01187172167525e-5*x_62 + 0.000484888965694955*x_63 - 5.68379739263164e-5*x_64 + 0.000414696985700101*x_65 + 3.62638597284992e-5*x_66 + 1.90833313686579e-5*x_67 + 7.26837367836047e-5*x_68 + 4.32176673215067e-5*x_69 + 0.00401100587686394*x_7 + 2.26883720585392e-5*x_70 - 2.19393818672938e-5*x_71 + 8.0355066777818e-6*x_72 + 0.000129154057848813*x_73 + 0.000101763964081846*x_74 - 1.48602901860736e-5*x_75 + 2.65829505438072e-5*x_76 - 0.00194104974312477*x_77 + 4.57074080713029e-5*x_78 + 0.000115945123344798*x_79 - 3.07903181852306e-5*x_8 + 4.50029451243544e-6*x_80 - 0.000114008433165482*x_81 - 4.72859206615529e-5*x_82 + 0.000264459965026887*x_83 + 8.97287363953089e-5*x_84 + 9.4578475175347e-5*x_85 - 8.13195364311553e-5*x_86 - 2.22851491095271e-5*x_87 + 0.000158966107679374*x_88 + 0.000173295403483503*x_89 + 3.79264814326262e-6*x_9 + 0.000686119081620227*x_90 + 0.000147833809582323*x_91 + 0.000456961508758645*x_92 + 9.22244313954933e-5*x_93 + 0.00103601584487802*x_94 - 5.92328296287923e-5*x_95 - 1.84935493901592e-5*x_96 - 0.000139521062173738*x_97 - 0.00286784048569495*x_98 + 0.0019212774365673*x_99 - 7.19342194406735e-10*std::pow(-6.62312030792236*x_10 - 9.87071990966797, 2) + 1.63870640363012e-8*std::pow(-7.36040019989014*x_44 - 6.54855966567993, 2) - 0.00166540794566807*std::sin(0.138000041246414*x_10 - 1.42351984977722) + 0.00038358907956342*std::sin(0.200960010290146*x_10 + 1.78887987136841) + 0.000308637835742572*std::sin(0.316079914569855*x_10 + 7.98695993423462) + 0.00023990187845209*std::sin(0.26335996389389*x_100 + 8.17239952087402) - 0.000421880325070847*std::sin(0.269679963588715*x_100 - 7.62152004241943) - 7.15429967494687e-5*std::sin(0.267759948968887*x_104 - 7.62703990936279) - 0.000688586277124643*std::sin(0.282559931278229*x_108 + 4.9696798324585) - 0.0311592723707139*std::sin(0.257279962301254*x_109 - 7.62152004241943) + 3.37653388564953e-5*std::sin(0.26063996553421*x_109 - 1.41407990455627) + 0.000964383547918927*std::sin(0.263759940862656*x_11 + 7.98880004882813) + 0.000328020091425453*std::sin(0.297439932823181*x_11 + 7.97616004943848) - 0.0422133376043263*std::sin(0.303839921951294*x_11 - 4.42399978637695) - 3.54191599974212e-6*std::sin(0.351279854774475*x_11 + 5.06895971298218) + 5.45048603409317e-5*std::sin(0.368719846010208*x_11 - 4.56192016601563) - 0.00564493445801235*std::sin(0.217519998550415*x_110 + 1.97559976577759) - 7.63064574867216e-5*std::sin(0.299279928207397*x_113 - 1.2027999162674) - 0.000606671207368668*std::sin(0.306559920310974*x_113 + 4.98847961425781) + 0.000761953162299354*std::sin(0.275919944047928*x_116 - 4.43304014205933) - 0.000712111030387297*std::sin(0.298799932003021*x_116 - 7.64735984802246) + 9.56643110682396e-5*std::sin(0.34079983830452*x_119 - 4.77639961242676) + 1.74680169351459e-5*std::sin(0.379839837551117*x_12 + 4.80951976776123) + 0.0012386678127743*std::sin(0.299279928207397*x_13 - 4.42256021499634) + 0.0298485613857147*std::sin(0.360239863395691*x_13 + 1.82303988933563) - 2.36430063925058e-5*std::sin(0.364799857139587*x_13 - 4.56383991241455) - 0.000541960377173456*std::sin(0.367439836263657*x_13 + 8.00944042205811) - 0.000257328579881185*std::sin(0.339519828557968*x_14 - 7.54960012435913) - 0.000884167844893032*std::sin(0.347119837999344*x_15 - 1.34447979927063) - 0.00117834296192093*std::sin(0.376879841089249*x_15 + 1.7986398935318) - 2.70593695945946e-5*std::sin(0.309759914875031*x_16 + 1.7869598865509) - 0.000382049849812409*std::sin(0.312959939241409*x_16 + 1.77959990501404) + 0.00066298094337905*std::sin(0.353839844465256*x_16 + 1.81879985332489) - 2.98622944605784e-6*std::sin(0.367599844932556*x_17 - 4.38447999954224) + 0.030264319668616*std::sin(0.375999838113785*x_17 + 8.1940803527832) - 0.00017762635914497*std::sin(0.37967985868454*x_17 - 7.58376026153564) + 4.04131601416395e-6*std::sin(0.416159868240356*x_17 + 8.00039958953857) - 0.000179699608243028*std::sin(0.38663986325264*x_18 + 5.01535987854004) + 0.0305962785055945*std::sin(0.339519828557968*x_19 - 4.35431957244873) - 1.21984857172317e-5*std::sin(0.305999934673309*x_20 + 4.99823999404907) - 5.11827308159341e-5*std::sin(0.364079833030701*x_20 - 7.58983993530273) + 3.24441985840545e-6*std::sin(0.291439920663834*x_21 + 8.20351982116699) - 0.000376198059890503*std::sin(0.356879830360413*x_21 - 1.38127982616425) + 3.58884705609181e-5*std::sin(0.3713598549366*x_21 - 7.59679985046387) - 0.00053296502348133*std::sin(0.371759831905365*x_21 - 1.39455986022949) + 1.163064191569e-5*std::sin(0.377679854631424*x_21 - 7.78287982940674) + 3.7442951654998e-5*std::sin(0.411999881267548*x_21 + 7.98016023635864) - 0.000211331882013852*std::sin(0.166400015354156*x_22 - 7.81447982788086) + 1.3525192753315e-5*std::sin(0.294319927692413*x_24 - 7.77375984191895) - 0.000182134185122674*std::sin(0.320479929447174*x_24 + 1.57775974273682) - 0.00017777723618639*std::sin(0.341279834508896*x_24 - 1.39759981632233) + 8.74275195831963e-5*std::sin(0.223199993371964*x_28 + 1.58655989170074) - 0.000458395265389478*std::sin(0.247759968042374*x_28 - 1.37271988391876) + 4.86913194970757e-5*std::sin(0.24967996776104*x_28 - 4.58311986923218) + 4.69420357136885e-5*std::sin(0.186240002512932*x_29 - 1.58527982234955) + 3.89299771037581e-5*std::sin(0.355439841747284*x_29 + 5.01103973388672) - 2.35791332403329e-6*std::sin(0.327199846506119*x_3 - 1.18575978279114) + 0.00226160084402374*std::sin(0.374479830265045*x_3 + 1.60391974449158) - 0.00152454897011497*std::sin(0.292399942874908*x_33 + 1.76831984519958) + 0.00100442944069531*std::sin(0.233039990067482*x_38 + 1.79367995262146) + 0.000542042834088653*std::sin(0.307439923286438*x_4 - 7.55136013031006) + 0.0498581076949694*std::sin(0.249119967222214*x_41 - 4.41247987747192) + 0.00127037461561015*std::sin(0.259039968252182*x_42 + 8.17671966552734) + 0.0455617149719975*std::sin(0.278879970312119*x_43 - 1.24959993362427) + 9.83000333517296e-5*std::sin(0.284799933433533*x_44 + 1.55623984336853) - 0.00115425202966324*std::sin(0.245679974555969*x_48 + 4.99599981307983) + 1.32050791965227e-5*std::sin(0.289359927177429*x_48 - 7.82352018356323) + 0.000358594751492151*std::sin(0.428159862756729*x_5 + 1.76775991916656) + 0.00114187158366659*std::sin(0.245119974017143*x_52 + 1.78615987300873) - 0.00243147279274989*std::sin(0.250079959630966*x_53 - 1.40391981601715) - 0.000834978771667889*std::sin(0.270319938659668*x_53 + 4.96719980239868) - 4.8737970203849e-5*std::sin(0.276479959487915*x_53 - 4.41447973251343) + 0.00120522086191237*std::sin(0.197279989719391*x_56 + 7.98432016372681) + 0.00121024039060845*std::sin(0.284719944000244*x_56 + 8.13599967956543) - 3.0253274500185e-5*std::sin(0.229599997401237*x_57 + 1.58239984512329) + 7.29162227813081e-5*std::sin(0.174960017204285*x_58 + 1.61359977722168) - 3.84321276031442e-5*std::sin(0.156480029225349*x_59 + 4.61399984359741) + 0.000378337938601983*std::sin(0.425759851932526*x_6 - 1.21807992458344) + 0.000186120235165247*std::sin(0.390319854021072*x_7 + 8.19863986968994) + 0.000794337020578096*std::sin(0.438399881124496*x_7 + 4.7912802696228) - 0.000405867434392021*std::sin(0.325519859790802*x_8 + 1.81727993488312) + 2.82656550317124e-5*std::sin(0.326719850301743*x_8 + 1.61639988422394) - 0.0284244995624641*std::sin(0.363439828157425*x_8 + 5.03832006454468) + 0.000298703307602214*std::sin(0.372399836778641*x_8 - 1.36783981323242) + 2.52739579503195e-5*std::sin(0.38351982831955*x_8 - 1.37175989151001) + 1.33464354289959e-5*std::sin(0.39711982011795*x_8 - 7.78391981124878) + 4.1896277258909e-6*std::sin(0.262079983949661*x_9 - 7.58767986297607) + 0.00330831384713139*std::sin(0.292239934206009*x_9 + 7.77375984191895) - 5.23080630276137e-5*std::sin(0.292479932308197*x_9 - 1.3971198797226) + 0.00249169605161682*std::sin(0.289119929075241*x_95 - 4.40375995635986) - 0.0320551178121108*std::sin(0.297679930925369*x_95 - 7.603440284729) + 0.00083623739325667*std::sin(0.305999934673309*x_96 + 8.15655994415283) + 0.0137267902012533*std::sin(0.315039932727814*x_97 - 4.61624002456665) + 1.96187315768284e-7*std::sin(0.259039968252182*x_98 + 1.97967982292175) - 0.112312687158367);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.25762335626033e-5*x_1 + 0.000151452456127492*x_10 + 0.000242676065712891*x_100 + 0.000185000286603644*x_101 + 0.000176548188755021*x_102 + 6.12174927389794e-5*x_103 + 0.000671041019068156*x_104 + 0.000402403030119211*x_105 + 0.00038056460540168*x_106 + 7.69943931445584e-7*x_107 + 0.000238123592494988*x_108 + 0.000170547169821158*x_109 - 0.000213878031297361*x_11 - 0.000623076073616916*x_110 - 0.000406965828907399*x_111 + 0.00048146535274208*x_112 - 0.0001801300507481*x_113 + 0.000975058730850497*x_114 - 0.000423685216365466*x_115 + 0.000149906384962446*x_116 - 0.00055658082785621*x_117 - 0.000580755719729447*x_118 - 0.0005007711953384*x_119 + 5.55205631650077e-5*x_12 - 0.000117156671905586*x_120 + 0.000132981571387959*x_13 - 0.000226087318679578*x_14 - 0.000177547005322243*x_15 + 0.000187744183266914*x_16 - 0.000352740729944316*x_17 + 0.000120597905440862*x_18 + 0.000178680931447746*x_19 + 5.4082388440302e-5*x_2 + 9.36731939007219e-6*x_20 + 1.0629277005769e-5*x_21 - 0.000313731899813234*x_22 - 0.000121988881697817*x_23 + 0.000446834198525017*x_24 + 0.000331441329661021*x_25 + 0.000197319478948908*x_26 - 0.000133379700585251*x_27 - 0.000141956121752021*x_28 - 0.000289122021323135*x_29 + 6.42913046161134e-5*x_3 + 9.54722394407293e-5*x_30 + 5.64329372102559e-6*x_31 + 9.00897937343952e-5*x_32 + 4.67406081343456e-5*x_33 + 0.00145761571953386*x_34 - 0.000655395562341232*x_35 - 0.000293945650982595*x_36 - 0.000373518461327157*x_37 - 0.00063416051112659*x_38 + 0.000259598853053789*x_39 + 3.95657110786126e-5*x_4 + 0.000409847259520998*x_40 - 8.11936542928116e-5*x_41 + 0.00127701036219213*x_42 - 9.29631731069031e-5*x_43 + 0.000366123415092759*x_44 + 0.000264947060592101*x_45 + 0.000436084785861923*x_46 + 0.000739508467771123*x_47 - 0.000314262304107086*x_48 + 0.00160545353085881*x_49 + 9.37647667369575e-5*x_5 + 0.000202513476392184*x_50 - 0.000327499496579461*x_51 - 0.00019355783241215*x_52 - 0.000282098993338033*x_53 - 0.00035989117696263*x_54 - 0.00018711203466521*x_55 + 0.000710186453659858*x_56 + 0.000510370314788822*x_57 - 0.000683820925533721*x_58 + 0.000164495844015061*x_59 + 8.14058671456145e-5*x_6 + 0.000368310801399058*x_60 + 2.44249954419512e-6*x_61 - 1.369352266254e-5*x_62 + 9.45821795861201e-6*x_63 - 1.6928893344618e-5*x_64 - 1.28065726068674e-5*x_65 - 1.11167008934503e-5*x_66 + 7.86118809282216e-6*x_67 + 1.43298389984242e-6*x_68 + 1.10232059776905e-5*x_69 - 0.000136233275848716*x_7 - 5.48500206874885e-6*x_70 + 1.35749554679467e-5*x_71 - 1.10367837541762e-5*x_72 - 2.32190068373712e-5*x_73 + 1.90233721785628e-5*x_74 + 6.67557030939511e-6*x_75 - 1.15149158606478e-5*x_76 + 1.54532210985233e-5*x_77 - 8.76232300620885e-6*x_78 - 1.52979598791899e-5*x_79 - 7.02265347218123e-5*x_8 + 9.33303247215765e-7*x_80 + 6.85508543360215e-6*x_81 - 8.21751941312886e-6*x_82 + 3.2647798379789e-6*x_83 + 3.01530386116838e-6*x_84 - 6.08576849953986e-6*x_85 + 4.18308167499311e-5*x_86 + 3.71005596356106e-5*x_87 + 4.08844729713479e-6*x_88 + 4.08741385946541e-5*x_89 - 3.80456231922976e-5*x_9 + 3.52162373022331e-5*x_90 + 7.61070405038381e-5*x_91 - 3.19133653697794e-5*x_92 - 0.000218037043289809*x_93 + 4.48238196590726e-5*x_94 + 1.46160213387909e-5*x_95 - 1.75356730698005e-5*x_96 + 0.000745353950158351*x_97 + 0.000265589063109822*x_98 - 0.000106369057848772*x_99 + 6.2229134537178e-9*std::pow(-6.62312030792236*x_10 - 9.87071990966797, 2) - 8.74235413723108e-9*std::pow(-7.36040019989014*x_44 - 6.54855966567993, 2) + 0.00371716707013547*std::pow(-0.000140048505468075*x_1 - 0.0235786174894831*x_10 + 0.0234013640363627*x_100 + 0.0536871515689186*x_101 - 0.157321030799679*x_102 - 0.20543627290182*x_103 - 0.089165558438237*x_104 + 0.0507009443064172*x_105 + 0.102566914901581*x_106 - 0.168699839124092*x_107 - 0.0148677176892203*x_108 - 0.265217185783268*x_111 + 0.0276792280914933*x_112 - 0.0858289820564336*x_113 - 0.0445909550170396*x_114 - 0.123843332202768*x_115 + 0.0117521784591501*x_116 + 0.0149556187656929*x_117 + 0.0081747439201579*x_118 + 0.0921364278728087*x_119 - 0.0143922523537691*x_12 + 0.00947436901646085*x_120 + 0.00751653014807299*x_14 - 0.225157679714385*x_15 - 0.00388904117601759*x_16 - 0.0124285247473158*x_18 - 0.00416462274582232*x_2 - 0.0150501906401576*x_20 + 0.0140894631647039*x_21 - 0.0100684631753793*x_22 - 0.0107234674981246*x_23 + 0.107155741377743*x_24 + 0.00294692098465879*x_25 + 0.0846264906676133*x_26 - 0.0910976222042766*x_27 + 0.188160695600874*x_28 - 0.0212148446321551*x_29 - 0.00562745688767651*x_30 + 0.0154806417285765*x_31 + 0.00611066639966257*x_32 - 0.00314759478214924*x_33 + 0.272702783724026*x_34 - 0.039178980331641*x_35 + 0.111730267406433*x_36 + 0.0162099998311914*x_37 + 0.0634361436206318*x_38 - 0.0697140020134961*x_39 - 0.00599309979068494*x_4 - 0.00109761413537898*x_40 + 0.127585850691958*x_42 + 0.00517327315877937*x_44 - 0.0137126727714937*x_45 - 0.00292825806409855*x_46 - 0.267643883594089*x_47 + 0.328104057624665*x_48 + 0.116584205056036*x_49 - 0.00457502892570297*x_5 + 0.0400308797654679*x_50 + 0.175853671204302*x_51 + 0.270908775376406*x_52 + 0.139785905607962*x_53 + 0.15027372253478*x_54 - 0.0114172235984058*x_55 + 0.134421166469137*x_56 - 0.0124861610754195*x_57 - 0.313456758758453*x_58 + 0.125326459614407*x_59 + 0.0742226453505223*x_6 + 0.26797050393535*x_60 + 0.000503333184798541*x_61 + 8.41000275774921e-5*x_62 + 0.0185069492466291*x_63 - 0.00270102389261078*x_64 + 0.016042829995586*x_65 + 0.00236609002001085*x_66 + 0.000723557072725362*x_67 + 0.00289589459085064*x_68 + 0.000600068766343819*x_69 + 0.158383922290903*x_7 + 0.000839930728559938*x_70 - 0.00223560076292858*x_71 + 0.000188552767111147*x_72 + 0.0035169094530984*x_73 + 0.00200482435647695*x_74 - 0.00104603052053359*x_75 + 0.000788591886866536*x_76 - 0.0767999764843609*x_77 + 0.00129296817992871*x_78 + 0.0044493049884325*x_79 + 0.000275590868865153*x_80 - 0.0037867031514342*x_81 - 0.00211620375646828*x_82 + 0.00980482291254284*x_83 + 0.00393207721111348*x_84 + 0.00331174625771004*x_85 - 0.00440404780858805*x_86 + 0.000427493533301386*x_87 + 0.00533632248484756*x_88 + 0.00527328710313936*x_89 + 0.0265690284091835*x_90 + 0.00717231900755519*x_91 + 0.027334170510275*x_92 + 0.0076790099503205*x_93 + 0.0557240035849378*x_94 + 0.0130120984123052*x_96 - 0.119197094076539*x_98 + 0.0833582513611648*x_99 - 1.21832888314665*std::sin(0.257279962301254*x_109 - 7.62152004241943) - 1.65054330683631*std::sin(0.303839921951294*x_11 - 4.42399978637695) - 0.220717178881564*std::sin(0.217519998550415*x_110 + 1.97559976577759) + 1.1670800275417*std::sin(0.360239863395691*x_13 + 1.82303988933563) + 1.18333619419539*std::sin(0.375999838113785*x_17 + 8.1940803527832) + 1.19631579892733*std::sin(0.339519828557968*x_19 - 4.35431957244873) + 0.0884286897858599*std::sin(0.374479830265045*x_3 + 1.60391974449158) + 1.94945414453611*std::sin(0.249119967222214*x_41 - 4.41247987747192) + 1.78146500520506*std::sin(0.278879970312119*x_43 - 1.24959993362427) - 1.1113991493103*std::sin(0.363439828157425*x_8 + 5.03832006454468) + 0.129355213001139*std::sin(0.292239934206009*x_9 + 7.77375984191895) - 1.25335647824271*std::sin(0.297679930925369*x_95 - 7.603440284729) + 0.536718084302883*std::sin(0.315039932727814*x_97 - 4.61624002456665) - 5.0580357717895, 2) - 0.000471316755005473*std::sin(0.138000041246414*x_10 - 1.42351984977722) - 0.000215669790177051*std::sin(0.200960010290146*x_10 + 1.78887987136841) - 0.00115609354947997*std::sin(0.316079914569855*x_10 + 7.98695993423462) - 0.000134882848718555*std::sin(0.26335996389389*x_100 + 8.17239952087402) - 0.000119393729524499*std::sin(0.269679963588715*x_100 - 7.62152004241943) + 0.000267985280720781*std::sin(0.267759948968887*x_104 - 7.62703990936279) - 0.000194872523888132*std::sin(0.282559931278229*x_108 + 4.9696798324585) + 0.00313182781548558*std::sin(0.26063996553421*x_109 - 1.41407990455627) + 0.00214839749010844*std::sin(0.263759940862656*x_11 + 7.98880004882813) + 9.28309279833691e-5*std::sin(0.297439932823181*x_11 + 7.97616004943848) + 5.26226958428678e-5*std::sin(0.351279854774475*x_11 + 5.06895971298218) - 3.06449073230582e-5*std::sin(0.368719846010208*x_11 - 4.56192016601563) + 0.000285828220223935*std::sin(0.299279928207397*x_113 - 1.2027999162674) - 0.00135150677554018*std::sin(0.306559920310974*x_113 + 4.98847961425781) + 0.00169743486914165*std::sin(0.275919944047928*x_116 - 4.43304014205933) + 0.00266742075469632*std::sin(0.298799932003021*x_116 - 7.64735984802246) + 2.70733622832753e-5*std::sin(0.34079983830452*x_119 - 4.77639961242676) + 0.000327125094801905*std::sin(0.379839837551117*x_12 + 4.80951976776123) + 0.000152333691396703*std::sin(0.299279928207397*x_13 - 4.42256021499634) + 1.26133353902947e-5*std::sin(0.364799857139587*x_13 - 4.56383991241455) - 0.000153376838975311*std::sin(0.367439836263657*x_13 + 8.00944042205811) + 0.000144680867590648*std::sin(0.339519828557968*x_14 - 7.54960012435913) - 0.00196969761968863*std::sin(0.347119837999344*x_15 - 1.34447979927063) - 0.000144914828067344*std::sin(0.376879841089249*x_15 + 1.7986398935318) + 1.44359350279054e-5*std::sin(0.309759914875031*x_16 + 1.7869598865509) + 0.00143107978283103*std::sin(0.312959939241409*x_16 + 1.77959990501404) + 0.00147695032522996*std::sin(0.353839844465256*x_16 + 1.81879985332489) + 1.59312707234393e-6*std::sin(0.367599844932556*x_17 - 4.38447999954224) + 9.98689526049853e-5*std::sin(0.37967985868454*x_17 - 7.58376026153564) - 0.000107709254297179*std::sin(0.416159868240356*x_17 + 8.00039958953857) + 0.000101034619777971*std::sin(0.38663986325264*x_18 + 5.01535987854004) - 0.00022844211861624*std::sin(0.305999934673309*x_20 + 4.99823999404907) + 2.87770674502113e-5*std::sin(0.364079833030701*x_20 - 7.58983993530273) - 4.82027578880642e-5*std::sin(0.291439920663834*x_21 + 8.20351982116699) + 0.00140916018711668*std::sin(0.356879830360413*x_21 - 1.38127982616425) - 1.91461825249544e-5*std::sin(0.3713598549366*x_21 - 7.59679985046387) - 0.00118730843266017*std::sin(0.371759831905365*x_21 - 1.39455986022949) + 0.00107877394680739*std::sin(0.377679854631424*x_21 - 7.78287982940674) - 2.1051990156325e-5*std::sin(0.411999881267548*x_21 + 7.98016023635864) + 0.000118819604310746*std::sin(0.166400015354156*x_22 - 7.81447982788086) - 7.21557104810584e-6*std::sin(0.294319927692413*x_24 - 7.77375984191895) + 0.00068223701755005*std::sin(0.320479929447174*x_24 + 1.57775974273682) + 9.99537819747439e-5*std::sin(0.341279834508896*x_24 - 1.39759981632233) - 4.91554004239856e-5*std::sin(0.223199993371964*x_28 + 1.58655989170074) - 0.000129727595905383*std::sin(0.247759968042374*x_28 - 1.37271988391876) - 0.000723413117721897*std::sin(0.24967996776104*x_28 - 4.58311986923218) + 0.000879087645726883*std::sin(0.186240002512932*x_29 - 1.58527982234955) - 2.07687994409138e-5*std::sin(0.355439841747284*x_29 + 5.01103973388672) + 3.50318177177221e-5*std::sin(0.327199846506119*x_3 - 1.18575978279114) - 0.00018749189244895*std::sin(0.292399942874908*x_33 + 1.76831984519958) + 0.000284257335178361*std::sin(0.233039990067482*x_38 + 1.79367995262146) + 0.00120753145032419*std::sin(0.307439923286438*x_4 - 7.55136013031006) - 0.00475856077397777*std::sin(0.259039968252182*x_42 + 8.17671966552734) + 2.78192816701626e-5*std::sin(0.284799933433533*x_44 + 1.55623984336853) - 0.000437602495235077*std::sin(0.245679974555969*x_48 + 4.99599981307983) + 0.00122480732413572*std::sin(0.289359927177429*x_48 - 7.82352018356323) + 0.000798856498261793*std::sin(0.428159862756729*x_5 + 1.76775991916656) + 0.000432908794101333*std::sin(0.245119974017143*x_52 + 1.78615987300873) - 0.000299027085575633*std::sin(0.250079959630966*x_53 - 1.40391981601715) - 0.000236302154186672*std::sin(0.270319938659668*x_53 + 4.96719980239868) - 0.00452058045096027*std::sin(0.276479959487915*x_53 - 4.41447973251343) + 0.000341082067717392*std::sin(0.197279989719391*x_56 + 7.98432016372681) + 0.00269610304242729*std::sin(0.284719944000244*x_56 + 8.13599967956543) + 1.61398551263108e-5*std::sin(0.229599997401237*x_57 + 1.58239984512329) - 0.0010833255824562*std::sin(0.174960017204285*x_58 + 1.61359977722168) + 0.000332470145330274*std::sin(0.156480029225349*x_59 + 4.61399984359741) + 0.000107071069272349*std::sin(0.425759851932526*x_6 - 1.21807992458344) - 0.000104644564207818*std::sin(0.390319854021072*x_7 + 8.19863986968994) + 9.76890569931754e-5*std::sin(0.438399881124496*x_7 + 4.7912802696228) - 0.000904167827464716*std::sin(0.325519859790802*x_8 + 1.81727993488312) - 0.000419946426635055*std::sin(0.326719850301743*x_8 + 1.61639988422394) + 8.4534167147859e-5*std::sin(0.372399836778641*x_8 - 1.36783981323242) - 1.34834336621688e-5*std::sin(0.38351982831955*x_8 - 1.37175989151001) + 0.00123791850251404*std::sin(0.39711982011795*x_8 - 7.78391981124878) - 2.23512944123258e-6*std::sin(0.262079983949661*x_9 - 7.58767986297607) + 2.94097761869893e-5*std::sin(0.292479932308197*x_9 - 1.3971198797226) + 0.00030643345493191*std::sin(0.289119929075241*x_95 - 4.40375995635986) + 0.000236658348862305*std::sin(0.305999934673309*x_96 + 8.15655994415283) - 5.22878918894406e-6*std::sin(0.259039968252182*x_98 + 1.97967982292175) + 0.0758581414754761);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (9.64825278855799e-6*x_1 + 3.30889885422927e-5*x_10 - 0.000582257658569026*x_100 - 0.000195051188812675*x_101 - 8.26060421092314e-6*x_102 - 0.000133349005475556*x_103 - 0.000287331619064752*x_104 + 0.000269621240637881*x_105 + 0.000238282118684403*x_106 - 4.67347714120936e-5*x_107 - 2.27597584315367e-5*x_108 + 2.22223095876812e-5*x_109 - 0.000493096262923437*x_11 - 0.000404657564714663*x_110 - 0.000103138918795705*x_111 - 0.000581062669100876*x_112 - 0.000497241171142317*x_113 - 9.60138738203737e-6*x_114 + 0.000134124560598846*x_115 + 0.000129228809265379*x_116 + 5.79620864780629e-5*x_117 - 0.000206346561850483*x_118 - 9.74756860975271e-5*x_119 - 0.000147306921578136*x_12 - 6.32068993106131e-5*x_120 - 0.000175977937788201*x_13 - 5.94599518785124e-5*x_14 - 6.85565307673442e-7*x_15 - 8.19875660517803e-5*x_16 - 4.11489300597438e-5*x_17 + 4.5225926400177e-6*x_18 - 0.000213925404707562*x_19 - 6.34842025904304e-5*x_2 - 0.000141316634228116*x_20 - 3.95316523797704e-5*x_21 + 4.56136831978826e-5*x_22 - 0.000151197839959463*x_23 + 2.08081378933453e-5*x_24 - 0.000262890529499227*x_25 + 2.94473680057347e-5*x_26 + 0.000542892195208566*x_27 + 9.01859986013712e-6*x_28 + 3.71747657110343e-5*x_29 + 8.51613329305248e-6*x_3 - 0.000859174755167397*x_30 - 8.23619660519011e-5*x_31 - 7.70985717448014e-5*x_32 - 8.48491596598075e-6*x_33 + 3.28905221070512e-5*x_34 - 1.18885661942338e-5*x_35 - 4.8974366147301e-5*x_36 + 0.00142234583401473*x_37 + 0.000784154279838851*x_38 + 2.8431752216475e-5*x_39 - 3.57117941149842e-5*x_4 - 9.80223872299969e-5*x_40 + 2.11349484914359e-6*x_41 + 0.000233487923270441*x_42 - 0.000174393470060142*x_43 + 7.49579080461818e-5*x_44 + 8.97002859453683e-5*x_45 + 0.000106043191512696*x_46 - 0.000718765980757437*x_47 + 0.00170972946747056*x_48 + 0.000181774597478458*x_49 - 2.44704641170277e-5*x_5 + 0.00128654256295877*x_50 + 0.00021873871111431*x_51 + 0.000143548524339287*x_52 + 0.000226777813502628*x_53 + 0.000483520358877815*x_54 - 0.00179163357028852*x_55 - 0.000349982796039607*x_56 + 0.000798016870934144*x_57 + 1.31169766650662e-5*x_58 + 0.0022584942035612*x_59 - 7.84795745028435e-5*x_6 + 0.000362697302300121*x_60 + 2.20743065699754e-5*x_61 - 1.80824412620505e-5*x_62 - 1.65284629130386e-5*x_63 + 3.94814902287027e-6*x_64 + 2.58083587151168e-5*x_65 + 1.35538517195577e-5*x_66 + 3.71807140695697e-5*x_67 + 6.5283571193161e-6*x_68 + 6.10442799524702e-6*x_69 - 1.05477851594028e-5*x_7 + 5.27646887324736e-5*x_70 + 7.11415926100167e-5*x_71 + 1.44194314624423e-5*x_72 + 4.04449464168829e-5*x_73 + 4.09222997456577e-5*x_74 + 2.0564124583034e-5*x_75 + 3.96823031658395e-6*x_76 - 1.38741098872468e-6*x_77 - 8.3635234347513e-6*x_78 + 3.8073119156115e-5*x_79 + 7.35060477019198e-5*x_8 + 3.76778109650273e-5*x_80 - 8.7415769997524e-5*x_81 + 9.08378658864036e-6*x_82 + 3.9449735106822e-7*x_83 - 3.73195254276102e-5*x_84 - 8.81411632598096e-6*x_85 + 1.09166854998076e-5*x_86 - 2.76525135069958e-6*x_87 + 6.62302013363462e-6*x_88 + 1.60920212412584e-5*x_89 - 0.000113273770402897*x_9 + 1.62362883768022e-6*x_90 - 2.75119767412448e-5*x_91 - 6.16316208517011e-5*x_92 + 0.000103381420503544*x_93 - 0.000554790349229*x_94 - 7.28945685024914e-5*x_95 - 0.000203995535640946*x_96 - 5.62611451796877e-5*x_97 - 0.000259575339862659*x_98 - 0.000843667263494798*x_99 - 3.62870704055158e-10*std::pow(-6.62312030792236*x_10 - 9.87071990966797, 2) + 6.33724416362213e-8*std::pow(-7.36040019989014*x_44 - 6.54855966567993, 2) + 9.09375924520547e-6*std::sin(0.138000041246414*x_10 - 1.42351984977722) + 0.00042750066860312*std::sin(0.200960010290146*x_10 + 1.78887987136841) + 0.0002366463983437*std::sin(0.316079914569855*x_10 + 7.98695993423462) + 0.000267364789305626*std::sin(0.26335996389389*x_100 + 8.17239952087402) + 2.30362663782316e-6*std::sin(0.269679963588715*x_100 - 7.62152004241943) - 5.48552074529128e-5*std::sin(0.267759948968887*x_104 - 7.62703990936279) + 3.75994232524929e-6*std::sin(0.282559931278229*x_108 + 4.9696798324585) - 0.000312232355518457*std::sin(0.257279962301254*x_109 - 7.62152004241943) + 0.00108189484896267*std::sin(0.26063996553421*x_109 - 1.41407990455627) - 0.000370172847441444*std::sin(0.263759940862656*x_11 + 7.98880004882813) - 1.79111415120382e-6*std::sin(0.297439932823181*x_11 + 7.97616004943848) - 0.000422999923672244*std::sin(0.303839921951294*x_11 - 4.42399978637695) - 9.31259542360289e-5*std::sin(0.351279854774475*x_11 + 5.06895971298218) + 6.0744336789743e-5*std::sin(0.368719846010208*x_11 - 4.56192016601563) - 5.65652227562629e-5*std::sin(0.217519998550415*x_110 + 1.97559976577759) - 5.85075653189223e-5*std::sin(0.299279928207397*x_113 - 1.2027999162674) + 0.000232867108503678*std::sin(0.306559920310974*x_113 + 4.98847961425781) - 0.000292471156640964*std::sin(0.275919944047928*x_116 - 4.43304014205933) - 0.000546007297376633*std::sin(0.298799932003021*x_116 - 7.64735984802246) - 5.2236343382164e-7*std::sin(0.34079983830452*x_119 - 4.77639961242676) - 0.000443988101029556*std::sin(0.379839837551117*x_12 + 4.80951976776123) + 0.0001371795257101*std::sin(0.299279928207397*x_13 - 4.42256021499634) + 0.000299098339634477*std::sin(0.360239863395691*x_13 + 1.82303988933563) - 9.14327935373146e-5*std::sin(0.364799857139587*x_13 - 4.56383991241455) + 2.95930928111378e-6*std::sin(0.367439836263657*x_13 + 8.00944042205811) - 0.000286786422791554*std::sin(0.339519828557968*x_14 - 7.54960012435913) + 0.000339382530391045*std::sin(0.347119837999344*x_15 - 1.34447979927063) - 0.000130498691394996*std::sin(0.376879841089249*x_15 + 1.7986398935318) - 0.000104644634117964*std::sin(0.309759914875031*x_16 + 1.7869598865509) - 0.000292934664761153*std::sin(0.312959939241409*x_16 + 1.77959990501404) - 0.000254481263330997*std::sin(0.353839844465256*x_16 + 1.81879985332489) - 1.15484171455878e-5*std::sin(0.367599844932556*x_17 - 4.38447999954224) + 0.00030326445707304*std::sin(0.375999838113785*x_17 + 8.1940803527832) - 0.000197960242722337*std::sin(0.37967985868454*x_17 - 7.58376026153564) + 0.000473874483343106*std::sin(0.416159868240356*x_17 + 8.00039958953857) - 0.000200270828249458*std::sin(0.38663986325264*x_18 + 5.01535987854004) + 0.000306590859832765*std::sin(0.339519828557968*x_19 - 4.35431957244873) + 0.000310051365826925*std::sin(0.305999934673309*x_20 + 4.99823999404907) - 5.70419045027264e-5*std::sin(0.364079833030701*x_20 - 7.58983993530273) + 8.53040262045535e-5*std::sin(0.291439920663834*x_21 + 8.20351982116699) - 0.000288447836354159*std::sin(0.356879830360413*x_21 - 1.38127982616425) + 0.000138788742205244*std::sin(0.3713598549366*x_21 - 7.59679985046387) + 0.000204575431377398*std::sin(0.371759831905365*x_21 - 1.39455986022949) + 0.000372664158123613*std::sin(0.377679854631424*x_21 - 7.78287982940674) + 4.17292559141779e-5*std::sin(0.411999881267548*x_21 + 7.98016023635864) - 0.000235524225457363*std::sin(0.166400015354156*x_22 - 7.81447982788086) + 5.23049453202458e-5*std::sin(0.294319927692413*x_24 - 7.77375984191895) - 0.000139650405533868*std::sin(0.320479929447174*x_24 + 1.57775974273682) - 0.000198128391503208*std::sin(0.341279834508896*x_24 - 1.39759981632233) + 9.74358371168107e-5*std::sin(0.223199993371964*x_28 + 1.58655989170074) + 2.50301206586462e-6*std::sin(0.247759968042374*x_28 - 1.37271988391876) + 0.00128021827494121*std::sin(0.24967996776104*x_28 - 4.58311986923218) - 0.00119313516653675*std::sin(0.186240002512932*x_29 - 1.58527982234955) + 0.000150550928246949*std::sin(0.355439841747284*x_29 + 5.01103973388672) - 6.19955211592919e-5*std::sin(0.327199846506119*x_3 - 1.18575978279114) + 2.26624341663305e-5*std::sin(0.374479830265045*x_3 + 1.60391974449158) - 0.000168840186598358*std::sin(0.292399942874908*x_33 + 1.76831984519958) - 5.48456583039505e-6*std::sin(0.233039990067482*x_38 + 1.79367995262146) - 0.000208059894595687*std::sin(0.307439923286438*x_4 - 7.55136013031006) + 0.000499604555012801*std::sin(0.249119967222214*x_41 - 4.41247987747192) + 0.00097405289474021*std::sin(0.259039968252182*x_42 + 8.17671966552734) + 0.000456552432223609*std::sin(0.278879970312119*x_43 - 1.24959993362427) - 5.36755477492158e-7*std::sin(0.284799933433533*x_44 + 1.55623984336853) + 0.000276768427241948*std::sin(0.245679974555969*x_48 + 4.99599981307983) + 0.000423111618206485*std::sin(0.289359927177429*x_48 - 7.82352018356323) - 0.000137644447091466*std::sin(0.428159862756729*x_5 + 1.76775991916656) - 0.000273799823783615*std::sin(0.245119974017143*x_52 + 1.78615987300873) - 0.00026927985134237*std::sin(0.250079959630966*x_53 - 1.40391981601715) + 4.55930088730257e-6*std::sin(0.270319938659668*x_53 + 4.96719980239868) - 0.00156164163305285*std::sin(0.276479959487915*x_53 - 4.41447973251343) - 6.58096317123888e-6*std::sin(0.197279989719391*x_56 + 7.98432016372681) - 0.000464543523629082*std::sin(0.284719944000244*x_56 + 8.13599967956543) - 0.0001169961787127*std::sin(0.229599997401237*x_57 + 1.58239984512329) + 0.00191715241871647*std::sin(0.174960017204285*x_58 + 1.61359977722168) - 1.93870084503972e-5*std::sin(0.156480029225349*x_59 + 4.61399984359741) - 2.06586868756269e-6*std::sin(0.425759851932526*x_6 - 1.21807992458344) + 0.000207426460274289*std::sin(0.390319854021072*x_7 + 8.19863986968994) + 8.79709431480417e-5*std::sin(0.438399881124496*x_7 + 4.7912802696228) + 0.000155789783221476*std::sin(0.325519859790802*x_8 + 1.81727993488312) + 0.00074317575490957*std::sin(0.326719850301743*x_8 + 1.61639988422394) - 0.000284828488522827*std::sin(0.363439828157425*x_8 + 5.03832006454468) - 1.63103338863407e-6*std::sin(0.372399836778641*x_8 - 1.36783981323242) + 9.77400479777741e-5*std::sin(0.38351982831955*x_8 - 1.37175989151001) + 0.000427640895416808*std::sin(0.39711982011795*x_8 - 7.78391981124878) + 1.62022274367364e-5*std::sin(0.262079983949661*x_9 - 7.58767986297607) + 3.31510509293865e-5*std::sin(0.292239934206009*x_9 + 7.77375984191895) - 5.82960597916131e-5*std::sin(0.292479932308197*x_9 - 1.3971198797226) + 0.000275949434585659*std::sin(0.289119929075241*x_95 - 4.40375995635986) - 0.000321209199682851*std::sin(0.297679930925369*x_95 - 7.603440284729) - 4.56617343870294e-6*std::sin(0.305999934673309*x_96 + 8.15655994415283) + 0.000137549683036671*std::sin(0.315039932727814*x_97 - 4.61624002456665) + 2.30044279072294e-5*std::sin(0.259039968252182*x_98 + 1.97967982292175) + 0.0506686046003803);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-2.23268028332326e-5*x_1 - 0.000210569630916587*x_10 - 0.000102090802705954*x_100 - 0.000141066321486078*x_101 + 4.40628030629437e-5*x_102 + 0.000145285929326929*x_103 - 0.000254877813659374*x_104 - 0.000168051848487177*x_105 - 0.000358899026194508*x_106 - 4.40478609159961e-5*x_107 + 0.000125803959117516*x_108 - 0.000132622879392093*x_109 + 0.00051928448969417*x_11 + 0.000571553137771148*x_110 + 0.000166984542455997*x_111 - 0.00022545339604826*x_112 + 2.16422760530747e-5*x_113 - 0.000322204468094557*x_114 - 6.6166972993574e-5*x_115 - 0.000651928305369724*x_116 + 3.54836867142561e-5*x_117 + 0.00100037293181076*x_118 + 6.54935780749629e-5*x_119 - 0.000234420458807746*x_12 - 2.58857355492303e-5*x_120 - 3.4280664584592e-5*x_13 - 0.000307925993210722*x_14 + 3.89496086697891e-5*x_15 - 1.11676268007311e-5*x_16 + 0.000154890649571284*x_17 - 2.92720204439661e-5*x_18 + 3.4292634421784e-6*x_19 - 4.87073838567924e-5*x_2 - 0.000125236968216334*x_20 + 0.000156508671056443*x_21 - 4.47281471890039e-5*x_22 - 0.00011380994109454*x_23 + 3.5571810994333e-5*x_24 - 0.000235029053751014*x_25 - 0.000268178112444078*x_26 - 2.31200430582356e-5*x_27 - 2.81437634155455e-5*x_28 + 0.000258618445649919*x_29 + 0.000110052614788425*x_3 + 7.61065360212511e-5*x_30 - 3.68806003125841e-5*x_31 - 5.61507822634143e-6*x_32 + 0.000164278932842423*x_33 - 0.000200472912533677*x_34 + 0.000280214988550186*x_35 + 0.000296005398584328*x_36 + 6.07200404713082e-5*x_37 + 0.000814877680939739*x_38 - 0.000876706373355488*x_39 - 1.79981563635426e-5*x_4 - 0.000567603218285274*x_40 + 3.64127454737842e-5*x_41 - 0.000142513155104688*x_42 - 0.000259736629331646*x_43 - 5.92594395837279e-6*x_44 + 0.000309092197667549*x_45 - 0.000421226002104682*x_46 + 0.000471671354321416*x_47 + 0.000257238713721141*x_48 - 0.00025576850376864*x_49 + 6.37849373001573e-5*x_5 + 0.000555344201721338*x_50 + 0.00017471829347995*x_51 + 0.000237551335156708*x_52 + 0.000179204473993532*x_53 + 0.00063305929324735*x_54 + 0.000449127405587023*x_55 + 7.39427093920133e-5*x_56 + 0.000228506592974192*x_57 - 0.000506027272604278*x_58 + 0.000751828183155276*x_59 - 1.89028914421498e-5*x_6 - 9.53574443470916e-5*x_60 + 8.37111431767089e-6*x_61 + 3.51706914795711e-6*x_62 - 1.0930617180435e-5*x_63 - 2.22220550131648e-6*x_64 + 1.23534904750525e-5*x_65 + 1.50524818182732e-6*x_66 + 1.30422055885841e-5*x_67 + 1.41146543202871e-6*x_68 - 7.66586636660452e-6*x_69 + 1.18667413449313e-5*x_7 + 4.58999633811137e-5*x_70 - 2.73456428605226e-5*x_71 - 2.03791895926505e-6*x_72 - 1.5615444768223e-5*x_73 - 4.54179085986318e-5*x_74 - 8.96378816062585e-6*x_75 + 5.17350811900997e-6*x_76 - 3.00040349076609e-5*x_77 + 5.96359154036095e-6*x_78 + 1.05874004185359e-5*x_79 + 6.8336343647987e-6*x_8 + 2.68040428989049e-5*x_80 - 7.36766379154753e-7*x_81 - 7.12369152989777e-6*x_82 + 5.93486080158719e-6*x_83 + 1.6976182653164e-6*x_84 - 1.44739383005542e-6*x_85 - 4.36050144480958e-5*x_86 - 2.03092956854038e-5*x_87 - 2.13116236169738e-5*x_88 - 3.23885787530695e-5*x_89 + 9.97863028026144e-5*x_9 - 2.6255889275399e-5*x_90 - 2.51954491607346e-6*x_91 + 0.000112611814710922*x_92 - 0.000124959817898944*x_93 + 5.70324563958824e-5*x_94 - 6.98960533929893e-5*x_95 + 0.000548185037927672*x_96 - 0.000176539969740239*x_97 - 0.000136486590417942*x_98 + 0.000241923171920027*x_99 + 9.32341398640895e-9*std::pow(-6.62312030792236*x_10 - 9.87071990966797, 2) - 3.29447638766669e-7*std::pow(-7.36040019989014*x_44 - 6.54855966567993, 2) - 0.00260436232201755*std::pow(-0.000209992030293873*x_1 - 0.0353543348541328*x_10 + 0.0350885568483415*x_100 + 0.0804997805651131*x_101 - 0.235890861920553*x_102 - 0.308035990091257*x_103 - 0.133696940114799*x_104 + 0.076022191005445*x_105 + 0.153791249890001*x_106 - 0.252952515341145*x_107 - 0.0222930063620508*x_108 - 0.397672900009286*x_111 + 0.0415028870495504*x_112 - 0.128693998838819*x_113 - 0.0668607290415207*x_114 - 0.185693611514806*x_115 + 0.0176214934016229*x_116 + 0.0224248073081002*x_117 + 0.0122574037272948*x_118 + 0.138151531773729*x_119 - 0.0215800824305025*x_12 + 0.0142060922311913*x_120 + 0.0112704624821488*x_14 - 0.337606732335028*x_15 - 0.00583132001101267*x_16 - 0.0186356229687965*x_18 - 0.0062445335127309*x_2 - 0.0225666106059017*x_20 + 0.0211260731831326*x_21 - 0.015096891016941*x_22 - 0.0160790199380947*x_23 + 0.160671844475247*x_24 + 0.00441868278862272*x_25 + 0.126890954905539*x_26 - 0.136593922067815*x_27 + 0.282132582269804*x_28 - 0.0318100381134795*x_29 - 0.00843794150665756*x_30 + 0.0232120391143829*x_31 + 0.00916247723904633*x_32 - 0.00471957781082206*x_33 + 0.408896982010658*x_34 - 0.0587458866282614*x_35 + 0.167530996632467*x_36 + 0.0243056558457253*x_37 + 0.0951176490487204*x_38 - 0.104530817903389*x_39 - 0.00898619509428894*x_4 - 0.00164578850732561*x_40 + 0.191305231955385*x_42 + 0.0077569277176222*x_44 - 0.0205611047859264*x_45 - 0.00439069916561611*x_46 - 0.40131154790846*x_47 + 0.491966958004898*x_48 + 0.174809105160318*x_49 - 0.00685990621285541*x_5 + 0.0600232447201426*x_50 + 0.263679139790895*x_51 + 0.406207003606235*x_52 + 0.209598281873668*x_53 + 0.225323961790438*x_54 - 0.0171192541879347*x_55 + 0.201554265552368*x_56 - 0.018722044237747*x_57 - 0.470004452821734*x_58 + 0.187917447715796*x_59 + 0.111291183999755*x_6 + 0.401801290147175*x_60 + 0.000754709641754947*x_61 + 0.000126101563738529*x_62 + 0.0277497559424595*x_63 - 0.00404997889256942*x_64 + 0.024054997453725*x_65 + 0.00354777114899959*x_66 + 0.00108491853038536*x_67 + 0.00434217261096295*x_68 + 0.000899757252955497*x_69 + 0.237484586476758*x_7 + 0.00125941193308*x_70 - 0.00335211248106406*x_71 + 0.000282720463534138*x_72 + 0.00527333693385394*x_73 + 0.00300608089741573*x_74 - 0.0015684428193079*x_75 + 0.00118243326369612*x_76 - 0.115155695054161*x_77 + 0.00193870696656949*x_78 + 0.00667139277777284*x_79 + 0.000413227444948622*x_80 - 0.00567787196466113*x_81 - 0.0031730857951754*x_82 + 0.014701582592369*x_83 + 0.00589584925647217*x_84 + 0.0049657104026233*x_85 - 0.00660353309552098*x_86 + 0.000640993880623188*x_87 + 0.00800140772049457*x_88 + 0.00790689098330403*x_89 + 0.0398382274764929*x_90 + 0.010754344184381*x_91 + 0.0409854995786443*x_92 + 0.0115140885275797*x_93 + 0.083553884490196*x_94 + 0.019510647077962*x_96 - 0.178726932548152*x_98 + 0.124989326994769*x_99 - 1.82679104559207*std::sin(0.257279962301254*x_109 - 7.62152004241943) - 2.47486354054331*std::sin(0.303839921951294*x_11 - 4.42399978637695) - 0.33094854071571*std::sin(0.217519998550415*x_110 + 1.97559976577759) + 1.74994730347035*std::sin(0.360239863395691*x_13 + 1.82303988933563) + 1.77432218293796*std::sin(0.375999838113785*x_17 + 8.1940803527832) + 1.79378410822565*std::sin(0.339519828557968*x_19 - 4.35431957244873) + 0.132592061888106*std::sin(0.374479830265045*x_3 + 1.60391974449158) + 2.92305749645618*std::sin(0.249119967222214*x_41 - 4.41247987747192) + 2.67117062113721*std::sin(0.278879970312119*x_43 - 1.24959993362427) - 1.66645808215179*std::sin(0.363439828157425*x_8 + 5.03832006454468) + 0.193958255508822*std::sin(0.292239934206009*x_9 + 7.77375984191895) - 1.87931224734248*std::sin(0.297679930925369*x_95 - 7.603440284729) + 0.804767747013855*std::sin(0.315039932727814*x_97 - 4.61624002456665) - 7.49089095900891, 2) - 0.000838863357102817*std::sin(0.138000041246414*x_10 - 1.42351984977722) + 0.000682914125771382*std::sin(0.200960010290146*x_10 + 1.78887987136841) + 0.000118500081315044*std::sin(0.316079914569855*x_10 + 7.98695993423462) + 0.000427103873187648*std::sin(0.26335996389389*x_100 + 8.17239952087402) - 0.000212500454741492*std::sin(0.269679963588715*x_100 - 7.62152004241943) - 2.74686054350288e-5*std::sin(0.267759948968887*x_104 - 7.62703990936279) - 0.000346839822390781*std::sin(0.282559931278229*x_108 + 4.9696798324585) - 0.0014073639587654*std::sin(0.26063996553421*x_109 - 1.41407990455627) + 2.06352192493424e-5*std::sin(0.263759940862656*x_11 + 7.98880004882813) + 0.000165223203003243*std::sin(0.297439932823181*x_11 + 7.97616004943848) - 5.9162028920001e-6*std::sin(0.351279854774475*x_11 + 5.06895971298218) + 9.70364930419364e-5*std::sin(0.368719846010208*x_11 - 4.56192016601563) - 2.92975143351557e-5*std::sin(0.299279928207397*x_113 - 1.2027999162674) - 1.29811353618904e-5*std::sin(0.306559920310974*x_113 + 4.98847961425781) + 1.6303752377056e-5*std::sin(0.275919944047928*x_116 - 4.43304014205933) - 0.000273411763671833*std::sin(0.298799932003021*x_116 - 7.64735984802246) + 4.81859626924262e-5*std::sin(0.34079983830452*x_119 - 4.77639961242676) + 0.00132572227534613*std::sin(0.379839837551117*x_12 + 4.80951976776123) - 0.000953813096599934*std::sin(0.299279928207397*x_13 - 4.42256021499634) + 0.000475322035240818*std::sin(0.364799857139587*x_13 - 4.56383991241455) - 0.000272984587707165*std::sin(0.367439836263657*x_13 + 8.00944042205811) - 0.000458129106192389*std::sin(0.339519828557968*x_14 - 7.54960012435913) - 1.89188185260498e-5*std::sin(0.347119837999344*x_15 - 1.34447979927063) + 0.000907361067895395*std::sin(0.376879841089249*x_15 + 1.7986398935318) + 0.000544005039566928*std::sin(0.309759914875031*x_16 + 1.7869598865509) - 0.000146686287377066*std::sin(0.312959939241409*x_16 + 1.77959990501404) + 1.41860125613763e-5*std::sin(0.353839844465256*x_16 + 1.81879985332489) + 6.00355400845381e-5*std::sin(0.367599844932556*x_17 - 4.38447999954224) - 0.00031623306353638*std::sin(0.37967985868454*x_17 - 7.58376026153564) - 0.0002123292492366*std::sin(0.416159868240356*x_17 + 8.00039958953857) - 0.00031992412558882*std::sin(0.38663986325264*x_18 + 5.01535987854004) - 0.000925795086005879*std::sin(0.305999934673309*x_20 + 4.99823999404907) - 9.11220150207031e-5*std::sin(0.364079833030701*x_20 - 7.58983993530273) + 5.41928327790902e-6*std::sin(0.291439920663834*x_21 + 8.20351982116699) - 0.000144439519478646*std::sin(0.356879830360413*x_21 - 1.38127982616425) - 0.00072150641866353*std::sin(0.3713598549366*x_21 - 7.59679985046387) - 1.14040208747865e-5*std::sin(0.371759831905365*x_21 - 1.39455986022949) - 0.000484773640774512*std::sin(0.377679854631424*x_21 - 7.78287982940674) + 6.66607105313733e-5*std::sin(0.411999881267548*x_21 + 7.98016023635864) - 0.000376239927417561*std::sin(0.166400015354156*x_22 - 7.81447982788086) - 0.000271912211154662*std::sin(0.294319927692413*x_24 - 7.77375984191895) - 6.99295849303711e-5*std::sin(0.320479929447174*x_24 + 1.57775974273682) - 0.000316501674058238*std::sin(0.341279834508896*x_24 - 1.39759981632233) + 0.000155649603404957*std::sin(0.223199993371964*x_28 + 1.58655989170074) - 0.000230892972622634*std::sin(0.247759968042374*x_28 - 1.37271988391876) + 8.13310437754238e-5*std::sin(0.24967996776104*x_28 - 4.58311986923218) + 0.00356263121491016*std::sin(0.186240002512932*x_29 - 1.58527982234955) - 0.000782653256596933*std::sin(0.355439841747284*x_29 + 5.01103973388672) - 3.93851622335114e-6*std::sin(0.327199846506119*x_3 - 1.18575978279114) + 0.00117395056132661*std::sin(0.292399942874908*x_33 + 1.76831984519958) + 0.000505929526027675*std::sin(0.233039990067482*x_38 + 1.79367995262146) + 1.15982616543917e-5*std::sin(0.307439923286438*x_4 - 7.55136013031006) + 0.000487754506469299*std::sin(0.259039968252182*x_42 + 8.17671966552734) + 4.95135718520139e-5*std::sin(0.284799933433533*x_44 + 1.55623984336853) + 0.00194260249810955*std::sin(0.245679974555969*x_48 + 4.99599981307983) - 0.000550397335350712*std::sin(0.289359927177429*x_48 - 7.82352018356323) + 7.67296511296981e-6*std::sin(0.428159862756729*x_5 + 1.76775991916656) - 0.00192176624683797*std::sin(0.245119974017143*x_52 + 1.78615987300873) + 0.00187231037234827*std::sin(0.250079959630966*x_53 - 1.40391981601715) - 0.000420577491138327*std::sin(0.270319938659668*x_53 + 4.96719980239868) + 0.00203143415737066*std::sin(0.276479959487915*x_53 - 4.41447973251343) + 0.000607067848393507*std::sin(0.197279989719391*x_56 + 7.98432016372681) + 2.5895895734126e-5*std::sin(0.284719944000244*x_56 + 8.13599967956543) + 0.000608215713746336*std::sin(0.229599997401237*x_57 + 1.58239984512329) + 0.000121794861347335*std::sin(0.174960017204285*x_58 + 1.61359977722168) + 0.000498119863965613*std::sin(0.156480029225349*x_59 + 4.61399984359741) + 0.00019056822331162*std::sin(0.425759851932526*x_6 - 1.21807992458344) + 0.000331354943240046*std::sin(0.390319854021072*x_7 + 8.19863986968994) - 0.000611664439430793*std::sin(0.438399881124496*x_7 + 4.7912802696228) - 8.68447363387779e-6*std::sin(0.325519859790802*x_8 + 1.81727993488312) + 4.72132456148225e-5*std::sin(0.326719850301743*x_8 + 1.61639988422394) + 0.000150456385202602*std::sin(0.372399836778641*x_8 - 1.36783981323242) - 0.00050811089470181*std::sin(0.38351982831955*x_8 - 1.37175989151001) - 0.000556289166253852*std::sin(0.39711982011795*x_8 - 7.78391981124878) - 8.4228813565903e-5*std::sin(0.262079983949661*x_9 - 7.58767986297607) - 9.31254747240298e-5*std::sin(0.292479932308197*x_9 - 1.3971198797226) - 0.00191868417203435*std::sin(0.289119929075241*x_95 - 4.40375995635986) + 0.00042121145684867*std::sin(0.305999934673309*x_96 + 8.15655994415283) - 1.03076090364691e-5*std::sin(0.259039968252182*x_98 + 1.97967982292175) + 0.0737505273053725);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-3.30436198582998e-5*x_1 + 2.36234954576406e-5*x_10 - 0.000472686968206022*x_100 - 7.22535219347387e-5*x_101 + 0.000143102777209634*x_102 - 0.000101229241959778*x_103 - 0.000683186570750784*x_104 - 0.000789340724428667*x_105 - 0.000521494647544083*x_106 + 1.50073441689952e-5*x_107 + 8.47049553005129e-5*x_108 + 5.39841850565739e-5*x_109 - 0.000369955478930355*x_11 - 0.000371264847224128*x_110 - 1.16605553689454e-5*x_111 - 0.000350812486119862*x_112 - 0.000157636312192505*x_113 - 0.000378777389822443*x_114 + 3.89535017620462e-5*x_115 + 0.000109122956623584*x_116 + 2.91213172726725e-5*x_117 - 0.000452077218134753*x_118 + 0.000116614018201309*x_119 - 0.000307143060736112*x_12 - 0.000264596806054903*x_120 - 1.23943364435162e-5*x_13 - 0.00035408219842534*x_14 - 7.19069326598634e-5*x_15 - 0.000232876965230634*x_16 + 7.8338919152192e-5*x_17 - 0.000150474813916079*x_18 + 5.68327159604474e-5*x_19 - 9.83392447930948e-5*x_2 - 3.24401415081227e-5*x_20 - 4.34532248991117e-5*x_21 - 6.99271206035751e-5*x_22 - 0.000342287732372182*x_23 + 1.40212351329016e-5*x_24 + 5.22782129956806e-5*x_25 - 0.000168320729127107*x_26 + 0.000344689865332677*x_27 + 6.44868527786183e-5*x_28 - 0.000193117205666248*x_29 + 5.38698531264337e-5*x_3 - 0.000509981171046119*x_30 - 8.30316436369598e-5*x_31 - 6.3473380400664e-5*x_32 - 0.000214460444466205*x_33 - 0.000539080125694272*x_34 - 0.000280168131847101*x_35 - 0.000347795102595489*x_36 + 0.00045186720264607*x_37 + 0.000783892111579683*x_38 - 0.000432206876300474*x_39 + 9.11141692905133e-6*x_4 + 9.17322857349469e-5*x_40 - 0.000258333297043622*x_41 - 0.000814367881738256*x_42 - 0.000533909116283354*x_43 + 0.000126533820441941*x_44 + 0.000341562911188086*x_45 - 0.000342824756595384*x_46 - 0.000527796294999549*x_47 + 0.00114853915116996*x_48 - 0.000306224877882641*x_49 - 5.0351659907876e-6*x_5 + 0.00103957670875173*x_50 - 0.00013766620215515*x_51 - 0.000378002553321606*x_52 + 1.52694565775333e-5*x_53 - 0.00123637387254357*x_54 - 0.00157660464298651*x_55 - 0.000714506974252866*x_56 + 0.000920077633166317*x_57 + 0.000332391671225404*x_58 + 0.000924496332137242*x_59 - 7.96588700827169e-5*x_6 + 0.000278170910050662*x_60 + 2.14328685880278e-5*x_61 - 1.58748439050413e-5*x_62 - 3.68259311203318e-5*x_63 + 6.26687273685703e-6*x_64 + 2.69328786114721e-5*x_65 + 2.49916861341966e-5*x_66 + 1.9603906459997e-5*x_67 + 7.2475694617391e-6*x_68 + 1.29143627720714e-6*x_69 - 6.03297210959283e-5*x_7 + 5.27741088248984e-5*x_70 + 6.92631517060604e-5*x_71 + 1.56425614442479e-5*x_72 + 4.35109901092094e-5*x_73 + 7.16595990998743e-5*x_74 + 1.89645874458461e-5*x_75 + 9.25223618053482e-6*x_76 + 1.6469162629875e-5*x_77 + 2.05182395266611e-5*x_78 + 4.58015459023026e-5*x_79 + 9.74414804323146e-6*x_8 + 4.48997676819852e-5*x_80 - 5.7278363141327e-5*x_81 - 5.95667086627529e-6*x_82 + 4.85872718448938e-7*x_83 - 6.07293697468378e-6*x_84 - 1.29104056584803e-5*x_85 + 4.3873476418039e-6*x_86 - 2.79257429387113e-6*x_87 + 2.43466707284105e-5*x_88 + 3.86074226592406e-5*x_89 - 5.94779144044665e-5*x_9 - 6.4159893566945e-6*x_90 - 5.18875163504709e-6*x_91 - 0.000171912058845311*x_92 - 0.000243396447112728*x_93 - 0.000448124802805181*x_94 - 7.52822724880038e-5*x_95 - 0.000254097345150223*x_96 - 0.000344928900121302*x_97 + 0.000120313971924495*x_98 - 0.000775354482699321*x_99 - 2.28393695038388e-8*std::pow(-6.62312030792236*x_10 - 9.87071990966797, 2) - 2.40407393906257e-7*std::pow(-7.36040019989014*x_44 - 6.54855966567993, 2) - 0.000198191788513213*std::pow(-0.00019421538998475*x_1 - 0.0326981739342095*x_10 + 0.0324523637528808*x_100 + 0.0744518554073736*x_101 - 0.218168449905576*x_102 - 0.284893335528923*x_103 - 0.123652327794657*x_104 + 0.0703106658522005*x_105 + 0.142236957906588*x_106 - 0.233948266254929*x_107 - 0.0206181392621382*x_108 - 0.367795850411964*x_111 + 0.0383847871871195*x_112 - 0.119025256045194*x_113 - 0.0618375018675294*x_114 - 0.171742504358638*x_115 + 0.0162975957150397*x_116 + 0.0207400380413514*x_117 + 0.0113365085416127*x_118 + 0.127772247274702*x_119 - 0.0199587770987202*x_12 + 0.0131387926436018*x_120 + 0.0104237159058645*x_14 - 0.312242436487542*x_15 - 0.00539321463047804*x_16 - 0.0172355340220699*x_18 - 0.0057753835217015*x_2 - 0.0208711876985318*x_20 + 0.0195388774343794*x_21 - 0.0139626659750335*x_22 - 0.0148710078352948*x_23 + 0.148600615416974*x_24 + 0.00408670843274524*x_25 + 0.117357674279487*x_26 - 0.12633166033407*x_27 + 0.26093604322151*x_28 - 0.0294201591793431*x_29 - 0.00780400140943741*x_30 + 0.0214681253504347*x_31 + 0.00847410298246781*x_32 - 0.0043649972992281*x_33 + 0.378176670389117*x_34 - 0.0543323252103469*x_35 + 0.154944441462728*x_36 + 0.0224795789740521*x_37 + 0.0879714876730198*x_38 - 0.0966774478827638*x_39 - 0.00831106486409974*x_4 - 0.0015221408942775*x_40 + 0.176932525383666*x_42 + 0.00717415198878369*x_44 - 0.019016354948936*x_45 - 0.00406082721121598*x_46 - 0.371161127750187*x_47 + 0.455005623188741*x_48 + 0.161675747808544*x_49 - 0.0063445234494092*x_5 + 0.0555137157593963*x_50 + 0.243869002521979*x_51 + 0.37568878928175*x_52 + 0.193851223769114*x_53 + 0.208395437916368*x_54 - 0.0158330895877567*x_55 + 0.186411552060151*x_56 - 0.0173154624861583*x_57 - 0.434693154647811*x_58 + 0.173799264391069*x_59 + 0.102929909635755*x_6 + 0.371614075796601*x_60 + 0.000698008525340521*x_61 + 0.000116627589841822*x_62 + 0.0256649248297861*x_63 - 0.00374570515342709*x_64 + 0.0222477524743171*x_65 + 0.00328122813192166*x_66 + 0.00100340891597457*x_67 + 0.00401594644253447*x_68 + 0.000832158751595527*x_69 + 0.219642438398275*x_7 + 0.00116479267995209*x_70 - 0.00310026924293993*x_71 + 0.000261479757137022*x_72 + 0.00487715266001365*x_73 + 0.00278023491177388*x_74 - 0.00145060616535956*x_75 + 0.00109359739566451*x_76 - 0.106504081095888*x_77 + 0.00179305247466542*x_78 + 0.00617017297400931*x_79 + 0.000382181786902987*x_80 - 0.00525129509132764*x_81 - 0.00293469278001948*x_82 + 0.0135970569577053*x_83 + 0.00545289581244861*x_84 + 0.00459263802081995*x_85 - 0.0061074115699963*x_86 + 0.000592836196349225*x_87 + 0.00740026427997342*x_88 + 0.00731284855782502*x_89 + 0.0368451930048033*x_90 + 0.00994637342606204*x_91 + 0.0379062708867884*x_92 + 0.0106490383971876*x_93 + 0.0772765053906794*x_94 + 0.0180448178237923*x_96 - 0.165299229961444*x_98 + 0.115598915121918*x_99 - 1.68954476435988*std::sin(0.257279962301254*x_109 - 7.62152004241943) - 2.28892776079647*std::sin(0.303839921951294*x_11 - 4.42399978637695) - 0.306084472872783*std::sin(0.217519998550415*x_110 + 1.97559976577759) + 1.6184742702884*std::sin(0.360239863395691*x_13 + 1.82303988933563) + 1.64101787213372*std::sin(0.375999838113785*x_17 + 8.1940803527832) + 1.6590176286212*std::sin(0.339519828557968*x_19 - 4.35431957244873) + 0.122630458748567*std::sin(0.374479830265045*x_3 + 1.60391974449158) + 2.70344903484011*std::sin(0.249119967222214*x_41 - 4.41247987747192) + 2.47048634738167*std::sin(0.278879970312119*x_43 - 1.24959993362427) - 1.54125756994404*std::sin(0.363439828157425*x_8 + 5.03832006454468) + 0.179386228047278*std::sin(0.292239934206009*x_9 + 7.77375984191895) - 1.73812006346122*std::sin(0.297679930925369*x_95 - 7.603440284729) + 0.74430577967513*std::sin(0.315039932727814*x_97 - 4.61624002456665) - 6.94803848542673, 2) - 0.000988315839244565*std::sin(0.138000041246414*x_10 - 1.42351984977722) + 0.000170215372715268*std::sin(0.200960010290146*x_10 + 1.78887987136841) - 1.51335569210138e-5*std::sin(0.316079914569855*x_10 + 7.98695993423462) + 0.000106455031781123*std::sin(0.26335996389389*x_100 + 8.17239952087402) - 0.000250359684315008*std::sin(0.269679963588715*x_100 - 7.62152004241943) + 3.50799509400087e-6*std::sin(0.267759948968887*x_104 - 7.62703990936279) - 0.000408633047619895*std::sin(0.282559931278229*x_108 + 4.9696798324585) - 0.0022925134064404*std::sin(0.26063996553421*x_109 - 1.41407990455627) + 0.00182656194053531*std::sin(0.263759940862656*x_11 + 7.98880004882813) + 0.000194659484356057*std::sin(0.297439932823181*x_11 + 7.97616004943848) - 1.44609033440108e-5*std::sin(0.351279854774475*x_11 + 5.06895971298218) + 2.41862076164539e-5*std::sin(0.368719846010208*x_11 - 4.56192016601563) + 3.7415636843028e-6*std::sin(0.299279928207397*x_113 - 1.2027999162674) - 0.00114904753424036*std::sin(0.306559920310974*x_113 + 4.98847961425781) + 0.00144315469683181*std::sin(0.275919944047928*x_116 - 4.43304014205933) + 3.4917212228758e-5*std::sin(0.298799932003021*x_116 - 7.64735984802246) + 5.67708074919947e-5*std::sin(0.34079983830452*x_119 - 4.77639961242676) - 0.000925848616234419*std::sin(0.379839837551117*x_12 + 4.80951976776123) + 7.34189099786115e-5*std::sin(0.299279928207397*x_13 - 4.42256021499634) + 0.000346856126170008*std::sin(0.364799857139587*x_13 - 4.56383991241455) - 0.000321619712693649*std::sin(0.367439836263657*x_13 + 8.00944042205811) - 0.000114188026897478*std::sin(0.339519828557968*x_14 - 7.54960012435913) - 0.00167463177696443*std::sin(0.347119837999344*x_15 - 1.34447979927063) - 6.98433066178066e-5*std::sin(0.376879841089249*x_15 + 1.7986398935318) + 0.000396976084951642*std::sin(0.309759914875031*x_16 + 1.7869598865509) + 1.87331962553785e-5*std::sin(0.312959939241409*x_16 + 1.77959990501404) + 0.00125569931288186*std::sin(0.353839844465256*x_16 + 1.81879985332489) + 4.38096560276171e-5*std::sin(0.367599844932556*x_17 - 4.38447999954224) - 7.88206404633015e-5*std::sin(0.37967985868454*x_17 - 7.58376026153564) + 0.000114298177016291*std::sin(0.416159868240356*x_17 + 8.00039958953857) - 7.97406324202135e-5*std::sin(0.38663986325264*x_18 + 5.01535987854004) + 0.00064655027318703*std::sin(0.305999934673309*x_20 + 4.99823999404907) - 2.27120323976248e-5*std::sin(0.364079833030701*x_20 - 7.58983993530273) + 1.32462887271201e-5*std::sin(0.291439920663834*x_21 + 8.20351982116699) + 1.84462632043482e-5*std::sin(0.356879830360413*x_21 - 1.38127982616425) - 0.000526503933817494*std::sin(0.3713598549366*x_21 - 7.59679985046387) - 0.00100944653154674*std::sin(0.371759831905365*x_21 - 1.39455986022949) - 0.00078966784934539*std::sin(0.377679854631424*x_21 - 7.78287982940674) + 1.66150871103241e-5*std::sin(0.411999881267548*x_21 + 7.98016023635864) - 9.37772657776079e-5*std::sin(0.166400015354156*x_22 - 7.81447982788086) - 0.000198422141678418*std::sin(0.294319927692413*x_24 - 7.77375984191895) + 8.93065508700447e-6*std::sin(0.320479929447174*x_24 + 1.57775974273682) - 7.88875912531122e-5*std::sin(0.341279834508896*x_24 - 1.39759981632233) + 3.87954418524179e-5*std::sin(0.223199993371964*x_28 + 1.58655989170074) - 0.000272029026039865*std::sin(0.247759968042374*x_28 - 1.37271988391876) + 0.000198796488959881*std::sin(0.24967996776104*x_28 - 4.58311986923218) - 0.00248804537859707*std::sin(0.186240002512932*x_29 - 1.58527982234955) - 0.000571124535768716*std::sin(0.355439841747284*x_29 + 5.01103973388672) - 9.62686768259981e-6*std::sin(0.327199846506119*x_3 - 1.18575978279114) - 9.03637944253668e-5*std::sin(0.292399942874908*x_33 + 1.76831984519958) + 0.00059606628407463*std::sin(0.233039990067482*x_38 + 1.79367995262146) + 0.00102664008839921*std::sin(0.307439923286438*x_4 - 7.55136013031006) - 6.22907638983792e-5*std::sin(0.259039968252182*x_42 + 8.17671966552734) + 5.83349444275718e-5*std::sin(0.284799933433533*x_44 + 1.55623984336853) + 0.000662187814987457*std::sin(0.245679974555969*x_48 + 4.99599981307983) - 0.000896565001755107*std::sin(0.289359927177429*x_48 - 7.82352018356323) + 0.000679185710462102*std::sin(0.428159862756729*x_5 + 1.76775991916656) - 0.000655085223636171*std::sin(0.245119974017143*x_52 + 1.78615987300873) - 0.000144119416235186*std::sin(0.250079959630966*x_53 - 1.40391981601715) - 0.000495507870980712*std::sin(0.270319938659668*x_53 + 4.96719980239868) + 0.00330908718463884*std::sin(0.276479959487915*x_53 - 4.41447973251343) + 0.000715223480657868*std::sin(0.197279989719391*x_56 + 7.98432016372681) + 0.00229221977205464*std::sin(0.284719944000244*x_56 + 8.13599967956543) + 0.000443832456113459*std::sin(0.229599997401237*x_57 + 1.58239984512329) + 0.000297701710014474*std::sin(0.174960017204285*x_58 + 1.61359977722168) - 0.00122023366621892*std::sin(0.156480029225349*x_59 + 4.61399984359741) + 0.000224519991201004*std::sin(0.425759851932526*x_6 - 1.21807992458344) + 8.2589747431191e-5*std::sin(0.390319854021072*x_7 + 8.19863986968994) + 4.70823231257468e-5*std::sin(0.438399881124496*x_7 + 4.7912802696228) - 0.000768721127774256*std::sin(0.325519859790802*x_8 + 1.81727993488312) + 0.000115402766581281*std::sin(0.326719850301743*x_8 + 1.61639988422394) + 0.000177261799972731*std::sin(0.372399836778641*x_8 - 1.36783981323242) - 0.000370783097635596*std::sin(0.38351982831955*x_8 - 1.37175989151001) - 0.000906162448989564*std::sin(0.39711982011795*x_8 - 7.78391981124878) - 6.14641817953238e-5*std::sin(0.262079983949661*x_9 - 7.58767986297607) - 2.32113918738058e-5*std::sin(0.292479932308197*x_9 - 1.3971198797226) + 0.000147688997987267*std::sin(0.289119929075241*x_95 - 4.40375995635986) + 0.000496254784465208*std::sin(0.305999934673309*x_96 + 8.15655994415283) + 5.54865109965256e-6*std::sin(0.259039968252182*x_98 + 1.97967982292175) + 0.0339796857439803);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.58201122870193e-5*x_1 - 0.000149229915742014*x_10 - 0.0006193860217836*x_100 - 0.000246866599268063*x_101 - 0.000198794510133527*x_102 - 5.09767502313584e-5*x_103 - 0.000338804065161841*x_104 - 0.000176196073412424*x_105 + 1.72312407044259e-5*x_106 - 1.29535659332107e-5*x_107 - 0.000158944211899177*x_108 - 3.40413204545836e-5*x_109 - 0.000539836375798894*x_11 + 0.000418472324557825*x_110 + 0.000184477026822214*x_111 - 0.00072783694283426*x_112 - 0.000177099009951321*x_113 - 0.00053955809791049*x_114 + 0.000210670451172812*x_115 + 3.97263996474991e-6*x_116 + 0.000645569877343654*x_117 + 0.000216785137526026*x_118 + 0.000289955740767056*x_119 - 6.09682429801664e-5*x_12 + 1.12673751902401e-5*x_120 + 1.25085820828767e-5*x_13 - 9.51672155066854e-6*x_14 + 4.59609641562562e-5*x_15 - 9.88284150432742e-5*x_16 + 0.000134907477540141*x_17 - 1.28706800772582e-5*x_18 + 4.36802920494425e-5*x_19 - 4.83854652381623e-5*x_2 + 1.25941737441505e-5*x_20 - 4.50809599127985e-5*x_21 + 0.000389433872567901*x_22 + 8.42128163902942e-5*x_23 - 0.000152849612646773*x_24 - 0.000333607394708429*x_25 - 6.14637211786e-5*x_26 + 0.000279242356041589*x_27 - 3.97000936155172e-5*x_28 + 0.000398363995854691*x_29 - 4.99524326672203e-5*x_3 - 0.000661604986063646*x_30 - 6.52077850583515e-5*x_31 - 0.000122253227641119*x_32 - 0.000229996669560405*x_33 - 0.000929585516022807*x_34 + 0.000182927803074274*x_35 + 4.40640354414386e-5*x_36 + 0.00082049151083707*x_37 + 0.000774793381256449*x_38 + 3.63754424751764e-5*x_39 + 3.89730863931763e-5*x_4 - 0.00031562119652649*x_40 - 0.000101736367432064*x_41 - 0.000473249627403468*x_42 - 5.92183508226801e-5*x_43 - 0.00028784207159883*x_44 - 0.000573311897679733*x_45 + 0.000285820530998603*x_46 - 0.000828733891965841*x_47 + 0.00109163267496585*x_48 - 0.00110471008510975*x_49 - 0.000113199402360883*x_5 + 0.000316090442162898*x_50 + 0.000439582493420484*x_51 - 0.00018744279248603*x_52 + 0.000321246163716749*x_53 + 0.000112522978000882*x_54 - 0.00110232967422773*x_55 - 0.00122310906089454*x_56 + 1.16324401803916e-5*x_57 + 0.000508971941460437*x_58 + 0.000994106282992854*x_59 - 8.40991642682721e-6*x_6 + 0.000239197228675673*x_60 + 5.9639436124648e-6*x_61 - 2.02433168577498e-6*x_62 - 1.29367577301843e-5*x_63 + 1.04991099071396e-5*x_64 + 1.27090016127969e-5*x_65 + 2.26050939701064e-5*x_66 + 9.9368921106052e-6*x_67 - 4.83401275140026e-8*x_68 + 2.17956413769411e-7*x_69 - 1.4065608621714e-5*x_7 + 2.85275162650035e-5*x_70 + 3.54622449482751e-5*x_71 + 1.94382681865757e-5*x_72 + 4.19308657031521e-5*x_73 + 2.08182071149618e-5*x_74 + 7.78742035791635e-6*x_75 + 1.11424633088135e-5*x_76 - 4.54107154710058e-6*x_77 + 1.75313893655089e-5*x_78 + 2.50113869671505e-5*x_79 + 6.13264900143149e-5*x_8 + 2.69396014594875e-5*x_80 - 4.72329212021899e-5*x_81 + 1.38973041432291e-5*x_82 - 6.72469589327531e-6*x_83 - 2.30630202620717e-6*x_84 - 1.92960990378051e-7*x_85 - 3.17542907667772e-5*x_86 - 3.37001609083163e-5*x_87 - 2.34498964967647e-6*x_88 - 1.89346639685903e-5*x_89 - 5.25067627967807e-5*x_9 - 2.10398926759558e-5*x_90 - 0.000104303676326668*x_91 + 6.76869319801948e-5*x_92 - 4.65838610394305e-5*x_93 - 0.00035799432475425*x_94 - 7.8764584360402e-5*x_95 - 0.000161190229043898*x_96 - 0.00043519102437447*x_97 - 0.000311272955379647*x_98 - 0.000409788257665575*x_99 - 9.91524388776201e-9*std::pow(-6.62312030792236*x_10 - 9.87071990966797, 2) - 3.12614294449648e-7*std::pow(-7.36040019989014*x_44 - 6.54855966567993, 2) + 0.000692368547811197*std::sin(0.138000041246414*x_10 - 1.42351984977722) + 6.32771220537102e-6*std::sin(0.200960010290146*x_10 + 1.78887987136841) + 0.00123056502374873*std::sin(0.316079914569855*x_10 + 7.98695993423462) + 3.95743811607062e-6*std::sin(0.26335996389389*x_100 + 8.17239952087402) + 0.000175390461405686*std::sin(0.269679963588715*x_100 - 7.62152004241943) - 0.000285247948561613*std::sin(0.267759948968887*x_104 - 7.62703990936279) + 0.000286269488491158*std::sin(0.282559931278229*x_108 + 4.9696798324585) - 0.000464621256533674*std::sin(0.26063996553421*x_109 - 1.41407990455627) - 0.000973384641882584*std::sin(0.263759940862656*x_11 + 7.98880004882813) - 0.000136369467279101*std::sin(0.297439932823181*x_11 + 7.97616004943848) + 3.0968835915112e-5*std::sin(0.351279854774475*x_11 + 5.06895971298218) + 8.9911597698217e-7*std::sin(0.368719846010208*x_11 - 4.56192016601563) - 0.000304240267378134*std::sin(0.299279928207397*x_113 - 1.2027999162674) + 0.000612333585739135*std::sin(0.306559920310974*x_113 + 4.98847961425781) - 0.000769064868035689*std::sin(0.275919944047928*x_116 - 4.43304014205933) - 0.00283924660407214*std::sin(0.298799932003021*x_116 - 7.64735984802246) - 3.97710124441047e-5*std::sin(0.34079983830452*x_119 - 4.77639961242676) - 0.000978396991003257*std::sin(0.379839837551117*x_12 + 4.80951976776123) - 2.51579903608305e-5*std::sin(0.299279928207397*x_13 - 4.42256021499634) + 0.000451035142456794*std::sin(0.364799857139587*x_13 - 4.56383991241455) + 0.000225311954521911*std::sin(0.367439836263657*x_13 + 8.00944042205811) - 4.24491019806458e-6*std::sin(0.339519828557968*x_14 - 7.54960012435913) + 0.000892420243919022*std::sin(0.347119837999344*x_15 - 1.34447979927063) + 2.39327611261349e-5*std::sin(0.376879841089249*x_15 + 1.7986398935318) + 0.000516208743392194*std::sin(0.309759914875031*x_16 + 1.7869598865509) - 0.00152326490164911*std::sin(0.312959939241409*x_16 + 1.77959990501404) - 0.000669168889845315*std::sin(0.353839844465256*x_16 + 1.81879985332489) + 5.69679845807722e-5*std::sin(0.367599844932556*x_17 - 4.38447999954224) - 2.93013680690931e-6*std::sin(0.37967985868454*x_17 - 7.58376026153564) - 1.92544219436175e-5*std::sin(0.416159868240356*x_17 + 8.00039958953857) - 2.96433726860517e-6*std::sin(0.38663986325264*x_18 + 5.01535987854004) + 0.00068324651646761*std::sin(0.305999934673309*x_20 + 4.99823999404907) - 8.44313896675098e-7*std::sin(0.364079833030701*x_20 - 7.58983993530273) - 2.83676705607938e-5*std::sin(0.291439920663834*x_21 + 8.20351982116699) - 0.00149993332278777*std::sin(0.356879830360413*x_21 - 1.38127982616425) - 0.000684640572492127*std::sin(0.3713598549366*x_21 - 7.59679985046387) + 0.000537939463646812*std::sin(0.371759831905365*x_21 - 1.39455986022949) - 0.000160041144089439*std::sin(0.377679854631424*x_21 - 7.78287982940674) + 6.17661541517569e-7*std::sin(0.411999881267548*x_21 + 7.98016023635864) - 3.48614546254825e-6*std::sin(0.166400015354156*x_22 - 7.81447982788086) - 0.000258018677446227*std::sin(0.294319927692413*x_24 - 7.77375984191895) - 0.000726184323129709*std::sin(0.320479929447174*x_24 + 1.57775974273682) - 2.93262568510571e-6*std::sin(0.341279834508896*x_24 - 1.39759981632233) + 1.44221045964485e-6*std::sin(0.223199993371964*x_28 + 1.58655989170074) + 0.000190571003967395*std::sin(0.247759968042374*x_28 - 1.37271988391876) - 0.000425733835614684*std::sin(0.24967996776104*x_28 - 4.58311986923218) - 0.00262925932945671*std::sin(0.186240002512932*x_29 - 1.58527982234955) - 0.000742663072425465*std::sin(0.355439841747284*x_29 + 5.01103973388672) + 2.06164773075815e-5*std::sin(0.327199846506119*x_3 - 1.18575978279114) + 3.09643860115021e-5*std::sin(0.292399942874908*x_33 + 1.76831984519958) - 0.00041757657938521*std::sin(0.233039990067482*x_38 + 1.79367995262146) - 0.000547102002188822*std::sin(0.307439923286438*x_4 - 7.55136013031006) + 0.00506509049762772*std::sin(0.259039968252182*x_42 + 8.17671966552734) - 4.08667747254127e-5*std::sin(0.284799933433533*x_44 + 1.55623984336853) + 0.0011257217565116*std::sin(0.245679974555969*x_48 + 4.99599981307983) - 0.000181705876401558*std::sin(0.289359927177429*x_48 - 7.82352018356323) - 0.000361941703086276*std::sin(0.428159862756729*x_5 + 1.76775991916656) - 0.00111364732471024*std::sin(0.245119974017143*x_52 + 1.78615987300873) + 4.93844826286525e-5*std::sin(0.250079959630966*x_53 - 1.40391981601715) + 0.000347129987638534*std::sin(0.270319938659668*x_53 + 4.96719980239868) + 0.00067064918416055*std::sin(0.276479959487915*x_53 - 4.41447973251343) - 0.000501052622046481*std::sin(0.197279989719391*x_56 + 7.98432016372681) - 0.00122153619454246*std::sin(0.284719944000244*x_56 + 8.13599967956543) + 0.000577138530838474*std::sin(0.229599997401237*x_57 + 1.58239984512329) - 0.00063754491609301*std::sin(0.174960017204285*x_58 + 1.61359977722168) - 0.000529739422035491*std::sin(0.156480029225349*x_59 + 4.61399984359741) - 0.00015728836277808*std::sin(0.425759851932526*x_6 - 1.21807992458344) + 3.07025237804493e-6*std::sin(0.390319854021072*x_7 + 8.19863986968994) - 1.61333998517291e-5*std::sin(0.438399881124496*x_7 + 4.7912802696228) + 0.000409655606558204*std::sin(0.325519859790802*x_8 + 1.81727993488312) - 0.000247141499904005*std::sin(0.326719850301743*x_8 + 1.61639988422394) - 0.000124181451066624*std::sin(0.372399836778641*x_8 - 1.36783981323242) - 0.000482148633524995*std::sin(0.38351982831955*x_8 - 1.37175989151001) - 0.000183650980836307*std::sin(0.39711982011795*x_8 - 7.78391981124878) - 7.99250868022906e-5*std::sin(0.262079983949661*x_9 - 7.58767986297607) - 8.62877455311977e-7*std::sin(0.292479932308197*x_9 - 1.3971198797226) - 5.06076484770315e-5*std::sin(0.289119929075241*x_95 - 4.40375995635986) - 0.000347653240817393*std::sin(0.305999934673309*x_96 + 8.15655994415283) - 9.34713678551497e-7*std::sin(0.259039968252182*x_98 + 1.97967982292175) - 1.12731075286865*std::sin(-1.34622919457697e-5*x_1 - 0.00226651638487788*x_10 + 0.00224947773297419*x_100 + 0.0051607270334086*x_101 - 0.0151226293972661*x_102 - 0.019747751486613*x_103 - 0.00857112166382071*x_104 + 0.00487367510205089*x_105 + 0.00985933943219947*x_106 - 0.0162164278576368*x_107 - 0.00142917309564003*x_108 - 0.0254942469547716*x_111 + 0.00266069136657923*x_112 - 0.00825039017724703*x_113 - 0.00428634673803721*x_114 - 0.0119045546975198*x_115 + 0.00112968900944058*x_116 + 0.00143762266780694*x_117 + 0.00078580481003532*x_118 + 0.00885669923230169*x_119 - 0.00138346855109994*x_12 + 0.000910732472833318*x_120 + 0.000722533403225817*x_14 - 0.0216434899324085*x_15 - 0.000373837675208914*x_16 - 0.00119470342110669*x_18 - 0.00040032820815095*x_2 - 0.00144671347659242*x_20 + 0.00135436266062582*x_21 - 0.00096784032260227*x_22 - 0.00103080321812955*x_23 + 0.0103004446157507*x_24 + 0.000283275501612798*x_25 + 0.00813479958179964*x_26 - 0.00875684307790747*x_27 + 0.0180871206617445*x_28 - 0.00203929653563722*x_29 - 0.00054094449120275*x_30 + 0.00148809098505852*x_31 + 0.000587393451865256*x_32 - 0.00030256545575157*x_33 + 0.0262138069709983*x_34 - 0.0037661156725614*x_35 + 0.0107401751555799*x_36 + 0.00155820120635361*x_37 + 0.00609785789916475*x_38 - 0.00670132283580561*x_39 - 0.00057609225298533*x_4 - 0.000105509172589091*x_40 + 0.0122643077441198*x_42 + 0.000497285660749716*x_44 - 0.00131814333605107*x_45 - 0.000281481511135692*x_46 - 0.0257275155232882*x_47 + 0.0315393055968153*x_48 + 0.0112067643955515*x_49 - 0.000439778881269063*x_5 + 0.00384800529250617*x_50 + 0.0169040965740785*x_51 + 0.0260413562615238*x_52 + 0.0134370492916625*x_53 + 0.0144452003809634*x_54 - 0.00109749116406606*x_55 + 0.0129213587867308*x_56 - 0.00120024376638221*x_57 - 0.0301313204641297*x_58 + 0.0120471216898738*x_59 + 0.00713472034104519*x_6 + 0.0257589122052791*x_60 + 4.83833672991007e-5*x_61 + 8.08419283098716e-6*x_62 + 0.00177899759052021*x_63 - 0.000259638416513588*x_64 + 0.00154213185149742*x_65 + 0.000227442588643826*x_66 + 6.95525919387677e-5*x_67 + 0.000278370542376787*x_68 + 5.76821644262376e-5*x_69 + 0.0152248008236138*x_7 + 8.07391170959299e-5*x_70 - 0.000214899188278668*x_71 + 1.81248088978115e-5*x_72 + 0.000338066169618929*x_73 + 0.000192715593048831*x_74 - 0.000100550649966191*x_75 + 7.58041235183528e-5*x_76 - 0.00738246867687136*x_77 + 0.000124287760562776*x_78 + 0.000427693551672365*x_79 + 2.64914268228071e-5*x_80 - 0.000364000338069969*x_81 - 0.00020342204075005*x_82 + 0.000942497658822303*x_83 + 0.000377974553833309*x_84 + 0.000318344667960529*x_85 - 0.000423343163457425*x_86 + 4.10932107486413e-5*x_87 + 0.000512958927820683*x_88 + 0.000506899593530519*x_89 + 0.00255397239666661*x_90 + 0.00068944578940838*x_91 + 0.00262752238786763*x_92 + 0.000738151924293474*x_93 + 0.0053565213148137*x_94 + 0.00125079997867932*x_96 - 0.0114579307660768*x_98 + 0.0080128889070413*x_99 - 0.117112989218029*std::sin(0.257279962301254*x_109 - 7.62152004241943) - 0.158659999915756*std::sin(0.303839921951294*x_11 - 4.42399978637695) - 0.0212166426883265*std::sin(0.217519998550415*x_110 + 1.97559976577759) + 0.112186645636321*std::sin(0.360239863395691*x_13 + 1.82303988933563) + 0.11374928467113*std::sin(0.375999838113785*x_17 + 8.1940803527832) + 0.114996961164771*std::sin(0.339519828557968*x_19 - 4.35431957244873) + 0.00850028948399251*std::sin(0.374479830265045*x_3 + 1.60391974449158) + 0.18739308028259*std::sin(0.249119967222214*x_41 - 4.41247987747192) + 0.171244969099007*std::sin(0.278879970312119*x_43 - 1.24959993362427) - 0.106834269785949*std::sin(0.363439828157425*x_8 + 5.03832006454468) + 0.0124343893303847*std::sin(0.292239934206009*x_9 + 7.77375984191895) - 0.120480049150338*std::sin(0.297679930925369*x_95 - 7.603440284729) + 0.0515925216003588*std::sin(0.315039932727814*x_97 - 4.61624002456665) - 2.05018285177797) - 1.06162439254706);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.28962161489628e-5*x_1 + 0.000149221449834506*x_10 + 0.000212940354323012*x_100 + 3.07327752902438e-5*x_101 + 0.000180803367098475*x_102 - 0.000251135236093537*x_103 - 0.000506653516401399*x_104 - 0.0001229196711276*x_105 - 0.00019200016845811*x_106 - 6.1067968132487e-6*x_107 - 0.000196980843444849*x_108 - 6.75874019594998e-7*x_109 + 0.000134440662410782*x_11 - 0.000317203057011992*x_110 + 8.44939030795713e-5*x_111 + 0.000330424803380425*x_112 + 0.000227697998481252*x_113 - 0.000381135221935697*x_114 - 0.000307932962374745*x_115 + 0.000197922362314496*x_116 - 0.000295241706302394*x_117 - 0.000431783017794454*x_118 + 7.7975184515993e-5*x_119 - 0.000379127870278031*x_12 + 0.000208120229795058*x_120 - 0.000345854626499339*x_13 + 0.000410648058481395*x_14 - 0.000183002700876023*x_15 + 0.000156409254683264*x_16 + 0.000103775010075376*x_17 - 0.000126227547491051*x_18 - 0.00048764202166682*x_19 - 1.91270688576484e-5*x_2 - 2.38981503145747e-5*x_20 - 8.97346651582151e-5*x_21 - 0.000115616062611404*x_22 - 0.000113505569158581*x_23 - 5.26923115172115e-5*x_24 - 1.00432608185255e-5*x_25 + 4.90344062862981e-5*x_26 - 0.000121051087291148*x_27 + 0.000223230330413702*x_28 - 0.000253055081935721*x_29 - 5.55675490212571e-5*x_3 + 0.000257593765667331*x_30 + 2.9308509581998e-5*x_31 + 7.73903376653943e-7*x_32 - 3.4867928200873e-5*x_33 - 0.0003498236648901*x_34 + 0.00063517424807348*x_35 + 4.2194779370906e-5*x_36 - 3.09767174682144e-5*x_37 - 0.000664660913236547*x_38 - 0.000203910311362801*x_39 - 0.000119483886533744*x_4 + 9.30769443820565e-5*x_40 - 0.000291729648903728*x_41 - 0.000687671124089789*x_42 - 0.00029921336459191*x_43 + 4.64483044154902e-6*x_44 + 4.30979098483892e-5*x_45 - 0.000385359026003556*x_46 - 0.000849368879513245*x_47 - 0.000602643713859235*x_48 - 0.000812217262799339*x_49 - 2.8395522083948e-5*x_5 - 0.00144043154791483*x_50 - 0.000508955602229581*x_51 - 3.21281067240232e-5*x_52 - 9.42177518813877e-5*x_53 + 0.000178878503095717*x_54 + 0.000635694166443397*x_55 + 0.000147132833808131*x_56 - 0.000605245920037056*x_57 + 0.000573740778239043*x_58 - 0.00137227827154125*x_59 - 0.000191040894577387*x_6 - 0.000549673649223551*x_60 - 6.70416339435603e-6*x_61 - 1.51871729253737e-5*x_62 + 1.2679963784078e-5*x_63 + 7.89442186660357e-7*x_64 - 9.70524667173153e-6*x_65 - 2.24910914760442e-5*x_66 - 1.99123023795383e-5*x_67 - 4.80172772339806e-7*x_68 + 7.85590463319989e-6*x_69 + 9.15314370281572e-5*x_7 - 2.52820523412671e-5*x_70 - 1.07134936014192e-5*x_71 - 5.12525192583256e-6*x_72 + 1.04474148338915e-5*x_73 + 2.58161644521856e-6*x_74 - 4.73143190243978e-6*x_75 - 5.90890344577388e-6*x_76 + 1.32426075563796e-5*x_77 + 4.9874421703873e-6*x_78 - 1.41871560039682e-5*x_79 - 3.43170124999617e-5*x_8 - 3.53198809187826e-5*x_80 + 2.7063736850095e-5*x_81 - 4.86628813355928e-6*x_82 + 3.40076760674011e-5*x_83 + 5.65382652872087e-6*x_84 + 9.75326695527064e-6*x_85 + 2.20855527245965e-5*x_86 - 1.81729198544123e-5*x_87 + 1.25698935819943e-5*x_88 - 4.86413458084596e-6*x_89 - 6.44941474060181e-5*x_9 + 6.55142464327304e-6*x_90 + 3.19628108297033e-6*x_91 - 0.000180462191746446*x_92 + 0.000208312469272425*x_93 + 6.9744598937323e-5*x_94 + 1.31318472494024e-5*x_95 - 3.69750084685761e-5*x_96 - 0.000208749749024039*x_97 - 1.63597214380285e-5*x_98 + 0.000329049193140419*x_99 - 2.62446429001267e-10*std::pow(-6.62312030792236*x_10 - 9.87071990966797, 2) - 1.28585904547448e-7*std::pow(-7.36040019989014*x_44 - 6.54855966567993, 2) - 0.00145233014484895*std::sin(0.138000041246414*x_10 - 1.42351984977722) + 0.000540772857063196*std::sin(0.200960010290146*x_10 + 1.78887987136841) - 9.70969807612062e-5*std::sin(0.316079914569855*x_10 + 7.98695993423462) + 0.000338206771613568*std::sin(0.26335996389389*x_100 + 8.17239952087402) - 0.000367903560934003*std::sin(0.269679963588715*x_100 - 7.62152004241943) + 2.25073149643785e-5*std::sin(0.267759948968887*x_104 - 7.62703990936279) - 0.000600486271365943*std::sin(0.282559931278229*x_108 + 4.9696798324585) - 0.00112147298537174*std::sin(0.26063996553421*x_109 - 1.41407990455627) - 0.0020372499066415*std::sin(0.263759940862656*x_11 + 7.98880004882813) + 0.000286052116019053*std::sin(0.297439932823181*x_11 + 7.97616004943848) - 0.000191052914960218*std::sin(0.351279854774475*x_11 + 5.06895971298218) + 7.68393852190543e-5*std::sin(0.368719846010208*x_11 - 4.56192016601563) + 2.40058922676084e-5*std::sin(0.299279928207397*x_113 - 1.2027999162674) + 0.00128158642195938*std::sin(0.306559920310974*x_113 + 4.98847961425781) - 0.00160961788710445*std::sin(0.275919944047928*x_116 - 4.43304014205933) + 0.000224029017216896*std::sin(0.298799932003021*x_116 - 7.64735984802246) + 8.34247027054252e-5*std::sin(0.34079983830452*x_119 - 4.77639961242676) - 7.10912419608459e-6*std::sin(0.379839837551117*x_12 + 4.80951976776123) + 0.000784653335984829*std::sin(0.299279928207397*x_13 - 4.42256021499634) + 0.000185521784528747*std::sin(0.364799857139587*x_13 - 4.56383991241455) - 0.000472620174012064*std::sin(0.367439836263657*x_13 + 8.00944042205811) - 0.000362774434310652*std::sin(0.339519828557968*x_14 - 7.54960012435913) + 0.00186779509392375*std::sin(0.347119837999344*x_15 - 1.34447979927063) - 0.000746439623658789*std::sin(0.376879841089249*x_15 + 1.7986398935318) + 0.000212329280467621*std::sin(0.309759914875031*x_16 + 1.7869598865509) + 0.000120192285653526*std::sin(0.312959939241409*x_16 + 1.77959990501404) - 0.00140054013563244*std::sin(0.353839844465256*x_16 + 1.81879985332489) + 2.34323252571022e-5*std::sin(0.367599844932556*x_17 - 4.38447999954224) - 0.000250412534772585*std::sin(0.37967985868454*x_17 - 7.58376026153564) - 8.42395319059115e-5*std::sin(0.416159868240356*x_17 + 8.00039958953857) - 0.000253335341749876*std::sin(0.38663986325264*x_18 + 5.01535987854004) + 4.9645331974393e-6*std::sin(0.305999934673309*x_20 + 4.99823999404907) - 7.2155942518309e-5*std::sin(0.364079833030701*x_20 - 7.58983993530273) + 0.000175005807971817*std::sin(0.291439920663834*x_21 + 8.20351982116699) + 0.00011835132168973*std::sin(0.356879830360413*x_21 - 1.38127982616425) - 0.000281609410915669*std::sin(0.3713598549366*x_21 - 7.59679985046387) + 0.00112588289863879*std::sin(0.371759831905365*x_21 - 1.39455986022949) - 0.000386297047585217*std::sin(0.377679854631424*x_21 - 7.78287982940674) + 5.27859968443254e-5*std::sin(0.411999881267548*x_21 + 7.98016023635864) - 0.00029792961195674*std::sin(0.166400015354156*x_22 - 7.81447982788086) - 0.000106129392093115*std::sin(0.294319927692413*x_24 - 7.77375984191895) + 5.72991299860094e-5*std::sin(0.320479929447174*x_24 + 1.57775974273682) - 0.00025062523688821*std::sin(0.341279834508896*x_24 - 1.39759981632233) + 0.000123252803767936*std::sin(0.223199993371964*x_28 + 1.58655989170074) - 0.000399746659016999*std::sin(0.247759968042374*x_28 - 1.37271988391876) + 0.00262643679970188*std::sin(0.24967996776104*x_28 - 4.58311986923218) - 1.91044446055125e-5*std::sin(0.186240002512932*x_29 - 1.58527982234955) - 0.000305475484126324*std::sin(0.355439841747284*x_29 + 5.01103973388672) - 0.00012718715345392*std::sin(0.327199846506119*x_3 - 1.18575978279114) - 0.000965749188714015*std::sin(0.292399942874908*x_33 + 1.76831984519958) + 0.000875919415954503*std::sin(0.233039990067482*x_38 + 1.79367995262146) - 0.00114505967623126*std::sin(0.307439923286438*x_4 - 7.55136013031006) - 0.000399657868629908*std::sin(0.259039968252182*x_42 + 8.17671966552734) + 8.57232019624508e-5*std::sin(0.284799933433533*x_44 + 1.55623984336853) - 2.65231410947756e-5*std::sin(0.245679974555969*x_48 + 4.99599981307983) - 0.000438589988731766*std::sin(0.289359927177429*x_48 - 7.82352018356323) - 0.000757527568337294*std::sin(0.428159862756729*x_5 + 1.76775991916656) + 2.62386552913751e-5*std::sin(0.245119974017143*x_52 + 1.78615987300873) - 0.00154025414926575*std::sin(0.250079959630966*x_53 - 1.40391981601715) - 0.000728148825971748*std::sin(0.270319938659668*x_53 + 4.96719980239868) + 0.00161876998118605*std::sin(0.276479959487915*x_53 - 4.41447973251343) + 0.00105102091863386*std::sin(0.197279989719391*x_56 + 7.98432016372681) - 0.00255661985120064*std::sin(0.284719944000244*x_56 + 8.13599967956543) + 0.000237391192132462*std::sin(0.229599997401237*x_57 + 1.58239984512329) + 0.00393314152884253*std::sin(0.174960017204285*x_58 + 1.61359977722168) - 1.4021664135363e-5*std::sin(0.156480029225349*x_59 + 4.61399984359741) + 0.000329932131404149*std::sin(0.425759851932526*x_6 - 1.21807992458344) + 0.000262386957006538*std::sin(0.390319854021072*x_7 + 8.19863986968994) + 0.000503185104727042*std::sin(0.438399881124496*x_7 + 4.7912802696228) + 0.000857390604192972*std::sin(0.325519859790802*x_8 + 1.81727993488312) + 0.00152466512121174*std::sin(0.326719850301743*x_8 + 1.61639988422394) + 0.0002604862184819*std::sin(0.372399836778641*x_8 - 1.36783981323242) - 0.000198319524311174*std::sin(0.38351982831955*x_8 - 1.37175989151001) - 0.000443284957045468*std::sin(0.39711982011795*x_8 - 7.78391981124878) - 3.28751428356747e-5*std::sin(0.262079983949661*x_9 - 7.58767986297607) - 7.37424035196175e-5*std::sin(0.292479932308197*x_9 - 1.3971198797226) + 0.00157840350657243*std::sin(0.289119929075241*x_95 - 4.40375995635986) + 0.000729246415351634*std::sin(0.305999934673309*x_96 + 8.15655994415283) - 4.08944205013289e-6*std::sin(0.259039968252182*x_98 + 1.97967982292175) - 0.266970992088318*std::sin(-2.10823607431464e-5*x_1 - 0.00354943394844909*x_10 + 0.00352275089867885*x_100 + 0.00808185630303589*x_101 - 0.0236824999504085*x_102 - 0.0309255825370514*x_103 - 0.0134226385535227*x_104 + 0.00763232420305779*x_105 + 0.0154400269609421*x_106 - 0.0253954217778898*x_107 - 0.00223812875905951*x_108 - 0.0399247701164475*x_111 + 0.00416672402012683*x_112 - 0.0129203632404578*x_113 - 0.00671255002978194*x_114 - 0.0186428965907619*x_115 + 0.00176912752453553*x_116 + 0.00225136104738499*x_117 + 0.00123059435537424*x_118 + 0.013869861756163*x_119 - 0.00216655404507494*x_12 + 0.00142623489448268*x_120 + 0.00113150939803876*x_14 - 0.0338943668978356*x_15 - 0.000585441227978282*x_16 - 0.0018709420807619*x_18 - 0.000626926212408269*x_2 - 0.0022655975318584*x_20 + 0.00212097333079554*x_21 - 0.00151566753306639*x_22 - 0.0016142693523024*x_23 + 0.0161308111634212*x_24 + 0.000443618095548241*x_25 + 0.0127393448342641*x_26 - 0.0137134839656766*x_27 + 0.0283249838981198*x_28 - 0.00319360071819439*x_29 - 0.000847135610451372*x_30 + 0.00233039597506917*x_31 + 0.000919876102841218*x_32 - 0.000473826753443238*x_33 + 0.0410516230995461*x_34 - 0.00589785227724962*x_35 + 0.0168194426318072*x_36 + 0.00244019072495866*x_37 + 0.00954943188786166*x_38 - 0.0104944764271832*x_39 - 0.000902178079906015*x_4 - 0.000165230589798128*x_40 + 0.0192062808597571*x_42 + 0.000778764547266698*x_44 - 0.00206425276124959*x_45 - 0.000440808651616964*x_46 - 0.0402900758260039*x_47 + 0.0493915167535301*x_48 + 0.0175501356457144*x_49 - 0.000688707172558771*x_5 + 0.00602609392553279*x_50 + 0.0264723320105752*x_51 + 0.0407815600165141*x_52 + 0.0210428299751207*x_53 + 0.0226216254011787*x_54 - 0.00171870471435787*x_55 + 0.0202352428792101*x_56 - 0.0018796184308374*x_57 - 0.047186568992195*x_58 + 0.0188661608592075*x_59 + 0.0111731901697946*x_6 + 0.0403392439898304*x_60 + 7.57698323195499e-5*x_61 + 1.26600931153915e-5*x_62 + 0.00278596461253545*x_63 - 0.000406601697672945*x_64 + 0.0024150256239972*x_65 + 0.000356182046969421*x_66 + 0.000108921485270176*x_67 + 0.000435936779435014*x_68 + 9.03320328944108e-5*x_69 + 0.0238425035275543*x_7 + 0.000126439925649838*x_70 - 0.00033653869853297*x_71 + 2.83840048279689e-5*x_72 + 0.000529421956652753*x_73 + 0.000301798510227789*x_74 - 0.000157465391783545*x_75 + 0.000118711574839538*x_76 - 0.0115611716376191*x_77 + 0.000194638432645611*x_78 + 0.000669781176949421*x_79 + 4.14863842746023e-5*x_80 - 0.000570035657281209*x_81 - 0.000318565134634985*x_82 + 0.00147598014683574*x_83 + 0.000591919706372707*x_84 + 0.000498537482149168*x_85 - 0.000662968336008996*x_86 + 6.43532242939682e-5*x_87 + 0.00080330936264768*x_88 + 0.000793820259909221*x_89 + 0.00399959885073532*x_90 + 0.00107969318327837*x_91 + 0.00411478038545478*x_92 + 0.00115596847950492*x_93 + 0.00838847613334826*x_94 + 0.00195879100484992*x_96 - 0.0179434698603706*x_98 + 0.0125484289906582*x_99 - 0.18340252137962*std::sin(0.257279962301254*x_109 - 7.62152004241943) - 0.248466410266985*std::sin(0.303839921951294*x_11 - 4.42399978637695) - 0.0332259110644451*std::sin(0.217519998550415*x_110 + 1.97559976577759) + 0.175687716727289*std::sin(0.360239863395691*x_13 + 1.82303988933563) + 0.178134857227278*std::sin(0.375999838113785*x_17 + 8.1940803527832) + 0.180088756759069*std::sin(0.339519828557968*x_19 - 4.35431957244873) + 0.0133117131944993*std::sin(0.374479830265045*x_3 + 1.60391974449158) + 0.293463292521182*std::sin(0.249119967222214*x_41 - 4.41247987747192) + 0.268174856743371*std::sin(0.278879970312119*x_43 - 1.24959993362427) - 0.167305732517988*std::sin(0.363439828157425*x_8 + 5.03832006454468) + 0.0194726338234164*std::sin(0.292239934206009*x_9 + 7.77375984191895) - 0.18867544016809*std::sin(0.297679930925369*x_95 - 7.603440284729) + 0.0807954660624581*std::sin(0.315039932727814*x_97 - 4.61624002456665) - 2.32497602980018) - 0.224235098774342);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-3.30924897913382e-5*x_1 - 0.000793078545808812*x_10 + 0.000862977023321194*x_100 + 0.00136588625625511*x_101 - 0.00352136839204361*x_102 - 0.00471033155259521*x_103 - 0.00198980794881256*x_104 + 0.000987234077479607*x_105 + 0.00211020066501497*x_106 - 0.0040343332668613*x_107 - 9.5151517192274e-5*x_108 - 7.54978149029102e-5*x_109 + 0.000150752355990972*x_11 - 0.000115066855016793*x_110 - 0.00646018518392428*x_111 + 0.00122912926179828*x_112 - 0.00196476558313109*x_113 - 0.000782654520614323*x_114 - 0.00353485162153515*x_115 - 0.000168230568963121*x_116 + 4.20356985540126e-5*x_117 + 0.000608615192423445*x_118 + 0.00192154992493503*x_119 - 0.000553341860363978*x_12 + 0.000279707707020675*x_120 + 0.000229242626562075*x_13 - 2.34404676897284e-6*x_14 - 0.00533285190836199*x_15 - 0.000325842033172623*x_16 + 7.50929600816341e-6*x_17 - 0.000407957715808815*x_18 + 0.000223028195929586*x_19 - 0.000112455304918386*x_2 - 0.000479536750448035*x_20 + 0.000433449496334054*x_21 - 0.000337707420399341*x_22 - 0.000198706889491102*x_23 + 0.00240535218964298*x_24 + 0.000557157793047812*x_25 + 0.00199280077729238*x_26 - 0.00247970118819893*x_27 + 0.0041998661567957*x_28 - 0.000356201222369463*x_29 + 9.27974148187801e-5*x_3 + 0.000301790356447935*x_30 + 0.000405642223842565*x_31 + 0.000196166890740559*x_32 + 0.000101269137496832*x_33 + 0.00732820624338818*x_34 - 0.000873507474009076*x_35 + 0.00297233538308655*x_36 - 0.000147318818537303*x_37 + 0.00199685651227577*x_38 - 0.00184767868434918*x_39 - 9.86448936569112e-5*x_4 + 0.000285902075134728*x_40 - 0.000409419977579066*x_41 + 0.00317182514199409*x_42 - 0.000542354974861569*x_43 + 8.98933888273129e-5*x_44 + 0.000431927456270247*x_45 - 0.000218398648381479*x_46 - 0.00523117261769575*x_47 + 0.007517911374484*x_48 + 0.00380099125456921*x_49 + 3.30759837081186e-5*x_5 + 0.00213959664627155*x_50 + 0.00489577994941067*x_51 + 0.00626947015832138*x_52 + 0.00343561651591531*x_53 + 0.00311670463005843*x_54 + 0.00048259293436153*x_55 + 0.00391086971432385*x_56 + 0.000197294206286532*x_57 - 0.00813165387333656*x_58 + 0.00270973971387935*x_59 + 0.00179178511971426*x_6 + 0.00640330943427256*x_60 + 5.21395619153597e-7*x_61 - 2.71523946020199e-5*x_62 + 0.000430068298441655*x_63 - 7.81538088696046e-5*x_64 + 0.000383247939368681*x_65 + 6.5488483967506e-5*x_66 + 3.64477483349254e-5*x_67 + 8.23373402174056e-5*x_68 - 2.48019582169685e-5*x_69 + 0.0037230828086061*x_7 + 4.4494347173419e-5*x_70 - 9.25862241273166e-5*x_71 - 1.10006390788929e-5*x_72 + 7.1956450629255e-5*x_73 + 9.11039895477435e-6*x_74 - 1.46493154794324e-5*x_75 + 1.64716375347438e-5*x_76 - 0.0018607319060392*x_77 + 1.89245749007321e-5*x_78 + 0.000113461187293982*x_79 - 1.62020865939231e-5*x_8 + 2.08138278961313e-5*x_80 - 6.21889756651467e-5*x_81 - 7.48483074292975e-5*x_82 + 0.000247611609659904*x_83 + 8.8222611294488e-5*x_84 + 7.37464150057535e-5*x_85 - 0.000121965194111684*x_86 + 4.65785110658022e-5*x_87 + 0.000107719630352872*x_88 + 0.000124510642391379*x_89 + 0.0001478747107003*x_9 + 0.000660150865154107*x_90 + 0.000306359249736965*x_91 + 0.00084796979677868*x_92 + 0.000305079415056108*x_93 + 0.00158340682875059*x_94 + 6.90880600928964e-5*x_95 + 0.000836614301023068*x_96 + 0.000434098769752947*x_97 - 0.00262894794174383*x_98 + 0.00205465773771395*x_99 + 1.00938982322363e-8*std::pow(-6.62312030792236*x_10 - 9.87071990966797, 2) - 3.25880384867287e-7*std::pow(-7.36040019989014*x_44 - 6.54855966567993, 2) - 0.00215771735040658*std::sin(0.138000041246414*x_10 - 1.42351984977722) + 0.000357963085468788*std::sin(0.200960010290146*x_10 + 1.78887987136841) - 0.00141402469564336*std::sin(0.316079914569855*x_10 + 7.98695993423462) + 0.000223875029805874*std::sin(0.26335996389389*x_100 + 8.17239952087402) - 0.000546591902343407*std::sin(0.269679963588715*x_100 - 7.62152004241943) + 0.000327774344194338*std::sin(0.267759948968887*x_104 - 7.62703990936279) - 0.000892138506525323*std::sin(0.282559931278229*x_108 + 4.9696798324585) - 0.0292410056783796*std::sin(0.257279962301254*x_109 - 7.62152004241943) - 0.000312717938405471*std::sin(0.26063996553421*x_109 - 1.41407990455627) + 0.000237784935425864*std::sin(0.263759940862656*x_11 + 7.98880004882813) + 0.000424985748621929*std::sin(0.297439932823181*x_11 + 7.97616004943848) - 0.0396145465114139*std::sin(0.303839921951294*x_11 - 4.42399978637695) + 0.000116944693992259*std::sin(0.351279854774475*x_11 + 5.06895971298218) + 5.086361687588e-5*std::sin(0.368719846010208*x_11 - 4.56192016601563) - 0.00529741383486093*std::sin(0.217519998550415*x_110 + 1.97559976577759) + 0.000349598146525628*std::sin(0.299279928207397*x_113 - 1.2027999162674) - 0.000149584959407683*std::sin(0.306559920310974*x_113 + 4.98847961425781) + 0.000187872329309081*std::sin(0.275919944047928*x_116 - 4.43304014205933) + 0.00326253772673401*std::sin(0.298799932003021*x_116 - 7.64735984802246) + 0.000123943532480164*std::sin(0.34079983830452*x_119 - 4.77639961242676) + 0.000522363793168446*std::sin(0.379839837551117*x_12 + 4.80951976776123) - 0.000396290969612982*std::sin(0.299279928207397*x_13 - 4.42256021499634) + 0.0280109863474052*std::sin(0.360239863395691*x_13 + 1.82303988933563) + 0.000470175255649309*std::sin(0.364799857139587*x_13 - 4.56383991241455) - 0.000702168686117901*std::sin(0.367439836263657*x_13 + 8.00944042205811) - 0.000240137525652215*std::sin(0.339519828557968*x_14 - 7.54960012435913) - 0.000218006408712801*std::sin(0.347119837999344*x_15 - 1.34447979927063) + 0.000376991046429464*std::sin(0.376879841089249*x_15 + 1.7986398935318) + 0.000538114561474737*std::sin(0.309759914875031*x_16 + 1.7869598865509) + 0.00175036194542323*std::sin(0.312959939241409*x_16 + 1.77959990501404) + 0.000163469069075428*std::sin(0.353839844465256*x_16 + 1.81879985332489) + 5.93854761919273e-5*std::sin(0.367599844932556*x_17 - 4.38447999954224) + 0.0284011491909565*std::sin(0.375999838113785*x_17 + 8.1940803527832) - 0.000165759879432667*std::sin(0.37967985868454*x_17 - 7.58376026153564) + 0.000316216589430487*std::sin(0.416159868240356*x_17 + 8.00039958953857) - 0.000167694623364719*std::sin(0.38663986325264*x_18 + 5.01535987854004) + 0.0287126715564852*std::sin(0.339519828557968*x_19 - 4.35431957244873) - 0.000364783666847929*std::sin(0.305999934673309*x_20 + 4.99823999404907) - 4.77634250340045e-5*std::sin(0.364079833030701*x_20 - 7.58983993530273) - 0.000107122158614506*std::sin(0.291439920663834*x_21 + 8.20351982116699) + 0.00172355196134145*std::sin(0.356879830360413*x_21 - 1.38127982616425) - 0.000713693958404163*std::sin(0.3713598549366*x_21 - 7.59679985046387) - 0.000131411463795944*std::sin(0.371759831905365*x_21 - 1.39455986022949) - 0.000107717277106703*std::sin(0.377679854631424*x_21 - 7.78287982940674) + 3.49415434838148e-5*std::sin(0.411999881267548*x_21 + 7.98016023635864) - 0.000197213676233181*std::sin(0.166400015354156*x_22 - 7.81447982788086) - 0.000268967949968993*std::sin(0.294319927692413*x_24 - 7.77375984191895) + 0.000834448035396253*std::sin(0.320479929447174*x_24 + 1.57775974273682) - 0.000165900677005254*std::sin(0.341279834508896*x_24 - 1.39759981632233) + 8.15868499189367e-5*std::sin(0.223199993371964*x_28 + 1.58655989170074) - 0.000593900983868754*std::sin(0.247759968042374*x_28 - 1.37271988391876) - 0.00160765852693271*std::sin(0.24967996776104*x_28 - 4.58311986923218) + 0.00140375521305539*std::sin(0.186240002512932*x_29 - 1.58527982234955) - 0.000774178699329162*std::sin(0.355439841747284*x_29 + 5.01103973388672) + 7.78520586483188e-5*std::sin(0.327199846506119*x_3 - 1.18575978279114) + 0.00212236930103934*std::sin(0.374479830265045*x_3 + 1.60391974449158) + 0.000487753845993751*std::sin(0.292399942874908*x_33 + 1.76831984519958) + 0.00130134771908876*std::sin(0.233039990067482*x_38 + 1.79367995262146) + 0.000133649750226409*std::sin(0.307439923286438*x_4 - 7.55136013031006) + 0.0467886795582595*std::sin(0.249119967222214*x_41 - 4.41247987747192) - 0.005820223158542*std::sin(0.259039968252182*x_42 + 8.17671966552734) + 0.042756786819742*std::sin(0.278879970312119*x_43 - 1.24959993362427) + 0.000127358397718877*std::sin(0.284799933433533*x_44 + 1.55623984336853) + 5.7162943010393e-5*std::sin(0.245679974555969*x_48 + 4.99599981307983) - 0.00012229893976092*std::sin(0.289359927177429*x_48 - 7.82352018356323) + 8.84175492329978e-5*std::sin(0.428159862756729*x_5 + 1.76775991916656) - 5.65498163181608e-5*std::sin(0.245119974017143*x_52 + 1.78615987300873) + 0.000777908895903484*std::sin(0.250079959630966*x_53 - 1.40391981601715) - 0.00108180592480977*std::sin(0.270319938659668*x_53 + 4.96719980239868) + 0.000451387075633718*std::sin(0.276479959487915*x_53 - 4.41447973251343) + 0.00156149487072197*std::sin(0.197279989719391*x_56 + 7.98432016372681) + 0.000298405062748742*std::sin(0.284719944000244*x_56 + 8.13599967956543) + 0.000601629963474609*std::sin(0.229599997401237*x_57 + 1.58239984512329) - 0.00240750073148326*std::sin(0.174960017204285*x_58 + 1.61359977722168) + 0.000539284346018931*std::sin(0.156480029225349*x_59 + 4.61399984359741) + 0.000490177999067422*std::sin(0.425759851932526*x_6 - 1.21807992458344) + 0.000173686314854834*std::sin(0.390319854021072*x_7 + 8.19863986968994) - 0.000254134792910566*std::sin(0.438399881124496*x_7 + 4.7912802696228) - 0.000100073421914577*std::sin(0.325519859790802*x_8 + 1.81727993488312) - 0.000933257134956058*std::sin(0.326719850301743*x_8 + 1.61639988422394) - 0.0266745944264188*std::sin(0.363439828157425*x_8 + 5.03832006454468) + 0.000387002662689103*std::sin(0.372399836778641*x_8 - 1.36783981323242) - 0.000502609077850946*std::sin(0.38351982831955*x_8 - 1.37175989151001) - 0.000123608111565404*std::sin(0.39711982011795*x_8 - 7.78391981124878) - 8.33167852849958e-5*std::sin(0.262079983949661*x_9 - 7.58767986297607) + 0.0031046432291132*std::sin(0.292239934206009*x_9 + 7.77375984191895) - 4.88135784719717e-5*std::sin(0.292479932308197*x_9 - 1.3971198797226) - 0.000797176316436656*std::sin(0.289119929075241*x_95 - 4.40375995635986) - 0.0300816999451513*std::sin(0.297679930925369*x_95 - 7.603440284729) + 0.00108343660613729*std::sin(0.305999934673309*x_96 + 8.15655994415283) + 0.0128817241123393*std::sin(0.315039932727814*x_97 - 4.61624002456665) + 1.53508618638929e-5*std::sin(0.259039968252182*x_98 + 1.97967982292175) - 0.0496453697003745);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-5.20599698285046e-5*x_1 + 2.02798855420016e-5*x_10 + 0.000620453566205131*x_100 + 0.00102649856643268*x_101 - 0.00273115556584481*x_102 - 0.00361400557446454*x_103 - 0.00156957597019605*x_104 + 0.000806397800842471*x_105 + 0.00180233622558115*x_106 - 0.00290529042785443*x_107 - 0.000482310831748116*x_108 + 0.000346781242117353*x_109 + 0.000240597198730955*x_11 - 0.00101276156532385*x_110 - 0.00463786306211921*x_111 + 0.000324651336575954*x_112 - 0.00148839277628481*x_113 - 0.000893588169288343*x_114 - 0.00190172038358761*x_115 + 0.000767474338713239*x_116 - 0.00011696925693466*x_117 - 0.000917052301655143*x_118 + 0.00172356002178161*x_119 - 9.13063576413773e-5*x_12 + 0.000134714848531918*x_120 + 7.88561915683548e-5*x_13 + 0.000196753282862172*x_14 - 0.00412314133577678*x_15 - 0.000251399574269627*x_16 - 3.99292368365434e-5*x_17 - 0.000266241141672159*x_18 + 9.5621647935265e-5*x_19 - 1.90059301104895e-5*x_2 + 3.32503562480734e-6*x_20 + 0.000239510644086493*x_21 - 1.56988840172542e-7*x_22 - 5.20165637992521e-5*x_23 + 0.00174138342661548*x_24 + 7.89055430675419e-5*x_25 + 0.00150410903221759*x_26 - 0.00174306605297547*x_27 + 0.00378962712656203*x_28 - 0.000561943380975423*x_29 + 4.89648072395208e-5*x_3 - 0.000123574194854109*x_30 + 0.000304334384343848*x_31 + 0.000120105717965691*x_32 + 5.49472938383084e-5*x_33 + 0.00446905307078608*x_34 - 0.00084118959336764*x_35 + 0.0013416554069378*x_36 + 0.000401369852588622*x_37 - 0.000198777505090367*x_38 - 0.000936337405381782*x_39 - 8.71317062838916e-5*x_4 - 0.000128219313617196*x_40 + 0.000133632822121597*x_41 + 0.00269766036152262*x_42 - 2.94519897546487e-5*x_43 + 0.000666012076661058*x_44 - 0.000676515272612367*x_45 - 0.000726318625530186*x_46 - 0.00471376033408637*x_47 + 0.00527277102257462*x_48 + 0.00140365242500091*x_49 - 0.000130485776546168*x_5 - 0.000883133154761266*x_50 + 0.00151592054903086*x_51 + 0.00517317298302193*x_52 + 0.00238534607076338*x_53 + 0.00290142126216456*x_54 - 0.000492082522465158*x_55 + 0.00214330648384433*x_56 - 0.000371131211958373*x_57 - 0.0049157287240044*x_58 + 0.00210557478421039*x_59 + 0.00141773962013068*x_6 + 0.00481914178045408*x_60 + 1.34566120923292e-5*x_61 + 2.51434512068905e-6*x_62 + 0.000344042111116693*x_63 - 1.62629929907441e-5*x_64 + 0.000290065414909175*x_65 + 3.47028795807898e-5*x_66 + 2.1031073625056e-5*x_67 + 5.84340612193384e-5*x_68 + 6.28254454916362e-5*x_69 + 0.00282759054424105*x_7 - 6.87336652955774e-6*x_70 + 1.42651035240045e-5*x_71 + 7.26334648809871e-6*x_72 + 0.00010419174948518*x_73 + 0.000116658209358708*x_74 - 1.35993545582272e-5*x_75 + 1.63796565434883e-5*x_76 - 0.00127702420407798*x_77 + 2.23254071812106e-5*x_78 + 6.91027142312095e-5*x_79 + 9.03327466202831e-5*x_8 - 2.84320879613889e-6*x_80 - 6.56746949599048e-5*x_81 - 2.4028509606241e-5*x_82 + 0.000176251923328566*x_83 + 3.9438383085504e-5*x_84 + 9.24211186233101e-5*x_85 + 1.14561885745495e-5*x_86 - 3.13793266448213e-6*x_87 + 0.00013070837134218*x_88 + 0.00012272757371336*x_89 + 0.000138008028546141*x_9 + 0.000468629412691409*x_90 + 7.64371609525552e-5*x_91 - 4.40561484567379e-5*x_92 + 0.000224558929168921*x_93 + 0.000877199374817645*x_94 + 1.59552052128455e-5*x_95 - 0.00050206692002795*x_96 - 0.00032548649185492*x_97 - 0.00202185251678745*x_98 + 0.00114787076352236*x_99 + 1.20421049415146e-8*std::pow(-6.62312030792236*x_10 - 9.87071990966797, 2) + 7.12793733418082e-9*std::pow(-7.36040019989014*x_44 - 6.54855966567993, 2) - 3.12714365959543e-5*std::sin(0.138000041246414*x_10 - 1.42351984977722) - 5.28548233003266e-5*std::sin(0.200960010290146*x_10 + 1.78887987136841) + 0.000483318831424409*std::sin(0.316079914569855*x_10 + 7.98695993423462) - 3.30561323837302e-5*std::sin(0.26335996389389*x_100 + 8.17239952087402) - 7.92166500156895e-6*std::sin(0.269679963588715*x_100 - 7.62152004241943) - 0.000112034474005301*std::sin(0.267759948968887*x_104 - 7.62703990936279) - 1.29296141296538e-5*std::sin(0.282559931278229*x_108 + 4.9696798324585) - 0.0210756067392258*std::sin(0.257279962301254*x_109 - 7.62152004241943) - 0.000152316618787689*std::sin(0.26063996553421*x_109 - 1.41407990455627) + 0.000553235918403824*std::sin(0.263759940862656*x_11 + 7.98880004882813) + 6.15924735911801e-6*std::sin(0.297439932823181*x_11 + 7.97616004943848) - 0.0285523901814582*std::sin(0.303839921951294*x_11 - 4.42399978637695) + 3.02630537317275e-5*std::sin(0.351279854774475*x_11 + 5.06895971298218) - 7.51023664596431e-6*std::sin(0.368719846010208*x_11 - 4.56192016601563) - 0.00381813853964034*std::sin(0.217519998550415*x_110 + 1.97559976577759) - 0.00011949392975066*std::sin(0.299279928207397*x_113 - 1.2027999162674) - 0.000348027818705569*std::sin(0.306559920310974*x_113 + 4.98847961425781) + 0.00043710809712073*std::sin(0.275919944047928*x_116 - 4.43304014205933) - 0.0011151473707789*std::sin(0.298799932003021*x_116 - 7.64735984802246) + 1.79629288178162e-6*std::sin(0.34079983830452*x_119 - 4.77639961242676) - 3.01230635535322e-7*std::sin(0.379839837551117*x_12 + 4.80951976776123) + 0.000422639376463956*std::sin(0.299279928207397*x_13 - 4.42256021499634) + 0.0201890639169169*std::sin(0.360239863395691*x_13 + 1.82303988933563) - 1.02840794167945e-5*std::sin(0.364799857139587*x_13 - 4.56383991241455) - 1.0176413302448e-5*std::sin(0.367439836263657*x_13 + 8.00944042205811) + 3.54573613910593e-5*std::sin(0.339519828557968*x_14 - 7.54960012435913) - 0.00050721874170094*std::sin(0.347119837999344*x_15 - 1.34447979927063) - 0.000402056249101629*std::sin(0.376879841089249*x_15 + 1.7986398935318) - 1.17701066124743e-5*std::sin(0.309759914875031*x_16 + 1.7869598865509) - 0.00059828013799066*std::sin(0.312959939241409*x_16 + 1.77959990501404) + 0.000380330908678439*std::sin(0.353839844465256*x_16 + 1.81879985332489) - 1.29893044353967e-6*std::sin(0.367599844932556*x_17 - 4.38447999954224) + 0.0204702758131625*std::sin(0.375999838113785*x_17 + 8.1940803527832) + 2.44751749366095e-5*std::sin(0.37967985868454*x_17 - 7.58376026153564) + 0.000501532095193397*std::sin(0.416159868240356*x_17 + 8.00039958953857) + 2.47608483839875e-5*std::sin(0.38663986325264*x_18 + 5.01535987854004) + 0.0206948071763642*std::sin(0.339519828557968*x_19 - 4.35431957244873) + 2.10359173500512e-7*std::sin(0.305999934673309*x_20 + 4.99823999404907) + 7.05247969098428e-6*std::sin(0.364079833030701*x_20 - 7.58983993530273) - 2.77211691384992e-5*std::sin(0.291439920663834*x_21 + 8.20351982116699) - 0.000589116387020231*std::sin(0.356879830360413*x_21 - 1.38127982616425) + 1.56105308804028e-5*std::sin(0.3713598549366*x_21 - 7.59679985046387) - 0.000305744944404212*std::sin(0.371759831905365*x_21 - 1.39455986022949) - 5.24662304873473e-5*std::sin(0.377679854631424*x_21 - 7.78287982940674) - 5.15927251062523e-6*std::sin(0.411999881267548*x_21 + 7.98016023635864) + 2.91194663160916e-5*std::sin(0.166400015354156*x_22 - 7.81447982788086) + 5.88309938649062e-6*std::sin(0.294319927692413*x_24 - 7.77375984191895) - 0.000285217401502746*std::sin(0.320479929447174*x_24 + 1.57775974273682) + 2.44959643171972e-5*std::sin(0.341279834508896*x_24 - 1.39759981632233) - 1.20466570748443e-5*std::sin(0.223199993371964*x_28 + 1.58655989170074) - 8.60730760580251e-6*std::sin(0.247759968042374*x_28 - 1.37271988391876) - 0.000416031328330768*std::sin(0.24967996776104*x_28 - 4.58311986923218) - 8.09501118750664e-7*std::sin(0.186240002512932*x_29 - 1.58527982234955) + 1.69335053919345e-5*std::sin(0.355439841747284*x_29 + 5.01103973388672) + 2.01466261834473e-5*std::sin(0.327199846506119*x_3 - 1.18575978279114) + 0.00152970869867118*std::sin(0.374479830265045*x_3 + 1.60391974449158) - 0.0005201833933789*std::sin(0.292399942874908*x_33 + 1.76831984519958) + 1.88602147909251e-5*std::sin(0.233039990067482*x_38 + 1.79367995262146) + 0.000310952593268894*std::sin(0.307439923286438*x_4 - 7.55136013031006) + 0.0337231838420195*std::sin(0.249119967222214*x_41 - 4.41247987747192) + 0.00198937363985423*std::sin(0.259039968252182*x_42 + 8.17671966552734) + 0.0308171762064968*std::sin(0.278879970312119*x_43 - 1.24959993362427) + 1.84578395241515e-6*std::sin(0.284799933433533*x_44 + 1.55623984336853) - 0.00161228281705413*std::sin(0.245679974555969*x_48 + 4.99599981307983) - 5.95685718596326e-5*std::sin(0.289359927177429*x_48 - 7.82352018356323) + 0.000205714310561039*std::sin(0.428159862756729*x_5 + 1.76775991916656) + 0.00159498955714651*std::sin(0.245119974017143*x_52 + 1.78615987300873) - 0.000829630135229917*std::sin(0.250079959630966*x_53 - 1.40391981601715) - 1.56784322934799e-5*std::sin(0.270319938659668*x_53 + 4.96719980239868) + 0.000219858679919551*std::sin(0.276479959487915*x_53 - 4.41447973251343) + 2.26304839396545e-5*std::sin(0.197279989719391*x_56 + 7.98432016372681) + 0.00069427610563505*std::sin(0.284719944000244*x_56 + 8.13599967956543) - 1.31593703614869e-5*std::sin(0.229599997401237*x_57 + 1.58239984512329) - 0.000623015217782128*std::sin(0.174960017204285*x_58 + 1.61359977722168) + 0.000643370731372753*std::sin(0.156480029225349*x_59 + 4.61399984359741) + 7.10406773884459e-6*std::sin(0.425759851932526*x_6 - 1.21807992458344) - 2.56455479740734e-5*std::sin(0.390319854021072*x_7 + 8.19863986968994) + 0.000271031587013987*std::sin(0.438399881124496*x_7 + 4.7912802696228) - 0.000232833132938255*std::sin(0.325519859790802*x_8 + 1.81727993488312) - 0.000241509125865624*std::sin(0.326719850301743*x_8 + 1.61639988422394) - 0.0192258524977894*std::sin(0.363439828157425*x_8 + 5.03832006454468) + 5.60876484886556e-6*std::sin(0.372399836778641*x_8 - 1.36783981323242) + 1.09934999983842e-5*std::sin(0.38351982831955*x_8 - 1.37175989151001) - 6.02062347442373e-5*std::sin(0.39711982011795*x_8 - 7.78391981124878) + 1.82237671235936e-6*std::sin(0.262079983949661*x_9 - 7.58767986297607) + 0.00223768773489106*std::sin(0.292239934206009*x_9 + 7.77375984191895) + 7.20753946294178e-6*std::sin(0.292479932308197*x_9 - 1.3971198797226) + 0.000850178598921031*std::sin(0.289119929075241*x_95 - 4.40375995635986) - 0.0216815414991066*std::sin(0.297679930925369*x_95 - 7.603440284729) + 1.57020654851637e-5*std::sin(0.305999934673309*x_96 + 8.15655994415283) + 0.00928456956990374*std::sin(0.315039932727814*x_97 - 4.61624002456665) + 2.43470778288026e-5*std::sin(0.259039968252182*x_98 + 1.97967982292175) - 0.0433626214120273);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-5.51188469634384e-5*x_1 + 0.000110683159248905*x_10 + 1.87671469086926e-5*x_100 + 0.000175763436528078*x_101 + 0.000335625517732654*x_102 - 0.000208946324631743*x_103 - 0.000219538159627292*x_104 - 0.000337254101522524*x_105 - 8.96346570181508e-5*x_106 + 1.06943662256733e-5*x_107 + 2.28073889737762e-5*x_108 + 7.62857380325202e-5*x_109 - 0.000539768653389441*x_11 - 0.000612337137479543*x_110 - 0.000183630415792942*x_111 + 0.000471460777749948*x_112 + 2.77245235855506e-5*x_113 + 0.000344876306305185*x_114 - 0.000419924231007551*x_115 + 0.000513564020197285*x_116 - 0.00023329363399726*x_117 - 0.00100233555150216*x_118 - 0.000182457801173625*x_119 + 0.000105274999174174*x_12 - 3.6048590066659e-5*x_120 + 0.000140948450667177*x_13 + 0.000249194743220788*x_14 - 0.000126276825832434*x_15 + 3.96496261110005e-5*x_16 - 6.65848777429127e-5*x_17 - 1.34431408505119e-5*x_18 + 0.000177139408402334*x_19 + 7.18837856145644e-6*x_2 - 5.14187672670536e-6*x_20 - 0.000226726611254287*x_21 - 0.000154543571447507*x_22 + 5.2533839352698e-5*x_23 + 0.000183531348393045*x_24 + 0.000665674455047347*x_25 + 0.000215442667938182*x_26 + 0.000172060528036922*x_27 + 4.62994853839791e-6*x_28 - 0.000117184219461234*x_29 - 6.15239521947826e-5*x_3 - 7.96751157549755e-6*x_30 - 1.3983955494363e-5*x_31 + 5.89208195586339e-5*x_32 - 0.000190783730806489*x_33 + 0.000365412201814408*x_34 + 0.000113059949824387*x_35 - 0.000265206483284223*x_36 - 0.00020962445474809*x_37 - 0.000118381864813114*x_38 + 0.000297652211677599*x_39 + 0.000136379388911633*x_4 + 0.000676351825809671*x_40 - 0.000261023929255343*x_41 + 1.51315594917861e-5*x_42 - 9.35715735585597e-5*x_43 - 0.000188339425797015*x_44 - 0.000207270371967115*x_45 + 0.000176429853184557*x_46 - 0.000191082859066031*x_47 + 0.000157542138032343*x_48 + 0.000193501573752252*x_49 + 3.90850495261497e-5*x_5 + 0.000184071317286223*x_50 - 0.000216031980449578*x_51 - 0.000562074197269485*x_52 - 0.000167016187892486*x_53 - 0.00136201146006729*x_54 - 0.000755618200206244*x_55 + 0.000485497680616348*x_56 + 0.000269456241580629*x_57 + 0.000404086594827668*x_58 - 0.000994726713817714*x_59 + 3.99798839333748e-5*x_6 + 0.000292735622013125*x_60 - 1.09320359390257e-5*x_61 + 1.29089563209065e-6*x_62 - 2.3063809723437e-6*x_63 - 2.1752945077947e-5*x_64 - 6.2017889288598e-6*x_65 - 3.56914887777726e-5*x_66 - 1.70207839861878e-5*x_67 - 1.9738676191177e-7*x_68 - 1.20030581136551e-5*x_69 + 2.1325015052142e-5*x_7 - 1.34381925867122e-5*x_70 + 2.97411344322871e-5*x_71 - 1.42916092240882e-5*x_72 - 5.17916840411202e-6*x_73 + 1.80308585880726e-5*x_74 + 5.19349463054467e-6*x_75 - 1.53067205655823e-5*x_76 + 1.03230562775839e-5*x_77 - 2.78592958838904e-6*x_78 - 1.57498483777423e-5*x_79 - 0.000113111783554418*x_8 - 9.62515415569863e-6*x_80 + 6.94255869942724e-6*x_81 - 6.63974587773073e-6*x_82 - 6.59065934077562e-6*x_83 + 1.05214359112601e-5*x_84 - 1.26246292632663e-5*x_85 + 2.62935741920272e-5*x_86 + 3.05812884771131e-5*x_87 + 4.23994610067561e-6*x_88 + 4.39297985939089e-5*x_89 + 2.17372679970581e-5*x_9 + 3.07742702657373e-5*x_90 + 7.30601449300348e-5*x_91 - 9.09101901679172e-5*x_92 - 0.000173147981279123*x_93 - 0.000250790559922175*x_94 + 8.69796162627456e-6*x_95 - 9.17807586695734e-5*x_96 + 0.000218930941101116*x_97 + 0.000461110110453977*x_98 - 0.000229735323487898*x_99 + 1.2672287418277e-8*std::pow(-6.62312030792236*x_10 - 9.87071990966797, 2) + 2.9977033534267e-8*std::pow(-7.36040019989014*x_44 - 6.54855966567993, 2) + 0.000164038200429999*std::sin(0.138000041246414*x_10 - 1.42351984977722) + 0.000106847576936156*std::sin(0.200960010290146*x_10 + 1.78887987136841) - 0.000871656349963114*std::sin(0.316079914569855*x_10 + 7.98695993423462) + 6.68239420272652e-5*std::sin(0.26335996389389*x_100 + 8.17239952087402) + 4.15540765861326e-5*std::sin(0.269679963588715*x_100 - 7.62152004241943) + 0.000202052049976396*std::sin(0.267759948968887*x_104 - 7.62703990936279) + 6.78238950607432e-5*std::sin(0.282559931278229*x_108 + 4.9696798324585) - 9.73287778819922e-5*std::sin(0.26063996553421*x_109 - 1.41407990455627) + 0.000808798193042945*std::sin(0.263759940862656*x_11 + 7.98880004882813) - 3.23090961840766e-5*std::sin(0.297439932823181*x_11 + 7.97616004943848) + 6.03045254081615e-5*std::sin(0.351279854774475*x_11 + 5.06895971298218) + 1.51821638543526e-5*std::sin(0.368719846010208*x_11 - 4.56192016601563) + 0.00021550503700061*std::sin(0.299279928207397*x_113 - 1.2027999162674) - 0.00050879608777006*std::sin(0.306559920310974*x_113 + 4.98847961425781) + 0.000639026186397451*std::sin(0.275919944047928*x_116 - 4.43304014205933) + 0.00201114714280717*std::sin(0.298799932003021*x_116 - 7.64735984802246) - 9.42267717277803e-6*std::sin(0.34079983830452*x_119 - 4.77639961242676) - 0.000810120231515225*std::sin(0.379839837551117*x_12 + 4.80951976776123) + 0.00149921192833484*std::sin(0.299279928207397*x_13 - 4.42256021499634) - 4.3250407388962e-5*std::sin(0.364799857139587*x_13 - 4.56383991241455) + 5.33816385391596e-5*std::sin(0.367439836263657*x_13 + 8.00944042205811) - 7.16780969573479e-5*std::sin(0.339519828557968*x_14 - 7.54960012435913) - 0.000741523802266561*std::sin(0.347119837999344*x_15 - 1.34447979927063) - 0.00142619821550426*std::sin(0.376879841089249*x_15 + 1.7986398935318) - 4.94999975563883e-5*std::sin(0.309759914875031*x_16 + 1.7869598865509) + 0.00107898688697779*std::sin(0.312959939241409*x_16 + 1.77959990501404) + 0.00055602129483026*std::sin(0.353839844465256*x_16 + 1.81879985332489) - 5.46274183387501e-6*std::sin(0.367599844932556*x_17 - 4.38447999954224) - 4.94772846407208e-5*std::sin(0.37967985868454*x_17 - 7.58376026153564) - 0.000318548063300382*std::sin(0.416159868240356*x_17 + 8.00039958953857) - 5.00547819009784e-5*std::sin(0.38663986325264*x_18 + 5.01535987854004) + 0.000565733369166574*std::sin(0.305999934673309*x_20 + 4.99823999404907) - 1.42567947317017e-5*std::sin(0.364079833030701*x_20 - 7.58983993530273) - 5.52393675626977e-5*std::sin(0.291439920663834*x_21 + 8.20351982116699) + 0.00106246023582432*std::sin(0.356879830360413*x_21 - 1.38127982616425) + 6.56511674766743e-5*std::sin(0.3713598549366*x_21 - 7.59679985046387) - 0.000446981026249349*std::sin(0.371759831905365*x_21 - 1.39455986022949) - 3.35253902958958e-5*std::sin(0.377679854631424*x_21 - 7.78287982940674) + 1.04296208386003e-5*std::sin(0.411999881267548*x_21 + 7.98016023635864) - 5.88658560046529e-5*std::sin(0.166400015354156*x_22 - 7.81447982788086) + 2.47417814335376e-5*std::sin(0.294319927692413*x_24 - 7.77375984191895) + 0.000514384176604819*std::sin(0.320479929447174*x_24 + 1.57775974273682) - 4.9519310983883e-5*std::sin(0.341279834508896*x_24 - 1.39759981632233) + 2.4352670924925e-5*std::sin(0.223199993371964*x_28 + 1.58655989170074) + 4.51506999325369e-5*std::sin(0.247759968042374*x_28 - 1.37271988391876) - 0.000829016530595898*std::sin(0.24967996776104*x_28 - 4.58311986923218) - 0.00217704694135343*std::sin(0.186240002512932*x_29 - 1.58527982234955) + 7.12150283017392e-5*std::sin(0.355439841747284*x_29 + 5.01103973388672) + 4.01457414489109e-5*std::sin(0.327199846506119*x_3 - 1.18575978279114) - 0.00184522595788434*std::sin(0.292399942874908*x_33 + 1.76831984519958) - 9.89335966236632e-5*std::sin(0.233039990067482*x_38 + 1.79367995262146) + 0.000454594300897006*std::sin(0.307439923286438*x_4 - 7.55136013031006) - 0.00358779764595077*std::sin(0.259039968252182*x_42 + 8.17671966552734) - 9.6822887240148e-6*std::sin(0.284799933433533*x_44 + 1.55623984336853) + 0.000264559652622959*std::sin(0.245679974555969*x_48 + 4.99599981307983) - 3.80637145534003e-5*std::sin(0.289359927177429*x_48 - 7.82352018356323) + 0.000300742155615783*std::sin(0.428159862756729*x_5 + 1.76775991916656) - 0.000261721999833086*std::sin(0.245119974017143*x_52 + 1.78615987300873) - 0.00294291413461995*std::sin(0.250079959630966*x_53 - 1.40391981601715) + 8.22431617778234e-5*std::sin(0.270319938659668*x_53 + 4.96719980239868) + 0.000140487471384492*std::sin(0.276479959487915*x_53 - 4.41447973251343) - 0.000118711011210824*std::sin(0.197279989719391*x_56 + 7.98432016372681) + 0.00101499060532914*std::sin(0.284719944000244*x_56 + 8.13599967956543) - 5.53426423552398e-5*std::sin(0.229599997401237*x_57 + 1.58239984512329) - 0.00124146880098306*std::sin(0.174960017204285*x_58 + 1.61359977722168) + 0.000677039343541644*std::sin(0.156480029225349*x_59 + 4.61399984359741) - 3.7265268707343e-5*std::sin(0.425759851932526*x_6 - 1.21807992458344) + 5.18432280940528e-5*std::sin(0.390319854021072*x_7 + 8.19863986968994) + 0.000961419618793011*std::sin(0.438399881124496*x_7 + 4.7912802696228) - 0.000340388270060823*std::sin(0.325519859790802*x_8 + 1.81727993488312) - 0.000481249954025543*std::sin(0.326719850301743*x_8 + 1.61639988422394) - 2.94214718796121e-5*std::sin(0.372399836778641*x_8 - 1.36783981323242) + 4.62339247190366e-5*std::sin(0.38351982831955*x_8 - 1.37175989151001) - 3.8471174683183e-5*std::sin(0.39711982011795*x_8 - 7.78391981124878) + 7.66413132681419e-6*std::sin(0.262079983949661*x_9 - 7.58767986297607) - 1.45702526127316e-5*std::sin(0.292479932308197*x_9 - 1.3971198797226) + 0.00301580488638194*std::sin(0.289119929075241*x_95 - 4.40375995635986) - 8.23671326169099e-5*std::sin(0.305999934673309*x_96 + 8.15655994415283) - 1.54640442031891e-5*std::sin(0.259039968252182*x_98 + 1.97967982292175) + 0.0475461259484291*std::sin(-2.1094513651394e-5*x_1 - 0.00355148001651669*x_10 + 0.00352478158532596*x_100 + 0.00808651508197045*x_101 - 0.0236961517066078*x_102 - 0.0309434095618165*x_103 - 0.0134303760216729*x_104 + 0.00763672384960998*x_105 + 0.0154489273508597*x_106 - 0.025410060946365*x_107 - 0.00223941892640777*x_108 - 0.039947784714952*x_111 + 0.00416912592451157*x_112 - 0.012927811172447*x_113 - 0.00671641947332353*x_114 - 0.0186536432720514*x_115 + 0.00177014733653599*x_116 + 0.00225265884247418*x_117 + 0.00123130373040453*x_118 + 0.0138778570257338*x_119 - 0.00216780295324249*x_12 + 0.00142705704632911*x_120 + 0.00113216165563283*x_14 - 0.0339139052757259*x_15 - 0.000585778705057564*x_16 - 0.00187202058367346*x_18 - 0.00062728760347022*x_2 - 0.00226690353355651*x_20 + 0.00212219596400056*x_21 - 0.00151654123827842*x_22 - 0.00161519989644612*x_23 + 0.0161401097552827*x_24 + 0.000443873818807976*x_25 + 0.0127466884183528*x_26 - 0.013721389091408*x_27 + 0.0283413118100943*x_28 - 0.0031954416665104*x_29 - 0.000847623941026515*x_30 + 0.00233173932977269*x_31 + 0.000920406364609014*x_32 - 0.000474099890457162*x_33 + 0.0410752872714584*x_34 - 0.00590125208899065*x_35 + 0.0168291381846711*x_36 + 0.00244159737074887*x_37 + 0.00955493664944712*x_38 - 0.0105005259588595*x_39 - 0.000902698139664107*x_4 - 0.000165325836825819*x_40 + 0.0192173523034113*x_42 + 0.000779213465402798*x_44 - 0.00206544269793234*x_45 - 0.000441062755375224*x_46 - 0.0403133010046623*x_47 + 0.0494199884497802*x_48 + 0.0175602524059213*x_49 - 0.000689104177200686*x_5 + 0.00602956766205881*x_50 + 0.0264875919630039*x_51 + 0.0408050685108004*x_52 + 0.0210549600958919*x_53 + 0.0226346656171801*x_54 - 0.0017196954601739*x_55 + 0.0202469074671125*x_56 - 0.0018807019352233*x_57 - 0.0472137696482537*x_58 + 0.0188770362409875*x_59 + 0.0111796309454089*x_6 + 0.0403624975114335*x_60 + 7.58135097725321e-5*x_61 + 1.26673910148968e-5*x_62 + 0.00278757057937805*x_63 - 0.000406836082862788*x_64 + 0.00241641776338716*x_65 + 0.000356387367796106*x_66 + 0.000108984272964249*x_67 + 0.000436188074806854*x_68 + 9.03841047150649e-5*x_69 + 0.0238562475176745*x_7 + 0.00012651281183341*x_70 - 0.000336732695968782*x_71 + 2.84003667625062e-5*x_72 + 0.00052972714147251*x_73 + 0.000301972481712707*x_74 - 0.000157556162569693*x_75 + 0.000118780006022104*x_76 - 0.0115678360648082*x_77 + 0.000194750631798363*x_78 + 0.000670167271717867*x_79 + 4.15102990642103e-5*x_80 - 0.000570364253832856*x_81 - 0.000318748771225747*x_82 + 0.001476830974289*x_83 + 0.000592260917965143*x_84 + 0.00049882486364085*x_85 - 0.000663350503521294*x_86 + 6.4390320653328e-5*x_87 + 0.000803772429620949*x_88 + 0.000794277856897589*x_89 + 0.00400190441596363*x_90 + 0.00108031557146116*x_91 + 0.00411715234697714*x_92 + 0.00115663483651492*x_93 + 0.00839331166301345*x_94 + 0.00195992014819626*x_96 - 0.0179538133577385*x_98 + 0.0125556625214773*x_99 - 0.183508243601237*std::sin(0.257279962301254*x_109 - 7.62152004241943) - 0.24860963850994*std::sin(0.303839921951294*x_11 - 4.42399978637695) - 0.03324506411156*std::sin(0.217519998550415*x_110 + 1.97559976577759) + 0.175788991756572*std::sin(0.360239863395691*x_13 + 1.82303988933563) + 0.178237542908542*std::sin(0.375999838113785*x_17 + 8.1940803527832) + 0.180192568763995*std::sin(0.339519828557968*x_19 - 4.35431957244873) + 0.0133193867198242*std::sin(0.374479830265045*x_3 + 1.60391974449158) + 0.293632459177207*std::sin(0.249119967222214*x_41 - 4.41247987747192) + 0.268329445902907*std::sin(0.278879970312119*x_43 - 1.24959993362427) - 0.16740217575987*std::sin(0.363439828157425*x_8 + 5.03832006454468) + 0.0194838588060015*std::sin(0.292239934206009*x_9 + 7.77375984191895) - 0.18878420195909*std::sin(0.297679930925369*x_95 - 7.603440284729) + 0.0808420405375769*std::sin(0.315039932727814*x_97 - 4.61624002456665) + 7.0770815756273) + 0.00741867382550033);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
