
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0251957758489298*x_1 + 0.00805408119519039*x_10 + 0.0196449389403583*x_100 - 0.0186636250283632*x_101 + 0.0155295231050271*x_102 - 0.0229936867170637*x_103 + 0.0105821833182494*x_104 + 0.012893750822665*x_105 - 0.00728240288403035*x_106 + 0.023047566265391*x_107 + 0.0127187831144413*x_108 - 0.00137526360729467*x_109 + 0.000999306990355976*x_11 + 0.000669342782173333*x_110 + 0.00157803657379272*x_111 - 0.00610550591156242*x_112 - 0.00865710510128034*x_113 + 0.0123509952017907*x_114 - 0.00610414304031905*x_115 - 0.0180733201974295*x_116 - 0.00481222634864692*x_117 + 0.027743498752141*x_118 - 0.0171157928123756*x_119 + 0.00470035567936303*x_12 - 0.00129486337438963*x_120 + 0.021607025515504*x_13 + 0.0308366058021229*x_14 - 0.00402900045298442*x_15 + 0.00842600810012639*x_16 - 0.00120941246408695*x_17 + 0.00364563705319609*x_18 + 0.00422348501057611*x_19 - 0.0122018500815976*x_2 - 0.0147458836089645*x_20 + 0.000655865125652784*x_21 + 0.00097821263623109*x_22 - 0.000803377285153805*x_23 - 0.0037268670521569*x_24 - 0.00288258669350449*x_25 - 0.00725480806556938*x_26 - 0.00221543173532982*x_27 + 0.00373846092636983*x_28 + 0.00749070977505974*x_29 - 0.0259748518459226*x_3 - 0.007279339418562*x_30 + 0.00322591943314748*x_32 + 0.0127774349502005*x_33 - 0.00307908415628408*x_34 + 0.0227827358131668*x_35 + 0.00754237537121585*x_36 - 0.0054837181141244*x_37 - 0.000263923676880328*x_38 - 0.00856589858314309*x_39 + 0.00137230938667364*x_4 + 0.0302434580417521*x_40 - 0.0159337910008337*x_41 - 0.0168484282759703*x_42 - 0.00295534839441616*x_43 + 0.0174266136783086*x_44 + 0.0290933808895316*x_45 - 0.0220686667810265*x_46 - 0.00167150458160424*x_47 - 0.0112934247927279*x_48 + 0.0132478640424789*x_49 - 0.000850903617541932*x_5 + 0.0094849067515213*x_50 + 0.0107624953946512*x_51 - 0.0253954247974202*x_52 - 0.0039536035147622*x_53 + 0.00784372903254541*x_54 + 0.000820909413316289*x_55 - 0.00803364072634822*x_56 - 0.0547556554855085*x_57 + 0.000726184833362106*x_58 + 0.00611735496089066*x_59 - 0.0131542902907619*x_6 - 0.0143820747671287*x_60 - 0.00634977492316598*x_61 - 0.0166209540964923*x_62 - 6.81666180651849e-5*x_63 + 0.0139328056264614*x_64 - 0.00934074010329483*x_65 - 0.00615721863389749*x_66 - 0.000171104156770527*x_67 - 0.000195325929955897*x_68 + 0.00882658577277461*x_69 - 0.0140515244195884*x_7 - 0.000465852911229486*x_70 - 0.00622068217547519*x_71 - 0.00836373400025368*x_72 - 0.000477421118889473*x_73 + 0.00485953724267261*x_74 + 0.0106328129379812*x_75 + 0.00380166628832206*x_76 - 0.000160195693564824*x_77 - 0.00559294703239886*x_78 - 0.0101059791975475*x_79 + 0.0268328536548441*x_8 + 0.00898267665956427*x_80 - 0.000756110401006763*x_81 - 0.000906612797345743*x_82 + 0.00512004644747445*x_83 - 0.0160131658580497*x_84 + 0.0125073938320176*x_85 + 0.00445586410128882*x_86 - 0.00389684921147968*x_87 + 0.0120526714251705*x_88 + 0.0264664910463739*x_89 + 0.0080418870509778*x_9 + 0.00528044927700175*x_90 - 0.0355174778060743*x_91 + 0.00398435203174295*x_92 + 0.0116006831390594*x_93 + 0.00866243239808065*x_94 + 0.00511634202769556*x_95 + 0.000984353614304621*x_96 + 0.0150167997423649*x_97 - 0.00373270169161705*x_98 + 0.0116837268079041*x_99 - 5.01665794497778e-5*std::pow(-8.29967975616455*x_104 - 9.30575942993164, 2) + 0.000159714399928345*std::pow(-5.02359962463379*x_104 - 6.63000011444092, 2) - 5.41772104019442e-5*std::pow(-7.76968002319336*x_106 - 8.38871955871582, 2) + 1.36225229071764e-5*std::pow(-6.33696031570435*x_106 - 6.55055999755859, 2) + 7.46209521870263e-5*std::pow(-4.04055976867676*x_107 - 6.8732795715332, 2) + 3.86765031172062e-5*std::pow(-5.1199197769165*x_112 - 7.47016000747681, 2) - 7.98963860437087e-5*std::pow(-5.11528015136719*x_114 - 6.48727989196777, 2) - 0.00203762138454924*std::pow(-1.28807985782623*x_114 - 1.71615982055664, 2) + 1.24396207094888e-6*std::pow(-9.0*x_115 - 9.99927997589111, 2) - 3.40017739151e-5*std::pow(-8.35487937927246*x_115 - 9.57288074493408, 2) + 3.42656906572104e-5*std::pow(-8.12743949890137*x_115 - 9.94367980957031, 2) + 2.49704120650266e-5*std::pow(-7.13303995132446*x_115 - 8.96848011016846, 2) - 2.97030308459056e-5*std::pow(-7.52023983001709*x_12 - 5.48464012145996, 2) - 0.000125667794833071*std::pow(-5.54967975616455*x_120 - 6.57407999038696, 2) - 3.2010180130664e-5*std::pow(-7.13495969772339*x_14 - 9.12439918518066, 2) + 5.1939430732657e-5*std::pow(-7.84424018859863*x_15 - 8.04736042022705, 2) - 9.40177918428396e-5*std::pow(-6.59600019454956*x_15 - 9.96271991729736, 2) - 0.000104880089637802*std::pow(-4.43039989471436*x_15 - 5.83872032165527, 2) + 9.98148354859418e-5*std::pow(-6.48343992233276*x_19 - 8.70903968811035, 2) - 0.000204250869094138*std::pow(-4.24728012084961*x_21 - 5.46327972412109, 2) - 0.000155403903837007*std::pow(-3.86207985877991*x_24 - 5.49304008483887, 2) + 1.9672711266601e-5*std::pow(-8.15999984741211*x_45 - 9.98680019378662, 2) + 7.70818311901819e-5*std::pow(-5.56400012969971*x_47 - 6.5978798866272, 2) - 7.87279863075268e-6*std::pow(-8.39575958251953*x_48 - 7.98016023635864, 2) + 2.48084018395253e-5*std::pow(-7.48736000061035*x_55 - 8.30447959899902, 2) + 7.16748078675775e-6*std::pow(-5.89743947982788*x_55 - 7.46456003189087, 2) + 0.000145690255428873*std::pow(-4.72551965713501*x_55 - 7.19879961013794, 2) + 4.65623191745989e-5*std::pow(-8.09127998352051*x_59 - 9.45944023132324, 2) - 0.000347359478210543*std::pow(-3.35439991950989*x_60 - 4.39711999893188, 2) + 3.24677049436878e-5*std::pow(-7.65072011947632*x_66 - 9.26943969726563, 2) - 4.18874553723702e-5*std::pow(-8.26799964904785*x_67 - 7.86800003051758, 2) + 9.83993146742767e-6*std::pow(-7.10328006744385*x_67 - 8.67744064331055, 2) + 6.38713393200056e-5*std::pow(-5.22671985626221*x_7 - 8.03615951538086, 2) + 9.61303547976334e-5*std::pow(-6.26759958267212*x_70 - 9.014479637146, 2) + 5.38559868037759e-6*std::pow(-5.07919979095459*x_71 - 7.71488046646118, 2) - 1.89814137500568e-5*std::pow(-3.47183990478516*x_78 - 4.69567966461182, 2) - 5.43360607755254e-5*std::pow(-6.55936002731323*x_79 - 9.14999961853027, 2) + 2.9355804595811e-6*std::pow(-7.44632005691528*x_82 - 8.2236795425415, 2) - 1.04866074622939e-5*std::pow(-9.99993991851807*x_84 - 8.60000038146973, 2) + 6.2889858051348e-5*std::pow(-8.00255966186523*x_84 - 8.5984001159668, 2) + 2.50604665940482e-6*std::pow(-7.19600009918213*x_87 - 9.9973201751709, 2) + 9.75541716890932e-5*std::pow(-4.31935977935791*x_87 - 6.28535985946655, 2) - 3.44249858219505e-5*std::pow(-4.3907995223999*x_90 - 5.78359985351563, 2) + 0.00496538941207923*std::exp(0.380719840526581*x_1) + 0.000728716320137405*std::exp(0.815199851989746*x_1) - 0.000514583201187791*std::exp(1.00071978569031*x_1) - 0.000123337573778125*std::exp(1.15455985069275*x_1) - 9.15835408705608e-5*std::exp(1.16367983818054*x_1) - 3.77724207329494e-5*std::exp(1.20775985717773*x_1) - 1.68330342164214e-5*std::exp(1.34047985076904*x_1) - 1.50400279509425e-6*std::exp(1.38623988628387*x_1) - 0.000228306873968954*std::exp(1.20671987533569*x_100) - 0.00085805263224099*std::exp(1.51599979400635*x_100) - 0.000816936413070599*std::exp(1.56199979782104*x_100) - 0.0100790577159097*std::exp(0.623199820518494*x_104) - 0.000319538066163525*std::exp(0.879519879817963*x_104) - 0.00874415445466857*std::exp(0.884399890899658*x_104) + 0.00896427910938074*std::exp(0.60591983795166*x_106) + 0.00192500322868452*std::exp(0.726879835128784*x_106) - 0.000441437376162118*std::exp(1.03599977493286*x_106) - 0.0174467030634459*std::exp(0.550239861011505*x_109) + 0.00516662699178963*std::exp(0.644079864025116*x_109) - 0.000843862903178006*std::exp(0.68751984834671*x_109) - 0.0057157136870198*std::exp(0.815999865531921*x_109) - 0.00134478252640791*std::exp(0.963039815425873*x_109) - 0.00206832303915754*std::exp(1.03647983074188*x_109) + 0.0154998996039022*std::exp(0.64031982421875*x_110) + 0.00188433199120066*std::exp(0.954399824142456*x_110) + 0.00192088770253078*std::exp(1.00471985340118*x_110) - 0.00154608819767225*std::exp(1.11807978153229*x_110) + 0.00010809831369553*std::exp(1.24599981307983*x_110) + 0.000699839581220939*std::exp(1.35839986801147*x_110) - 0.00412915584110837*std::exp(0.422239869832993*x_112) - 0.000127435523768641*std::exp(0.832239866256714*x_112) - 0.00095556290700736*std::exp(0.840879857540131*x_112) - 0.00615552890951693*std::exp(0.667279839515686*x_114) + 0.00364211034254685*std::exp(0.739199817180634*x_114) + 0.0014775505977135*std::exp(1.27807986736298*x_23) - 0.000256770342692082*std::exp(1.61607992649078*x_23) + 0.0160367601311328*std::exp(0.619119822978973*x_26) - 0.00288713501679847*std::exp(0.657599866390228*x_26) - 0.000862438061803617*std::exp(0.88647985458374*x_26) + 9.69286988464721e-5*std::exp(0.919839859008789*x_26) - 0.000232717174115931*std::exp(1.32983994483948*x_26) + 4.54021763375335e-5*std::exp(1.48503994941711*x_26) + 0.000455908492463029*std::exp(0.493599832057953*x_31) - 0.00160662420074807*std::exp(0.610639870166779*x_31) + 0.0113254512089901*std::exp(0.643439829349518*x_31) + 0.0100828044131212*std::exp(0.645119845867157*x_31) - 0.0293786322219502*std::exp(0.645279824733734*x_31) - 0.0142182287339944*std::exp(0.650719821453094*x_31) - 0.00160806613582244*std::exp(0.652079820632935*x_31) + 0.00564823186258769*std::exp(0.660639822483063*x_31) + 0.00359208921430014*std::exp(0.66271984577179*x_31) + 0.00191709799707786*std::exp(0.662879824638367*x_31) - 0.000780834976766934*std::exp(0.51231986284256*x_45) + 0.00319484775296695*std::exp(0.891679883003235*x_45) + 0.00241189069563227*std::exp(0.86599987745285*x_49) - 0.00167691932216844*std::exp(0.91407984495163*x_50) - 0.00349383735746464*std::exp(0.959999799728394*x_50) - 0.000642656879584396*std::exp(1.3595198392868*x_50) + 0.00218494583524397*std::exp(0.910159826278687*x_52) + 0.00129621329128406*std::exp(0.954559803009033*x_6) - 0.000549495644721856*std::exp(1.37487983703613*x_60) - 0.00358444894181967*std::exp(0.692239880561829*x_66) - 0.00429808758427553*std::exp(0.945199847221375*x_66) - 1.3390269997399e-5*std::exp(1.67783987522125*x_66) + 0.00435828336808952*std::exp(0.66951984167099*x_68) + 0.000301503384408819*std::exp(1.33463990688324*x_68) + 0.00257936767548181*std::exp(0.661919832229614*x_70) - 0.00497637065926248*std::exp(0.710639834403992*x_70) + 0.00276900189906544*std::exp(0.77295982837677*x_70) + 0.0068530701085204*std::exp(0.801199853420258*x_72) + 0.00131136905614611*std::exp(0.824319899082184*x_72) - 0.0062080797188804*std::exp(0.90671980381012*x_72) + 0.0110313808322226*std::exp(0.693759858608246*x_74) - 0.0058425318386567*std::exp(1.17047989368439*x_74) - 0.00295651128647444*std::exp(1.25959992408752*x_74) - 0.000544897588785454*std::exp(1.45263981819153*x_74) - 0.000122184069012413*std::exp(1.60871982574463*x_74) + 0.000814573593808541*std::exp(0.611519813537598*x_78) - 0.00637088766840486*std::exp(0.926559805870056*x_78) + 0.00165684630434771*std::exp(1.16831982135773*x_81) + 0.000484101605083218*std::exp(1.27199983596802*x_81) + 0.000221526053551408*std::exp(2.01087975502014*x_81) + 0.00257776688646735*std::exp(0.700319886207581*x_87) + 0.00766943473990467*std::exp(0.611999809741974*x_90) - 0.0154176821463614*std::sin(0.364159852266312*x_100 + 5.18175983428955) - 0.00766247391195869*std::sin(0.235039994120598*x_102 - 1.34447979927063) - 0.0661739448766232*std::sin(0.323359847068787*x_102 + 1.94719982147217) - 0.0458343582486402*std::sin(0.375599831342697*x_102 + 1.9761598110199) + 0.0173001425718471*std::sin(0.377599835395813*x_102 + 5.17960023880005) - 0.0288574352252585*std::sin(0.442639857530594*x_102 + 8.43080043792725) - 0.0440753521610127*std::sin(0.459279865026474*x_102 + 5.24032020568848) + 0.0127418563712894*std::sin(0.521439850330353*x_103 + 8.35359954833984) - 0.0424048409468103*std::sin(0.325759828090668*x_105 + 1.9398398399353) - 0.084995296811033*std::sin(0.326879858970642*x_105 - 7.46807956695557) - 0.125336195400498*std::sin(0.267679959535599*x_106 - 7.52112007141113) - 0.0402536114168961*std::sin(0.526319861412048*x_106 - 4.0403995513916) + 0.00410369385831388*std::sin(0.272559970617294*x_107 - 7.52992010116577) - 0.0177022749245601*std::sin(0.584239840507507*x_107 + 2.17967987060547) + 0.0201518796720134*std::sin(0.444399863481522*x_108 + 2.046719789505) - 0.0126346504512694*std::sin(0.472879856824875*x_109 - 7.34272003173828) + 0.00513386480849803*std::sin(0.535279810428619*x_109 + 8.36967945098877) - 0.0161998779795463*std::sin(0.611279845237732*x_110 - 0.978959858417511) - 0.0907552442882764*std::sin(0.230719983577728*x_111 - 7.57328033447266) - 0.0819382699035086*std::sin(0.247679978609085*x_111 + 5.05423974990845) - 0.028266020463719*std::sin(0.29775995016098*x_111 - 4.2792797088623) - 0.00303585772405365*std::sin(0.326159834861755*x_111 - 7.47175979614258) - 0.0274273839889198*std::sin(0.414799869060516*x_111 - 1.16295981407166) - 0.0417318546192576*std::sin(0.453359842300415*x_111 + 8.24512004852295) + 0.0138151497256084*std::sin(0.455839842557907*x_111 - 4.36560010910034) + 0.0299687935777328*std::sin(0.535999834537506*x_112 - 0.999279797077179) + 0.0319612483562387*std::sin(0.5933598279953*x_112 - 1.00103986263275) + 0.00603284373623716*std::sin(0.337679862976074*x_115 + 5.1374397277832) - 0.0796585289241441*std::sin(0.342799842357635*x_115 - 7.43576002120972) + 0.0232803142720422*std::sin(0.493279844522476*x_115 - 4.12056016921997) - 0.065762957716551*std::sin(0.301039934158325*x_116 + 1.90431988239288) - 0.00473226219648641*std::sin(0.396719843149185*x_117 + 1.99855983257294) - 0.0255247346579073*std::sin(0.550879836082458*x_117 + 8.3601598739624) + 0.0220790028628706*std::sin(0.597839832305908*x_117 + 5.40000009536743) - 0.0136918294705651*std::sin(0.294559925794601*x_119 - 4.29423999786377) + 0.0800637225110155*std::sin(0.300399929285049*x_119 + 8.296799659729) + 0.0450699387790135*std::sin(0.36575984954834*x_119 + 5.16232013702393) - 0.00213826801336909*std::sin(0.45279985666275*x_119 - 1.16775989532471) + 0.0429067707233624*std::sin(0.29615992307663*x_120 - 7.47679996490479) - 0.0549896410903267*std::sin(0.304079920053482*x_120 - 7.47528028488159) - 0.0375117398518143*std::sin(0.405039846897125*x_120 + 5.21120023727417) - 0.0390815240667515*std::sin(0.449199855327606*x_120 - 4.16680002212524) + 0.106099185304947*std::sin(0.183280006051064*x_15 + 1.78319990634918) - 0.0331587146874234*std::sin(0.346639841794968*x_16 - 7.43271970748901) - 0.0328093873973055*std::sin(0.375999838113785*x_16 + 5.18239974975586) + 0.0264726265059431*std::sin(0.387439846992493*x_16 - 7.39447975158691) - 0.0712831387197122*std::sin(0.274959951639175*x_18 - 7.52424001693726) - 0.0696914544088782*std::sin(0.25655996799469*x_20 - 7.54432010650635) + 0.00501509148951274*std::sin(0.343279838562012*x_20 - 7.44608020782471) - 0.120181593192804*std::sin(0.234959989786148*x_21 + 5.042799949646) - 0.0334687264494069*std::sin(0.420959860086441*x_21 + 8.42536067962646) + 0.0265074555892284*std::sin(0.457599848508835*x_22 - 7.32376003265381) - 0.0773286731856081*std::sin(0.266079962253571*x_24 + 5.06623983383179) - 0.0643841859127561*std::sin(0.305119842290878*x_24 + 5.10567998886108) + 0.144523813834461*std::sin(0.306879937648773*x_24 + 5.1399998664856) - 0.0681636101584939*std::sin(0.313759922981262*x_24 - 7.46903991699219) + 0.00925230843949434*std::sin(0.351119846105576*x_24 - 4.26471996307373) - 0.0364061501781004*std::sin(0.404879868030548*x_24 + 8.39160060882568) + 0.0203028737635635*std::sin(0.788399875164032*x_25 - 4.00871992111206) - 0.090621928571878*std::sin(0.290719836950302*x_27 - 4.32800006866455) + 0.0652862769560165*std::sin(0.317679852247238*x_28 + 5.11696004867554) - 0.0221398430387616*std::sin(0.320399850606918*x_28 - 4.27432012557983) - 0.0886995488987852*std::sin(0.324319839477539*x_28 + 8.30976009368896) + 0.0561608115175488*std::sin(0.330559849739075*x_28 + 5.13048028945923) - 0.00118189915308992*std::sin(0.338479846715927*x_28 + 8.32632064819336) - 0.0123401809108282*std::sin(0.33943983912468*x_28 + 8.31999969482422) - 0.0314260982951652*std::sin(0.291439920663834*x_3 + 5.0874400138855) - 0.0516512087996109*std::sin(0.303439915180206*x_3 - 7.50208044052124) + 0.0490565522093852*std::sin(0.271119952201843*x_33 - 1.1729599237442) + 0.058722181699462*std::sin(0.34895983338356*x_34 - 7.40207958221436) + 0.0639325902386649*std::sin(0.355359852313995*x_34 - 7.41152000427246) + 0.0139231069062727*std::sin(0.369519829750061*x_34 + 8.19623947143555) + 0.0629229846154422*std::sin(0.31007993221283*x_35 + 8.25119972229004) - 0.0711527945571258*std::sin(0.314959853887558*x_35 + 1.97399973869324) + 0.0262690760238674*std::sin(0.331679850816727*x_35 - 7.42903995513916) - 0.0151617152257933*std::sin(0.326639831066132*x_36 - 7.46719980239868) - 0.00258239071527763*std::sin(0.332639843225479*x_36 - 4.26639986038208) - 0.00471449838704243*std::sin(0.365359842777252*x_36 + 5.18416023254395) + 0.0363675945309315*std::sin(0.418479859828949*x_36 + 5.22432041168213) - 0.0552986636880015*std::sin(0.29367995262146*x_37 - 1.33159983158112) - 0.00927880594344077*std::sin(0.428959846496582*x_37 - 1.1684798002243) - 0.00322252041859077*std::sin(0.47775986790657*x_38 - 7.32087993621826) - 0.0375631265651776*std::sin(0.479759842157364*x_38 + 5.2579197883606) + 0.0123619152949341*std::sin(0.635359883308411*x_38 - 0.950879812240601) + 0.0486101186259265*std::sin(0.317439913749695*x_41 + 1.91527986526489) + 0.0374962607418454*std::sin(0.387199848890305*x_41 + 1.97423982620239) + 0.00672880734208405*std::sin(0.355519831180573*x_43 + 8.34455966949463) + 0.0116832889242727*std::sin(0.401679843664169*x_43 + 1.97855985164642) + 0.0053240209264008*std::sin(0.352319836616516*x_44 + 5.15360021591187) - 0.242210052702934*std::sin(0.182240009307861*x_46 + 4.96335983276367) + 0.0208305034172067*std::sin(0.265519976615906*x_48 - 7.5195198059082) + 0.00405243369612854*std::sin(0.220799997448921*x_51 + 5.01679992675781) + 0.00582763828607209*std::sin(0.186400011181831*x_53 - 4.42840003967285) - 0.0592842746467842*std::sin(0.354639858007431*x_53 - 4.25040006637573) - 0.14408193714929*std::sin(0.280239939689636*x_54 - 1.33415985107422) + 0.00907698523704421*std::sin(0.53823983669281*x_54 - 1.03471982479095) + 0.0450098368133469*std::sin(0.356959849596024*x_55 - 7.43415975570679) + 0.0101593474560108*std::sin(0.487919867038727*x_55 + 2.06407976150513) - 0.0175229020938223*std::sin(0.239359974861145*x_56 + 1.83567988872528) - 0.0271634879857778*std::sin(0.395439833402634*x_56 + 5.18455982208252) + 0.0438664907460633*std::sin(0.139120042324066*x_58 - 7.6723198890686) - 0.292752431744843*std::sin(0.184960007667542*x_58 - 7.6159200668335) - 0.0836946858835918*std::sin(0.255359977483749*x_58 + 5.05471992492676) + 0.0440705556595178*std::sin(0.277119934558868*x_58 + 5.09000015258789) - 0.0435963479777733*std::sin(0.386319845914841*x_58 + 5.19648027420044) + 0.00243145608304081*std::sin(0.490319848060608*x_58 - 4.12143993377686) - 0.00705164380685202*std::sin(0.605599880218506*x_58 - 0.993359804153442) - 0.00449702155901849*std::sin(0.298159927129745*x_59 + 5.10799980163574) + 0.0559091658805611*std::sin(0.362959831953049*x_59 - 4.22071981430054) - 0.0407699101557538*std::sin(0.125840052962303*x_63 - 1.45423996448517) + 0.142263555273088*std::sin(0.164000019431114*x_64 - 1.42503988742828) + 0.107807306498566*std::sin(0.179200008511543*x_64 - 4.42479991912842) + 0.0293410639546789*std::sin(0.281999945640564*x_64 + 5.10519981384277) + 0.0308305334109384*std::sin(0.417919874191284*x_64 + 1.99703979492188) + 0.0492190617342272*std::sin(0.398639857769012*x_65 - 7.40407991409302) - 0.0151191523478073*std::sin(0.440159857273102*x_66 - 4.15623998641968) - 0.110011856274598*std::sin(0.243359968066216*x_69 - 7.54400014877319) + 0.00864900267516114*std::sin(0.254959970712662*x_70 - 7.52400016784668) + 0.0341249496031055*std::sin(0.515119850635529*x_70 + 5.33439970016479) - 0.0102485881308782*std::sin(0.514559864997864*x_72 - 4.07624006271362) + 0.0315369218759054*std::sin(0.245599970221519*x_73 + 1.86039984226227) - 0.0476521271757748*std::sin(0.42799985408783*x_73 - 4.17216014862061) - 0.0798455201782742*std::sin(0.225519984960556*x_74 + 1.8199999332428) - 0.130706034284507*std::sin(0.199359983205795*x_75 - 7.59999990463257) + 0.0639514831016182*std::sin(0.382159858942032*x_75 - 7.40551996231079) - 0.0150315293598094*std::sin(0.527119874954224*x_75 - 7.25256013870239) + 0.0353701006721859*std::sin(0.262239962816238*x_76 - 7.52232027053833) - 0.0187927381106372*std::sin(0.289119929075241*x_77 - 7.48000001907349) - 0.0125892266392785*std::sin(0.231439992785454*x_79 + 1.83111989498138) - 0.00350381308915669*std::sin(0.367839843034744*x_79 + 8.36952018737793) + 0.0510843997058899*std::sin(0.375919848680496*x_79 - 7.42759990692139) - 0.0325285077598693*std::sin(0.465919852256775*x_81 + 8.46975994110107) - 0.0401178459738443*std::sin(0.263439983129501*x_82 + 1.86799991130829) - 0.0124491951078142*std::sin(0.397759824991226*x_82 - 7.40991973876953) + 0.336448814908579*std::sin(0.158560022711754*x_84 - 7.65680027008057) - 0.0257642709605352*std::sin(0.353839844465256*x_84 + 5.14383983612061) + 0.0413499611040698*std::sin(0.174960017204285*x_85 - 4.43856000900269) + 0.0657432277859394*std::sin(0.212719991803169*x_85 - 7.58776044845581) - 0.025543324768343*std::sin(0.21399998664856*x_85 - 7.5816798210144) + 0.00155685898406914*std::sin(0.631679832935333*x_86 - 7.16951990127563) + 0.0264329761293476*std::sin(0.51615983247757*x_87 + 5.32791996002197) - 0.00179558835820257*std::sin(0.797919869422913*x_87 - 0.793519854545593) + 0.014229875048879*std::sin(0.988159835338593*x_87 + 5.58551979064941) - 0.110976441576376*std::sin(0.225519984960556*x_89 + 1.8122398853302) - 0.0249958275950833*std::sin(0.321119844913483*x_90 + 8.31783962249756) + 0.0316170660358636*std::sin(0.351999849081039*x_92 - 7.39856004714966) - 0.0446227536330379*std::sin(0.353839844465256*x_92 + 1.99631977081299) - 0.0836524380207448*std::sin(0.359439849853516*x_92 - 1.18815994262695) - 0.00374751464995943*std::sin(0.373199850320816*x_92 - 7.38935995101929) + 0.0427268773681901*std::sin(0.381119847297668*x_92 + 8.18279933929443) - 0.024160920757395*std::sin(0.38487982749939*x_92 - 1.19791984558105) + 0.0456864922128135*std::sin(0.353119850158691*x_95 - 1.21815991401672) - 0.0364333040089127*std::sin(0.364959836006165*x_95 + 5.16431999206543) - 0.0294430325880579*std::sin(0.38919985294342*x_95 + 1.98527979850769) - 0.003362779383831*std::sin(0.386959850788116*x_96 + 5.19655990600586) + 0.027378300799694*std::sin(0.415279865264893*x_96 - 7.3996000289917) - 0.00767918427651869*std::sin(0.439519852399826*x_96 + 8.20975971221924) + 0.0802103470859147*std::sin(0.305199921131134*x_97 + 5.11439990997314) - 0.00381699893244331*std::sin(0.353279858827591*x_97 + 5.16728019714355) - 0.00311296667446609*std::sin(0.37255984544754*x_98 + 5.18039989471436) + 0.0351473524919603*std::sin(0.415599852800369*x_98 - 7.38839960098267) + 0.00511036827557916*std::sin(0.436959862709045*x_98 - 7.37871980667114) - 0.0122110260228706*std::sin(0.451919853687286*x_98 + 2.00551986694336) - 0.0518739401988797*std::sin(0.406159847974777*x_99 - 4.20160007476807) - 0.0575358748167053*std::sin(0.407679855823517*x_99 + 5.20464038848877) - 0.0268766237928201*std::sin(0.443759858608246*x_99 + 5.22552013397217) - 0.00525759658846802*std::sin(0.681439816951752*x_99 + 8.60767936706543) - 0.0843559190352874 + 0.000137538564077102*std::exp(-2.08247995376587*x_54));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.036879427394024*x_1 + 0.00931423310415467*x_10 - 0.0128064632889652*x_100 + 0.00633038634004111*x_101 - 0.00723134944420351*x_102 + 0.0199418100705895*x_103 - 0.0109898211131389*x_104 - 0.014173797877293*x_105 - 0.00125630463971835*x_106 - 0.00746481746667277*x_107 + 0.000609250235072663*x_108 + 0.00246003758320519*x_109 + 0.00532320248634722*x_11 - 0.00384910211896*x_110 - 0.00314203433642703*x_111 + 0.00725032419165379*x_112 + 0.0153518607614581*x_113 - 0.0068723953454194*x_114 + 0.00211136633412671*x_115 + 0.0194030896594039*x_116 + 0.0062440056172178*x_117 - 0.00632968674806882*x_118 + 0.0168028158248518*x_119 + 0.0123524459366566*x_12 - 0.0033887480916634*x_120 + 0.00100125357332057*x_13 - 0.0129120681903352*x_14 + 0.00257820868422245*x_15 + 0.00120882285169333*x_16 + 0.0205572579513223*x_17 - 0.0230492364446744*x_18 - 0.0341842683348416*x_19 - 0.0113898676611808*x_2 + 0.00679061888105073*x_20 + 0.0019247269017526*x_21 - 0.00712327724352703*x_22 + 0.0138808898601863*x_23 - 0.00105508444870876*x_24 + 0.0138178272817318*x_25 + 0.0128770117781324*x_26 + 0.00518446305857162*x_27 - 0.00107663254301472*x_28 + 0.00941889660419666*x_29 + 0.0091389664183906*x_3 + 0.0102883880133866*x_30 + 0.023914599781672*x_32 - 0.0209809122576047*x_33 + 0.0117086168382175*x_34 - 0.0152857989241445*x_35 - 0.00484452548520603*x_36 + 0.00709022968238868*x_37 + 0.000103240636664929*x_38 + 0.0145085232035476*x_39 + 0.0200807985061106*x_4 - 0.0191404067678878*x_40 + 0.0132743928872985*x_41 - 0.00375513250829963*x_42 + 0.00370472092667647*x_43 - 0.0219527878740335*x_44 - 0.0181199034908817*x_45 + 0.0176101590040005*x_46 - 0.00783184791434687*x_47 + 0.00214002291158192*x_48 - 0.00616994778647297*x_49 + 0.0115531660570248*x_5 - 0.00816534546559103*x_50 - 0.000352654373564629*x_51 + 0.0179997912902399*x_52 - 0.00563734621187738*x_53 + 0.00835923471875257*x_54 - 0.00377375256964518*x_55 + 0.00851990165995229*x_56 + 0.0259668271176675*x_57 + 0.000348165737961259*x_58 - 0.00340720601402594*x_59 + 0.00738436444943985*x_6 + 0.0270399468965802*x_60 + 0.0130253861613841*x_61 + 0.017705513619421*x_62 - 0.0198844639030695*x_63 - 0.000325443786512071*x_64 - 0.0113940103260984*x_65 + 0.00435497097472305*x_66 + 0.00305660068962982*x_67 - 0.000758721329244448*x_68 - 0.0182662845585044*x_69 + 0.0160932223633375*x_7 + 0.00205811068378522*x_70 + 0.0119563821403437*x_71 + 0.00990395589742254*x_72 - 0.00345649298899338*x_73 - 0.000635367964821239*x_74 - 0.00632023964838553*x_75 + 0.00363926489187451*x_76 + 0.00786287804543361*x_77 + 0.0103836037352901*x_78 + 0.0159957303720997*x_79 + 0.00891422503143287*x_8 + 0.00718451815397437*x_80 + 0.000324977098823322*x_81 + 0.00930283228292554*x_82 + 0.00177531716273371*x_83 + 0.0136010682426472*x_84 - 0.00740011676003781*x_85 + 0.00457432293613776*x_86 + 0.000765287622448328*x_87 - 0.0134592126072367*x_88 - 0.0159680222706276*x_89 + 0.0136244824347099*x_9 - 0.00593861813385285*x_90 - 0.00673682512026154*x_91 + 0.00568284747966635*x_92 - 3.84033923938876e-5*x_93 - 0.00566057232775685*x_94 - 0.000346884794109313*x_95 - 0.00883398719213526*x_96 - 0.0305191838894603*x_97 + 0.0136270187147283*x_98 - 0.0134078574701037*x_99 + 3.74091194274895e-5*std::pow(-8.29967975616455*x_104 - 9.30575942993164, 2) - 0.000128906516170787*std::pow(-5.02359962463379*x_104 - 6.63000011444092, 2) + 4.37267738657229e-5*std::pow(-7.76968002319336*x_106 - 8.38871955871582, 2) + 2.84199591138039e-5*std::pow(-6.33696031570435*x_106 - 6.55055999755859, 2) + 5.75444012022524e-5*std::pow(-4.04055976867676*x_107 - 6.8732795715332, 2) + 2.98256206500623e-5*std::pow(-5.1199197769165*x_112 - 7.47016000747681, 2) + 0.00230209590836548*std::pow(-1.28807985782623*x_114 - 1.71615982055664, 2) - 1.4731214549262e-5*std::pow(-9.0*x_115 - 9.99927997589111, 2) - 9.0361007555582e-6*std::pow(-8.35487937927246*x_115 - 9.57288074493408, 2) - 3.8713230464418e-5*std::pow(-8.12743949890137*x_115 - 9.94367980957031, 2) + 1.92560851602919e-5*std::pow(-7.13303995132446*x_115 - 8.96848011016846, 2) - 7.89369343314942e-6*std::pow(-7.52023983001709*x_12 - 5.48464012145996, 2) - 3.33966944982289e-5*std::pow(-5.54967975616455*x_120 - 6.57407999038696, 2) + 4.53376634312095e-5*std::pow(-7.13495969772339*x_14 - 9.12439918518066, 2) - 3.87311311352002e-5*std::pow(-7.84424018859863*x_15 - 8.04736042022705, 2) + 0.000106220898325936*std::pow(-6.59600019454956*x_15 - 9.96271991729736, 2) + 8.46493927720637e-5*std::pow(-4.43039989471436*x_15 - 5.83872032165527, 2) - 5.78892350735295e-5*std::pow(-6.48343992233276*x_19 - 8.70903968811035, 2) + 0.000230761756618356*std::pow(-4.24728012084961*x_21 - 5.46327972412109, 2) + 9.01290181641559e-5*std::pow(-3.86207985877991*x_24 - 5.49304008483887, 2) + 1.51707309633899e-5*std::pow(-8.15999984741211*x_45 - 9.98680019378662, 2) - 6.2213240153981e-5*std::pow(-5.56400012969971*x_47 - 6.5978798866272, 2) - 1.64246092094536e-5*std::pow(-8.39575958251953*x_48 - 7.98016023635864, 2) - 8.48785503298364e-5*std::pow(-5.89743947982788*x_55 - 7.46456003189087, 2) - 8.44954299968006e-5*std::pow(-4.72551965713501*x_55 - 7.19879961013794, 2) + 1.237411343669e-5*std::pow(-8.09127998352051*x_59 - 9.45944023132324, 2) + 0.000259025278326131*std::pow(-3.35439991950989*x_60 - 4.39711999893188, 2) + 3.12353929194504e-5*std::pow(-8.26799964904785*x_67 - 7.86800003051758, 2) + 2.05285358587729e-5*std::pow(-7.10328006744385*x_67 - 8.67744064331055, 2) - 9.04642608435996e-5*std::pow(-5.22671985626221*x_7 - 8.03615951538086, 2) - 5.57523606535e-5*std::pow(-6.26759958267212*x_70 - 9.014479637146, 2) - 6.37771934447712e-5*std::pow(-5.07919979095459*x_71 - 7.71488046646118, 2) + 0.000224781193036786*std::pow(-3.47183990478516*x_78 - 4.69567966461182, 2) + 4.38549830206894e-5*std::pow(-6.55936002731323*x_79 - 9.14999961853027, 2) - 3.47636528368778e-5*std::pow(-7.44632005691528*x_82 - 8.2236795425415, 2) - 8.08681113513975e-6*std::pow(-9.99993991851807*x_84 - 8.60000038146973, 2) + 1.67132190006817e-5*std::pow(-8.00255966186523*x_84 - 8.5984001159668, 2) - 2.96770390933172e-5*std::pow(-7.19600009918213*x_87 - 9.9973201751709, 2) - 7.27459535689605e-5*std::pow(-4.31935977935791*x_87 - 6.28535985946655, 2) - 7.18190526248046e-5*std::pow(-4.3907995223999*x_90 - 5.78359985351563, 2) - 0.00287975823942477*std::exp(0.380719840526581*x_1) + 0.000193659134003504*std::exp(0.815199851989746*x_1) + 0.000581373895538539*std::exp(1.00071978569031*x_1) + 9.95465465595374e-5*std::exp(1.15455985069275*x_1) - 2.91284320198613e-5*std::exp(1.20775985717773*x_1) + 1.25523604406701e-5*std::exp(1.34047985076904*x_1) + 1.78106618960842e-5*std::exp(1.38623988628387*x_1) + 0.000692539780777337*std::exp(1.51599979400635*x_100) + 0.00115706903208002*std::exp(1.56199979782104*x_100) + 0.00584551323052718*std::exp(0.623199820518494*x_104) + 0.00378402518793888*std::exp(0.879519879817963*x_104) - 0.00232379230777306*std::exp(0.884399890899658*x_104) - 0.0126965692634513*std::exp(0.60591983795166*x_106) + 0.00148447794969725*std::exp(0.726879835128784*x_106) + 0.00522757795448467*std::exp(1.03599977493286*x_106) + 0.0197112103560452*std::exp(0.550239861011505*x_109) - 0.0038527435653978*std::exp(0.644079864025116*x_109) + 0.00999317082666036*std::exp(0.68751984834671*x_109) + 0.00331492098975088*std::exp(0.815999865531921*x_109) - 0.0010370372256232*std::exp(0.963039815425873*x_109) + 0.00292947223144526*std::exp(1.03647983074188*x_109) + 0.00411915727901766*std::exp(0.64031982421875*x_110) + 0.00148130423666882*std::exp(1.00471985340118*x_110) + 0.0011529149219762*std::exp(1.11807978153229*x_110) - 0.00128011897520928*std::exp(1.24599981307983*x_110) - 0.000991218770394824*std::exp(1.35839986801147*x_110) + 0.00239477099749191*std::exp(0.422239869832993*x_112) + 0.00150911356999934*std::exp(0.832239866256714*x_112) + 0.00135341286079633*std::exp(0.840879857540131*x_112) + 0.00496816684826408*std::exp(0.667279839515686*x_114) + 0.000967904677570323*std::exp(0.739199817180634*x_114) + 0.000392664691722017*std::exp(1.27807986736298*x_23) - 0.000198010011714671*std::exp(1.61607992649078*x_23) - 0.0181182628732013*std::exp(0.619119822978973*x_26) - 0.00179925955138125*std::exp(0.88647985458374*x_26) - 0.001147846459337*std::exp(0.919839859008789*x_26) - 6.18454742423444e-5*std::exp(1.32983994483948*x_26) - 6.43054360029565e-5*std::exp(1.48503994941711*x_26) - 0.00539894742303561*std::exp(0.493599832057953*x_31) + 0.00129671669309108*std::exp(0.610639870166779*x_31) + 0.00300978173909759*std::exp(0.643439829349518*x_31) - 0.0142807941429513*std::exp(0.645119845867157*x_31) + 0.0331918527869628*std::exp(0.645279824733734*x_31) + 0.00824609269257714*std::exp(0.650719821453094*x_31) - 0.0033548245169983*std::exp(0.652079820632935*x_31) + 0.00435566835932979*std::exp(0.660639822483063*x_31) - 0.00267861384782027*std::exp(0.66271984577179*x_31) + 0.00924678319295352*std::exp(0.51231986284256*x_45) - 0.00452502708659288*std::exp(0.891679883003235*x_45) - 0.00341608476256874*std::exp(0.86599987745285*x_49) + 0.00237510702905838*std::exp(0.91407984495163*x_50) + 0.000518692487825648*std::exp(1.3595198392868*x_50) + 0.00168493427199029*std::exp(0.910159826278687*x_52) + 0.00270422219085831*std::exp(0.954559803009033*x_6) - 0.00114638410686625*std::exp(1.37487983703613*x_60) - 0.00276416960587808*std::exp(0.692239880561829*x_66) + 0.0024927457058003*std::exp(0.945199847221375*x_66) + 0.000158569899204216*std::exp(1.67783987522125*x_66) + 0.00336091673097212*std::exp(0.66951984167099*x_68) - 0.00357045535935595*std::exp(1.33463990688324*x_68) + 0.00198909507337876*std::exp(0.661919832229614*x_70) + 0.00704828954843837*std::exp(0.710639834403992*x_70) - 0.00397454931980919*std::exp(0.801199853420258*x_72) + 0.00273584087270255*std::exp(0.824319899082184*x_72) + 0.00462935281149612*std::exp(0.90671980381012*x_72) + 0.00293163141787227*std::exp(0.693759858608246*x_74) + 0.00660086743408518*std::exp(1.17047989368439*x_74) + 0.00220466463963655*std::exp(1.25959992408752*x_74) + 0.000316022207066035*std::exp(1.45263981819153*x_74) - 9.42229880711229e-5*std::exp(1.60871982574463*x_74) + 0.00369489978185941*std::exp(0.926559805870056*x_78) - 0.00096091492538303*std::exp(1.16831982135773*x_81) + 0.0010099559323291*std::exp(1.27199983596802*x_81) - 0.000250279185988159*std::exp(2.01087975502014*x_81) - 0.00619004995018527*std::exp(0.611999809741974*x_90) - 0.00409730767693338*std::sin(0.364159852266312*x_100 + 5.18175983428955) + 0.0907403447510945*std::sin(0.235039994120598*x_102 - 1.34447979927063) + 0.0937255594465636*std::sin(0.323359847068787*x_102 + 1.94719982147217) + 0.0369932044036527*std::sin(0.375599831342697*x_102 + 1.9761598110199) + 0.0133411101819687*std::sin(0.377599835395813*x_102 + 5.17960023880005) + 0.0215189325752908*std::sin(0.442639857530594*x_102 + 8.43080043792725) + 0.0497961439936895*std::sin(0.459279865026474*x_102 + 5.24032020568848) + 0.00982596005011084*std::sin(0.521439850330353*x_103 + 8.35359954833984) - 0.0225878234368235*std::sin(0.326879858970642*x_105 - 7.46807956695557) + 0.0934629538977895*std::sin(0.267679959535599*x_106 - 7.52112007141113) + 0.045478357678441*std::sin(0.526319861412048*x_106 - 4.0403995513916) - 0.0485966542574713*std::sin(0.272559970617294*x_107 - 7.52992010116577) + 0.0102667218701016*std::sin(0.584239840507507*x_107 + 2.17967987060547) - 0.0162647112845028*std::sin(0.444399863481522*x_108 + 2.046719789505) - 0.00414357520206191*std::sin(0.535279810428619*x_109 + 8.36967945098877) + 0.013075025380755*std::sin(0.611279845237732*x_110 - 0.978959858417511) + 0.102534886079913*std::sin(0.230719983577728*x_111 - 7.57328033447266) + 0.0611012063832428*std::sin(0.247679978609085*x_111 + 5.05423974990845) - 0.021797513624305*std::sin(0.29775995016098*x_111 - 4.2792797088623) + 0.0359511535910057*std::sin(0.326159834861755*x_111 - 7.47175979614258) + 0.0221368174646513*std::sin(0.414799869060516*x_111 - 1.16295981407166) - 0.0110903991067494*std::sin(0.453359842300415*x_111 + 8.24512004852295) - 0.0195671066502808*std::sin(0.455839842557907*x_111 - 4.36560010910034) - 0.0241880054377076*std::sin(0.535999834537506*x_112 - 0.999279797077179) + 0.00849382332643929*std::sin(0.5933598279953*x_112 - 1.00103986263275) + 0.0125860072684117*std::sin(0.337679862976074*x_115 + 5.1374397277832) + 0.0594012080278403*std::sin(0.342799842357635*x_115 - 7.43576002120972) - 0.0329731057035679*std::sin(0.493279844522476*x_115 - 4.12056016921997) - 0.0174767561655473*std::sin(0.301039934158325*x_116 + 1.90431988239288) + 0.0560402695129024*std::sin(0.396719843149185*x_117 + 1.99855983257294) + 0.0148034844480525*std::sin(0.550879836082458*x_117 + 8.3601598739624) + 0.00586757899600515*std::sin(0.597839832305908*x_117 + 5.40000009536743) + 0.0212772388076289*std::sin(0.300399929285049*x_119 + 8.296799659729) - 0.0363762365487385*std::sin(0.36575984954834*x_119 + 5.16232013702393) + 0.0253217405935352*std::sin(0.45279985666275*x_119 - 1.16775989532471) + 0.0330878172474927*std::sin(0.29615992307663*x_120 - 7.47679996490479) + 0.0531298052425352*std::sin(0.405039846897125*x_120 + 5.21120023727417) + 0.0315429486405104*std::sin(0.449199855327606*x_120 - 4.16680002212524) - 0.150273729608701*std::sin(0.183280006051064*x_15 + 1.78319990634918) + 0.0469643919582255*std::sin(0.346639841794968*x_16 - 7.43271970748901) + 0.0264806669215917*std::sin(0.375999838113785*x_16 + 5.18239974975586) + 0.00703520119183344*std::sin(0.387439846992493*x_16 - 7.39447975158691) + 0.0575330782834835*std::sin(0.274959951639175*x_18 - 7.52424001693726) + 0.0404186909415878*std::sin(0.25655996799469*x_20 - 7.54432010650635) - 0.0593895830439885*std::sin(0.343279838562012*x_20 - 7.44608020782471) + 0.170219367731152*std::sin(0.234959989786148*x_21 + 5.042799949646) - 0.00889444136391809*std::sin(0.420959860086441*x_21 + 8.42536067962646) - 0.0213943373552561*std::sin(0.457599848508835*x_22 - 7.32376003265381) + 0.0519648892412282*std::sin(0.305119842290878*x_24 + 5.10567998886108) - 0.163282385536647*std::sin(0.306879937648773*x_24 + 5.1399998664856) + 0.0508294697584614*std::sin(0.313759922981262*x_24 - 7.46903991699219) + 0.0193026085806916*std::sin(0.351119846105576*x_24 - 4.26471996307373) - 0.00967507289333528*std::sin(0.404879868030548*x_24 + 8.39160060882568) - 0.0163865795838725*std::sin(0.788399875164032*x_25 - 4.00871992111206) + 0.0525576593937573*std::sin(0.290719836950302*x_27 - 4.32800006866455) + 0.0173500764402135*std::sin(0.317679852247238*x_28 + 5.11696004867554) + 0.0661430788049034*std::sin(0.324319839477539*x_28 + 8.30976009368896) - 0.0453277510437344*std::sin(0.330559849739075*x_28 + 5.13048028945923) + 0.0139962547141634*std::sin(0.338479846715927*x_28 + 8.32632064819336) + 0.0174780325050223*std::sin(0.33943983912468*x_28 + 8.31999969482422) + 0.0731562618770966*std::sin(0.303439915180206*x_3 - 7.50208044052124) - 0.0694813163839116*std::sin(0.271119952201843*x_33 - 1.1729599237442) - 0.0831712442407089*std::sin(0.34895983338356*x_34 - 7.40207958221436) - 0.0516004034773209*std::sin(0.355359852313995*x_34 - 7.41152000427246) + 0.0290470518353789*std::sin(0.369519829750061*x_34 + 8.19623947143555) - 0.0364932069486248*std::sin(0.31007993221283*x_35 + 8.25119972229004) + 0.0530584986734417*std::sin(0.314959853887558*x_35 + 1.97399973869324) - 0.0116920489258918*std::sin(0.326639831066132*x_36 - 7.46719980239868) - 0.00538750707516843*std::sin(0.332639843225479*x_36 - 4.26639986038208) + 0.0558299074011927*std::sin(0.365359842777252*x_36 + 5.18416023254395) - 0.029352518712135*std::sin(0.418479859828949*x_36 + 5.22432041168213) + 0.0624761932611876*std::sin(0.29367995262146*x_37 - 1.33159983158112) - 0.00715540764675516*std::sin(0.428959846496582*x_37 - 1.1684798002243) + 0.038161645587335*std::sin(0.47775986790657*x_38 - 7.32087993621826) + 0.0303174402819771*std::sin(0.479759842157364*x_38 + 5.2579197883606) + 0.0032852260124903*std::sin(0.635359883308411*x_38 - 0.950879812240601) - 0.0362484696586139*std::sin(0.317439913749695*x_41 + 1.91527986526489) + 0.0140379598441306*std::sin(0.355519831180573*x_43 + 8.34455966949463) + 0.00900963932402179*std::sin(0.401679843664169*x_43 + 1.97855985164642) - 0.0630479790044934*std::sin(0.352319836616516*x_44 + 5.15360021591187) + 0.273647879591605*std::sin(0.182240009307861*x_46 + 4.96335983276367) + 0.0160635694232408*std::sin(0.265519976615906*x_48 - 7.5195198059082) - 0.0479896225282755*std::sin(0.220799997448921*x_51 + 5.01679992675781) - 0.069011903105806*std::sin(0.186400011181831*x_53 - 4.42840003967285) + 0.047848718161028*std::sin(0.354639858007431*x_53 - 4.25040006637573) + 0.162783155151333*std::sin(0.280239939689636*x_54 - 1.33415985107422) - 0.0335637466064026*std::sin(0.356959849596024*x_55 - 7.43415975570679) + 0.00269988523106051*std::sin(0.487919867038727*x_55 + 2.06407976150513) - 0.036557116802444*std::sin(0.239359974861145*x_56 + 1.83567988872528) - 0.00721880025803238*std::sin(0.395439833402634*x_56 + 5.18455982208252) + 0.0915163719645804*std::sin(0.139120042324066*x_58 - 7.6723198890686) + 0.33075044284193*std::sin(0.184960007667542*x_58 - 7.6159200668335) + 0.0624109623180492*std::sin(0.255359977483749*x_58 + 5.05471992492676) + 0.0339852770803747*std::sin(0.277119934558868*x_58 + 5.09000015258789) + 0.0252844101194573*std::sin(0.386319845914841*x_58 + 5.19648027420044) - 0.0287937245538851*std::sin(0.490319848060608*x_58 - 4.12143993377686) + 0.00569142692723025*std::sin(0.605599880218506*x_58 - 0.993359804153442) + 0.0532545090928907*std::sin(0.298159927129745*x_59 + 5.10799980163574) - 0.0451246462367276*std::sin(0.362959831953049*x_59 - 4.22071981430054) + 0.482804345634449*std::sin(0.125840052962303*x_63 - 1.45423996448517) - 0.160728755099982*std::sin(0.164000019431114*x_64 - 1.42503988742828) - 0.152693029452061*std::sin(0.179200008511543*x_64 - 4.42479991912842) + 0.0226265399519056*std::sin(0.281999945640564*x_64 + 5.10519981384277) - 0.0697114869768786*std::sin(0.398639857769012*x_65 - 7.40407991409302) + 0.0170815535318604*std::sin(0.440159857273102*x_66 - 4.15623998641968) + 0.0820356244127879*std::sin(0.243359968066216*x_69 - 7.54400014877319) - 0.102422989430661*std::sin(0.254959970712662*x_70 - 7.52400016784668) + 0.0090688351631874*std::sin(0.515119850635529*x_70 + 5.33439970016479) + 0.0145156021436362*std::sin(0.514559864997864*x_72 - 4.07624006271362) + 0.0243198891453801*std::sin(0.245599970221519*x_73 + 1.86039984226227) + 0.0276366251409659*std::sin(0.42799985408783*x_73 - 4.17216014862061) + 0.0644438312553118*std::sin(0.225519984960556*x_74 + 1.8199999332428) + 0.105493678276189*std::sin(0.199359983205795*x_75 - 7.59999990463257) + 0.0169953498960526*std::sin(0.382159858942032*x_75 - 7.40551996231079) + 0.0212899276476907*std::sin(0.527119874954224*x_75 - 7.25256013870239) + 0.0272758682915626*std::sin(0.262239962816238*x_76 - 7.52232027053833) - 0.0392063094611771*std::sin(0.289119929075241*x_77 - 7.48000001907349) - 0.0262642469974649*std::sin(0.231439992785454*x_79 + 1.83111989498138) + 0.041492762168792*std::sin(0.367839843034744*x_79 + 8.36952018737793) - 0.0296272273431829*std::sin(0.375919848680496*x_79 - 7.42759990692139) + 0.0460717974943134*std::sin(0.465919852256775*x_81 + 8.46975994110107) + 0.0176324349155055*std::sin(0.397759824991226*x_82 - 7.40991973876953) - 0.380118429286507*std::sin(0.158560022711754*x_84 - 7.65680027008057) + 0.0149424074174084*std::sin(0.353839844465256*x_84 + 5.14383983612061) + 0.0318872740394194*std::sin(0.174960017204285*x_85 - 4.43856000900269) - 0.0530617806503991*std::sin(0.212719991803169*x_85 - 7.58776044845581) - 0.0532897063556776*std::sin(0.21399998664856*x_85 - 7.5816798210144) - 0.0184365940512757*std::sin(0.631679832935333*x_86 - 7.16951990127563) - 0.0213342245056707*std::sin(0.51615983247757*x_87 + 5.32791996002197) - 0.00374604235008891*std::sin(0.797919869422913*x_87 - 0.793519854545593) - 0.0160768518503859*std::sin(0.988159835338593*x_87 + 5.58551979064941) + 0.0895697975076743*std::sin(0.225519984960556*x_89 + 1.8122398853302) + 0.0632014995645228*std::sin(0.353839844465256*x_92 + 1.99631977081299) + 0.094510165996788*std::sin(0.359439849853516*x_92 - 1.18815994262695) - 0.00781824437778121*std::sin(0.373199850320816*x_92 - 7.38935995101929) - 0.0344851366618219*std::sin(0.381119847297668*x_92 + 8.18279933929443) + 0.0180167509924877*std::sin(0.38487982749939*x_92 - 1.19791984558105) - 0.026496623217548*std::sin(0.353119850158691*x_95 - 1.21815991401672) - 0.00968228912716272*std::sin(0.364959836006165*x_95 + 5.16431999206543) + 0.0417016804161238*std::sin(0.38919985294342*x_95 + 1.98527979850769) + 0.0398226165748469*std::sin(0.386959850788116*x_96 + 5.19655990600586) - 0.0387772946577665*std::sin(0.415279865264893*x_96 - 7.3996000289917) - 0.00592184966772439*std::sin(0.439519852399826*x_96 + 8.20975971221924) - 0.0647382853915099*std::sin(0.305199921131134*x_97 + 5.11439990997314) + 0.0452015632319367*std::sin(0.353279858827591*x_97 + 5.16728019714355) + 0.0368642911526097*std::sin(0.37255984544754*x_98 + 5.18039989471436) - 0.0283676535390543*std::sin(0.415599852800369*x_98 - 7.38839960098267) + 0.0106614948228076*std::sin(0.436959862709045*x_98 - 7.37871980667114) - 0.00941660699785839*std::sin(0.451919853687286*x_98 + 2.00551986694336) + 0.0418677897177048*std::sin(0.406159847974777*x_99 - 4.20160007476807) - 0.0152903775903306*std::sin(0.407679855823517*x_99 + 5.20464038848877) + 0.038066743726907*std::sin(0.443759858608246*x_99 + 5.22552013397217) + 0.00392057941435815*std::sin(0.681439816951752*x_99 + 8.60767936706543) + 2.91391611099243*std::sin(-0.00221209309811249*x_10 + 0.00109826634055996*x_101 - 0.00261776769421299*x_102 + 0.001501003045559*x_103 - 3.0245276767506e-5*x_104 - 0.000888060755474091*x_106 - 0.000491547013877554*x_107 - 0.00278085842558016*x_108 - 0.000600332823004589*x_11 - 0.00203063472098986*x_111 - 0.000429216124614719*x_112 + 0.002265937340342*x_113 + 0.00229512771060905*x_115 + 0.00299332313886231*x_116 - 0.00349607967917165*x_117 - 0.00252880489837013*x_118 - 0.010606125183427*x_12 - 0.0018009187718743*x_13 + 0.00376176072832249*x_14 - 0.00159087703430927*x_15 + 0.000749474558416295*x_16 - 0.00111537583775404*x_17 + 0.000961545882274145*x_18 - 0.004378215289765*x_19 + 0.00593775407007789*x_2 + 0.000876091126822409*x_20 + 0.00179733494429374*x_21 + 0.000570807760542705*x_22 + 0.000984481928000664*x_23 - 0.00441578408233824*x_25 - 0.00310848424716483*x_27 + 6.97986814479258e-5*x_29 - 0.0019845998900149*x_30 + 0.00973166283196074*x_32 + 0.00780616799026016*x_33 - 0.00297790162962926*x_34 - 0.00220781267632394*x_36 - 0.00532128142017724*x_37 - 0.00108285557985716*x_38 - 0.000335415926709081*x_39 + 0.00121239447443463*x_4 + 0.00144337798239356*x_40 + 0.00940175550588521*x_42 - 0.00213150831384634*x_43 + 0.00738498349696384*x_44 - 0.00113005255142156*x_45 + 0.0027678726392076*x_46 + 0.000625219751289334*x_47 - 0.00319663616890229*x_48 + 0.00232904741807696*x_49 + 0.00422807528404438*x_5 + 0.000874315491901569*x_51 + 0.00411387920798113*x_52 - 0.000585596120325573*x_53 + 0.00420730022595253*x_56 + 0.0053939771078576*x_57 + 0.000920419919811743*x_58 - 0.000336469355499454*x_59 + 0.000953432525280401*x_6 + 0.00148110744142362*x_60 + 0.00595572997214101*x_61 + 0.00141535617402178*x_62 + 0.00215714343384341*x_63 - 0.00157805402947944*x_65 + 0.00136301180960476*x_67 + 0.00252247843120783*x_68 + 0.001457307442823*x_69 + 0.0024587672423229*x_7 - 0.00357061745144686*x_71 - 0.00153752042065158*x_72 + 0.00107518143633503*x_73 - 0.00354146104573993*x_74 - 0.00207183026804389*x_75 + 0.000163835580551165*x_76 - 0.00166414385900503*x_77 - 0.00253766219557091*x_79 + 0.00204878231893226*x_8 - 0.00110579802155497*x_80 + 0.000565577784432572*x_81 - 0.000494826602638618*x_83 + 0.000781218653930165*x_84 + 0.000769124942559706*x_85 + 0.000133410052225245*x_86 + 0.00333533793158723*x_88 - 0.00232363319643803*x_89 - 0.00134048660897714*x_9 + 0.00653759530448634*x_91 + 0.00158179925145015*x_93 + 0.00147352764320729*x_94 - 0.00231223278202252*x_95 - 0.00190328923093389*x_96 - 0.000480479579638304*x_97 - 0.00357145476692136*x_98 - 0.00386363800642979*x_99 + 6.66662360851548e-5*std::pow(-5.11528015136719*x_114 - 6.48727989196777, 2) - 2.07003452324414e-5*std::pow(-7.48736000061035*x_55 - 8.30447959899902, 2) - 2.7091334040252e-5*std::pow(-7.65072011947632*x_66 - 9.26943969726563, 2) + 7.64180992348152e-5*std::exp(1.16367983818054*x_1) + 0.000190501231827324*std::exp(1.20671987533569*x_100) - 0.00157230292393288*std::exp(0.954399824142456*x_110) + 0.0024090504485936*std::exp(0.657599866390228*x_26) - 0.0015996431628541*std::exp(0.662879824638367*x_31) + 0.00291528813316347*std::exp(0.959999799728394*x_50) - 0.00231047915261587*std::exp(0.77295982837677*x_70) - 0.000679687257492035*std::exp(0.611519813537598*x_78) - 0.00215091100280447*std::exp(0.700319886207581*x_87) + 0.0353829663355105*std::sin(0.325759828090668*x_105 + 1.9398398399353) + 0.010542461700044*std::sin(0.472879856824875*x_109 - 7.34272003173828) + 0.0114245810245162*std::sin(0.294559925794601*x_119 - 4.29423999786377) + 0.0458838325072692*std::sin(0.304079920053482*x_120 - 7.47528028488159) + 0.0645237142506456*std::sin(0.266079962253571*x_24 + 5.06623983383179) + 0.0184736766704678*std::sin(0.320399850606918*x_28 - 4.27432012557983) + 0.0262222084367449*std::sin(0.291439920663834*x_3 + 5.0874400138855) - 0.0219191444152176*std::sin(0.331679850816727*x_35 - 7.42903995513916) - 0.031287204524606*std::sin(0.387199848890305*x_41 + 1.97423982620239) - 0.00757391505071592*std::sin(0.53823983669281*x_54 - 1.03471982479095) - 0.0257252639422321*std::sin(0.417919874191284*x_64 + 1.99703979492188) + 0.0334746779342066*std::sin(0.263439983129501*x_82 + 1.86799991130829) + 0.0208567349052062*std::sin(0.321119844913483*x_90 + 8.31783962249756) - 0.0263815535725698*std::sin(0.351999849081039*x_92 - 7.39856004714966) - 1.86651046565785) + 3.95117110507806 - 0.000194802937736863*std::exp(-2.08247995376587*x_54));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0435062384695752*x_1 - 2.26047127153577e-5*x_10 + 0.0148842214791411*x_100 - 0.0104762031324704*x_101 + 0.0117570234121346*x_102 + 0.000684398291744964*x_103 + 0.00222386953381494*x_104 + 0.0185939277813073*x_105 - 0.00975068051797043*x_106 + 0.0290509245616676*x_107 + 0.00174652859324689*x_108 - 0.000776102913358661*x_109 + 0.00611496993863959*x_11 - 0.00099936344737227*x_110 - 0.00349724103433473*x_111 + 0.000524114614655735*x_112 - 0.00432781906206465*x_113 + 0.00405411224463242*x_114 - 0.000709211505966443*x_115 - 0.00589231961653014*x_116 - 0.00225007266151411*x_117 + 0.0135224560649767*x_118 + 0.00520605822680187*x_119 + 0.024792555952514*x_12 + 0.0132667188770419*x_120 + 0.0111124249152717*x_13 + 0.0290210971766786*x_14 - 0.00699657685922476*x_15 + 0.00713900601593394*x_16 + 0.013701416902526*x_17 - 0.0171753151344005*x_18 - 0.0155484546143865*x_19 - 0.0199453882512463*x_2 - 0.00333823847202975*x_20 + 5.85588318165698e-5*x_21 - 0.0134071298895423*x_22 + 0.0150573564786368*x_23 + 0.00166065241110459*x_24 - 0.00487528623861295*x_25 + 0.00173235609479149*x_26 + 0.0010812281579476*x_27 + 0.00397841913147102*x_28 + 0.0330528444538183*x_29 - 0.0120086702254028*x_3 + 0.0034991509847499*x_30 + 0.0188080451219272*x_32 + 0.011187879411244*x_33 - 0.00959042998072604*x_34 + 0.00498555641543286*x_35 - 0.00111290054565171*x_36 - 0.00628734092197514*x_37 - 0.00145540494054763*x_38 + 0.00242729343909461*x_39 + 0.033929223947001*x_4 + 0.00828006453690231*x_40 - 0.00570116394878039*x_41 - 0.00552772532038229*x_42 - 0.000929014106655646*x_43 + 0.0254910332987423*x_44 + 0.0103629363297284*x_45 + 0.00570285446771162*x_46 + 0.0155224369519374*x_47 - 0.0203414088918439*x_48 + 0.0108178831552202*x_49 + 0.012719948980958*x_5 - 2.03230000828392e-5*x_50 + 0.0100061038440657*x_51 - 0.00258891845747484*x_52 - 0.00156347149397183*x_53 + 0.0106609407165696*x_54 - 0.0108109899772413*x_55 + 0.011108881209854*x_56 - 0.0189847725768567*x_57 + 0.00263647164144638*x_58 + 0.00696181530783072*x_59 - 0.00652155303586639*x_6 + 0.010520274321137*x_60 + 0.0189738662682888*x_61 - 0.0107801595777571*x_62 + 0.000567786915514296*x_63 + 0.00940376565216586*x_64 - 0.0180552209499232*x_65 + 0.00329148247897984*x_66 + 0.00690837263879228*x_67 - 0.00491043337145114*x_68 - 0.0123871270713991*x_69 - 0.00181294608555258*x_7 - 0.000761105959087563*x_70 + 0.00705695188198067*x_71 - 0.00987005679420003*x_72 - 0.00239068869089794*x_73 - 0.0039873031151486*x_74 + 0.00322014469952022*x_75 + 0.0140094847020658*x_76 + 0.00990235939187455*x_77 + 0.0174507993695519*x_78 - 0.00234238942902002*x_79 + 0.0554905401795522*x_8 + 0.0105026383343686*x_80 - 0.00215001245414439*x_81 + 0.00805777519939265*x_82 - 0.0069418327228332*x_83 + 0.00519253596385761*x_84 + 0.00339208227442716*x_85 + 0.0132521778146059*x_86 + 0.000819736406832645*x_87 + 0.00160040531528255*x_88 + 0.0153235615476164*x_89 + 0.0219273959129617*x_9 + 0.00352258082939212*x_90 + 0.0207180260880808*x_91 + 0.0073269335086578*x_92 + 0.0873087596553331*x_93 + 0.0309748134051966*x_94 + 0.00310983389169437*x_95 + 0.00212484277593297*x_96 + 0.00424803992677595*x_97 - 0.00107984693684537*x_98 - 0.00336165798006865*x_99 + 1.63337661697242e-5*std::pow(-8.29967975616455*x_104 - 9.30575942993164, 2) - 1.50992710412356e-5*std::pow(-5.02359962463379*x_104 - 6.63000011444092, 2) + 5.12186994086952e-6*std::pow(-7.76968002319336*x_106 - 8.38871955871582, 2) + 1.95919213031975e-5*std::pow(-6.33696031570435*x_106 - 6.55055999755859, 2) + 8.15336211383225e-5*std::pow(-4.04055976867676*x_107 - 6.8732795715332, 2) + 4.22593823811016e-5*std::pow(-5.1199197769165*x_112 - 7.47016000747681, 2) + 7.09145253094737e-5*std::pow(-5.11528015136719*x_114 - 6.48727989196777, 2) - 0.00144483245680757*std::pow(-1.28807985782623*x_114 - 1.71615982055664, 2) - 8.75423505198168e-6*std::pow(-9.0*x_115 - 9.99927997589111, 2) - 3.49420764658606e-5*std::pow(-8.35487937927246*x_115 - 9.57288074493408, 2) + 2.42970467388462e-5*std::pow(-8.12743949890137*x_115 - 9.94367980957031, 2) + 2.72835987387955e-5*std::pow(-7.13303995132446*x_115 - 8.96848011016846, 2) - 3.0524453744001e-5*std::pow(-7.52023983001709*x_12 - 5.48464012145996, 2) - 0.00012914307669116*std::pow(-5.54967975616455*x_120 - 6.57407999038696, 2) + 5.39211893046208e-5*std::pow(-7.13495969772339*x_14 - 9.12439918518066, 2) - 1.6910989863782e-5*std::pow(-7.84424018859863*x_15 - 8.04736042022705, 2) - 6.66659459907283e-5*std::pow(-6.59600019454956*x_15 - 9.96271991729736, 2) + 9.91527940486727e-6*std::pow(-4.43039989471436*x_15 - 5.83872032165527, 2) + 0.000122629034024258*std::pow(-6.48343992233276*x_19 - 8.70903968811035, 2) - 0.000144829793815522*std::pow(-4.24728012084961*x_21 - 5.46327972412109, 2) - 0.000190923829292038*std::pow(-3.86207985877991*x_24 - 5.49304008483887, 2) + 2.14951342774949e-5*std::pow(-8.15999984741211*x_45 - 9.98680019378662, 2) - 7.28725438668956e-6*std::pow(-5.56400012969971*x_47 - 6.5978798866272, 2) - 1.13226641100652e-5*std::pow(-8.39575958251953*x_48 - 7.98016023635864, 2) - 2.20194695561595e-5*std::pow(-7.48736000061035*x_55 - 8.30447959899902, 2) - 5.04402931594034e-5*std::pow(-5.89743947982788*x_55 - 7.46456003189087, 2) + 0.000178989978824403*std::pow(-4.72551965713501*x_55 - 7.19879961013794, 2) + 4.78499775067355e-5*std::pow(-8.09127998352051*x_59 - 9.45944023132324, 2) + 0.000113096977233786*std::pow(-3.35439991950989*x_60 - 4.39711999893188, 2) - 2.88177225276508e-5*std::pow(-7.65072011947632*x_66 - 9.26943969726563, 2) + 1.36381612818947e-5*std::pow(-8.26799964904785*x_67 - 7.86800003051758, 2) + 1.41517958349066e-5*std::pow(-7.10328006744385*x_67 - 8.67744064331055, 2) - 0.000107591352643296*std::pow(-5.22671985626221*x_7 - 8.03615951538086, 2) + 0.000118102409244598*std::pow(-6.26759958267212*x_70 - 9.014479637146, 2) - 3.79005098665949e-5*std::pow(-5.07919979095459*x_71 - 7.71488046646118, 2) + 0.000133579440617642*std::pow(-3.47183990478516*x_78 - 4.69567966461182, 2) + 5.13688752755413e-6*std::pow(-6.55936002731323*x_79 - 9.14999961853027, 2) - 2.06587981718564e-5*std::pow(-7.44632005691528*x_82 - 8.2236795425415, 2) - 1.14580564144239e-5*std::pow(-9.99993991851807*x_84 - 8.60000038146973, 2) + 6.4629046544581e-5*std::pow(-8.00255966186523*x_84 - 8.5984001159668, 2) - 1.76360051644732e-5*std::pow(-7.19600009918213*x_87 - 9.9973201751709, 2) - 3.17627202557427e-5*std::pow(-4.31935977935791*x_87 - 6.28535985946655, 2) - 4.95100369941047e-5*std::pow(-4.3907995223999*x_90 - 5.78359985351563, 2) + 0.00610030467107581*std::exp(0.380719840526581*x_1) + 0.000748868616200457*std::exp(0.815199851989746*x_1) - 0.000364879617205496*std::exp(1.00071978569031*x_1) + 1.16602351251973e-5*std::exp(1.15455985069275*x_1) + 8.12878234998467e-5*std::exp(1.16367983818054*x_1) - 4.12715484224692e-5*std::exp(1.20775985717773*x_1) + 5.48067753140807e-6*std::exp(1.34047985076904*x_1) + 1.05842407052245e-5*std::exp(1.38623988628387*x_1) + 0.000202640875189787*std::exp(1.20671987533569*x_100) + 8.11196064203664e-5*std::exp(1.51599979400635*x_100) + 0.00137613043098186*std::exp(1.56199979782104*x_100) - 0.0123827796294953*std::exp(0.623199820518494*x_104) + 0.00224871111795026*std::exp(0.879519879817963*x_104) - 0.00898596980108253*std::exp(0.884399890899658*x_104) - 0.015100339606441*std::exp(0.60591983795166*x_106) + 0.00210332995408894*std::exp(0.726879835128784*x_106) + 0.00310656300694561*std::exp(1.03599977493286*x_106) - 0.0123710729782741*std::exp(0.550239861011505*x_109) - 0.00168220512731113*std::exp(0.644079864025116*x_109) + 0.00593858476764724*std::exp(0.68751984834671*x_109) - 0.00702212696926386*std::exp(0.815999865531921*x_109) - 0.00146935928593849*std::exp(0.963039815425873*x_109) + 0.00348409280054898*std::exp(1.03647983074188*x_109) + 0.0159285418027026*std::exp(0.64031982421875*x_110) - 0.00167249753459872*std::exp(0.954399824142456*x_110) + 0.00209883317750851*std::exp(1.00471985340118*x_110) + 0.000503391767497929*std::exp(1.11807978153229*x_110) - 0.000760729019729423*std::exp(1.24599981307983*x_110) - 0.00117888066820754*std::exp(1.35839986801147*x_110) - 0.0050729372008238*std::exp(0.422239869832993*x_112) + 0.000896812334633414*std::exp(0.832239866256714*x_112) + 0.00160964693703362*std::exp(0.840879857540131*x_112) + 0.000581938757235768*std::exp(0.667279839515686*x_114) + 0.00374283113593249*std::exp(0.739199817180634*x_114) + 0.0015184115421859*std::exp(1.27807986736298*x_23) - 0.000280556803780015*std::exp(1.61607992649078*x_23) + 0.0113713134909133*std::exp(0.619119822978973*x_26) + 0.00256256658603577*std::exp(0.657599866390228*x_26) - 0.00124035898128953*std::exp(0.88647985458374*x_26) - 0.000682124184331046*std::exp(0.919839859008789*x_26) - 0.000239152854588762*std::exp(1.32983994483948*x_26) - 7.64800240156331e-5*std::exp(1.48503994941711*x_26) - 0.00320840176595705*std::exp(0.493599832057953*x_31) + 0.000151888961041629*std::exp(0.610639870166779*x_31) + 0.0116386510640011*std::exp(0.643439829349518*x_31) - 0.0169844969088619*std::exp(0.645119845867157*x_31) - 0.0208317412119604*std::exp(0.645279824733734*x_31) - 0.0174680211282946*std::exp(0.650719821453094*x_31) - 0.00231272176219084*std::exp(0.652079820632935*x_31) + 0.00617146770831066*std::exp(0.660639822483063*x_31) - 0.00116955044435318*std::exp(0.66271984577179*x_31) - 0.00170158002340864*std::exp(0.662879824638367*x_31) + 0.00549503323538818*std::exp(0.51231986284256*x_45) - 0.00538172511944562*std::exp(0.891679883003235*x_45) - 0.00406283295658991*std::exp(0.86599987745285*x_49) + 0.00282477273948866*std::exp(0.91407984495163*x_50) + 0.00310106414046773*std::exp(0.959999799728394*x_50) + 6.07562650312871e-5*std::exp(1.3595198392868*x_50) + 0.00238735289107596*std::exp(0.910159826278687*x_52) + 0.00186421479839227*std::exp(0.954559803009033*x_6) - 0.000790284993550566*std::exp(1.37487983703613*x_60) - 0.00391650191328967*std::exp(0.692239880561829*x_66) - 0.00528048086284326*std::exp(0.945199847221375*x_66) + 9.42324317632242e-5*std::exp(1.67783987522125*x_66) + 0.00476202212023025*std::exp(0.66951984167099*x_68) - 0.00212179419109577*std::exp(1.33463990688324*x_68) + 0.00281831282857488*std::exp(0.661919832229614*x_70) + 0.00838270272996701*std::exp(0.710639834403992*x_70) - 0.00245771385887008*std::exp(0.77295982837677*x_70) + 0.00841944349672084*std::exp(0.801199853420258*x_72) + 0.00188601182927196*std::exp(0.824319899082184*x_72) + 0.00202129233452549*std::exp(0.90671980381012*x_72) + 0.0113364483137267*std::exp(0.693759858608246*x_74) - 0.00414281067838823*std::exp(1.17047989368439*x_74) + 0.000962612252241925*std::exp(1.25959992408752*x_74) - 0.000669442218980751*std::exp(1.45263981819153*x_74) - 0.000133502847391015*std::exp(1.60871982574463*x_74) - 0.000723000158016702*std::exp(0.611519813537598*x_78) - 0.00782705092735016*std::exp(0.926559805870056*x_78) + 0.00203554372293122*std::exp(1.16831982135773*x_81) + 0.000696235243219559*std::exp(1.27199983596802*x_81) + 0.000157079246726875*std::exp(2.01087975502014*x_81) - 0.00228797726861272*std::exp(0.700319886207581*x_87) - 0.000725062198041274*std::exp(0.611999809741974*x_90) - 0.0158440506612877*std::sin(0.364159852266312*x_100 + 5.18175983428955) + 0.0539237483774701*std::sin(0.235039994120598*x_102 - 1.34447979927063) + 0.111470094643667*std::sin(0.323359847068787*x_102 + 1.94719982147217) + 0.0043331434016457*std::sin(0.375599831342697*x_102 + 1.9761598110199) + 0.0189027776884518*std::sin(0.377599835395813*x_102 + 5.17960023880005) + 0.00939570934269516*std::sin(0.442639857530594*x_102 + 8.43080043792725) - 0.0312528617094104*std::sin(0.459279865026474*x_102 + 5.24032020568848) + 0.0139222250524465*std::sin(0.521439850330353*x_103 + 8.35359954833984) + 0.0376377370175629*std::sin(0.325759828090668*x_105 + 1.9398398399353) - 0.0873458004816246*std::sin(0.326879858970642*x_105 - 7.46807956695557) + 0.0408082857298269*std::sin(0.267679959535599*x_106 - 7.52112007141113) - 0.0285429494997753*std::sin(0.526319861412048*x_106 - 4.0403995513916) - 0.0288792572185504*std::sin(0.272559970617294*x_107 - 7.52992010116577) - 0.0217483990577372*std::sin(0.584239840507507*x_107 + 2.17967987060547) - 0.00190514251247607*std::sin(0.444399863481522*x_108 + 2.046719789505) + 0.0112142774356869*std::sin(0.472879856824875*x_109 - 7.34272003173828) - 0.000485351454016361*std::sin(0.535279810428619*x_109 + 8.36967945098877) + 0.00153152344784099*std::sin(0.611279845237732*x_110 - 0.978959858417511) - 0.0643525453587684*std::sin(0.230719983577728*x_111 - 7.57328033447266) + 0.026678329589832*std::sin(0.247679978609085*x_111 + 5.05423974990845) - 0.0308845027573586*std::sin(0.29775995016098*x_111 - 4.2792797088623) + 0.0213644874883263*std::sin(0.326159834861755*x_111 - 7.47175979614258) + 0.00259296284484395*std::sin(0.414799869060516*x_111 - 1.16295981407166) - 0.0428859287991648*std::sin(0.453359842300415*x_111 + 8.24512004852295) - 0.0232716373536621*std::sin(0.455839842557907*x_111 - 4.36560010910034) - 0.00283322566538799*std::sin(0.535999834537506*x_112 - 0.999279797077179) + 0.0328451211632841*std::sin(0.5933598279953*x_112 - 1.00103986263275) + 0.00867643978433542*std::sin(0.337679862976074*x_115 + 5.1374397277832) + 0.02593606738075*std::sin(0.342799842357635*x_115 - 7.43576002120972) - 0.0392157191184108*std::sin(0.493279844522476*x_115 - 4.12056016921997) - 0.0675816003862198*std::sin(0.301039934158325*x_116 + 1.90431988239288) + 0.0333027321034386*std::sin(0.396719843149185*x_117 + 1.99855983257294) - 0.0313588009195839*std::sin(0.550879836082458*x_117 + 8.3601598739624) + 0.0226895869683366*std::sin(0.597839832305908*x_117 + 5.40000009536743) + 0.0121526095935329*std::sin(0.294559925794601*x_119 - 4.29423999786377) + 0.0822778458884744*std::sin(0.300399929285049*x_119 + 8.296799659729) - 0.00426087579918613*std::sin(0.36575984954834*x_119 + 5.16232013702393) + 0.0150478067059459*std::sin(0.45279985666275*x_119 - 1.16775989532471) + 0.0468815297298729*std::sin(0.29615992307663*x_120 - 7.47679996490479) + 0.0488077682603257*std::sin(0.304079920053482*x_120 - 7.47528028488159) + 0.0631885736799636*std::sin(0.405039846897125*x_120 + 5.21120023727417) + 0.00369473588388523*std::sin(0.449199855327606*x_120 - 4.16680002212524) - 0.178724213126613*std::sin(0.183280006051064*x_15 + 1.78319990634918) + 0.0558558972320715*std::sin(0.346639841794968*x_16 - 7.43271970748901) + 0.00310177312271825*std::sin(0.375999838113785*x_16 + 5.18239974975586) + 0.0272047141402832*std::sin(0.387439846992493*x_16 - 7.39447975158691) + 0.00673905065968889*std::sin(0.274959951639175*x_18 - 7.52424001693726) - 0.0856204961146283*std::sin(0.25655996799469*x_20 - 7.54432010650635) - 0.0352931095985094*std::sin(0.343279838562012*x_20 - 7.44608020782471) + 0.202446047195852*std::sin(0.234959989786148*x_21 + 5.042799949646) - 0.0343942878312826*std::sin(0.420959860086441*x_21 + 8.42536067962646) - 0.00250599355308501*std::sin(0.457599848508835*x_22 - 7.32376003265381) + 0.0686354718068081*std::sin(0.266079962253571*x_24 + 5.06623983383179) + 0.00608682920451855*std::sin(0.305119842290878*x_24 + 5.10567998886108) + 0.102478654078239*std::sin(0.306879937648773*x_24 + 5.1399998664856) + 0.022193430005083*std::sin(0.313759922981262*x_24 - 7.46903991699219) + 0.0133066760140288*std::sin(0.351119846105576*x_24 - 4.26471996307373) - 0.0374129445871603*std::sin(0.404879868030548*x_24 + 8.39160060882568) - 0.00191941737256986*std::sin(0.788399875164032*x_25 - 4.00871992111206) - 0.111334948438099*std::sin(0.290719836950302*x_27 - 4.32800006866455) + 0.0670917372506672*std::sin(0.317679852247238*x_28 + 5.11696004867554) + 0.0196509070968632*std::sin(0.320399850606918*x_28 - 4.27432012557983) + 0.0288797384027983*std::sin(0.324319839477539*x_28 + 8.30976009368896) - 0.00530939799654671*std::sin(0.330559849739075*x_28 + 5.13048028945923) + 0.00831747465257919*std::sin(0.338479846715927*x_28 + 8.32632064819336) + 0.020787050501744*std::sin(0.33943983912468*x_28 + 8.31999969482422) + 0.0278932121123893*std::sin(0.291439920663834*x_3 + 5.0874400138855) + 0.0870065271775321*std::sin(0.303439915180206*x_3 - 7.50208044052124) - 0.0826358248381217*std::sin(0.271119952201843*x_33 - 1.1729599237442) - 0.0989175900564153*std::sin(0.34895983338356*x_34 - 7.40207958221436) - 0.00604413571233994*std::sin(0.355359852313995*x_34 - 7.41152000427246) + 0.0200242214061536*std::sin(0.369519829750061*x_34 + 8.19623947143555) + 0.0773049896215246*std::sin(0.31007993221283*x_35 + 8.25119972229004) + 0.0231666803151688*std::sin(0.314959853887558*x_35 + 1.97399973869324) - 0.0233159364120916*std::sin(0.331679850816727*x_35 - 7.42903995513916) - 0.0165662526247138*std::sin(0.326639831066132*x_36 - 7.46719980239868) - 0.00371399600592149*std::sin(0.332639843225479*x_36 - 4.26639986038208) + 0.033177721408239*std::sin(0.365359842777252*x_36 + 5.18416023254395) - 0.00343816316616819*std::sin(0.418479859828949*x_36 + 5.22432041168213) - 0.0392110647838462*std::sin(0.29367995262146*x_37 - 1.33159983158112) - 0.010138367659962*std::sin(0.428959846496582*x_37 - 1.1684798002243) + 0.022678103989646*std::sin(0.47775986790657*x_38 - 7.32087993621826) + 0.00355118780409477*std::sin(0.479759842157364*x_38 + 5.2579197883606) + 0.0127037780610691*std::sin(0.635359883308411*x_38 - 0.950879812240601) - 0.0158269971727553*std::sin(0.317439913749695*x_41 + 1.91527986526489) - 0.0332809738094231*std::sin(0.387199848890305*x_41 + 1.97423982620239) + 0.00967737509481735*std::sin(0.355519831180573*x_43 + 8.34455966949463) + 0.01276559498214*std::sin(0.401679843664169*x_43 + 1.97855985164642) - 0.0374671637502823*std::sin(0.352319836616516*x_44 + 5.15360021591187) - 0.171745815078244*std::sin(0.182240009307861*x_46 + 4.96335983276367) + 0.0227601809406332*std::sin(0.265519976615906*x_48 - 7.5195198059082) - 0.0285185199267527*std::sin(0.220799997448921*x_51 + 5.01679992675781) - 0.0410113109922138*std::sin(0.186400011181831*x_53 - 4.42840003967285) + 0.00560468769113148*std::sin(0.354639858007431*x_53 - 4.25040006637573) - 0.102165329050595*std::sin(0.280239939689636*x_54 - 1.33415985107422) - 0.00805656089342952*std::sin(0.53823983669281*x_54 - 1.03471982479095) - 0.0146547792954999*std::sin(0.356959849596024*x_55 - 7.43415975570679) + 0.0104402992778423*std::sin(0.487919867038727*x_55 + 2.06407976150513) - 0.0252014491856677*std::sin(0.239359974861145*x_56 + 1.83567988872528) - 0.0279146810589497*std::sin(0.395439833402634*x_56 + 5.18455982208252) + 0.0630888155153375*std::sin(0.139120042324066*x_58 - 7.6723198890686) - 0.207584303149558*std::sin(0.184960007667542*x_58 - 7.6159200668335) + 0.0272502021039659*std::sin(0.255359977483749*x_58 + 5.05471992492676) + 0.0481531243328627*std::sin(0.277119934558868*x_58 + 5.09000015258789) - 0.0535609562794171*std::sin(0.386319845914841*x_58 + 5.19648027420044) - 0.0171110828590405*std::sin(0.490319848060608*x_58 - 4.12143993377686) + 0.000666656739615703*std::sin(0.605599880218506*x_58 - 0.993359804153442) + 0.0316472541091607*std::sin(0.298159927129745*x_59 + 5.10799980163574) - 0.00528560762021918*std::sin(0.362959831953049*x_59 - 4.22071981430054) + 0.286913391402198*std::sin(0.125840052962303*x_63 - 1.45423996448517) + 0.100875954501658*std::sin(0.164000019431114*x_64 - 1.42503988742828) - 0.181601545458403*std::sin(0.179200008511543*x_64 - 4.42479991912842) + 0.0320591351646141*std::sin(0.281999945640564*x_64 + 5.10519981384277) - 0.0273645999542269*std::sin(0.417919874191284*x_64 + 1.99703979492188) - 0.0829095723402302*std::sin(0.398639857769012*x_65 - 7.40407991409302) - 0.0107206580168291*std::sin(0.440159857273102*x_66 - 4.15623998641968) + 0.0358188251221213*std::sin(0.243359968066216*x_69 - 7.54400014877319) - 0.0608663271588532*std::sin(0.254959970712662*x_70 - 7.52400016784668) + 0.0350686585177197*std::sin(0.515119850635529*x_70 + 5.33439970016479) + 0.0172637597931166*std::sin(0.514559864997864*x_72 - 4.07624006271362) + 0.0344584110057229*std::sin(0.245599970221519*x_73 + 1.86039984226227) - 0.0585437454895106*std::sin(0.42799985408783*x_73 - 4.17216014862061) + 0.0075485313230435*std::sin(0.225519984960556*x_74 + 1.8199999332428) + 0.0123568434610294*std::sin(0.199359983205795*x_75 - 7.59999990463257) + 0.0657200303202287*std::sin(0.382159858942032*x_75 - 7.40551996231079) + 0.025320630400696*std::sin(0.527119874954224*x_75 - 7.25256013870239) + 0.0386466843870122*std::sin(0.262239962816238*x_76 - 7.52232027053833) - 0.0270277281707665*std::sin(0.289119929075241*x_77 - 7.48000001907349) - 0.0181058339388019*std::sin(0.231439992785454*x_79 + 1.83111989498138) + 0.0246576676869983*std::sin(0.367839843034744*x_79 + 8.36952018737793) + 0.0627605161010825*std::sin(0.375919848680496*x_79 - 7.42759990692139) + 0.0547943128578814*std::sin(0.465919852256775*x_81 + 8.46975994110107) + 0.0356078434150624*std::sin(0.263439983129501*x_82 + 1.86799991130829) + 0.0209706850557695*std::sin(0.397759824991226*x_82 - 7.40991973876953) + 0.238568446287628*std::sin(0.158560022711754*x_84 - 7.65680027008057) - 0.0316530868868151*std::sin(0.353839844465256*x_84 + 5.14383983612061) + 0.0451805017750733*std::sin(0.174960017204285*x_85 - 4.43856000900269) - 0.00621531193124069*std::sin(0.212719991803169*x_85 - 7.58776044845581) - 0.0367364262914732*std::sin(0.21399998664856*x_85 - 7.5816798210144) - 0.0109562098456383*std::sin(0.631679832935333*x_86 - 7.16951990127563) - 0.00249895232479095*std::sin(0.51615983247757*x_87 + 5.32791996002197) - 0.00258241634435496*std::sin(0.797919869422913*x_87 - 0.793519854545593) + 0.0100900910654139*std::sin(0.988159835338593*x_87 + 5.58551979064941) + 0.0104916236188179*std::sin(0.225519984960556*x_89 + 1.8122398853302) + 0.0221858251217153*std::sin(0.321119844913483*x_90 + 8.31783962249756) - 0.0280627114771496*std::sin(0.351999849081039*x_92 - 7.39856004714966) + 0.0751670854746478*std::sin(0.353839844465256*x_92 + 1.99631977081299) - 0.0593161018332132*std::sin(0.359439849853516*x_92 - 1.18815994262695) - 0.00538967800640703*std::sin(0.373199850320816*x_92 - 7.38935995101929) - 0.00403936465601961*std::sin(0.381119847297668*x_92 + 8.18279933929443) + 0.00786656842911929*std::sin(0.38487982749939*x_92 - 1.19791984558105) + 0.0561288347642787*std::sin(0.353119850158691*x_95 - 1.21815991401672) - 0.0374408493439813*std::sin(0.364959836006165*x_95 + 5.16431999206543) + 0.0495968259910526*std::sin(0.38919985294342*x_95 + 1.98527979850769) + 0.0236651597677406*std::sin(0.386959850788116*x_96 + 5.19655990600586) - 0.0461187826570512*std::sin(0.415279865264893*x_96 - 7.3996000289917) - 0.00839056167339948*std::sin(0.439519852399826*x_96 + 8.20975971221924) - 0.00758302176575919*std::sin(0.305199921131134*x_97 + 5.11439990997314) + 0.0268616757923201*std::sin(0.353279858827591*x_97 + 5.16728019714355) + 0.0219071325514569*std::sin(0.37255984544754*x_98 + 5.18039989471436) - 0.003322802464249*std::sin(0.415599852800369*x_98 - 7.38839960098267) + 0.00734973497697398*std::sin(0.436959862709045*x_98 - 7.37871980667114) - 0.0133422201175292*std::sin(0.451919853687286*x_98 + 2.00551986694336) + 0.00490412062651292*std::sin(0.406159847974777*x_99 - 4.20160007476807) - 0.0591270015027857*std::sin(0.407679855823517*x_99 + 5.20464038848877) + 0.0452737070983695*std::sin(0.443759858608246*x_99 + 5.22552013397217) + 0.00171182397190839*std::sin(0.681439816951752*x_99 + 8.60767936706543) + 0.73127720610756 - 0.000231683886813958*std::exp(-2.08247995376587*x_54));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0220721966735338*x_1 + 0.0265323030925592*x_10 - 0.00611781390036122*x_100 - 0.01753701187876*x_101 - 0.00304880242952647*x_102 - 0.000393517304473041*x_103 - 0.00762222232903358*x_104 - 0.0128444753983662*x_105 - 0.00738183260875004*x_106 - 0.00944408361458692*x_107 + 0.00534832281254819*x_108 + 0.00107093262349571*x_109 - 0.00649222928369926*x_11 - 0.00478121949789543*x_110 - 0.00518969815134339*x_111 + 0.00209597437263372*x_112 + 0.00455150253816203*x_113 + 0.00547565459046345*x_114 + 0.00277505966595644*x_115 + 0.00837096960325378*x_116 - 0.00308227473442078*x_117 - 0.00879650442861396*x_118 - 0.000315929478205107*x_119 - 0.027164917763782*x_12 - 0.0107072489856865*x_120 + 0.0157264758631517*x_13 + 0.000178598607345153*x_14 - 0.00712652063533997*x_15 - 0.00190373327982279*x_16 + 0.0031830969489435*x_17 + 0.00219321305361279*x_18 - 0.023814044036498*x_19 + 0.0440820046285979*x_2 + 0.00739563952950962*x_20 - 0.00578104985388263*x_21 - 0.00129763908644616*x_22 + 0.00308534119020176*x_23 + 0.00156364077325864*x_24 + 0.0124011856292192*x_25 - 0.00266197090216593*x_26 - 0.0127736579879557*x_27 - 0.00232539405965646*x_28 - 0.0167932635596679*x_29 + 0.00397233349635899*x_3 - 0.0163747524307937*x_30 + 0.0313416330362273*x_32 - 0.00707001521695613*x_33 + 0.0159115188969182*x_34 - 0.0152723220243137*x_35 - 0.00519299045262868*x_36 - 0.0156237918003029*x_37 - 0.000126060648620883*x_38 - 0.00607170100854332*x_39 + 0.00195776169301833*x_4 + 0.00866431906230905*x_40 + 0.00300047185236569*x_41 - 0.00224900101410715*x_42 - 0.0191610556904826*x_43 + 0.00417849582785347*x_44 - 0.00609747305542843*x_45 + 0.000796440234705154*x_46 - 0.0331265917140824*x_47 + 0.00866919455797817*x_48 + 0.0101471782569092*x_49 + 0.00299723351080519*x_5 + 0.00911771883857328*x_50 + 0.0161901723577245*x_51 + 0.0133761694108114*x_52 - 0.00990277853352269*x_53 - 0.00405333207351356*x_54 + 0.00910498840960903*x_55 + 0.00566364963032072*x_56 + 0.00273854390414305*x_57 + 0.0025161386728548*x_58 - 0.00336441932917732*x_59 + 0.00853963080335693*x_6 + 0.0157569251210871*x_60 + 0.00250387380322922*x_61 + 0.0023164142457588*x_62 - 0.033720524697928*x_63 + 0.00622350322592145*x_64 - 0.00755512748645419*x_65 - 0.0058495444557767*x_66 + 0.000672954073860536*x_67 + 0.013589074580963*x_68 - 0.00383941827291515*x_69 + 0.0260929330283847*x_7 + 0.00382435758174655*x_70 - 0.00191859934974676*x_71 + 0.0158453999756054*x_72 - 0.00674378670739102*x_73 - 0.000559653071874966*x_74 + 0.00060297923889909*x_75 - 0.00698345711329335*x_76 - 0.00862329748264898*x_77 + 0.000394049890306323*x_78 - 0.000464470925478554*x_79 - 0.0263538700443962*x_8 - 0.0112985552030124*x_80 - 0.0046093526263456*x_81 + 0.00936473499948028*x_82 + 0.0104262795685906*x_83 + 0.00203683875964813*x_84 + 0.0146132749590418*x_85 + 0.00867230209870755*x_86 - 0.00238717393444674*x_87 + 0.00217496265103714*x_88 - 0.00687217732475287*x_89 - 0.0126359261261717*x_9 + 0.00826624660017149*x_90 - 0.0305471913761898*x_91 - 0.00179238438963522*x_92 - 0.0366131273176047*x_93 - 0.0090149714592563*x_94 - 0.0143183702309344*x_95 - 0.0171611547519029*x_96 - 0.0291651983131388*x_97 + 0.00297933938222421*x_98 - 0.00773160519518463*x_99 - 9.97226427871478e-6*std::pow(-8.29967975616455*x_104 - 9.30575942993164, 2) - 0.000103263034157333*std::pow(-5.02359962463379*x_104 - 6.63000011444092, 2) + 3.50281698506516e-5*std::pow(-7.76968002319336*x_106 - 8.38871955871582, 2) + 3.33095829026794e-5*std::pow(-6.33696031570435*x_106 - 6.55055999755859, 2) - 6.54439719373823e-5*std::pow(-4.04055976867676*x_107 - 6.8732795715332, 2) - 3.39200172398576e-5*std::pow(-5.1199197769165*x_112 - 7.47016000747681, 2) + 5.91463695388606e-5*std::pow(-5.11528015136719*x_114 - 6.48727989196777, 2) + 0.00215797804732181*std::pow(-1.28807985782623*x_114 - 1.71615982055664, 2) + 1.0975094122345e-5*std::pow(-9.0*x_115 - 9.99927997589111, 2) - 3.16417697771296e-5*std::pow(-8.35487937927246*x_115 - 9.57288074493408, 2) - 3.6289670286778e-5*std::pow(-8.12743949890137*x_115 - 9.94367980957031, 2) - 2.18995188154754e-5*std::pow(-7.13303995132446*x_115 - 8.96848011016846, 2) - 2.76413950065041e-5*std::pow(-7.52023983001709*x_12 - 5.48464012145996, 2) - 0.000116945411214022*std::pow(-5.54967975616455*x_120 - 6.57407999038696, 2) - 2.87119543018154e-5*std::pow(-7.13495969772339*x_14 - 9.12439918518066, 2) + 1.03246770147162e-5*std::pow(-7.84424018859863*x_15 - 8.04736042022705, 2) + 9.95711629221058e-5*std::pow(-6.59600019454956*x_15 - 9.96271991729736, 2) + 6.78100176537079e-5*std::pow(-4.43039989471436*x_15 - 5.83872032165527, 2) - 1.00959970323954e-5*std::pow(-6.48343992233276*x_19 - 8.70903968811035, 2) + 0.000216315403339299*std::pow(-4.24728012084961*x_21 - 5.46327972412109, 2) + 1.57186789350774e-5*std::pow(-3.86207985877991*x_24 - 5.49304008483887, 2) - 1.72533360447724e-5*std::pow(-8.15999984741211*x_45 - 9.98680019378662, 2) - 4.9837107804134e-5*std::pow(-5.56400012969971*x_47 - 6.5978798866272, 2) - 1.92504457840925e-5*std::pow(-8.39575958251953*x_48 - 7.98016023635864, 2) - 1.83653726473483e-5*std::pow(-7.48736000061035*x_55 - 8.30447959899902, 2) + 6.32364748828413e-5*std::pow(-5.89743947982788*x_55 - 7.46456003189087, 2) - 1.47361700222007e-5*std::pow(-4.72551965713501*x_55 - 7.19879961013794, 2) + 4.33305093813825e-5*std::pow(-8.09127998352051*x_59 - 9.45944023132324, 2) - 6.90491668840968e-5*std::pow(-3.35439991950989*x_60 - 4.39711999893188, 2) - 2.40354660550915e-5*std::pow(-7.65072011947632*x_66 - 9.26943969726563, 2) - 8.32651497306734e-6*std::pow(-8.26799964904785*x_67 - 7.86800003051758, 2) + 2.40604486558285e-5*std::pow(-7.10328006744385*x_67 - 8.67744064331055, 2) + 5.72902422999801e-5*std::pow(-5.22671985626221*x_7 - 8.03615951538086, 2) - 9.72332190936403e-6*std::pow(-6.26759958267212*x_70 - 9.014479637146, 2) + 4.75154780058808e-5*std::pow(-5.07919979095459*x_71 - 7.71488046646118, 2) - 0.000167467165878412*std::pow(-3.47183990478516*x_78 - 4.69567966461182, 2) + 3.51308742502573e-5*std::pow(-6.55936002731323*x_79 - 9.14999961853027, 2) + 2.58997220253217e-5*std::pow(-7.44632005691528*x_82 - 8.2236795425415, 2) + 9.19695104882387e-6*std::pow(-9.99993991851807*x_84 - 8.60000038146973, 2) + 5.85247821112472e-5*std::pow(-8.00255966186523*x_84 - 8.5984001159668, 2) + 2.21100776336182e-5*std::pow(-7.19600009918213*x_87 - 9.9973201751709, 2) + 1.9392113080954e-5*std::pow(-4.31935977935791*x_87 - 6.28535985946655, 2) - 8.41754443705684e-5*std::pow(-4.3907995223999*x_90 - 5.78359985351563, 2) - 0.000502235529668333*std::exp(0.380719840526581*x_1) + 0.000678137384602307*std::exp(0.815199851989746*x_1) + 0.000544978208466087*std::exp(1.00071978569031*x_1) + 7.97436680702999e-5*std::exp(1.15455985069275*x_1) + 6.7798234941993e-5*std::exp(1.16367983818054*x_1) + 3.31271200648645e-5*std::exp(1.20775985717773*x_1) - 3.34612141509175e-6*std::exp(1.34047985076904*x_1) - 1.32693533202652e-5*std::exp(1.38623988628387*x_1) + 0.000169012935436685*std::exp(1.20671987533569*x_100) + 0.000554772257928169*std::exp(1.51599979400635*x_100) - 0.000732761917109696*std::exp(1.56199979782104*x_100) + 0.00101946906282782*std::exp(0.623199820518494*x_104) - 0.00281918591709291*std::exp(0.879519879817963*x_104) - 0.00813723786415193*std::exp(0.884399890899658*x_104) + 0.00804062867146133*std::exp(0.60591983795166*x_106) - 0.00168826386671736*std::exp(0.726879835128784*x_106) - 0.00389466597547039*std::exp(1.03599977493286*x_106) + 0.0184772315870581*std::exp(0.550239861011505*x_109) + 0.00102703772823992*std::exp(0.644079864025116*x_109) - 0.00744514242437426*std::exp(0.68751984834671*x_109) + 0.000578128773555922*std::exp(0.815999865531921*x_109) + 0.00117939944936032*std::exp(0.963039815425873*x_109) - 0.00185520969701746*std::exp(1.03647983074188*x_109) + 0.0144240784630796*std::exp(0.64031982421875*x_110) - 0.00139494915607922*std::exp(0.954399824142456*x_110) - 0.0016846544732398*std::exp(1.00471985340118*x_110) - 0.000307336084590432*std::exp(1.11807978153229*x_110) + 0.000953718119693363*std::exp(1.24599981307983*x_110) + 0.00062773036554607*std::exp(1.35839986801147*x_110) + 0.000417652795951357*std::exp(0.422239869832993*x_112) - 0.00112432436691926*std::exp(0.832239866256714*x_112) - 0.000857104783744187*std::exp(0.840879857540131*x_112) + 0.00397984522575968*std::exp(0.667279839515686*x_114) + 0.00338931778234639*std::exp(0.739199817180634*x_114) + 0.00137499637412001*std::exp(1.27807986736298*x_23) + 0.000225192397161801*std::exp(1.61607992649078*x_23) - 0.0169840072231112*std::exp(0.619119822978973*x_26) + 0.00213731262536365*std::exp(0.657599866390228*x_26) - 0.00210882024672096*std::exp(0.88647985458374*x_26) + 0.000855172048923497*std::exp(0.919839859008789*x_26) - 0.000216564678800195*std::exp(1.32983994483948*x_26) + 4.07240823664552e-5*std::exp(1.48503994941711*x_26) + 0.00402234017645045*std::exp(0.493599832057953*x_31) + 0.00103875974736328*std::exp(0.610639870166779*x_31) + 0.0105393712890325*std::exp(0.643439829349518*x_31) + 0.0090439047316187*std::exp(0.645119845867157*x_31) + 0.0311139468186012*std::exp(0.645279824733734*x_31) + 0.00143813486648029*std::exp(0.650719821453094*x_31) - 0.00393201851295483*std::exp(0.652079820632935*x_31) - 0.00495360507575088*std::exp(0.660639822483063*x_31) + 0.000714046350191822*std::exp(0.66271984577179*x_31) - 0.00141920545086163*std::exp(0.662879824638367*x_31) - 0.00688906644677625*std::exp(0.51231986284256*x_45) + 0.00286566093380313*std::exp(0.891679883003235*x_45) + 0.00216337724909051*std::exp(0.86599987745285*x_49) - 0.0015041349579851*std::exp(0.91407984495163*x_50) + 0.00258644734369124*std::exp(0.959999799728394*x_50) + 0.000415508553629113*std::exp(1.3595198392868*x_50) - 0.00191623839867414*std::exp(0.910159826278687*x_52) + 0.00316948074741984*std::exp(0.954559803009033*x_6) - 0.00134361827520815*std::exp(1.37487983703613*x_60) + 0.0031436288211853*std::exp(0.692239880561829*x_66) + 0.000434739778756966*std::exp(0.945199847221375*x_66) - 0.000118138227022443*std::exp(1.67783987522125*x_66) - 0.00382229609884286*std::exp(0.66951984167099*x_68) + 0.00266007147594805*std::exp(1.33463990688324*x_68) - 0.00226215373595528*std::exp(0.661919832229614*x_70) - 0.00446362145962331*std::exp(0.710639834403992*x_70) - 0.00204986004606434*std::exp(0.77295982837677*x_70) - 0.000693169258272879*std::exp(0.801199853420258*x_72) + 0.00320653938990228*std::exp(0.824319899082184*x_72) - 0.0012340608488562*std::exp(0.90671980381012*x_72) + 0.0102657118269355*std::exp(0.693759858608246*x_74) + 0.00618763404438308*std::exp(1.17047989368439*x_74) - 0.000587704248826491*std::exp(1.25959992408752*x_74) + 5.51148976257359e-5*std::exp(1.45263981819153*x_74) + 0.000107157715752571*std::exp(1.60871982574463*x_74) - 0.000603019400272254*std::exp(0.611519813537598*x_78) + 0.000644397826042593*std::exp(0.926559805870056*x_78) - 0.000167585462525615*std::exp(1.16831982135773*x_81) + 0.00118371777810297*std::exp(1.27199983596802*x_81) - 0.000234610985190228*std::exp(2.01087975502014*x_81) - 0.00190829098037835*std::exp(0.700319886207581*x_87) - 0.00495865809137763*std::exp(0.611999809741974*x_90) - 0.0143475675766282*std::sin(0.364159852266312*x_100 + 5.18175983428955) - 0.0676036467330651*std::sin(0.235039994120598*x_102 - 1.34447979927063) - 0.0593555947986803*std::sin(0.323359847068787*x_102 + 1.94719982147217) + 0.0296341150424269*std::sin(0.375599831342697*x_102 + 1.9761598110199) - 0.0151725488860958*std::sin(0.377599835395813*x_102 + 5.17960023880005) - 0.00573636818831279*std::sin(0.442639857530594*x_102 + 8.43080043792725) + 0.0466787613796486*std::sin(0.459279865026474*x_102 + 5.24032020568848) - 0.0111748465592188*std::sin(0.521439850330353*x_103 + 8.35359954833984) + 0.0313918127849307*std::sin(0.325759828090668*x_105 + 1.9398398399353) - 0.0790959207172176*std::sin(0.326879858970642*x_105 - 7.46807956695557) - 0.0249147077183859*std::sin(0.267679959535599*x_106 - 7.52112007141113) + 0.0426312809738698*std::sin(0.526319861412048*x_106 - 4.0403995513916) + 0.0362056266795412*std::sin(0.272559970617294*x_107 - 7.52992010116577) + 0.00179053658942491*std::sin(0.584239840507507*x_107 + 2.17967987060547) - 0.0130291585470013*std::sin(0.444399863481522*x_108 + 2.046719789505) + 0.00935328544367813*std::sin(0.472879856824875*x_109 - 7.34272003173828) - 0.0033192902914008*std::sin(0.535279810428619*x_109 + 8.36967945098877) + 0.0104739995510551*std::sin(0.611279845237732*x_110 - 0.978959858417511) + 0.0961159057018601*std::sin(0.230719983577728*x_111 - 7.57328033447266) - 0.0162879369289362*std::sin(0.247679978609085*x_111 + 5.05423974990845) + 0.024789829073378*std::sin(0.29775995016098*x_111 - 4.2792797088623) - 0.0267844374371655*std::sin(0.326159834861755*x_111 - 7.47175979614258) + 0.0177331216907478*std::sin(0.414799869060516*x_111 - 1.16295981407166) - 0.038835318990483*std::sin(0.453359842300415*x_111 + 8.24512004852295) + 0.0123916812081426*std::sin(0.455839842557907*x_111 - 4.36560010910034) - 0.0193762651098454*std::sin(0.535999834537506*x_112 - 0.999279797077179) + 0.0297428735572131*std::sin(0.5933598279953*x_112 - 1.00103986263275) + 0.0147514164549681*std::sin(0.337679862976074*x_115 + 5.1374397277832) - 0.0158347631271227*std::sin(0.342799842357635*x_115 - 7.43576002120972) + 0.0208815856949978*std::sin(0.493279844522476*x_115 - 4.12056016921997) - 0.061198464913212*std::sin(0.301039934158325*x_116 + 1.90431988239288) - 0.0417512914830568*std::sin(0.396719843149185*x_117 + 1.99855983257294) + 0.00258175695130217*std::sin(0.550879836082458*x_117 + 8.3601598739624) + 0.0205465375788904*std::sin(0.597839832305908*x_117 + 5.40000009536743) + 0.0101359028315258*std::sin(0.294559925794601*x_119 - 4.29423999786377) + 0.0745066384336052*std::sin(0.300399929285049*x_119 + 8.296799659729) - 0.0291398811233939*std::sin(0.36575984954834*x_119 + 5.16232013702393) - 0.0188652799418753*std::sin(0.45279985666275*x_119 - 1.16775989532471) - 0.0376300411190897*std::sin(0.29615992307663*x_120 - 7.47679996490479) + 0.0407081946229517*std::sin(0.304079920053482*x_120 - 7.47528028488159) - 0.033646651034467*std::sin(0.405039846897125*x_120 + 5.21120023727417) + 0.0252680832563386*std::sin(0.449199855327606*x_120 - 4.16680002212524) + 0.095167067086176*std::sin(0.183280006051064*x_15 + 1.78319990634918) - 0.0297421475582458*std::sin(0.346639841794968*x_16 - 7.43271970748901) + 0.0212128455105433*std::sin(0.375999838113785*x_16 + 5.18239974975586) + 0.024635207427369*std::sin(0.387439846992493*x_16 - 7.39447975158691) + 0.0460879744829393*std::sin(0.274959951639175*x_18 - 7.52424001693726) + 0.00704909959997331*std::sin(0.25655996799469*x_20 - 7.54432010650635) + 0.0442466072036982*std::sin(0.343279838562012*x_20 - 7.44608020782471) - 0.107798469036594*std::sin(0.234959989786148*x_21 + 5.042799949646) - 0.0311457202112494*std::sin(0.420959860086441*x_21 + 8.42536067962646) - 0.0171383437759057*std::sin(0.457599848508835*x_22 - 7.32376003265381) + 0.0572455214392755*std::sin(0.266079962253571*x_24 + 5.06623983383179) + 0.041627469984446*std::sin(0.305119842290878*x_24 + 5.10567998886108) - 0.153060436023537*std::sin(0.306879937648773*x_24 + 5.1399998664856) - 0.0135497684344273*std::sin(0.313759922981262*x_24 - 7.46903991699219) + 0.0226236018912576*std::sin(0.351119846105576*x_24 - 4.26471996307373) - 0.0338792624550534*std::sin(0.404879868030548*x_24 + 8.39160060882568) - 0.0131267834827634*std::sin(0.788399875164032*x_25 - 4.00871992111206) + 0.00916615969437218*std::sin(0.290719836950302*x_27 - 4.32800006866455) + 0.0607548697372756*std::sin(0.317679852247238*x_28 + 5.11696004867554) + 0.0163898694640154*std::sin(0.320399850606918*x_28 - 4.27432012557983) - 0.0176319644018582*std::sin(0.324319839477539*x_28 + 8.30976009368896) - 0.0363106632879816*std::sin(0.330559849739075*x_28 + 5.13048028945923) - 0.0104275321179104*std::sin(0.338479846715927*x_28 + 8.32632064819336) - 0.0110686884279175*std::sin(0.33943983912468*x_28 + 8.31999969482422) + 0.0232643767130286*std::sin(0.291439920663834*x_3 + 5.0874400138855) - 0.0463292346570495*std::sin(0.303439915180206*x_3 - 7.50208044052124) + 0.0440019231223012*std::sin(0.271119952201843*x_33 - 1.1729599237442) + 0.0526716372908734*std::sin(0.34895983338356*x_34 - 7.40207958221436) - 0.0413354916810501*std::sin(0.355359852313995*x_34 - 7.41152000427246) + 0.0340445662611469*std::sin(0.369519829750061*x_34 + 8.19623947143555) - 0.00636448743169486*std::sin(0.31007993221283*x_35 + 8.25119972229004) - 0.0141439675432346*std::sin(0.314959853887558*x_35 + 1.97399973869324) - 0.0194466928341677*std::sin(0.331679850816727*x_35 - 7.42903995513916) + 0.0132971080732458*std::sin(0.326639831066132*x_36 - 7.46719980239868) - 0.00631442194693136*std::sin(0.332639843225479*x_36 - 4.26639986038208) - 0.0415945668648614*std::sin(0.365359842777252*x_36 + 5.18416023254395) - 0.0235133974015647*std::sin(0.418479859828949*x_36 + 5.22432041168213) + 0.0585650028949503*std::sin(0.29367995262146*x_37 - 1.33159983158112) + 0.00813768650730953*std::sin(0.428959846496582*x_37 - 1.1684798002243) - 0.0284313048855538*std::sin(0.47775986790657*x_38 - 7.32087993621826) + 0.0242863663094648*std::sin(0.479759842157364*x_38 + 5.2579197883606) + 0.0115038962009266*std::sin(0.635359883308411*x_38 - 0.950879812240601) + 0.00966286629214386*std::sin(0.317439913749695*x_41 + 1.91527986526489) - 0.027758047691286*std::sin(0.387199848890305*x_41 + 1.97423982620239) + 0.0164531759296387*std::sin(0.355519831180573*x_43 + 8.34455966949463) - 0.0102464630922971*std::sin(0.401679843664169*x_43 + 1.97855985164642) + 0.0469721964529132*std::sin(0.352319836616516*x_44 + 5.15360021591187) + 0.256516730996724*std::sin(0.182240009307861*x_46 + 4.96335983276367) - 0.0182687414341817*std::sin(0.265519976615906*x_48 - 7.5195198059082) + 0.0357533740603906*std::sin(0.220799997448921*x_51 + 5.01679992675781) + 0.0514154572669855*std::sin(0.186400011181831*x_53 - 4.42840003967285) + 0.0383301322898256*std::sin(0.354639858007431*x_53 - 4.25040006637573) + 0.152592458904013*std::sin(0.280239939689636*x_54 - 1.33415985107422) - 0.00671958707663316*std::sin(0.53823983669281*x_54 - 1.03471982479095) + 0.00894719139250602*std::sin(0.356959849596024*x_55 - 7.43415975570679) + 0.00945420477448094*std::sin(0.487919867038727*x_55 + 2.06407976150513) - 0.0428467299315182*std::sin(0.239359974861145*x_56 + 1.83567988872528) - 0.0252781174104598*std::sin(0.395439833402634*x_56 + 5.18455982208252) + 0.107261666587902*std::sin(0.139120042324066*x_58 - 7.6723198890686) + 0.310044508658905*std::sin(0.184960007667542*x_58 - 7.6159200668335) - 0.0166370826057764*std::sin(0.255359977483749*x_58 + 5.05471992492676) - 0.0386507022936082*std::sin(0.277119934558868*x_58 + 5.09000015258789) + 0.00440965110711291*std::sin(0.386319845914841*x_58 + 5.19648027420044) + 0.0214519879576119*std::sin(0.490319848060608*x_58 - 4.12143993377686) + 0.00455922656704089*std::sin(0.605599880218506*x_58 - 0.993359804153442) - 0.0396758358096845*std::sin(0.298159927129745*x_59 + 5.10799980163574) - 0.0361479622915814*std::sin(0.362959831953049*x_59 - 4.22071981430054) - 0.359700357244524*std::sin(0.125840052962303*x_63 - 1.45423996448517) - 0.150666670236772*std::sin(0.164000019431114*x_64 - 1.42503988742828) + 0.0966991889753053*std::sin(0.179200008511543*x_64 - 4.42479991912842) - 0.0257326623392617*std::sin(0.281999945640564*x_64 + 5.10519981384277) - 0.0228234869247523*std::sin(0.417919874191284*x_64 + 1.99703979492188) + 0.0441476881892839*std::sin(0.398639857769012*x_65 - 7.40407991409302) + 0.016012198884485*std::sin(0.440159857273102*x_66 - 4.15623998641968) - 0.0218684892730341*std::sin(0.243359968066216*x_69 - 7.54400014877319) + 0.0763074860891064*std::sin(0.254959970712662*x_70 - 7.52400016784668) + 0.0317563960543274*std::sin(0.515119850635529*x_70 + 5.33439970016479) - 0.00919260662922737*std::sin(0.514559864997864*x_72 - 4.07624006271362) - 0.0276584708416118*std::sin(0.245599970221519*x_73 + 1.86039984226227) + 0.00481988205672803*std::sin(0.42799985408783*x_73 - 4.17216014862061) + 0.0516239655358455*std::sin(0.225519984960556*x_74 + 1.8199999332428) + 0.0845077318572776*std::sin(0.199359983205795*x_75 - 7.59999990463257) + 0.0595127216085852*std::sin(0.382159858942032*x_75 - 7.40551996231079) - 0.0134827290038212*std::sin(0.527119874954224*x_75 - 7.25256013870239) - 0.0310202404012658*std::sin(0.262239962816238*x_76 - 7.52232027053833) - 0.0459517133742417*std::sin(0.289119929075241*x_77 - 7.48000001907349) - 0.0307829828056854*std::sin(0.231439992785454*x_79 + 1.83111989498138) - 0.0309130634596169*std::sin(0.367839843034744*x_79 + 8.36952018737793) - 0.00516704701582165*std::sin(0.375919848680496*x_79 - 7.42759990692139) - 0.0291768751220784*std::sin(0.465919852256775*x_81 + 8.46975994110107) + 0.0296987768855276*std::sin(0.263439983129501*x_82 + 1.86799991130829) - 0.0111664701532728*std::sin(0.397759824991226*x_82 - 7.40991973876953) - 0.356321916390157*std::sin(0.158560022711754*x_84 - 7.65680027008057) + 0.00260598539178107*std::sin(0.353839844465256*x_84 + 5.14383983612061) - 0.0362646899402214*std::sin(0.174960017204285*x_85 - 4.43856000900269) - 0.0425061558602014*std::sin(0.212719991803169*x_85 - 7.58776044845581) - 0.0624581437505208*std::sin(0.21399998664856*x_85 - 7.5816798210144) + 0.0137356871920893*std::sin(0.631679832935333*x_86 - 7.16951990127563) - 0.0170901892262024*std::sin(0.51615983247757*x_87 + 5.32791996002197) - 0.00439054495882888*std::sin(0.797919869422913*x_87 - 0.793519854545593) - 0.0150703944336579*std::sin(0.988159835338593*x_87 + 5.58551979064941) + 0.0717516021241787*std::sin(0.225519984960556*x_89 + 1.8122398853302) + 0.0185041217641516*std::sin(0.321119844913483*x_90 + 8.31783962249756) - 0.0234057479204218*std::sin(0.351999849081039*x_92 - 7.39856004714966) - 0.0400249688662523*std::sin(0.353839844465256*x_92 + 1.99631977081299) + 0.0885935563017513*std::sin(0.359439849853516*x_92 - 1.18815994262695) - 0.00916336502147256*std::sin(0.373199850320816*x_92 - 7.38935995101929) - 0.0276249793324024*std::sin(0.381119847297668*x_92 + 8.18279933929443) - 0.00480278084837407*std::sin(0.38487982749939*x_92 - 1.19791984558105) - 0.00462106346772554*std::sin(0.353119850158691*x_95 - 1.21815991401672) - 0.033904531585578*std::sin(0.364959836006165*x_95 + 5.16431999206543) - 0.0264093173710499*std::sin(0.38919985294342*x_95 + 1.98527979850769) - 0.0296687665260362*std::sin(0.386959850788116*x_96 + 5.19655990600586) + 0.0245573288939147*std::sin(0.415279865264893*x_96 - 7.3996000289917) + 0.00673478836124865*std::sin(0.439519852399826*x_96 + 8.20975971221924) - 0.0518598436623144*std::sin(0.305199921131134*x_97 + 5.11439990997314) - 0.0336762056712077*std::sin(0.353279858827591*x_97 + 5.16728019714355) - 0.0274647459515611*std::sin(0.37255984544754*x_98 + 5.18039989471436) - 0.0227244522882435*std::sin(0.415599852800369*x_98 - 7.38839960098267) + 0.0124957936865683*std::sin(0.436959862709045*x_98 - 7.37871980667114) + 0.0107092984067593*std::sin(0.451919853687286*x_98 + 2.00551986694336) + 0.0335389949875251*std::sin(0.406159847974777*x_99 - 4.20160007476807) - 0.0535424095643271*std::sin(0.407679855823517*x_99 + 5.20464038848877) - 0.024107343069504*std::sin(0.443759858608246*x_99 + 5.22552013397217) - 0.00104512093960005*std::sin(0.681439816951752*x_99 + 8.60767936706543) - 0.374447519584214 + 0.000123367033562431*std::exp(-2.08247995376587*x_54));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0410139031812722*x_1 - 0.00468937103150856*x_10 + 0.00459086890803208*x_100 + 0.00203146218648853*x_101 - 0.000824000628803476*x_102 + 0.0096732410155671*x_103 + 0.00407833509440732*x_104 - 0.0066117076094071*x_105 + 0.000540339502896416*x_106 - 0.0117236633866431*x_107 - 0.0131785792553421*x_108 + 0.00525731841568781*x_109 - 0.0119135418816108*x_11 - 0.0028685157735401*x_110 - 0.00598393203731353*x_111 + 0.00198545285726473*x_112 + 0.0136534114693442*x_113 + 0.0179752694413044*x_114 + 0.00201318860882222*x_115 + 0.0137816300886546*x_116 + 0.0126864585073309*x_117 + 0.0017368367856957*x_118 - 0.0143556676641867*x_119 - 0.0148766920817795*x_12 + 0.00313159925415839*x_120 - 0.0101043108677434*x_13 + 0.00197544306429356*x_14 + 0.00221648864483491*x_15 + 0.0037933336519805*x_16 - 0.00504330839182934*x_17 - 0.00312781527387758*x_18 - 0.0116623969425768*x_19 + 0.0286552350060117*x_2 + 0.00393912867809283*x_20 - 0.00377313028693466*x_21 + 0.0215723616787481*x_22 + 0.00925106724481995*x_23 - 0.00665536725023413*x_24 - 0.00231515052824489*x_25 + 0.00731933940085628*x_26 - 0.00383998162973592*x_27 + 0.00203643770788555*x_28 - 0.0114165144000581*x_29 + 0.0109303503991619*x_3 - 0.0139083484641152*x_30 + 0.02032010087632*x_32 + 0.00723306986595417*x_33 - 0.00787513562356415*x_34 - 0.000219947060059148*x_35 - 0.00359484182533218*x_36 - 0.0188549295831918*x_37 - 0.0105213263383122*x_38 - 0.0010832021025734*x_39 - 0.0244872927353879*x_4 + 0.00760514714132342*x_40 + 0.000646305109109406*x_41 - 0.0115027481952904*x_42 - 0.00837637545116962*x_43 + 0.0118011904375299*x_44 - 0.00876202220881607*x_45 - 0.00649361434371027*x_46 - 0.00662807857484614*x_47 + 0.0134481315013667*x_48 + 0.00314861198954751*x_49 - 0.00575978693682984*x_5 - 0.00739452227507057*x_50 + 0.00392114135697696*x_51 + 0.0187395752052802*x_52 + 0.00384461776865589*x_53 - 0.0109837474502787*x_54 + 0.00463426104404234*x_55 - 0.00398888595410062*x_56 + 0.00352458287194503*x_57 + 0.000694027397879154*x_58 + 0.000234203723968693*x_59 + 0.00871076804839854*x_6 + 0.00987469333660744*x_60 + 0.0262340032303248*x_61 + 0.00330458600935786*x_62 - 0.00793379267271274*x_63 - 0.00397535449830678*x_64 - 0.00278225172016886*x_65 - 0.0040664949314781*x_66 + 0.000340043076856453*x_67 + 0.0116706374537258*x_68 + 0.0126278314836947*x_69 + 0.0107213645023632*x_7 + 0.00237590386701185*x_70 - 0.00312226612688075*x_71 - 0.000695965973913341*x_72 - 0.0035990475134932*x_73 - 0.00287232612206146*x_74 - 0.000277570915530111*x_75 + 0.0144323903387843*x_76 - 0.00700537195330248*x_77 - 0.00535244606869725*x_78 - 0.00351467634439118*x_79 - 0.0117424757241326*x_8 - 0.00747775154987482*x_80 - 0.00242734750510084*x_81 - 0.00285104611978209*x_82 - 0.00643878180098285*x_83 + 0.00799455400143893*x_84 - 0.00135396618651535*x_85 - 0.00726781820557417*x_86 - 0.00315176733045764*x_87 + 0.013284778215713*x_88 + 0.00127704309054246*x_89 - 0.0128592478252987*x_9 - 0.00546226370244722*x_90 + 0.00593615724307394*x_91 + 0.000876465648466455*x_92 + 0.00962975133176249*x_93 - 0.00906866383610075*x_94 - 0.0078723906850074*x_95 + 0.000252409879372945*x_96 - 0.00165015921669261*x_97 - 0.0119104158811462*x_98 - 0.00537466048264111*x_99 + 8.77135346133782e-6*std::pow(-8.29967975616455*x_104 - 9.30575942993164, 2) - 0.000136880874553382*std::pow(-5.02359962463379*x_104 - 6.63000011444092, 2) + 4.64317803780235e-5*std::pow(-7.76968002319336*x_106 - 8.38871955871582, 2) + 3.84781547943053e-5*std::pow(-6.33696031570435*x_106 - 6.55055999755859, 2) + 8.21052781562113e-5*std::pow(-4.04055976867676*x_107 - 6.8732795715332, 2) + 4.25556757650152e-5*std::pow(-5.1199197769165*x_112 - 7.47016000747681, 2) + 7.82603669665736e-5*std::pow(-5.11528015136719*x_114 - 6.48727989196777, 2) + 7.49349913965651e-5*std::pow(-1.28807985782623*x_114 - 1.71615982055664, 2) - 7.56206274047918e-7*std::pow(-9.0*x_115 - 9.99927997589111, 2) + 1.0144429696481e-5*std::pow(-8.35487937927246*x_115 - 9.57288074493408, 2) - 1.26014540977319e-6*std::pow(-8.12743949890137*x_115 - 9.94367980957031, 2) + 2.74748923484076e-5*std::pow(-7.13303995132446*x_115 - 8.96848011016846, 2) + 8.86189964503238e-6*std::pow(-7.52023983001709*x_12 - 5.48464012145996, 2) + 3.74929882475849e-5*std::pow(-5.54967975616455*x_120 - 6.57407999038696, 2) - 5.26175711754193e-5*std::pow(-7.13495969772339*x_14 - 9.12439918518066, 2) - 9.08132686209734e-6*std::pow(-7.84424018859863*x_15 - 8.04736042022705, 2) + 3.45757189058249e-6*std::pow(-6.59600019454956*x_15 - 9.96271991729736, 2) + 8.98859363920862e-5*std::pow(-4.43039989471436*x_15 - 5.83872032165527, 2) + 4.98552203708217e-5*std::pow(-6.48343992233276*x_19 - 8.70903968811035, 2) + 7.51147256029414e-6*std::pow(-4.24728012084961*x_21 - 5.46327972412109, 2) - 7.76206846864079e-5*std::pow(-3.86207985877991*x_24 - 5.49304008483887, 2) + 2.16458432020911e-5*std::pow(-8.15999984741211*x_45 - 9.98680019378662, 2) - 6.60618483381707e-5*std::pow(-5.56400012969971*x_47 - 6.5978798866272, 2) - 2.22374934835977e-5*std::pow(-8.39575958251953*x_48 - 7.98016023635864, 2) - 2.43004061629687e-5*std::pow(-7.48736000061035*x_55 - 8.30447959899902, 2) - 4.35712154465429e-6*std::pow(-5.89743947982788*x_55 - 7.46456003189087, 2) + 7.2768940157305e-5*std::pow(-4.72551965713501*x_55 - 7.19879961013794, 2) - 1.3891868540484e-5*std::pow(-8.09127998352051*x_59 - 9.45944023132324, 2) + 6.07339147884448e-5*std::pow(-3.35439991950989*x_60 - 4.39711999893188, 2) - 3.18028715599899e-5*std::pow(-7.65072011947632*x_66 - 9.26943969726563, 2) + 7.32379366296819e-6*std::pow(-8.26799964904785*x_67 - 7.86800003051758, 2) + 2.77938535136966e-5*std::pow(-7.10328006744385*x_67 - 8.67744064331055, 2) + 0.000104990185279224*std::pow(-5.22671985626221*x_7 - 8.03615951538086, 2) + 4.8014906796458e-5*std::pow(-6.26759958267212*x_70 - 9.014479637146, 2) - 3.27391293248931e-6*std::pow(-5.07919979095459*x_71 - 7.71488046646118, 2) + 1.15388278335074e-5*std::pow(-3.47183990478516*x_78 - 4.69567966461182, 2) + 4.65679207515194e-5*std::pow(-6.55936002731323*x_79 - 9.14999961853027, 2) - 1.78454344658144e-6*std::pow(-7.44632005691528*x_82 - 8.2236795425415, 2) - 1.15383923331434e-5*std::pow(-9.99993991851807*x_84 - 8.60000038146973, 2) - 1.87631899799276e-5*std::pow(-8.00255966186523*x_84 - 8.5984001159668, 2) - 1.52342925170797e-6*std::pow(-7.19600009918213*x_87 - 9.9973201751709, 2) - 1.70568161293457e-5*std::pow(-4.31935977935791*x_87 - 6.28535985946655, 2) - 9.72367557958712e-5*std::pow(-4.3907995223999*x_90 - 5.78359985351563, 2) + 0.00248009809524778*std::exp(0.380719840526581*x_1) - 0.000217412523733925*std::exp(0.815199851989746*x_1) + 1.89241671913226e-5*std::exp(1.00071978569031*x_1) + 0.000105704651375307*std::exp(1.15455985069275*x_1) + 8.97082067354992e-5*std::exp(1.16367983818054*x_1) - 4.15609158020293e-5*std::exp(1.20775985717773*x_1) + 2.9431644445051e-6*std::exp(1.34047985076904*x_1) + 9.14285392132842e-7*std::exp(1.38623988628387*x_1) + 0.000223631889032214*std::exp(1.20671987533569*x_100) + 0.000735381373042582*std::exp(1.51599979400635*x_100) - 0.00134286060512844*std::exp(1.56199979782104*x_100) - 0.00503425809510731*std::exp(0.623199820518494*x_104) + 0.00019424763509524*std::exp(0.879519879817963*x_104) + 0.00260881859699571*std::exp(0.884399890899658*x_104) + 0.0147352683474069*std::exp(0.60591983795166*x_106) + 0.0021180770401671*std::exp(0.726879835128784*x_106) + 0.000268350395280471*std::exp(1.03599977493286*x_106) + 0.000641615048738288*std::exp(0.550239861011505*x_109) - 0.00090335661798995*std::exp(0.644079864025116*x_109) + 0.000512985433175417*std::exp(0.68751984834671*x_109) - 0.00285486785662266*std::exp(0.815999865531921*x_109) - 0.00147966141082733*std::exp(0.963039815425873*x_109) - 0.00339986011582541*std::exp(1.03647983074188*x_109) - 0.00462439525146278*std::exp(0.64031982421875*x_110) - 0.00184574697831192*std::exp(0.954399824142456*x_110) + 0.00211354873531828*std::exp(1.00471985340118*x_110) + 0.000270325109124938*std::exp(1.11807978153229*x_110) - 6.57131153269057e-5*std::exp(1.24599981307983*x_110) + 0.00115037962379328*std::exp(1.35839986801147*x_110) - 0.00206241861143895*std::exp(0.422239869832993*x_112) + 7.74682322403294e-5*std::exp(0.832239866256714*x_112) - 0.00157073153186931*std::exp(0.840879857540131*x_112) + 0.0052755054074731*std::exp(0.667279839515686*x_114) - 0.00108662366878408*std::exp(0.739199817180634*x_114) - 0.000440827240335294*std::exp(1.27807986736298*x_23) - 0.000282523872868302*std::exp(1.61607992649078*x_23) - 0.00058976338370195*std::exp(0.619119822978973*x_26) + 0.00282801584758895*std::exp(0.657599866390228*x_26) - 0.00243604106733402*std::exp(0.88647985458374*x_26) - 5.89230909163433e-5*std::exp(0.919839859008789*x_26) + 6.94311719699536e-5*std::exp(1.32983994483948*x_26) + 7.46310153584742e-5*std::exp(1.48503994941711*x_26) - 0.000277147407018038*std::exp(0.493599832057953*x_31) + 0.00137693361259654*std::exp(0.610639870166779*x_31) - 0.00337894851772729*std::exp(0.643439829349518*x_31) + 0.0165738735830173*std::exp(0.645119845867157*x_31) + 0.00108042032218939*std::exp(0.645279824733734*x_31) - 0.00710167905767752*std::exp(0.650719821453094*x_31) - 0.0045421408439005*std::exp(0.652079820632935*x_31) + 0.00621473774558945*std::exp(0.660639822483063*x_31) - 0.000628057254627619*std::exp(0.66271984577179*x_31) - 0.00187784204256896*std::exp(0.662879824638367*x_31) + 0.000474670668999427*std::exp(0.51231986284256*x_45) + 0.00525161459105104*std::exp(0.891679883003235*x_45) + 0.00396460844102504*std::exp(0.86599987745285*x_49) - 0.00275648001446606*std::exp(0.91407984495163*x_50) + 0.00342229489037367*std::exp(0.959999799728394*x_50) + 0.000550779615079955*std::exp(1.3595198392868*x_50) + 0.00240409134835661*std::exp(0.910159826278687*x_52) + 0.00366128183511361*std::exp(0.954559803009033*x_6) - 0.00155210445381344*std::exp(1.37487983703613*x_60) - 0.00394396169948644*std::exp(0.692239880561829*x_66) - 0.00214679614151475*std::exp(0.945199847221375*x_66) + 8.13996376553902e-6*std::exp(1.67783987522125*x_66) + 0.00479541010577983*std::exp(0.66951984167099*x_68) - 0.000183284326959194*std::exp(1.33463990688324*x_68) + 0.00283807287706246*std::exp(0.661919832229614*x_70) - 0.00818003948400712*std::exp(0.710639834403992*x_70) - 0.00271230171328962*std::exp(0.77295982837677*x_70) + 0.00342295129590326*std::exp(0.801199853420258*x_72) + 0.00370409078249888*std::exp(0.824319899082184*x_72) + 0.00108544896079623*std::exp(0.90671980381012*x_72) - 0.00329121261693623*std::exp(0.693759858608246*x_74) + 0.000214863308946254*std::exp(1.17047989368439*x_74) + 0.000516929912115361*std::exp(1.25959992408752*x_74) - 0.000272163844544475*std::exp(1.45263981819153*x_74) - 0.000134438876461645*std::exp(1.60871982574463*x_74) - 0.000797893766282022*std::exp(0.611519813537598*x_78) - 0.00318211222930693*std::exp(0.926559805870056*x_78) + 0.00082755671761309*std::exp(1.16831982135773*x_81) + 0.001367392561825*std::exp(1.27199983596802*x_81) - 8.14677988897433e-6*std::exp(2.01087975502014*x_81) - 0.00252498257404099*std::exp(0.700319886207581*x_87) - 0.00657297610609457*std::exp(0.611999809741974*x_90) + 0.00459986567192*std::sin(0.364159852266312*x_100 + 5.18175983428955) + 0.00465802855430452*std::sin(0.235039994120598*x_102 - 1.34447979927063) - 0.108775153413414*std::sin(0.323359847068787*x_102 + 1.94719982147217) + 0.039281661794313*std::sin(0.375599831342697*x_102 + 1.9761598110199) + 0.0190353108124849*std::sin(0.377599835395813*x_102 + 5.17960023880005) + 0.00504556553635081*std::sin(0.442639857530594*x_102 + 8.43080043792725) + 0.0016209027643851*std::sin(0.459279865026474*x_102 + 5.24032020568848) + 0.0140198380070135*std::sin(0.521439850330353*x_103 + 8.35359954833984) + 0.0415365272196549*std::sin(0.325759828090668*x_105 + 1.9398398399353) + 0.0253583479257283*std::sin(0.326879858970642*x_105 - 7.46807956695557) + 0.0219143518137938*std::sin(0.267679959535599*x_106 - 7.52112007141113) + 0.00148035550081993*std::sin(0.526319861412048*x_106 - 4.0403995513916) - 0.00249464120723693*std::sin(0.272559970617294*x_107 - 7.52992010116577) - 0.00884188019879187*std::sin(0.584239840507507*x_107 + 2.17967987060547) - 0.0172708717225075*std::sin(0.444399863481522*x_108 + 2.046719789505) + 0.0123759337533714*std::sin(0.472879856824875*x_109 - 7.34272003173828) - 0.00439990323440665*std::sin(0.535279810428619*x_109 + 8.36967945098877) + 0.0138838668679419*std::sin(0.611279845237732*x_110 - 0.978959858417511) + 0.00333758935860383*std::sin(0.230719983577728*x_111 - 7.57328033447266) + 0.0143264606679768*std::sin(0.247679978609085*x_111 + 5.05423974990845) - 0.031101043400332*std::sin(0.29775995016098*x_111 - 4.2792797088623) + 0.0018455021352018*std::sin(0.326159834861755*x_111 - 7.47175979614258) + 0.02350623556047*std::sin(0.414799869060516*x_111 - 1.16295981407166) + 0.0124506993766234*std::sin(0.453359842300415*x_111 + 8.24512004852295) + 0.022709013851813*std::sin(0.455839842557907*x_111 - 4.36560010910034) - 0.025684313224545*std::sin(0.535999834537506*x_112 - 0.999279797077179) - 0.00953563886905453*std::sin(0.5933598279953*x_112 - 1.00103986263275) + 0.0170403600503765*std::sin(0.337679862976074*x_115 + 5.1374397277832) + 0.0139278603617645*std::sin(0.342799842357635*x_115 - 7.43576002120972) + 0.0382676257426578*std::sin(0.493279844522476*x_115 - 4.12056016921997) + 0.0196203793029732*std::sin(0.301039934158325*x_116 + 1.90431988239288) + 0.00287674877473806*std::sin(0.396719843149185*x_117 + 1.99855983257294) - 0.0127490193725355*std::sin(0.550879836082458*x_117 + 8.3601598739624) - 0.0065872707956371*std::sin(0.597839832305908*x_117 + 5.40000009536743) + 0.0134114651722041*std::sin(0.294559925794601*x_119 - 4.29423999786377) - 0.0238870126682086*std::sin(0.300399929285049*x_119 + 8.296799659729) - 0.0386265273444758*std::sin(0.36575984954834*x_119 + 5.16232013702393) + 0.00129985610097603*std::sin(0.45279985666275*x_119 - 1.16775989532471) + 0.0472102303947676*std::sin(0.29615992307663*x_120 - 7.47679996490479) + 0.0538636314380332*std::sin(0.304079920053482*x_120 - 7.47528028488159) - 0.0616609039221208*std::sin(0.405039846897125*x_120 + 5.21120023727417) + 0.0334942446988877*std::sin(0.449199855327606*x_120 - 4.16680002212524) + 0.174403312060376*std::sin(0.183280006051064*x_15 + 1.78319990634918) - 0.0545055049059085*std::sin(0.346639841794968*x_16 - 7.43271970748901) + 0.0281188023278975*std::sin(0.375999838113785*x_16 + 5.18239974975586) - 0.00789810846755492*std::sin(0.387439846992493*x_16 - 7.39447975158691) + 0.0610921643461192*std::sin(0.274959951639175*x_18 - 7.52424001693726) - 0.0348092826141766*std::sin(0.25655996799469*x_20 - 7.54432010650635) - 0.00304868109555867*std::sin(0.343279838562012*x_20 - 7.44608020782471) - 0.197551638509523*std::sin(0.234959989786148*x_21 + 5.042799949646) + 0.00998539497805387*std::sin(0.420959860086441*x_21 + 8.42536067962646) - 0.0227178244720975*std::sin(0.457599848508835*x_22 - 7.32376003265381) + 0.075745232546979*std::sin(0.266079962253571*x_24 + 5.06623983383179) + 0.0551795184347779*std::sin(0.305119842290878*x_24 + 5.10567998886108) - 0.00531496716141888*std::sin(0.306879937648773*x_24 + 5.1399998664856) + 0.0119180363592367*std::sin(0.313759922981262*x_24 - 7.46903991699219) + 0.0261340545187831*std::sin(0.351119846105576*x_24 - 4.26471996307373) + 0.0108617753862911*std::sin(0.404879868030548*x_24 + 8.39160060882568) - 0.017400278985178*std::sin(0.788399875164032*x_25 - 4.00871992111206) - 0.045263574271143*std::sin(0.290719836950302*x_27 - 4.32800006866455) - 0.0194781615917744*std::sin(0.317679852247238*x_28 + 5.11696004867554) + 0.0216864907988195*std::sin(0.320399850606918*x_28 - 4.27432012557983) + 0.0155086335123036*std::sin(0.324319839477539*x_28 + 8.30976009368896) - 0.0481317965042515*std::sin(0.330559849739075*x_28 + 5.13048028945923) + 0.000718478139913677*std::sin(0.338479846715927*x_28 + 8.32632064819336) - 0.020284495268149*std::sin(0.33943983912468*x_28 + 8.31999969482422) + 0.0307825936402402*std::sin(0.291439920663834*x_3 + 5.0874400138855) - 0.0849030259816159*std::sin(0.303439915180206*x_3 - 7.50208044052124) + 0.080637991319059*std::sin(0.271119952201843*x_33 - 1.1729599237442) + 0.0965261227064283*std::sin(0.34895983338356*x_34 - 7.40207958221436) - 0.0547924850123573*std::sin(0.355359852313995*x_34 - 7.41152000427246) + 0.0393271838416211*std::sin(0.369519829750061*x_34 + 8.19623947143555) + 0.0314285872347555*std::sin(0.31007993221283*x_35 + 8.25119972229004) + 0.012440678987239*std::sin(0.314959853887558*x_35 + 1.97399973869324) - 0.025731170473418*std::sin(0.331679850816727*x_35 - 7.42903995513916) - 0.016682403660824*std::sin(0.326639831066132*x_36 - 7.46719980239868) - 0.0072942163767244*std::sin(0.332639843225479*x_36 - 4.26639986038208) + 0.00286595013025665*std::sin(0.365359842777252*x_36 + 5.18416023254395) - 0.0311683113547061*std::sin(0.418479859828949*x_36 + 5.22432041168213) + 0.00203364811496549*std::sin(0.29367995262146*x_37 - 1.33159983158112) - 0.010209450839414*std::sin(0.428959846496582*x_37 - 1.1684798002243) + 0.00195897464697379*std::sin(0.47775986790657*x_38 - 7.32087993621826) + 0.0321929244796191*std::sin(0.479759842157364*x_38 + 5.2579197883606) - 0.00368817759145269*std::sin(0.635359883308411*x_38 - 0.950879812240601) - 0.00849921475496274*std::sin(0.317439913749695*x_41 + 1.91527986526489) - 0.0367284588307385*std::sin(0.387199848890305*x_41 + 1.97423982620239) + 0.0190061776554893*std::sin(0.355519831180573*x_43 + 8.34455966949463) + 0.0128550984514718*std::sin(0.401679843664169*x_43 + 1.97855985164642) - 0.00323647973015421*std::sin(0.352319836616516*x_44 + 5.15360021591187) + 0.0089074488288564*std::sin(0.182240009307861*x_46 + 4.96335983276367) + 0.0229197594921741*std::sin(0.265519976615906*x_48 - 7.5195198059082) - 0.00246348008330998*std::sin(0.220799997448921*x_51 + 5.01679992675781) - 0.0035426294239406*std::sin(0.186400011181831*x_53 - 4.42840003967285) + 0.0508087145840039*std::sin(0.354639858007431*x_53 - 4.25040006637573) + 0.00529871682862756*std::sin(0.280239939689636*x_54 - 1.33415985107422) - 0.00889111799390565*std::sin(0.53823983669281*x_54 - 1.03471982479095) - 0.00786972506910175*std::sin(0.356959849596024*x_55 - 7.43415975570679) - 0.00303104144763034*std::sin(0.487919867038727*x_55 + 2.06407976150513) - 0.04949515914239*std::sin(0.239359974861145*x_56 + 1.83567988872528) + 0.00810422699918474*std::sin(0.395439833402634*x_56 + 5.18455982208252) + 0.123905214379987*std::sin(0.139120042324066*x_58 - 7.6723198890686) + 0.0107661811563566*std::sin(0.184960007667542*x_58 - 7.6159200668335) + 0.0146335604454666*std::sin(0.255359977483749*x_58 + 5.05471992492676) + 0.0484907405343*std::sin(0.277119934558868*x_58 + 5.09000015258789) - 0.0217753756264121*std::sin(0.386319845914841*x_58 + 5.19648027420044) - 0.00147808553653482*std::sin(0.490319848060608*x_58 - 4.12143993377686) + 0.00604350748432135*std::sin(0.605599880218506*x_58 - 0.993359804153442) + 0.00273374566385657*std::sin(0.298159927129745*x_59 + 5.10799980163574) - 0.0479161273167276*std::sin(0.362959831953049*x_59 - 4.22071981430054) + 0.0247840851197609*std::sin(0.125840052962303*x_63 - 1.45423996448517) - 0.00523184452777614*std::sin(0.164000019431114*x_64 - 1.42503988742828) + 0.177211080967475*std::sin(0.179200008511543*x_64 - 4.42479991912842) + 0.0322839115126828*std::sin(0.281999945640564*x_64 + 5.10519981384277) - 0.0301992239948785*std::sin(0.417919874191284*x_64 + 1.99703979492188) + 0.0809051206027793*std::sin(0.398639857769012*x_65 - 7.40407991409302) + 0.000556017697741684*std::sin(0.440159857273102*x_66 - 4.15623998641968) + 0.0192349744970836*std::sin(0.243359968066216*x_69 - 7.54400014877319) - 0.00525774076232495*std::sin(0.254959970712662*x_70 - 7.52400016784668) - 0.0101811791646237*std::sin(0.515119850635529*x_70 + 5.33439970016479) - 0.0168463849070148*std::sin(0.514559864997864*x_72 - 4.07624006271362) + 0.0347000094065016*std::sin(0.245599970221519*x_73 + 1.86039984226227) - 0.023801144288028*std::sin(0.42799985408783*x_73 - 4.17216014862061) + 0.06843042728818*std::sin(0.225519984960556*x_74 + 1.8199999332428) + 0.112019681946615*std::sin(0.199359983205795*x_75 - 7.59999990463257) - 0.0190799258276919*std::sin(0.382159858942032*x_75 - 7.40551996231079) - 0.0247084697035964*std::sin(0.527119874954224*x_75 - 7.25256013870239) + 0.0389176480464146*std::sin(0.262239962816238*x_76 - 7.52232027053833) - 0.0530819357733654*std::sin(0.289119929075241*x_77 - 7.48000001907349) - 0.0355595079316445*std::sin(0.231439992785454*x_79 + 1.83111989498138) + 0.00212997285286232*std::sin(0.367839843034744*x_79 + 8.36952018737793) + 0.0255154856735398*std::sin(0.375919848680496*x_79 - 7.42759990692139) - 0.053469585778604*std::sin(0.465919852256775*x_81 + 8.46975994110107) + 0.0392963624925906*std::sin(0.263439983129501*x_82 + 1.86799991130829) - 0.020463690206935*std::sin(0.397759824991226*x_82 - 7.40991973876953) - 0.0123731470634012*std::sin(0.158560022711754*x_84 - 7.65680027008057) - 0.0128686622602504*std::sin(0.353839844465256*x_84 + 5.14383983612061) + 0.0454972760155751*std::sin(0.174960017204285*x_85 - 4.43856000900269) - 0.0563442652593564*std::sin(0.212719991803169*x_85 - 7.58776044845581) - 0.0721496312463339*std::sin(0.21399998664856*x_85 - 7.5816798210144) - 0.000946416742966223*std::sin(0.631679832935333*x_86 - 7.16951990127563) - 0.0226539929477683*std::sin(0.51615983247757*x_87 + 5.32791996002197) - 0.00507181579099224*std::sin(0.797919869422913*x_87 - 0.793519854545593) - 0.000523313885713772*std::sin(0.988159835338593*x_87 + 5.58551979064941) + 0.0951107250480348*std::sin(0.225519984960556*x_89 + 1.8122398853302) + 0.0244839940464173*std::sin(0.321119844913483*x_90 + 8.31783962249756) - 0.0309696509804515*std::sin(0.351999849081039*x_92 - 7.39856004714966) - 0.073349818893408*std::sin(0.353839844465256*x_92 + 1.99631977081299) + 0.00307637855144169*std::sin(0.359439849853516*x_92 - 1.18815994262695) - 0.0105852234404467*std::sin(0.373199850320816*x_92 - 7.38935995101929) - 0.0366184410655324*std::sin(0.381119847297668*x_92 + 8.18279933929443) + 0.00422440553529556*std::sin(0.38487982749939*x_92 - 1.19791984558105) + 0.0228193547196743*std::sin(0.353119850158691*x_95 - 1.21815991401672) + 0.0108698767320725*std::sin(0.364959836006165*x_95 + 5.16431999206543) - 0.0483977552296952*std::sin(0.38919985294342*x_95 + 1.98527979850769) + 0.00204423826713001*std::sin(0.386959850788116*x_96 + 5.19655990600586) + 0.0450037983263312*std::sin(0.415279865264893*x_96 - 7.3996000289917) - 0.00844939045344949*std::sin(0.439519852399826*x_96 + 8.20975971221924) - 0.0687430968170443*std::sin(0.305199921131134*x_97 + 5.11439990997314) + 0.00232035896283084*std::sin(0.353279858827591*x_97 + 5.16728019714355) + 0.00189237677346361*std::sin(0.37255984544754*x_98 + 5.18039989471436) - 0.0301225208841154*std::sin(0.415599852800369*x_98 - 7.38839960098267) + 0.0144347374494083*std::sin(0.436959862709045*x_98 - 7.37871980667114) - 0.0134357664810773*std::sin(0.451919853687286*x_98 + 2.00551986694336) + 0.0444577965677367*std::sin(0.406159847974777*x_99 - 4.20160007476807) + 0.0171658290111856*std::sin(0.407679855823517*x_99 + 5.20464038848877) - 0.0441791536192878*std::sin(0.443759858608246*x_99 + 5.22552013397217) + 0.000919262157005229*std::sin(0.681439816951752*x_99 + 8.60767936706543) - 0.221900200468639 + 0.000226082613567029*std::exp(-2.08247995376587*x_54));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0193567291878305*x_1 + 0.00599486127608735*x_10 - 0.00591677937784152*x_100 - 0.0196120206605309*x_101 + 0.00627703919399607*x_102 + 0.0135452740028713*x_103 - 0.010891295937151*x_104 - 0.00581314280159355*x_105 + 0.00113194629195456*x_106 - 0.00902324783437741*x_107 + 0.000440247434687042*x_108 + 4.30582670585976e-5*x_109 + 0.00992440816806379*x_11 - 0.00430946290939674*x_110 + 0.00210311402953711*x_111 + 0.00686724027451402*x_112 + 0.0157445332151349*x_113 - 0.000113474819246583*x_114 - 0.00313169293525775*x_115 + 0.0125012061866188*x_116 - 0.00248261421463426*x_117 - 0.0138379049492255*x_118 + 0.00917155967446648*x_119 + 0.00434911194170775*x_12 + 0.00309644874206245*x_120 + 0.000444305828357031*x_13 - 0.00757021143346839*x_14 + 0.000929619858912498*x_15 - 0.00334196955017431*x_16 + 0.0145269716454113*x_17 - 0.0141009056839678*x_18 - 0.0203788306622323*x_19 - 0.0133375575823239*x_2 + 0.00944366775550566*x_20 - 0.000419750101564302*x_21 - 0.00405419647310469*x_22 + 0.0175598566110823*x_23 + 0.000511295631709764*x_24 + 0.0169435979184914*x_25 - 0.00400794477211354*x_26 + 0.0019545291371671*x_27 - 0.0013007815415187*x_28 + 0.0174349834168607*x_29 + 0.000155731690887404*x_3 + 0.0103727557228193*x_30 + 0.0145472332919933*x_32 - 0.00521328180923975*x_33 + 0.0157581961741496*x_34 - 0.00836074716571467*x_35 - 0.00561283632501874*x_36 + 0.015644544855398*x_37 + 0.00601763556824389*x_38 + 0.0051657714032908*x_39 + 0.0148663185305502*x_4 - 0.0166341587175556*x_40 - 0.00495465545166737*x_41 - 0.0155242687197121*x_42 - 0.00962629834718611*x_43 - 0.01513673726604*x_44 - 0.00832093418664824*x_45 + 0.00309617735323918*x_46 + 0.000666000573241866*x_47 + 0.0151994677662884*x_48 - 0.0289363903080031*x_49 - 0.00744195307099207*x_5 - 0.0154848670541966*x_50 + 0.0047348470615225*x_51 + 0.0171250305989705*x_52 + 0.00285893277570252*x_53 + 0.00814735249591773*x_54 + 0.00276130838156353*x_55 + 0.0163698724510912*x_56 + 0.0195686764886984*x_57 - 0.00101050527962348*x_58 + 0.00179350168516713*x_59 - 0.000352384808442417*x_6 + 0.00338837813039135*x_60 - 0.0163520183187264*x_61 + 0.00392995057110073*x_62 - 0.00522344356116043*x_63 - 0.00508490011343229*x_64 + 0.0122869684488526*x_65 + 0.00661483870499762*x_66 + 0.00820628259616359*x_67 - 0.0103257935311826*x_68 - 0.015357434396874*x_69 + 0.00674201960557101*x_7 - 0.00115838784622237*x_70 + 0.00754642757113499*x_71 + 0.0104202198208613*x_72 + 0.00302184199918563*x_73 + 0.00179602020141942*x_74 + 0.00193419358794711*x_75 + 0.00999390459247185*x_76 - 0.00198060948067561*x_77 + 0.000647143858900059*x_78 + 0.013765886051827*x_79 - 0.0198778421912744*x_8 + 0.00865170806987988*x_80 + 0.00194904625105827*x_81 - 0.00254216860035863*x_82 - 0.00706283119501458*x_83 + 0.00340310170465561*x_84 - 0.00744083419066115*x_85 - 0.0025281148203873*x_86 + 0.00275238032428617*x_87 - 0.00866861165828538*x_88 - 0.0063266591891473*x_89 - 0.00132410844658553*x_9 - 0.00331603757518143*x_90 - 0.0202698534551375*x_91 + 0.00136808503044504*x_92 + 0.0200516490562547*x_93 - 0.000492761223013526*x_94 + 0.00670134623503823*x_95 + 0.00184845536343181*x_96 - 0.0275201881804538*x_97 + 0.00957177872223148*x_98 - 0.00686187220543835*x_99 + 4.26144517593413e-5*std::pow(-8.29967975616455*x_104 - 9.30575942993164, 2) + 5.20006611748968e-5*std::pow(-5.02359962463379*x_104 - 6.63000011444092, 2) - 1.76393034239652e-5*std::pow(-7.76968002319336*x_106 - 8.38871955871582, 2) - 2.78146183073228e-6*std::pow(-6.33696031570435*x_106 - 6.55055999755859, 2) - 6.36819474433174e-5*std::pow(-4.04055976867676*x_107 - 6.8732795715332, 2) - 3.30067489976287e-5*std::pow(-5.1199197769165*x_112 - 7.47016000747681, 2) - 5.31101072499235e-5*std::pow(-5.11528015136719*x_114 - 6.48727989196777, 2) + 0.00228106072966123*std::pow(-1.28807985782623*x_114 - 1.71615982055664, 2) - 7.82175962771912e-6*std::pow(-9.0*x_115 - 9.99927997589111, 2) + 4.18104428561975e-6*std::pow(-8.35487937927246*x_115 - 9.57288074493408, 2) - 3.83594920653884e-5*std::pow(-8.12743949890137*x_115 - 9.94367980957031, 2) - 2.13098924920911e-5*std::pow(-7.13303995132446*x_115 - 8.96848011016846, 2) + 3.65244730154238e-6*std::pow(-7.52023983001709*x_12 - 5.48464012145996, 2) + 1.54528001034648e-5*std::pow(-5.54967975616455*x_120 - 6.57407999038696, 2) + 2.43510132382783e-5*std::pow(-7.13495969772339*x_14 - 9.12439918518066, 2) - 4.41204162141508e-5*std::pow(-7.84424018859863*x_15 - 8.04736042022705, 2) + 0.000105250315141156*std::pow(-6.59600019454956*x_15 - 9.96271991729736, 2) - 3.41474156850915e-5*std::pow(-4.43039989471436*x_15 - 5.83872032165527, 2) + 4.05494774405791e-5*std::pow(-6.48343992233276*x_19 - 8.70903968811035, 2) + 0.000228653193386505*std::pow(-4.24728012084961*x_21 - 5.46327972412109, 2) - 6.31323696736861e-5*std::pow(-3.86207985877991*x_24 - 5.49304008483887, 2) - 1.67888043267968e-5*std::pow(-8.15999984741211*x_45 - 9.98680019378662, 2) + 2.50967113063039e-5*std::pow(-5.56400012969971*x_47 - 6.5978798866272, 2) + 1.60747675314563e-6*std::pow(-8.39575958251953*x_48 - 7.98016023635864, 2) + 1.64910698423278e-5*std::pow(-7.48736000061035*x_55 - 8.30447959899902, 2) - 4.50675411731409e-5*std::pow(-5.89743947982788*x_55 - 7.46456003189087, 2) + 5.91862291518511e-5*std::pow(-4.72551965713501*x_55 - 7.19879961013794, 2) - 5.72555770167343e-6*std::pow(-8.09127998352051*x_59 - 9.45944023132324, 2) + 0.000295067630476423*std::pow(-3.35439991950989*x_60 - 4.39711999893188, 2) + 2.15824942416643e-5*std::pow(-7.65072011947632*x_66 - 9.26943969726563, 2) + 3.55816754075175e-5*std::pow(-8.26799964904785*x_67 - 7.86800003051758, 2) - 2.00912811673477e-6*std::pow(-7.10328006744385*x_67 - 8.67744064331055, 2) - 4.85886621999387e-5*std::pow(-5.22671985626221*x_7 - 8.03615951538086, 2) + 3.90526682155431e-5*std::pow(-6.26759958267212*x_70 - 9.014479637146, 2) - 3.38634587927126e-5*std::pow(-5.07919979095459*x_71 - 7.71488046646118, 2) + 0.000119350950655576*std::pow(-3.47183990478516*x_78 - 4.69567966461182, 2) - 1.76910227708607e-5*std::pow(-6.55936002731323*x_79 - 9.14999961853027, 2) - 1.84582836236782e-5*std::pow(-7.44632005691528*x_82 - 8.2236795425415, 2) + 8.94933079383311e-6*std::pow(-9.99993991851807*x_84 - 8.60000038146973, 2) - 7.7332812777822e-6*std::pow(-8.00255966186523*x_84 - 8.5984001159668, 2) - 1.5757469655615e-5*std::pow(-7.19600009918213*x_87 - 9.9973201751709, 2) - 8.28682678580705e-5*std::pow(-4.31935977935791*x_87 - 6.28535985946655, 2) + 7.02893177274914e-6*std::pow(-4.3907995223999*x_90 - 5.78359985351563, 2) + 0.00201717455094293*std::exp(0.380719840526581*x_1) - 8.96069485596834e-5*std::exp(0.815199851989746*x_1) + 0.000576061647798469*std::exp(1.00071978569031*x_1) - 4.01569012377567e-5*std::exp(1.15455985069275*x_1) - 6.08789948934899e-5*std::exp(1.16367983818054*x_1) + 3.22351999193702e-5*std::exp(1.20775985717773*x_1) + 1.42989721931741e-5*std::exp(1.34047985076904*x_1) + 9.45683844980219e-6*std::exp(1.38623988628387*x_1) - 0.000151764093006065*std::exp(1.20671987533569*x_100) - 0.000279369325617542*std::exp(1.51599979400635*x_100) + 0.000621465712729842*std::exp(1.56199979782104*x_100) - 0.00409458695677694*std::exp(0.623199820518494*x_104) + 0.00200918500958058*std::exp(0.879519879817963*x_104) + 0.00107522910735644*std::exp(0.884399890899658*x_104) - 0.0068193705369075*std::exp(0.60591983795166*x_106) - 0.00164280876676641*std::exp(0.726879835128784*x_106) + 0.00277566103313531*std::exp(1.03599977493286*x_106) + 0.0195311010778827*std::exp(0.550239861011505*x_109) - 0.00438883773051633*std::exp(0.644079864025116*x_109) + 0.00530602414780444*std::exp(0.68751984834671*x_109) - 0.00232199153643109*std::exp(0.815999865531921*x_109) + 0.00114764510046402*std::exp(0.963039815425873*x_109) + 0.001573429499677*std::exp(1.03647983074188*x_109) - 0.00190595251966531*std::exp(0.64031982421875*x_110) + 0.0012525857438956*std::exp(0.954399824142456*x_110) - 0.00163929655320516*std::exp(1.00471985340118*x_110) + 0.00131333851416658*std::exp(1.11807978153229*x_110) - 0.000679698397269673*std::exp(1.24599981307983*x_110) - 0.00053238697306352*std::exp(1.35839986801147*x_110) - 0.0016774571716971*std::exp(0.422239869832993*x_112) + 0.000801286516871428*std::exp(0.832239866256714*x_112) + 0.000726922650967951*std::exp(0.840879857540131*x_112) - 0.00200414974053485*std::exp(0.667279839515686*x_114) - 0.000447853828842133*std::exp(0.739199817180634*x_114) - 0.000181687711314986*std::exp(1.27807986736298*x_23) + 0.000219129279231613*std::exp(1.61607992649078*x_23) - 0.0179527089985936*std::exp(0.619119822978973*x_26) - 0.00191918631092139*std::exp(0.657599866390228*x_26) + 0.000176093559660213*std::exp(0.88647985458374*x_26) - 0.000609466318234583*std::exp(0.919839859008789*x_26) + 2.86161778921448e-5*std::exp(1.32983994483948*x_26) - 3.45386684026446e-5*std::exp(1.48503994941711*x_26) - 0.00286665222643123*std::exp(0.493599832057953*x_31) - 0.000523093226008249*std::exp(0.610639870166779*x_31) - 0.00139263948927042*std::exp(0.643439829349518*x_31) - 0.00767026310819427*std::exp(0.645119845867157*x_31) + 0.032888565442434*std::exp(0.645279824733734*x_31) - 0.00577611276407204*std::exp(0.650719821453094*x_31) + 0.000328336726505117*std::exp(0.652079820632935*x_31) - 0.00482023338055872*std::exp(0.660639822483063*x_31) - 0.00305133246509836*std::exp(0.66271984577179*x_31) + 0.00127436652989182*std::exp(0.662879824638367*x_31) + 0.00490971842294828*std::exp(0.51231986284256*x_45) - 0.00243040743942131*std::exp(0.891679883003235*x_45) - 0.00183479074528417*std::exp(0.86599987745285*x_49) + 0.00127567806388353*std::exp(0.91407984495163*x_50) - 0.00232248398153108*std::exp(0.959999799728394*x_50) - 0.000209239634384738*std::exp(1.3595198392868*x_50) - 0.00186464527412843*std::exp(0.910159826278687*x_52) - 0.00026466226695021*std::exp(0.954559803009033*x_6) + 0.00011219662997537*std::exp(1.37487983703613*x_60) + 0.00305898923072039*std::exp(0.692239880561829*x_66) - 0.00174608518551093*std::exp(0.945199847221375*x_66) + 8.41950697017823e-5*std::exp(1.67783987522125*x_66) - 0.00371938395658821*std::exp(0.66951984167099*x_68) - 0.00189578690127643*std::exp(1.33463990688324*x_68) - 0.00220124712875994*std::exp(0.661919832229614*x_70) + 0.00378566029018365*std::exp(0.710639834403992*x_70) + 0.001840658822217*std::exp(0.77295982837677*x_70) + 0.00278403917024232*std::exp(0.801199853420258*x_72) - 0.000267756787823223*std::exp(0.824319899082184*x_72) + 0.0052735091090518*std::exp(0.90671980381012*x_72) - 0.00135647898566189*std::exp(0.693759858608246*x_74) + 0.00654055264634133*std::exp(1.17047989368439*x_74) + 0.00251143508238474*std::exp(1.25959992408752*x_74) - 0.000221363010581665*std::exp(1.45263981819153*x_74) + 0.000104272583412732*std::exp(1.60871982574463*x_74) + 0.000541477444379775*std::exp(0.611519813537598*x_78) - 0.00258815400064283*std::exp(0.926559805870056*x_78) + 0.000673088840086469*std::exp(1.16831982135773*x_81) - 9.88444024583622e-5*std::exp(1.27199983596802*x_81) - 0.000247992284133165*std::exp(2.01087975502014*x_81) + 0.0017135377779251*std::exp(0.700319886207581*x_87) + 0.00249705522790489*std::exp(0.611999809741974*x_90) + 0.00189584261093269*std::sin(0.364159852266312*x_100 + 5.18175983428955) + 0.0481799489652386*std::sin(0.235039994120598*x_102 - 1.34447979927063) + 0.0503403167724169*std::sin(0.323359847068787*x_102 + 1.94719982147217) - 0.0149229933839759*std::sin(0.375599831342697*x_102 + 1.9761598110199) - 0.014764040631122*std::sin(0.377599835395813*x_102 + 5.17960023880005) + 0.0245132076931058*std::sin(0.442639857530594*x_102 + 8.43080043792725) + 0.0493411365442242*std::sin(0.459279865026474*x_102 + 5.24032020568848) - 0.0108739731132488*std::sin(0.521439850330353*x_103 + 8.35359954833984) - 0.0281880791124767*std::sin(0.325759828090668*x_105 + 1.9398398399353) + 0.0104514870584004*std::sin(0.326879858970642*x_105 - 7.46807956695557) + 0.106467957576038*std::sin(0.267679959535599*x_106 - 7.52112007141113) + 0.0450628035838155*std::sin(0.526319861412048*x_106 - 4.0403995513916) - 0.0258031234995729*std::sin(0.272559970617294*x_107 - 7.52992010116577) - 0.00719149607576601*std::sin(0.584239840507507*x_107 + 2.17967987060547) + 0.00656115583398741*std::sin(0.444399863481522*x_108 + 2.046719789505) - 0.00839872331853799*std::sin(0.472879856824875*x_109 - 7.34272003173828) + 0.00167151092540313*std::sin(0.535279810428619*x_109 + 8.36967945098877) - 0.00527444216843942*std::sin(0.611279845237732*x_110 - 0.978959858417511) + 0.10159798347552*std::sin(0.230719983577728*x_111 - 7.57328033447266) + 0.0696031997466078*std::sin(0.247679978609085*x_111 + 5.05423974990845) + 0.0241223835510805*std::sin(0.29775995016098*x_111 - 4.2792797088623) + 0.0190888049853394*std::sin(0.326159834861755*x_111 - 7.47175979614258) - 0.00892995310605361*std::sin(0.414799869060516*x_111 - 1.16295981407166) + 0.00513157733240131*std::sin(0.453359842300415*x_111 + 8.24512004852295) - 0.0105095595364933*std::sin(0.455839842557907*x_111 - 4.36560010910034) + 0.00975739871517708*std::sin(0.535999834537506*x_112 - 0.999279797077179) - 0.00393013009070625*std::sin(0.5933598279953*x_112 - 1.00103986263275) - 0.00123179272279117*std::sin(0.337679862976074*x_115 + 5.1374397277832) + 0.0676666532837145*std::sin(0.342799842357635*x_115 - 7.43576002120972) - 0.0177099672265424*std::sin(0.493279844522476*x_115 - 4.12056016921997) + 0.00808657334328464*std::sin(0.301039934158325*x_116 + 1.90431988239288) + 0.0297554228225178*std::sin(0.396719843149185*x_117 + 1.99855983257294) - 0.0103693468726235*std::sin(0.550879836082458*x_117 + 8.3601598739624) - 0.00271495507800525*std::sin(0.597839832305908*x_117 + 5.40000009536743) - 0.00910146963633075*std::sin(0.294559925794601*x_119 - 4.29423999786377) - 0.00984507368133127*std::sin(0.300399929285049*x_119 + 8.296799659729) + 0.0146741096399091*std::sin(0.36575984954834*x_119 + 5.16232013702393) + 0.0134449585005882*std::sin(0.45279985666275*x_119 - 1.16775989532471) - 0.036616883570707*std::sin(0.29615992307663*x_120 - 7.47679996490479) - 0.0365536650724645*std::sin(0.304079920053482*x_120 - 7.47528028488159) + 0.0285361991089625*std::sin(0.405039846897125*x_120 + 5.21120023727417) - 0.0127243698257984*std::sin(0.449199855327606*x_120 - 4.16680002212524) - 0.0807125313067617*std::sin(0.183280006051064*x_15 + 1.78319990634918) + 0.0252247346632157*std::sin(0.346639841794968*x_16 - 7.43271970748901) - 0.0106822543125019*std::sin(0.375999838113785*x_16 + 5.18239974975586) - 0.00325521909693264*std::sin(0.387439846992493*x_16 - 7.39447975158691) - 0.0232087422656313*std::sin(0.274959951639175*x_18 - 7.52424001693726) - 0.0283119442575444*std::sin(0.25655996799469*x_20 - 7.54432010650635) - 0.0315337911485249*std::sin(0.343279838562012*x_20 - 7.44608020782471) + 0.0914254013844766*std::sin(0.234959989786148*x_21 + 5.042799949646) + 0.00411549785072006*std::sin(0.420959860086441*x_21 + 8.42536067962646) + 0.00863043793998854*std::sin(0.457599848508835*x_22 - 7.32376003265381) - 0.0514032527595824*std::sin(0.266079962253571*x_24 + 5.06623983383179) - 0.0209625446307463*std::sin(0.305119842290878*x_24 + 5.10567998886108) - 0.161790408531459*std::sin(0.306879937648773*x_24 + 5.1399998664856) + 0.0579021912337009*std::sin(0.313759922981262*x_24 - 7.46903991699219) - 0.00188914659538274*std::sin(0.351119846105576*x_24 - 4.26471996307373) + 0.00447669955525359*std::sin(0.404879868030548*x_24 + 8.39160060882568) + 0.00661031729092325*std::sin(0.788399875164032*x_25 - 4.00871992111206) - 0.0368148865883237*std::sin(0.290719836950302*x_27 - 4.32800006866455) - 0.00802795806706776*std::sin(0.317679852247238*x_28 + 5.11696004867554) - 0.014717179293214*std::sin(0.320399850606918*x_28 - 4.27432012557983) + 0.0753466289525817*std::sin(0.324319839477539*x_28 + 8.30976009368896) + 0.0182851347927396*std::sin(0.330559849739075*x_28 + 5.13048028945923) + 0.00743152166417945*std::sin(0.338479846715927*x_28 + 8.32632064819336) + 0.00938751070739735*std::sin(0.33943983912468*x_28 + 8.31999969482422) - 0.0208900994594397*std::sin(0.291439920663834*x_3 + 5.0874400138855) + 0.0392924770844241*std::sin(0.303439915180206*x_3 - 7.50208044052124) - 0.0373186513602493*std::sin(0.271119952201843*x_33 - 1.1729599237442) - 0.0446715581764057*std::sin(0.34895983338356*x_34 - 7.40207958221436) + 0.020815511716701*std::sin(0.355359852313995*x_34 - 7.41152000427246) - 0.00284283540493084*std::sin(0.369519829750061*x_34 + 8.19623947143555) + 0.0255622737114779*std::sin(0.31007993221283*x_35 + 8.25119972229004) + 0.0604413807848403*std::sin(0.314959853887558*x_35 + 1.97399973869324) + 0.0174620344432194*std::sin(0.331679850816727*x_35 - 7.42903995513916) + 0.0129390945017635*std::sin(0.326639831066132*x_36 - 7.46719980239868) + 0.000527275399390096*std::sin(0.332639843225479*x_36 - 4.26639986038208) + 0.0296437278996674*std::sin(0.365359842777252*x_36 + 5.18416023254395) + 0.0118407542575839*std::sin(0.418479859828949*x_36 + 5.22432041168213) + 0.0619053230879534*std::sin(0.29367995262146*x_37 - 1.33159983158112) + 0.00791858606877533*std::sin(0.428959846496582*x_37 - 1.1684798002243) + 0.0202624989123721*std::sin(0.47775986790657*x_38 - 7.32087993621826) - 0.0122300019163075*std::sin(0.479759842157364*x_38 + 5.2579197883606) - 0.00152008878808074*std::sin(0.635359883308411*x_38 - 0.950879812240601) - 0.0412923021246484*std::sin(0.317439913749695*x_41 + 1.91527986526489) + 0.024925162802496*std::sin(0.387199848890305*x_41 + 1.97423982620239) - 0.00137389534346081*std::sin(0.355519831180573*x_43 + 8.34455966949463) - 0.00997058559874534*std::sin(0.401679843664169*x_43 + 1.97855985164642) - 0.0334762714328489*std::sin(0.352319836616516*x_44 + 5.15360021591187) + 0.271147448559027*std::sin(0.182240009307861*x_46 + 4.96335983276367) - 0.0177768707709285*std::sin(0.265519976615906*x_48 - 7.5195198059082) - 0.025480810885342*std::sin(0.220799997448921*x_51 + 5.01679992675781) - 0.0366429065125589*std::sin(0.186400011181831*x_53 - 4.42840003967285) - 0.0193020884797491*std::sin(0.354639858007431*x_53 - 4.25040006637573) + 0.161295739815504*std::sin(0.280239939689636*x_54 - 1.33415985107422) + 0.00603381058038921*std::sin(0.53823983669281*x_54 - 1.03471982479095) - 0.0382340103833149*std::sin(0.356959849596024*x_55 - 7.43415975570679) - 0.00124924898720404*std::sin(0.487919867038727*x_55 + 2.06407976150513) + 0.00357784557748472*std::sin(0.239359974861145*x_56 + 1.83567988872528) + 0.00334017120706754*std::sin(0.395439833402634*x_56 + 5.18455982208252) - 0.00895670871612695*std::sin(0.139120042324066*x_58 - 7.6723198890686) + 0.327728242660604*std::sin(0.184960007667542*x_58 - 7.6159200668335) + 0.0710952030857536*std::sin(0.255359977483749*x_58 + 5.05471992492676) - 0.0376100642923067*std::sin(0.277119934558868*x_58 + 5.09000015258789) - 0.0177108855633523*std::sin(0.386319845914841*x_58 + 5.19648027420044) - 0.0152884605335224*std::sin(0.490319848060608*x_58 - 4.12143993377686) - 0.00229591158023751*std::sin(0.605599880218506*x_58 - 0.993359804153442) + 0.0282762814854014*std::sin(0.298159927129745*x_59 + 5.10799980163574) + 0.0182032026719602*std::sin(0.362959831953049*x_59 - 4.22071981430054) + 0.256352219034109*std::sin(0.125840052962303*x_63 - 1.45423996448517) - 0.159260111645922*std::sin(0.164000019431114*x_64 - 1.42503988742828) - 0.0820119454815218*std::sin(0.179200008511543*x_64 - 4.42479991912842) - 0.0250398318157314*std::sin(0.281999945640564*x_64 + 5.10519981384277) + 0.0204942052714564*std::sin(0.417919874191284*x_64 + 1.99703979492188) - 0.0374422767686232*std::sin(0.398639857769012*x_65 - 7.40407991409302) + 0.0169254724885889*std::sin(0.440159857273102*x_66 - 4.15623998641968) + 0.0934505599861108*std::sin(0.243359968066216*x_69 - 7.54400014877319) - 0.0543830246311346*std::sin(0.254959970712662*x_70 - 7.52400016784668) - 0.00419619064262302*std::sin(0.515119850635529*x_70 + 5.33439970016479) + 0.00779637928402689*std::sin(0.514559864997864*x_72 - 4.07624006271362) - 0.0269137895264567*std::sin(0.245599970221519*x_73 + 1.86039984226227) - 0.01935853369394*std::sin(0.42799985408783*x_73 - 4.17216014862061) - 0.0259965278208265*std::sin(0.225519984960556*x_74 + 1.8199999332428) - 0.0425559636788697*std::sin(0.199359983205795*x_75 - 7.59999990463257) - 0.00786382450652627*std::sin(0.382159858942032*x_75 - 7.40551996231079) + 0.0114348925541237*std::sin(0.527119874954224*x_75 - 7.25256013870239) - 0.0301850462377589*std::sin(0.262239962816238*x_76 - 7.52232027053833) + 0.00383712210328884*std::sin(0.289119929075241*x_77 - 7.48000001907349) + 0.00257048225311806*std::sin(0.231439992785454*x_79 + 1.83111989498138) + 0.0220312052946555*std::sin(0.367839843034744*x_79 + 8.36952018737793) + 0.020752884111413*std::sin(0.375919848680496*x_79 - 7.42759990692139) + 0.0247453191406201*std::sin(0.465919852256775*x_81 + 8.46975994110107) - 0.0266678282687426*std::sin(0.263439983129501*x_82 + 1.86799991130829) + 0.00947044076724487*std::sin(0.397759824991226*x_82 - 7.40991973876953) - 0.37664513390391*std::sin(0.158560022711754*x_84 - 7.65680027008057) - 0.0104666577768826*std::sin(0.353839844465256*x_84 + 5.14383983612061) - 0.0352882933363374*std::sin(0.174960017204285*x_85 - 4.43856000900269) + 0.0214050286898018*std::sin(0.212719991803169*x_85 - 7.58776044845581) + 0.00521546437156045*std::sin(0.21399998664856*x_85 - 7.5816798210144) - 0.00978918652909979*std::sin(0.631679832935333*x_86 - 7.16951990127563) + 0.00860618852253159*std::sin(0.51615983247757*x_87 + 5.32791996002197) + 0.000366625221780073*std::sin(0.797919869422913*x_87 - 0.793519854545593) - 0.0159299511715542*std::sin(0.988159835338593*x_87 + 5.58551979064941) - 0.0361322982736555*std::sin(0.225519984960556*x_89 + 1.8122398853302) - 0.0166156587314127*std::sin(0.321119844913483*x_90 + 8.31783962249756) + 0.0210170428381329*std::sin(0.351999849081039*x_92 - 7.39856004714966) + 0.0339457403866848*std::sin(0.353839844465256*x_92 + 1.99631977081299) + 0.0936465884960042*std::sin(0.359439849853516*x_92 - 1.18815994262695) + 0.000765171696168042*std::sin(0.373199850320816*x_92 - 7.38935995101929) + 0.0139112432822678*std::sin(0.381119847297668*x_92 + 8.18279933929443) + 0.0205237112709274*std::sin(0.38487982749939*x_92 - 1.19791984558105) + 0.0185600003877539*std::sin(0.353119850158691*x_95 - 1.21815991401672) + 0.00448003853896173*std::sin(0.364959836006165*x_95 + 5.16431999206543) + 0.0223981143936158*std::sin(0.38919985294342*x_95 + 1.98527979850769) + 0.0211444164059697*std::sin(0.386959850788116*x_96 + 5.19655990600586) - 0.0208274168559352*std::sin(0.415279865264893*x_96 - 7.3996000289917) + 0.0065534597880652*std::sin(0.439519852399826*x_96 + 8.20975971221924) + 0.0261153100998208*std::sin(0.305199921131134*x_97 + 5.11439990997314) + 0.0240004489253105*std::sin(0.353279858827591*x_97 + 5.16728019714355) + 0.0195736490889959*std::sin(0.37255984544754*x_98 + 5.18039989471436) + 0.0114434613845031*std::sin(0.415599852800369*x_98 - 7.38839960098267) - 0.00104344066046829*std::sin(0.436959862709045*x_98 - 7.37871980667114) + 0.0104209594574515*std::sin(0.451919853687286*x_98 + 2.00551986694336) - 0.0168893924987291*std::sin(0.406159847974777*x_99 - 4.20160007476807) + 0.00707492618535669*std::sin(0.407679855823517*x_99 + 5.20464038848877) + 0.0204457775341363*std::sin(0.443759858608246*x_99 + 5.22552013397217) + 0.00446611267195616*std::sin(0.681439816951752*x_99 + 8.60767936706543) + 1.20449627339594 - 0.000104629320451932*std::exp(-2.08247995376587*x_54));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0407979413002265*x_1 + 0.0104608394959483*x_10 - 0.00473656767743275*x_100 - 0.0107477249529532*x_101 + 0.00465769082354911*x_102 + 0.0149355193909279*x_103 - 0.00492598220497094*x_104 - 0.0172672490066237*x_105 + 0.00273076732117551*x_106 - 0.0271698394810626*x_107 + 0.00127203514760113*x_108 - 0.00436739190292118*x_109 - 0.00477706020453429*x_11 - 0.00173950213704281*x_110 + 0.00528022347998629*x_111 - 0.000646485689444751*x_112 + 0.016239110504894*x_113 + 0.00358788492859662*x_114 - 0.000690018501573272*x_115 + 0.00124591076601076*x_116 + 0.00401491257784*x_117 - 0.0201888756702424*x_118 - 0.011470889740734*x_119 - 0.0327422166665552*x_12 - 0.00891232047510781*x_120 - 0.00870705363990523*x_13 - 0.0148091465595266*x_14 - 0.00174681970225662*x_15 - 0.00562452780105512*x_16 - 0.00709722349364886*x_17 + 0.0111400652803474*x_18 - 0.000659972057937973*x_19 + 0.0359796527466363*x_2 + 0.0058062723177878*x_20 - 0.00332486183105375*x_21 + 0.00655837354490676*x_22 + 0.0115290412489347*x_23 - 0.00261986520155243*x_24 + 0.00413750797994748*x_25 - 0.00782830182443512*x_26 - 0.0098830371420929*x_27 - 0.00200221135142679*x_28 - 0.015515305897302*x_29 - 0.00479512249771001*x_3 - 0.0144657041991729*x_30 + 0.0234908498668288*x_32 + 0.00306627333628766*x_33 + 0.0155730385499936*x_34 - 0.0118726089658516*x_35 - 0.00538743411028647*x_36 - 0.00434161027504403*x_37 + 0.00974038483455999*x_38 - 0.00701976886180726*x_39 - 0.014235787476268*x_4 - 0.00643049707393691*x_40 - 0.0059177432828528*x_41 - 0.00739924795760934*x_42 - 0.0163969181316332*x_43 - 0.00114226818069553*x_44 - 0.00694585816147133*x_45 - 0.00854449439688768*x_46 - 0.00837734441722332*x_47 + 0.0259929771612085*x_48 - 0.0183064873825774*x_49 - 0.0146487104914278*x_5 - 0.00972445768026987*x_50 + 0.00781922613700281*x_51 + 0.0142875360780877*x_52 - 0.00163231341671711*x_53 - 0.0141536059312685*x_54 + 0.0103162640729615*x_55 + 0.00328260531854857*x_56 + 0.0145986529334553*x_57 - 0.000704266927264957*x_58 + 0.00175440971378312*x_59 + 0.00715564984142344*x_6 + 0.00184669296993656*x_60 - 0.0021042927655023*x_61 + 0.000706237128637361*x_62 - 0.00986803944705572*x_63 + 0.000915167982781333*x_64 + 0.0157984770546517*x_65 - 0.00465578417286067*x_66 + 0.000573064831371987*x_67 + 0.00428196889620869*x_68 - 0.000317182606962245*x_69 + 0.0147722337853443*x_7 + 0.00084483838781536*x_70 - 0.00225311762991856*x_71 + 0.0129680964445604*x_72 + 0.00178882941136214*x_73 - 0.000905570140863686*x_74 + 0.00131205102367844*x_75 - 0.0019854715891737*x_76 - 0.0167420680114372*x_77 - 0.0170047574185892*x_78 + 0.00206153174475799*x_79 - 0.0601007601326572*x_8 - 0.0133738335579141*x_80 + 0.00296953215856775*x_81 - 0.00992913153639511*x_82 + 0.0014758305975718*x_83 + 0.00115994434876296*x_84 + 0.00166243416269222*x_85 - 0.0115527386963063*x_86 - 0.000416565989433019*x_87 + 0.00408687331912642*x_88 - 0.00447379585556153*x_89 - 0.0306563188711931*x_9 - 0.00273170707995609*x_90 - 0.0459893539995933*x_91 - 0.00363093933757683*x_92 - 0.0169523203173075*x_93 - 0.0209695707274498*x_94 - 0.00507884605732249*x_95 - 0.00155281202275409*x_96 - 0.0226212759764949*x_97 - 0.0019116807657783*x_98 - 0.000266590496243694*x_99 - 1.01593976374744e-5*std::pow(-8.29967975616455*x_104 - 9.30575942993164, 2) - 5.17847316828062e-5*std::pow(-5.02359962463379*x_104 - 6.63000011444092, 2) + 1.75660573201059e-5*std::pow(-7.76968002319336*x_106 - 8.38871955871582, 2) - 4.84566351866401e-5*std::pow(-6.33696031570435*x_106 - 6.55055999755859, 2) - 0.000100513329690997*std::pow(-4.04055976867676*x_107 - 6.8732795715332, 2) - 5.2096683239463e-5*std::pow(-5.1199197769165*x_112 - 7.47016000747681, 2) - 1.03542531684062e-5*std::pow(-5.11528015136719*x_114 - 6.48727989196777, 2) + 0.00221919777646332*std::pow(-1.28807985782623*x_114 - 1.71615982055664, 2) + 4.12186154249361e-6*std::pow(-9.0*x_115 - 9.99927997589111, 2) + 1.33975815019204e-5*std::pow(-8.35487937927246*x_115 - 9.57288074493408, 2) - 3.73191727825742e-5*std::pow(-8.12743949890137*x_115 - 9.94367980957031, 2) - 3.36347793327734e-5*std::pow(-7.13303995132446*x_115 - 8.96848011016846, 2) + 1.1703765150775e-5*std::pow(-7.52023983001709*x_12 - 5.48464012145996, 2) + 4.95163731059038e-5*std::pow(-5.54967975616455*x_120 - 6.57407999038696, 2) - 4.96213854465521e-5*std::pow(-7.13495969772339*x_14 - 9.12439918518066, 2) + 1.05184235334477e-5*std::pow(-7.84424018859863*x_15 - 8.04736042022705, 2) + 0.000102395899546263*std::pow(-6.59600019454956*x_15 - 9.96271991729736, 2) + 3.40056206779032e-5*std::pow(-4.43039989471436*x_15 - 5.83872032165527, 2) + 2.17511410593639e-5*std::pow(-6.48343992233276*x_19 - 8.70903968811035, 2) + 0.000222452060020309*std::pow(-4.24728012084961*x_21 - 5.46327972412109, 2) - 3.38648279795105e-5*std::pow(-3.86207985877991*x_24 - 5.49304008483887, 2) - 2.64988539478788e-5*std::pow(-8.15999984741211*x_45 - 9.98680019378662, 2) - 2.49924987827884e-5*std::pow(-5.56400012969971*x_47 - 6.5978798866272, 2) + 2.80043082876588e-5*std::pow(-8.39575958251953*x_48 - 7.98016023635864, 2) + 3.21506999339711e-6*std::pow(-7.48736000061035*x_55 - 8.30447959899902, 2) + 2.37494085241388e-5*std::pow(-5.89743947982788*x_55 - 7.46456003189087, 2) + 3.17480791445524e-5*std::pow(-4.72551965713501*x_55 - 7.19879961013794, 2) - 1.83467623665095e-5*std::pow(-8.09127998352051*x_59 - 9.45944023132324, 2) - 7.03449009478391e-5*std::pow(-3.35439991950989*x_60 - 4.39711999893188, 2) + 4.20768514611093e-6*std::pow(-7.65072011947632*x_66 - 9.26943969726563, 2) - 8.48276521575272e-6*std::pow(-8.26799964904785*x_67 - 7.86800003051758, 2) - 3.5001590573762e-5*std::pow(-7.10328006744385*x_67 - 8.67744064331055, 2) + 9.90117623346149e-5*std::pow(-5.22671985626221*x_7 - 8.03615951538086, 2) + 2.09482377755811e-5*std::pow(-6.26759958267212*x_70 - 9.014479637146, 2) + 1.78451518759088e-5*std::pow(-5.07919979095459*x_71 - 7.71488046646118, 2) - 6.28948110120747e-5*std::pow(-3.47183990478516*x_78 - 4.69567966461182, 2) + 1.76175619056492e-5*std::pow(-6.55936002731323*x_79 - 9.14999961853027, 2) + 9.72702985390324e-6*std::pow(-7.44632005691528*x_82 - 8.2236795425415, 2) + 1.4125306663949e-5*std::pow(-9.99993991851807*x_84 - 8.60000038146973, 2) - 2.47802364956306e-5*std::pow(-8.00255966186523*x_84 - 8.5984001159668, 2) + 8.3037719479791e-6*std::pow(-7.19600009918213*x_87 - 9.9973201751709, 2) + 1.97560135104713e-5*std::pow(-4.31935977935791*x_87 - 6.28535985946655, 2) + 0.00012245301334019*std::pow(-4.3907995223999*x_90 - 5.78359985351563, 2) + 0.00108203239519459*std::exp(0.380719840526581*x_1) - 0.000287133145323477*std::exp(0.815199851989746*x_1) + 0.000560438707868167*std::exp(1.00071978569031*x_1) + 3.99901522177964e-5*std::exp(1.15455985069275*x_1) - 1.18688618495722e-5*std::exp(1.16367983818054*x_1) + 5.08788975091379e-5*std::exp(1.20775985717773*x_1) - 3.40891266507496e-6*std::exp(1.34047985076904*x_1) - 4.98350506472689e-6*std::exp(1.38623988628387*x_1) - 2.95876608469965e-5*std::exp(1.20671987533569*x_100) + 0.000278209261971747*std::exp(1.51599979400635*x_100) - 0.00126639451801982*std::exp(1.56199979782104*x_100) - 0.00219637697198928*std::exp(0.623199820518494*x_104) - 0.00105878764074981*std::exp(0.879519879817963*x_104) + 0.00344542382595447*std::exp(0.884399890899658*x_104) + 0.0138962026180835*std::exp(0.60591983795166*x_106) - 0.00259295115527407*std::exp(0.726879835128784*x_106) - 0.00146270034007869*std::exp(1.03599977493286*x_106) + 0.0190014125973555*std::exp(0.550239861011505*x_109) + 0.0010463104845856*std::exp(0.644079864025116*x_109) - 0.002796135130626*std::exp(0.68751984834671*x_109) - 0.0012455392433003*std::exp(0.815999865531921*x_109) + 0.00181140236727012*std::exp(0.963039815425873*x_109) - 0.00320626295556842*std::exp(1.03647983074188*x_109) - 0.0061073627727006*std::exp(0.64031982421875*x_110) + 0.000244201915209843*std::exp(0.954399824142456*x_110) - 0.00258740760182132*std::exp(1.00471985340118*x_110) - 0.000313103363933417*std::exp(1.11807978153229*x_110) + 0.000358183173294138*std::exp(1.24599981307983*x_110) + 0.00108487392038295*std::exp(1.35839986801147*x_110) - 0.000899804630431856*std::exp(0.422239869832993*x_112) - 0.00042225691348356*std::exp(0.832239866256714*x_112) - 0.00148128986258399*std::exp(0.840879857540131*x_112) + 0.00199582763412756*std::exp(0.667279839515686*x_114) - 0.00143508601272091*std::exp(0.739199817180634*x_114) - 0.000582193288076855*std::exp(1.27807986736298*x_23) + 0.00034586589092556*std::exp(1.61607992649078*x_23) - 0.0174658269168874*std::exp(0.619119822978973*x_26) - 0.000374161190206375*std::exp(0.657599866390228*x_26) + 0.00306777583100082*std::exp(0.88647985458374*x_26) + 0.000321172715366204*std::exp(0.919839859008789*x_26) + 9.1696607209372e-5*std::exp(1.32983994483948*x_26) + 7.03813250334979e-5*std::exp(1.48503994941711*x_26) + 0.00151065030507415*std::exp(0.493599832057953*x_31) + 0.000520921114114747*std::exp(0.610639870166779*x_31) - 0.00446252174952213*std::exp(0.643439829349518*x_31) + 0.0156301127367416*std::exp(0.645119845867157*x_31) + 0.031996619095607*std::exp(0.645279824733734*x_31) - 0.00309836405882741*std::exp(0.650719821453094*x_31) + 0.00572004720641641*std::exp(0.652079820632935*x_31) - 0.00760808559441266*std::exp(0.660639822483063*x_31) + 0.000727445703446691*std::exp(0.66271984577179*x_31) + 0.000248448258967925*std::exp(0.662879824638367*x_31) - 0.00258729243996522*std::exp(0.51231986284256*x_45) + 0.00495257356084536*std::exp(0.891679883003235*x_45) + 0.00373885299534048*std::exp(0.86599987745285*x_49) - 0.00259951864401974*std::exp(0.91407984495163*x_50) - 0.000452787395272591*std::exp(0.959999799728394*x_50) + 0.0002083707798941*std::exp(1.3595198392868*x_50) - 0.00294309003916773*std::exp(0.910159826278687*x_52) - 0.00461075639276312*std::exp(0.954559803009033*x_6) + 0.0019546093021365*std::exp(1.37487983703613*x_60) + 0.00482820022648149*std::exp(0.692239880561829*x_66) - 0.00093661737632423*std::exp(0.945199847221375*x_66) - 4.43685866593864e-5*std::exp(1.67783987522125*x_66) - 0.00587054386502097*std::exp(0.66951984167099*x_68) + 0.000999029821044642*std::exp(1.33463990688324*x_68) - 0.00347437048123166*std::exp(0.661919832229614*x_70) - 0.00771424608047195*std::exp(0.710639834403992*x_70) + 0.000358851609020666*std::exp(0.77295982837677*x_70) + 0.00149338616744133*std::exp(0.801199853420258*x_72) - 0.00466466691828758*std::exp(0.824319899082184*x_72) - 0.00125721847335408*std::exp(0.90671980381012*x_72) - 0.00434665038793141*std::exp(0.693759858608246*x_74) + 0.00636317117771678*std::exp(1.17047989368439*x_74) - 0.000598732744157779*std::exp(1.25959992408752*x_74) - 0.000118741309935324*std::exp(1.45263981819153*x_74) + 0.000164580151441266*std::exp(1.60871982574463*x_74) + 0.000105565490909414*std::exp(0.611519813537598*x_78) - 0.00138831142358946*std::exp(0.926559805870056*x_78) + 0.000361051516080778*std::exp(1.16831982135773*x_81) - 0.00172199636077886*std::exp(1.27199983596802*x_81) - 0.000241266669655969*std::exp(2.01087975502014*x_81) + 0.000334068313640813*std::exp(0.700319886207581*x_87) - 0.00248668636230008*std::exp(0.611999809741974*x_90) + 0.00607496696032228*std::sin(0.364159852266312*x_100 + 5.18175983428955) - 0.0253895655467787*std::sin(0.235039994120598*x_102 - 1.34447979927063) - 0.102581204224348*std::sin(0.323359847068787*x_102 + 1.94719982147217) + 0.0148610265876109*std::sin(0.375599831342697*x_102 + 1.9761598110199) - 0.0233030386648919*std::sin(0.377599835395813*x_102 + 5.17960023880005) - 0.0058440133345061*std::sin(0.442639857530594*x_102 + 8.43080043792725) + 0.0480029922409726*std::sin(0.459279865026474*x_102 + 5.24032020568848) - 0.017163093913795*std::sin(0.521439850330353*x_103 + 8.35359954833984) - 0.00549549836320596*std::sin(0.325759828090668*x_105 + 1.9398398399353) + 0.0334903531547814*std::sin(0.326879858970642*x_105 - 7.46807956695557) - 0.0253822417515349*std::sin(0.267679959535599*x_106 - 7.52112007141113) + 0.0438406887699384*std::sin(0.526319861412048*x_106 - 4.0403995513916) + 0.0135975672343842*std::sin(0.272559970617294*x_107 - 7.52992010116577) - 0.00385758967673676*std::sin(0.584239840507507*x_107 + 2.17967987060547) - 0.00653391104488761*std::sin(0.444399863481522*x_108 + 2.046719789505) - 0.00163740033742192*std::sin(0.472879856824875*x_109 - 7.34272003173828) - 0.00166457008086401*std::sin(0.535279810428619*x_109 + 8.36967945098877) + 0.00525254037733215*std::sin(0.611279845237732*x_110 - 0.978959858417511) + 0.0988426200540109*std::sin(0.230719983577728*x_111 - 7.57328033447266) - 0.0165935863040016*std::sin(0.247679978609085*x_111 + 5.05423974990845) + 0.0380739155780461*std::sin(0.29775995016098*x_111 - 4.2792797088623) - 0.0100592980232218*std::sin(0.326159834861755*x_111 - 7.47175979614258) + 0.00889287203448612*std::sin(0.414799869060516*x_111 - 1.16295981407166) + 0.0164434339480007*std::sin(0.453359842300415*x_111 + 8.24512004852295) + 0.0214159016518482*std::sin(0.455839842557907*x_111 - 4.36560010910034) - 0.00971688172748711*std::sin(0.535999834537506*x_112 - 0.999279797077179) - 0.0125935614660877*std::sin(0.5933598279953*x_112 - 1.00103986263275) - 0.0214594102764069*std::sin(0.337679862976074*x_115 + 5.1374397277832) - 0.0161319085222227*std::sin(0.342799842357635*x_115 - 7.43576002120972) + 0.0360885644221431*std::sin(0.493279844522476*x_115 - 4.12056016921997) + 0.0259123123403736*std::sin(0.301039934158325*x_116 + 1.90431988239288) - 0.0156803249972203*std::sin(0.396719843149185*x_117 + 1.99855983257294) - 0.00556222029865661*std::sin(0.550879836082458*x_117 + 8.3601598739624) - 0.00869970022961296*std::sin(0.597839832305908*x_117 + 5.40000009536743) - 0.00177440652446181*std::sin(0.294559925794601*x_119 - 4.29423999786377) - 0.0315471848723784*std::sin(0.300399929285049*x_119 + 8.296799659729) - 0.0146131763177198*std::sin(0.36575984954834*x_119 + 5.16232013702393) - 0.00708513940873399*std::sin(0.45279985666275*x_119 - 1.16775989532471) - 0.0577947917480896*std::sin(0.29615992307663*x_120 - 7.47679996490479) - 0.00712643829944385*std::sin(0.304079920053482*x_120 - 7.47528028488159) - 0.058149766554252*std::sin(0.405039846897125*x_120 + 5.21120023727417) + 0.012671532676201*std::sin(0.449199855327606*x_120 - 4.16680002212524) + 0.164472319371253*std::sin(0.183280006051064*x_15 + 1.78319990634918) - 0.0514018151631924*std::sin(0.346639841794968*x_16 - 7.43271970748901) + 0.0106378969198079*std::sin(0.375999838113785*x_16 + 5.18239974975586) - 0.0104309019896684*std::sin(0.387439846992493*x_16 - 7.39447975158691) + 0.0231123694154357*std::sin(0.274959951639175*x_18 - 7.52424001693726) - 0.0151868071324251*std::sin(0.25655996799469*x_20 - 7.54432010650635) + 0.0166174783182429*std::sin(0.343279838562012*x_20 - 7.44608020782471) - 0.186302517982024*std::sin(0.234959989786148*x_21 + 5.042799949646) + 0.0131875469641976*std::sin(0.420959860086441*x_21 + 8.42536067962646) - 0.00859460058640887*std::sin(0.457599848508835*x_22 - 7.32376003265381) - 0.0100214878167669*std::sin(0.266079962253571*x_24 + 5.06623983383179) + 0.0208754989756955*std::sin(0.305119842290878*x_24 + 5.10567998886108) - 0.15740261107359*std::sin(0.306879937648773*x_24 + 5.1399998664856) - 0.0138040350289219*std::sin(0.313759922981262*x_24 - 7.46903991699219) - 0.0329113584716868*std::sin(0.351119846105576*x_24 - 4.26471996307373) + 0.0143449681596067*std::sin(0.404879868030548*x_24 + 8.39160060882568) - 0.00658286836194933*std::sin(0.788399875164032*x_25 - 4.00871992111206) - 0.0197478695610948*std::sin(0.290719836950302*x_27 - 4.32800006866455) - 0.025724487747586*std::sin(0.317679852247238*x_28 + 5.11696004867554) - 0.00286923540955536*std::sin(0.320399850606918*x_28 - 4.27432012557983) - 0.0179628349672413*std::sin(0.324319839477539*x_28 + 8.30976009368896) - 0.0182092069145281*std::sin(0.330559849739075*x_28 + 5.13048028945923) - 0.00391621640241095*std::sin(0.338479846715927*x_28 + 8.32632064819336) - 0.0191294416637726*std::sin(0.33943983912468*x_28 + 8.31999969482422) - 0.00407269707625258*std::sin(0.291439920663834*x_3 + 5.0874400138855) - 0.0800684198015686*std::sin(0.303439915180206*x_3 - 7.50208044052124) + 0.0760462476600976*std::sin(0.271119952201843*x_33 - 1.1729599237442) + 0.091029666202351*std::sin(0.34895983338356*x_34 - 7.40207958221436) - 0.0207290766066266*std::sin(0.355359852313995*x_34 - 7.41152000427246) - 0.0495258416241258*std::sin(0.369519829750061*x_34 + 8.19623947143555) + 0.0137118566351735*std::sin(0.31007993221283*x_35 + 8.25119972229004) - 0.0144093845115957*std::sin(0.314959853887558*x_35 + 1.97399973869324) + 0.00340436754551617*std::sin(0.331679850816727*x_35 - 7.42903995513916) + 0.0204226083493494*std::sin(0.326639831066132*x_36 - 7.46719980239868) + 0.00918581423222666*std::sin(0.332639843225479*x_36 - 4.26639986038208) - 0.0156214647114405*std::sin(0.365359842777252*x_36 + 5.18416023254395) - 0.0117915862663499*std::sin(0.418479859828949*x_36 + 5.22432041168213) + 0.0602264348167672*std::sin(0.29367995262146*x_37 - 1.33159983158112) + 0.0124984157076194*std::sin(0.428959846496582*x_37 - 1.1684798002243) - 0.0106778038442585*std::sin(0.47775986790657*x_38 - 7.32087993621826) + 0.0121792175985241*std::sin(0.479759842157364*x_38 + 5.2579197883606) - 0.00487091550273987*std::sin(0.635359883308411*x_38 - 0.950879812240601) + 0.00984419367918003*std::sin(0.317439913749695*x_41 + 1.91527986526489) + 0.00485936593398908*std::sin(0.387199848890305*x_41 + 1.97423982620239) - 0.0239350203217338*std::sin(0.355519831180573*x_43 + 8.34455966949463) - 0.0157372190665341*std::sin(0.401679843664169*x_43 + 1.97855985164642) + 0.0176411143237055*std::sin(0.352319836616516*x_44 + 5.15360021591187) + 0.263793860071959*std::sin(0.182240009307861*x_46 + 4.96335983276367) - 0.0280583830176205*std::sin(0.265519976615906*x_48 - 7.5195198059082) + 0.0134277169663511*std::sin(0.220799997448921*x_51 + 5.01679992675781) + 0.0193098477002609*std::sin(0.186400011181831*x_53 - 4.42840003967285) + 0.0192219377649784*std::sin(0.354639858007431*x_53 - 4.25040006637573) + 0.156921357900337*std::sin(0.280239939689636*x_54 - 1.33415985107422) + 0.0011763411063277*std::sin(0.53823983669281*x_54 - 1.03471982479095) + 0.0091150888659332*std::sin(0.356959849596024*x_55 - 7.43415975570679) - 0.00400304660245347*std::sin(0.487919867038727*x_55 + 2.06407976150513) + 0.0623306622390957*std::sin(0.239359974861145*x_56 + 1.83567988872528) + 0.0107031193453197*std::sin(0.395439833402634*x_56 + 5.18455982208252) - 0.156037362057239*std::sin(0.139120042324066*x_58 - 7.6723198890686) + 0.318840168496811*std::sin(0.184960007667542*x_58 - 7.6159200668335) - 0.0169492838331972*std::sin(0.255359977483749*x_58 + 5.05471992492676) - 0.059362393012196*std::sin(0.277119934558868*x_58 + 5.09000015258789) - 0.0095002943191868*std::sin(0.386319845914841*x_58 + 5.19648027420044) + 0.00805661647971575*std::sin(0.490319848060608*x_58 - 4.12143993377686) + 0.00228637795104502*std::sin(0.605599880218506*x_58 - 0.993359804153442) - 0.0149008564270323*std::sin(0.298159927129745*x_59 + 5.10799980163574) - 0.0181276150117541*std::sin(0.362959831953049*x_59 - 4.22071981430054) - 0.135090875105007*std::sin(0.125840052962303*x_63 - 1.45423996448517) - 0.154940936489849*std::sin(0.164000019431114*x_64 - 1.42503988742828) + 0.167120206380699*std::sin(0.179200008511543*x_64 - 4.42479991912842) - 0.039521983415189*std::sin(0.281999945640564*x_64 + 5.10519981384277) + 0.00399551424114758*std::sin(0.417919874191284*x_64 + 1.99703979492188) + 0.0762981658854249*std::sin(0.398639857769012*x_65 - 7.40407991409302) + 0.0164664493250234*std::sin(0.440159857273102*x_66 - 4.15623998641968) - 0.0222788598502957*std::sin(0.243359968066216*x_69 - 7.54400014877319) + 0.0286584232270665*std::sin(0.254959970712662*x_70 - 7.52400016784668) - 0.013446115920249*std::sin(0.515119850635529*x_70 + 5.33439970016479) - 0.0158871065345273*std::sin(0.514559864997864*x_72 - 4.07624006271362) - 0.0424797718743559*std::sin(0.245599970221519*x_73 + 1.86039984226227) - 0.0103841090849166*std::sin(0.42799985408783*x_73 - 4.17216014862061) + 0.0258885788655317*std::sin(0.225519984960556*x_74 + 1.8199999332428) + 0.0423792527022208*std::sin(0.199359983205795*x_75 - 7.59999990463257) - 0.0251985443218925*std::sin(0.382159858942032*x_75 - 7.40551996231079) - 0.0233015031208696*std::sin(0.527119874954224*x_75 - 7.25256013870239) - 0.0476430075718771*std::sin(0.262239962816238*x_76 - 7.52232027053833) + 0.0668475921083229*std::sin(0.289119929075241*x_77 - 7.48000001907349) + 0.0447811001455597*std::sin(0.231439992785454*x_79 + 1.83111989498138) - 0.0116098655751331*std::sin(0.367839843034744*x_79 + 8.36952018737793) + 0.0111320524501814*std::sin(0.375919848680496*x_79 - 7.42759990692139) - 0.0504248840514149*std::sin(0.465919852256775*x_81 + 8.46975994110107) - 0.00519911293055313*std::sin(0.263439983129501*x_82 + 1.86799991130829) - 0.0192984327617829*std::sin(0.397759824991226*x_82 - 7.40991973876953) - 0.366430421078452*std::sin(0.158560022711754*x_84 - 7.65680027008057) - 0.00561441883088815*std::sin(0.353839844465256*x_84 + 5.14383983612061) - 0.055697791992071*std::sin(0.174960017204285*x_85 - 4.43856000900269) - 0.0213161456473799*std::sin(0.212719991803169*x_85 - 7.58776044845581) + 0.090860083568031*std::sin(0.21399998664856*x_85 - 7.5816798210144) + 0.00515864375882888*std::sin(0.631679832935333*x_86 - 7.16951990127563) - 0.00857045186314074*std::sin(0.51615983247757*x_87 + 5.32791996002197) + 0.00638708193861531*std::sin(0.797919869422913*x_87 - 0.793519854545593) - 0.0154979268019455*std::sin(0.988159835338593*x_87 + 5.58551979064941) + 0.0359822611657031*std::sin(0.225519984960556*x_89 + 1.8122398853302) - 0.00323935962424807*std::sin(0.321119844913483*x_90 + 8.31783962249756) + 0.00409744573425957*std::sin(0.351999849081039*x_92 - 7.39856004714966) - 0.069173083333898*std::sin(0.353839844465256*x_92 + 1.99631977081299) + 0.091106868949768*std::sin(0.359439849853516*x_92 - 1.18815994262695) + 0.0133302730696096*std::sin(0.373199850320816*x_92 - 7.38935995101929) - 0.0138534777148996*std::sin(0.381119847297668*x_92 + 8.18279933929443) - 0.00489290687055147*std::sin(0.38487982749939*x_92 - 1.19791984558105) + 0.00995576791556596*std::sin(0.353119850158691*x_95 - 1.21815991401672) + 0.014355667473775*std::sin(0.364959836006165*x_95 + 5.16431999206543) - 0.0456418571468098*std::sin(0.38919985294342*x_95 + 1.98527979850769) - 0.0111425511611704*std::sin(0.386959850788116*x_96 + 5.19655990600586) + 0.042441161258941*std::sin(0.415279865264893*x_96 - 7.3996000289917) + 0.0103437487504728*std::sin(0.439519852399826*x_96 + 8.20975971221924) - 0.0260068679085441*std::sin(0.305199921131134*x_97 + 5.11439990997314) - 0.0126476051599999*std::sin(0.353279858827591*x_97 + 5.16728019714355) - 0.0103147981101695*std::sin(0.37255984544754*x_98 + 5.18039989471436) - 0.0113959431270678*std::sin(0.415599852800369*x_98 - 7.38839960098267) - 0.0181780755948419*std::sin(0.436959862709045*x_98 - 7.37871980667114) + 0.0164480732090621*std::sin(0.451919853687286*x_98 + 2.00551986694336) + 0.0168192603530684*std::sin(0.406159847974777*x_99 - 4.20160007476807) + 0.0226706281285746*std::sin(0.407679855823517*x_99 + 5.20464038848877) - 0.0416634740348721*std::sin(0.443759858608246*x_99 + 5.22552013397217) - 0.00106473303433312*std::sin(0.681439816951752*x_99 + 8.60767936706543) - 0.286710510709919 + 0.000213208862742305*std::exp(-2.08247995376587*x_54));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00810711628434849*x_1 + 0.00609180490684539*x_10 - 0.00615534174930833*x_100 + 0.0214001106177751*x_101 - 0.00319460420768225*x_102 - 0.0118235076507978*x_103 + 0.00665147052485706*x_104 + 0.0044416982029333*x_105 - 0.00530522093990686*x_106 + 0.023604233727483*x_107 - 0.000443582012610706*x_108 - 0.00150983495830886*x_109 + 0.00230306862626763*x_11 + 0.00248789336033585*x_110 + 3.25848679565087e-5*x_111 + 0.00369823358494458*x_112 - 0.0126255901687952*x_113 + 0.000958822692910465*x_114 + 0.000390839447029325*x_115 + 0.014215986053501*x_116 + 0.0215676164030866*x_117 + 0.0147097773011776*x_118 - 0.000136732664205914*x_119 + 0.0390175557890927*x_12 + 0.0118107582911557*x_120 + 0.006433117215536*x_13 + 0.00218079535712618*x_14 - 0.000127225741564604*x_15 - 0.00506570182465377*x_16 + 0.0120641105348855*x_17 - 0.0126888650778108*x_18 - 0.0126181482008512*x_19 - 0.0033853499613627*x_2 - 0.00409208678880714*x_20 - 0.00133636416263622*x_21 - 0.00368719795133076*x_22 - 0.013328783365368*x_23 - 0.00105044101483334*x_24 + 0.00035541320994185*x_25 + 0.0220547256544083*x_26 + 0.00102977584464091*x_27 + 0.00272682193340524*x_28 + 0.00895676945149038*x_29 + 0.012462515825064*x_3 + 0.00212555669512788*x_30 - 0.0126741538363079*x_32 - 0.0132107535044206*x_33 - 0.0104710523221031*x_34 + 0.00481741851222915*x_35 + 0.00665495535806681*x_36 + 0.012235712671618*x_37 - 0.0109843426039019*x_38 + 0.0232520685842285*x_39 - 0.00512900095187056*x_4 + 0.00212098828039308*x_40 + 0.0149627334863556*x_41 - 0.0149348206330916*x_42 + 0.0113904764274309*x_43 - 0.0165959403566819*x_44 - 0.00149458994106645*x_45 + 0.00249263860181964*x_46 - 0.0106894079561834*x_47 - 0.0128435111287364*x_48 + 0.0236448066291196*x_49 + 0.0144773253643845*x_5 + 0.0149031757713699*x_50 + 0.0036034104773478*x_51 - 0.0120759994103422*x_52 - 0.0144118794044689*x_53 + 0.0239219148068749*x_54 - 0.00868334353106653*x_55 - 0.0137967608913355*x_56 - 0.00820638629853366*x_57 + 0.000950705375816574*x_58 - 0.00201830579162183*x_59 + 0.0020054882477115*x_6 + 0.0134586608197431*x_60 + 0.0212211069798434*x_61 + 0.00571814602055957*x_62 - 0.00116864443392885*x_63 + 0.00216947479201918*x_64 - 0.0193076815118751*x_65 + 0.00187327854826115*x_66 - 0.00288608916812151*x_67 + 0.00336401552907392*x_68 - 0.00106421753937704*x_69 - 0.00852023027393159*x_7 - 0.00122062038800955*x_70 + 0.00820646229640306*x_71 - 0.00204892184657409*x_72 - 0.00591112220770399*x_73 + 0.00289045376997108*x_74 - 0.0083225449668049*x_75 + 0.00019993800806348*x_76 + 0.0219025554237922*x_77 + 0.00546769118349214*x_78 + 0.00496498807420684*x_79 + 0.0579654275303266*x_8 + 0.0090456231002525*x_80 - 0.013716727102209*x_81 + 0.0194008738065829*x_82 + 0.0161962616760616*x_83 + 0.007686109482186*x_84 + 0.00111528692691906*x_85 - 0.00125524414580236*x_86 - 0.00441193140603067*x_87 - 0.00681933721098904*x_88 + 0.00683367260944959*x_89 + 0.0428258780354195*x_9 + 0.00511075531701988*x_90 + 0.0212869496251363*x_91 + 0.0048687822665929*x_92 - 0.00114767540431398*x_93 + 0.00355252725224634*x_94 + 0.00157382098393408*x_95 - 0.000220866656286844*x_96 + 0.0114409894923073*x_97 + 0.0078685376996377*x_98 + 0.0101738046896798*x_99 + 4.02001689966891e-5*std::pow(-8.29967975616455*x_104 - 9.30575942993164, 2) - 6.92651219680915e-5*std::pow(-5.02359962463379*x_104 - 6.63000011444092, 2) + 2.34956340071102e-5*std::pow(-7.76968002319336*x_106 - 8.38871955871582, 2) + 1.03651613786372e-5*std::pow(-6.33696031570435*x_106 - 6.55055999755859, 2) + 0.00019965931167967*std::pow(-4.04055976867676*x_107 - 6.8732795715332, 2) + 0.000103484661669871*std::pow(-5.1199197769165*x_112 - 7.47016000747681, 2) - 4.56412327915442e-5*std::pow(-5.11528015136719*x_114 - 6.48727989196777, 2) - 0.00108781659278698*std::pow(-1.28807985782623*x_114 - 1.71615982055664, 2) + 3.81607440690812e-7*std::pow(-9.0*x_115 - 9.99927997589111, 2) - 3.1254159206367e-5*std::pow(-8.35487937927246*x_115 - 9.57288074493408, 2) + 1.8293284092356e-5*std::pow(-8.12743949890137*x_115 - 9.94367980957031, 2) + 6.68120030519756e-5*std::pow(-7.13303995132446*x_115 - 8.96848011016846, 2) - 2.73027888864731e-5*std::pow(-7.52023983001709*x_12 - 5.48464012145996, 2) - 0.000115512834025451*std::pow(-5.54967975616455*x_120 - 6.57407999038696, 2) + 9.83737780506848e-6*std::pow(-7.13495969772339*x_14 - 9.12439918518066, 2) - 4.16208144136064e-5*std::pow(-7.84424018859863*x_15 - 8.04736042022705, 2) - 5.0192893910199e-5*std::pow(-6.59600019454956*x_15 - 9.96271991729736, 2) + 4.54845161365908e-5*std::pow(-4.43039989471436*x_15 - 5.83872032165527, 2) - 6.26262991639167e-5*std::pow(-6.48343992233276*x_19 - 8.70903968811035, 2) - 0.000109042575905688*std::pow(-4.24728012084961*x_21 - 5.46327972412109, 2) + 9.75042570130537e-5*std::pow(-3.86207985877991*x_24 - 5.49304008483887, 2) + 5.26372268812371e-5*std::pow(-8.15999984741211*x_45 - 9.98680019378662, 2) - 3.34289359087668e-5*std::pow(-5.56400012969971*x_47 - 6.5978798866272, 2) - 5.99028747210082e-6*std::pow(-8.39575958251953*x_48 - 7.98016023635864, 2) + 1.41719306668578e-5*std::pow(-7.48736000061035*x_55 - 8.30447959899902, 2) + 2.1987519258918e-6*std::pow(-5.89743947982788*x_55 - 7.46456003189087, 2) - 9.14096734952898e-5*std::pow(-4.72551965713501*x_55 - 7.19879961013794, 2) + 4.27997121601445e-5*std::pow(-8.09127998352051*x_59 - 9.45944023132324, 2) + 0.000278350843924788*std::pow(-3.35439991950989*x_60 - 4.39711999893188, 2) + 1.85473480456468e-5*std::pow(-7.65072011947632*x_66 - 9.26943969726563, 2) + 3.35658281525115e-5*std::pow(-8.26799964904785*x_67 - 7.86800003051758, 2) + 7.48704761295632e-6*std::pow(-7.10328006744385*x_67 - 8.67744064331055, 2) - 1.96289584513996e-5*std::pow(-5.22671985626221*x_7 - 8.03615951538086, 2) - 6.03145647536328e-5*std::pow(-6.26759958267212*x_70 - 9.014479637146, 2) + 1.65212796837048e-6*std::pow(-5.07919979095459*x_71 - 7.71488046646118, 2) - 5.82288551316309e-6*std::pow(-3.47183990478516*x_78 - 4.69567966461182, 2) + 2.35645244171529e-5*std::pow(-6.55936002731323*x_79 - 9.14999961853027, 2) + 9.00541400967471e-7*std::pow(-7.44632005691528*x_82 - 8.2236795425415, 2) - 2.80584576638586e-5*std::pow(-9.99993991851807*x_84 - 8.60000038146973, 2) + 5.78078555816099e-5*std::pow(-8.00255966186523*x_84 - 8.5984001159668, 2) + 7.68774285230222e-7*std::pow(-7.19600009918213*x_87 - 9.9973201751709, 2) - 7.81734419856075e-5*std::pow(-4.31935977935791*x_87 - 6.28535985946655, 2) - 2.61934251043791e-5*std::pow(-4.3907995223999*x_90 - 5.78359985351563, 2) - 0.00311540825842482*std::exp(0.380719840526581*x_1) + 0.000669830225408855*std::exp(0.815199851989746*x_1) - 0.000274718428490261*std::exp(1.00071978569031*x_1) + 5.34891787767609e-5*std::exp(1.15455985069275*x_1) - 5.23175817547046e-5*std::exp(1.16367983818054*x_1) - 0.000101065656534556*std::exp(1.20775985717773*x_1) + 1.34888770103338e-5*std::exp(1.34047985076904*x_1) - 4.61379547521052e-7*std::exp(1.38623988628387*x_1) - 0.000130421508389957*std::exp(1.20671987533569*x_100) + 0.000372121237996565*std::exp(1.51599979400635*x_100) + 0.000251061134466858*std::exp(1.56199979782104*x_100) + 0.00632385036486729*std::exp(0.623199820518494*x_104) - 9.8023972337791e-5*std::exp(0.879519879817963*x_104) - 0.00803755698551679*std::exp(0.884399890899658*x_104) - 0.00275490484555521*std::exp(0.60591983795166*x_106) + 0.00515062872230564*std::exp(0.726879835128784*x_106) - 0.000135418748912495*std::exp(1.03599977493286*x_106) - 0.00931419999110492*std::exp(0.550239861011505*x_109) - 0.004140192145664*std::exp(0.644079864025116*x_109) - 0.000258869920792714*std::exp(0.68751984834671*x_109) + 0.0035861802862863*std::exp(0.815999865531921*x_109) - 0.00359816305892881*std::exp(0.963039815425873*x_109) + 0.000635637633904753*std::exp(1.03647983074188*x_109) + 0.0142473840074541*std::exp(0.64031982421875*x_110) + 0.00107643460894331*std::exp(0.954399824142456*x_110) + 0.00513961702793598*std::exp(1.00471985340118*x_110) + 0.00123893252264554*std::exp(1.11807978153229*x_110) + 3.31610760454119e-5*std::exp(1.24599981307983*x_110) - 0.000215074902275112*std::exp(1.35839986801147*x_110) + 0.00259073461115014*std::exp(0.422239869832993*x_112) - 3.90931083946551e-5*std::exp(0.832239866256714*x_112) + 0.000293663868630843*std::exp(0.840879857540131*x_112) + 0.00266953675364958*std::exp(0.667279839515686*x_114) + 0.00334779875830429*std::exp(0.739199817180634*x_114) + 0.00135815271672907*std::exp(1.27807986736298*x_23) - 0.00068702674489012*std::exp(1.61607992649078*x_23) + 0.00856147952581977*std::exp(0.619119822978973*x_26) - 0.00164929113727659*std::exp(0.657599866390228*x_26) - 0.000656215427243971*std::exp(0.88647985458374*x_26) + 2.97345984737928e-5*std::exp(0.919839859008789*x_26) - 0.000213911769075233*std::exp(1.32983994483948*x_26) - 1.39530099481322e-5*std::exp(1.48503994941711*x_26) + 0.000139858020643117*std::exp(0.493599832057953*x_31) + 0.000696762604196172*std::exp(0.610639870166779*x_31) + 0.0104102643601345*std::exp(0.643439829349518*x_31) - 0.00309865036502772*std::exp(0.645119845867157*x_31) - 0.0156842501981757*std::exp(0.645279824733734*x_31) + 0.00892086874602464*std::exp(0.650719821453094*x_31) - 0.00122355198951733*std::exp(0.652079820632935*x_31) + 0.0151126734896785*std::exp(0.660639822483063*x_31) - 0.00287846201694123*std::exp(0.66271984577179*x_31) + 0.00109515236297379*std::exp(0.662879824638367*x_31) - 0.000239534985868669*std::exp(0.51231986284256*x_45) - 0.000981841534390581*std::exp(0.891679883003235*x_45) - 0.000741222945344667*std::exp(0.86599987745285*x_49) + 0.000515351330528366*std::exp(0.91407984495163*x_50) - 0.00199587305589267*std::exp(0.959999799728394*x_50) + 0.00027870816387262*std::exp(1.3595198392868*x_50) + 0.00584614332485051*std::exp(0.910159826278687*x_52) + 0.000986268111776554*std::exp(0.954559803009033*x_6) - 0.000418102511055411*std::exp(1.37487983703613*x_60) - 0.00959071932881423*std::exp(0.692239880561829*x_66) + 0.00269672656950345*std::exp(0.945199847221375*x_66) - 4.10770294625518e-6*std::exp(1.67783987522125*x_66) + 0.0116612269325745*std::exp(0.66951984167099*x_68) + 9.2491513664966e-5*std::exp(1.33463990688324*x_68) + 0.00690147685819834*std::exp(0.661919832229614*x_70) + 0.00152933966861146*std::exp(0.710639834403992*x_70) + 0.00158180696942081*std::exp(0.77295982837677*x_70) - 0.00429978586567866*std::exp(0.801199853420258*x_72) + 0.000997799892613499*std::exp(0.824319899082184*x_72) + 0.00497474327692111*std::exp(0.90671980381012*x_72) + 0.0101399572168568*std::exp(0.693759858608246*x_74) - 0.00311912857126935*std::exp(1.17047989368439*x_74) + 0.00236915202631814*std::exp(1.25959992408752*x_74) + 0.000341882238675642*std::exp(1.45263981819153*x_74) - 0.0003269214128506*std::exp(1.60871982574463*x_74) + 0.000465329470603607*std::exp(0.611519813537598*x_78) + 0.00399725266408343*std::exp(0.926559805870056*x_78) - 0.00103954639427646*std::exp(1.16831982135773*x_81) + 0.000368345224635405*std::exp(1.27199983596802*x_81) + 0.000118265207960186*std::exp(2.01087975502014*x_81) + 0.00147256295776916*std::exp(0.700319886207581*x_87) - 0.00332608914990851*std::exp(0.611999809741974*x_90) - 0.01417181037668*std::sin(0.364159852266312*x_100 + 5.18175983428955) - 0.00235059985122556*std::sin(0.235039994120598*x_102 - 1.34447979927063) + 0.0203365958562513*std::sin(0.323359847068787*x_102 + 1.94719982147217) + 0.0198774964301628*std::sin(0.375599831342697*x_102 + 1.9761598110199) + 0.0462890710533668*std::sin(0.377599835395813*x_102 + 5.17960023880005) + 0.0231244343463314*std::sin(0.442639857530594*x_102 + 8.43080043792725) - 0.0235303279486759*std::sin(0.459279865026474*x_102 + 5.24032020568848) + 0.0340927071827845*std::sin(0.521439850330353*x_103 + 8.35359954833984) - 0.0242239895066465*std::sin(0.325759828090668*x_105 + 1.9398398399353) - 0.0781269984606517*std::sin(0.326879858970642*x_105 - 7.46807956695557) + 0.100436112881608*std::sin(0.267679959535599*x_106 - 7.52112007141113) - 0.0214900308521181*std::sin(0.526319861412048*x_106 - 4.0403995513916) + 0.0012588809154408*std::sin(0.272559970617294*x_107 - 7.52992010116577) + 0.0111068455897375*std::sin(0.584239840507507*x_107 + 2.17967987060547) - 0.00873949001464201*std::sin(0.444399863481522*x_108 + 2.046719789505) - 0.00721761084626157*std::sin(0.472879856824875*x_109 - 7.34272003173828) - 0.00222646030844962*std::sin(0.535279810428619*x_109 + 8.36967945098877) + 0.00702558144177917*std::sin(0.611279845237732*x_110 - 0.978959858417511) - 0.0484511309941234*std::sin(0.230719983577728*x_111 - 7.57328033447266) + 0.0656598941674897*std::sin(0.247679978609085*x_111 + 5.05423974990845) - 0.0756298871068385*std::sin(0.29775995016098*x_111 - 4.2792797088623) - 0.000931303231370917*std::sin(0.326159834861755*x_111 - 7.47175979614258) + 0.0118947389722563*std::sin(0.414799869060516*x_111 - 1.16295981407166) - 0.0383595876939823*std::sin(0.453359842300415*x_111 + 8.24512004852295) - 0.00424567580468594*std::sin(0.455839842557907*x_111 - 4.36560010910034) - 0.0129969003629574*std::sin(0.535999834537506*x_112 - 0.999279797077179) + 0.0293785243985904*std::sin(0.5933598279953*x_112 - 1.00103986263275) + 0.00459029500807495*std::sin(0.337679862976074*x_115 + 5.1374397277832) + 0.0638330609720776*std::sin(0.342799842357635*x_115 - 7.43576002120972) - 0.00715451290745538*std::sin(0.493279844522476*x_115 - 4.12056016921997) - 0.0604487858629602*std::sin(0.301039934158325*x_116 + 1.90431988239288) - 0.00145170540778753*std::sin(0.396719843149185*x_117 + 1.99855983257294) + 0.0160148505077768*std::sin(0.550879836082458*x_117 + 8.3601598739624) + 0.0202948432136812*std::sin(0.597839832305908*x_117 + 5.40000009536743) - 0.00782152994837985*std::sin(0.294559925794601*x_119 - 4.29423999786377) + 0.0735939347241645*std::sin(0.300399929285049*x_119 + 8.296799659729) - 0.0195459821282449*std::sin(0.36575984954834*x_119 + 5.16232013702393) - 0.000655951658936342*std::sin(0.45279985666275*x_119 - 1.16775989532471) + 0.114803363639112*std::sin(0.29615992307663*x_120 - 7.47679996490479) - 0.031413123101138*std::sin(0.304079920053482*x_120 - 7.47528028488159) + 0.0115281187278994*std::sin(0.405039846897125*x_120 + 5.21120023727417) + 0.0169489196490544*std::sin(0.449199855327606*x_120 - 4.16680002212524) - 0.0326064322785515*std::sin(0.183280006051064*x_15 + 1.78319990634918) + 0.0101903457768481*std::sin(0.346639841794968*x_16 - 7.43271970748901) + 0.0142288123099251*std::sin(0.375999838113785*x_16 + 5.18239974975586) + 0.0243334269998191*std::sin(0.387439846992493*x_16 - 7.39447975158691) + 0.0309141523864123*std::sin(0.274959951639175*x_18 - 7.52424001693726) + 0.0437261440319017*std::sin(0.25655996799469*x_20 - 7.54432010650635) + 0.00153846831252934*std::sin(0.343279838562012*x_20 - 7.44608020782471) + 0.0369342419388672*std::sin(0.234959989786148*x_21 + 5.042799949646) - 0.0307641862302829*std::sin(0.420959860086441*x_21 + 8.42536067962646) - 0.0114957833813069*std::sin(0.457599848508835*x_22 - 7.32376003265381) - 0.0441744132506165*std::sin(0.266079962253571*x_24 + 5.06623983383179) + 0.0279222067143858*std::sin(0.305119842290878*x_24 + 5.10567998886108) + 0.0771563372538716*std::sin(0.306879937648773*x_24 + 5.1399998664856) + 0.0546217955828365*std::sin(0.313759922981262*x_24 - 7.46903991699219) + 0.00703993458141032*std::sin(0.351119846105576*x_24 - 4.26471996307373) - 0.0334642426774077*std::sin(0.404879868030548*x_24 + 8.39160060882568) - 0.00880497330338977*std::sin(0.788399875164032*x_25 - 4.00871992111206) + 0.056858441752908*std::sin(0.290719836950302*x_27 - 4.32800006866455) + 0.0600106247123815*std::sin(0.317679852247238*x_28 + 5.11696004867554) - 0.0126475023481984*std::sin(0.320399850606918*x_28 - 4.27432012557983) + 0.071077934648324*std::sin(0.324319839477539*x_28 + 8.30976009368896) - 0.024355884386976*std::sin(0.330559849739075*x_28 + 5.13048028945923) - 0.000362568539265227*std::sin(0.338479846715927*x_28 + 8.32632064819336) + 0.0037923879624289*std::sin(0.33943983912468*x_28 + 8.31999969482422) - 0.017952324742635*std::sin(0.291439920663834*x_3 + 5.0874400138855) + 0.0158734644096397*std::sin(0.303439915180206*x_3 - 7.50208044052124) - 0.01507607379677*std::sin(0.271119952201843*x_33 - 1.1729599237442) - 0.0180465178439314*std::sin(0.34895983338356*x_34 - 7.40207958221436) - 0.0277263581906445*std::sin(0.355359852313995*x_34 - 7.41152000427246) + 0.0105938709708103*std::sin(0.369519829750061*x_34 + 8.19623947143555) - 0.0394794384985809*std::sin(0.31007993221283*x_35 + 8.25119972229004) + 0.0570171296738836*std::sin(0.314959853887558*x_35 + 1.97399973869324) + 0.0150063485145398*std::sin(0.331679850816727*x_35 - 7.42903995513916) - 0.0405673947751013*std::sin(0.326639831066132*x_36 - 7.46719980239868) - 0.0019649000914835*std::sin(0.332639843225479*x_36 - 4.26639986038208) - 0.00144625604400293*std::sin(0.365359842777252*x_36 + 5.18416023254395) - 0.0157719396122154*std::sin(0.418479859828949*x_36 + 5.22432041168213) - 0.0295220713597202*std::sin(0.29367995262146*x_37 - 1.33159983158112) - 0.0248268073989909*std::sin(0.428959846496582*x_37 - 1.1684798002243) - 0.00098856532544781*std::sin(0.47775986790657*x_38 - 7.32087993621826) + 0.0162904192997449*std::sin(0.479759842157364*x_38 + 5.2579197883606) + 0.0113629738756634*std::sin(0.635359883308411*x_38 - 0.950879812240601) - 0.0389529245394865*std::sin(0.317439913749695*x_41 + 1.91527986526489) + 0.0214199371219966*std::sin(0.387199848890305*x_41 + 1.97423982620239) + 0.0051198426650997*std::sin(0.355519831180573*x_43 + 8.34455966949463) + 0.0312603545841722*std::sin(0.401679843664169*x_43 + 1.97855985164642) + 0.0016332378995755*std::sin(0.352319836616516*x_44 + 5.15360021591187) - 0.129307689970257*std::sin(0.182240009307861*x_46 + 4.96335983276367) + 0.0557350697401524*std::sin(0.265519976615906*x_48 - 7.5195198059082) + 0.00124315595102447*std::sin(0.220799997448921*x_51 + 5.01679992675781) + 0.00178773146187924*std::sin(0.186400011181831*x_53 - 4.42840003967285) + 0.0257104714167391*std::sin(0.354639858007431*x_53 - 4.25040006637573) - 0.0769204343556493*std::sin(0.280239939689636*x_54 - 1.33415985107422) + 0.00518527578985491*std::sin(0.53823983669281*x_54 - 1.03471982479095) - 0.036067897517736*std::sin(0.356959849596024*x_55 - 7.43415975570679) + 0.00933839109735243*std::sin(0.487919867038727*x_55 + 2.06407976150513) - 0.0133328979706721*std::sin(0.239359974861145*x_56 + 1.83567988872528) - 0.0249684613581503*std::sin(0.395439833402634*x_56 + 5.18455982208252) + 0.033377316286832*std::sin(0.139120042324066*x_58 - 7.6723198890686) - 0.156290543103632*std::sin(0.184960007667542*x_58 - 7.6159200668335) + 0.0670673694229736*std::sin(0.255359977483749*x_58 + 5.05471992492676) + 0.117917241075486*std::sin(0.277119934558868*x_58 + 5.09000015258789) + 0.0273534281514172*std::sin(0.386319845914841*x_58 + 5.19648027420044) + 0.000745892302241618*std::sin(0.490319848060608*x_58 - 4.12143993377686) + 0.00305816487790879*std::sin(0.605599880218506*x_58 - 0.993359804153442) - 0.00137954116764946*std::sin(0.298159927129745*x_59 + 5.10799980163574) - 0.0242467504219327*std::sin(0.362959831953049*x_59 - 4.22071981430054) - 0.0125068934456048*std::sin(0.125840052962303*x_63 - 1.45423996448517) + 0.0759496622622886*std::sin(0.164000019431114*x_64 - 1.42503988742828) - 0.033131372577228*std::sin(0.179200008511543*x_64 - 4.42479991912842) + 0.0785063237796485*std::sin(0.281999945640564*x_64 + 5.10519981384277) + 0.0176121051548729*std::sin(0.417919874191284*x_64 + 1.99703979492188) - 0.0151260162708912*std::sin(0.398639857769012*x_65 - 7.40407991409302) - 0.00807160001241212*std::sin(0.440159857273102*x_66 - 4.15623998641968) + 0.0881562040383025*std::sin(0.243359968066216*x_69 - 7.54400014877319) + 0.00265323505633787*std::sin(0.254959970712662*x_70 - 7.52400016784668) + 0.0313673813156867*std::sin(0.515119850635529*x_70 + 5.33439970016479) + 0.00314959906506151*std::sin(0.514559864997864*x_72 - 4.07624006271362) + 0.0843816639924026*std::sin(0.245599970221519*x_73 + 1.86039984226227) + 0.0298981244399024*std::sin(0.42799985408783*x_73 - 4.17216014862061) + 0.0346274956812605*std::sin(0.225519984960556*x_74 + 1.8199999332428) + 0.0566847410799759*std::sin(0.199359983205795*x_75 - 7.59999990463257) + 0.0587836928547317*std::sin(0.382159858942032*x_75 - 7.40551996231079) + 0.00461949394526436*std::sin(0.527119874954224*x_75 - 7.25256013870239) + 0.0946378965595278*std::sin(0.262239962816238*x_76 - 7.52232027053833) - 0.0142990960331293*std::sin(0.289119929075241*x_77 - 7.48000001907349) - 0.00957894265530046*std::sin(0.231439992785454*x_79 + 1.83111989498138) - 0.0010748568439809*std::sin(0.367839843034744*x_79 + 8.36952018737793) - 0.032051617207151*std::sin(0.375919848680496*x_79 - 7.42759990692139) + 0.0099966704018138*std::sin(0.465919852256775*x_81 + 8.46975994110107) - 0.022917531541237*std::sin(0.263439983129501*x_82 + 1.86799991130829) + 0.00382589023693938*std::sin(0.397759824991226*x_82 - 7.40991973876953) + 0.179618552424071*std::sin(0.158560022711754*x_84 - 7.65680027008057) + 0.0161651415148798*std::sin(0.353839844465256*x_84 + 5.14383983612061) + 0.11063789096831*std::sin(0.174960017204285*x_85 - 4.43856000900269) - 0.0285115975341743*std::sin(0.212719991803169*x_85 - 7.58776044845581) - 0.0194355102336689*std::sin(0.21399998664856*x_85 - 7.5816798210144) + 0.000477594121478274*std::sin(0.631679832935333*x_86 - 7.16951990127563) - 0.0114634830447369*std::sin(0.51615983247757*x_87 + 5.32791996002197) - 0.00136623467100702*std::sin(0.797919869422913*x_87 - 0.793519854545593) + 0.00759684517881139*std::sin(0.988159835338593*x_87 + 5.58551979064941) + 0.0481283889544156*std::sin(0.225519984960556*x_89 + 1.8122398853302) - 0.0142789986202928*std::sin(0.321119844913483*x_90 + 8.31783962249756) + 0.0180614160738014*std::sin(0.351999849081039*x_92 - 7.39856004714966) + 0.0137134775374218*std::sin(0.353839844465256*x_92 + 1.99631977081299) - 0.0446591848692149*std::sin(0.359439849853516*x_92 - 1.18815994262695) - 0.0028514243932872*std::sin(0.373199850320816*x_92 - 7.38935995101929) - 0.0185298406001659*std::sin(0.381119847297668*x_92 + 8.18279933929443) + 0.0193609591926682*std::sin(0.38487982749939*x_92 - 1.19791984558105) - 0.0286648363957137*std::sin(0.353119850158691*x_95 - 1.21815991401672) - 0.033489202261969*std::sin(0.364959836006165*x_95 + 5.16431999206543) + 0.00904844128066021*std::sin(0.38919985294342*x_95 + 1.98527979850769) - 0.00103159225207945*std::sin(0.386959850788116*x_96 + 5.19655990600586) - 0.00841390731098681*std::sin(0.415279865264893*x_96 - 7.3996000289917) - 0.020546784810093*std::sin(0.439519852399826*x_96 + 8.20975971221924) - 0.0347857142280309*std::sin(0.305199921131134*x_97 + 5.11439990997314) - 0.00117093215922426*std::sin(0.353279858827591*x_97 + 5.16728019714355) - 0.000954957770290098*std::sin(0.37255984544754*x_98 + 5.18039989471436) - 0.0152427436618324*std::sin(0.415599852800369*x_98 - 7.38839960098267) + 0.00388839807732979*std::sin(0.436959862709045*x_98 - 7.37871980667114) - 0.0326723926614911*std::sin(0.451919853687286*x_98 + 2.00551986694336) + 0.0224967491751082*std::sin(0.406159847974777*x_99 - 4.20160007476807) - 0.0528865169237633*std::sin(0.407679855823517*x_99 + 5.20464038848877) + 0.00825973178830655*std::sin(0.443759858608246*x_99 + 5.22552013397217) + 0.00421308914602044*std::sin(0.681439816951752*x_99 + 8.60767936706543) + 0.0886022606089721 - 4.22683912452263e-5*std::exp(-2.08247995376587*x_54));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.029451518929318*x_1 - 0.0166727962732474*x_10 + 0.0145199428937952*x_100 - 0.00855662664534701*x_101 + 0.00910948493104595*x_102 - 0.00225312737468094*x_103 + 0.00256008115415751*x_104 + 0.0175818679855304*x_105 + 0.00336445585532572*x_106 + 0.00992793142394965*x_107 - 0.00233537027285993*x_108 + 0.00413445553951235*x_109 + 0.00425058189324832*x_11 - 0.000129725602614659*x_110 - 0.000204591488026951*x_111 - 0.00112959709942263*x_112 - 0.00566607563265213*x_113 + 0.00170097988057432*x_114 - 0.00462228674882295*x_115 - 0.0165700231805123*x_116 - 0.0075778501634622*x_117 + 0.0127297607478468*x_118 + 0.00489334944681602*x_119 + 0.0257087484201748*x_12 + 0.00730470787317882*x_120 - 0.000211442959868621*x_13 + 0.0098663948832403*x_14 + 0.00429763839280348*x_15 + 0.00719787983122732*x_16 - 0.00143087679814807*x_17 - 0.00556996734331536*x_18 + 0.0193320003387788*x_19 - 0.0391173900354573*x_2 - 0.00403604391462192*x_20 - 0.000561664898839795*x_21 - 0.00132227039486315*x_22 + 0.00482849602959383*x_23 + 0.00196048451520378*x_24 - 0.00152744679178015*x_25 - 0.00763559239681585*x_26 + 0.0136664646633305*x_27 + 0.00188357164161467*x_28 + 0.0164619259408564*x_29 - 0.00567404004020836*x_3 + 0.0121936416508119*x_30 - 0.0258069023335876*x_32 + 0.00412233868725274*x_33 - 0.00788463972469651*x_34 + 0.00948160313688402*x_35 + 0.00258820110587249*x_36 + 0.00269331577361893*x_37 + 0.00071896590519624*x_38 - 0.00932842184940724*x_39 + 0.0127656801003392*x_4 + 0.000744178239295889*x_40 - 0.00869312857211309*x_41 - 0.00697211276624741*x_42 + 0.00730234954938049*x_43 + 0.00899708463589881*x_44 + 0.00989404590733879*x_45 - 0.00246544855276575*x_46 + 0.0250940720629183*x_47 - 0.00519127633781761*x_48 - 0.00926248032692384*x_49 - 0.00940881289426236*x_5 - 0.00865513410762624*x_50 - 0.00967636434584364*x_51 - 0.00734991695938885*x_52 + 0.016210911160395*x_53 - 0.00606169553512597*x_54 - 0.00533139466843132*x_55 + 0.00178476888337542*x_56 - 0.0173152571073398*x_57 - 0.00173418684529691*x_58 + 0.00463809143644109*x_59 - 0.0104371983610106*x_6 - 0.0139351982696398*x_60 - 0.0155707087793982*x_61 - 0.00995062874961994*x_62 + 0.014031246902354*x_63 - 0.00381443117812159*x_64 + 0.00616712566635578*x_65 + 0.00402624452367655*x_66 + 0.00288958585550609*x_67 - 0.0131488926534049*x_68 - 0.00117797691732508*x_69 - 0.0139662491105069*x_7 - 0.000921588522244578*x_70 + 0.00398981641231554*x_71 - 0.0111680311628446*x_72 + 0.00185009965307097*x_73 + 0.00316637809426672*x_74 + 0.00925808084869061*x_75 + 0.0102238566901538*x_76 + 0.00043541229144257*x_77 + 0.00989478340278734*x_78 - 0.00140996718328141*x_79 + 0.0152118498691482*x_8 + 0.00723532029170027*x_80 + 0.00507050879799904*x_81 - 0.00932722886755632*x_82 - 0.0176659825346815*x_83 - 0.00483099922870837*x_84 - 0.00646978688316226*x_85 + 0.00595557662578586*x_86 + 0.00374198902494682*x_87 - 0.000113042515033891*x_88 + 0.00925617273118887*x_89 - 0.00145192249364358*x_9 - 0.00447257557044301*x_90 + 0.02419008398918*x_91 + 0.000650052695730787*x_92 + 0.0530715472537362*x_93 + 0.0186344213446015*x_94 + 0.00876604875090862*x_95 + 0.0118704891555478*x_96 + 0.0170699279131922*x_97 - 0.00269975756959174*x_98 + 0.00199125550546211*x_99 - 6.75301217557502e-6*std::pow(-8.29967975616455*x_104 - 9.30575942993164, 2) + 8.1300123208588e-5*std::pow(-5.02359962463379*x_104 - 6.63000011444092, 2) - 2.75780636107438e-5*std::pow(-7.76968002319336*x_106 - 8.38871955871582, 2) + 2.32148035308784e-5*std::pow(-6.33696031570435*x_106 - 6.55055999755859, 2) - 1.37279181097287e-5*std::pow(-4.04055976867676*x_107 - 6.8732795715332, 2) - 7.11526524390809e-6*std::pow(-5.1199197769165*x_112 - 7.47016000747681, 2) - 5.44968727594221e-5*std::pow(-5.11528015136719*x_114 - 6.48727989196777, 2) - 0.00169789007539766*std::pow(-1.28807985782623*x_114 - 1.71615982055664, 2) - 5.62153922671001e-6*std::pow(-9.0*x_115 - 9.99927997589111, 2) + 1.7301131511802e-5*std::pow(-8.35487937927246*x_115 - 9.57288074493408, 2) + 2.85525939876186e-5*std::pow(-8.12743949890137*x_115 - 9.94367980957031, 2) - 4.59377375855122e-6*std::pow(-7.13303995132446*x_115 - 8.96848011016846, 2) + 1.5113800951894e-5*std::pow(-7.52023983001709*x_12 - 5.48464012145996, 2) + 6.3943576903779e-5*std::pow(-5.54967975616455*x_120 - 6.57407999038696, 2) + 3.61899076207886e-5*std::pow(-7.13495969772339*x_14 - 9.12439918518066, 2) + 6.99165882898604e-6*std::pow(-7.84424018859863*x_15 - 8.04736042022705, 2) - 7.8342265590265e-5*std::pow(-6.59600019454956*x_15 - 9.96271991729736, 2) - 5.3387573152493e-5*std::pow(-4.43039989471436*x_15 - 5.83872032165527, 2) + 9.03815041930289e-5*std::pow(-6.48343992233276*x_19 - 8.70903968811035, 2) - 0.000170196252432343*std::pow(-4.24728012084961*x_21 - 5.46327972412109, 2) - 0.000140716943707589*std::pow(-3.86207985877991*x_24 - 5.49304008483887, 2) - 3.61916273310689e-6*std::pow(-8.15999984741211*x_45 - 9.98680019378662, 2) + 3.9237303434862e-5*std::pow(-5.56400012969971*x_47 - 6.5978798866272, 2) - 1.34164188745691e-5*std::pow(-8.39575958251953*x_48 - 7.98016023635864, 2) + 1.6921670495504e-5*std::pow(-7.48736000061035*x_55 - 8.30447959899902, 2) - 3.23902756687063e-5*std::pow(-5.89743947982788*x_55 - 7.46456003189087, 2) + 0.000131921315782589*std::pow(-4.72551965713501*x_55 - 7.19879961013794, 2) - 2.36923170404495e-5*std::pow(-8.09127998352051*x_59 - 9.45944023132324, 2) - 4.67586750259804e-5*std::pow(-3.35439991950989*x_60 - 4.39711999893188, 2) + 2.21460377962357e-5*std::pow(-7.65072011947632*x_66 - 9.26943969726563, 2) - 5.63854460949748e-6*std::pow(-8.26799964904785*x_67 - 7.86800003051758, 2) + 1.67687055716605e-5*std::pow(-7.10328006744385*x_67 - 8.67744064331055, 2) - 7.22113358991305e-5*std::pow(-5.22671985626221*x_7 - 8.03615951538086, 2) + 8.70452375433045e-5*std::pow(-6.26759958267212*x_70 - 9.014479637146, 2) - 2.43378435308455e-5*std::pow(-5.07919979095459*x_71 - 7.71488046646118, 2) + 8.57781474743553e-5*std::pow(-3.47183990478516*x_78 - 4.69567966461182, 2) - 2.7658923914822e-5*std::pow(-6.55936002731323*x_79 - 9.14999961853027, 2) - 1.32660642089438e-5*std::pow(-7.44632005691528*x_82 - 8.2236795425415, 2) + 1.92920733751063e-6*std::pow(-9.99993991851807*x_84 - 8.60000038146973, 2) - 3.20002629163335e-5*std::pow(-8.00255966186523*x_84 - 8.5984001159668, 2) - 1.13249751972451e-5*std::pow(-7.19600009918213*x_87 - 9.9973201751709, 2) + 1.31319399572398e-5*std::pow(-4.31935977935791*x_87 - 6.28535985946655, 2) - 5.86652918740073e-5*std::pow(-4.3907995223999*x_90 - 5.78359985351563, 2) + 0.00449611885631037*std::exp(0.380719840526581*x_1) - 0.000370792915715926*std::exp(0.815199851989746*x_1) - 0.000428787073441705*std::exp(1.00071978569031*x_1) - 6.27830674560879e-5*std::exp(1.15455985069275*x_1) - 6.24686149252091e-5*std::exp(1.16367983818054*x_1) + 6.94894240063453e-6*std::exp(1.20775985717773*x_1) - 2.26592457094199e-6*std::exp(1.34047985076904*x_1) + 6.79667885955285e-6*std::exp(1.38623988628387*x_1) - 0.00015572682666749*std::exp(1.20671987533569*x_100) - 0.000436778303972235*std::exp(1.51599979400635*x_100) + 0.000923607839768509*std::exp(1.56199979782104*x_100) - 0.00912650301708479*std::exp(0.623199820518494*x_104) + 0.0014440116908027*std::exp(0.879519879817963*x_104) + 0.00444929039753852*std::exp(0.884399890899658*x_104) - 0.0101347893554864*std::exp(0.60591983795166*x_106) - 0.000354140303893616*std::exp(0.726879835128784*x_106) + 0.00199488198570105*std::exp(1.03599977493286*x_106) - 0.0145378254294223*std::exp(0.550239861011505*x_109) + 0.000695488816755764*std::exp(0.644079864025116*x_109) + 0.00381346708470141*std::exp(0.68751984834671*x_109) - 0.00517553125298985*std::exp(0.815999865531921*x_109) + 0.000247397866910784*std::exp(0.963039815425873*x_109) + 0.00233839420495343*std::exp(1.03647983074188*x_109) - 0.00788681796827514*std::exp(0.64031982421875*x_110) + 0.00128529218711836*std::exp(0.954399824142456*x_110) - 0.000353383175977646*std::exp(1.00471985340118*x_110) - 0.000208121672593721*std::exp(1.11807978153229*x_110) - 0.000488502764651898*std::exp(1.24599981307983*x_110) - 0.000791221095613118*std::exp(1.35839986801147*x_110) - 0.00373891630587688*std::exp(0.422239869832993*x_112) + 0.000575888777055157*std::exp(0.832239866256714*x_112) + 0.00108033548044053*std::exp(0.840879857540131*x_112) - 0.00313337594470051*std::exp(0.667279839515686*x_114) - 0.00185321595791547*std::exp(0.739199817180634*x_114) - 0.000751822456975706*std::exp(1.27807986736298*x_23) + 4.72377011304973e-5*std::exp(1.61607992649078*x_23) + 0.0133629613797004*std::exp(0.619119822978973*x_26) - 0.00196929845567311*std::exp(0.657599866390228*x_26) - 0.00146972262764742*std::exp(0.88647985458374*x_26) - 0.000438026605058601*std::exp(0.919839859008789*x_26) + 0.000118413540554912*std::exp(1.32983994483948*x_26) - 5.13305629874946e-5*std::exp(1.48503994941711*x_26) - 0.00206027782841979*std::exp(0.493599832057953*x_31) - 0.000817826980718824*std::exp(0.610639870166779*x_31) - 0.00576273229998206*std::exp(0.643439829349518*x_31) - 0.0113993660385493*std::exp(0.645119845867157*x_31) - 0.0244803516770324*std::exp(0.645279824733734*x_31) - 0.0128744879824999*std::exp(0.650719821453094*x_31) - 0.00274038367651492*std::exp(0.652079820632935*x_31) - 0.00103909776278418*std::exp(0.660639822483063*x_31) + 0.00048353749579847*std::exp(0.66271984577179*x_31) + 0.00130764169429315*std::exp(0.662879824638367*x_31) + 0.00352864010406223*std::exp(0.51231986284256*x_45) - 0.00361201482061013*std::exp(0.891679883003235*x_45) - 0.00272682318906279*std::exp(0.86599987745285*x_49) + 0.00189588296938873*std::exp(0.91407984495163*x_50) - 0.00238312668870533*std::exp(0.959999799728394*x_50) - 0.000327134456971313*std::exp(1.3595198392868*x_50) - 0.000401961602221917*std::exp(0.910159826278687*x_52) + 0.00220894008373592*std::exp(0.954559803009033*x_6) - 0.000936422241328812*std::exp(1.37487983703613*x_60) + 0.000659426342061062*std::exp(0.692239880561829*x_66) - 0.00389188259569808*std::exp(0.945199847221375*x_66) + 6.05114334307627e-5*std::exp(1.67783987522125*x_66) - 0.000801787640369025*std::exp(0.66951984167099*x_68) - 0.00136251188201192*std::exp(1.33463990688324*x_68) - 0.000474522867721485*std::exp(0.661919832229614*x_70) + 0.00562615998130519*std::exp(0.710639834403992*x_70) + 0.00188872052462315*std::exp(0.77295982837677*x_70) + 0.00620539804261457*std::exp(0.801199853420258*x_72) + 0.00223476775941905*std::exp(0.824319899082184*x_72) - 0.000835680614232618*std::exp(0.90671980381012*x_72) - 0.0056131003932797*std::exp(0.693759858608246*x_74) - 0.00486841024503897*std::exp(1.17047989368439*x_74) - 0.000397981224427995*std::exp(1.25959992408752*x_74) - 0.000493400239211136*std::exp(1.45263981819153*x_74) + 2.2478041951433e-5*std::exp(1.60871982574463*x_74) + 0.000555616038386067*std::exp(0.611519813537598*x_78) - 0.00576878584943767*std::exp(0.926559805870056*x_78) + 0.0015002605622157*std::exp(1.16831982135773*x_81) + 0.000824981079317501*std::exp(1.27199983596802*x_81) + 0.000184591156443007*std::exp(2.01087975502014*x_81) + 0.00175828020479438*std::exp(0.700319886207581*x_87) + 0.00390400608570184*std::exp(0.611999809741974*x_90) + 0.00784498323785692*std::sin(0.364159852266312*x_100 + 5.18175983428955) + 0.0346271792972441*std::sin(0.235039994120598*x_102 - 1.34447979927063) + 0.0748146040482303*std::sin(0.323359847068787*x_102 + 1.94719982147217) - 0.0233312648982986*std::sin(0.375599831342697*x_102 + 1.9761598110199) - 0.00318268440099375*std::sin(0.377599835395813*x_102 + 5.17960023880005) - 0.00388455050293252*std::sin(0.442639857530594*x_102 + 8.43080043792725) - 0.0367266969081181*std::sin(0.459279865026474*x_102 + 5.24032020568848) - 0.00234410250344403*std::sin(0.521439850330353*x_103 + 8.35359954833984) - 0.0289241020263122*std::sin(0.325759828090668*x_105 + 1.9398398399353) + 0.0432481791004227*std::sin(0.326879858970642*x_105 - 7.46807956695557) - 0.0168717274102203*std::sin(0.267679959535599*x_106 - 7.52112007141113) - 0.0335421525519478*std::sin(0.526319861412048*x_106 - 4.0403995513916) - 0.0185448387355762*std::sin(0.272559970617294*x_107 - 7.52992010116577) - 0.0160292628598845*std::sin(0.584239840507507*x_107 + 2.17967987060547) + 0.0102579999108056*std::sin(0.444399863481522*x_108 + 2.046719789505) - 0.00861802356899997*std::sin(0.472879856824875*x_109 - 7.34272003173828) + 0.00261331377542903*std::sin(0.535279810428619*x_109 + 8.36967945098877) - 0.00824629511360339*std::sin(0.611279845237732*x_110 - 0.978959858417511) - 0.0756236805010968*std::sin(0.230719983577728*x_111 - 7.57328033447266) - 0.0110298557400727*std::sin(0.247679978609085*x_111 + 5.05423974990845) + 0.00520006248702512*std::sin(0.29775995016098*x_111 - 4.2792797088623) + 0.0137192231829547*std::sin(0.326159834861755*x_111 - 7.47175979614258) - 0.0139614818613027*std::sin(0.414799869060516*x_111 - 1.16295981407166) + 0.021234430497714*std::sin(0.453359842300415*x_111 + 8.24512004852295) - 0.015619062132618*std::sin(0.455839842557907*x_111 - 4.36560010910034) + 0.0152551467580602*std::sin(0.535999834537506*x_112 - 0.999279797077179) - 0.0162628503581421*std::sin(0.5933598279953*x_112 - 1.00103986263275) + 0.0102808622913349*std::sin(0.337679862976074*x_115 + 5.1374397277832) - 0.0107229757662005*std::sin(0.342799842357635*x_115 - 7.43576002120972) - 0.0263201400132408*std::sin(0.493279844522476*x_115 - 4.12056016921997) + 0.0334621829702197*std::sin(0.301039934158325*x_116 + 1.90431988239288) + 0.0213853767650111*std::sin(0.396719843149185*x_117 + 1.99855983257294) - 0.0231124351533347*std::sin(0.550879836082458*x_117 + 8.3601598739624) - 0.0112344647998008*std::sin(0.597839832305908*x_117 + 5.40000009536743) - 0.00933911939512371*std::sin(0.294559925794601*x_119 - 4.29423999786377) - 0.0407388448598661*std::sin(0.300399929285049*x_119 + 8.296799659729) + 0.0229421490947669*std::sin(0.36575984954834*x_119 + 5.16232013702393) + 0.0096629614319387*std::sin(0.45279985666275*x_119 - 1.16775989532471) - 0.00789350199347407*std::sin(0.29615992307663*x_120 - 7.47679996490479) - 0.0375081229825138*std::sin(0.304079920053482*x_120 - 7.47528028488159) + 0.0424098331965262*std::sin(0.405039846897125*x_120 + 5.21120023727417) - 0.0198938400246427*std::sin(0.449199855327606*x_120 - 4.16680002212524) - 0.119953080524802*std::sin(0.183280006051064*x_15 + 1.78319990634918) + 0.0374884120134143*std::sin(0.346639841794968*x_16 - 7.43271970748901) - 0.0167011067192185*std::sin(0.375999838113785*x_16 + 5.18239974975586) - 0.013470073466924*std::sin(0.387439846992493*x_16 - 7.39447975158691) - 0.0362855695116252*std::sin(0.274959951639175*x_18 - 7.52424001693726) - 0.0631050329162888*std::sin(0.25655996799469*x_20 - 7.54432010650635) - 0.0226634993077647*std::sin(0.343279838562012*x_20 - 7.44608020782471) + 0.13587429803934*std::sin(0.234959989786148*x_21 + 5.042799949646) + 0.0170299008304553*std::sin(0.420959860086441*x_21 + 8.42536067962646) + 0.0134932066633772*std::sin(0.457599848508835*x_22 - 7.32376003265381) - 0.0527454503504775*std::sin(0.266079962253571*x_24 + 5.06623983383179) - 0.0327737652318145*std::sin(0.305119842290878*x_24 + 5.10567998886108) + 0.120427450864447*std::sin(0.306879937648773*x_24 + 5.1399998664856) - 0.00917562437742599*std::sin(0.313759922981262*x_24 - 7.46903991699219) + 0.0157673086030779*std::sin(0.351119846105576*x_24 - 4.26471996307373) + 0.0185245509143865*std::sin(0.404879868030548*x_24 + 8.39160060882568) + 0.0103348610971*std::sin(0.788399875164032*x_25 - 4.00871992111206) - 0.0820574033641837*std::sin(0.290719836950302*x_27 - 4.32800006866455) - 0.0332196333741973*std::sin(0.317679852247238*x_28 + 5.11696004867554) - 0.0151014616397906*std::sin(0.320399850606918*x_28 - 4.27432012557983) - 0.011940003489398*std::sin(0.324319839477539*x_28 + 8.30976009368896) + 0.0285877848078788*std::sin(0.330559849739075*x_28 + 5.13048028945923) + 0.00534107317761085*std::sin(0.338479846715927*x_28 + 8.32632064819336) + 0.0139514993468869*std::sin(0.33943983912468*x_28 + 8.31999969482422) - 0.021435563796087*std::sin(0.291439920663834*x_3 + 5.0874400138855) + 0.0583955625157306*std::sin(0.303439915180206*x_3 - 7.50208044052124) - 0.0554621087855534*std::sin(0.271119952201843*x_33 - 1.1729599237442) - 0.0663898273086855*std::sin(0.34895983338356*x_34 - 7.40207958221436) + 0.0325438875003103*std::sin(0.355359852313995*x_34 - 7.41152000427246) + 0.0237270433363163*std::sin(0.369519829750061*x_34 + 8.19623947143555) + 0.0569762397560578*std::sin(0.31007993221283*x_35 + 8.25119972229004) - 0.00957800378739172*std::sin(0.314959853887558*x_35 + 1.97399973869324) + 0.0179179880901887*std::sin(0.331679850816727*x_35 - 7.42903995513916) + 0.00278928074384589*std::sin(0.326639831066132*x_36 - 7.46719980239868) - 0.00440077755813888*std::sin(0.332639843225479*x_36 - 4.26639986038208) + 0.0213051010444427*std::sin(0.365359842777252*x_36 + 5.18416023254395) + 0.0185123565407453*std::sin(0.418479859828949*x_36 + 5.22432041168213) - 0.0460787528883247*std::sin(0.29367995262146*x_37 - 1.33159983158112) + 0.00170700968581*std::sin(0.428959846496582*x_37 - 1.1684798002243) + 0.0145627630978842*std::sin(0.47775986790657*x_38 - 7.32087993621826) - 0.019120923468509*std::sin(0.479759842157364*x_38 + 5.2579197883606) - 0.00629011659184143*std::sin(0.635359883308411*x_38 - 0.950879812240601) + 0.00654349422538677*std::sin(0.317439913749695*x_41 + 1.91527986526489) + 0.0255759872478409*std::sin(0.387199848890305*x_41 + 1.97423982620239) + 0.0114668877056042*std::sin(0.355519831180573*x_43 + 8.34455966949463) - 0.00214935924702127*std::sin(0.401679843664169*x_43 + 1.97855985164642) - 0.0240595699664359*std::sin(0.352319836616516*x_44 + 5.15360021591187) - 0.201826525655957*std::sin(0.182240009307861*x_46 + 4.96335983276367) - 0.00383216022731957*std::sin(0.265519976615906*x_48 - 7.5195198059082) - 0.0183131909874479*std::sin(0.220799997448921*x_51 + 5.01679992675781) - 0.0263354470279325*std::sin(0.186400011181831*x_53 - 4.42840003967285) - 0.0301777349774204*std::sin(0.354639858007431*x_53 - 4.25040006637573) - 0.120059247996146*std::sin(0.280239939689636*x_54 - 1.33415985107422) + 0.00619136026042198*std::sin(0.53823983669281*x_54 - 1.03471982479095) + 0.00605885390941325*std::sin(0.356959849596024*x_55 - 7.43415975570679) - 0.00516938342244771*std::sin(0.487919867038727*x_55 + 2.06407976150513) - 0.0298616293157123*std::sin(0.239359974861145*x_56 + 1.83567988872528) + 0.0138216046943506*std::sin(0.395439833402634*x_56 + 5.18455982208252) + 0.0747550194041136*std::sin(0.139120042324066*x_58 - 7.6723198890686) - 0.243942006192704*std::sin(0.184960007667542*x_58 - 7.6159200668335) - 0.0112662900082442*std::sin(0.255359977483749*x_58 + 5.05471992492676) - 0.00810760197253671*std::sin(0.277119934558868*x_58 + 5.09000015258789) - 0.0394761308614171*std::sin(0.386319845914841*x_58 + 5.19648027420044) - 0.0109878959077992*std::sin(0.490319848060608*x_58 - 4.12143993377686) - 0.00358952925082118*std::sin(0.605599880218506*x_58 - 0.993359804153442) + 0.0203223102116768*std::sin(0.298159927129745*x_59 + 5.10799980163574) + 0.0284596885228776*std::sin(0.362959831953049*x_59 - 4.22071981430054) + 0.184241669872772*std::sin(0.125840052962303*x_63 - 1.45423996448517) + 0.118544043766206*std::sin(0.164000019431114*x_64 - 1.42503988742828) - 0.121884239548271*std::sin(0.179200008511543*x_64 - 4.42479991912842) - 0.0053978368195116*std::sin(0.281999945640564*x_64 + 5.10519981384277) + 0.0210293323590614*std::sin(0.417919874191284*x_64 + 1.99703979492188) - 0.0556458379825628*std::sin(0.398639857769012*x_65 - 7.40407991409302) - 0.0125983457547222*std::sin(0.440159857273102*x_66 - 4.15623998641968) - 0.0148088909594426*std::sin(0.243359968066216*x_69 - 7.54400014877319) - 0.0390853619622428*std::sin(0.254959970712662*x_70 - 7.52400016784668) - 0.0173638070293371*std::sin(0.515119850635529*x_70 + 5.33439970016479) + 0.0115867969560314*std::sin(0.514559864997864*x_72 - 4.07624006271362) - 0.00580180590379297*std::sin(0.245599970221519*x_73 + 1.86039984226227) - 0.0431486052266312*std::sin(0.42799985408783*x_73 - 4.17216014862061) - 0.040644116191526*std::sin(0.225519984960556*x_74 + 1.8199999332428) - 0.0665338673044125*std::sin(0.199359983205795*x_75 - 7.59999990463257) - 0.0325404498682499*std::sin(0.382159858942032*x_75 - 7.40551996231079) + 0.0169942704698985*std::sin(0.527119874954224*x_75 - 7.25256013870239) - 0.00650699074897424*std::sin(0.262239962816238*x_76 - 7.52232027053833) - 0.0320256186037216*std::sin(0.289119929075241*x_77 - 7.48000001907349) - 0.021453913128132*std::sin(0.231439992785454*x_79 + 1.83111989498138) + 0.0158339415515537*std::sin(0.367839843034744*x_79 + 8.36952018737793) + 0.0462564994846536*std::sin(0.375919848680496*x_79 - 7.42759990692139) + 0.0367759158513476*std::sin(0.465919852256775*x_81 + 8.46975994110107) - 0.0273641556981393*std::sin(0.263439983129501*x_82 + 1.86799991130829) + 0.0140747480665809*std::sin(0.397759824991226*x_82 - 7.40991973876953) + 0.280352919361881*std::sin(0.158560022711754*x_84 - 7.65680027008057) - 0.0233293332851099*std::sin(0.353839844465256*x_84 + 5.14383983612061) - 0.00760709778206007*std::sin(0.174960017204285*x_85 - 4.43856000900269) + 0.0334655642917928*std::sin(0.212719991803169*x_85 - 7.58776044845581) - 0.0435296214998557*std::sin(0.21399998664856*x_85 - 7.5816798210144) - 0.00703553914849246*std::sin(0.631679832935333*x_86 - 7.16951990127563) + 0.0134552940564518*std::sin(0.51615983247757*x_87 + 5.32791996002197) - 0.00305994941187037*std::sin(0.797919869422913*x_87 - 0.793519854545593) + 0.0118573370906122*std::sin(0.988159835338593*x_87 + 5.58551979064941) - 0.0564908259834924*std::sin(0.225519984960556*x_89 + 1.8122398853302) - 0.0170495125426636*std::sin(0.321119844913483*x_90 + 8.31783962249756) + 0.0215658218112656*std::sin(0.351999849081039*x_92 - 7.39856004714966) + 0.0504493672067117*std::sin(0.353839844465256*x_92 + 1.99631977081299) - 0.0697051205759996*std::sin(0.359439849853516*x_92 - 1.18815994262695) - 0.00638632189651637*std::sin(0.373199850320816*x_92 - 7.38935995101929) + 0.0217494502431249*std::sin(0.381119847297668*x_92 + 8.18279933929443) - 0.00325234436625546*std::sin(0.38487982749939*x_92 - 1.19791984558105) + 0.0413687390996978*std::sin(0.353119850158691*x_95 - 1.21815991401672) + 0.0185383676052187*std::sin(0.364959836006165*x_95 + 5.16431999206543) + 0.033287554930594*std::sin(0.38919985294342*x_95 + 1.98527979850769) + 0.0151966017762567*std::sin(0.386959850788116*x_96 + 5.19655990600586) - 0.0309532209038068*std::sin(0.415279865264893*x_96 - 7.3996000289917) + 0.00141272939848513*std::sin(0.439519852399826*x_96 + 8.20975971221924) + 0.0408298256363493*std::sin(0.305199921131134*x_97 + 5.11439990997314) + 0.0172492471660915*std::sin(0.353279858827591*x_97 + 5.16728019714355) + 0.0140676831558085*std::sin(0.37255984544754*x_98 + 5.18039989471436) + 0.0178912113706344*std::sin(0.415599852800369*x_98 - 7.38839960098267) + 0.00870882701364412*std::sin(0.436959862709045*x_98 - 7.37871980667114) + 0.00224644634468868*std::sin(0.451919853687286*x_98 + 2.00551986694336) - 0.0264056198525364*std::sin(0.406159847974777*x_99 - 4.20160007476807) + 0.0292759942271226*std::sin(0.407679855823517*x_99 + 5.20464038848877) + 0.0303860374496641*std::sin(0.443759858608246*x_99 + 5.22552013397217) - 0.000707734395400234*std::sin(0.681439816951752*x_99 + 8.60767936706543) + 1.26068822642846 - 0.000155497654431444*std::exp(-2.08247995376587*x_54));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0230216052916949*x_1 + 0.0101533020956196*x_10 + 0.0111824395735904*x_100 - 0.0206319914402708*x_101 + 0.0149744956738846*x_102 + 0.0149368429329928*x_103 - 0.00467402716486478*x_104 + 0.000887663056874227*x_105 - 0.00530761786211854*x_106 - 0.000764707759160194*x_107 - 0.000775742597732432*x_108 + 0.000209669020841869*x_109 + 0.0109905820652007*x_11 - 0.00546212161571194*x_110 - 0.000822622231544867*x_111 + 0.00114989030916023*x_112 + 0.0229819050779461*x_113 + 0.00818334043713611*x_114 - 0.00358577417152978*x_115 + 0.000141297454579163*x_116 - 0.00141446335915456*x_117 + 0.0111474172288057*x_118 - 0.00175394581376116*x_119 + 0.00851106723284927*x_12 - 0.0029569171035199*x_120 + 0.0126623349803976*x_13 + 0.0170920039145327*x_14 - 0.00182869456454292*x_15 + 0.00766553496089047*x_16 + 0.0145531584198914*x_17 - 0.0223214063532543*x_18 - 0.0274042908697381*x_19 - 0.00918564328459545*x_2 - 0.00523488247010013*x_20 + 0.000209957007514907*x_21 - 0.00768047418095045*x_22 + 0.0297749752807044*x_23 - 0.00233032224642535*x_24 + 0.00365475751933772*x_25 + 0.0018182409995232*x_26 + 0.00255044903186152*x_27 + 0.00386159299997301*x_28 + 0.0263814229319067*x_29 - 0.0174565266170015*x_3 - 0.00574392287147395*x_30 + 0.0422475969074823*x_32 + 0.0173279187263405*x_33 + 0.00762595337034352*x_34 - 0.00172368004615746*x_35 - 0.00608744205993272*x_36 - 0.00686806059962477*x_37 + 0.00778562246381617*x_38 - 0.00287893403625323*x_39 + 0.0308546465210006*x_4 - 0.000882032961977165*x_40 - 0.00349741250215782*x_41 - 0.0218617023874035*x_42 - 0.0133333857734683*x_43 + 0.00967096294530383*x_44 + 0.00500554714399705*x_45 - 0.00470687930451906*x_46 + 0.0058083050310696*x_47 + 0.00462186558269234*x_48 - 0.0106868687328291*x_49 - 0.00138095486584882*x_5 - 0.0150560207414529*x_50 + 0.00938270788006948*x_51 + 0.0115857770734088*x_52 - 0.00118660345933681*x_53 + 0.00273907529071319*x_54 - 0.00424953619311196*x_55 + 0.0168239337526632*x_56 - 0.0125101343526086*x_57 + 0.000834150896571197*x_58 + 0.00889589764030635*x_59 - 0.00645316750439517*x_6 + 0.0160082485798519*x_60 + 0.00602890155396842*x_61 + 0.00739723097024383*x_62 - 0.0134353182138641*x_63 + 0.00889912060397634*x_64 - 0.00368997788334602*x_65 + 0.0003898243110045*x_66 + 0.0161092162042197*x_67 - 0.00643560286608149*x_68 - 0.0169094519721346*x_69 + 0.0119025348201609*x_7 + 0.00152653584644628*x_70 + 0.00679920966223046*x_71 + 0.00499021983572692*x_72 - 0.000451988148399947*x_73 - 0.000720442670450483*x_74 + 0.00524048445851341*x_75 + 0.0125230085758329*x_76 - 0.0106448165101128*x_77 + 0.00137775489148359*x_78 + 0.00952361433697489*x_79 + 0.0220376696375301*x_8 + 0.00677327637870966*x_80 + 0.000648581421200226*x_81 - 0.00663655033859826*x_82 - 0.00101715660914062*x_83 + 0.000998783063016862*x_84 + 0.00224028036746173*x_85 + 0.00216629139700762*x_86 - 0.000188272049534126*x_87 + 0.00544981829361935*x_88 + 0.00527130306735573*x_89 + 0.00198567736188407*x_9 - 0.0115594069235636*x_90 - 0.0350938851942663*x_91 + 0.00738597082450636*x_92 + 0.0676092082778076*x_93 + 0.00350094961956112*x_94 - 0.000566068696886996*x_95 - 0.00267411965952358*x_96 - 0.0316848293963233*x_97 + 0.00332962035461822*x_98 - 0.00384285535813805*x_99 - 7.61308135841059e-6*std::pow(-8.29967975616455*x_104 - 9.30575942993164, 2) + 1.52442348201437e-5*std::pow(-6.33696031570435*x_106 - 6.55055999755859, 2) + 0.000125004535580325*std::pow(-4.04055976867676*x_107 - 6.8732795715332, 2) + 6.47906274087713e-5*std::pow(-5.1199197769165*x_112 - 7.47016000747681, 2) - 3.36938342970193e-7*std::pow(-5.11528015136719*x_114 - 6.48727989196777, 2) + 0.00130962416609592*std::pow(-1.28807985782623*x_114 - 1.71615982055664, 2) - 1.11846820202035e-5*std::pow(-9.0*x_115 - 9.99927997589111, 2) - 1.77384279905554e-5*std::pow(-8.35487937927246*x_115 - 9.57288074493408, 2) - 2.20233144846862e-5*std::pow(-8.12743949890137*x_115 - 9.94367980957031, 2) + 4.1830272489885e-5*std::pow(-7.13303995132446*x_115 - 8.96848011016846, 2) - 1.54958113384595e-5*std::pow(-7.52023983001709*x_12 - 5.48464012145996, 2) - 6.55597891728925e-5*std::pow(-5.54967975616455*x_120 - 6.57407999038696, 2) + 2.83798441025376e-5*std::pow(-7.13495969772339*x_14 - 9.12439918518066, 2) + 7.88212224580922e-6*std::pow(-7.84424018859863*x_15 - 8.04736042022705, 2) + 6.04273066498055e-5*std::pow(-6.59600019454956*x_15 - 9.96271991729736, 2) + 0.000136122956076875*std::pow(-6.48343992233276*x_19 - 8.70903968811035, 2) + 0.000131276534561376*std::pow(-4.24728012084961*x_21 - 5.46327972412109, 2) - 0.000211932812123496*std::pow(-3.86207985877991*x_24 - 5.49304008483887, 2) + 3.29555984400162e-5*std::pow(-8.15999984741211*x_45 - 9.98680019378662, 2) - 8.81002673562585e-6*std::pow(-8.39575958251953*x_48 - 7.98016023635864, 2) + 1.04621776045984e-7*std::pow(-7.48736000061035*x_55 - 8.30447959899902, 2) - 6.4444081823696e-5*std::pow(-5.89743947982788*x_55 - 7.46456003189087, 2) + 0.000198685777960995*std::pow(-4.72551965713501*x_55 - 7.19879961013794, 2) + 2.42911545678234e-5*std::pow(-8.09127998352051*x_59 - 9.45944023132324, 2) - 5.2713898321079e-5*std::pow(-3.35439991950989*x_60 - 4.39711999893188, 2) + 1.36922522350218e-7*std::pow(-7.65072011947632*x_66 - 9.26943969726563, 2) - 6.35667428683061e-6*std::pow(-8.26799964904785*x_67 - 7.86800003051758, 2) + 1.10113395973492e-5*std::pow(-7.10328006744385*x_67 - 8.67744064331055, 2) - 5.66275680150145e-5*std::pow(-5.22671985626221*x_7 - 8.03615951538086, 2) + 0.000131098228034606*std::pow(-6.26759958267212*x_70 - 9.014479637146, 2) - 4.84228660464734e-5*std::pow(-5.07919979095459*x_71 - 7.71488046646118, 2) + 0.000170665233326901*std::pow(-3.47183990478516*x_78 - 4.69567966461182, 2) - 2.63943208172678e-5*std::pow(-7.44632005691528*x_82 - 8.2236795425415, 2) - 1.75670968704837e-5*std::pow(-9.99993991851807*x_84 - 8.60000038146973, 2) + 3.28090887600623e-5*std::pow(-8.00255966186523*x_84 - 8.5984001159668, 2) - 2.25323067863764e-5*std::pow(-7.19600009918213*x_87 - 9.9973201751709, 2) + 1.48044346269399e-5*std::pow(-4.31935977935791*x_87 - 6.28535985946655, 2) - 3.8523155448208e-5*std::pow(-4.3907995223999*x_90 - 5.78359985351563, 2) + 0.00677157339942955*std::exp(0.380719840526581*x_1) + 0.0003801649291174*std::exp(0.815199851989746*x_1) + 0.00033073396306724*std::exp(1.00071978569031*x_1) - 3.86225310458828e-7*std::exp(1.16367983818054*x_1) - 6.3276114456871e-5*std::exp(1.20775985717773*x_1) - 2.55451458728254e-6*std::exp(1.34047985076904*x_1) + 1.35227539596887e-5*std::exp(1.38623988628387*x_1) - 9.62813759332252e-7*std::exp(1.20671987533569*x_100) + 0.000724286084926475*std::exp(1.56199979782104*x_100) - 0.0137453628419023*std::exp(0.623199820518494*x_104) + 0.0028730230180279*std::exp(0.879519879817963*x_104) - 0.00456174888168261*std::exp(0.884399890899658*x_104) - 0.00794762299297886*std::exp(0.60591983795166*x_106) + 0.00322475293519736*std::exp(0.726879835128784*x_106) + 0.00396904117859488*std::exp(1.03599977493286*x_106) + 0.0112133805248824*std::exp(0.550239861011505*x_109) + 0.00078406684427094*std::exp(0.644079864025116*x_109) + 0.00758731995220109*std::exp(0.68751984834671*x_109) - 0.00779483169388952*std::exp(0.815999865531921*x_109) - 0.0022527709744152*std::exp(0.963039815425873*x_109) + 0.00183375054952433*std::exp(1.03647983074188*x_109) + 0.00808616202411005*std::exp(0.64031982421875*x_110) + 7.94658845236805e-6*std::exp(0.954399824142456*x_110) + 0.00321785863245209*std::exp(1.00471985340118*x_110) - 0.000234628219927587*std::exp(1.11807978153229*x_110) - 0.000971930972688321*std::exp(1.24599981307983*x_110) - 0.000620469429748988*std::exp(1.35839986801147*x_110) - 0.00563115589438536*std::exp(0.422239869832993*x_112) + 0.0011457952334054*std::exp(0.832239866256714*x_112) + 0.000847190681849937*std::exp(0.840879857540131*x_112) + 0.00190005710308642*std::exp(0.739199817180634*x_114) + 0.000770825220630727*std::exp(1.27807986736298*x_23) - 0.000430140014276112*std::exp(1.61607992649078*x_23) - 0.0103071791319372*std::exp(0.619119822978973*x_26) - 1.21756006330389e-5*std::exp(0.657599866390228*x_26) - 0.000965108183083909*std::exp(0.88647985458374*x_26) - 0.000871502998803582*std::exp(0.919839859008789*x_26) - 0.000121406513834496*std::exp(1.32983994483948*x_26) - 4.02530282902346e-5*std::exp(1.48503994941711*x_26) - 0.00409915353337079*std::exp(0.493599832057953*x_31) + 0.00590838881620827*std::exp(0.643439829349518*x_31) - 0.00893929419305715*std::exp(0.645119845867157*x_31) + 0.0188822943341957*std::exp(0.645279824733734*x_31) - 0.0193901769814676*std::exp(0.650719821453094*x_31) - 0.00179950057326639*std::exp(0.652079820632935*x_31) + 0.0094618814172077*std::exp(0.660639822483063*x_31) + 0.000545121228815557*std::exp(0.66271984577179*x_31) + 8.08476896681554e-6*std::exp(0.662879824638367*x_31) + 0.00702062476770652*std::exp(0.51231986284256*x_45) - 0.00283251393120679*std::exp(0.891679883003235*x_45) - 0.00213835353799944*std::exp(0.86599987745285*x_49) + 0.00148673668006273*std::exp(0.91407984495163*x_50) - 1.4734180457017e-5*std::exp(0.959999799728394*x_50) + 0.00366020710534869*std::exp(0.910159826278687*x_52) + 0.00145052277936828*std::exp(0.954559803009033*x_6) - 0.00061491110698543*std::exp(1.37487983703613*x_60) - 0.00600464564108654*std::exp(0.692239880561829*x_66) - 0.00586153736166105*std::exp(0.945199847221375*x_66) + 0.000120394275342608*std::exp(1.67783987522125*x_66) + 0.00730096805773816*std::exp(0.66951984167099*x_68) - 0.00271087001877441*std::exp(1.33463990688324*x_68) + 0.00432094001636934*std::exp(0.661919832229614*x_70) + 0.00441199090195129*std::exp(0.710639834403992*x_70) + 1.16774106784007e-5*std::exp(0.77295982837677*x_70) + 0.00934590691686561*std::exp(0.801199853420258*x_72) + 0.00146748278303355*std::exp(0.824319899082184*x_72) - 0.000942113584336566*std::exp(0.90671980381012*x_72) + 0.00575497487329254*std::exp(0.693759858608246*x_74) + 0.00375512396223809*std::exp(1.17047989368439*x_74) - 0.000448668440381154*std::exp(1.25959992408752*x_74) - 0.000743106675310646*std::exp(1.45263981819153*x_74) - 0.000204681960690212*std::exp(1.60871982574463*x_74) + 3.43521266124574e-6*std::exp(0.611519813537598*x_78) - 0.00868832832348975*std::exp(0.926559805870056*x_78) + 0.0022595320186108*std::exp(1.16831982135773*x_81) + 0.000541732144257167*std::exp(1.27199983596802*x_81) - 0.000142379676298382*std::exp(2.01087975502014*x_81) + 1.08709360497806e-5*std::exp(0.700319886207581*x_87) - 0.00804326989578182*std::sin(0.364159852266312*x_100 + 5.18175983428955) + 0.0688946521721442*std::sin(0.235039994120598*x_102 - 1.34447979927063) + 0.0586690306515788*std::sin(0.323359847068787*x_102 + 1.94719982147217) + 0.0289810867361614*std::sin(0.377599835395813*x_102 + 5.17960023880005) - 0.00437929004876433*std::sin(0.442639857530594*x_102 + 8.43080043792725) + 0.0283282001047605*std::sin(0.459279865026474*x_102 + 5.24032020568848) + 0.0213450752294361*std::sin(0.521439850330353*x_103 + 8.35359954833984) - 0.000178829325705877*std::sin(0.325759828090668*x_105 + 1.9398398399353) - 0.0443413027738778*std::sin(0.326879858970642*x_105 - 7.46807956695557) - 0.0190205244846898*std::sin(0.267679959535599*x_106 - 7.52112007141113) + 0.0258718831103471*std::sin(0.526319861412048*x_106 - 4.0403995513916) - 0.0368970340699312*std::sin(0.272559970617294*x_107 - 7.52992010116577) - 0.0241415615252509*std::sin(0.584239840507507*x_107 + 2.17967987060547) - 5.32827377790202e-5*std::sin(0.472879856824875*x_109 - 7.34272003173828) + 0.0583303954410343*std::sin(0.230719983577728*x_111 - 7.57328033447266) - 0.0124346272355944*std::sin(0.247679978609085*x_111 + 5.05423974990845) - 0.0473510543247325*std::sin(0.29775995016098*x_111 - 4.2792797088623) + 0.0272959313592403*std::sin(0.326159834861755*x_111 - 7.47175979614258) - 0.0217711434681143*std::sin(0.453359842300415*x_111 + 8.24512004852295) - 0.0122483470528927*std::sin(0.455839842557907*x_111 - 4.36560010910034) + 0.0166739036578212*std::sin(0.5933598279953*x_112 - 1.00103986263275) + 0.00675103188851928*std::sin(0.337679862976074*x_115 + 5.1374397277832) - 0.0120886627759409*std::sin(0.342799842357635*x_115 - 7.43576002120972) - 0.020640049103183*std::sin(0.493279844522476*x_115 - 4.12056016921997) - 0.0343079597203876*std::sin(0.301039934158325*x_116 + 1.90431988239288) + 0.0425486026785021*std::sin(0.396719843149185*x_117 + 1.99855983257294) - 0.0348094781481813*std::sin(0.550879836082458*x_117 + 8.3601598739624) + 0.0115184226377192*std::sin(0.597839832305908*x_117 + 5.40000009536743) - 5.77410639264568e-5*std::sin(0.294559925794601*x_119 - 4.29423999786377) + 0.0417685436049192*std::sin(0.300399929285049*x_119 + 8.296799659729) + 0.019225544220382*std::sin(0.45279985666275*x_119 - 1.16775989532471) + 0.0718771442916258*std::sin(0.29615992307663*x_120 - 7.47679996490479) - 0.00023190183520146*std::sin(0.304079920053482*x_120 - 7.47528028488159) + 0.0332574613658494*std::sin(0.405039846897125*x_120 + 5.21120023727417) - 0.0940662728566213*std::sin(0.183280006051064*x_15 + 1.78319990634918) + 0.0293981211485947*std::sin(0.346639841794968*x_16 - 7.43271970748901) + 0.0138105376551545*std::sin(0.387439846992493*x_16 - 7.39447975158691) - 0.0950420520281213*std::sin(0.25655996799469*x_20 - 7.54432010650635) - 0.0450915706534706*std::sin(0.343279838562012*x_20 - 7.44608020782471) + 0.106551567810113*std::sin(0.234959989786148*x_21 + 5.042799949646) - 0.0174603417910132*std::sin(0.420959860086441*x_21 + 8.42536067962646) - 0.000326109806681226*std::sin(0.266079962253571*x_24 + 5.06623983383179) - 0.0928886399647927*std::sin(0.306879937648773*x_24 + 5.1399998664856) - 0.0103442394420992*std::sin(0.313759922981262*x_24 - 7.46903991699219) + 0.0103537621805537*std::sin(0.351119846105576*x_24 - 4.26471996307373) - 0.0189927700525292*std::sin(0.404879868030548*x_24 + 8.39160060882568) - 0.123586085600761*std::sin(0.290719836950302*x_27 - 4.32800006866455) + 0.0340592795378084*std::sin(0.317679852247238*x_28 + 5.11696004867554) - 9.33679531264345e-5*std::sin(0.320399850606918*x_28 - 4.27432012557983) - 0.013460692150574*std::sin(0.324319839477539*x_28 + 8.30976009368896) + 0.0106266633975224*std::sin(0.338479846715927*x_28 + 8.32632064819336) + 0.0109406572851782*std::sin(0.33943983912468*x_28 + 8.31999969482422) - 0.000132529867869101*std::sin(0.291439920663834*x_3 + 5.0874400138855) + 0.0457933459748441*std::sin(0.303439915180206*x_3 - 7.50208044052124) - 0.0434929543734957*std::sin(0.271119952201843*x_33 - 1.1729599237442) - 0.0520623862530276*std::sin(0.34895983338356*x_34 - 7.40207958221436) + 0.015580602253447*std::sin(0.369519829750061*x_34 + 8.19623947143555) + 0.0858115191928565*std::sin(0.31007993221283*x_35 + 8.25119972229004) - 0.0107978662245443*std::sin(0.314959853887558*x_35 + 1.97399973869324) + 0.000110781718487214*std::sin(0.331679850816727*x_35 - 7.42903995513916) - 0.0253988071024769*std::sin(0.326639831066132*x_36 - 7.46719980239868) - 0.00288981495786751*std::sin(0.332639843225479*x_36 - 4.26639986038208) + 0.0423888851398903*std::sin(0.365359842777252*x_36 + 5.18416023254395) + 0.0355416697467759*std::sin(0.29367995262146*x_37 - 1.33159983158112) - 0.0155437955923247*std::sin(0.428959846496582*x_37 - 1.1684798002243) + 0.0289742485139101*std::sin(0.47775986790657*x_38 - 7.32087993621826) + 0.00644910306244795*std::sin(0.635359883308411*x_38 - 0.950879812240601) + 0.00737687902982605*std::sin(0.317439913749695*x_41 + 1.91527986526489) + 0.000158128904041093*std::sin(0.387199848890305*x_41 + 1.97423982620239) + 0.00752984743583723*std::sin(0.355519831180573*x_43 + 8.34455966949463) + 0.0195717699014217*std::sin(0.401679843664169*x_43 + 1.97855985164642) - 0.0478692096176859*std::sin(0.352319836616516*x_44 + 5.15360021591187) + 0.15567373835807*std::sin(0.182240009307861*x_46 + 4.96335983276367) + 0.034895124348534*std::sin(0.265519976615906*x_48 - 7.5195198059082) - 0.0364361449256909*std::sin(0.220799997448921*x_51 + 5.01679992675781) - 0.0523973219768362*std::sin(0.186400011181831*x_53 - 4.42840003967285) + 0.0926046360817738*std::sin(0.280239939689636*x_54 - 1.33415985107422) + 3.82793830406978e-5*std::sin(0.53823983669281*x_54 - 1.03471982479095) + 0.00683051452475124*std::sin(0.356959849596024*x_55 - 7.43415975570679) + 0.00530004268981532*std::sin(0.487919867038727*x_55 + 2.06407976150513) - 0.0196089399936258*std::sin(0.239359974861145*x_56 + 1.83567988872528) - 0.0141709540452551*std::sin(0.395439833402634*x_56 + 5.18455982208252) + 0.0490886372682383*std::sin(0.139120042324066*x_58 - 7.6723198890686) + 0.188158439150463*std::sin(0.184960007667542*x_58 - 7.6159200668335) - 0.0127011739665505*std::sin(0.255359977483749*x_58 + 5.05471992492676) + 0.0738267092756649*std::sin(0.277119934558868*x_58 + 5.09000015258789) - 0.0594547266646189*std::sin(0.386319845914841*x_58 + 5.19648027420044) - 0.0218616497801714*std::sin(0.490319848060608*x_58 - 4.12143993377686) + 0.0404335126852022*std::sin(0.298159927129745*x_59 + 5.10799980163574) + 0.366569441089586*std::sin(0.125840052962303*x_63 - 1.45423996448517) - 0.0914359219789859*std::sin(0.164000019431114*x_64 - 1.42503988742828) - 0.0955806727439472*std::sin(0.179200008511543*x_64 - 4.42479991912842) + 0.0491519602148005*std::sin(0.281999945640564*x_64 + 5.10519981384277) + 0.000130018256829362*std::sin(0.417919874191284*x_64 + 1.99703979492188) - 0.0436370333809043*std::sin(0.398639857769012*x_65 - 7.40407991409302) + 0.00971741238863882*std::sin(0.440159857273102*x_66 - 4.15623998641968) - 0.0166949634875295*std::sin(0.243359968066216*x_69 - 7.54400014877319) - 0.0777647059928265*std::sin(0.254959970712662*x_70 - 7.52400016784668) + 0.0178026876693983*std::sin(0.515119850635529*x_70 + 5.33439970016479) + 0.00908627606087165*std::sin(0.514559864997864*x_72 - 4.07624006271362) + 0.0528304471758798*std::sin(0.245599970221519*x_73 + 1.86039984226227) - 0.0649858148133824*std::sin(0.42799985408783*x_73 - 4.17216014862061) + 0.0333629292612729*std::sin(0.382159858942032*x_75 - 7.40551996231079) + 0.0133267747358115*std::sin(0.527119874954224*x_75 - 7.25256013870239) + 0.0592517634574576*std::sin(0.262239962816238*x_76 - 7.52232027053833) - 0.0210299453797283*std::sin(0.289119929075241*x_77 - 7.48000001907349) - 0.014087928381612*std::sin(0.231439992785454*x_79 + 1.83111989498138) + 0.0315034004457642*std::sin(0.367839843034744*x_79 + 8.36952018737793) + 0.0696665927817689*std::sin(0.375919848680496*x_79 - 7.42759990692139) + 0.0288393871994787*std::sin(0.465919852256775*x_81 + 8.46975994110107) - 0.000169184630435796*std::sin(0.263439983129501*x_82 + 1.86799991130829) + 0.0110373079726406*std::sin(0.397759824991226*x_82 - 7.40991973876953) - 0.216243067529486*std::sin(0.158560022711754*x_84 - 7.65680027008057) - 0.0351361469188374*std::sin(0.353839844465256*x_84 + 5.14383983612061) + 0.0692691869050879*std::sin(0.174960017204285*x_85 - 4.43856000900269) - 0.0285841648796702*std::sin(0.21399998664856*x_85 - 7.5816798210144) - 0.0139979932618268*std::sin(0.631679832935333*x_86 - 7.16951990127563) - 0.00200934663566147*std::sin(0.797919869422913*x_87 - 0.793519854545593) - 0.00914585427197004*std::sin(0.988159835338593*x_87 + 5.58551979064941) - 0.00010541218630901*std::sin(0.321119844913483*x_90 + 8.31783962249756) + 0.000133335215360995*std::sin(0.351999849081039*x_92 - 7.39856004714966) + 0.0395620014121205*std::sin(0.353839844465256*x_92 + 1.99631977081299) + 0.0537652653311957*std::sin(0.359439849853516*x_92 - 1.18815994262695) - 0.00419364266848212*std::sin(0.373199850320816*x_92 - 7.38935995101929) - 0.00366656561873632*std::sin(0.38487982749939*x_92 - 1.19791984558105) + 0.0623051707946479*std::sin(0.353119850158691*x_95 - 1.21815991401672) - 0.0190069359685115*std::sin(0.364959836006165*x_95 + 5.16431999206543) + 0.0261038416948666*std::sin(0.38919985294342*x_95 + 1.98527979850769) + 0.0302353415675738*std::sin(0.386959850788116*x_96 + 5.19655990600586) - 0.0242732751054837*std::sin(0.415279865264893*x_96 - 7.3996000289917) - 0.0128641197410082*std::sin(0.439519852399826*x_96 + 8.20975971221924) + 0.0343193095093888*std::sin(0.353279858827591*x_97 + 5.16728019714355) + 0.027989231509957*std::sin(0.37255984544754*x_98 + 5.18039989471436) + 0.0057187390721363*std::sin(0.436959862709045*x_98 - 7.37871980667114) - 0.0204558316694006*std::sin(0.451919853687286*x_98 + 2.00551986694336) - 0.0300159625453099*std::sin(0.407679855823517*x_99 + 5.20464038848877) + 0.0238284942518056*std::sin(0.443759858608246*x_99 + 5.22552013397217) - 0.000797872029879572*std::sin(0.681439816951752*x_99 + 8.60767936706543) - 1.43077075481415*std::sin(0.00275643562249409*x_10 + 0.00971954649995076*x_101 + 0.0112011641406471*x_103 - 0.00428220524560802*x_105 - 0.00486772599208502*x_107 - 0.00890088633243602*x_11 - 0.00259405457653592*x_113 + 0.0009663839933009*x_115 - 0.00553735693059049*x_116 + 0.0133170018652884*x_117 - 0.00258072332668237*x_118 + 0.00926723411645729*x_12 - 0.00643909932972286*x_13 - 0.00997581269223814*x_14 - 0.0022002151068298*x_17 + 0.00596135539265465*x_19 + 0.01530053049185*x_2 + 0.00236696505276502*x_20 - 0.0061020879837347*x_21 + 0.00372861492325063*x_23 + 0.00477805839996926*x_26 + 0.00138298322104557*x_27 - 0.00941994275426661*x_29 + 0.00668373747477353*x_3 - 0.00623830328432071*x_30 - 0.00156991045342329*x_32 - 0.0152623671487639*x_33 - 0.0119610562496974*x_35 - 0.00881131878381641*x_37 - 0.00150094600585921*x_39 - 0.00265120300840489*x_4 - 0.00425484073227536*x_40 + 0.0064372601974404*x_41 - 0.00639020984166783*x_42 + 0.00307592831819455*x_43 + 0.00246277045715006*x_44 - 0.00807286505982536*x_45 + 0.00466045499284356*x_46 + 0.00465881672715038*x_48 + 0.00777796354500722*x_49 - 0.0017608850594419*x_5 - 3.86871989894136e-5*x_51 + 0.00389989571905433*x_52 - 0.0146079721123639*x_54 - 0.00209989486980002*x_55 - 0.00821852348832996*x_56 + 0.00240420051042054*x_57 + 0.00834525937087289*x_6 + 0.0145980507891569*x_60 + 0.0193956610097027*x_61 - 0.00208953745227275*x_62 - 0.0126880819243912*x_63 + 0.00252974292177175*x_64 - 0.00714811565420406*x_65 - 0.00312678591881275*x_66 - 0.00562181260136339*x_67 + 0.00523095720887679*x_68 - 0.00337016607870645*x_69 + 0.00977562203710086*x_7 + 0.00239297781984648*x_70 + 0.0085355447739752*x_71 + 0.00194008502893436*x_72 - 0.00655635278682027*x_73 + 9.63433423440027e-6*x_76 + 0.00181861019399535*x_77 + 0.00602759878311433*x_78 - 0.00779206390874998*x_8 - 0.0109792815313927*x_80 - 0.00104770219674516*x_81 + 0.00342621727772894*x_82 - 0.00208948208960805*x_83 + 0.0109660566938492*x_84 + 0.00325377035780686*x_86 - 0.00325340795771376*x_88 - 0.00720170607249725*x_9 + 0.0074957095854186*x_91 + 0.0150486422116486*x_93 - 0.00156040498332449*x_94 - 0.00591804985289116*x_95 - 0.000248272271179804*x_96 - 0.000210651407401383*std::pow(-5.02359962463379*x_104 - 6.63000011444092, 2) + 7.14557085984141e-5*std::pow(-7.76968002319336*x_106 - 8.38871955871582, 2) + 0.000138329032951932*std::pow(-4.43039989471436*x_15 - 5.83872032165527, 2) - 0.000101665198833496*std::pow(-5.56400012969971*x_47 - 6.5978798866272, 2) + 7.16652204193653e-5*std::pow(-6.55936002731323*x_79 - 9.14999961853027, 2) + 0.000162673080908736*std::exp(1.15455985069275*x_1) + 0.00113170756479765*std::exp(1.51599979400635*x_100) + 0.00811868453108415*std::exp(0.667279839515686*x_114) + 0.00211901775421966*std::exp(0.610639870166779*x_31) + 0.000847616597009225*std::exp(1.3595198392868*x_50) - 0.0101154136549917*std::exp(0.611999809741974*x_90) + 0.0604521074915407*std::sin(0.375599831342697*x_102 + 1.9761598110199) - 0.0265788295645066*std::sin(0.444399863481522*x_108 + 2.046719789505) - 0.00677118561509626*std::sin(0.535279810428619*x_109 + 8.36967945098877) + 0.0213664334440296*std::sin(0.611279845237732*x_110 - 0.978959858417511) + 0.0361746783082566*std::sin(0.414799869060516*x_111 - 1.16295981407166) - 0.0395266084216779*std::sin(0.535999834537506*x_112 - 0.999279797077179) - 0.0594438950999585*std::sin(0.36575984954834*x_119 + 5.16232013702393) + 0.0515456217582493*std::sin(0.449199855327606*x_120 - 4.16680002212524) + 0.0432731402698838*std::sin(0.375999838113785*x_16 + 5.18239974975586) + 0.0940171550093929*std::sin(0.274959951639175*x_18 - 7.52424001693726) - 0.0349613612110478*std::sin(0.457599848508835*x_22 - 7.32376003265381) + 0.0849179496839305*std::sin(0.305119842290878*x_24 + 5.10567998886108) - 0.0267779795341312*std::sin(0.788399875164032*x_25 - 4.00871992111206) - 0.0740719308483335*std::sin(0.330559849739075*x_28 + 5.13048028945923) - 0.0843223285980024*std::sin(0.355359852313995*x_34 - 7.41152000427246) - 0.0479661506738314*std::sin(0.418479859828949*x_36 + 5.22432041168213) + 0.0495429684543218*std::sin(0.479759842157364*x_38 + 5.2579197883606) + 0.0781915462645699*std::sin(0.354639858007431*x_53 - 4.25040006637573) + 0.00930059339090938*std::sin(0.605599880218506*x_58 - 0.993359804153442) - 0.0737400289808647*std::sin(0.362959831953049*x_59 - 4.22071981430054) + 0.105310298932313*std::sin(0.225519984960556*x_74 + 1.8199999332428) + 0.172391531948513*std::sin(0.199359983205795*x_75 - 7.59999990463257) - 0.0867104247734147*std::sin(0.212719991803169*x_85 - 7.58776044845581) - 0.0348631283463003*std::sin(0.51615983247757*x_87 + 5.32791996002197) + 0.146369667462352*std::sin(0.225519984960556*x_89 + 1.8122398853302) - 0.0563535714720373*std::sin(0.381119847297668*x_92 + 8.18279933929443) - 0.10579147847271*std::sin(0.305199921131134*x_97 + 5.11439990997314) - 0.0463567422360516*std::sin(0.415599852800369*x_98 - 7.38839960098267) + 0.0684178666122257*std::sin(0.406159847974777*x_99 - 4.20160007476807) + 7.79796244824294) + 2.23956103235926 - 0.00012194005127937*std::exp(-2.08247995376587*x_54));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0276452266671745*x_1 + 0.00108654657945599*x_10 - 0.00751695980635379*x_100 + 0.0170520002328093*x_101 - 0.00824593819597569*x_102 + 0.00308602670103652*x_103 + 0.00289415352325776*x_104 - 0.0155678303168898*x_105 + 0.00139583858200547*x_106 - 0.00480382881110413*x_107 + 0.0053190801245659*x_108 + 0.000166093426468571*x_109 - 0.00554528542766207*x_11 + 0.0013160128772037*x_110 + 0.000481847836230716*x_111 + 0.00054380856546741*x_112 + 0.00654189290498716*x_113 - 0.000155646932761886*x_114 + 0.00122459020815531*x_115 + 0.0122088764042719*x_116 + 0.0103610781362415*x_117 + 0.00170829788096859*x_118 - 0.00588888880735788*x_119 - 0.00914949857617892*x_12 - 0.00551952893697253*x_120 - 0.00654052735383959*x_13 - 0.00886165928334447*x_14 + 0.00408456550046606*x_15 + 0.0026768369441708*x_16 + 0.0033705121784393*x_17 - 0.000573988689151198*x_18 - 0.0124272158594036*x_19 - 0.00399145543580993*x_2 - 0.00135077754544964*x_20 + 0.00562850815980616*x_21 + 0.0114160850805374*x_22 - 0.00240092087559848*x_23 - 0.00834667110513481*x_24 + 0.0023065826084498*x_25 + 0.00952916391351636*x_26 - 0.000823748222122604*x_27 - 0.00053273257442455*x_28 - 0.0118732011917727*x_29 + 0.000502545038774046*x_3 + 0.0036004563110244*x_30 + 0.0106847688848411*x_32 - 0.0153926465351232*x_33 + 0.00185077074521285*x_34 + 0.00533674290442005*x_35 + 0.00337035253621824*x_36 + 0.00459528662496052*x_37 - 0.00541744713114143*x_38 + 0.0123903495451343*x_39 - 0.0191112622647891*x_4 + 0.000869461595009057*x_40 + 0.0028399395205445*x_41 + 0.00124144266092283*x_42 + 0.0108366744986309*x_43 - 0.0167443371605146*x_44 - 0.00468770888955991*x_45 - 0.000411043958391416*x_46 - 0.00955169656754828*x_47 + 9.58077761858047e-5*x_48 + 0.0033077548095968*x_49 + 0.00841561444652879*x_5 + 0.000303599859622004*x_50 - 0.00165467855158144*x_51 - 0.00187965840397697*x_52 - 0.00733415615513311*x_53 + 0.00674699283542756*x_54 + 0.00279743732859644*x_55 - 0.0124683662748919*x_56 + 0.00454484054807403*x_57 - 0.000393756067703804*x_58 - 0.00473334770256424*x_59 + 0.00617694918397286*x_6 + 0.00527413213730351*x_60 + 0.0171255447915432*x_61 + 0.00626784746748945*x_62 - 0.00403430398107859*x_63 + 0.0019306009184236*x_64 - 0.0105275512974807*x_65 - 0.00282354982065579*x_66 - 0.0094780882802413*x_67 + 0.00751973939279133*x_68 + 0.00852825273682891*x_69 - 0.00220343631880127*x_7 + 0.000530512566998799*x_70 - 0.00247993462640829*x_71 - 0.000794448444261996*x_72 - 8.37877855475001e-5*x_73 + 0.000560734619782024*x_74 - 0.00546469381620274*x_75 + 0.00125338410869195*x_76 + 0.00925408629599441*x_77 - 0.00814764941091472*x_78 + 0.00131453690334541*x_79 - 0.00489254170526875*x_8 + 0.00628797528504959*x_80 + 0.00289175622789792*x_81 + 0.00494647787129445*x_82 + 0.00538411998710198*x_83 + 0.00280858220140868*x_84 - 0.00531259796631698*x_85 - 0.00700615648344164*x_86 - 0.00350468900239724*x_87 - 0.00148062516331802*x_88 - 0.00259948061155987*x_89 + 0.00759598366869697*x_9 - 0.00184090324218624*x_90 - 0.022249661497342*x_91 + 0.00394177034559129*x_92 - 0.0498378876777072*x_93 - 0.0172142286635243*x_94 + 0.00384044853614129*x_95 - 0.00383384725221172*x_96 + 0.00204339465806679*x_97 + 0.00214884789609477*x_98 - 0.00306011140547612*x_99 - 3.02119106576047e-5*std::pow(-5.02359962463379*x_104 - 6.63000011444092, 2) + 1.02482746770243e-5*std::pow(-7.76968002319336*x_106 - 8.38871955871582, 2) + 1.90693238091215e-6*std::pow(-6.33696031570435*x_106 - 6.55055999755859, 2) + 6.50097294367137e-5*std::pow(-4.04055976867676*x_107 - 6.8732795715332, 2) + 3.36949466539364e-5*std::pow(-5.1199197769165*x_112 - 7.47016000747681, 2) - 3.71745150000059e-5*std::pow(-5.11528015136719*x_114 - 6.48727989196777, 2) + 0.000227317747976612*std::pow(-1.28807985782623*x_114 - 1.71615982055664, 2) - 1.14865524839148e-5*std::pow(-9.0*x_115 - 9.99927997589111, 2) - 5.94355747767003e-7*std::pow(-8.35487937927246*x_115 - 9.57288074493408, 2) - 3.82269232749704e-6*std::pow(-8.12743949890137*x_115 - 9.94367980957031, 2) + 2.17542082309807e-5*std::pow(-7.13303995132446*x_115 - 8.96848011016846, 2) - 5.19213119687396e-7*std::pow(-7.52023983001709*x_12 - 5.48464012145996, 2) - 2.1966905713431e-6*std::pow(-5.54967975616455*x_120 - 6.57407999038696, 2) - 3.47132927657567e-5*std::pow(-7.13495969772339*x_14 - 9.12439918518066, 2) + 1.04886574480941e-5*std::pow(-6.59600019454956*x_15 - 9.96271991729736, 2) + 1.98393375883479e-5*std::pow(-4.43039989471436*x_15 - 5.83872032165527, 2) - 9.01019273658032e-5*std::pow(-6.48343992233276*x_19 - 8.70903968811035, 2) + 2.27862977571843e-5*std::pow(-4.24728012084961*x_21 - 5.46327972412109, 2) + 0.000140281664421081*std::pow(-3.86207985877991*x_24 - 5.49304008483887, 2) + 1.7138854426876e-5*std::pow(-8.15999984741211*x_45 - 9.98680019378662, 2) - 1.4580960754241e-5*std::pow(-5.56400012969971*x_47 - 6.5978798866272, 2) - 1.10206418735213e-6*std::pow(-8.39575958251953*x_48 - 7.98016023635864, 2) + 1.1542953967969e-5*std::pow(-7.48736000061035*x_55 - 8.30447959899902, 2) - 6.61834039455432e-5*std::pow(-5.89743947982788*x_55 - 7.46456003189087, 2) - 0.000131513243984722*std::pow(-4.72551965713501*x_55 - 7.19879961013794, 2) + 8.13915829800116e-7*std::pow(-8.09127998352051*x_59 - 9.45944023132324, 2) + 1.5106705624765e-5*std::pow(-7.65072011947632*x_66 - 9.26943969726563, 2) + 1.37743089654188e-6*std::pow(-7.10328006744385*x_67 - 8.67744064331055, 2) + 6.92649804564019e-5*std::pow(-5.22671985626221*x_7 - 8.03615951538086, 2) - 8.67759807793819e-5*std::pow(-6.26759958267212*x_70 - 9.014479637146, 2) - 4.97297814331848e-5*std::pow(-5.07919979095459*x_71 - 7.71488046646118, 2) + 0.000175271425351915*std::pow(-3.47183990478516*x_78 - 4.69567966461182, 2) + 1.02783231466471e-5*std::pow(-6.55936002731323*x_79 - 9.14999961853027, 2) - 2.71066938512137e-5*std::pow(-7.44632005691528*x_82 - 8.2236795425415, 2) - 9.13592622249167e-6*std::pow(-9.99993991851807*x_84 - 8.60000038146973, 2) + 1.0993234853688e-6*std::pow(-8.00255966186523*x_84 - 8.5984001159668, 2) - 2.31404454787238e-5*std::pow(-7.19600009918213*x_87 - 9.9973201751709, 2) - 4.81893997342712e-6*std::pow(-4.3907995223999*x_90 - 5.78359985351563, 2) - 0.00448221102576584*std::exp(0.380719840526581*x_1) + 1.27380628565659e-5*std::exp(0.815199851989746*x_1) + 5.7407080298424e-5*std::exp(1.00071978569031*x_1) + 2.33307939758858e-5*std::exp(1.15455985069275*x_1) - 4.26123618655766e-5*std::exp(1.16367983818054*x_1) - 3.29073106151771e-5*std::exp(1.20775985717773*x_1) + 1.38877281271341e-5*std::exp(1.38623988628387*x_1) - 0.000106227549595551*std::exp(1.20671987533569*x_100) + 0.000162311034424058*std::exp(1.51599979400635*x_100) - 0.000885922939582616*std::exp(1.56199979782104*x_100) + 0.00909827203354492*std::exp(0.623199820518494*x_104) + 0.00295056485508135*std::exp(0.879519879817963*x_104) - 0.000152849038772847*std::exp(0.884399890899658*x_104) + 0.00972127129205992*std::exp(0.60591983795166*x_106) + 0.00167706167495593*std::exp(0.726879835128784*x_106) + 0.00407616414363826*std::exp(1.03599977493286*x_106) + 0.00194636024144226*std::exp(0.550239861011505*x_109) + 0.00779209893368304*std::exp(0.68751984834671*x_109) + 0.00515952179818118*std::exp(0.815999865531921*x_109) - 0.0011715737421024*std::exp(0.963039815425873*x_109) - 0.00224298341650557*std::exp(1.03647983074188*x_109) + 0.000270940405709232*std::exp(0.64031982421875*x_110) + 0.000876749642137234*std::exp(0.954399824142456*x_110) + 0.00167347623100349*std::exp(1.00471985340118*x_110) - 0.000998163033008926*std::exp(1.24599981307983*x_110) + 0.000758937818307214*std::exp(1.35839986801147*x_110) + 0.00372735072763836*std::exp(0.422239869832993*x_112) + 0.00117671982632646*std::exp(0.832239866256714*x_112) - 0.00103625580398619*std::exp(0.840879857540131*x_112) + 0.00116439275073546*std::exp(0.667279839515686*x_114) + 6.36645964854507e-5*std::exp(0.739199817180634*x_114) + 2.58277904135346e-5*std::exp(1.27807986736298*x_23) - 0.000223698170775776*std::exp(1.61607992649078*x_23) - 0.0017890665191741*std::exp(0.619119822978973*x_26) - 0.00134333790680221*std::exp(0.657599866390228*x_26) - 0.000120727348215215*std::exp(0.88647985458374*x_26) - 0.000895024544959242*std::exp(0.919839859008789*x_26) - 4.06792864352505e-6*std::exp(1.32983994483948*x_26) + 4.92361815201889e-5*std::exp(1.48503994941711*x_26) - 0.00420978818312723*std::exp(0.493599832057953*x_31) + 0.000303912401355939*std::exp(0.610639870166779*x_31) + 0.000197970465862331*std::exp(0.643439829349518*x_31) + 0.0109342509184212*std::exp(0.645119845867157*x_31) + 0.00327749039442094*std::exp(0.645279824733734*x_31) + 0.012834663368665*std::exp(0.650719821453094*x_31) - 0.000225103191673303*std::exp(0.652079820632935*x_31) + 0.00492073626000301*std::exp(0.660639822483063*x_31) + 0.000891995142431902*std::exp(0.662879824638367*x_31) + 0.00721010885409736*std::exp(0.51231986284256*x_45) + 0.00346463796636128*std::exp(0.891679883003235*x_45) + 0.00261556378298178*std::exp(0.86599987745285*x_49) - 0.00181852745399656*std::exp(0.91407984495163*x_50) - 0.00162562683600728*std::exp(0.959999799728394*x_50) + 0.000121566322374248*std::exp(1.3595198392868*x_50) + 0.00190352352013783*std::exp(0.910159826278687*x_52) + 0.000181448848686915*std::exp(0.954559803009033*x_6) - 7.69204827351248e-5*std::exp(1.37487983703613*x_60) - 0.00312276979933693*std::exp(0.692239880561829*x_66) + 0.00387984384730863*std::exp(0.945199847221375*x_66) + 0.000123643672657633*std::exp(1.67783987522125*x_66) + 0.00379693389408785*std::exp(0.66951984167099*x_68) - 0.00278403540587708*std::exp(1.33463990688324*x_68) + 0.00224714359420933*std::exp(0.661919832229614*x_70) - 0.00539660229654312*std::exp(0.710639834403992*x_70) + 0.00128837244998215*std::exp(0.77295982837677*x_70) - 0.00618620290405257*std::exp(0.801199853420258*x_72) + 0.000183570410087095*std::exp(0.824319899082184*x_72) + 0.000192830074684031*std::exp(0.693759858608246*x_74) + 0.000651794877162076*std::exp(1.17047989368439*x_74) + 0.00049187400577806*std::exp(1.45263981819153*x_74) - 0.000106446688700319*std::exp(1.60871982574463*x_74) + 0.000379008110142534*std::exp(0.611519813537598*x_78) + 0.00575094128202169*std::exp(0.926559805870056*x_78) - 0.00149561981086131*std::exp(1.16831982135773*x_81) + 6.77663772470822e-5*std::exp(1.27199983596802*x_81) - 2.47135233234668e-5*std::exp(2.01087975502014*x_81) + 0.00119939384661373*std::exp(0.700319886207581*x_87) - 0.00145076635081298*std::exp(0.611999809741974*x_90) - 0.000269503233090586*std::sin(0.364159852266312*x_100 + 5.18175983428955) + 0.0707540935546408*std::sin(0.235039994120598*x_102 - 1.34447979927063) - 0.0717620304725108*std::sin(0.323359847068787*x_102 + 1.94719982147217) + 0.00867012327678546*std::sin(0.375599831342697*x_102 + 1.9761598110199) + 0.0150718739824375*std::sin(0.377599835395813*x_102 + 5.17960023880005) + 0.00491706156525929*std::sin(0.459279865026474*x_102 + 5.24032020568848) + 0.0111006977389255*std::sin(0.521439850330353*x_103 + 8.35359954833984) - 0.0197302966242763*std::sin(0.325759828090668*x_105 + 1.9398398399353) - 0.00148572963631069*std::sin(0.326879858970642*x_105 - 7.46807956695557) + 0.00449070684308639*std::sin(0.526319861412048*x_106 - 4.0403995513916) - 0.0378928714807884*std::sin(0.272559970617294*x_107 - 7.52992010116577) + 0.0159796795906841*std::sin(0.584239840507507*x_107 + 2.17967987060547) - 0.00381197179782672*std::sin(0.444399863481522*x_108 + 2.046719789505) - 0.00587870147798166*std::sin(0.472879856824875*x_109 - 7.34272003173828) - 0.000971132627941814*std::sin(0.535279810428619*x_109 + 8.36967945098877) + 0.00306440287414116*std::sin(0.611279845237732*x_110 - 0.978959858417511) + 0.0101246865119852*std::sin(0.230719983577728*x_111 - 7.57328033447266) - 0.0246253403198795*std::sin(0.29775995016098*x_111 - 4.2792797088623) + 0.0280326385308846*std::sin(0.326159834861755*x_111 - 7.47175979614258) + 0.00518822144413295*std::sin(0.414799869060516*x_111 - 1.16295981407166) - 0.000729478636022504*std::sin(0.453359842300415*x_111 + 8.24512004852295) + 0.0149817756435681*std::sin(0.455839842557907*x_111 - 4.36560010910034) - 0.00566895980883923*std::sin(0.535999834537506*x_112 - 0.999279797077179) + 0.000558687076555819*std::sin(0.5933598279953*x_112 - 1.00103986263275) + 0.000844500328463621*std::sin(0.337679862976074*x_115 + 5.1374397277832) + 0.0252462298464255*std::sin(0.493279844522476*x_115 - 4.12056016921997) - 0.00114954566801682*std::sin(0.301039934158325*x_116 + 1.90431988239288) + 0.0436969738523652*std::sin(0.396719843149185*x_117 + 1.99855983257294) + 0.0230409415291986*std::sin(0.550879836082458*x_117 + 8.3601598739624) + 0.000385944047780504*std::sin(0.597839832305908*x_117 + 5.40000009536743) - 0.00637059002584415*std::sin(0.294559925794601*x_119 - 4.29423999786377) + 0.00139952503010179*std::sin(0.300399929285049*x_119 + 8.296799659729) - 0.00852552408766002*std::sin(0.36575984954834*x_119 + 5.16232013702393) + 0.0197444346044291*std::sin(0.45279985666275*x_119 - 1.16775989532471) + 0.0373803532918983*std::sin(0.29615992307663*x_120 - 7.47679996490479) - 0.0255858035485982*std::sin(0.304079920053482*x_120 - 7.47528028488159) - 0.0406794339273818*std::sin(0.405039846897125*x_120 + 5.21120023727417) + 0.00739274300875471*std::sin(0.449199855327606*x_120 - 4.16680002212524) + 0.115058774010794*std::sin(0.183280006051064*x_15 + 1.78319990634918) - 0.0359588157886711*std::sin(0.346639841794968*x_16 - 7.43271970748901) + 0.00620629248973698*std::sin(0.375999838113785*x_16 + 5.18239974975586) + 0.000462745201517529*std::sin(0.387439846992493*x_16 - 7.39447975158691) + 0.0134840679322578*std::sin(0.274959951639175*x_18 - 7.52424001693726) + 0.0629098303132537*std::sin(0.25655996799469*x_20 - 7.54432010650635) - 0.0463085755998826*std::sin(0.343279838562012*x_20 - 7.44608020782471) - 0.130330376540444*std::sin(0.234959989786148*x_21 + 5.042799949646) - 0.000585038003761694*std::sin(0.420959860086441*x_21 + 8.42536067962646) - 0.00501420585984411*std::sin(0.457599848508835*x_22 - 7.32376003265381) - 0.0359797991325454*std::sin(0.266079962253571*x_24 + 5.06623983383179) + 0.0121790475588393*std::sin(0.305119842290878*x_24 + 5.10567998886108) - 0.0161231267687683*std::sin(0.306879937648773*x_24 + 5.1399998664856) + 0.00129517319821601*std::sin(0.351119846105576*x_24 - 4.26471996307373) - 0.000636384580006083*std::sin(0.404879868030548*x_24 + 8.39160060882568) - 0.00384053415667342*std::sin(0.788399875164032*x_25 - 4.00871992111206) + 0.0818035754522921*std::sin(0.290719836950302*x_27 - 4.32800006866455) + 0.00114121322187501*std::sin(0.317679852247238*x_28 + 5.11696004867554) - 0.0103013160907173*std::sin(0.320399850606918*x_28 - 4.27432012557983) - 0.0106234968217518*std::sin(0.330559849739075*x_28 + 5.13048028945923) + 0.0109134731433622*std::sin(0.338479846715927*x_28 + 8.32632064819336) - 0.0133822524894081*std::sin(0.33943983912468*x_28 + 8.31999969482422) - 0.0146220626528235*std::sin(0.291439920663834*x_3 + 5.0874400138855) - 0.0560129160613046*std::sin(0.303439915180206*x_3 - 7.50208044052124) + 0.0531991526436842*std::sin(0.271119952201843*x_33 - 1.1729599237442) + 0.0636810001336004*std::sin(0.34895983338356*x_34 - 7.40207958221436) - 0.0120936227745674*std::sin(0.355359852313995*x_34 - 7.41152000427246) + 0.00194900926820876*std::sin(0.369519829750061*x_34 + 8.19623947143555) - 0.056799995329939*std::sin(0.31007993221283*x_35 + 8.25119972229004) + 0.012222582385032*std::sin(0.331679850816727*x_35 - 7.42903995513916) - 0.0132088773425849*std::sin(0.326639831066132*x_36 - 7.46719980239868) - 0.000361492838638252*std::sin(0.332639843225479*x_36 - 4.26639986038208) + 0.0435329455959917*std::sin(0.365359842777252*x_36 + 5.18416023254395) - 0.00687937040926453*std::sin(0.418479859828949*x_36 + 5.22432041168213) + 0.00616913808963255*std::sin(0.29367995262146*x_37 - 1.33159983158112) - 0.00808369025320117*std::sin(0.428959846496582*x_37 - 1.1684798002243) + 0.0297562528497312*std::sin(0.47775986790657*x_38 - 7.32087993621826) + 0.00710551975474091*std::sin(0.479759842157364*x_38 + 5.2579197883606) + 0.000216088002564184*std::sin(0.635359883308411*x_38 - 0.950879812240601) + 0.0174464124901633*std::sin(0.387199848890305*x_41 + 1.97423982620239) + 0.000941923951456882*std::sin(0.355519831180573*x_43 + 8.34455966949463) + 0.0101784744048063*std::sin(0.401679843664169*x_43 + 1.97855985164642) - 0.0491611820205383*std::sin(0.352319836616516*x_44 + 5.15360021591187) + 0.0270210374386639*std::sin(0.182240009307861*x_46 + 4.96335983276367) + 0.01814752226411*std::sin(0.265519976615906*x_48 - 7.5195198059082) - 0.0374195431076599*std::sin(0.220799997448921*x_51 + 5.01679992675781) - 0.0538115064707543*std::sin(0.186400011181831*x_53 - 4.42840003967285) + 0.0112143376541696*std::sin(0.354639858007431*x_53 - 4.25040006637573) + 0.0160738308525996*std::sin(0.280239939689636*x_54 - 1.33415985107422) + 0.00422337655754209*std::sin(0.53823983669281*x_54 - 1.03471982479095) + 0.000177586809709376*std::sin(0.487919867038727*x_55 + 2.06407976150513) - 0.00245292224046545*std::sin(0.239359974861145*x_56 + 1.83567988872528) - 0.000474821556488767*std::sin(0.395439833402634*x_56 + 5.18455982208252) + 0.00614059761254532*std::sin(0.139120042324066*x_58 - 7.6723198890686) + 0.0326595627644711*std::sin(0.184960007667542*x_58 - 7.6159200668335) + 0.0383942420403608*std::sin(0.277119934558868*x_58 + 5.09000015258789) + 0.0393540194679863*std::sin(0.386319845914841*x_58 + 5.19648027420044) - 0.0224516876860066*std::sin(0.490319848060608*x_58 - 4.12143993377686) + 0.0013339037230046*std::sin(0.605599880218506*x_58 - 0.993359804153442) + 0.0415247983562396*std::sin(0.298159927129745*x_59 + 5.10799980163574) - 0.0105758950056008*std::sin(0.362959831953049*x_59 - 4.22071981430054) + 0.376463015798657*std::sin(0.125840052962303*x_63 - 1.45423996448517) - 0.0158709715401709*std::sin(0.164000019431114*x_64 - 1.42503988742828) + 0.116911138190923*std::sin(0.179200008511543*x_64 - 4.42479991912842) + 0.025561917573743*std::sin(0.281999945640564*x_64 + 5.10519981384277) + 0.0143449558045856*std::sin(0.417919874191284*x_64 + 1.99703979492188) + 0.0533753853512178*std::sin(0.398639857769012*x_65 - 7.40407991409302) + 0.00168669787678889*std::sin(0.440159857273102*x_66 - 4.15623998641968) - 0.0798635468732397*std::sin(0.254959970712662*x_70 - 7.52400016784668) + 0.000596508875963609*std::sin(0.515119850635529*x_70 + 5.33439970016479) - 0.0111140343094176*std::sin(0.514559864997864*x_72 - 4.07624006271362) + 0.0274749476967387*std::sin(0.245599970221519*x_73 + 1.86039984226227) + 0.0430151337796113*std::sin(0.42799985408783*x_73 - 4.17216014862061) + 0.0151037459560206*std::sin(0.225519984960556*x_74 + 1.8199999332428) + 0.0247246274098328*std::sin(0.199359983205795*x_75 - 7.59999990463257) + 0.00111788083923442*std::sin(0.382159858942032*x_75 - 7.40551996231079) - 0.0163008729489866*std::sin(0.527119874954224*x_75 - 7.25256013870239) + 0.0308144107982571*std::sin(0.262239962816238*x_76 - 7.52232027053833) - 0.00263067869831197*std::sin(0.289119929075241*x_77 - 7.48000001907349) - 0.00176228765351792*std::sin(0.231439992785454*x_79 + 1.83111989498138) + 0.0323536656642001*std::sin(0.367839843034744*x_79 + 8.36952018737793) - 0.0461134143979431*std::sin(0.375919848680496*x_79 - 7.42759990692139) - 0.0352753907816923*std::sin(0.465919852256775*x_81 + 8.46975994110107) - 0.0186661943145554*std::sin(0.263439983129501*x_82 + 1.86799991130829) - 0.0135004724344429*std::sin(0.397759824991226*x_82 - 7.40991973876953) - 0.0375343464170292*std::sin(0.158560022711754*x_84 - 7.65680027008057) + 0.023257168730654*std::sin(0.353839844465256*x_84 + 5.14383983612061) + 0.0360240616718045*std::sin(0.174960017204285*x_85 - 4.43856000900269) - 0.0124361267681716*std::sin(0.212719991803169*x_85 - 7.58776044845581) - 0.00357565140090521*std::sin(0.21399998664856*x_85 - 7.5816798210144) - 0.0143757939636565*std::sin(0.631679832935333*x_86 - 7.16951990127563) - 0.00500011716910142*std::sin(0.51615983247757*x_87 + 5.32791996002197) - 0.00025135326300252*std::sin(0.797919869422913*x_87 - 0.793519854545593) - 0.00158748979306345*std::sin(0.988159835338593*x_87 + 5.58551979064941) + 0.0209925362992228*std::sin(0.225519984960556*x_89 + 1.8122398853302) - 0.0116301601847504*std::sin(0.321119844913483*x_90 + 8.31783962249756) + 0.0147109168988369*std::sin(0.351999849081039*x_92 - 7.39856004714966) - 0.0483909401495064*std::sin(0.353839844465256*x_92 + 1.99631977081299) + 0.00933229498267924*std::sin(0.359439849853516*x_92 - 1.18815994262695) - 0.000524591302407398*std::sin(0.373199850320816*x_92 - 7.38935995101929) - 0.00808230568004721*std::sin(0.381119847297668*x_92 + 8.18279933929443) - 0.0412407733070604*std::sin(0.353119850158691*x_95 - 1.21815991401672) - 0.000636859232753832*std::sin(0.364959836006165*x_95 + 5.16431999206543) - 0.0319293614084317*std::sin(0.38919985294342*x_95 + 1.98527979850769) + 0.0310513823421783*std::sin(0.386959850788116*x_96 + 5.19655990600586) + 0.0296902725073486*std::sin(0.415279865264893*x_96 - 7.3996000289917) - 0.00669010080251885*std::sin(0.439519852399826*x_96 + 8.20975971221924) - 0.0151727573785603*std::sin(0.305199921131134*x_97 + 5.11439990997314) + 0.0352455750802058*std::sin(0.353279858827591*x_97 + 5.16728019714355) + 0.0287446505982754*std::sin(0.37255984544754*x_98 + 5.18039989471436) - 0.00664854686750129*std::sin(0.415599852800369*x_98 - 7.38839960098267) + 0.000715368717637047*std::sin(0.436959862709045*x_98 - 7.37871980667114) - 0.0106382386531581*std::sin(0.451919853687286*x_98 + 2.00551986694336) + 0.00981258325767498*std::sin(0.406159847974777*x_99 - 4.20160007476807) - 0.00100573511210028*std::sin(0.407679855823517*x_99 + 5.20464038848877) - 0.0291462311822959*std::sin(0.443759858608246*x_99 + 5.22552013397217) - 3.21030020713806*std::sin(-0.00141441755739566*x_10 - 0.00225050592189798*x_100 + 0.000239957071580137*x_101 - 0.000197458471944936*x_103 + 0.00104416834387253*x_105 + 0.00263086830644542*x_107 - 0.00224770764083068*x_108 + 0.000424064422474531*x_11 + 0.00238664234001392*x_112 - 0.000917688173975531*x_113 + 0.00152720787794933*x_114 + 0.00652804688757918*x_116 + 0.00354906452180174*x_117 - 0.00315312925075395*x_118 + 0.000805309157395279*x_119 + 0.00487876226690333*x_12 + 0.00599238119143637*x_120 - 0.00257864534309508*x_13 - 0.0014149352011712*x_14 - 0.00265057580088618*x_16 + 0.0026134179804756*x_17 - 0.00241631305762655*x_18 - 0.00344495080776755*x_19 - 0.000187406840970614*x_2 + 0.00335838690149567*x_20 - 0.000796179979516827*x_21 + 0.00159161986710176*x_22 - 0.000608895992587765*x_23 + 0.00220614542360553*x_25 + 0.00197664541689176*x_26 - 0.000681475954516618*x_27 + 0.00359801356732634*x_29 + 0.00534816917503546*x_3 + 0.00270294512555449*x_30 - 0.00283972188819604*x_32 - 0.00203125459210858*x_33 - 0.00156152884755912*x_34 - 0.0001177681378326*x_36 + 0.00493764029167603*x_37 - 0.00277888634078713*x_38 + 0.00514759666710933*x_39 - 0.00340433776643971*x_4 - 0.00233345024282969*x_40 - 0.00377307504533433*x_42 - 0.000370827461541996*x_43 - 0.00322610569371006*x_44 - 0.00304019536656536*x_45 + 0.00108565053747268*x_46 - 0.000344642424164319*x_47 + 0.00154231180069438*x_48 - 0.00226357193504678*x_49 - 0.000209603928968857*x_5 - 0.000506195131190357*x_50 + 0.00150038114909696*x_51 + 0.00283501727428369*x_52 - 8.49717814199323e-5*x_53 + 0.00505133550181814*x_54 + 0.000546197545736319*x_56 + 0.00575796951899782*x_57 - 0.000419007331434625*x_59 + 0.00136053287516823*x_6 + 0.00124856859209396*x_61 - 0.000931837736231044*x_62 + 0.00281678757048895*x_63 - 0.00318316865943522*x_64 + 0.00121800927045032*x_65 + 0.00219771521121341*x_66 - 0.000746364821742322*x_68 - 0.00176789622084887*x_7 - 0.000987245087370092*x_70 + 0.00149141623192431*x_71 + 0.000143434037908452*x_73 - 0.00136686701653003*x_75 + 0.00391625623989723*x_76 + 0.00412535375207879*x_77 + 0.000834148045936511*x_78 + 0.00145503521590611*x_79 + 0.00185528963632731*x_8 + 0.00235097645203077*x_80 - 0.00223411029915042*x_81 + 0.00284705729038532*x_82 - 0.00148663564674154*x_83 + 0.00280078908088762*x_84 - 0.00236712866315468*x_85 - 0.00202802108387878*x_86 - 0.0018403547396543*x_88 + 0.000452970597232624*x_89 + 0.00537143406199446*x_9 + 0.00184492863039045*x_90 + 0.00913854659513445*x_91 + 0.0045649223670507*x_93 + 0.00235141432050391*x_94 + 0.00187327371016889*x_95 + 0.00243599189842182*x_96 + 0.00188986154701971*x_97 + 0.000552578384497752*x_98 + 2.34531882194349e-5*std::pow(-8.29967975616455*x_104 - 9.30575942993164, 2) - 2.42820072315834e-5*std::pow(-7.84424018859863*x_15 - 8.04736042022705, 2) + 0.000162392718651115*std::pow(-3.35439991950989*x_60 - 4.39711999893188, 2) + 1.95826461691466e-5*std::pow(-8.26799964904785*x_67 - 7.86800003051758, 2) - 4.56071826165838e-5*std::pow(-4.31935977935791*x_87 - 6.28535985946655, 2) + 7.86954829513833e-6*std::exp(1.34047985076904*x_1) - 0.00241543028500405*std::exp(0.644079864025116*x_109) + 0.000722805858034533*std::exp(1.11807978153229*x_110) - 0.0016793240712838*std::exp(0.66271984577179*x_31) + 0.00290231591878652*std::exp(0.90671980381012*x_72) + 0.00138218743304963*std::exp(1.25959992408752*x_74) + 0.0134910306281832*std::sin(0.442639857530594*x_102 + 8.43080043792725) + 0.0585954516667524*std::sin(0.267679959535599*x_106 - 7.52112007141113) + 0.0383066513104744*std::sin(0.247679978609085*x_111 + 5.05423974990845) + 0.0372408582094295*std::sin(0.342799842357635*x_115 - 7.43576002120972) + 0.0318669121215205*std::sin(0.313759922981262*x_24 - 7.46903991699219) + 0.0414675913350795*std::sin(0.324319839477539*x_28 + 8.30976009368896) + 0.0332643744379197*std::sin(0.314959853887558*x_35 + 1.97399973869324) - 0.0227255330940839*std::sin(0.317439913749695*x_41 + 1.91527986526489) - 0.021042378932099*std::sin(0.356959849596024*x_55 - 7.43415975570679) + 0.039127786716243*std::sin(0.255359977483749*x_58 + 5.05471992492676) + 0.0514312277192541*std::sin(0.243359968066216*x_69 - 7.54400014877319) + 0.0112953808749372*std::sin(0.38487982749939*x_92 - 1.19791984558105) + 0.00245795913780894*std::sin(0.681439816951752*x_99 + 8.60767936706543) + 7.77375767289022) + 3.55331792885941 + 0.000149153063865974*std::exp(-2.08247995376587*x_54));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0314118050700666*x_1 + 0.0124912627935899*x_10 + 0.00391536045684777*x_100 - 0.0322639267189032*x_101 + 0.0175767835610089*x_102 + 0.00764068380298018*x_103 - 0.00808849893574751*x_104 + 0.0113887935818487*x_105 - 0.00771911291099975*x_106 + 0.00664685836236397*x_107 - 0.00831744530087991*x_108 - 0.00474299936476225*x_109 + 0.0161835974158478*x_11 - 0.00478691404999114*x_110 + 0.00105437597419549*x_111 + 0.0054211224428723*x_112 + 0.012254503586952*x_113 + 0.00733346518845774*x_114 - 0.00199659889440158*x_115 + 0.00950818908358646*x_116 - 0.00366415957238309*x_117 - 0.00990677834558484*x_118 + 0.00301515812788885*x_119 + 0.00852398080357751*x_12 + 0.0136241418099544*x_120 + 0.0111870325176817*x_13 + 0.0167220796186294*x_14 - 0.0097087785333843*x_15 - 0.00820230308936552*x_16 + 0.0142481900926333*x_17 - 0.016552371960363*x_18 - 0.0255069571974366*x_19 + 0.0157107425430464*x_2 + 0.00639103751530892*x_20 - 0.00540854467130033*x_21 - 0.0163584590722047*x_22 + 0.022123799582668*x_23 + 0.00633522022138154*x_24 + 0.00423889237895686*x_25 - 0.00343443861239769*x_26 - 0.00846014196498173*x_27 + 0.00242767133708487*x_28 + 0.0366044781278625*x_29 - 0.00466730617449074*x_3 - 0.00797778673027189*x_30 + 0.0319760679546273*x_32 + 0.0294044687842788*x_33 + 0.00564690942842802*x_34 - 0.00967895634636556*x_35 - 0.0102860004751074*x_36 + 0.00302444233803773*x_37 + 0.00812457501971591*x_38 + 0.00147627623093748*x_39 + 0.0322208859317158*x_4 - 0.00746457341496986*x_40 - 0.00494003845380786*x_41 - 0.0198672310543006*x_42 - 0.0285283328873328*x_43 + 0.0148362351998949*x_44 + 7.51136801925606e-5*x_45 - 0.000965613954036625*x_46 + 0.0033718431469688*x_47 + 0.00860177347358836*x_48 - 0.0160052996408751*x_49 - 0.00516754576405546*x_5 - 0.00897267132004246*x_50 + 0.0193809843695462*x_51 + 0.0190504754841534*x_52 - 0.00336620246465635*x_53 + 0.013417749124319*x_54 - 0.0030516579946664*x_55 + 0.0300218774006347*x_56 + 0.00817167785777634*x_57 + 0.00207857807769588*x_58 + 0.00970701865589453*x_59 - 0.00532625586246851*x_6 + 0.00950974596830675*x_60 - 0.00685123806426456*x_61 + 0.000424105798675009*x_62 - 0.00140575959504649*x_63 + 0.000733887757094448*x_64 + 0.0113466249914324*x_65 + 0.0068641863852202*x_66 + 0.0224641679511499*x_67 - 0.00992709329674309*x_68 - 0.0223307264234016*x_69 + 0.0119059852176931*x_7 - 0.00241564635164971*x_70 + 0.00689862199650156*x_71 + 0.010267240007368*x_72 + 0.00194893194213716*x_73 - 0.00381544469405909*x_74 + 0.00162740005204464*x_75 + 0.0107434645284502*x_76 - 0.00992106212765142*x_77 + 0.0029388107218835*x_78 + 0.00942838739900218*x_79 + 0.0169943716207219*x_8 + 0.00197775622124752*x_80 - 0.00938193416804949*x_81 - 0.000702148311461447*x_82 + 0.000621297773215821*x_83 + 0.00385230592008569*x_84 + 0.00592866881676261*x_85 - 0.000822516762491902*x_86 + 0.00190769454996851*x_87 + 0.00234080990347952*x_88 + 0.00441556531394765*x_89 + 0.00688988549171388*x_9 + 0.000487950134355862*x_90 - 0.00244138128380794*x_91 + 0.000988149546093611*x_92 + 0.0890767320518114*x_93 + 0.0174944751646182*x_94 - 0.00263474013023763*x_95 + 0.00229508638642313*x_96 - 0.0316667942676081*x_97 + 0.00281582065156036*x_98 + 0.000460151727780529*x_99 + 5.01164920381837e-5*std::pow(-8.29967975616455*x_104 - 9.30575942993164, 2) + 5.06168605618174e-5*std::pow(-5.02359962463379*x_104 - 6.63000011444092, 2) - 1.71699001829126e-5*std::pow(-7.76968002319336*x_106 - 8.38871955871582, 2) - 2.40315788070099e-5*std::pow(-6.33696031570435*x_106 - 6.55055999755859, 2) + 1.47545070757953e-5*std::pow(-4.04055976867676*x_107 - 6.8732795715332, 2) + 7.6473526829245e-6*std::pow(-5.1199197769165*x_112 - 7.47016000747681, 2) + 7.13199130478203e-5*std::pow(-5.11528015136719*x_114 - 6.48727989196777, 2) + 0.00171711605236433*std::pow(-1.28807985782623*x_114 - 1.71615982055664, 2) + 6.63626948157598e-6*std::pow(-9.0*x_115 - 9.99927997589111, 2) - 2.32886553694086e-5*std::pow(-8.35487937927246*x_115 - 9.57288074493408, 2) - 2.88759079184196e-5*std::pow(-8.12743949890137*x_115 - 9.94367980957031, 2) + 4.93730126326387e-6*std::pow(-7.13303995132446*x_115 - 8.96848011016846, 2) - 2.03443399901559e-5*std::pow(-7.52023983001709*x_12 - 5.48464012145996, 2) - 8.6072978786593e-5*std::pow(-5.54967975616455*x_120 - 6.57407999038696, 2) + 4.01283539139692e-5*std::pow(-7.13495969772339*x_14 - 9.12439918518066, 2) - 5.18875732675158e-5*std::pow(-7.84424018859863*x_15 - 8.04736042022705, 2) + 7.92293704833205e-5*std::pow(-6.59600019454956*x_15 - 9.96271991729736, 2) - 3.32387115707116e-5*std::pow(-4.43039989471436*x_15 - 5.83872032165527, 2) + 0.000160709021741949*std::pow(-6.48343992233276*x_19 - 8.70903968811035, 2) + 0.000172123461547051*std::pow(-4.24728012084961*x_21 - 5.46327972412109, 2) - 0.000250211396321371*std::pow(-3.86207985877991*x_24 - 5.49304008483887, 2) + 3.88980774267857e-6*std::pow(-8.15999984741211*x_45 - 9.98680019378662, 2) + 2.4428857403925e-5*std::pow(-5.56400012969971*x_47 - 6.5978798866272, 2) + 1.38884538507168e-5*std::pow(-8.39575958251953*x_48 - 7.98016023635864, 2) - 2.2145345361208e-5*std::pow(-7.48736000061035*x_55 - 8.30447959899902, 2) + 3.82369648687604e-5*std::pow(-5.89743947982788*x_55 - 7.46456003189087, 2) + 0.000234571727873123*std::pow(-4.72551965713501*x_55 - 7.19879961013794, 2) + 3.18916832740917e-5*std::pow(-8.09127998352051*x_59 - 9.45944023132324, 2) + 0.000347012666900164*std::pow(-3.35439991950989*x_60 - 4.39711999893188, 2) - 2.89824610111816e-5*std::pow(-7.65072011947632*x_66 - 9.26943969726563, 2) + 4.18456340195717e-5*std::pow(-8.26799964904785*x_67 - 7.86800003051758, 2) - 1.73586853277003e-5*std::pow(-7.10328006744385*x_67 - 8.67744064331055, 2) - 8.0069893350495e-5*std::pow(-5.22671985626221*x_7 - 8.03615951538086, 2) + 0.000154776744398983*std::pow(-6.26759958267212*x_70 - 9.014479637146, 2) + 2.87310079601892e-5*std::pow(-5.07919979095459*x_71 - 7.71488046646118, 2) - 0.00010126175044114*std::pow(-3.47183990478516*x_78 - 4.69567966461182, 2) - 1.72202432153089e-5*std::pow(-6.55936002731323*x_79 - 9.14999961853027, 2) + 1.56606889145493e-5*std::pow(-7.44632005691528*x_82 - 8.2236795425415, 2) - 2.07347560529258e-6*std::pow(-9.99993991851807*x_84 - 8.60000038146973, 2) + 4.30748182152474e-5*std::pow(-8.00255966186523*x_84 - 8.5984001159668, 2) + 1.33692186872931e-5*std::pow(-7.19600009918213*x_87 - 9.9973201751709, 2) - 9.74567714675971e-5*std::pow(-4.31935977935791*x_87 - 6.28535985946655, 2) + 6.07293351861117e-5*std::pow(-4.3907995223999*x_90 - 5.78359985351563, 2) + 0.00799463197127121*std::exp(0.380719840526581*x_1) + 0.000499115819195746*std::exp(0.815199851989746*x_1) + 0.000433642423335702*std::exp(1.00071978569031*x_1) - 3.90882774299694e-5*std::exp(1.15455985069275*x_1) + 8.1752510907397e-5*std::exp(1.16367983818054*x_1) - 7.46859203266924e-6*std::exp(1.20775985717773*x_1) + 1.68162277464085e-5*std::exp(1.34047985076904*x_1) - 8.02353068665156e-6*std::exp(1.38623988628387*x_1) + 0.000203799285624479*std::exp(1.20671987533569*x_100) - 0.000271934969297247*std::exp(1.51599979400635*x_100) + 0.00102412149432117*std::exp(1.56199979782104*x_100) - 0.0162280035599781*std::exp(0.623199820518494*x_104) - 0.00170466669861187*std::exp(0.879519879817963*x_104) - 0.00598908751349648*std::exp(0.884399890899658*x_104) - 0.0112377300976272*std::exp(0.60591983795166*x_106) + 0.000380623309219747*std::exp(0.726879835128784*x_106) - 0.00235497323902895*std::exp(1.03599977493286*x_106) + 0.0147024437995404*std::exp(0.550239861011505*x_109) - 0.0051614685182495*std::exp(0.644079864025116*x_109) - 0.00450182667283627*std::exp(0.68751984834671*x_109) - 0.00920270770097493*std::exp(0.815999865531921*x_109) - 0.000265898554223234*std::exp(0.963039815425873*x_109) + 0.00259287509738885*std::exp(1.03647983074188*x_109) + 0.0106162643465907*std::exp(0.64031982421875*x_110) - 0.00168205848124515*std::exp(0.954399824142456*x_110) + 0.000379809562437156*std::exp(1.00471985340118*x_110) + 0.00154454454935564*std::exp(1.11807978153229*x_110) + 0.000576681200287944*std::exp(1.24599981307983*x_110) - 0.000877327471560695*std::exp(1.35839986801147*x_110) - 0.00664823613257415*std::exp(0.422239869832993*x_112) - 0.000679841047411836*std::exp(0.832239866256714*x_112) + 0.00119790536519724*std::exp(0.840879857540131*x_112) - 0.00195081688712502*std::exp(0.667279839515686*x_114) + 0.00249457139491373*std::exp(0.739199817180634*x_114) + 0.00101201092469273*std::exp(1.27807986736298*x_23) - 5.07701888955977e-5*std::exp(1.61607992649078*x_23) - 0.0135142762330089*std::exp(0.619119822978973*x_26) + 0.00257721567334394*std::exp(0.657599866390228*x_26) + 0.00152143243873571*std::exp(0.88647985458374*x_26) + 0.000517093712956259*std::exp(0.919839859008789*x_26) - 0.000159393744575242*std::exp(1.32983994483948*x_26) - 5.69167244014253e-5*std::exp(1.48503994941711*x_26) + 0.00243217352488559*std::exp(0.493599832057953*x_31) - 0.000509173081331371*std::exp(0.610639870166779*x_31) + 0.00775708146192015*std::exp(0.643439829349518*x_31) - 0.0126399271195437*std::exp(0.645119845867157*x_31) + 0.0247575537670255*std::exp(0.645279824733734*x_31) - 0.0228923648435542*std::exp(0.650719821453094*x_31) + 0.00283679963933427*std::exp(0.652079820632935*x_31) + 0.00111680264777928*std::exp(0.660639822483063*x_31) - 0.00358850279376015*std::exp(0.66271984577179*x_31) - 0.00171130722209318*std::exp(0.662879824638367*x_31) - 0.00416558627266896*std::exp(0.51231986284256*x_45) - 0.00400510027775491*std::exp(0.891679883003235*x_45) - 0.00302357572000747*std::exp(0.86599987745285*x_49) + 0.00210220660335137*std::exp(0.91407984495163*x_50) + 0.00311879158590836*std::exp(0.959999799728394*x_50) - 0.0002036715141378*std::exp(1.3595198392868*x_50) + 0.000432020737359895*std::exp(0.910159826278687*x_52) - 0.00228665806418109*std::exp(0.954559803009033*x_6) + 0.000969368741768486*std::exp(1.37487983703613*x_60) - 0.000708738976451979*std::exp(0.692239880561829*x_66) - 0.00692022831743709*std::exp(0.945199847221375*x_66) - 7.14342038306838e-5*std::exp(1.67783987522125*x_66) + 0.000861746210791151*std::exp(0.66951984167099*x_68) + 0.00160845555927432*std::exp(1.33463990688324*x_68) + 0.000510008214899066*std::exp(0.661919832229614*x_70) + 0.00623843921548824*std::exp(0.710639834403992*x_70) - 0.00247176354838577*std::exp(0.77295982837677*x_70) + 0.0110339328588527*std::exp(0.801199853420258*x_72) - 0.00231339444481665*std::exp(0.824319899082184*x_72) + 0.00620188143612924*std::exp(0.90671980381012*x_72) + 0.00755566539239421*std::exp(0.693759858608246*x_74) + 0.0049235374553288*std::exp(1.17047989368439*x_74) + 0.00295355944085705*std::exp(1.25959992408752*x_74) - 0.000877324077297016*std::exp(1.45263981819153*x_74) - 2.41589748985613e-5*std::exp(1.60871982574463*x_74) - 0.000727133237912584*std::exp(0.611519813537598*x_78) - 0.0102575846549524*std::exp(0.926559805870056*x_78) + 0.00266764101200154*std::exp(1.16831982135773*x_81) - 0.00085400670290146*std::exp(1.27199983596802*x_81) - 0.000186681365563992*std::exp(2.01087975502014*x_81) - 0.00230105664729098*std::exp(0.700319886207581*x_87) + 0.00243060556212764*std::exp(0.611999809741974*x_90) - 0.0105599515777687*std::sin(0.364159852266312*x_100 + 5.18175983428955) - 0.0408776464836389*std::sin(0.235039994120598*x_102 - 1.34447979927063) + 0.0829564678815677*std::sin(0.323359847068787*x_102 + 1.94719982147217) - 0.0145258744449634*std::sin(0.375599831342697*x_102 + 1.9761598110199) + 0.00342068907602286*std::sin(0.377599835395813*x_102 + 5.17960023880005) + 0.0288286233299384*std::sin(0.442639857530594*x_102 + 8.43080043792725) + 0.0371425699019291*std::sin(0.459279865026474*x_102 + 5.24032020568848) + 0.00251939709262571*std::sin(0.521439850330353*x_103 + 8.35359954833984) + 0.0378528957176944*std::sin(0.325759828090668*x_105 + 1.9398398399353) - 0.0582153795974066*std::sin(0.326879858970642*x_105 - 7.46807956695557) + 0.125211056998089*std::sin(0.267679959535599*x_106 - 7.52112007141113) + 0.033921965510231*std::sin(0.526319861412048*x_106 - 4.0403995513916) + 0.0218923220809185*std::sin(0.272559970617294*x_107 - 7.52992010116577) - 0.0285019283143916*std::sin(0.584239840507507*x_107 + 2.17967987060547) + 0.00638655552582894*std::sin(0.444399863481522*x_108 + 2.046719789505) + 0.0112783846203153*std::sin(0.472879856824875*x_109 - 7.34272003173828) + 0.00162702999398646*std::sin(0.535279810428619*x_109 + 8.36967945098877) - 0.00513408287027993*std::sin(0.611279845237732*x_110 - 0.978959858417511) + 0.0764800016260724*std::sin(0.230719983577728*x_111 - 7.57328033447266) + 0.0818564609403507*std::sin(0.247679978609085*x_111 + 5.05423974990845) - 0.00558892893635608*std::sin(0.29775995016098*x_111 - 4.2792797088623) - 0.0161956465032541*std::sin(0.326159834861755*x_111 - 7.47175979614258) - 0.00869231623175762*std::sin(0.414799869060516*x_111 - 1.16295981407166) - 0.0285831787065247*std::sin(0.453359842300415*x_111 + 8.24512004852295) - 0.0173188409218799*std::sin(0.455839842557907*x_111 - 4.36560010910034) + 0.00949774251044713*std::sin(0.535999834537506*x_112 - 0.999279797077179) + 0.0218910489788877*std::sin(0.5933598279953*x_112 - 1.00103986263275) - 0.010642577785748*std::sin(0.337679862976074*x_115 + 5.1374397277832) + 0.0795789961043074*std::sin(0.342799842357635*x_115 - 7.43576002120972) - 0.0291844871388907*std::sin(0.493279844522476*x_115 - 4.12056016921997) - 0.0450426751897672*std::sin(0.301039934158325*x_116 + 1.90431988239288) - 0.025245598661544*std::sin(0.396719843149185*x_117 + 1.99855983257294) - 0.0410966477791056*std::sin(0.550879836082458*x_117 + 8.3601598739624) + 0.0151224547830203*std::sin(0.597839832305908*x_117 + 5.40000009536743) + 0.0122220808181746*std::sin(0.294559925794601*x_119 - 4.29423999786377) + 0.0548376224666019*std::sin(0.300399929285049*x_119 + 8.296799659729) + 0.0142836137989466*std::sin(0.36575984954834*x_119 + 5.16232013702393) - 0.0114071988945188*std::sin(0.45279985666275*x_119 - 1.16775989532471) + 0.00848378684113657*std::sin(0.29615992307663*x_120 - 7.47679996490479) + 0.0490867812086949*std::sin(0.304079920053482*x_120 - 7.47528028488159) + 0.0470251765706363*std::sin(0.405039846897125*x_120 + 5.21120023727417) - 0.0123857589241645*std::sin(0.449199855327606*x_120 - 4.16680002212524) - 0.133007238338599*std::sin(0.183280006051064*x_15 + 1.78319990634918) + 0.0415681709030624*std::sin(0.346639841794968*x_16 - 7.43271970748901) - 0.0103979865795015*std::sin(0.375999838113785*x_16 + 5.18239974975586) + 0.0181317562124661*std::sin(0.387439846992493*x_16 - 7.39447975158691) - 0.0225911295074404*std::sin(0.274959951639175*x_18 - 7.52424001693726) - 0.112208224431747*std::sin(0.25655996799469*x_20 - 7.54432010650635) + 0.0267544319689572*std::sin(0.343279838562012*x_20 - 7.44608020782471) + 0.150661117366398*std::sin(0.234959989786148*x_21 + 5.042799949646) - 0.0229235579849293*std::sin(0.420959860086441*x_21 + 8.42536067962646) + 0.00840077152724175*std::sin(0.457599848508835*x_22 - 7.32376003265381) + 0.0690278311797954*std::sin(0.266079962253571*x_24 + 5.06623983383179) - 0.0204047059137699*std::sin(0.305119842290878*x_24 + 5.10567998886108) - 0.121791105337739*std::sin(0.306879937648773*x_24 + 5.1399998664856) + 0.0680955541172969*std::sin(0.313759922981262*x_24 - 7.46903991699219) - 0.0163220558280975*std::sin(0.351119846105576*x_24 - 4.26471996307373) - 0.0249354721004186*std::sin(0.404879868030548*x_24 + 8.39160060882568) + 0.00643440873681731*std::sin(0.788399875164032*x_25 - 4.00871992111206) - 0.145907784331384*std::sin(0.290719836950302*x_27 - 4.32800006866455) + 0.0447161847548553*std::sin(0.317679852247238*x_28 + 5.11696004867554) + 0.0197632428524745*std::sin(0.320399850606918*x_28 - 4.27432012557983) + 0.0886109893266033*std::sin(0.324319839477539*x_28 + 8.30976009368896) + 0.0177985451962856*std::sin(0.330559849739075*x_28 + 5.13048028945923) - 0.0063051771940026*std::sin(0.338479846715927*x_28 + 8.32632064819336) + 0.0154698019483419*std::sin(0.33943983912468*x_28 + 8.31999969482422) + 0.0280526655688443*std::sin(0.291439920663834*x_3 + 5.0874400138855) + 0.0647505880421333*std::sin(0.303439915180206*x_3 - 7.50208044052124) - 0.06149789475791*std::sin(0.271119952201843*x_33 - 1.1729599237442) - 0.0736148462838262*std::sin(0.34895983338356*x_34 - 7.40207958221436) + 0.0202615857237554*std::sin(0.355359852313995*x_34 - 7.41152000427246) - 0.0245618409406565*std::sin(0.369519829750061*x_34 + 8.19623947143555) + 0.101310504128975*std::sin(0.31007993221283*x_35 + 8.25119972229004) + 0.0710817540487607*std::sin(0.314959853887558*x_35 + 1.97399973869324) - 0.023449223558671*std::sin(0.331679850816727*x_35 - 7.42903995513916) - 0.00299786625637635*std::sin(0.326639831066132*x_36 - 7.46719980239868) + 0.00455561179140995*std::sin(0.332639843225479*x_36 - 4.26639986038208) - 0.0251508325675909*std::sin(0.365359842777252*x_36 + 5.18416023254395) + 0.0115256574370673*std::sin(0.418479859828949*x_36 + 5.22432041168213) + 0.046600523440212*std::sin(0.29367995262146*x_37 - 1.33159983158112) - 0.00183466176636688*std::sin(0.428959846496582*x_37 - 1.1684798002243) - 0.0171914517388274*std::sin(0.47775986790657*x_38 - 7.32087993621826) - 0.011904546743866*std::sin(0.479759842157364*x_38 + 5.2579197883606) + 0.00846698133245604*std::sin(0.635359883308411*x_38 - 0.950879812240601) - 0.0485615852189061*std::sin(0.317439913749695*x_41 + 1.91527986526489) - 0.0334712267744355*std::sin(0.387199848890305*x_41 + 1.97423982620239) - 0.011870331583975*std::sin(0.355519831180573*x_43 + 8.34455966949463) + 0.00231009071915479*std::sin(0.401679843664169*x_43 + 1.97855985164642) + 0.0284025039173381*std::sin(0.352319836616516*x_44 + 5.15360021591187) + 0.204111898654923*std::sin(0.182240009307861*x_46 + 4.96335983276367) + 0.00411873342611927*std::sin(0.265519976615906*x_48 - 7.5195198059082) + 0.0216188601660615*std::sin(0.220799997448921*x_51 + 5.01679992675781) + 0.0310891939639479*std::sin(0.186400011181831*x_53 - 4.42840003967285) - 0.0187884365132452*std::sin(0.354639858007431*x_53 - 4.25040006637573) + 0.121418733141891*std::sin(0.280239939689636*x_54 - 1.33415985107422) - 0.00810261677528427*std::sin(0.53823983669281*x_54 - 1.03471982479095) - 0.0449648980065361*std::sin(0.356959849596024*x_55 - 7.43415975570679) + 0.00695838817915442*std::sin(0.487919867038727*x_55 + 2.06407976150513) + 0.0309122623954899*std::sin(0.239359974861145*x_56 + 1.83567988872528) - 0.0186049443158881*std::sin(0.395439833402634*x_56 + 5.18455982208252) - 0.0773851537291703*std::sin(0.139120042324066*x_58 - 7.6723198890686) + 0.246704271818863*std::sin(0.184960007667542*x_58 - 7.6159200668335) + 0.083611123276253*std::sin(0.255359977483749*x_58 + 5.05471992492676) + 0.00871389745446902*std::sin(0.277119934558868*x_58 + 5.09000015258789) - 0.0701932373170754*std::sin(0.386319845914841*x_58 + 5.19648027420044) + 0.0129712940422435*std::sin(0.490319848060608*x_58 - 4.12143993377686) - 0.00223481459068918*std::sin(0.605599880218506*x_58 - 0.993359804153442) - 0.0239906405726177*std::sin(0.298159927129745*x_59 + 5.10799980163574) + 0.0177187933885331*std::sin(0.362959831953049*x_59 - 4.22071981430054) - 0.217498681713699*std::sin(0.125840052962303*x_63 - 1.45423996448517) - 0.119886371569407*std::sin(0.164000019431114*x_64 - 1.42503988742828) - 0.135148559990202*std::sin(0.179200008511543*x_64 - 4.42479991912842) + 0.00580149305312587*std::sin(0.281999945640564*x_64 + 5.10519981384277) - 0.0275210315630939*std::sin(0.417919874191284*x_64 + 1.99703979492188) - 0.0617016186888793*std::sin(0.398639857769012*x_65 - 7.40407991409302) + 0.0127410025196142*std::sin(0.440159857273102*x_66 - 4.15623998641968) + 0.109902018027983*std::sin(0.243359968066216*x_69 - 7.54400014877319) + 0.0461405647645343*std::sin(0.254959970712662*x_70 - 7.52400016784668) + 0.0233730214426321*std::sin(0.515119850635529*x_70 + 5.33439970016479) + 0.0128477556188577*std::sin(0.514559864997864*x_72 - 4.07624006271362) + 0.00623567139428366*std::sin(0.245599970221519*x_73 + 1.86039984226227) - 0.0767233318079288*std::sin(0.42799985408783*x_73 - 4.17216014862061) - 0.0253047287105152*std::sin(0.225519984960556*x_74 + 1.8199999332428) - 0.0414234979121184*std::sin(0.199359983205795*x_75 - 7.59999990463257) + 0.0438019514521487*std::sin(0.382159858942032*x_75 - 7.40551996231079) + 0.0188437093311082*std::sin(0.527119874954224*x_75 - 7.25256013870239) + 0.00699359074555055*std::sin(0.262239962816238*x_76 - 7.52232027053833) + 0.0331523881429746*std::sin(0.289119929075241*x_77 - 7.48000001907349) + 0.0222087343264257*std::sin(0.231439992785454*x_79 + 1.83111989498138) - 0.0186920874966714*std::sin(0.367839843034744*x_79 + 8.36952018737793) + 0.0822495359837022*std::sin(0.375919848680496*x_79 - 7.42759990692139) + 0.0407781357790895*std::sin(0.465919852256775*x_81 + 8.46975994110107) + 0.03581139808946*std::sin(0.263439983129501*x_82 + 1.86799991130829) + 0.0156064634810307*std::sin(0.397759824991226*x_82 - 7.40991973876953) - 0.283527482219804*std::sin(0.158560022711754*x_84 - 7.65680027008057) - 0.0414823183528194*std::sin(0.353839844465256*x_84 + 5.14383983612061) + 0.00817596500463752*std::sin(0.174960017204285*x_85 - 4.43856000900269) + 0.0208354149357707*std::sin(0.212719991803169*x_85 - 7.58776044845581) + 0.0450611407553667*std::sin(0.21399998664856*x_85 - 7.5816798210144) + 0.00830550706036764*std::sin(0.631679832935333*x_86 - 7.16951990127563) + 0.00837716741617102*std::sin(0.51615983247757*x_87 + 5.32791996002197) + 0.00316760877769289*std::sin(0.797919869422913*x_87 - 0.793519854545593) - 0.0119916030793788*std::sin(0.988159835338593*x_87 + 5.58551979064941) - 0.0351707740281294*std::sin(0.225519984960556*x_89 + 1.8122398853302) + 0.0223126519097421*std::sin(0.321119844913483*x_90 + 8.31783962249756) - 0.0282231338883262*std::sin(0.351999849081039*x_92 - 7.39856004714966) + 0.0559396305516902*std::sin(0.353839844465256*x_92 + 1.99631977081299) + 0.0704944231710689*std::sin(0.359439849853516*x_92 - 1.18815994262695) + 0.00661101429262274*std::sin(0.373199850320816*x_92 - 7.38935995101929) + 0.0135410482395942*std::sin(0.381119847297668*x_92 + 8.18279933929443) + 0.0241367979649754*std::sin(0.38487982749939*x_92 - 1.19791984558105) + 0.0735585189776378*std::sin(0.353119850158691*x_95 - 1.21815991401672) - 0.0249540704302976*std::sin(0.364959836006165*x_95 + 5.16431999206543) + 0.0369101463088083*std::sin(0.38919985294342*x_95 + 1.98527979850769) - 0.0179397030820787*std::sin(0.386959850788116*x_96 + 5.19655990600586) - 0.0343217732474046*std::sin(0.415279865264893*x_96 - 7.3996000289917) - 0.00151837487225109*std::sin(0.439519852399826*x_96 + 8.20975971221924) + 0.0254203500491141*std::sin(0.305199921131134*x_97 + 5.11439990997314) - 0.0203628664556145*std::sin(0.353279858827591*x_97 + 5.16728019714355) - 0.0166070061309541*std::sin(0.37255984544754*x_98 + 5.18039989471436) + 0.0111389370088155*std::sin(0.415599852800369*x_98 - 7.38839960098267) - 0.00901523299202724*std::sin(0.436959862709045*x_98 - 7.37871980667114) - 0.00241443809783612*std::sin(0.451919853687286*x_98 + 2.00551986694336) - 0.0164399452962085*std::sin(0.406159847974777*x_99 - 4.20160007476807) - 0.0394077427645218*std::sin(0.407679855823517*x_99 + 5.20464038848877) + 0.0336928648063974*std::sin(0.443759858608246*x_99 + 5.22552013397217) + 0.00525234728889028*std::sin(0.681439816951752*x_99 + 8.60767936706543) + 0.674558181063712 - 0.000172420028677627*std::exp(-2.08247995376587*x_54));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
