
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0100447960917921*x_1 + 0.00138936850634425*x_10 + 0.00120564718072094*x_100 - 0.000410247275081668*x_101 - 0.000300045321226029*x_102 - 0.000308721911419061*x_103 - 0.00167738883423427*x_104 + 0.000728098862789183*x_105 + 0.000453389750828513*x_106 - 0.000414167452258839*x_107 - 0.000612355562996254*x_108 - 0.00104419559982698*x_109 - 5.57155366749772e-5*x_11 + 0.000453746413324877*x_110 - 0.000416533661568483*x_111 + 0.000167030388575193*x_112 + 0.00135840945435076*x_113 - 0.000945039192386294*x_114 + 0.0014756221972819*x_115 - 0.00354710485003337*x_116 + 0.000988042997388398*x_117 - 5.34731948061451e-5*x_118 + 0.000713612755920931*x_119 - 0.000268504071758605*x_12 - 0.00208010853029822*x_120 + 0.00123206000401981*x_13 - 0.00109935425359519*x_14 - 0.0023811013397732*x_15 + 0.00130694722676262*x_16 + 0.00209580828035107*x_17 - 0.000233842903067309*x_18 + 0.000132123964818694*x_19 + 0.00356684965901639*x_2 - 0.00275856253185105*x_20 - 5.21245995367833e-5*x_21 - 0.003355959534984*x_22 - 0.000114476058461412*x_23 - 0.000427711357783855*x_24 - 0.00393224798041703*x_25 + 0.000876122055288142*x_26 - 3.39068766542672e-5*x_27 - 0.000498483429500737*x_28 - 0.00274950568030892*x_29 - 0.00128226163710751*x_3 - 0.000218917846572431*x_30 - 0.00422970599446044*x_31 - 8.41925747588027e-5*x_32 - 0.000184168025984378*x_33 - 6.04123866067466e-5*x_34 + 0.000622630323419914*x_35 + 0.000271052928017904*x_36 + 1.0848282371705e-5*x_37 - 9.92384146695315e-5*x_38 - 0.000751942446909735*x_39 + 0.000909068786655253*x_4 - 4.30542823348622e-5*x_40 - 0.000192177185717711*x_41 + 0.00266421834190534*x_42 - 1.90197872937593e-5*x_43 + 0.000154995997658887*x_44 - 0.000276751467446494*x_45 + 0.000169531939058411*x_46 + 0.00011786317501898*x_47 + 0.00363931263082894*x_48 - 0.000251705500441749*x_49 - 0.000479670531151246*x_5 + 2.66213153909228e-5*x_50 + 0.000141512921764913*x_51 - 0.00328612901481668*x_52 + 4.94452478520009e-5*x_53 + 0.000110812245957965*x_54 - 0.000200983931733609*x_55 - 0.000139843071418432*x_56 - 9.1655900792873e-5*x_57 + 0.000189378081700225*x_58 + 0.000959098576056238*x_59 + 0.00146559978603022*x_6 - 0.00101555170894861*x_60 - 0.00044221199667569*x_61 + 0.000280114826710294*x_62 - 3.3971542620309e-5*x_63 + 0.00077435138150274*x_64 - 7.71490342961091e-5*x_65 + 0.00122945371682945*x_66 + 0.000722601977129957*x_67 + 5.4441927859329e-7*x_68 + 0.000539998204704365*x_69 + 0.000243563876652134*x_7 + 0.000240207066417096*x_70 - 4.44379496229789e-5*x_71 - 0.00147678810451673*x_72 - 0.000277986808830155*x_73 - 5.35436866379593e-5*x_74 - 0.000422883414604494*x_75 + 0.00152892541283096*x_76 + 2.86920199264278e-5*x_77 + 6.10676388453928e-5*x_78 + 0.000333849476611372*x_79 + 0.00128436589569269*x_8 + 0.000339552931156049*x_80 - 0.000641426492486702*x_81 - 0.00176827740440188*x_82 + 0.00122907335464278*x_83 + 0.00132531599702769*x_84 + 0.000774163596875157*x_85 - 0.000959612731237187*x_86 + 6.23882981217057e-5*x_87 + 6.20824057009097e-5*x_88 + 0.00139380069586689*x_89 + 0.0013068692945411*x_9 - 0.00103922753511794*x_90 + 0.000621345581419979*x_91 - 0.0013993617573421*x_92 + 0.000537173356664604*x_94 - 2.28334205407557e-5*x_95 - 0.000385815536187533*x_96 + 0.00227334654985476*x_97 - 0.000715758473921634*x_98 - 5.47042852429515e-6*x_99 - 4.29923284656508e-7*std::pow(-7.84783983230591*x_108 - 9.05935955047607, 2) + 4.77862080845429e-5*std::pow(-4.29967975616455*x_14 - 6.14551973342896, 2) + 1.64408698396754e-5*std::pow(-5.92399978637695*x_17 - 9.46343994140625, 2) + 1.00345580161364e-6*std::pow(-6.35599994659424*x_23 - 8.75072002410889, 2) + 6.5925197559231e-6*std::pow(-6.58143997192383*x_37 - 9.56688022613525, 2) - 5.37163704157063e-6*std::pow(-8.35695934295654*x_38 - 9.16335964202881, 2) - 7.24668225869187e-5*std::pow(-5.15975999832153*x_4 - 8.7344799041748, 2) + 3.9598607637638e-7*std::pow(-5.26968002319336*x_44 - 9.51232051849365, 2) + 1.69807286894269e-5*std::pow(-5.72951984405518*x_46 - 7.57535982131958, 2) + 9.21527838984267e-6*std::pow(-5.29848003387451*x_47 - 9.61719989776611, 2) + 2.22920483584829e-5*std::pow(-6.17368030548096*x_5 - 9.76648044586182, 2) + 1.33261112235724e-5*std::pow(-7.51959991455078*x_50 - 9.97152042388916, 2) - 3.57625616558517e-5*std::pow(-4.18656015396118*x_50 - 5.98431968688965, 2) - 8.24401552406186e-6*std::pow(-4.89456033706665*x_53 - 9.16567993164063, 2) - 6.47082295635868e-5*std::pow(-3.0511200428009*x_54 - 3.61879992485046, 2) - 5.26362282352769e-7*std::pow(-5.50551986694336*x_55 - 7.75392007827759, 2) + 4.64000600903282e-6*std::pow(-1.89527988433838*x_56 - 2.83895993232727, 2) - 6.8783041172917e-6*std::pow(-6.54728031158447*x_58 - 9.33351993560791, 2) - 1.24575000475295e-5*std::pow(-7.056960105896*x_60 - 9.21016025543213, 2) - 5.11641941601922e-7*std::pow(-5.30559968948364*x_60 - 6.09144020080566, 2) + 1.70098922342937e-5*std::pow(-4.85904026031494*x_64 - 7.49032020568848, 2) - 3.39429312621315e-5*std::pow(-4.05999994277954*x_66 - 5.80347967147827, 2) - 1.893166951068e-5*std::pow(-6.47735977172852*x_68 - 8.89960098266602, 2) - 4.78301827280693e-6*std::pow(-2.09295964241028*x_69 - 3.34831976890564, 2) + 5.44133580844034e-5*std::pow(-4.50415992736816*x_7 - 7.37455987930298, 2) - 6.19154190640664e-5*std::pow(-4.27399969100952*x_7 - 6.91639995574951, 2) + 3.56911059323911e-6*std::pow(-3.77760004997253*x_7 - 5.96271991729736, 2) - 1.32690611742218e-5*std::pow(-5.52303981781006*x_70 - 5.93503999710083, 2) - 6.45190646008417e-7*std::pow(-6.29328012466431*x_71 - 9.53400039672852, 2) + 3.27165744549261e-5*std::pow(-4.51783990859985*x_71 - 6.98280000686646, 2) + 1.94193708058442e-5*std::pow(-6.04655981063843*x_72 - 7.45879983901978, 2) - 8.965580282219e-7*std::pow(-5.11975955963135*x_73 - 7.37648010253906, 2) + 1.22384693603777e-5*std::pow(-4.88303995132446*x_73 - 6.30624008178711, 2) - 1.78770786774631e-5*std::pow(-5.61847972869873*x_74 - 9.03551959991455, 2) + 1.66124336643438e-5*std::pow(-6.10015964508057*x_75 - 8.54423999786377, 2) + 3.01660146798403e-5*std::pow(-4.85663986206055*x_75 - 7.2629599571228, 2) + 5.55474107036726e-7*std::pow(-6.23928022384644*x_76 - 8.45512008666992, 2) + 4.29009924076758e-6*std::pow(-5.75799989700317*x_77 - 6.99304008483887, 2) + 4.42039179426525e-6*std::pow(-6.51543998718262*x_79 - 9.14416027069092, 2) + 2.68974392362209e-7*std::pow(-4.61711978912354*x_80 - 6.62912034988403, 2) + 9.49975108850398e-8*std::pow(-9.80399990081787*x_81 - 9.96455955505371, 2) + 3.66075205904327e-5*std::pow(-5.51904010772705*x_82 - 7.76719999313354, 2) + 1.43453699635133e-5*std::pow(-6.52063989639282*x_83 - 9.15176010131836, 2) + 2.03447873449803e-5*std::pow(-5.5021595954895*x_83 - 7.13471984863281, 2) + 8.13262084815029e-6*std::pow(-7.79527997970581*x_85 - 9.79351997375488, 2) - 4.07616563547528e-5*std::pow(-3.08799982070923*x_86 - 4.93535995483398, 2) - 4.72017833132511e-6*std::pow(-7.49096012115479*x_87 - 9.92399978637695, 2) - 2.60979681024807e-5*std::pow(-5.73847961425781*x_87 - 7.79936027526855, 2) + 2.22045858223108e-5*std::pow(-4.00183963775635*x_87 - 5.6003999710083, 2) + 1.58874373943256e-5*std::pow(-6.34912014007568*x_89 - 9.13704013824463, 2) + 8.13880440743792e-7*std::pow(-5.6814398765564*x_90 - 8.55256080627441, 2) + 6.99786771373037e-6*std::pow(-5.93959999084473*x_99 - 7.78736019134521, 2) + 4.45651641520343e-5*std::exp(0.754959881305695*x_22) - 0.0201118058446139*std::sin(0.221119984984398*x_1 + 5.20879983901978) + 0.0787195856596973*std::sin(0.241199970245361*x_10 - 7.54232025146484) + 0.0190433679767319*std::sin(0.34215983748436*x_10 - 1.05311977863312) - 0.0126843519102892*std::sin(0.320959836244583*x_101 + 5.14448022842407) - 0.00570674637686971*std::sin(0.403039842844009*x_102 + 1.98351979255676) - 0.0003041793949676*std::sin(0.376479834318161*x_104 + 5.18048000335693) - 0.014119295905194*std::sin(0.388159841299057*x_104 - 7.40119981765747) - 0.0113170438617981*std::sin(0.322239845991135*x_105 - 1.24519991874695) + 0.000397398582574146*std::sin(0.388559848070145*x_105 + 1.97791981697083) - 0.00449395203084026*std::sin(0.345919847488403*x_106 + 1.94127976894379) - 0.0146566465213444*std::sin(0.391999840736389*x_106 - 7.40279960632324) - 0.000514924713011533*std::sin(0.314319938421249*x_107 + 5.11247968673706) + 0.00789543617424085*std::sin(0.386559844017029*x_107 - 7.42159986495972) - 0.0174827492539614*std::sin(0.37951985001564*x_108 - 7.40759992599487) - 0.0128042389296804*std::sin(0.32151985168457*x_109 - 7.4521598815918) - 0.000228234221244367*std::sin(0.435439854860306*x_109 + 5.23640012741089) + 0.0220761339745092*std::sin(0.19743999838829*x_110 + 1.78303980827332) - 0.005703654378467*std::sin(0.364959836006165*x_110 + 5.18104028701782) - 0.0151890532284559*std::sin(0.22647999227047*x_111 + 5.04263973236084) + 0.0143928530001699*std::sin(0.326559841632843*x_111 - 4.26839971542358) - 0.000659700478615929*std::sin(0.371999859809875*x_111 + 5.18032026290894) - 0.0198576281110999*std::sin(0.332879841327667*x_112 - 4.2545599937439) + 0.00789085123772047*std::sin(0.33519983291626*x_112 + 5.14775991439819) + 0.00964386450537088*std::sin(0.368799835443497*x_112 + 1.98655986785889) - 0.00858751223075913*std::sin(0.376959830522537*x_113 + 1.98927986621857) - 0.000803505767458012*std::sin(0.244079977273941*x_114 + 5.04392004013062) + 0.0089355700187386*std::sin(0.366399854421616*x_114 - 7.43375968933105) + 0.0117083532826398*std::sin(0.205520004034042*x_115 - 7.59376001358032) + 0.023964651726519*std::sin(0.228079989552498*x_115 + 1.83607995510101) + 0.000586817609544883*std::sin(0.405839860439301*x_117 + 5.1910400390625) + 0.00030877599420615*std::sin(0.266799956560135*x_118 + 5.07727956771851) + 0.000310172098149363*std::sin(0.36575984954834*x_119 - 1.21287977695465) + 0.0212613411395015*std::sin(0.249359980225563*x_12 + 8.27031993865967) - 0.000441375868253436*std::sin(0.463279873132706*x_120 - 1.14679980278015) - 0.0626446600932782*std::sin(0.138080030679703*x_14 + 8.09639930725098) - 0.000908834790347432*std::sin(0.393119841814041*x_15 + 2.19063997268677) - 0.0116806728207951*std::sin(0.293359935283661*x_16 - 4.28935956954956) + 0.0232513794968205*std::sin(0.315119922161102*x_16 - 4.26247978210449) - 0.000322340122587701*std::sin(0.365359842777252*x_16 + 2.14367985725403) + 0.0409236100740836*std::sin(0.181920006871223*x_19 - 4.4191198348999) + 0.0165335665783068*std::sin(0.296239942312241*x_21 - 4.29503965377808) - 0.00877944177087857*std::sin(0.318959832191467*x_21 + 5.13607978820801) + 0.0182625344319073*std::sin(0.363199830055237*x_21 - 4.21568012237549) - 0.0432271998409815*std::sin(0.134160041809082*x_23 - 4.49503993988037) + 0.0311480414080436*std::sin(0.29807984828949*x_23 - 4.32223987579346) + 0.00114603277919696*std::sin(0.317679941654205*x_24 + 8.35151958465576) + 0.0142323302266056*std::sin(0.465839862823486*x_24 + 8.48311996459961) - 0.0214252179980736*std::sin(0.297679930925369*x_26 + 5.10839986801147) + 0.0364337586164247*std::sin(0.310239940881729*x_27 + 5.1334400177002) - 0.0149744697516285*std::sin(0.360559850931168*x_27 + 5.16951990127563) - 0.0292059771900596*std::sin(0.36287984251976*x_27 + 5.17112016677856) + 0.00625823256671704*std::sin(0.519679844379425*x_27 - 4.07424020767212) + 0.0176936509919583*std::sin(0.257439970970154*x_28 - 7.52328014373779) + 0.0147496474933782*std::sin(0.262639969587326*x_28 + 5.06967973709106) - 0.021097378710213*std::sin(0.336719840764999*x_28 - 4.25856018066406) - 0.000484313336394172*std::sin(0.849039852619171*x_29 - 3.96919989585876) + 0.0005005894464369*std::sin(0.32847985625267*x_3 - 1.05927979946136) - 0.0254946693484832*std::sin(0.372319847345352*x_3 - 1.03087985515594) + 0.000769978538490393*std::sin(0.268079966306686*x_32 - 7.42328023910522) - 0.0143265666279676*std::sin(0.302319914102554*x_33 - 1.18495988845825) + 0.0153262937806945*std::sin(0.348319828510284*x_34 + 1.97575974464417) - 0.0119172809599272*std::sin(0.357759833335876*x_34 + 1.97135984897614) + 0.0010406152225511*std::sin(0.361279845237732*x_34 + 1.99055981636047) - 0.0195163574738583*std::sin(0.29615992307663*x_35 + 8.26560020446777) + 0.0195804267949671*std::sin(0.309519916772842*x_35 + 8.2775993347168) + 0.000669959843708157*std::sin(0.31743985414505*x_35 - 1.20303988456726) + 0.0149784402847428*std::sin(0.332799851894379*x_35 - 1.22799980640411) + 0.00554436970319097*std::sin(0.313519924879074*x_36 - 4.28071975708008) - 0.0127847152782112*std::sin(0.317359834909439*x_36 + 1.92511987686157) + 0.0210189549112703*std::sin(0.340159833431244*x_36 + 5.15488004684448) - 0.00922813189457836*std::sin(0.351599842309952*x_37 + 5.16336011886597) + 0.0295837296083967*std::sin(0.3713598549366*x_37 + 5.17824029922485) - 0.0200137760430798*std::sin(0.377359837293625*x_37 + 5.18239974975586) + 0.00188081772745732*std::sin(0.149600028991699*x_38 + 4.92015981674194) + 0.0232907258128191*std::sin(0.320479840040207*x_38 - 7.46943950653076) - 0.0184272003011508*std::sin(0.3574398458004*x_38 + 5.16215991973877) - 0.0125342753660851*std::sin(0.353839844465256*x_39 - 7.44127988815308) + 0.0682683902812206*std::sin(0.132800042629242*x_40 + 4.9093599319458) - 0.000666951393268436*std::sin(0.315199851989746*x_41 + 5.12504005432129) - 0.0114647521153408*std::sin(0.309279918670654*x_43 + 5.13111972808838) - 0.000411688435460242*std::sin(0.331439822912216*x_43 + 5.13816022872925) + 0.0209651619723048*std::sin(0.34911984205246*x_43 + 5.14328002929688) + 0.0177498069599351*std::sin(0.307359933853149*x_44 - 7.48016023635864) + 0.0181504483516462*std::sin(0.27687993645668*x_45 - 7.51800012588501) - 0.0119077024159509*std::sin(0.298879951238632*x_45 - 7.48623991012573) + 0.000523015413922674*std::sin(0.321199834346771*x_45 - 7.46703958511353) + 0.000691055832333574*std::sin(0.298079937696457*x_47 + 5.12423944473267) - 0.0144369981858504*std::sin(0.306559920310974*x_47 + 5.11695957183838) + 0.017200159303784*std::sin(0.251199960708618*x_48 + 5.06759977340698) + 0.0140077673058782*std::sin(0.273039966821671*x_49 + 1.8582398891449) + 0.000495459901508023*std::sin(0.314719915390015*x_49 - 7.46687984466553) + 0.000422199295369958*std::sin(1.0694397687912*x_5 - 6.76344013214111) + 0.00702271699965512*std::sin(0.367279857397079*x_50 + 5.15799999237061) - 0.014360477781572*std::sin(0.323439836502075*x_51 - 4.28312015533447) - 0.000800398370224176*std::sin(0.229279980063438*x_52 + 5.04008007049561) - 0.0402435120415776*std::sin(0.20728000998497*x_53 + 4.99191951751709) - 0.0154070994877025*std::sin(0.273679941892624*x_53 + 5.08431959152222) - 0.00932865269602465*std::sin(0.270639955997467*x_54 + 5.09176015853882) + 0.0182823369504643*std::sin(0.22647999227047*x_56 + 5.04399967193604) - 0.0415216329187302*std::sin(0.157680034637451*x_57 + 4.92840003967285) - 0.000408200985287487*std::sin(0.266399949789047*x_57 - 7.50400018692017) + 0.0104104075563262*std::sin(0.347279846668243*x_59 - 4.26007986068726) + 0.000450630214656617*std::sin(0.374879837036133*x_59 + 1.95975983142853) + 0.028956184418025*std::sin(0.247119963169098*x_60 - 7.52824020385742) - 0.00860539711364352*std::sin(0.218399986624718*x_63 + 8.20975971221924) - 0.0245693625352758*std::sin(0.149120032787323*x_65 + 4.93391990661621) - 0.00122884046585468*std::sin(0.282159924507141*x_65 + 5.1081600189209) - 0.0192445560516439*std::sin(0.287759929895401*x_65 + 5.12423992156982) - 0.00325227809313844*std::sin(0.166320025920868*x_67 + 4.94535970687866) + 0.0241809697577236*std::sin(0.20320001244545*x_69 + 4.98776006698608) - 0.00966034792750262*std::sin(0.358319848775864*x_7 + 8.53191947937012) - 0.00442048550487219*std::sin(0.121280059218407*x_74 + 4.8842396736145) - 0.0159474055802495*std::sin(0.235679984092712*x_74 + 5.03487968444824) + 0.0163978409448702*std::sin(0.274879962205887*x_74 - 7.51688003540039) + 0.00152961972878703*std::sin(0.225279986858368*x_75 - 7.56712007522583) - 0.0343287639503404*std::sin(0.175280019640923*x_78 + 4.95191955566406) - 0.0457480261758149*std::sin(0.157200023531914*x_8 - 4.46224021911621) - 0.00104178084055688*std::sin(0.257999956607819*x_8 - 4.33247995376587) + 0.00660386648466932*std::sin(0.29887992143631*x_80 + 5.11567974090576) - 0.00991709754811248*std::sin(0.385439842939377*x_81 - 4.21808004379272) + 0.0840349739226517*std::sin(0.13728004693985*x_84 + 4.90903997421265) + 0.000893102571189952*std::sin(0.294639945030212*x_84 - 7.47824001312256) + 0.0343614027531732*std::sin(0.186480015516281*x_85 - 7.60864019393921) - 0.00731381942278225*std::sin(0.333439826965332*x_88 - 4.27568006515503) - 0.120947378567654*std::sin(0.129600048065186*x_9 - 4.49575996398926) - 0.0462159490039268*std::sin(0.222719997167587*x_9 - 4.3692798614502) - 0.0206440395764356*std::sin(0.372239857912064*x_9 - 1.00943982601166) + 7.00133145628182e-5*std::sin(0.677919805049896*x_9 - 6.93639993667603) - 0.0187404059498264*std::sin(0.372079849243164*x_92 + 1.99183976650238) - 0.0240165107728538*std::sin(0.325199842453003*x_93 + 1.97279977798462) - 0.0159927449127399*std::sin(0.332959830760956*x_93 + 1.98767983913422) - 0.014174809719366*std::sin(0.351759850978851*x_93 + 1.96647977828979) - 0.0150921707239807*std::sin(0.358479827642441*x_93 - 7.410719871521) - 0.000799343579967387*std::sin(0.362159848213196*x_93 - 7.41519975662231) - 0.0165503667722425*std::sin(0.395199835300446*x_94 - 7.40279960632324) - 0.00723210464204805*std::sin(0.279039949178696*x_95 - 7.51416015625) + 0.00553027844826552*std::sin(0.329999834299088*x_95 - 1.22255992889404) - 0.000177134303114583*std::sin(0.33111983537674*x_95 + 8.16551971435547) - 0.00930822740364879*std::sin(0.340319842100143*x_95 + 5.15104007720947) - 0.0144334194812694*std::sin(0.380959838628769*x_96 + 5.1799201965332) - 0.0167387281344224*std::sin(0.382799863815308*x_96 - 7.40703964233398) - 0.00030150540028861*std::sin(0.392399847507477*x_96 - 7.41631984710693) - 0.000354926416626763*std::sin(0.319759905338287*x_98 + 1.9171998500824) + 0.00362882043364884*std::sin(0.392799854278564*x_98 - 1.18863987922668) + 0.00715132172959625*std::sin(0.374879837036133*x_99 - 1.20063984394073) - 0.00898619661147313*std::sin(0.398159861564636*x_99 - 7.40623998641968) + 0.345891916726864);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000863720695885094*x_1 - 0.00190634442670773*x_10 - 0.00163988292569762*x_100 + 0.000741517875703502*x_101 + 5.19045071924375e-5*x_102 + 0.000190023932466927*x_103 - 0.000462326057078628*x_104 + 0.00106063995073154*x_105 + 1.93776882881219e-5*x_106 + 0.000229535350401296*x_107 + 0.000661518357217747*x_108 - 0.000134171802409279*x_109 + 0.000479762755300657*x_11 + 0.000168409082883202*x_110 + 0.000331687059335776*x_111 + 2.98820616880103e-5*x_112 - 0.00177217401386591*x_113 + 0.00112159051046453*x_114 + 0.000301277320843666*x_115 - 0.00021684863688007*x_116 + 0.000410282277746727*x_117 + 1.93971250038813e-5*x_118 + 0.000931084088330649*x_119 - 0.000255703689866053*x_12 + 0.00239315349499059*x_120 - 0.00116180600464545*x_13 + 0.000779878414451988*x_14 + 0.00211640512005*x_15 - 0.000363032737493271*x_16 - 0.000585753155259925*x_17 - 0.000257712456346664*x_18 - 7.5608092416033e-5*x_19 - 0.00149370482622043*x_2 + 0.00118789462189772*x_20 + 9.76348717923459e-5*x_21 + 0.00474601052635666*x_22 - 1.71593523868667e-5*x_23 + 0.000510617725597692*x_24 + 0.00340127211921312*x_25 - 0.000940108636225293*x_26 - 7.88363273123613e-5*x_27 - 0.000122998799671589*x_28 + 0.00276327905553638*x_29 - 0.000260995810284324*x_3 + 0.000348425001140399*x_30 + 0.00863619881419379*x_31 - 0.000442520702216206*x_32 - 0.000128092100490349*x_33 - 0.000104744864502117*x_34 - 0.000690902997996332*x_35 + 1.50632261693749e-6*x_36 + 2.52231648627836e-5*x_37 - 3.29897477233999e-6*x_38 - 0.000337706933366483*x_39 - 8.22360918026843e-5*x_4 - 0.000170961544616005*x_40 + 0.000177583523801646*x_41 - 0.001669502459012*x_42 + 3.94634323995048e-5*x_43 - 9.90238317018975e-5*x_44 - 2.33804216894061e-5*x_45 - 0.000194573181902722*x_46 + 0.000597533443685201*x_47 - 0.00466411312089633*x_48 - 6.69143955866045e-5*x_49 + 0.000799956229617209*x_5 + 7.15278920870031e-5*x_50 - 0.000330428750657504*x_51 - 0.000474431811080719*x_52 - 7.69305227231351e-6*x_53 + 8.76427510975859e-6*x_54 + 5.7409655291947e-5*x_55 + 0.000149692740600984*x_56 + 3.14300271194332e-5*x_57 - 0.000187569333225655*x_58 - 9.99495855211639e-5*x_59 + 0.000406990411917714*x_6 + 0.0011566260303253*x_60 - 6.68404687393149e-6*x_61 + 2.71216725113383e-5*x_62 + 0.000142665603649606*x_63 - 0.000966773920507041*x_64 - 1.11090346645918e-5*x_65 - 0.00143292043446965*x_66 - 0.00193210617675592*x_67 - 0.000745498900824024*x_68 - 0.000219432278658428*x_69 - 0.000270271148469391*x_7 + 0.000175025137563698*x_70 + 9.01078590774066e-6*x_71 + 0.00176449172270486*x_72 + 2.96823214359057e-5*x_73 - 1.77994854134785e-6*x_74 + 0.000440543784057991*x_75 + 0.000135728694150197*x_76 - 2.56312739775381e-6*x_77 + 1.18040472763569e-5*x_78 - 0.000486291220149672*x_79 + 0.000404305818182835*x_8 - 0.000663031385692243*x_80 - 6.91279693884434e-5*x_81 + 0.000717339190514603*x_82 - 0.00139764059574313*x_83 + 0.000699345052337135*x_84 + 0.000155286777687282*x_85 + 0.00206726102065366*x_86 + 2.75370799630511e-7*x_87 + 4.17320731297874e-5*x_88 + 0.000309585155818607*x_89 - 0.00145017015655187*x_9 - 0.000167621513770186*x_90 + 0.00166287035260003*x_91 + 0.00188346543098503*x_92 - 1.80849907601773e-5*x_94 - 4.68095971705664e-6*x_95 + 0.000717219715811333*x_96 - 0.00203286414118454*x_97 - 0.00011324553934904*x_98 + 2.38262515133359e-5*x_99 - 9.99607635170382e-7*std::pow(-7.84783983230591*x_108 - 9.05935955047607, 2) - 5.79613080021937e-5*std::pow(-4.29967975616455*x_14 - 6.14551973342896, 2) + 3.37045644543385e-6*std::pow(-5.92399978637695*x_17 - 9.46343994140625, 2) + 2.33311876013048e-6*std::pow(-6.35599994659424*x_23 - 8.75072002410889, 2) + 2.19154612993033e-7*std::pow(-6.58143997192383*x_37 - 9.56688022613525, 2) + 6.51541776429793e-6*std::pow(-8.35695934295654*x_38 - 9.16335964202881, 2) - 2.40900885349674e-6*std::pow(-5.15975999832153*x_4 - 8.7344799041748, 2) + 9.20700784288168e-7*std::pow(-5.26968002319336*x_44 - 9.51232051849365, 2) + 3.48113007508443e-6*std::pow(-5.72951984405518*x_46 - 7.57535982131958, 2) - 1.02257523082749e-5*std::pow(-5.29848003387451*x_47 - 9.61719989776611, 2) - 2.47364165589601e-5*std::pow(-6.17368030548096*x_5 - 9.76648044586182, 2) + 2.73191612755598e-6*std::pow(-7.51959991455078*x_50 - 9.97152042388916, 2) + 4.33774709099121e-5*std::pow(-4.18656015396118*x_50 - 5.98431968688965, 2) - 1.69006235863976e-6*std::pow(-4.89456033706665*x_53 - 9.16567993164063, 2) + 7.84865293637912e-5*std::pow(-3.0511200428009*x_54 - 3.61879992485046, 2) - 1.22383637984604e-6*std::pow(-5.50551986694336*x_55 - 7.75392007827759, 2) + 1.07884024880657e-5*std::pow(-1.89527988433838*x_56 - 2.83895993232727, 2) - 1.41008503028437e-6*std::pow(-6.54728031158447*x_58 - 9.33351993560791, 2) + 1.51100710044779e-5*std::pow(-7.056960105896*x_60 - 9.21016025543213, 2) - 1.18961035503649e-6*std::pow(-5.30559968948364*x_60 - 6.09144020080566, 2) - 1.88750613296779e-5*std::pow(-4.85904026031494*x_64 - 7.49032020568848, 2) - 6.95846220820321e-6*std::pow(-4.05999994277954*x_66 - 5.80347967147827, 2) + 2.29627830181237e-5*std::pow(-6.47735977172852*x_68 - 8.89960098266602, 2) - 1.11209179760459e-5*std::pow(-2.09295964241028*x_69 - 3.34831976890564, 2) - 6.59995746426243e-5*std::pow(-4.50415992736816*x_7 - 7.37455987930298, 2) - 2.05824938045816e-6*std::pow(-4.27399969100952*x_7 - 6.91639995574951, 2) + 8.29848097811165e-6*std::pow(-3.77760004997253*x_7 - 5.96271991729736, 2) + 1.60944375468828e-5*std::pow(-5.52303981781006*x_70 - 5.93503999710083, 2) - 1.50012227508404e-6*std::pow(-6.29328012466431*x_71 - 9.53400039672852, 2) + 6.70705323498256e-6*std::pow(-4.51783990859985*x_71 - 6.98280000686646, 2) + 3.9810632975682e-6*std::pow(-6.04655981063843*x_72 - 7.45879983901978, 2) - 2.08457248622844e-6*std::pow(-5.11975955963135*x_73 - 7.37648010253906, 2) - 1.48444021927263e-5*std::pow(-4.88303995132446*x_73 - 6.30624008178711, 2) + 2.16836385421227e-5*std::pow(-5.61847972869873*x_74 - 9.03551959991455, 2) + 3.40562784477559e-6*std::pow(-6.10015964508057*x_75 - 8.54423999786377, 2) - 3.65892532205854e-5*std::pow(-4.85663986206055*x_75 - 7.2629599571228, 2) + 1.29152380982805e-6*std::pow(-6.23928022384644*x_76 - 8.45512008666992, 2) - 4.76051730161093e-6*std::pow(-5.75799989700317*x_77 - 6.99304008483887, 2) + 1.4694673490806e-7*std::pow(-6.51543998718262*x_79 - 9.14416027069092, 2) + 6.25387984010669e-7*std::pow(-4.61711978912354*x_80 - 6.62912034988403, 2) + 2.20877167140963e-7*std::pow(-9.80399990081787*x_81 - 9.96455955505371, 2) - 4.44023466432996e-5*std::pow(-5.51904010772705*x_82 - 7.76719999313354, 2) - 1.59183688014397e-5*std::pow(-6.52063989639282*x_83 - 9.15176010131836, 2) + 4.17077808574293e-6*std::pow(-5.5021595954895*x_83 - 7.13471984863281, 2) - 9.86429684922362e-6*std::pow(-7.79527997970581*x_85 - 9.79351997375488, 2) + 4.52312544369955e-5*std::pow(-3.08799982070923*x_86 - 4.93535995483398, 2) + 5.23775543452039e-6*std::pow(-7.49096012115479*x_87 - 9.92399978637695, 2) - 5.3502074805958e-6*std::pow(-5.73847961425781*x_87 - 7.79936027526855, 2) - 2.69326002103189e-5*std::pow(-4.00183963775635*x_87 - 5.6003999710083, 2) + 5.28144825121869e-7*std::pow(-6.34912014007568*x_89 - 9.13704013824463, 2) + 1.89234017258064e-6*std::pow(-5.6814398765564*x_90 - 8.55256080627441, 2) + 2.32629563104628e-7*std::pow(-5.93959999084473*x_99 - 7.78736019134521, 2) + 0.000103617738184585*std::exp(0.754959881305695*x_22) + 0.0223171060427017*std::sin(0.221119984984398*x_1 + 5.20879983901978) - 0.095481318420464*std::sin(0.241199970245361*x_10 - 7.54232025146484) + 0.000633057175941706*std::sin(0.34215983748436*x_10 - 1.05311977863312) - 0.00260035241864244*std::sin(0.320959836244583*x_101 + 5.14448022842407) + 0.00633250266213725*std::sin(0.403039842844009*x_102 + 1.98351979255676) - 0.000707242562854099*std::sin(0.376479834318161*x_104 + 5.18048000335693) + 0.0156675052652661*std::sin(0.388159841299057*x_104 - 7.40119981765747) + 0.0137267778976628*std::sin(0.322239845991135*x_105 - 1.24519991874695) + 0.000923984979469966*std::sin(0.388559848070145*x_105 + 1.97791981697083) - 0.00092128152193407*std::sin(0.345919847488403*x_106 + 1.94127976894379) + 0.0162637774635656*std::sin(0.391999840736389*x_106 - 7.40279960632324) - 0.0011972430734369*std::sin(0.314319938421249*x_107 + 5.11247968673706) - 0.00876118672362308*std::sin(0.386559844017029*x_107 - 7.42159986495972) - 0.00358404667645501*std::sin(0.37951985001564*x_108 - 7.40759992599487) + 0.014208249631959*std::sin(0.32151985168457*x_109 - 7.4521598815918) - 0.000530663674904964*std::sin(0.435439854860306*x_109 + 5.23640012741089) - 0.0267767971572558*std::sin(0.19743999838829*x_110 + 1.78303980827332) + 0.00632907161985442*std::sin(0.364959836006165*x_110 + 5.18104028701782) - 0.000504928495515251*std::sin(0.22647999227047*x_111 + 5.04263973236084) - 0.0159710584491263*std::sin(0.326559841632843*x_111 - 4.26839971542358) - 0.00153385885083407*std::sin(0.371999859809875*x_111 + 5.18032026290894) + 0.0240859056467546*std::sin(0.332879841327667*x_112 - 4.2545599937439) + 0.000262314943786783*std::sin(0.33519983291626*x_112 + 5.14775991439819) - 0.0107013337584227*std::sin(0.368799835443497*x_112 + 1.98655986785889) + 0.00952915031984432*std::sin(0.376959830522537*x_113 + 1.98927986621857) - 0.00186821818849887*std::sin(0.244079977273941*x_114 + 5.04392004013062) + 0.00183183431636958*std::sin(0.366399854421616*x_114 - 7.43375968933105) - 0.012992197906687*std::sin(0.205520004034042*x_115 - 7.59376001358032) - 0.0290674363077444*std::sin(0.228079989552498*x_115 + 1.83607995510101) + 0.00136440007761422*std::sin(0.405839860439301*x_117 + 5.1910400390625) + 0.000717930040966255*std::sin(0.266799956560135*x_118 + 5.07727956771851) + 0.000721176099532823*std::sin(0.36575984954834*x_119 - 1.21287977695465) - 0.0235926902082432*std::sin(0.249359980225563*x_12 + 8.27031993865967) - 0.00102623585098117*std::sin(0.463279873132706*x_120 - 1.14679980278015) - 0.0128424530114503*std::sin(0.138080030679703*x_14 + 8.09639930725098) - 0.00211311698612836*std::sin(0.393119841814041*x_15 + 2.19063997268677) + 0.0129614822262019*std::sin(0.293359935283661*x_16 - 4.28935956954956) + 0.00476664328922359*std::sin(0.315119922161102*x_16 - 4.26247978210449) - 0.000749467775205195*std::sin(0.365359842777252*x_16 + 2.14367985725403) + 0.00136042033397104*std::sin(0.181920006871223*x_19 - 4.4191198348999) + 0.00338945971735544*std::sin(0.296239942312241*x_21 - 4.29503965377808) - 0.000291854288622052*std::sin(0.318959832191467*x_21 + 5.13607978820801) - 0.0221511692502516*std::sin(0.363199830055237*x_21 - 4.21568012237549) + 0.0479671497544115*std::sin(0.134160041809082*x_23 - 4.49503993988037) - 0.0377803825430685*std::sin(0.29807984828949*x_23 - 4.32223987579346) + 0.00266462217126968*std::sin(0.317679941654205*x_24 + 8.35151958465576) - 0.0172628151284523*std::sin(0.465839862823486*x_24 + 8.48311996459961) + 0.025987281878559*std::sin(0.297679930925369*x_26 + 5.10839986801147) + 0.00121116455696477*std::sin(0.310239940881729*x_27 + 5.1334400177002) + 0.0166164506540232*std::sin(0.360559850931168*x_27 + 5.16951990127563) + 0.0354247952970693*std::sin(0.36287984251976*x_27 + 5.17112016677856) + 0.00128296741578802*std::sin(0.519679844379425*x_27 - 4.07424020767212) - 0.0214611536662174*std::sin(0.257439970970154*x_28 - 7.52328014373779) + 0.000490321365406716*std::sin(0.262639969587326*x_28 + 5.06967973709106) + 0.0234107489668788*std::sin(0.336719840764999*x_28 - 4.25856018066406) - 1.60999899483756e-5*std::sin(0.849039852619171*x_29 - 3.96919989585876) + 0.00116391237833009*std::sin(0.32847985625267*x_3 - 1.05927979946136) - 0.00084751727735548*std::sin(0.372319847345352*x_3 - 1.03087985515594) + 0.00179026457384664*std::sin(0.268079966306686*x_32 - 7.42328023910522) + 0.0173771172525024*std::sin(0.302319914102554*x_33 - 1.18495988845825) + 0.00314196305679009*std::sin(0.348319828510284*x_34 + 1.97575974464417) + 0.0132240349264605*std::sin(0.357759833335876*x_34 + 1.97135984897614) + 0.00241951752524335*std::sin(0.361279845237732*x_34 + 1.99055981636047) - 0.00064878072839665*std::sin(0.29615992307663*x_35 + 8.26560020446777) + 0.00401408054068905*std::sin(0.309519916772842*x_35 + 8.2775993347168) + 0.00155771273371083*std::sin(0.31743985414505*x_35 - 1.20303988456726) - 0.0181677941300655*std::sin(0.332799851894379*x_35 - 1.22799980640411) - 0.00615232105769321*std::sin(0.313519924879074*x_36 - 4.28071975708008) - 0.00262092738600102*std::sin(0.317359834909439*x_36 + 1.92511987686157) - 0.025494513340355*std::sin(0.340159833431244*x_36 + 5.15488004684448) - 0.00189181089119366*std::sin(0.351599842309952*x_37 + 5.16336011886597) - 0.0358829824005338*std::sin(0.3713598549366*x_37 + 5.17824029922485) + 0.0222083270751101*std::sin(0.377359837293625*x_37 + 5.18239974975586) + 0.00437305870100116*std::sin(0.149600028991699*x_38 + 4.92015981674194) + 0.00477470947098007*std::sin(0.320479840040207*x_38 - 7.46943950653076) + 0.0204477800933535*std::sin(0.3574398458004*x_38 + 5.16215991973877) - 0.00256958601390512*std::sin(0.353839844465256*x_39 - 7.44127988815308) + 0.0139953444243846*std::sin(0.132800042629242*x_40 + 4.9093599319458) - 0.00155071783453486*std::sin(0.315199851989746*x_41 + 5.12504005432129) + 0.0139059376159419*std::sin(0.309279918670654*x_43 + 5.13111972808838) - 0.000957210083948352*std::sin(0.331439822912216*x_43 + 5.13816022872925) + 0.00429795783241324*std::sin(0.34911984205246*x_43 + 5.14328002929688) + 0.00363879477525874*std::sin(0.307359933853149*x_44 - 7.48016023635864) + 0.00372092816443877*std::sin(0.27687993645668*x_45 - 7.51800012588501) + 0.0132134060757593*std::sin(0.298879951238632*x_45 - 7.48623991012573) + 0.00121605463050602*std::sin(0.321199834346771*x_45 - 7.46703958511353) + 0.00160676267367462*std::sin(0.298079937696457*x_47 + 5.12423944473267) - 0.00295965323384478*std::sin(0.306559920310974*x_47 + 5.11695957183838) + 0.00352611439377909*std::sin(0.251199960708618*x_48 + 5.06759977340698) - 0.0169904361066407*std::sin(0.273039966821671*x_49 + 1.8582398891449) + 0.00115198575686331*std::sin(0.314719915390015*x_49 - 7.46687984466553) + 8.65528618749409e-5*std::sin(1.0694397687912*x_5 - 6.76344013214111) - 0.00779277212598788*std::sin(0.367279857397079*x_50 + 5.15799999237061) + 0.0159351332223124*std::sin(0.323439836502075*x_51 - 4.28312015533447) - 0.00186099322974156*std::sin(0.229279980063438*x_52 + 5.04008007049561) + 0.0488125484324916*std::sin(0.20728000998497*x_53 + 4.99191951751709) + 0.0170965191158901*std::sin(0.273679941892624*x_53 + 5.08431959152222) + 0.0103515583364918*std::sin(0.270639955997467*x_54 + 5.09176015853882) - 0.0202870321831982*std::sin(0.22647999227047*x_56 + 5.04399967193604) + 0.0460745639686851*std::sin(0.157680034637451*x_57 + 4.92840003967285) - 0.000949101470285457*std::sin(0.266399949789047*x_57 - 7.50400018692017) - 0.0126270918532196*std::sin(0.347279846668243*x_59 - 4.26007986068726) + 0.00104775298125366*std::sin(0.374879837036133*x_59 + 1.95975983142853) + 0.00593615540775004*std::sin(0.247119963169098*x_60 - 7.52824020385742) + 0.00954899631631904*std::sin(0.218399986624718*x_63 + 8.20975971221924) - 0.000816757376125594*std::sin(0.149120032787323*x_65 + 4.93391990661621) - 0.00285715697640354*std::sin(0.282159924507141*x_65 + 5.1081600189209) + 0.0213547605554413*std::sin(0.287759929895401*x_65 + 5.12423992156982) - 0.00756181888635313*std::sin(0.166320025920868*x_67 + 4.94535970687866) - 0.0268324620110135*std::sin(0.20320001244545*x_69 + 4.98776006698608) - 0.00198041723186756*std::sin(0.358319848775864*x_7 + 8.53191947937012) - 0.0102779989349976*std::sin(0.121280059218407*x_74 + 4.8842396736145) + 0.0176960708645521*std::sin(0.235679984092712*x_74 + 5.03487968444824) + 0.0033616353175221*std::sin(0.274879962205887*x_74 - 7.51688003540039) + 0.00355649394757577*std::sin(0.225279986858368*x_75 - 7.56712007522583) - 0.00703755974279317*std::sin(0.175280019640923*x_78 + 4.95191955566406) + 0.0507643897966217*std::sin(0.157200023531914*x_8 - 4.46224021911621) - 0.00242222768470635*std::sin(0.257999956607819*x_8 - 4.33247995376587) - 0.00732799380467758*std::sin(0.29887992143631*x_80 + 5.11567974090576) + 0.0110045273570655*std::sin(0.385439842939377*x_81 - 4.21808004379272) - 0.101928510374161*std::sin(0.13728004693985*x_84 + 4.90903997421265) + 0.00207653825929677*std::sin(0.294639945030212*x_84 - 7.47824001312256) - 0.0381292000799578*std::sin(0.186480015516281*x_85 - 7.60864019393921) + 0.0081157945187262*std::sin(0.333439826965332*x_88 - 4.27568006515503) + 0.146700659922947*std::sin(0.129600048065186*x_9 - 4.49575996398926) - 0.00947448916761224*std::sin(0.222719997167587*x_9 - 4.3692798614502) - 0.000686268175369782*std::sin(0.372239857912064*x_9 - 1.00943982601166) + 0.000162786818714634*std::sin(0.677919805049896*x_9 - 6.93639993667603) - 0.000622985833235694*std::sin(0.372079849243164*x_92 + 1.99183976650238) + 0.029130337681965*std::sin(0.325199842453003*x_93 + 1.97279977798462) - 0.00327858870588735*std::sin(0.332959830760956*x_93 + 1.98767983913422) - 0.000471212078736129*std::sin(0.351759850978851*x_93 + 1.96647977828979) + 0.016747057776109*std::sin(0.358479827642441*x_93 - 7.410719871521) - 0.00185854075407482*std::sin(0.362159848213196*x_93 - 7.41519975662231) + 0.0183651479710689*std::sin(0.395199835300446*x_94 - 7.40279960632324) - 0.000240416282792197*std::sin(0.279039949178696*x_95 - 7.51416015625) - 0.00670783862805586*std::sin(0.329999834299088*x_95 - 1.22255992889404) - 0.000411852086553977*std::sin(0.33111983537674*x_95 + 8.16551971435547) + 0.0103288933694855*std::sin(0.340319842100143*x_95 + 5.15104007720947) - 0.00295891958239939*std::sin(0.380959838628769*x_96 + 5.1799201965332) + 0.0185741635376766*std::sin(0.382799863815308*x_96 - 7.40703964233398) - 0.000701025301326477*std::sin(0.392399847507477*x_96 - 7.41631984710693) - 0.000825233637362158*std::sin(0.319759905338287*x_98 + 1.9171998500824) - 0.00402672793549031*std::sin(0.392799854278564*x_98 - 1.18863987922668) - 0.00793547862474109*std::sin(0.374879837036133*x_99 - 1.20063984394073) - 0.00184221300846169*std::sin(0.398159861564636*x_99 - 7.40623998641968) - 0.0576349232439972);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00548002115589413*x_1 - 0.00145254017895727*x_10 - 0.00249452109619028*x_100 + 0.000975021018899058*x_101 - 9.25255487964128e-5*x_102 - 0.000109414543449007*x_103 - 0.00258502587566951*x_104 + 0.00201002371967043*x_105 + 7.93011709525254e-6*x_106 + 2.75357481226812e-5*x_107 + 0.000496185536655168*x_108 - 0.00142508604386573*x_109 - 0.000557346697481104*x_11 - 0.000199003775518485*x_110 + 5.97624931961784e-5*x_111 + 0.000256466042825517*x_112 - 0.00126842246506002*x_113 + 0.00122630553575829*x_114 + 0.00198050563253949*x_115 - 0.00354382516501578*x_116 + 0.00207528289171251*x_117 + 4.89550045364987e-5*x_118 + 0.00259040294891119*x_119 + 0.00356450565258347*x_12 + 0.00170731484030739*x_120 - 0.000778098977706697*x_13 + 0.000630467012940362*x_14 + 0.00103918624569628*x_15 - 0.000272058874352379*x_16 - 0.000357629622779477*x_17 - 0.00063068987619286*x_18 - 0.000450188474791158*x_19 + 0.00173895272851217*x_2 - 0.00266464484450869*x_20 - 1.46340070653548e-5*x_21 + 0.00393275814844829*x_22 - 0.000109288587879777*x_23 + 0.000131892749630327*x_24 + 0.00387173500990282*x_25 - 0.00116937785565737*x_26 + 0.00029070564018192*x_27 - 0.000606096822733482*x_28 + 0.00135737433868696*x_29 - 0.00184839928321624*x_3 + 0.000101674559084302*x_30 + 0.009229292504191*x_31 - 0.000899135145823538*x_32 + 0.00022277416382521*x_33 - 6.31504788841424e-5*x_34 - 0.000827755136130634*x_35 + 2.41332621117529e-5*x_36 - 9.30093592487776e-5*x_37 + 1.42522544880476e-6*x_38 - 0.000619961991095931*x_39 - 0.000399363683087842*x_4 + 0.000579293869438994*x_40 + 0.000555218310757345*x_41 - 0.00223252713973504*x_42 + 4.64098087163823e-5*x_43 - 0.000136335286844982*x_44 - 4.86160676118278e-6*x_45 - 0.000250001686252586*x_46 + 0.000368205967884387*x_47 - 0.0029142262653494*x_48 + 7.41899342772281e-5*x_49 + 4.59240004752254e-5*x_5 - 0.000264210871510602*x_50 - 0.000321139284364184*x_51 - 0.00423913269494997*x_52 + 3.41596629642799e-5*x_53 + 7.8462519958302e-5*x_54 - 0.000107341077271277*x_55 + 6.98876458771211e-6*x_56 - 4.18935861551904e-6*x_57 + 0.000523501456312027*x_58 + 0.000981911145465082*x_59 + 0.000975732007743225*x_6 + 0.00138431828450901*x_60 + 3.7865320518909e-5*x_61 + 0.000320421298325137*x_62 - 0.000398035100952695*x_63 - 0.000646589292297166*x_64 - 0.000101658357078652*x_65 - 0.00126837500642339*x_66 - 0.00118257364784161*x_67 - 0.00100915889737968*x_68 + 0.000248330878591711*x_69 - 0.000323805703466713*x_7 - 0.000396039227996326*x_70 + 1.14670475340887e-5*x_71 + 0.00107889746372297*x_72 + 9.91373144900013e-5*x_73 + 7.68974646293666e-7*x_74 + 0.000529166706982946*x_75 + 0.00100753361661941*x_76 - 3.63239258438507e-5*x_77 + 0.000194259973711942*x_78 - 0.000367347118782394*x_79 + 0.000978514040765858*x_8 - 0.000469719742902572*x_80 - 0.000904216334589014*x_81 - 0.000252854384302331*x_82 - 0.000854133980347116*x_83 + 0.0021568547188578*x_84 + 0.00110393104191986*x_85 + 0.00196827636820551*x_86 + 5.82118791104203e-6*x_87 - 0.00015380514057061*x_88 + 0.00200630900598782*x_89 - 0.00173741581499918*x_9 - 0.00138866692897726*x_90 + 0.00141194803653875*x_91 + 0.0018171082624928*x_92 - 1.32512329118734e-6*x_94 - 3.22520733426743e-5*x_95 + 0.000460453062204261*x_96 - 0.00286890491501056*x_97 - 0.000113609922849909*x_98 - 3.34895026018106e-5*x_99 + 3.68601109944624e-6*std::pow(-7.84783983230591*x_108 - 9.05935955047607, 2) - 3.77935081953248e-5*std::pow(-4.29967975616455*x_14 - 6.14551973342896, 2) + 2.32226327606115e-5*std::pow(-5.92399978637695*x_17 - 9.46343994140625, 2) - 8.60327726958724e-6*std::pow(-6.35599994659424*x_23 - 8.75072002410889, 2) - 9.46793331914694e-8*std::pow(-6.58143997192383*x_37 - 9.56688022613525, 2) + 4.24835986554408e-6*std::pow(-8.35695934295654*x_38 - 9.16335964202881, 2) + 1.04074173382181e-6*std::pow(-5.15975999832153*x_4 - 8.7344799041748, 2) - 3.39504540656754e-6*std::pow(-5.26968002319336*x_44 - 9.51232051849365, 2) + 2.39851802372718e-5*std::pow(-5.72951984405518*x_46 - 7.57535982131958, 2) - 1.22512407943251e-5*std::pow(-5.29848003387451*x_47 - 9.61719989776611, 2) - 2.96361369331542e-5*std::pow(-6.17368030548096*x_5 - 9.76648044586182, 2) + 1.88230543815433e-5*std::pow(-7.51959991455078*x_50 - 9.97152042388916, 2) + 2.82841581536458e-5*std::pow(-4.18656015396118*x_50 - 5.98431968688965, 2) - 1.16446238462434e-5*std::pow(-4.89456033706665*x_53 - 9.16567993164063, 2) + 5.11769211733589e-5*std::pow(-3.0511200428009*x_54 - 3.61879992485046, 2) + 4.51284516174157e-6*std::pow(-5.50551986694336*x_55 - 7.75392007827759, 2) - 3.97817802877483e-5*std::pow(-1.89527988433838*x_56 - 2.83895993232727, 2) - 9.71556444940632e-6*std::pow(-6.54728031158447*x_58 - 9.33351993560791, 2) + 9.85247938707769e-6*std::pow(-7.056960105896*x_60 - 9.21016025543213, 2) + 4.38663813520519e-6*std::pow(-5.30559968948364*x_60 - 6.09144020080566, 2) - 2.26137808139958e-5*std::pow(-4.85904026031494*x_64 - 7.49032020568848, 2) - 4.7944192442723e-5*std::pow(-4.05999994277954*x_66 - 5.80347967147827, 2) + 1.49728182143522e-5*std::pow(-6.47735977172852*x_68 - 8.89960098266602, 2) + 4.1007917160166e-5*std::pow(-2.09295964241028*x_69 - 3.34831976890564, 2) - 4.30348373961741e-5*std::pow(-4.50415992736816*x_7 - 7.37455987930298, 2) + 8.89206374541287e-7*std::pow(-4.27399969100952*x_7 - 6.91639995574951, 2) - 3.06002994751529e-5*std::pow(-3.77760004997253*x_7 - 5.96271991729736, 2) + 1.04943328281038e-5*std::pow(-5.52303981781006*x_70 - 5.93503999710083, 2) + 5.53163777660006e-6*std::pow(-6.29328012466431*x_71 - 9.53400039672852, 2) + 4.62119706050146e-5*std::pow(-4.51783990859985*x_71 - 6.98280000686646, 2) + 2.74297480038419e-5*std::pow(-6.04655981063843*x_72 - 7.45879983901978, 2) + 7.68677334135068e-6*std::pow(-5.11975955963135*x_73 - 7.37648010253906, 2) - 9.67925078406209e-6*std::pow(-4.88303995132446*x_73 - 6.30624008178711, 2) + 1.41387556491161e-5*std::pow(-5.61847972869873*x_74 - 9.03551959991455, 2) + 2.34649656623454e-5*std::pow(-6.10015964508057*x_75 - 8.54423999786377, 2) - 2.38579198626896e-5*std::pow(-4.85663986206055*x_75 - 7.2629599571228, 2) - 4.76243971207147e-6*std::pow(-6.23928022384644*x_76 - 8.45512008666992, 2) - 5.70346728625443e-6*std::pow(-5.75799989700317*x_77 - 6.99304008483887, 2) - 6.348403387795e-8*std::pow(-6.51543998718262*x_79 - 9.14416027069092, 2) - 2.30609187987116e-6*std::pow(-4.61711978912354*x_80 - 6.62912034988403, 2) - 8.14475261142899e-7*std::pow(-9.80399990081787*x_81 - 9.96455955505371, 2) - 2.89524254989498e-5*std::pow(-5.51904010772705*x_82 - 7.76719999313354, 2) - 1.90714348793191e-5*std::pow(-6.52063989639282*x_83 - 9.15176010131836, 2) + 2.87368934680735e-5*std::pow(-5.5021595954895*x_83 - 7.13471984863281, 2) - 6.43198707313747e-6*std::pow(-7.79527997970581*x_85 - 9.79351997375488, 2) + 5.41905351148198e-5*std::pow(-3.08799982070923*x_86 - 4.93535995483398, 2) + 6.27523541697442e-6*std::pow(-7.49096012115479*x_87 - 9.92399978637695, 2) - 3.68632277338209e-5*std::pow(-5.73847961425781*x_87 - 7.79936027526855, 2) - 1.75613263719233e-5*std::pow(-4.00183963775635*x_87 - 5.6003999710083, 2) - 2.28169506396169e-7*std::pow(-6.34912014007568*x_89 - 9.13704013824463, 2) - 6.97792477232463e-6*std::pow(-5.6814398765564*x_90 - 8.55256080627441, 2) - 1.00500790809588e-7*std::pow(-5.93959999084473*x_99 - 7.78736019134521, 2) - 0.000382086050175873*std::exp(0.754959881305695*x_22) + 0.0267376161400249*std::sin(0.221119984984398*x_1 + 5.20879983901978) - 0.0622583256762881*std::sin(0.241199970245361*x_10 - 7.54232025146484) - 0.000273493815492448*std::sin(0.34215983748436*x_10 - 1.05311977863312) - 0.0179165730944575*std::sin(0.320959836244583*x_101 + 5.14448022842407) + 0.00758682712095114*std::sin(0.403039842844009*x_102 + 1.98351979255676) + 0.00260792719559077*std::sin(0.376479834318161*x_104 + 5.18048000335693) + 0.0187708809938419*std::sin(0.388159841299057*x_104 - 7.40119981765747) + 0.00895050699944669*std::sin(0.322239845991135*x_105 - 1.24519991874695) - 0.00340715573812858*std::sin(0.388559848070145*x_105 + 1.97791981697083) - 0.00634768103352784*std::sin(0.345919847488403*x_106 + 1.94127976894379) + 0.019485261125504*std::sin(0.391999840736389*x_106 - 7.40279960632324) + 0.00441478346318489*std::sin(0.314319938421249*x_107 + 5.11247968673706) - 0.0104965781449931*std::sin(0.386559844017029*x_107 - 7.42159986495972) - 0.0246942813567469*std::sin(0.37951985001564*x_108 - 7.40759992599487) + 0.0170225800762015*std::sin(0.32151985168457*x_109 - 7.4521598815918) + 0.00195679997526152*std::sin(0.435439854860306*x_109 + 5.23640012741089) - 0.0174597354284861*std::sin(0.19743999838829*x_110 + 1.78303980827332) + 0.00758271646738598*std::sin(0.364959836006165*x_110 + 5.18104028701782) + 0.000218139571017269*std::sin(0.22647999227047*x_111 + 5.04263973236084) - 0.0191345611454085*std::sin(0.326559841632843*x_111 - 4.26839971542358) + 0.00565603998032142*std::sin(0.371999859809875*x_111 + 5.18032026290894) + 0.0157051471719373*std::sin(0.332879841327667*x_112 - 4.2545599937439) - 0.000113325490276948*std::sin(0.33519983291626*x_112 + 5.14775991439819) - 0.0128210240911844*std::sin(0.368799835443497*x_112 + 1.98655986785889) + 0.011416657827636*std::sin(0.376959830522537*x_113 + 1.98927986621857) + 0.00688897597087726*std::sin(0.244079977273941*x_114 + 5.04392004013062) + 0.0126214405366276*std::sin(0.366399854421616*x_114 - 7.43375968933105) - 0.0155656562181294*std::sin(0.205520004034042*x_115 - 7.59376001358032) - 0.0189533402571288*std::sin(0.228079989552498*x_115 + 1.83607995510101) - 0.0050311678835007*std::sin(0.405839860439301*x_117 + 5.1910400390625) - 0.00264733682148842*std::sin(0.266799956560135*x_118 + 5.07727956771851) - 0.00265930652588527*std::sin(0.36575984954834*x_119 - 1.21287977695465) - 0.028265864458032*std::sin(0.249359980225563*x_12 + 8.27031993865967) + 0.00378420152495284*std::sin(0.463279873132706*x_120 - 1.14679980278015) - 0.0884852170198955*std::sin(0.138080030679703*x_14 + 8.09639930725098) + 0.00779202998381452*std::sin(0.393119841814041*x_15 + 2.19063997268677) + 0.0155288564613545*std::sin(0.293359935283661*x_16 - 4.28935956954956) + 0.0328424379304578*std::sin(0.315119922161102*x_16 - 4.26247978210449) + 0.00276363088964678*std::sin(0.365359842777252*x_16 + 2.14367985725403) - 0.000587729769049346*std::sin(0.181920006871223*x_19 - 4.4191198348999) + 0.023353566363294*std::sin(0.296239942312241*x_21 - 4.29503965377808) + 0.000126087099232928*std::sin(0.318959832191467*x_21 + 5.13607978820801) - 0.0144436077350726*std::sin(0.363199830055237*x_21 - 4.21568012237549) + 0.0574683489432075*std::sin(0.134160041809082*x_23 - 4.49503993988037) - 0.0246345923941179*std::sin(0.29807984828949*x_23 - 4.32223987579346) - 0.00982568215123373*std::sin(0.317679941654205*x_24 + 8.35151958465576) - 0.0112561701507296*std::sin(0.465839862823486*x_24 + 8.48311996459961) + 0.0169449342070466*std::sin(0.297679930925369*x_26 + 5.10839986801147) - 0.000523248181146941*std::sin(0.310239940881729*x_27 + 5.1334400177002) + 0.0199077908375236*std::sin(0.360559850931168*x_27 + 5.16951990127563) + 0.0230986383420957*std::sin(0.36287984251976*x_27 + 5.17112016677856) + 0.00883971700065707*std::sin(0.519679844379425*x_27 - 4.07424020767212) - 0.0139936850102591*std::sin(0.257439970970154*x_28 - 7.52328014373779) - 0.000211828988184312*std::sin(0.262639969587326*x_28 + 5.06967973709106) + 0.0280478848032177*std::sin(0.336719840764999*x_28 - 4.25856018066406) + 6.95552921238312e-6*std::sin(0.849039852619171*x_29 - 3.96919989585876) - 0.00429187792725925*std::sin(0.32847985625267*x_3 - 1.05927979946136) + 0.000366145022422218*std::sin(0.372319847345352*x_3 - 1.03087985515594) - 0.00660152529649228*std::sin(0.268079966306686*x_32 - 7.42328023910522) + 0.0113307005298899*std::sin(0.302319914102554*x_33 - 1.18495988845825) + 0.0216483005778324*std::sin(0.348319828510284*x_34 + 1.97575974464417) + 0.0158434148679243*std::sin(0.357759833335876*x_34 + 1.97135984897614) - 0.00892186908099354*std::sin(0.361279845237732*x_34 + 1.99055981636047) + 0.000280286715908752*std::sin(0.29615992307663*x_35 + 8.26560020446777) + 0.0276572386491525*std::sin(0.309519916772842*x_35 + 8.2775993347168) - 0.00574400016985486*std::sin(0.31743985414505*x_35 - 1.20303988456726) - 0.0118462591686098*std::sin(0.332799851894379*x_35 - 1.22799980640411) - 0.00737095564702883*std::sin(0.313519924879074*x_36 - 4.28071975708008) - 0.018058335766299*std::sin(0.317359834909439*x_36 + 1.92511987686157) - 0.0166236258648279*std::sin(0.340159833431244*x_36 + 5.15488004684448) - 0.0130346824799454*std::sin(0.351599842309952*x_37 + 5.16336011886597) - 0.0233973979568567*std::sin(0.3713598549366*x_37 + 5.17824029922485) + 0.0266072905380402*std::sin(0.377359837293625*x_37 + 5.18239974975586) - 0.0161254699777006*std::sin(0.149600028991699*x_38 + 4.92015981674194) + 0.0328980143723266*std::sin(0.320479840040207*x_38 - 7.46943950653076) + 0.0244980193222913*std::sin(0.3574398458004*x_38 + 5.16215991973877) - 0.0177045908510593*std::sin(0.353839844465256*x_39 - 7.44127988815308) + 0.0964287031111356*std::sin(0.132800042629242*x_40 + 4.9093599319458) + 0.00571820677343111*std::sin(0.315199851989746*x_41 + 5.12504005432129) + 0.00906732759087984*std::sin(0.309279918670654*x_43 + 5.13111972808838) + 0.00352967191305427*std::sin(0.331439822912216*x_43 + 5.13816022872925) + 0.0296131690109642*std::sin(0.34911984205246*x_43 + 5.14328002929688) + 0.0250714988088767*std::sin(0.307359933853149*x_44 - 7.48016023635864) + 0.0256374024380116*std::sin(0.27687993645668*x_45 - 7.51800012588501) + 0.0158306806841321*std::sin(0.298879951238632*x_45 - 7.48623991012573) - 0.00448415028844208*std::sin(0.321199834346771*x_45 - 7.46703958511353) - 0.0059248697598544*std::sin(0.298079937696457*x_47 + 5.12423944473267) - 0.0203921757367455*std::sin(0.306559920310974*x_47 + 5.11695957183838) + 0.0242951247002681*std::sin(0.251199960708618*x_48 + 5.06759977340698) - 0.0110785661740788*std::sin(0.273039966821671*x_49 + 1.8582398891449) - 0.00424789901237435*std::sin(0.314719915390015*x_49 - 7.46687984466553) + 0.0005963540423211*std::sin(1.0694397687912*x_5 - 6.76344013214111) - 0.00933634268586045*std::sin(0.367279857397079*x_50 + 5.15799999237061) + 0.0190915199499034*std::sin(0.323439836502075*x_51 - 4.28312015533447) + 0.00686233423942635*std::sin(0.229279980063438*x_52 + 5.04008007049561) + 0.0318280851969082*std::sin(0.20728000998497*x_53 + 4.99191951751709) + 0.0204829499208639*std::sin(0.273679941892624*x_53 + 5.08431959152222) + 0.0124019661295962*std::sin(0.270639955997467*x_54 + 5.09176015853882) - 0.0243054309145999*std::sin(0.22647999227047*x_56 + 5.04399967193604) + 0.0552008850456037*std::sin(0.157680034637451*x_57 + 4.92840003967285) + 0.00349977174131593*std::sin(0.266399949789047*x_57 - 7.50400018692017) - 0.0082334598007987*std::sin(0.347279846668243*x_59 - 4.26007986068726) - 0.00386354503756927*std::sin(0.374879837036133*x_59 + 1.95975983142853) + 0.0409004416095791*std::sin(0.247119963169098*x_60 - 7.52824020385742) + 0.0114404348637195*std::sin(0.218399986624718*x_63 + 8.20975971221924) + 0.000352856107816648*std::sin(0.149120032787323*x_65 + 4.93391990661621) + 0.0105356461448883*std::sin(0.282159924507141*x_65 + 5.1081600189209) + 0.0255846519437165*std::sin(0.287759929895401*x_65 + 5.12423992156982) + 0.0278838890044582*std::sin(0.166320025920868*x_67 + 4.94535970687866) - 0.0321473612201122*std::sin(0.20320001244545*x_69 + 4.98776006698608) - 0.0136451851056414*std::sin(0.358319848775864*x_7 + 8.53191947937012) + 0.0378996886593811*std::sin(0.121280059218407*x_74 + 4.8842396736145) + 0.0212012592070739*std::sin(0.235679984092712*x_74 + 5.03487968444824) + 0.0231618546976561*std::sin(0.274879962205887*x_74 - 7.51688003540039) - 0.0131144218037542*std::sin(0.225279986858368*x_75 - 7.56712007522583) - 0.0484891788645297*std::sin(0.175280019640923*x_78 + 4.95191955566406) + 0.0608196584883168*std::sin(0.157200023531914*x_8 - 4.46224021911621) + 0.00893186267999218*std::sin(0.257999956607819*x_8 - 4.33247995376587) - 0.00877950237145669*std::sin(0.29887992143631*x_80 + 5.11567974090576) + 0.013184273431897*std::sin(0.385439842939377*x_81 - 4.21808004379272) - 0.0664621990935279*std::sin(0.13728004693985*x_84 + 4.90903997421265) - 0.00765714746755416*std::sin(0.294639945030212*x_84 - 7.47824001312256) - 0.0456817256463913*std::sin(0.186480015516281*x_85 - 7.60864019393921) + 0.00972334845287808*std::sin(0.333439826965332*x_88 - 4.27568006515503) + 0.0956557535390267*std::sin(0.129600048065186*x_9 - 4.49575996398926) - 0.0652797584232033*std::sin(0.222719997167587*x_9 - 4.3692798614502) + 0.000296482069654646*std::sin(0.372239857912064*x_9 - 1.00943982601166) - 0.000600269545283543*std::sin(0.677919805049896*x_9 - 6.93639993667603) + 0.000269142786788442*std::sin(0.372079849243164*x_92 + 1.99183976650238) + 0.0189943549216359*std::sin(0.325199842453003*x_93 + 1.97279977798462) - 0.0225896589149099*std::sin(0.332959830760956*x_93 + 1.98767983913422) + 0.000203573380442242*std::sin(0.351759850978851*x_93 + 1.96647977828979) + 0.0200642682539413*std::sin(0.358479827642441*x_93 - 7.410719871521) + 0.00685329083858516*std::sin(0.362159848213196*x_93 - 7.41519975662231) + 0.0220028652400377*std::sin(0.395199835300446*x_94 - 7.40279960632324) + 0.000103864815037503*std::sin(0.279039949178696*x_95 - 7.51416015625) - 0.00437382734966489*std::sin(0.329999834299088*x_95 - 1.22255992889404) + 0.00151868724182894*std::sin(0.33111983537674*x_95 + 8.16551971435547) + 0.0123748117491635*std::sin(0.340319842100143*x_95 + 5.15104007720947) - 0.0203871208373968*std::sin(0.380959838628769*x_96 + 5.1799201965332) + 0.0222532820268986*std::sin(0.382799863815308*x_96 - 7.40703964233398) + 0.00258500130527875*std::sin(0.392399847507477*x_96 - 7.41631984710693) + 0.00304301431874801*std::sin(0.319759905338287*x_98 + 1.9171998500824) - 0.00482433096985997*std::sin(0.392799854278564*x_98 - 1.18863987922668) - 0.00950731608971708*std::sin(0.374879837036133*x_99 - 1.20063984394073) - 0.0126929503035961*std::sin(0.398159861564636*x_99 - 7.40623998641968) + 0.25819153078523);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00989858609732414*x_1 + 0.00452939229885079*x_10 - 0.00150453165071511*x_100 - 0.000427322218905133*x_101 + 8.05182984259464e-5*x_102 - 0.000490879465906148*x_103 - 0.00278046598737517*x_104 + 0.000391776677387629*x_105 + 7.25226106170282e-5*x_106 - 0.000274884563765393*x_107 - 0.000340420009341725*x_108 - 0.00168345831321555*x_109 - 0.00168963774245899*x_11 - 0.00185027309711334*x_110 - 0.000352184205813815*x_111 + 0.000351039477112415*x_112 + 0.000813269621064785*x_113 - 0.000829565895135635*x_114 + 0.00211828440851608*x_115 - 0.00411321971168471*x_116 + 0.00156954813932035*x_117 - 3.86805828677643e-6*x_118 + 0.00128880801066702*x_119 + 0.00615397451124148*x_12 - 0.00119932353610791*x_120 + 0.000731607682583603*x_13 - 0.00179626290389096*x_14 - 0.00169257729203155*x_15 + 0.00023498116497852*x_16 + 0.000608006192704364*x_17 - 0.000423158465430737*x_18 - 0.00127720853902299*x_19 + 0.00707077796891801*x_2 - 0.00358710137502691*x_20 - 0.000527250761356068*x_21 - 0.0025114478527461*x_22 - 0.000125284036005561*x_23 - 0.0010535036219171*x_24 + 0.00311490888924408*x_25 + 0.000716224937204571*x_26 + 0.00137493146989909*x_27 - 0.000375537361318156*x_28 - 0.00206351054003202*x_29 - 0.00201185039667174*x_3 - 0.00120001191895847*x_30 - 0.00153661336641263*x_31 + 0.000240667935252601*x_32 + 0.0017501902590696*x_33 + 3.57785485812829e-5*x_34 + 0.000561325564360036*x_35 + 0.00014935279062105*x_36 - 0.000439900288643413*x_37 - 5.99695147816643e-6*x_38 - 0.000262404907325513*x_39 - 0.00378604121782437*x_4 + 0.00267860869715565*x_40 + 0.000295880485533239*x_41 + 0.00155476831473146*x_42 - 3.0657648022592e-5*x_43 + 9.55387650924682e-5*x_44 - 1.12817278717026e-5*x_45 + 0.000242663532762767*x_46 - 0.000220701076834465*x_47 + 0.00514268333744681*x_48 + 0.000212914316613266*x_49 - 0.0022093577686446*x_5 - 0.00125016028579663*x_50 - 5.27442128480703e-5*x_51 - 0.00503553278624903*x_52 + 0.00016843217766182*x_53 + 0.000135284570798747*x_54 - 0.000268043994453936*x_55 - 0.000177436230173229*x_56 - 5.12517851200788e-5*x_57 + 0.0025646417970239*x_58 + 0.00169408297619807*x_59 + 0.000394142809664043*x_6 - 0.000937429678993217*x_60 - 1.38154616364173e-5*x_61 + 0.000296937104824729*x_62 - 0.00176057660931042*x_63 + 0.000387283701807891*x_64 - 0.000118652906030136*x_65 + 0.000210241303645062*x_66 + 0.00077777388958323*x_67 + 0.000146516282562422*x_68 + 0.000609952851615639*x_69 + 0.000219582351480289*x_7 - 0.00247049745304537*x_70 - 9.57667471855649e-6*x_71 - 0.00100903642006103*x_72 + 2.21052688663687e-5*x_73 - 3.23563099833128e-6*x_74 - 0.000360117158200609*x_75 + 0.00118500356897485*x_76 + 6.81544309099293e-6*x_77 + 0.000700324844426021*x_78 + 0.000127213431155074*x_79 + 0.000867476812822575*x_8 + 0.000225573467317445*x_80 - 0.00108386063150619*x_81 - 0.0022579570557361*x_82 + 0.000864591742835561*x_83 + 0.00150514074392785*x_84 + 0.00128085595071041*x_85 - 1.66779203603157e-5*x_86 + 3.56406732180745e-5*x_87 - 0.000776356272723519*x_88 + 0.00231797412823843*x_89 + 0.00117819373183394*x_9 - 0.00159369599470709*x_90 - 0.000558429739164628*x_91 - 0.000860874728610848*x_92 - 4.60276017519846e-5*x_94 - 3.61430106501353e-5*x_95 - 0.000303498703581594*x_96 - 0.00017787693474072*x_97 - 9.09393488677459e-5*x_98 - 0.00020259565898138*x_99 + 1.74334858307341e-5*std::pow(-7.84783983230591*x_108 - 9.05935955047607, 2) + 2.57423383635995e-5*std::pow(-4.29967975616455*x_14 - 6.14551973342896, 2) + 2.60242451476877e-5*std::pow(-5.92399978637695*x_17 - 9.46343994140625, 2) - 4.06903583116608e-5*std::pow(-6.35599994659424*x_23 - 8.75072002410889, 2) + 3.98384246934797e-7*std::pow(-6.58143997192383*x_37 - 9.56688022613525, 2) - 2.89369054028968e-6*std::pow(-8.35695934295654*x_38 - 9.16335964202881, 2) - 4.37915116114881e-6*std::pow(-5.15975999832153*x_4 - 8.7344799041748, 2) - 1.60573244065885e-5*std::pow(-5.26968002319336*x_44 - 9.51232051849365, 2) + 2.68787874674121e-5*std::pow(-5.72951984405518*x_46 - 7.57535982131958, 2) + 8.30793353349843e-6*std::pow(-5.29848003387451*x_47 - 9.61719989776611, 2) + 2.00971526038694e-5*std::pow(-6.17368030548096*x_5 - 9.76648044586182, 2) + 2.10938951971198e-5*std::pow(-7.51959991455078*x_50 - 9.97152042388916, 2) - 1.92652231636645e-5*std::pow(-4.18656015396118*x_50 - 5.98431968688965, 2) - 1.30494483011956e-5*std::pow(-4.89456033706665*x_53 - 9.16567993164063, 2) - 3.48581987796209e-5*std::pow(-3.0511200428009*x_54 - 3.61879992485046, 2) + 2.13441088648209e-5*std::pow(-5.50551986694336*x_55 - 7.75392007827759, 2) - 0.000188153286644207*std::pow(-1.89527988433838*x_56 - 2.83895993232727, 2) - 1.08876643568321e-5*std::pow(-6.54728031158447*x_58 - 9.33351993560791, 2) - 6.71083130975171e-6*std::pow(-7.056960105896*x_60 - 9.21016025543213, 2) + 2.07471957385442e-5*std::pow(-5.30559968948364*x_60 - 6.09144020080566, 2) + 1.53350824702428e-5*std::pow(-4.85904026031494*x_64 - 7.49032020568848, 2) - 5.37282499533652e-5*std::pow(-4.05999994277954*x_66 - 5.80347967147827, 2) - 1.01984539444846e-5*std::pow(-6.47735977172852*x_68 - 8.89960098266602, 2) + 0.000193952466086463*std::pow(-2.09295964241028*x_69 - 3.34831976890564, 2) + 2.93123713191527e-5*std::pow(-4.50415992736816*x_7 - 7.37455987930298, 2) - 3.74153260220859e-6*std::pow(-4.27399969100952*x_7 - 6.91639995574951, 2) - 0.000144728236818506*std::pow(-3.77760004997253*x_7 - 5.96271991729736, 2) - 7.14801772741216e-6*std::pow(-5.52303981781006*x_70 - 5.93503999710083, 2) + 2.61626257212298e-5*std::pow(-6.29328012466431*x_71 - 9.53400039672852, 2) + 5.17870503392042e-5*std::pow(-4.51783990859985*x_71 - 6.98280000686646, 2) + 3.07389129281689e-5*std::pow(-6.04655981063843*x_72 - 7.45879983901978, 2) + 3.63556295722045e-5*std::pow(-5.11975955963135*x_73 - 7.37648010253906, 2) + 6.59283989995629e-6*std::pow(-4.88303995132446*x_73 - 6.30624008178711, 2) - 9.6303478914621e-6*std::pow(-5.61847972869873*x_74 - 9.03551959991455, 2) + 2.62958134451795e-5*std::pow(-6.10015964508057*x_75 - 8.54423999786377, 2) + 1.62503740743753e-5*std::pow(-4.85663986206055*x_75 - 7.2629599571228, 2) - 2.25245998994948e-5*std::pow(-6.23928022384644*x_76 - 8.45512008666992, 2) + 3.86769209096217e-6*std::pow(-5.75799989700317*x_77 - 6.99304008483887, 2) + 2.6712312155499e-7*std::pow(-6.51543998718262*x_79 - 9.14416027069092, 2) - 1.09069720701994e-5*std::pow(-4.61711978912354*x_80 - 6.62912034988403, 2) - 3.85217041987513e-6*std::pow(-9.80399990081787*x_81 - 9.96455955505371, 2) + 1.97204009161835e-5*std::pow(-5.51904010772705*x_82 - 7.76719999313354, 2) + 1.29329115332725e-5*std::pow(-6.52063989639282*x_83 - 9.15176010131836, 2) + 3.22037543333411e-5*std::pow(-5.5021595954895*x_83 - 7.13471984863281, 2) + 4.38102720528827e-6*std::pow(-7.79527997970581*x_85 - 9.79351997375488, 2) - 3.67482258684506e-5*std::pow(-3.08799982070923*x_86 - 4.93535995483398, 2) - 4.25542519541594e-6*std::pow(-7.49096012115479*x_87 - 9.92399978637695, 2) - 4.13104614523791e-5*std::pow(-5.73847961425781*x_87 - 7.79936027526855, 2) + 1.19615676650938e-5*std::pow(-4.00183963775635*x_87 - 5.6003999710083, 2) + 9.60073692062211e-7*std::pow(-6.34912014007568*x_89 - 9.13704013824463, 2) - 3.30030348157459e-5*std::pow(-5.6814398765564*x_90 - 8.55256080627441, 2) + 4.2287931815131e-7*std::pow(-5.93959999084473*x_99 - 7.78736019134521, 2) - 0.00180712742369738*std::exp(0.754959881305695*x_22) - 0.0181315787898329*std::sin(0.221119984984398*x_1 + 5.20879983901978) + 0.0424060893534208*std::sin(0.241199970245361*x_10 - 7.54232025146484) + 0.00115078575285214*std::sin(0.34215983748436*x_10 - 1.05311977863312) - 0.0200780546815292*std::sin(0.320959836244583*x_101 + 5.14448022842407) - 0.00514485483627109*std::sin(0.403039842844009*x_102 + 1.98351979255676) + 0.0123345428392086*std::sin(0.376479834318161*x_104 + 5.18048000335693) - 0.0127290969363922*std::sin(0.388159841299057*x_104 - 7.40119981765747) - 0.00609646975651826*std::sin(0.322239845991135*x_105 - 1.24519991874695) - 0.0161146018504102*std::sin(0.388559848070145*x_105 + 1.97791981697083) - 0.00711347455901063*std::sin(0.345919847488403*x_106 + 1.94127976894379) - 0.0132135395125474*std::sin(0.391999840736389*x_106 - 7.40279960632324) + 0.0208803128571034*std::sin(0.314319938421249*x_107 + 5.11247968673706) + 0.00711804420644226*std::sin(0.386559844017029*x_107 - 7.42159986495972) - 0.0276734355832373*std::sin(0.37951985001564*x_108 - 7.40759992599487) - 0.0115435216902475*std::sin(0.32151985168457*x_109 - 7.4521598815918) + 0.00925494897381824*std::sin(0.435439854860306*x_109 + 5.23640012741089) + 0.0118923709017999*std::sin(0.19743999838829*x_110 + 1.78303980827332) - 0.00514206727889858*std::sin(0.364959836006165*x_110 + 5.18104028701782) - 0.000917870519331292*std::sin(0.22647999227047*x_111 + 5.04263973236084) + 0.012975719346105*std::sin(0.326559841632843*x_111 - 4.26839971542358) + 0.0267510026949764*std::sin(0.371999859809875*x_111 + 5.18032026290894) - 0.0106972660611631*std::sin(0.332879841327667*x_112 - 4.2545599937439) + 0.000476842079265579*std::sin(0.33519983291626*x_112 + 5.14775991439819) + 0.00869432066262882*std::sin(0.368799835443497*x_112 + 1.98655986785889) - 0.00774197781261709*std::sin(0.376959830522537*x_113 + 1.98927986621857) + 0.0325823394819943*std::sin(0.244079977273941*x_114 + 5.04392004013062) + 0.0141441095860274*std::sin(0.366399854421616*x_114 - 7.43375968933105) + 0.0105555379603188*std::sin(0.205520004034042*x_115 - 7.59376001358032) + 0.0129097117816598*std::sin(0.228079989552498*x_115 + 1.83607995510101) - 0.0237955859715754*std::sin(0.405839860439301*x_117 + 5.1910400390625) - 0.0125209359715527*std::sin(0.266799956560135*x_118 + 5.07727956771851) - 0.0125775483002654*std::sin(0.36575984954834*x_119 - 1.21287977695465) + 0.019167929773528*std::sin(0.249359980225563*x_12 + 8.27031993865967) + 0.0178978906698949*std::sin(0.463279873132706*x_120 - 1.14679980278015) - 0.0991602030402809*std::sin(0.138080030679703*x_14 + 8.09639930725098) + 0.0368534550359585*std::sin(0.393119841814041*x_15 + 2.19063997268677) - 0.0105305829424176*std::sin(0.293359935283661*x_16 - 4.28935956954956) + 0.0368045976853938*std::sin(0.315119922161102*x_16 - 4.26247978210449) + 0.0130709644263617*std::sin(0.365359842777252*x_16 + 2.14367985725403) + 0.00247300306784356*std::sin(0.181920006871223*x_19 - 4.4191198348999) + 0.0261709747717319*std::sin(0.296239942312241*x_21 - 4.29503965377808) - 0.000530539373091286*std::sin(0.318959832191467*x_21 + 5.13607978820801) + 0.00983799216483788*std::sin(0.363199830055237*x_21 - 4.21568012237549) - 0.0389710096565254*std::sin(0.134160041809082*x_23 - 4.49503993988037) + 0.0167793899836265*std::sin(0.29807984828949*x_23 - 4.32223987579346) - 0.0464718868010367*std::sin(0.317679941654205*x_24 + 8.35151958465576) + 0.00766692891278549*std::sin(0.465839862823486*x_24 + 8.48311996459961) - 0.0115417237175321*std::sin(0.297679930925369*x_26 + 5.10839986801147) + 0.00220168251697202*std::sin(0.310239940881729*x_27 + 5.1334400177002) - 0.0135000695728343*std::sin(0.360559850931168*x_27 + 5.16951990127563) - 0.0157332037255593*std::sin(0.36287984251976*x_27 + 5.17112016677856) + 0.00990615339064705*std::sin(0.519679844379425*x_27 - 4.07424020767212) + 0.00953153575016048*std::sin(0.257439970970154*x_28 - 7.52328014373779) + 0.000891317345529962*std::sin(0.262639969587326*x_28 + 5.06967973709106) - 0.019020111237083*std::sin(0.336719840764999*x_28 - 4.25856018066406) - 2.92669284193681e-5*std::sin(0.849039852619171*x_29 - 3.96919989585876) - 0.0202990145752289*std::sin(0.32847985625267*x_3 - 1.05927979946136) - 0.00154063620971659*std::sin(0.372319847345352*x_3 - 1.03087985515594) - 0.0312228028111258*std::sin(0.268079966306686*x_32 - 7.42328023910522) - 0.00771769388090638*std::sin(0.302319914102554*x_33 - 1.18495988845825) + 0.0242599832273929*std::sin(0.348319828510284*x_34 + 1.97575974464417) - 0.0107438944247448*std::sin(0.357759833335876*x_34 + 1.97135984897614) - 0.0421971811833483*std::sin(0.361279845237732*x_34 + 1.99055981636047) - 0.00117936838462226*std::sin(0.29615992307663*x_35 + 8.26560020446777) + 0.0309938483777107*std::sin(0.309519916772842*x_35 + 8.2775993347168) - 0.0271670222555605*std::sin(0.31743985414505*x_35 - 1.20303988456726) + 0.00806885696573069*std::sin(0.332799851894379*x_35 - 1.22799980640411) + 0.00499846592046791*std::sin(0.313519924879074*x_36 - 4.28071975708008) - 0.0202369198094767*std::sin(0.317359834909439*x_36 + 1.92511987686157) + 0.0113228705742438*std::sin(0.340159833431244*x_36 + 5.15488004684448) - 0.0146072056418911*std::sin(0.351599842309952*x_37 + 5.16336011886597) + 0.015936698226594*std::sin(0.3713598549366*x_37 + 5.17824029922485) - 0.018043201093469*std::sin(0.377359837293625*x_37 + 5.18239974975586) - 0.0762675816175391*std::sin(0.149600028991699*x_38 + 4.92015981674194) + 0.0368668789505088*std::sin(0.320479840040207*x_38 - 7.46943950653076) - 0.0166128410704516*std::sin(0.3574398458004*x_38 + 5.16215991973877) - 0.0198404985901928*std::sin(0.353839844465256*x_39 - 7.44127988815308) + 0.108062002913563*std::sin(0.132800042629242*x_40 + 4.9093599319458) + 0.027045028913992*std::sin(0.315199851989746*x_41 + 5.12504005432129) - 0.00617603990853924*std::sin(0.309279918670654*x_43 + 5.13111972808838) + 0.0166940585970065*std::sin(0.331439822912216*x_43 + 5.13816022872925) + 0.0331857450395711*std::sin(0.34911984205246*x_43 + 5.14328002929688) + 0.0280961611005981*std::sin(0.307359933853149*x_44 - 7.48016023635864) + 0.0287303361713745*std::sin(0.27687993645668*x_45 - 7.51800012588501) - 0.0107352589930914*std::sin(0.298879951238632*x_45 - 7.48623991012573) - 0.0212083925976733*std::sin(0.321199834346771*x_45 - 7.46703958511353) - 0.0280224693362656*std::sin(0.298079937696457*x_47 + 5.12423944473267) - 0.0228523176479763*std::sin(0.306559920310974*x_47 + 5.11695957183838) + 0.0272261240838213*std::sin(0.251199960708618*x_48 + 5.06759977340698) + 0.00754595729940584*std::sin(0.273039966821671*x_49 + 1.8582398891449) - 0.0200910103753468*std::sin(0.314719915390015*x_49 - 7.46687984466553) + 0.000668299066353156*std::sin(1.0694397687912*x_5 - 6.76344013214111) + 0.00633125377113001*std::sin(0.367279857397079*x_50 + 5.15799999237061) - 0.0129465318215544*std::sin(0.323439836502075*x_51 - 4.28312015533447) + 0.0324563338256833*std::sin(0.229279980063438*x_52 + 5.04008007049561) - 0.0216791025159617*std::sin(0.20728000998497*x_53 + 4.99191951751709) - 0.0138901021838815*std::sin(0.273679941892624*x_53 + 5.08431959152222) - 0.00841014490035248*std::sin(0.270639955997467*x_54 + 5.09176015853882) + 0.0164822410996173*std::sin(0.22647999227047*x_56 + 5.04399967193604) - 0.0374333744351505*std::sin(0.157680034637451*x_57 + 4.92840003967285) + 0.0165526417085942*std::sin(0.266399949789047*x_57 - 7.50400018692017) + 0.00560806652295576*std::sin(0.347279846668243*x_59 - 4.26007986068726) - 0.0182731564967306*std::sin(0.374879837036133*x_59 + 1.95975983142853) + 0.045834730715879*std::sin(0.247119963169098*x_60 - 7.52824020385742) - 0.00775810173334657*std::sin(0.218399986624718*x_63 + 8.20975971221924) - 0.00148472016067752*std::sin(0.149120032787323*x_65 + 4.93391990661621) + 0.0498297571084721*std::sin(0.282159924507141*x_65 + 5.1081600189209) - 0.0173497192157504*std::sin(0.287759929895401*x_65 + 5.12423992156982) + 0.131880607721994*std::sin(0.166320025920868*x_67 + 4.94535970687866) + 0.0218000890503899*std::sin(0.20320001244545*x_69 + 4.98776006698608) - 0.0152913601974145*std::sin(0.358319848775864*x_7 + 8.53191947937012) + 0.179251680856799*std::sin(0.121280059218407*x_74 + 4.8842396736145) - 0.0143772092374864*std::sin(0.235679984092712*x_74 + 5.03487968444824) + 0.0259561347303093*std::sin(0.274879962205887*x_74 - 7.51688003540039) - 0.0620264238293715*std::sin(0.225279986858368*x_75 - 7.56712007522583) - 0.0543389843343229*std::sin(0.175280019640923*x_78 + 4.95191955566406) - 0.0412436330926629*std::sin(0.157200023531914*x_8 - 4.46224021911621) + 0.0422444472554898*std::sin(0.257999956607819*x_8 - 4.33247995376587) + 0.005953643666284*std::sin(0.29887992143631*x_80 + 5.11567974090576) - 0.00894065092659076*std::sin(0.385439842939377*x_81 - 4.21808004379272) + 0.0452694787848819*std::sin(0.13728004693985*x_84 + 4.90903997421265) - 0.0362155100128434*std::sin(0.294639945030212*x_84 - 7.47824001312256) + 0.0309781471719604*std::sin(0.186480015516281*x_85 - 7.60864019393921) - 0.00659369397971299*std::sin(0.333439826965332*x_88 - 4.27568006515503) - 0.0651541201547232*std::sin(0.129600048065186*x_9 - 4.49575996398926) - 0.0731552039727706*std::sin(0.222719997167587*x_9 - 4.3692798614502) - 0.00124751391953908*std::sin(0.372239857912064*x_9 - 1.00943982601166) - 0.00283905564307553*std::sin(0.677919805049896*x_9 - 6.93639993667603) - 0.0011324778366976*std::sin(0.372079849243164*x_92 + 1.99183976650238) - 0.0129376481501535*std::sin(0.325199842453003*x_93 + 1.97279977798462) - 0.0253149084113057*std::sin(0.332959830760956*x_93 + 1.98767983913422) - 0.00085658004898962*std::sin(0.351759850978851*x_93 + 1.96647977828979) - 0.0136061815982949*std::sin(0.358479827642441*x_93 - 7.410719871521) + 0.0324135618436754*std::sin(0.362159848213196*x_93 - 7.41519975662231) - 0.0149208023113406*std::sin(0.395199835300446*x_94 - 7.40279960632324) - 0.000437034194548657*std::sin(0.279039949178696*x_95 - 7.51416015625) + 0.00297915036088043*std::sin(0.329999834299088*x_95 - 1.22255992889404) + 0.0071828358074448*std::sin(0.33111983537674*x_95 + 8.16551971435547) - 0.00839173070120599*std::sin(0.340319842100143*x_95 + 5.15104007720947) - 0.0228466529181757*std::sin(0.380959838628769*x_96 + 5.1799201965332) - 0.0150906174391174*std::sin(0.382799863815308*x_96 - 7.40703964233398) + 0.0122261117539165*std::sin(0.392399847507477*x_96 - 7.41631984710693) + 0.0143923459743744*std::sin(0.319759905338287*x_98 + 1.9171998500824) + 0.0032715234084502*std::sin(0.392799854278564*x_98 - 1.18863987922668) + 0.00644719596009546*std::sin(0.374879837036133*x_99 - 1.20063984394073) - 0.0142242463958899*std::sin(0.398159861564636*x_99 - 7.40623998641968) + 0.638878337509417);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00546156991559176*x_1 + 0.0017369910154049*x_10 + 5.74447604228798e-5*x_100 - 0.000759027089189433*x_101 - 7.60561832932567e-5*x_102 + 2.56314477688229e-5*x_103 - 0.00165552431516786*x_104 + 0.00029232059162581*x_105 + 0.00035064073096267*x_106 + 5.39566836197121e-5*x_107 + 0.000315295900205852*x_108 - 0.000814440228176332*x_109 + 0.00141593037936379*x_11 + 0.000340086584421759*x_110 + 0.000203413822400595*x_111 + 0.000150161060099987*x_112 - 0.00158550450638027*x_113 - 0.000749222892979212*x_114 + 0.00130601537200389*x_115 - 0.00337262587161483*x_116 + 9.14795749607055e-5*x_117 - 7.49424121234087e-5*x_118 + 0.000136364529313674*x_119 - 0.000595649836541694*x_12 + 0.00146376482304619*x_120 - 0.000568596677377273*x_13 - 0.00112249074053975*x_14 + 0.000949439466367702*x_15 + 0.00038869583929786*x_16 + 0.000572695059338095*x_17 - 0.000560486056401998*x_18 - 1.03130998358213e-5*x_19 + 0.00359391276915678*x_2 + 0.00335335543369468*x_20 - 7.23493839326965e-5*x_21 + 0.00179984255277861*x_22 - 9.68228945678464e-5*x_23 - 0.000599861159291223*x_24 + 0.00130745925409939*x_25 + 0.00101646821220456*x_26 - 8.77309167368551e-6*x_27 - 0.000438049655188191*x_28 + 0.00180224854588834*x_29 - 0.00101949958629552*x_3 - 0.00020734620063213*x_30 + 0.00629302601098224*x_31 + 0.000855217600074673*x_32 - 0.000143548756921615*x_33 - 0.000194671939507077*x_34 + 0.000736352313307614*x_35 + 0.000204799220672245*x_36 + 2.80689302997233e-6*x_37 - 7.43929883115559e-5*x_38 - 2.52408632201899e-5*x_39 - 0.000661542787523855*x_4 - 0.00010494147770761*x_40 - 0.000182262023186677*x_41 + 0.00303423685437754*x_42 - 2.94490368289169e-5*x_43 + 0.000205128294640022*x_44 - 0.000228082748490555*x_45 + 0.000323790001957974*x_46 + 0.00095150312287648*x_47 - 0.00201680286660495*x_48 - 0.000143315851495841*x_49 + 0.000647099151698774*x_5 + 4.82509631213911e-6*x_50 - 0.000381761226779264*x_51 - 0.00282938864373402*x_52 + 3.9065963366563e-5*x_53 + 9.05209468929459e-5*x_54 - 0.000136878608092873*x_55 + 0.000127063236827879*x_56 - 1.63655062189864e-5*x_57 + 2.8768911158159e-5*x_58 + 0.000961820886485063*x_59 + 0.000354856257850162*x_6 - 0.00121229877162011*x_60 - 0.000349432788430667*x_61 + 0.000148301812671402*x_62 + 3.67043841127883e-5*x_63 - 0.000864637111646727*x_64 - 6.22715744578234e-5*x_65 - 0.000607529853800056*x_66 - 0.00243857088738105*x_67 + 0.000276254747127301*x_68 + 2.65233632274092e-5*x_69 + 0.000288050255930136*x_7 + 0.000167600230678779*x_70 - 3.29798989933778e-5*x_71 + 0.00155565015882808*x_72 - 0.000214670704925526*x_73 - 4.01384369901495e-5*x_74 - 0.000489244865655145*x_75 + 0.00109869459631846*x_76 + 2.65815363420963e-5*x_77 + 8.94639506042432e-5*x_78 - 0.000521437118526261*x_79 + 0.00142536799944886*x_8 - 0.000722293796415596*x_80 - 0.000477926592028455*x_81 - 0.00181571238487079*x_82 - 0.00114736630647585*x_83 + 0.000984282573723975*x_84 + 0.000690478394962816*x_85 + 0.00229149777352201*x_86 + 4.7153951669218e-5*x_87 + 2.64622999408692e-5*x_88 + 0.0013570350438359*x_89 + 0.0015455659514627*x_9 - 0.000850817111692198*x_90 + 0.00633586778548372*x_91 + 0.000413194701837302*x_92 + 0.000326803479827767*x_94 - 2.03495386554141e-5*x_95 + 0.000772302422761232*x_96 + 0.00283633629865028*x_97 - 0.000661042409825598*x_98 + 1.22307412073324e-5*x_99 - 1.11238685515106e-7*std::pow(-7.84783983230591*x_108 - 9.05935955047607, 2) - 5.0766261859533e-5*std::pow(-4.29967975616455*x_14 - 6.14551973342896, 2) + 1.46523870890889e-5*std::pow(-5.92399978637695*x_17 - 9.46343994140625, 2) + 2.59634935644836e-7*std::pow(-6.35599994659424*x_23 - 8.75072002410889, 2) + 4.94201007522407e-6*std::pow(-6.58143997192383*x_37 - 9.56688022613525, 2) + 5.70662422480326e-6*std::pow(-8.35695934295654*x_38 - 9.16335964202881, 2) - 5.4323958153066e-5*std::pow(-5.15975999832153*x_4 - 8.7344799041748, 2) + 1.02457745812922e-7*std::pow(-5.26968002319336*x_44 - 9.51232051849365, 2) + 1.51335186178441e-5*std::pow(-5.72951984405518*x_46 - 7.57535982131958, 2) + 1.08984276944024e-5*std::pow(-5.29848003387451*x_47 - 9.61719989776611, 2) + 2.63636394818882e-5*std::pow(-6.17368030548096*x_5 - 9.76648044586182, 2) + 1.18764604272233e-5*std::pow(-7.51959991455078*x_50 - 9.97152042388916, 2) + 3.79927942090873e-5*std::pow(-4.18656015396118*x_50 - 5.98431968688965, 2) - 7.34720898620028e-6*std::pow(-4.89456033706665*x_53 - 9.16567993164063, 2) + 6.87435780775917e-5*std::pow(-3.0511200428009*x_54 - 3.61879992485046, 2) - 1.36191386889952e-7*std::pow(-5.50551986694336*x_55 - 7.75392007827759, 2) + 1.20055876861703e-6*std::pow(-1.89527988433838*x_56 - 2.83895993232727, 2) - 6.13006339845955e-6*std::pow(-6.54728031158447*x_58 - 9.33351993560791, 2) + 1.32343773418714e-5*std::pow(-7.056960105896*x_60 - 9.21016025543213, 2) - 1.32382634459232e-7*std::pow(-5.30559968948364*x_60 - 6.09144020080566, 2) + 2.01167097468655e-5*std::pow(-4.85904026031494*x_64 - 7.49032020568848, 2) - 3.02505264405709e-5*std::pow(-4.05999994277954*x_66 - 5.80347967147827, 2) + 2.0112290351998e-5*std::pow(-6.47735977172852*x_68 - 8.89960098266602, 2) - 1.23756187313016e-6*std::pow(-2.09295964241028*x_69 - 3.34831976890564, 2) - 5.78066956114662e-5*std::pow(-4.50415992736816*x_7 - 7.37455987930298, 2) - 4.64142143148559e-5*std::pow(-4.27399969100952*x_7 - 6.91639995574951, 2) + 9.23474454674318e-7*std::pow(-3.77760004997253*x_7 - 5.96271991729736, 2) + 1.40965492179028e-5*std::pow(-5.52303981781006*x_70 - 5.93503999710083, 2) - 1.66937130250947e-7*std::pow(-6.29328012466431*x_71 - 9.53400039672852, 2) + 2.91575760782276e-5*std::pow(-4.51783990859985*x_71 - 6.98280000686646, 2) + 1.73068785805435e-5*std::pow(-6.04655981063843*x_72 - 7.45879983901978, 2) - 2.31976122500789e-7*std::pow(-5.11975955963135*x_73 - 7.37648010253906, 2) - 1.30016874159507e-5*std::pow(-4.88303995132446*x_73 - 6.30624008178711, 2) + 1.8991932898671e-5*std::pow(-5.61847972869873*x_74 - 9.03551959991455, 2) + 1.48052877320621e-5*std::pow(-6.10015964508057*x_75 - 8.54423999786377, 2) - 3.20472341681919e-5*std::pow(-4.85663986206055*x_75 - 7.2629599571228, 2) + 1.43723803082243e-7*std::pow(-6.23928022384644*x_76 - 8.45512008666992, 2) + 5.07367595414709e-6*std::pow(-5.75799989700317*x_77 - 6.99304008483887, 2) + 3.31369819014487e-6*std::pow(-6.51543998718262*x_79 - 9.14416027069092, 2) + 6.95946437688338e-8*std::pow(-4.61711978912354*x_80 - 6.62912034988403, 2) + 2.45797299546168e-8*std::pow(-9.80399990081787*x_81 - 9.96455955505371, 2) - 3.88904466542782e-5*std::pow(-5.51904010772705*x_82 - 7.76719999313354, 2) + 1.69655186401233e-5*std::pow(-6.52063989639282*x_83 - 9.15176010131836, 2) + 1.81316257795843e-5*std::pow(-5.5021595954895*x_83 - 7.13471984863281, 2) - 8.63978909670049e-6*std::pow(-7.79527997970581*x_85 - 9.79351997375488, 2) - 4.82066787017527e-5*std::pow(-3.08799982070923*x_86 - 4.93535995483398, 2) - 5.58230799682981e-6*std::pow(-7.49096012115479*x_87 - 9.92399978637695, 2) - 2.32589598120553e-5*std::pow(-5.73847961425781*x_87 - 7.79936027526855, 2) - 2.35893129738102e-5*std::pow(-4.00183963775635*x_87 - 5.6003999710083, 2) + 1.19098430614039e-5*std::pow(-6.34912014007568*x_89 - 9.13704013824463, 2) + 2.10584059123778e-7*std::pow(-5.6814398765564*x_90 - 8.55256080627441, 2) + 5.24587472267623e-6*std::pow(-5.93959999084473*x_99 - 7.78736019134521, 2) + 1.15308252819988e-5*std::exp(0.754959881305695*x_22) - 0.023785180710653*std::sin(0.221119984984398*x_1 + 5.20879983901978) - 0.0836287133727773*std::sin(0.241199970245361*x_10 - 7.54232025146484) + 0.0142756517828638*std::sin(0.34215983748436*x_10 - 1.05311977863312) - 0.0113045134458318*std::sin(0.320959836244583*x_101 + 5.14448022842407) - 0.00674907041627303*std::sin(0.403039842844009*x_102 + 1.98351979255676) - 7.87036135621505e-5*std::sin(0.376479834318161*x_104 + 5.18048000335693) - 0.0166981526774315*std::sin(0.388159841299057*x_104 - 7.40119981765747) + 0.0120227997824691*std::sin(0.322239845991135*x_105 - 1.24519991874695) + 0.000102823218766654*std::sin(0.388559848070145*x_105 + 1.97791981697083) - 0.00400508764790322*std::sin(0.345919847488403*x_106 + 1.94127976894379) - 0.017333649141989*std::sin(0.391999840736389*x_106 - 7.40279960632324) - 0.00013323202129052*std::sin(0.314319938421249*x_107 + 5.11247968673706) + 0.00933751934782321*std::sin(0.386559844017029*x_107 - 7.42159986495972) - 0.0155809280134523*std::sin(0.37951985001564*x_108 - 7.40759992599487) - 0.0151429035839856*std::sin(0.32151985168457*x_109 - 7.4521598815918) - 5.90535001635739e-5*std::sin(0.435439854860306*x_109 + 5.23640012741089) - 0.0234528505842794*std::sin(0.19743999838829*x_110 + 1.78303980827332) - 0.00674541367150662*std::sin(0.364959836006165*x_110 + 5.18104028701782) - 0.0113863070369567*std::sin(0.22647999227047*x_111 + 5.04263973236084) + 0.0170216743437083*std::sin(0.326559841632843*x_111 - 4.26839971542358) - 0.000170691415640708*std::sin(0.371999859809875*x_111 + 5.18032026290894) + 0.0210959937815908*std::sin(0.332879841327667*x_112 - 4.2545599937439) + 0.00591529002000669*std::sin(0.33519983291626*x_112 + 5.14775991439819) + 0.0114052940736164*std::sin(0.368799835443497*x_112 + 1.98655986785889) - 0.0101560014969143*std::sin(0.376959830522537*x_113 + 1.98927986621857) - 0.000207899708077565*std::sin(0.244079977273941*x_114 + 5.04392004013062) + 0.00796353429307363*std::sin(0.366399854421616*x_114 - 7.43375968933105) + 0.0138468569557287*std::sin(0.205520004034042*x_115 - 7.59376001358032) - 0.0254591404860704*std::sin(0.228079989552498*x_115 + 1.83607995510101) + 0.000151833645332896*std::sin(0.405839860439301*x_117 + 5.1910400390625) + 7.98929412291657e-5*std::sin(0.266799956560135*x_118 + 5.07727956771851) + 8.02541702507793e-5*std::sin(0.36575984954834*x_119 - 1.21287977695465) + 0.0251446759709704*std::sin(0.249359980225563*x_12 + 8.27031993865967) - 0.000114201935914749*std::sin(0.463279873132706*x_120 - 1.14679980278015) - 0.0558300027736995*std::sin(0.138080030679703*x_14 + 8.09639930725098) - 0.000235152621494829*std::sin(0.393119841814041*x_15 + 2.19063997268677) - 0.013814120721488*std::sin(0.293359935283661*x_16 - 4.28935956954956) + 0.0207220308940446*std::sin(0.315119922161102*x_16 - 4.26247978210449) - 8.34025343709453e-5*std::sin(0.365359842777252*x_16 + 2.14367985725403) + 0.0306779351125879*std::sin(0.181920006871223*x_19 - 4.4191198348999) + 0.0147350000231713*std::sin(0.296239942312241*x_21 - 4.29503965377808) - 0.00658141215997761*std::sin(0.318959832191467*x_21 + 5.13607978820801) - 0.0194014265276854*std::sin(0.363199830055237*x_21 - 4.21568012237549) - 0.0511225480087165*std::sin(0.134160041809082*x_23 - 4.49503993988037) - 0.0330905022581987*std::sin(0.29807984828949*x_23 - 4.32223987579346) + 0.000296525413869938*std::sin(0.317679941654205*x_24 + 8.35151958465576) - 0.0151198898618808*std::sin(0.465839862823486*x_24 + 8.48311996459961) + 0.0227613420458781*std::sin(0.297679930925369*x_26 + 5.10839986801147) + 0.0273121672481724*std::sin(0.310239940881729*x_27 + 5.1334400177002) - 0.0177095220509041*std::sin(0.360559850931168*x_27 + 5.16951990127563) + 0.0310273266142183*std::sin(0.36287984251976*x_27 + 5.17112016677856) + 0.00557744492568105*std::sin(0.519679844379425*x_27 - 4.07424020767212) - 0.0187970662564349*std::sin(0.257439970970154*x_28 - 7.52328014373779) + 0.0110569113505936*std::sin(0.262639969587326*x_28 + 5.06967973709106) - 0.0249507661828333*std::sin(0.336719840764999*x_28 - 4.25856018066406) - 0.000363060176782169*std::sin(0.849039852619171*x_29 - 3.96919989585876) + 0.000129522903252066*std::sin(0.32847985625267*x_3 - 1.05927979946136) - 0.019111799046413*std::sin(0.372319847345352*x_3 - 1.03087985515594) + 0.000199224846742009*std::sin(0.268079966306686*x_32 - 7.42328023910522) + 0.0152200030539504*std::sin(0.302319914102554*x_33 - 1.18495988845825) + 0.013659057659705*std::sin(0.348319828510284*x_34 + 1.97575974464417) - 0.0140939447905125*std::sin(0.357759833335876*x_34 + 1.97135984897614) + 0.000269249593159578*std::sin(0.361279845237732*x_34 + 1.99055981636047) - 0.0146302231678299*std::sin(0.29615992307663*x_35 + 8.26560020446777) + 0.0174504144590375*std::sin(0.309519916772842*x_35 + 8.2775993347168) + 0.000173345931755114*std::sin(0.31743985414505*x_35 - 1.20303988456726) - 0.0159125289957584*std::sin(0.332799851894379*x_35 - 1.22799980640411) + 0.00655703601834363*std::sin(0.313519924879074*x_36 - 4.28071975708008) - 0.0113939590123193*std::sin(0.317359834909439*x_36 + 1.92511987686157) - 0.0223297434931736*std::sin(0.340159833431244*x_36 + 5.15488004684448) - 0.00822427048854969*std::sin(0.351599842309952*x_37 + 5.16336011886597) - 0.0314286365100244*std::sin(0.3713598549366*x_37 + 5.17824029922485) - 0.0236692459923821*std::sin(0.377359837293625*x_37 + 5.18239974975586) + 0.000486644243665518*std::sin(0.149600028991699*x_38 + 4.92015981674194) + 0.0207570970102636*std::sin(0.320479840040207*x_38 - 7.46943950653076) - 0.0217928858572216*std::sin(0.3574398458004*x_38 + 5.16215991973877) - 0.0111707626382338*std::sin(0.353839844465256*x_39 - 7.44127988815308) + 0.06084196822333*std::sin(0.132800042629242*x_40 + 4.9093599319458) - 0.000172567522945228*std::sin(0.315199851989746*x_41 + 5.12504005432129) + 0.0121797194498529*std::sin(0.309279918670654*x_43 + 5.13111972808838) - 0.000106520586431965*std::sin(0.331439822912216*x_43 + 5.13816022872925) + 0.0186845143595955*std::sin(0.34911984205246*x_43 + 5.14328002929688) + 0.0158189344523579*std::sin(0.307359933853149*x_44 - 7.48016023635864) + 0.0161759929786103*std::sin(0.27687993645668*x_45 - 7.51800012588501) - 0.0140826167476117*std::sin(0.298879951238632*x_45 - 7.48623991012573) + 0.000135325415545661*std::sin(0.321199834346771*x_45 - 7.46703958511353) + 0.000178804324282534*std::sin(0.298079937696457*x_47 + 5.12423944473267) - 0.0128665020699252*std::sin(0.306559920310974*x_47 + 5.11695957183838) + 0.0153290789703139*std::sin(0.251199960708618*x_48 + 5.06759977340698) - 0.0148813227000457*std::sin(0.273039966821671*x_49 + 1.8582398891449) + 0.000128195680802055*std::sin(0.314719915390015*x_49 - 7.46687984466553) + 0.000376271302238065*std::sin(1.0694397687912*x_5 - 6.76344013214111) + 0.00830540003255383*std::sin(0.367279857397079*x_50 + 5.15799999237061) - 0.0169833858662415*std::sin(0.323439836502075*x_51 - 4.28312015533447) - 0.000207095697697105*std::sin(0.229279980063438*x_52 + 5.04008007049561) + 0.0427531865854582*std::sin(0.20728000998497*x_53 + 4.99191951751709) - 0.0182211706086132*std::sin(0.273679941892624*x_53 + 5.08431959152222) - 0.0110325095556394*std::sin(0.270639955997467*x_54 + 5.09176015853882) + 0.0216215635502617*std::sin(0.22647999227047*x_56 + 5.04399967193604) - 0.0491054632290957*std::sin(0.157680034637451*x_57 + 4.92840003967285) - 0.000105618240858088*std::sin(0.266399949789047*x_57 - 7.50400018692017) - 0.0110596236289329*std::sin(0.347279846668243*x_59 - 4.26007986068726) + 0.000116596412710798*std::sin(0.374879837036133*x_59 + 1.95975983142853) + 0.0258062515458928*std::sin(0.247119963169098*x_60 - 7.52824020385742) - 0.0101771530123318*std::sin(0.218399986624718*x_63 + 8.20975971221924) - 0.0184181529501028*std::sin(0.149120032787323*x_65 + 4.93391990661621) - 0.000317951139210008*std::sin(0.282159924507141*x_65 + 5.1081600189209) - 0.0227595297469137*std::sin(0.287759929895401*x_65 + 5.12423992156982) - 0.000841496966835243*std::sin(0.166320025920868*x_67 + 4.94535970687866) + 0.0285975680100513*std::sin(0.20320001244545*x_69 + 4.98776006698608) - 0.00860946888025727*std::sin(0.358319848775864*x_7 + 8.53191947937012) - 0.00114375986239832*std::sin(0.121280059218407*x_74 + 4.8842396736145) - 0.018860162360502*std::sin(0.235679984092712*x_74 + 5.03487968444824) + 0.0146140389950494*std::sin(0.274879962205887*x_74 - 7.51688003540039) + 0.000395774999961187*std::sin(0.225279986858368*x_75 - 7.56712007522583) - 0.0305943871945572*std::sin(0.175280019640923*x_78 + 4.95191955566406) - 0.0541037974488428*std::sin(0.157200023531914*x_8 - 4.46224021911621) - 0.000269551186070229*std::sin(0.257999956607819*x_8 - 4.33247995376587) + 0.00781004743882563*std::sin(0.29887992143631*x_80 + 5.11567974090576) - 0.011728432500267*std::sin(0.385439842939377*x_81 - 4.21808004379272) - 0.0892755810205478*std::sin(0.13728004693985*x_84 + 4.90903997421265) + 0.000231082054857082*std::sin(0.294639945030212*x_84 - 7.47824001312256) + 0.0406374335686337*std::sin(0.186480015516281*x_85 - 7.60864019393921) - 0.00864967164062735*std::sin(0.333439826965332*x_88 - 4.27568006515503) + 0.128489924974308*std::sin(0.129600048065186*x_9 - 4.49575996398926) - 0.0411884517728471*std::sin(0.222719997167587*x_9 - 4.3692798614502) - 0.0154755776785357*std::sin(0.372239857912064*x_9 - 1.00943982601166) + 1.8115299539419e-5*std::sin(0.677919805049896*x_9 - 6.93639993667603) - 0.0140485396247194*std::sin(0.372079849243164*x_92 + 1.99183976650238) + 0.0255142335773942*std::sin(0.325199842453003*x_93 + 1.97279977798462) - 0.0142530104163363*std::sin(0.332959830760956*x_93 + 1.98767983913422) - 0.0106259905227515*std::sin(0.351759850978851*x_93 + 1.96647977828979) - 0.0178487208338899*std::sin(0.358479827642441*x_93 - 7.410719871521) - 0.000206822780444547*std::sin(0.362159848213196*x_93 - 7.41519975662231) - 0.0195732530209762*std::sin(0.395199835300446*x_94 - 7.40279960632324) - 0.00542146786499416*std::sin(0.279039949178696*x_95 - 7.51416015625) - 0.00587515886098508*std::sin(0.329999834299088*x_95 - 1.22255992889404) - 4.58318675478196e-5*std::sin(0.33111983537674*x_95 + 8.16551971435547) - 0.0110083536308069*std::sin(0.340319842100143*x_95 + 5.15104007720947) - 0.0128633126666084*std::sin(0.380959838628769*x_96 + 5.1799201965332) - 0.0197960181507198*std::sin(0.382799863815308*x_96 - 7.40703964233398) - 7.80117420962844e-5*std::sin(0.392399847507477*x_96 - 7.41631984710693) - 9.1833937470245e-5*std::sin(0.319759905338287*x_98 + 1.9171998500824) + 0.00429161610089644*std::sin(0.392799854278564*x_98 - 1.18863987922668) + 0.00845749411925731*std::sin(0.374879837036133*x_99 - 1.20063984394073) - 0.00800865358669871*std::sin(0.398159861564636*x_99 - 7.40623998641968) + 0.0120257094645783);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00460928173585835*x_1 - 0.00316873310635666*x_10 + 0.00153609704699154*x_100 + 4.67102726043503e-5*x_101 - 0.000616436072992752*x_102 - 0.000180675057874498*x_103 - 0.00212228289801888*x_104 + 0.000961099653479009*x_105 - 7.21260498403961e-5*x_106 - 0.000226544187102374*x_107 - 0.000217356111352181*x_108 - 0.00130514623027894*x_109 + 0.000357884560522738*x_11 + 0.00200240826993224*x_110 - 0.000308838779228078*x_111 + 0.000135606649883786*x_112 + 0.000397889612767976*x_113 + 0.000105090266041758*x_114 + 0.00183704487788224*x_115 - 0.00472675451516842*x_116 + 0.0017254115818549*x_117 + 3.28297021558112e-5*x_118 + 0.0017002193348032*x_119 + 0.00134559676421802*x_12 - 0.000891346145481017*x_120 + 0.000362161466248094*x_13 + 0.00117145925017366*x_14 - 0.00126692424845938*x_15 + 0.000115427230715724*x_16 - 2.49926055860572e-6*x_17 - 0.000538719806672704*x_18 + 0.00109131589610246*x_19 + 0.00154335550608679*x_2 - 0.00332130043209324*x_20 + 0.00040685770782302*x_21 - 0.00111848226470276*x_22 - 9.1931668415612e-5*x_23 - 0.00037417200738406*x_24 - 0.0054484736015017*x_25 - 0.000264373235092693*x_26 - 0.00114457985314118*x_27 - 0.000923839453322193*x_28 - 0.00155514920953054*x_29 - 0.00160222275909648*x_3 + 0.000796984024586769*x_30 + 0.00124361164631362*x_31 - 0.000514228717340834*x_32 - 0.00186939248998689*x_33 + 5.4067195079913e-5*x_34 - 0.000153975333498336*x_35 - 0.000128007385437301*x_36 + 0.000366200802581959*x_37 + 6.32228861795179e-6*x_38 + 0.000303430199571145*x_39 + 0.00481679503376978*x_4 - 0.00220038324212619*x_40 + 0.000389482113017601*x_41 - 0.000845110922038671*x_42 + 7.65252822985779e-6*x_43 - 4.41365178673423e-5*x_44 + 2.4562790893457e-5*x_45 - 0.000139055433345583*x_46 - 0.000297672616999136*x_47 - 0.000968828405463773*x_48 + 0.000146757293665042*x_49 + 0.00127383667657575*x_5 + 0.00104076875588708*x_50 + 0.000134518893529649*x_51 - 0.00378522712383009*x_52 - 0.000140930882709461*x_53 + 7.66337418572205e-6*x_54 - 0.000167864651324278*x_55 - 0.00016051966268979*x_56 - 3.88286980435769e-5*x_57 - 0.00208402938853913*x_58 + 0.00108326298089395*x_59 + 0.000287406663963431*x_6 + 0.000255917693077587*x_60 + 5.46551135635776e-5*x_61 + 0.00040037021560097*x_62 + 0.00125028260940752*x_63 + 0.000450880608640685*x_64 - 9.13329829609086e-5*x_65 + 0.000896222666909648*x_66 + 0.000966095554175296*x_67 + 0.00010004480901691*x_68 + 0.000498004736898434*x_69 - 6.02328985997158e-5*x_7 + 0.00237578919254168*x_70 + 2.99006070654954e-6*x_71 - 0.000604543351391509*x_72 + 7.51168395648096e-5*x_73 + 3.41116534077685e-6*x_74 + 9.99664864345999e-5*x_75 + 0.000872940403865606*x_76 - 0.000107195143417462*x_77 - 0.000617443493143414*x_78 + 0.000155417072857882*x_79 + 0.000536665797216673*x_8 + 0.000261957659976766*x_80 - 0.000846454001032866*x_81 - 0.000936164293966913*x_82 + 0.000415334564062878*x_83 + 0.00146520925114457*x_84 + 0.000889668549895081*x_85 - 0.000411279821274413*x_86 - 3.05162289136306e-5*x_87 + 0.000693163271836848*x_88 + 0.00161062224698251*x_89 - 0.000323186372228759*x_9 - 0.00123063354004611*x_90 + 0.00361878457046219*x_91 - 9.98368167016977e-5*x_92 + 0.000220197955841502*x_94 - 2.76868025346475e-5*x_95 - 0.000332272269385453*x_96 + 0.00182643863325475*x_97 + 1.90888552669481e-5*x_98 + 0.000158387304999257*x_99 - 1.45127354262573e-5*std::pow(-7.84783983230591*x_108 - 9.05935955047607, 2) + 2.60640669997409e-5*std::pow(-4.29967975616455*x_14 - 6.14551973342896, 2) + 1.99354764187192e-5*std::pow(-5.92399978637695*x_17 - 9.46343994140625, 2) + 3.38732259463381e-5*std::pow(-6.35599994659424*x_23 - 8.75072002410889, 2) - 4.19996759876613e-7*std::pow(-6.58143997192383*x_37 - 9.56688022613525, 2) - 2.92985598485003e-6*std::pow(-8.35695934295654*x_38 - 9.16335964202881, 2) + 4.6167219533493e-6*std::pow(-5.15975999832153*x_4 - 8.7344799041748, 2) + 1.33671316814664e-5*std::pow(-5.26968002319336*x_44 - 9.51232051849365, 2) + 2.0590085540597e-5*std::pow(-5.72951984405518*x_46 - 7.57535982131958, 2) - 2.27892139201046e-6*std::pow(-5.29848003387451*x_47 - 9.61719989776611, 2) - 5.51278254728294e-6*std::pow(-6.17368030548096*x_5 - 9.76648044586182, 2) + 1.61586569714003e-5*std::pow(-7.51959991455078*x_50 - 9.97152042388916, 2) - 1.95060005897808e-5*std::pow(-4.18656015396118*x_50 - 5.98431968688965, 2) - 9.99633101400034e-6*std::pow(-4.89456033706665*x_53 - 9.16567993164063, 2) - 3.52938577548588e-5*std::pow(-3.0511200428009*x_54 - 3.61879992485046, 2) - 1.77681851966913e-5*std::pow(-5.50551986694336*x_55 - 7.75392007827759, 2) + 0.00015663068735423*std::pow(-1.89527988433838*x_56 - 2.83895993232727, 2) - 8.34032936628095e-6*std::pow(-6.54728031158447*x_58 - 9.33351993560791, 2) - 6.79470351180908e-6*std::pow(-7.056960105896*x_60 - 9.21016025543213, 2) - 1.72712769846319e-5*std::pow(-5.30559968948364*x_60 - 6.09144020080566, 2) - 4.20651505561152e-6*std::pow(-4.85904026031494*x_64 - 7.49032020568848, 2) - 4.11577071260231e-5*std::pow(-4.05999994277954*x_66 - 5.80347967147827, 2) - 1.03259145749823e-5*std::pow(-6.47735977172852*x_68 - 8.89960098266602, 2) - 0.000161458290838238*std::pow(-2.09295964241028*x_69 - 3.34831976890564, 2) + 2.96787183507772e-5*std::pow(-4.50415992736816*x_7 - 7.37455987930298, 2) + 3.9445123194279e-6*std::pow(-4.27399969100952*x_7 - 6.91639995574951, 2) + 0.000120480931355266*std::pow(-3.77760004997253*x_7 - 5.96271991729736, 2) - 7.23735390045409e-6*std::pow(-5.52303981781006*x_70 - 5.93503999710083, 2) - 2.17794231649891e-5*std::pow(-6.29328012466431*x_71 - 9.53400039672852, 2) + 3.96706807430285e-5*std::pow(-4.51783990859985*x_71 - 6.98280000686646, 2) + 2.35470758263673e-5*std::pow(-6.04655981063843*x_72 - 7.45879983901978, 2) - 3.02647237826791e-5*std::pow(-5.11975955963135*x_73 - 7.37648010253906, 2) + 6.67523744128884e-6*std::pow(-4.88303995132446*x_73 - 6.30624008178711, 2) - 9.75070831283967e-6*std::pow(-5.61847972869873*x_74 - 9.03551959991455, 2) + 2.01435071746544e-5*std::pow(-6.10015964508057*x_75 - 8.54423999786377, 2) + 1.64534718121911e-5*std::pow(-4.85663986206055*x_75 - 7.2629599571228, 2) + 1.87509005426429e-5*std::pow(-6.23928022384644*x_76 - 8.45512008666992, 2) - 1.06093364953677e-6*std::pow(-5.75799989700317*x_77 - 6.99304008483887, 2) - 2.81614663241402e-7*std::pow(-6.51543998718262*x_79 - 9.14416027069092, 2) + 9.07965288716531e-6*std::pow(-4.61711978912354*x_80 - 6.62912034988403, 2) + 3.20679012007709e-6*std::pow(-9.80399990081787*x_81 - 9.96455955505371, 2) + 1.99668671696104e-5*std::pow(-5.51904010772705*x_82 - 7.76719999313354, 2) - 3.54758360009924e-6*std::pow(-6.52063989639282*x_83 - 9.15176010131836, 2) + 2.46691952624642e-5*std::pow(-5.5021595954895*x_83 - 7.13471984863281, 2) + 4.4357814349836e-6*std::pow(-7.79527997970581*x_85 - 9.79351997375488, 2) + 1.00802826253208e-5*std::pow(-3.08799982070923*x_86 - 4.93535995483398, 2) + 1.16729141739414e-6*std::pow(-7.49096012115479*x_87 - 9.92399978637695, 2) - 3.16452494762747e-5*std::pow(-5.73847961425781*x_87 - 7.79936027526855, 2) + 1.21110637519156e-5*std::pow(-4.00183963775635*x_87 - 5.6003999710083, 2) - 1.01215809362789e-6*std::pow(-6.34912014007568*x_89 - 9.13704013824463, 2) + 2.74738120187125e-5*std::pow(-5.6814398765564*x_90 - 8.55256080627441, 2) - 4.45820699008337e-7*std::pow(-5.93959999084473*x_99 - 7.78736019134521, 2) + 0.00150436708047329*std::exp(0.754959881305695*x_22) + 0.00497361258470175*std::sin(0.221119984984398*x_1 + 5.20879983901978) + 0.0429360821263795*std::sin(0.241199970245361*x_10 - 7.54232025146484) - 0.00121321636392207*std::sin(0.34215983748436*x_10 - 1.05311977863312) - 0.0153804878245602*std::sin(0.320959836244583*x_101 + 5.14448022842407) + 0.00141126788001991*std::sin(0.403039842844009*x_102 + 1.98351979255676) - 0.0102680530197633*std::sin(0.376479834318161*x_104 + 5.18048000335693) + 0.00349167590139635*std::sin(0.388159841299057*x_104 - 7.40119981765747) - 0.00617266364661237*std::sin(0.322239845991135*x_105 - 1.24519991874695) + 0.0134148130457184*std::sin(0.388559848070145*x_105 + 1.97791981697083) - 0.0054491687855513*std::sin(0.345919847488403*x_106 + 1.94127976894379) + 0.00362456172018019*std::sin(0.391999840736389*x_106 - 7.40279960632324) - 0.0173820920873091*std::sin(0.314319938421249*x_107 + 5.11247968673706) - 0.0019525268402703*std::sin(0.386559844017029*x_107 - 7.42159986495972) - 0.0211988136202901*std::sin(0.37951985001564*x_108 - 7.40759992599487) + 0.00316646473072638*std::sin(0.32151985168457*x_109 - 7.4521598815918) - 0.00770440445156109*std::sin(0.435439854860306*x_109 + 5.23640012741089) + 0.0120410021650783*std::sin(0.19743999838829*x_110 + 1.78303980827332) + 0.00141050323450342*std::sin(0.364959836006165*x_110 + 5.18104028701782) + 0.000967665381027229*std::sin(0.22647999227047*x_111 + 5.04263973236084) - 0.00355932606770756*std::sin(0.326559841632843*x_111 - 4.26839971542358) - 0.0222692253441857*std::sin(0.371999859809875*x_111 + 5.18032026290894) - 0.0108309608627653*std::sin(0.332879841327667*x_112 - 4.2545599937439) - 0.000502710962607787*std::sin(0.33519983291626*x_112 + 5.14775991439819) - 0.00238490994988978*std::sin(0.368799835443497*x_112 + 1.98655986785889) + 0.00212367597580116*std::sin(0.376959830522537*x_113 + 1.98927986621857) - 0.0271235986343626*std::sin(0.244079977273941*x_114 + 5.04392004013062) + 0.0108348796099887*std::sin(0.366399854421616*x_114 - 7.43375968933105) - 0.00289545422636759*std::sin(0.205520004034042*x_115 - 7.59376001358032) + 0.013071057806478*std::sin(0.228079989552498*x_115 + 1.83607995510101) + 0.019808949677145*std::sin(0.405839860439301*x_117 + 5.1910400390625) + 0.0104232184434339*std::sin(0.266799956560135*x_118 + 5.07727956771851) + 0.010470346123833*std::sin(0.36575984954834*x_119 - 1.21287977695465) - 0.00525789054827125*std::sin(0.249359980225563*x_12 + 8.27031993865967) - 0.0148993353654118*std::sin(0.463279873132706*x_120 - 1.14679980278015) - 0.0759601624626013*std::sin(0.138080030679703*x_14 + 8.09639930725098) - 0.0306791451619754*std::sin(0.393119841814041*x_15 + 2.19063997268677) + 0.00288860889907847*std::sin(0.293359935283661*x_16 - 4.28935956954956) + 0.0281936012012554*std::sin(0.315119922161102*x_16 - 4.26247978210449) - 0.0108810968917867*std::sin(0.365359842777252*x_16 + 2.14367985725403) - 0.00260716452432721*std::sin(0.181920006871223*x_19 - 4.4191198348999) + 0.0200478764112438*std::sin(0.296239942312241*x_21 - 4.29503965377808) + 0.000559321357206623*std::sin(0.318959832191467*x_21 + 5.13607978820801) + 0.00996094773153333*std::sin(0.363199830055237*x_21 - 4.21568012237549) + 0.0106900069934844*std::sin(0.134160041809082*x_23 - 4.49503993988037) + 0.0169890993805921*std::sin(0.29807984828949*x_23 - 4.32223987579346) + 0.0386861356616035*std::sin(0.317679941654205*x_24 + 8.35151958465576) + 0.0077627504557884*std::sin(0.465839862823486*x_24 + 8.48311996459961) - 0.0116859725801612*std::sin(0.297679930925369*x_26 + 5.10839986801147) - 0.00232112471946356*std::sin(0.310239940881729*x_27 + 5.1334400177002) + 0.00370315882031453*std::sin(0.360559850931168*x_27 + 5.16951990127563) - 0.0159298378504497*std::sin(0.36287984251976*x_27 + 5.17112016677856) + 0.0075884578476239*std::sin(0.519679844379425*x_27 - 4.07424020767212) + 0.0096506612139749*std::sin(0.257439970970154*x_28 - 7.52328014373779) - 0.000939671686379899*std::sin(0.262639969587326*x_28 + 5.06967973709106) + 0.0052173429411579*std::sin(0.336719840764999*x_28 - 4.25856018066406) + 3.08546715947007e-5*std::sin(0.849039852619171*x_29 - 3.96919989585876) + 0.0168981826586101*std::sin(0.32847985625267*x_3 - 1.05927979946136) + 0.00162421637202803*std::sin(0.372319847345352*x_3 - 1.03087985515594) + 0.0259918343849073*std::sin(0.268079966306686*x_32 - 7.42328023910522) - 0.0078141498862385*std::sin(0.302319914102554*x_33 - 1.18495988845825) + 0.0185839904598034*std::sin(0.348319828510284*x_34 + 1.97575974464417) + 0.00294712165658631*std::sin(0.357759833335876*x_34 + 1.97135984897614) + 0.0351276005380495*std::sin(0.361279845237732*x_34 + 1.99055981636047) + 0.00124334961548651*std::sin(0.29615992307663*x_35 + 8.26560020446777) + 0.0237423652425941*std::sin(0.309519916772842*x_35 + 8.2775993347168) + 0.0226155463194356*std::sin(0.31743985414505*x_35 - 1.20303988456726) + 0.0081697018194552*std::sin(0.332799851894379*x_35 - 1.22799980640411) - 0.00137111242735146*std::sin(0.313519924879074*x_36 - 4.28071975708008) - 0.0155021840349202*std::sin(0.317359834909439*x_36 + 1.92511987686157) + 0.0114643842027107*std::sin(0.340159833431244*x_36 + 5.15488004684448) - 0.0111896272865834*std::sin(0.351599842309952*x_37 + 5.16336011886597) + 0.0161358756328038*std::sin(0.3713598549366*x_37 + 5.17824029922485) + 0.0049493699951326*std::sin(0.377359837293625*x_37 + 5.18239974975586) + 0.0634899551565596*std::sin(0.149600028991699*x_38 + 4.92015981674194) + 0.0282413108153088*std::sin(0.320479840040207*x_38 - 7.46943950653076) + 0.00455701273305441*std::sin(0.3574398458004*x_38 + 5.16215991973877) - 0.015198511600847*std::sin(0.353839844465256*x_39 - 7.44127988815308) + 0.0827792506033281*std::sin(0.132800042629242*x_40 + 4.9093599319458) - 0.0225139913517637*std::sin(0.315199851989746*x_41 + 5.12504005432129) - 0.00625322826914825*std::sin(0.309279918670654*x_43 + 5.13111972808838) - 0.0138971894640642*std::sin(0.331439822912216*x_43 + 5.13816022872925) + 0.0254214342786721*std::sin(0.34911984205246*x_43 + 5.14328002929688) + 0.0215226360610607*std::sin(0.307359933853149*x_44 - 7.48016023635864) + 0.0220084362100008*std::sin(0.27687993645668*x_45 - 7.51800012588501) + 0.00294475290028309*std::sin(0.298879951238632*x_45 - 7.48623991012573) + 0.0176552063984593*std::sin(0.321199834346771*x_45 - 7.46703958511353) + 0.0233276745348697*std::sin(0.298079937696457*x_47 + 5.12423944473267) - 0.017505669693739*std::sin(0.306559920310974*x_47 + 5.11695957183838) + 0.0208561574626254*std::sin(0.251199960708618*x_48 + 5.06759977340698) + 0.00764026693499634*std::sin(0.273039966821671*x_49 + 1.8582398891449) + 0.0167250268164711*std::sin(0.314719915390015*x_49 - 7.46687984466553) + 0.000511940315745108*std::sin(1.0694397687912*x_5 - 6.76344013214111) - 0.00173670499397933*std::sin(0.367279857397079*x_50 + 5.15799999237061) + 0.00355131973571057*std::sin(0.323439836502075*x_51 - 4.28312015533447) - 0.0270187035623151*std::sin(0.229279980063438*x_52 + 5.04008007049561) - 0.0219500486897984*std::sin(0.20728000998497*x_53 + 4.99191951751709) + 0.00381014735811557*std::sin(0.273679941892624*x_53 + 5.08431959152222) + 0.00230695864934902*std::sin(0.270639955997467*x_54 + 5.09176015853882) - 0.00452118829294182*std::sin(0.22647999227047*x_56 + 5.04399967193604) + 0.0102682234314264*std::sin(0.157680034637451*x_57 + 4.92840003967285) - 0.0137794651084041*std::sin(0.266399949789047*x_57 - 7.50400018692017) + 0.00567815633252689*std::sin(0.347279846668243*x_59 - 4.26007986068726) + 0.0152117303569964*std::sin(0.374879837036133*x_59 + 1.95975983142853) + 0.0351109970014225*std::sin(0.247119963169098*x_60 - 7.52824020385742) + 0.00212809887443478*std::sin(0.218399986624718*x_63 + 8.20975971221924) + 0.00156526685381238*std::sin(0.149120032787323*x_65 + 4.93391990661621) - 0.0414814391276254*std::sin(0.282159924507141*x_65 + 5.1081600189209) + 0.00475914330642207*std::sin(0.287759929895401*x_65 + 5.12423992156982) - 0.109785752907152*std::sin(0.166320025920868*x_67 + 4.94535970687866) - 0.00597990933417425*std::sin(0.20320001244545*x_69 + 4.98776006698608) - 0.0117137134581897*std::sin(0.358319848775864*x_7 + 8.53191947937012) - 0.149220428102822*std::sin(0.121280059218407*x_74 + 4.8842396736145) + 0.00394376406077495*std::sin(0.235679984092712*x_74 + 5.03487968444824) + 0.0198833014714032*std::sin(0.274879962205887*x_74 - 7.51688003540039) + 0.0516347153525441*std::sin(0.225279986858368*x_75 - 7.56712007522583) - 0.0416255508917343*std::sin(0.175280019640923*x_78 + 4.95191955566406) + 0.0113134027084014*std::sin(0.157200023531914*x_8 - 4.46224021911621) - 0.0351669478037821*std::sin(0.257999956607819*x_8 - 4.33247995376587) - 0.00163312403220309*std::sin(0.29887992143631*x_80 + 5.11567974090576) + 0.00245247997867961*std::sin(0.385439842939377*x_81 - 4.21808004379272) + 0.0458352582980936*std::sin(0.13728004693985*x_84 + 4.90903997421265) + 0.0301480794057142*std::sin(0.294639945030212*x_84 - 7.47824001312256) - 0.00849751168450923*std::sin(0.186480015516281*x_85 - 7.60864019393921) + 0.00180869408766333*std::sin(0.333439826965332*x_88 - 4.27568006515503) - 0.0659684186042381*std::sin(0.129600048065186*x_9 - 4.49575996398926) - 0.0560394292103161*std::sin(0.222719997167587*x_9 - 4.3692798614502) + 0.00131519207433205*std::sin(0.372239857912064*x_9 - 1.00943982601166) + 0.00236340934959436*std::sin(0.677919805049896*x_9 - 6.93639993667603) + 0.00119391523561652*std::sin(0.372079849243164*x_92 + 1.99183976650238) - 0.0130993433246723*std::sin(0.325199842453003*x_93 + 1.97279977798462) - 0.0193920998212107*std::sin(0.332959830760956*x_93 + 1.98767983913422) + 0.000903049876893028*std::sin(0.351759850978851*x_93 + 1.96647977828979) + 0.003732266054237*std::sin(0.358479827642441*x_93 - 7.410719871521) - 0.0269830974612424*std::sin(0.362159848213196*x_93 - 7.41519975662231) + 0.00409287525425766*std::sin(0.395199835300446*x_94 - 7.40279960632324) + 0.000460743483403255*std::sin(0.279039949178696*x_95 - 7.51416015625) + 0.00301638388523739*std::sin(0.329999834299088*x_95 - 1.22255992889404) - 0.00597944649141368*std::sin(0.33111983537674*x_95 + 8.16551971435547) + 0.00230190751212188*std::sin(0.340319842100143*x_95 + 5.15104007720947) - 0.0175013303137986*std::sin(0.380959838628769*x_96 + 5.1799201965332) + 0.00413945667258716*std::sin(0.382799863815308*x_96 - 7.40703964233398) - 0.0101777881313695*std::sin(0.392399847507477*x_96 - 7.41631984710693) - 0.0119810984055194*std::sin(0.319759905338287*x_98 + 1.9171998500824) - 0.000897400617123214*std::sin(0.392799854278564*x_98 - 1.18863987922668) - 0.00176850870709337*std::sin(0.374879837036133*x_99 - 1.20063984394073) - 0.010896267192*std::sin(0.398159861564636*x_99 - 7.40623998641968) + 0.147101026722724);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00454667483577627*x_1 - 0.00188266332031201*x_10 + 0.00227586329415993*x_100 - 0.00133782537290175*x_101 - 0.000587682213221523*x_102 - 0.000199696458929014*x_103 - 0.00236218379876652*x_104 - 0.00163259964403379*x_105 - 0.00105375196967867*x_106 + 9.0817751105484e-5*x_107 + 9.85538935229499e-6*x_108 - 0.00149599682240552*x_109 + 0.000282466363085103*x_11 + 0.00173080058677391*x_110 - 0.00018106969564212*x_111 + 0.000142475711321009*x_112 - 0.000456256600930249*x_113 - 0.000746182542117559*x_114 + 0.00185880071500794*x_115 - 0.00575914851283008*x_116 + 0.00114792472553256*x_117 + 9.93240794299383e-5*x_118 + 0.000660214039362878*x_119 + 0.00755305547472278*x_12 - 0.000208837289791411*x_120 - 0.000425723421290551*x_13 + 0.00160891368988598*x_14 - 0.000446304743835149*x_15 - 0.00212661131700698*x_16 - 0.00369806534522498*x_17 - 0.000810459060422159*x_18 + 0.00122952084803961*x_19 + 0.00468293849796933*x_2 - 0.000565552416362308*x_20 + 0.000380631825907119*x_21 - 0.00244021010663759*x_22 - 1.99653290564382e-5*x_23 - 0.00195000723506754*x_24 - 0.00398720406975171*x_25 + 0.000435020281424873*x_26 - 0.00125657328638541*x_27 - 0.000995738981052668*x_28 - 0.000703441947370486*x_29 - 0.00162242824887489*x_3 + 0.000573403529652831*x_30 + 0.00232505476720635*x_31 + 0.00110625931226673*x_32 - 0.00215265676908712*x_33 + 0.000319816520186726*x_34 + 0.00047631108528383*x_35 - 0.000723239792429313*x_36 + 0.000402032365600818*x_37 + 0.000217736384758752*x_38 + 0.00324448184516461*x_39 + 0.00457746476922007*x_4 - 0.00250616156782998*x_40 + 0.00100248330499482*x_41 - 0.00167059059663702*x_42 - 6.20810664614809e-5*x_43 - 4.96677712427473e-5*x_44 + 0.000633060979139253*x_45 + 0.000125493436891468*x_46 - 0.00134063706495553*x_47 - 0.00141041142120093*x_48 + 0.00114510959570123*x_49 + 0.00160634332998304*x_5 + 0.0011515309433845*x_50 + 0.000131855450307025*x_51 - 0.00402581734010548*x_52 - 0.000268402266193125*x_53 - 0.000129991979098482*x_54 - 0.000225371516964434*x_55 - 0.000237105168480832*x_56 + 6.05385047118091e-5*x_57 - 0.00281647004392039*x_58 + 0.00190734849826631*x_59 - 0.00371798639047681*x_6 - 0.000853835650105016*x_60 + 0.000999506893127311*x_61 + 0.000350520103229875*x_62 + 0.00131381418533803*x_63 + 0.000113210067609449*x_64 - 9.57446401011984e-5*x_65 + 0.000877844835130785*x_66 + 0.00194599989218917*x_67 + 0.00212001537493715*x_68 + 0.000411263561086367*x_69 + 0.000186325930588951*x_7 + 0.00251568043064824*x_70 + 7.21458528292252e-5*x_71 + 0.000209194176070678*x_72 + 0.000670234427959074*x_73 + 0.00011747878877376*x_74 - 0.000249172832692831*x_75 - 0.000813226440992676*x_76 - 0.000269082352749501*x_77 - 0.000941684062015844*x_78 - 7.14130630846272e-5*x_79 - 0.00125518023411764*x_8 + 0.00035555004993115*x_80 - 0.00105001334430018*x_81 - 0.00184705824488516*x_82 - 0.000335020122361653*x_83 - 5.60216975088565e-5*x_84 + 0.00094206436516333*x_85 - 3.90331646397296e-5*x_86 - 0.000167690099610253*x_87 + 0.000715655331401724*x_88 + 0.00177934681828362*x_89 + 0.000999752676014742*x_9 - 0.00126301279352054*x_90 + 0.00867665889779219*x_91 - 0.000276828793170048*x_92 - 0.000699536697491122*x_94 - 2.95316659684426e-5*x_95 - 0.000484212305169499*x_96 + 0.00445158116107709*x_97 + 0.00153723810858961*x_98 + 0.000179270322067086*x_99 - 1.59327596051655e-5*std::pow(-7.84783983230591*x_108 - 9.05935955047607, 2) + 3.70048467362381e-6*std::pow(-4.29967975616455*x_14 - 6.14551973342896, 2) + 2.12638432979987e-5*std::pow(-5.92399978637695*x_17 - 9.46343994140625, 2) + 3.71876114462897e-5*std::pow(-6.35599994659424*x_23 - 8.75072002410889, 2) - 1.44644734892773e-5*std::pow(-6.58143997192383*x_37 - 9.56688022613525, 2) - 4.15970660602212e-7*std::pow(-8.35695934295654*x_38 - 9.16335964202881, 2) + 0.000158997541602949*std::pow(-5.15975999832153*x_4 - 8.7344799041748, 2) + 1.46750622426472e-5*std::pow(-5.26968002319336*x_44 - 9.51232051849365, 2) + 2.19620711956767e-5*std::pow(-5.72951984405518*x_46 - 7.57535982131958, 2) + 7.0496715080456e-6*std::pow(-5.29848003387451*x_47 - 9.61719989776611, 2) + 1.70533771765363e-5*std::pow(-6.17368030548096*x_5 - 9.76648044586182, 2) + 1.7235361850863e-5*std::pow(-7.51959991455078*x_50 - 9.97152042388916, 2) - 2.76939344220143e-6*std::pow(-4.18656015396118*x_50 - 5.98431968688965, 2) - 1.06624196869976e-5*std::pow(-4.89456033706665*x_53 - 9.16567993164063, 2) - 5.01089794222107e-6*std::pow(-3.0511200428009*x_54 - 3.61879992485046, 2) - 1.95067445966629e-5*std::pow(-5.50551986694336*x_55 - 7.75392007827759, 2) + 0.000171956493046216*std::pow(-1.89527988433838*x_56 - 2.83895993232727, 2) - 8.89607315989541e-6*std::pow(-6.54728031158447*x_58 - 9.33351993560791, 2) - 9.64688135873705e-7*std::pow(-7.056960105896*x_60 - 9.21016025543213, 2) - 1.89612155247106e-5*std::pow(-5.30559968948364*x_60 - 6.09144020080566, 2) + 1.30125371764351e-5*std::pow(-4.85904026031494*x_64 - 7.49032020568848, 2) - 4.39001815883822e-5*std::pow(-4.05999994277954*x_66 - 5.80347967147827, 2) - 1.4660370780297e-6*std::pow(-6.47735977172852*x_68 - 8.89960098266602, 2) - 0.000177256461902576*std::pow(-2.09295964241028*x_69 - 3.34831976890564, 2) + 4.21368017473791e-6*std::pow(-4.50415992736816*x_7 - 7.37455987930298, 2) + 0.00013584698579402*std::pow(-4.27399969100952*x_7 - 6.91639995574951, 2) + 0.000132269600451536*std::pow(-3.77760004997253*x_7 - 5.96271991729736, 2) - 1.02753408309179e-6*std::pow(-5.52303981781006*x_70 - 5.93503999710083, 2) - 2.39104692144474e-5*std::pow(-6.29328012466431*x_71 - 9.53400039672852, 2) + 4.23140697080412e-5*std::pow(-4.51783990859985*x_71 - 6.98280000686646, 2) + 2.51160955465211e-5*std::pow(-6.04655981063843*x_72 - 7.45879983901978, 2) - 3.32260290278382e-5*std::pow(-5.11975955963135*x_73 - 7.37648010253906, 2) + 9.47726762846901e-7*std::pow(-4.88303995132446*x_73 - 6.30624008178711, 2) - 1.38437131354052e-6*std::pow(-5.61847972869873*x_74 - 9.03551959991455, 2) + 2.14857358328176e-5*std::pow(-6.10015964508057*x_75 - 8.54423999786377, 2) + 2.33600612941641e-6*std::pow(-4.85663986206055*x_75 - 7.2629599571228, 2) + 2.05856154578394e-5*std::pow(-6.23928022384644*x_76 - 8.45512008666992, 2) + 3.28191825628e-6*std::pow(-5.75799989700317*x_77 - 6.99304008483887, 2) - 9.69866489409038e-6*std::pow(-6.51543998718262*x_79 - 9.14416027069092, 2) + 9.96806752831842e-6*std::pow(-4.61711978912354*x_80 - 6.62912034988403, 2) + 3.52056415188053e-6*std::pow(-9.80399990081787*x_81 - 9.96455955505371, 2) + 2.83482566025327e-6*std::pow(-5.51904010772705*x_82 - 7.76719999313354, 2) + 1.09741823986155e-5*std::pow(-6.52063989639282*x_83 - 9.15176010131836, 2) + 2.63129855204371e-5*std::pow(-5.5021595954895*x_83 - 7.13471984863281, 2) + 6.29776665931108e-7*std::pow(-7.79527997970581*x_85 - 9.79351997375488, 2) - 3.1182594303562e-5*std::pow(-3.08799982070923*x_86 - 4.93535995483398, 2) - 3.61092799235607e-6*std::pow(-7.49096012115479*x_87 - 9.92399978637695, 2) - 3.37538773519222e-5*std::pow(-5.73847961425781*x_87 - 7.79936027526855, 2) + 1.71948628722027e-6*std::pow(-4.00183963775635*x_87 - 5.6003999710083, 2) - 3.48582068026883e-5*std::pow(-6.34912014007568*x_89 - 9.13704013824463, 2) + 3.0162035582877e-5*std::pow(-5.6814398765564*x_90 - 8.55256080627441, 2) - 1.53538367383397e-5*std::pow(-5.93959999084473*x_99 - 7.78736019134521, 2) + 0.00165156452916106*std::exp(0.754959881305695*x_22) - 0.0153854955477411*std::sin(0.221119984984398*x_1 + 5.20879983901978) + 0.00609591411254813*std::sin(0.241199970245361*x_10 - 7.54232025146484) - 0.041782550746019*std::sin(0.34215983748436*x_10 - 1.05311977863312) - 0.0164053407141617*std::sin(0.320959836244583*x_101 + 5.14448022842407) - 0.00436565078500549*std::sin(0.403039842844009*x_102 + 1.98351979255676) - 0.0112727487666446*std::sin(0.376479834318161*x_104 + 5.18048000335693) - 0.0108012361478111*std::sin(0.388159841299057*x_104 - 7.40119981765747) - 0.000876373100942038*std::sin(0.322239845991135*x_105 - 1.24519991874695) + 0.0147274090740308*std::sin(0.388559848070145*x_105 + 1.97791981697083) - 0.00581226496556201*std::sin(0.345919847488403*x_106 + 1.94127976894379) - 0.011212308409359*std::sin(0.391999840736389*x_106 - 7.40279960632324) - 0.0190828735264395*std::sin(0.314319938421249*x_107 + 5.11247968673706) + 0.00603999457059143*std::sin(0.386559844017029*x_107 - 7.42159986495972) - 0.0226113608452349*std::sin(0.37951985001564*x_108 - 7.40759992599487) - 0.00979521991047707*std::sin(0.32151985168457*x_109 - 7.4521598815918) - 0.00845825548542687*std::sin(0.435439854860306*x_109 + 5.23640012741089) + 0.00170953918923652*std::sin(0.19743999838829*x_110 + 1.78303980827332) - 0.00436328541175031*std::sin(0.364959836006165*x_110 + 5.18104028701782) + 0.0333259005485465*std::sin(0.22647999227047*x_111 + 5.04263973236084) + 0.0110105068368443*std::sin(0.326559841632843*x_111 - 4.26839971542358) - 0.0244481969512257*std::sin(0.371999859809875*x_111 + 5.18032026290894) - 0.00153774177582036*std::sin(0.332879841327667*x_112 - 4.2545599937439) - 0.0173131083048013*std::sin(0.33519983291626*x_112 + 5.14775991439819) + 0.00737753912089096*std::sin(0.368799835443497*x_112 + 1.98655986785889) - 0.00656943151765264*std::sin(0.376959830522537*x_113 + 1.98927986621857) - 0.0297775549526257*std::sin(0.244079977273941*x_114 + 5.04392004013062) + 0.0115568435556999*std::sin(0.366399854421616*x_114 - 7.43375968933105) + 0.00895686934794462*std::sin(0.205520004034042*x_115 - 7.59376001358032) + 0.00185578287077775*std::sin(0.228079989552498*x_115 + 1.83607995510101) + 0.0217471912748956*std::sin(0.405839860439301*x_117 + 5.1910400390625) + 0.0114430966246994*std::sin(0.266799956560135*x_118 + 5.07727956771851) + 0.0114948355960575*std::sin(0.36575984954834*x_119 - 1.21287977695465) + 0.0162648879950484*std::sin(0.249359980225563*x_12 + 8.27031993865967) - 0.0163571870968137*std::sin(0.463279873132706*x_120 - 1.14679980278015) - 0.0810216398931215*std::sin(0.138080030679703*x_14 + 8.09639930725098) - 0.0336810001974788*std::sin(0.393119841814041*x_15 + 2.19063997268677) - 0.00893569384407576*std::sin(0.293359935283661*x_16 - 4.28935956954956) + 0.0300722343102288*std::sin(0.315119922161102*x_16 - 4.26247978210449) - 0.0119457769969186*std::sin(0.365359842777252*x_16 + 2.14367985725403) - 0.089789412078784*std::sin(0.181920006871223*x_19 - 4.4191198348999) + 0.0213837328746279*std::sin(0.296239942312241*x_21 - 4.29503965377808) + 0.0192627413260964*std::sin(0.318959832191467*x_21 + 5.13607978820801) + 0.00141422036766838*std::sin(0.363199830055237*x_21 - 4.21568012237549) - 0.0330687306666124*std::sin(0.134160041809082*x_23 - 4.49503993988037) + 0.00241205265000193*std::sin(0.29807984828949*x_23 - 4.32223987579346) + 0.0424714487962043*std::sin(0.317679941654205*x_24 + 8.35151958465576) + 0.00110212804038206*std::sin(0.465839862823486*x_24 + 8.48311996459961) - 0.00165913333593351*std::sin(0.297679930925369*x_26 + 5.10839986801147) - 0.079938347571658*std::sin(0.310239940881729*x_27 + 5.1334400177002) - 0.0114554426128355*std::sin(0.360559850931168*x_27 + 5.16951990127563) - 0.00226166241897274*std::sin(0.36287984251976*x_27 + 5.17112016677856) + 0.00809410194951893*std::sin(0.519679844379425*x_27 - 4.07424020767212) + 0.00137016697789355*std::sin(0.257439970970154*x_28 - 7.52328014373779) - 0.0323618120298346*std::sin(0.262639969587326*x_28 + 5.06967973709106) - 0.0161394570295099*std::sin(0.336719840764999*x_28 - 4.25856018066406) + 0.0010626191007593*std::sin(0.849039852619171*x_29 - 3.96919989585876) + 0.018551615126718*std::sin(0.32847985625267*x_3 - 1.05927979946136) + 0.0559371807081357*std::sin(0.372319847345352*x_3 - 1.03087985515594) + 0.0285350512352585*std::sin(0.268079966306686*x_32 - 7.42328023910522) - 0.00110942555095919*std::sin(0.302319914102554*x_33 - 1.18495988845825) + 0.0198223033495054*std::sin(0.348319828510284*x_34 + 1.97575974464417) - 0.00911669864788617*std::sin(0.357759833335876*x_34 + 1.97135984897614) + 0.0385647225309723*std::sin(0.361279845237732*x_34 + 1.99055981636047) + 0.0428203245101014*std::sin(0.29615992307663*x_35 + 8.26560020446777) + 0.0253243977439296*std::sin(0.309519916772842*x_35 + 8.2775993347168) + 0.0248284043127477*std::sin(0.31743985414505*x_35 - 1.20303988456726) + 0.00115990556543885*std::sin(0.332799851894379*x_35 - 1.22799980640411) + 0.0042414329196759*std::sin(0.313519924879074*x_36 - 4.28071975708008) - 0.0165351459464373*std::sin(0.317359834909439*x_36 + 1.92511987686157) + 0.00162767299650848*std::sin(0.340159833431244*x_36 + 5.15488004684448) - 0.0119352292459638*std::sin(0.351599842309952*x_37 + 5.16336011886597) + 0.00229091493953281*std::sin(0.3713598549366*x_37 + 5.17824029922485) - 0.0153105029246669*std::sin(0.377359837293625*x_37 + 5.18239974975586) + 0.0697022417305292*std::sin(0.149600028991699*x_38 + 4.92015981674194) + 0.0301231229740225*std::sin(0.320479840040207*x_38 - 7.46943950653076) - 0.0140967753160076*std::sin(0.3574398458004*x_38 + 5.16215991973877) - 0.0162112388114169*std::sin(0.353839844465256*x_39 - 7.44127988815308) + 0.0882951064817356*std::sin(0.132800042629242*x_40 + 4.9093599319458) - 0.0247169125202563*std::sin(0.315199851989746*x_41 + 5.12504005432129) - 0.000887811383038737*std::sin(0.309279918670654*x_43 + 5.13111972808838) - 0.0152569844632988*std::sin(0.331439822912216*x_43 + 5.13816022872925) + 0.0271153487159445*std::sin(0.34911984205246*x_43 + 5.14328002929688) + 0.0229567606486956*std::sin(0.307359933853149*x_44 - 7.48016023635864) + 0.0234749312719724*std::sin(0.27687993645668*x_45 - 7.51800012588501) - 0.00910937107885336*std::sin(0.298879951238632*x_45 - 7.48623991012573) + 0.0193827111887738*std::sin(0.321199834346771*x_45 - 7.46703958511353) + 0.0256102119686662*std::sin(0.298079937696457*x_47 + 5.12423944473267) - 0.0186721304961974*std::sin(0.306559920310974*x_47 + 5.11695957183838) + 0.0222458723718903*std::sin(0.251199960708618*x_48 + 5.06759977340698) + 0.0010847382603655*std::sin(0.273039966821671*x_49 + 1.8582398891449) + 0.0183615165459887*std::sin(0.314719915390015*x_49 - 7.46687984466553) + 0.000546052596049841*std::sin(1.0694397687912*x_5 - 6.76344013214111) + 0.00537236596087049*std::sin(0.367279857397079*x_50 + 5.15799999237061) - 0.010985739852445*std::sin(0.323439836502075*x_51 - 4.28312015533447) - 0.0296623962373585*std::sin(0.229279980063438*x_52 + 5.04008007049561) - 0.00311639080588241*std::sin(0.20728000998497*x_53 + 4.99191951751709) - 0.0117864035881757*std::sin(0.273679941892624*x_53 + 5.08431959152222) - 0.00713640264976743*std::sin(0.270639955997467*x_54 + 5.09176015853882) + 0.013985955111485*std::sin(0.22647999227047*x_56 + 5.04399967193604) - 0.0317639750175467*std::sin(0.157680034637451*x_57 + 4.92840003967285) - 0.0151277411605502*std::sin(0.266399949789047*x_57 - 7.50400018692017) + 0.000806164689615195*std::sin(0.347279846668243*x_59 - 4.26007986068726) + 0.0167001489269983*std::sin(0.374879837036133*x_59 + 1.95975983142853) + 0.0374505591235185*std::sin(0.247119963169098*x_60 - 7.52824020385742) - 0.00658311342111351*std::sin(0.218399986624718*x_63 + 8.20975971221924) + 0.0539069894664545*std::sin(0.149120032787323*x_65 + 4.93391990661621) - 0.0455402636570496*std::sin(0.282159924507141*x_65 + 5.1081600189209) - 0.0147220510051869*std::sin(0.287759929895401*x_65 + 5.12423992156982) - 0.120527933416123*std::sin(0.166320025920868*x_67 + 4.94535970687866) + 0.0184983986729941*std::sin(0.20320001244545*x_69 + 4.98776006698608) - 0.0124942370165141*std::sin(0.358319848775864*x_7 + 8.53191947937012) - 0.163821163916531*std::sin(0.121280059218407*x_74 + 4.8842396736145) - 0.012199736783888*std::sin(0.235679984092712*x_74 + 5.03487968444824) + 0.0212081917609848*std::sin(0.274879962205887*x_74 - 7.51688003540039) + 0.0566870050910448*std::sin(0.225279986858368*x_75 - 7.56712007522583) - 0.0443991993350905*std::sin(0.175280019640923*x_78 + 4.95191955566406) - 0.0349971583100999*std::sin(0.157200023531914*x_8 - 4.46224021911621) - 0.0386079197992767*std::sin(0.257999956607819*x_8 - 4.33247995376587) + 0.0050519460650505*std::sin(0.29887992143631*x_80 + 5.11567974090576) - 0.00758656191054376*std::sin(0.385439842939377*x_81 - 4.21808004379272) + 0.0065075289610547*std::sin(0.13728004693985*x_84 + 4.90903997421265) + 0.033097971376204*std::sin(0.294639945030212*x_84 - 7.47824001312256) + 0.0262864117303851*std::sin(0.186480015516281*x_85 - 7.60864019393921) - 0.00559505879460022*std::sin(0.333439826965332*x_88 - 4.27568006515503) - 0.00936596433667125*std::sin(0.129600048065186*x_9 - 4.49575996398926) - 0.0597735221476094*std::sin(0.222719997167587*x_9 - 4.3692798614502) + 0.0452945420294963*std::sin(0.372239857912064*x_9 - 1.00943982601166) + 0.0025946613033101*std::sin(0.677919805049896*x_9 - 6.93639993667603) + 0.0411178297639553*std::sin(0.372079849243164*x_92 + 1.99183976650238) - 0.00185979874928837*std::sin(0.325199842453003*x_93 + 1.97279977798462) - 0.0206842597165213*std::sin(0.332959830760956*x_93 + 1.98767983913422) + 0.0311005756512306*std::sin(0.351759850978851*x_93 + 1.96647977828979) - 0.0115454836464493*std::sin(0.358479827642441*x_93 - 7.410719871521) - 0.0296233061945647*std::sin(0.362159848213196*x_93 - 7.41519975662231) - 0.0126610010187629*std::sin(0.395199835300446*x_94 - 7.40279960632324) + 0.0158677697966088*std::sin(0.279039949178696*x_95 - 7.51416015625) + 0.0004282555879402*std::sin(0.329999834299088*x_95 - 1.22255992889404) - 0.00656451597314163*std::sin(0.33111983537674*x_95 + 8.16551971435547) - 0.00712077733758323*std::sin(0.340319842100143*x_95 + 5.15104007720947) - 0.0186675019689867*std::sin(0.380959838628769*x_96 + 5.1799201965332) - 0.0128050971243825*std::sin(0.382799863815308*x_96 - 7.40703964233398) - 0.011173651751139*std::sin(0.392399847507477*x_96 - 7.41631984710693) - 0.0131534100976994*std::sin(0.319759905338287*x_98 + 1.9171998500824) + 0.00277604114999988*std::sin(0.392799854278564*x_98 - 1.18863987922668) + 0.00547074834956372*std::sin(0.374879837036133*x_99 - 1.20063984394073) - 0.0116223215957985*std::sin(0.398159861564636*x_99 - 7.40623998641968) + 0.0457029059253863);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00314287446221112*x_1 - 0.00331457091384907*x_10 - 6.1511692681586e-6*x_100 + 0.000912059805831381*x_101 - 7.05613923932843e-5*x_102 + 0.00017101816609248*x_103 + 0.00107298745450918*x_104 + 0.00068824773399037*x_105 + 1.69757680261769e-6*x_106 + 4.41541917205128e-5*x_107 + 0.000111413119506699*x_108 + 0.000624791765589909*x_109 + 0.000140307794639323*x_11 + 0.000795255172532093*x_110 + 5.95221143849776e-5*x_111 - 0.000135812060194767*x_112 + 4.54771065707937e-5*x_113 + 0.00106314578286325*x_114 - 0.000792108413306066*x_115 + 0.00199551997989094*x_116 - 1.87106458756781e-5*x_117 + 3.0865577956055e-5*x_118 + 0.000286434681501732*x_119 - 0.00252023325036059*x_12 + 0.000271837551232702*x_120 - 0.00016481282467478*x_13 + 0.00132186677659597*x_14 + 0.000458717399613535*x_15 + 6.16435242516241e-5*x_16 + 4.04440291467456e-5*x_17 + 0.000237949831698344*x_18 + 0.000489095258753614*x_19 - 0.00431773156403791*x_2 - 0.000881057224701884*x_20 + 0.000278247424429676*x_21 + 0.00157832162923634*x_22 + 4.47780975418935e-5*x_23 + 0.000930444056651663*x_24 - 0.00140501793822882*x_25 - 0.00107730842171181*x_26 - 0.000571183557364979*x_27 + 0.000127052401822528*x_28 + 0.000380734358980881*x_29 + 0.000691534273504329*x_3 + 0.000700053449785415*x_30 + 0.000636223409223091*x_31 - 0.000909708384402338*x_32 - 0.000717787913851385*x_33 - 2.92350433518515e-6*x_34 - 0.000811868904620266*x_35 - 4.21674725068718e-5*x_36 + 0.000182746425733979*x_37 - 4.69950036754759e-6*x_38 - 0.0004821294180756*x_39 + 0.00209025318794535*x_4 - 0.00106342547230403*x_40 - 6.13452777348565e-6*x_41 - 0.00219130577482877*x_42 + 4.65060389756144e-5*x_43 - 0.000147725045328927*x_44 - 1.31143931311728e-5*x_45 - 0.00032933451621577*x_46 + 5.9434012954342e-6*x_47 - 0.00223524412535559*x_48 - 0.000176390206363082*x_49 + 0.000767184443786941*x_5 + 0.000519045746556439*x_50 + 8.50391433649653e-5*x_51 + 0.00196495523162716*x_52 - 6.60932747282429e-5*x_53 - 4.8704285052156e-5*x_54 + 0.000137781064905635*x_55 + 3.80926509254409e-5*x_56 + 8.88630976206269e-6*x_57 - 0.00099899948099206*x_58 - 0.000902706857984033*x_59 + 0.000600872050332388*x_6 + 0.00135934810078668*x_60 - 1.15913885355704e-5*x_61 - 7.20008862960724e-5*x_62 + 0.000716914230463388*x_63 + 5.29649317228963e-5*x_64 + 4.40193137018945e-5*x_65 - 0.000137149586953683*x_66 + 0.000116458089392921*x_67 - 0.000723969973776864*x_68 - 0.000172251266829257*x_69 - 0.000317591242033473*x_7 + 0.00103224041165021*x_70 + 7.51976508936608e-6*x_71 - 1.32477119461035e-6*x_72 - 1.91470839354837e-6*x_73 - 2.53559648119004e-6*x_74 + 0.000517467546773745*x_75 - 0.000332284837090835*x_76 - 1.18986757852734e-6*x_77 - 0.000271427176558544*x_78 + 8.0929225941975e-5*x_79 - 0.000316512647914707*x_8 + 3.75184607342621e-5*x_80 + 0.000401956410932161*x_81 + 0.00164499486631345*x_82 - 4.33921333541596e-5*x_83 - 0.000144255002143799*x_84 - 0.000486112274478792*x_85 - 0.000390104783498909*x_86 - 1.02285866694503e-5*x_87 + 0.000326739333010937*x_88 - 0.000926746600030963*x_89 - 0.00170407142526108*x_9 + 0.000586054583495937*x_90 - 0.00221736090401976*x_91 + 0.000698112665150154*x_92 + 6.58833842064674e-5*x_94 + 1.36617926649075e-5*x_95 - 1.78254570568815e-5*x_96 - 0.0019255281667773*x_97 - 6.0451078456476e-7*x_98 + 8.13707790855035e-5*x_99 - 7.24233947078213e-6*std::pow(-7.84783983230591*x_108 - 9.05935955047607, 2) + 2.22664116415964e-6*std::pow(-4.29967975616455*x_14 - 6.14551973342896, 2) - 9.83697359663934e-6*std::pow(-5.92399978637695*x_17 - 9.46343994140625, 2) + 1.69038705708116e-5*std::pow(-6.35599994659424*x_23 - 8.75072002410889, 2) + 3.12193107066405e-7*std::pow(-6.58143997192383*x_37 - 9.56688022613525, 2) - 2.50296238917411e-7*std::pow(-8.35695934295654*x_38 - 9.16335964202881, 2) - 3.43171402441588e-6*std::pow(-5.15975999832153*x_4 - 8.7344799041748, 2) + 6.67064495730238e-6*std::pow(-5.26968002319336*x_44 - 9.51232051849365, 2) - 1.01599843194724e-5*std::pow(-5.72951984405518*x_46 - 7.57535982131958, 2) - 1.20161156479471e-5*std::pow(-5.29848003387451*x_47 - 9.61719989776611, 2) - 2.9067361806498e-5*std::pow(-6.17368030548096*x_5 - 9.76648044586182, 2) - 7.97333751379842e-6*std::pow(-7.51959991455078*x_50 - 9.97152042388916, 2) - 1.6663885901521e-6*std::pow(-4.18656015396118*x_50 - 5.98431968688965, 2) + 4.93259564921429e-6*std::pow(-4.89456033706665*x_53 - 9.16567993164063, 2) - 3.01513791073913e-6*std::pow(-3.0511200428009*x_54 - 3.61879992485046, 2) - 8.86691758614598e-6*std::pow(-5.50551986694336*x_55 - 7.75392007827759, 2) + 7.81639419477672e-5*std::pow(-1.89527988433838*x_56 - 2.83895993232727, 2) + 4.11545718999439e-6*std::pow(-6.54728031158447*x_58 - 9.33351993560791, 2) - 5.80468371946887e-7*std::pow(-7.056960105896*x_60 - 9.21016025543213, 2) - 8.61894379954728e-6*std::pow(-5.30559968948364*x_60 - 6.09144020080566, 2) - 2.21797783636876e-5*std::pow(-4.85904026031494*x_64 - 7.49032020568848, 2) + 2.03088840112564e-5*std::pow(-4.05999994277954*x_66 - 5.80347967147827, 2) - 8.82138096501979e-7*std::pow(-6.47735977172852*x_68 - 8.89960098266602, 2) - 8.05730772509752e-5*std::pow(-2.09295964241028*x_69 - 3.34831976890564, 2) + 2.53543915383572e-6*std::pow(-4.50415992736816*x_7 - 7.37455987930298, 2) - 2.932045373935e-6*std::pow(-4.27399969100952*x_7 - 6.91639995574951, 2) + 6.01240068810285e-5*std::pow(-3.77760004997253*x_7 - 5.96271991729736, 2) - 6.18283789498492e-7*std::pow(-5.52303981781006*x_70 - 5.93503999710083, 2) - 1.08686592434729e-5*std::pow(-6.29328012466431*x_71 - 9.53400039672852, 2) - 1.95751248093299e-5*std::pow(-4.51783990859985*x_71 - 6.98280000686646, 2) - 1.16190834027192e-5*std::pow(-6.04655981063843*x_72 - 7.45879983901978, 2) - 1.51031075249294e-5*std::pow(-5.11975955963135*x_73 - 7.37648010253906, 2) + 5.70262440909976e-7*std::pow(-4.88303995132446*x_73 - 6.30624008178711, 2) - 8.32998492111697e-7*std::pow(-5.61847972869873*x_74 - 9.03551959991455, 2) - 9.93962441924535e-6*std::pow(-6.10015964508057*x_75 - 8.54423999786377, 2) + 1.40561247140476e-6*std::pow(-4.85663986206055*x_75 - 7.2629599571228, 2) + 9.3573253507395e-6*std::pow(-6.23928022384644*x_76 - 8.45512008666992, 2) - 5.59400665258831e-6*std::pow(-5.75799989700317*x_77 - 6.99304008483887, 2) + 2.09330559451509e-7*std::pow(-6.51543998718262*x_79 - 9.14416027069092, 2) + 4.5310499057776e-6*std::pow(-4.61711978912354*x_80 - 6.62912034988403, 2) + 1.60029532538222e-6*std::pow(-9.80399990081787*x_81 - 9.96455955505371, 2) + 1.70576020847415e-6*std::pow(-5.51904010772705*x_82 - 7.76719999313354, 2) - 1.87054169393471e-5*std::pow(-6.52063989639282*x_83 - 9.15176010131836, 2) - 1.21727826990549e-5*std::pow(-5.5021595954895*x_83 - 7.13471984863281, 2) + 3.78946752187515e-7*std::pow(-7.79527997970581*x_85 - 9.79351997375488, 2) + 5.31505133149806e-5*std::pow(-3.08799982070923*x_86 - 4.93535995483398, 2) + 6.15480144047007e-6*std::pow(-7.49096012115479*x_87 - 9.92399978637695, 2) + 1.5615051128895e-5*std::pow(-5.73847961425781*x_87 - 7.79936027526855, 2) + 1.03464256334382e-6*std::pow(-4.00183963775635*x_87 - 5.6003999710083, 2) + 7.52360042455876e-7*std::pow(-6.34912014007568*x_89 - 9.13704013824463, 2) + 1.3710349382927e-5*std::pow(-5.6814398765564*x_90 - 8.55256080627441, 2) + 3.31388626090398e-7*std::pow(-5.93959999084473*x_99 - 7.78736019134521, 2) + 0.000750729394938524*std::exp(0.754959881305695*x_22) + 0.0262244692666375*std::sin(0.221119984984398*x_1 + 5.20879983901978) + 0.00366800959693995*std::sin(0.241199970245361*x_10 - 7.54232025146484) + 0.000901811209943402*std::sin(0.34215983748436*x_10 - 1.05311977863312) + 0.00758935725717419*std::sin(0.320959836244583*x_101 + 5.14448022842407) + 0.00744122114786595*std::sin(0.403039842844009*x_102 + 1.98351979255676) - 0.00512410124548748*std::sin(0.376479834318161*x_104 + 5.18048000335693) + 0.0184106312676781*std::sin(0.388159841299057*x_104 - 7.40119981765747) - 0.000527327794553149*std::sin(0.322239845991135*x_105 - 1.24519991874695) + 0.00669443954985852*std::sin(0.388559848070145*x_105 + 1.97791981697083) + 0.00268884115640029*std::sin(0.345919847488403*x_106 + 1.94127976894379) + 0.0191113010547435*std::sin(0.391999840736389*x_106 - 7.40279960632324) - 0.00867424423523401*std::sin(0.314319938421249*x_107 + 5.11247968673706) - 0.0102951283886588*std::sin(0.386559844017029*x_107 - 7.42159986495972) + 0.0104603554729729*std::sin(0.37951985001564*x_108 - 7.40759992599487) + 0.0166958836460731*std::sin(0.32151985168457*x_109 - 7.4521598815918) - 0.00384475502512487*std::sin(0.435439854860306*x_109 + 5.23640012741089) + 0.00102865723445099*std::sin(0.19743999838829*x_110 + 1.78303980827332) + 0.00743718938574023*std::sin(0.364959836006165*x_110 + 5.18104028701782) - 0.000719287601152538*std::sin(0.22647999227047*x_111 + 5.04263973236084) - 0.0187673316895743*std::sin(0.326559841632843*x_111 - 4.26839971542358) - 0.0111130868824452*std::sin(0.371999859809875*x_111 + 5.18032026290894) - 0.000925283966799006*std::sin(0.332879841327667*x_112 - 4.2545599937439) + 0.000373676447930158*std::sin(0.33519983291626*x_112 + 5.14775991439819) - 0.0125749636947915*std::sin(0.368799835443497*x_112 + 1.98655986785889) + 0.0111975499521207*std::sin(0.376959830522537*x_113 + 1.98927986621857) - 0.0135355812126148*std::sin(0.244079977273941*x_114 + 5.04392004013062) - 0.00534636957791214*std::sin(0.366399854421616*x_114 - 7.43375968933105) - 0.0152669209913715*std::sin(0.205520004034042*x_115 - 7.59376001358032) + 0.00111665441050714*std::sin(0.228079989552498*x_115 + 1.83607995510101) + 0.00988532719076255*std::sin(0.405839860439301*x_117 + 5.1910400390625) + 0.00520153397194079*std::sin(0.266799956560135*x_118 + 5.07727956771851) + 0.00522505225777013*std::sin(0.36575984954834*x_119 - 1.21287977695465) - 0.0277233875261219*std::sin(0.249359980225563*x_12 + 8.27031993865967) - 0.00743526574667048*std::sin(0.463279873132706*x_120 - 1.14679980278015) + 0.0374818287181447*std::sin(0.138080030679703*x_14 + 8.09639930725098) - 0.0153099176282393*std::sin(0.393119841814041*x_15 + 2.19063997268677) + 0.0152308274935253*std::sin(0.293359935283661*x_16 - 4.28935956954956) - 0.0139118677068841*std::sin(0.315119922161102*x_16 - 4.26247978210449) - 0.00543003060348041*std::sin(0.365359842777252*x_16 + 2.14367985725403) + 0.00193796445887378*std::sin(0.181920006871223*x_19 - 4.4191198348999) - 0.00989243631724375*std::sin(0.296239942312241*x_21 - 4.29503965377808) - 0.000415756236801049*std::sin(0.318959832191467*x_21 + 5.13607978820801) + 0.000850959148213331*std::sin(0.363199830055237*x_21 - 4.21568012237549) + 0.0563654195188151*std::sin(0.134160041809082*x_23 - 4.49503993988037) + 0.0014513708863318*std::sin(0.29807984828949*x_23 - 4.32223987579346) + 0.0193056731928806*std::sin(0.317679941654205*x_24 + 8.35151958465576) + 0.000663168173720904*std::sin(0.465839862823486*x_24 + 8.48311996459961) - 0.000998327221553198*std::sin(0.297679930925369*x_26 + 5.10839986801147) + 0.0017253445913984*std::sin(0.310239940881729*x_27 + 5.1334400177002) + 0.0195257215995322*std::sin(0.360559850931168*x_27 + 5.16951990127563) - 0.0013608786647361*std::sin(0.36287984251976*x_27 + 5.17112016677856) - 0.003744453250999*std::sin(0.519679844379425*x_27 - 4.07424020767212) + 0.000824451514823415*std::sin(0.257439970970154*x_28 - 7.52328014373779) + 0.000698479253695797*std::sin(0.262639969587326*x_28 + 5.06967973709106) + 0.0275095913249762*std::sin(0.336719840764999*x_28 - 4.25856018066406) - 2.29349764400398e-5*std::sin(0.849039852619171*x_29 - 3.96919989585876) + 0.00843275727548351*std::sin(0.32847985625267*x_3 - 1.05927979946136) - 0.0012073168275882*std::sin(0.372319847345352*x_3 - 1.03087985515594) + 0.0129707930693251*std::sin(0.268079966306686*x_32 - 7.42328023910522) - 0.000667559203242724*std::sin(0.302319914102554*x_33 - 1.18495988845825) - 0.00917009554392325*std::sin(0.348319828510284*x_34 + 1.97575974464417) + 0.0155393489122805*std::sin(0.357759833335876*x_34 + 1.97135984897614) + 0.0175298453681101*std::sin(0.361279845237732*x_34 + 1.99055981636047) - 0.00092420993853045*std::sin(0.29615992307663*x_35 + 8.26560020446777) - 0.0117154471309179*std::sin(0.309519916772842*x_35 + 8.2775993347168) + 0.0112859126106725*std::sin(0.31743985414505*x_35 - 1.20303988456726) + 0.000697933840113659*std::sin(0.332799851894379*x_35 - 1.22799980640411) - 0.0072294926675193*std::sin(0.313519924879074*x_36 - 4.28071975708008) + 0.00764940710915559*std::sin(0.317359834909439*x_36 + 1.92511987686157) + 0.000979397029164749*std::sin(0.340159833431244*x_36 + 5.15488004684448) + 0.00552141648699197*std::sin(0.351599842309952*x_37 + 5.16336011886597) + 0.00137848037699253*std::sin(0.3713598549366*x_37 + 5.17824029922485) + 0.0260966448665113*std::sin(0.377359837293625*x_37 + 5.18239974975586) + 0.0316836071714374*std::sin(0.149600028991699*x_38 + 4.92015981674194) - 0.0139354095678305*std::sin(0.320479840040207*x_38 - 7.46943950653076) + 0.0240278546691082*std::sin(0.3574398458004*x_38 + 5.16215991973877) + 0.00749956279877834*std::sin(0.353839844465256*x_39 - 7.44127988815308) - 0.0408466437135114*std::sin(0.132800042629242*x_40 + 4.9093599319458) - 0.0112352332914937*std::sin(0.315199851989746*x_41 + 5.12504005432129) - 0.000534210392917984*std::sin(0.309279918670654*x_43 + 5.13111972808838) - 0.00693516148626476*std::sin(0.331439822912216*x_43 + 5.13816022872925) - 0.012543967976265*std::sin(0.34911984205246*x_43 + 5.14328002929688) - 0.0106201426148979*std::sin(0.307359933853149*x_44 - 7.48016023635864) - 0.010859856135558*std::sin(0.27687993645668*x_45 - 7.51800012588501) + 0.0155268591222504*std::sin(0.298879951238632*x_45 - 7.48623991012573) + 0.0088105373941446*std::sin(0.321199834346771*x_45 - 7.46703958511353) + 0.0116412883638585*std::sin(0.298079937696457*x_47 + 5.12423944473267) + 0.00863800828994001*std::sin(0.306559920310974*x_47 + 5.11695957183838) - 0.0102912750103406*std::sin(0.251199960708618*x_48 + 5.06759977340698) + 0.000652704463305738*std::sin(0.273039966821671*x_49 + 1.8582398891449) + 0.00834634672962245*std::sin(0.314719915390015*x_49 - 7.46687984466553) - 0.000252612140450837*std::sin(1.0694397687912*x_5 - 6.76344013214111) - 0.00915716010529558*std::sin(0.367279857397079*x_50 + 5.15799999237061) + 0.0187251165383501*std::sin(0.323439836502075*x_51 - 4.28312015533447) - 0.0134832350698465*std::sin(0.229279980063438*x_52 + 5.04008007049561) - 0.00187518248662035*std::sin(0.20728000998497*x_53 + 4.99191951751709) + 0.0200898422610562*std::sin(0.273679941892624*x_53 + 5.08431959152222) + 0.0121639482707889*std::sin(0.270639955997467*x_54 + 5.09176015853882) - 0.0238389624076528*std::sin(0.22647999227047*x_56 + 5.04399967193604) + 0.0541414726648954*std::sin(0.157680034637451*x_57 + 4.92840003967285) - 0.00687641310268114*std::sin(0.266399949789047*x_57 - 7.50400018692017) + 0.000485082263894725*std::sin(0.347279846668243*x_59 - 4.26007986068726) + 0.00759116127646388*std::sin(0.374879837036133*x_59 + 1.95975983142853) - 0.0173251916934557*std::sin(0.247119963169098*x_60 - 7.52824020385742) + 0.0112208706606221*std::sin(0.218399986624718*x_63 + 8.20975971221924) - 0.00116349831513772*std::sin(0.149120032787323*x_65 + 4.93391990661621) - 0.0207006229408211*std::sin(0.282159924507141*x_65 + 5.1081600189209) + 0.0250936326964183*std::sin(0.287759929895401*x_65 + 5.12423992156982) - 0.054786755787641*std::sin(0.166320025920868*x_67 + 4.94535970687866) - 0.0315303908136495*std::sin(0.20320001244545*x_69 + 4.98776006698608) + 0.00578002188593867*std::sin(0.358319848775864*x_7 + 8.53191947937012) - 0.0744659751972601*std::sin(0.121280059218407*x_74 + 4.8842396736145) + 0.0207943657945493*std::sin(0.235679984092712*x_74 + 5.03487968444824) - 0.00981122835893482*std::sin(0.274879962205887*x_74 - 7.51688003540039) + 0.0257674467339732*std::sin(0.225279986858368*x_75 - 7.56712007522583) + 0.0205397371232659*std::sin(0.175280019640923*x_78 + 4.95191955566406) + 0.059652410913577*std::sin(0.157200023531914*x_8 - 4.46224021911621) - 0.0175494809672796*std::sin(0.257999956607819*x_8 - 4.33247995376587) - 0.00861100663989197*std::sin(0.29887992143631*x_80 + 5.11567974090576) + 0.0129312415739321*std::sin(0.385439842939377*x_81 - 4.21808004379272) + 0.00391568487364*std::sin(0.13728004693985*x_84 + 4.90903997421265) + 0.0150448980867687*std::sin(0.294639945030212*x_84 - 7.47824001312256) - 0.0448050044546581*std::sin(0.186480015516281*x_85 - 7.60864019393921) + 0.00953673847870085*std::sin(0.333439826965332*x_88 - 4.27568006515503) - 0.0056356514276982*std::sin(0.129600048065186*x_9 - 4.49575996398926) + 0.0276521299985083*std::sin(0.222719997167587*x_9 - 4.3692798614502) - 0.000977612065853691*std::sin(0.372239857912064*x_9 - 1.00943982601166) + 0.00117942016549233*std::sin(0.677919805049896*x_9 - 6.93639993667603) - 0.000887464243987361*std::sin(0.372079849243164*x_92 + 1.99183976650238) - 0.0011190708292173*std::sin(0.325199842453003*x_93 + 1.97279977798462) + 0.00956884951821485*std::sin(0.332959830760956*x_93 + 1.98767983913422) - 0.000671257433000183*std::sin(0.351759850978851*x_93 + 1.96647977828979) + 0.0196791959098925*std::sin(0.358479827642441*x_93 - 7.410719871521) - 0.0134654664367374*std::sin(0.362159848213196*x_93 - 7.41519975662231) + 0.0215805874481673*std::sin(0.395199835300446*x_94 - 7.40279960632324) - 0.000342481069821869*std::sin(0.279039949178696*x_95 - 7.51416015625) + 0.000257688277345363*std::sin(0.329999834299088*x_95 - 1.22255992889404) - 0.00298394341702425*std::sin(0.33111983537674*x_95 + 8.16551971435547) + 0.0121373150357472*std::sin(0.340319842100143*x_95 + 5.15104007720947) + 0.00863586706366568*std::sin(0.380959838628769*x_96 + 5.1799201965332) + 0.0218261982496872*std::sin(0.382799863815308*x_96 - 7.40703964233398) - 0.00507905605277645*std::sin(0.392399847507477*x_96 - 7.41631984710693) - 0.00597896808127756*std::sin(0.319759905338287*x_98 + 1.9171998500824) - 0.00473174267251869*std::sin(0.392799854278564*x_98 - 1.18863987922668) - 0.00932485219689304*std::sin(0.374879837036133*x_99 - 1.20063984394073) + 0.00537666070367821*std::sin(0.398159861564636*x_99 - 7.40623998641968) - 0.0862080296087866);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00636112919009962*x_1 - 0.00201886654073059*x_10 + 0.000720166774491119*x_100 - 0.000295181029881025*x_101 + 1.56262422792133e-5*x_102 + 0.000522484523773027*x_103 + 0.00130509376352659*x_104 - 0.00040416289592352*x_105 + 0.000115105115432781*x_106 + 0.000427209552481856*x_107 + 0.0007898780358617*x_108 + 0.000979910641141946*x_109 + 0.00265652141734638*x_11 + 0.00144149429989005*x_110 + 0.000633880566520359*x_111 - 0.000195698193905961*x_112 - 0.00264576867987297*x_113 + 0.000208796483747002*x_114 - 0.00103834346560313*x_115 + 0.00151458614696266*x_116 - 0.00161794136962478*x_117 - 5.25615507547113e-5*x_118 - 0.00127538117140922*x_119 - 0.00525072233080251*x_12 + 0.00310331487408041*x_120 - 0.00156380580920101*x_13 + 0.000593248807208237*x_14 + 0.00312896756296579*x_15 - 0.000297672521708384*x_16 - 0.000692104397051201*x_17 - 9.03456618644015e-5*x_18 + 0.00085192384051838*x_19 - 0.00329282691175133*x_2 + 0.00724742080564437*x_20 + 0.00032310522962847*x_21 + 0.00483593511663591*x_22 + 5.1776018352298e-5*x_23 + 0.000382321388395007*x_24 + 0.00060332444531293*x_25 + 0.000167730782123806*x_26 - 0.000973115982875806*x_27 + 0.000113332792386384*x_28 + 0.00437895252330044*x_29 + 0.00114645860564103*x_3 + 0.000734500483811165*x_30 + 0.00851082184311731*x_31 + 0.000738950208282962*x_32 - 0.00128732018705523*x_33 - 0.000192981290507753*x_34 + 9.19412946180027e-5*x_35 - 1.13068077288593e-5*x_36 + 0.000311342064039018*x_37 - 2.99044685511102e-5*x_38 + 0.000466159287819506*x_39 + 0.00160313510016838*x_4 - 0.0019918374891051*x_40 - 0.000361702976719655*x_41 + 0.000877435928972037*x_42 - 3.40145745528538e-7*x_43 + 7.49832345212033e-5*x_44 - 0.000107520037782791*x_45 + 8.34207227403593e-5*x_46 + 0.00104538201998583*x_47 - 0.00704719428057995*x_48 - 0.000210839570589067*x_49 + 0.00239487427104011*x_5 + 0.000883362364792101*x_50 - 0.000381684142828465*x_51 + 0.00260528861244206*x_52 - 0.000100792449910797*x_53 - 5.86832186130922e-5*x_54 + 0.000156392441561207*x_55 + 0.000317290234561806*x_56 + 5.96999220009176e-5*x_57 - 0.00187049566120752*x_58 - 0.00078605739554665*x_59 - 0.00056068555147362*x_6 - 0.000145966650061313*x_60 - 0.000162671290231217*x_61 - 0.000216101138803722*x_62 + 0.00131222859850038*x_63 - 0.0014270680712952*x_64 + 6.57153065186298e-5*x_65 - 0.00122216074674732*x_66 - 0.0032339618011773*x_67 + 0.000187461325399466*x_68 - 0.000670236277198465*x_69 + 3.596608982771e-5*x_7 + 0.00180664987884705*x_70 - 8.29989378434062e-6*x_71 + 0.0028250481273321*x_72 - 0.000124940498303048*x_73 - 1.6134835471802e-5*x_74 - 6.63057797372316e-5*x_75 - 0.000483222774065046*x_76 + 1.62657800353549e-5*x_77 - 0.000434456359385811*x_78 - 0.000724989280005798*x_79 + 0.00018260972196371*x_8 - 0.000997407100178036*x_80 + 0.000663953343565935*x_81 + 0.000657381698153215*x_82 - 0.00222372671743061*x_83 - 0.000822818334093533*x_84 - 0.000664487478325825*x_85 + 0.00256074934264444*x_86 - 3.48646434797856e-6*x_87 + 0.000551124894904823*x_88 - 0.00109575015416705*x_89 + 0.00019298008837194*x_9 + 0.000870797352407996*x_90 + 0.00609847763022382*x_91 + 0.00152580786151826*x_92 + 0.000133776823240992*x_94 + 1.84568120003787e-5*x_95 + 0.00112569997046501*x_96 + 0.00201522048598549*x_97 - 0.000295476825091218*x_98 + 0.000158235694604579*x_99 - 1.23386540133315e-5*std::pow(-7.84783983230591*x_108 - 9.05935955047607, 2) - 8.6907024753987e-5*std::pow(-4.29967975616455*x_14 - 6.14551973342896, 2) - 1.32895569987843e-5*std::pow(-5.92399978637695*x_17 - 9.46343994140625, 2) + 2.8798844807099e-5*std::pow(-6.35599994659424*x_23 - 8.75072002410889, 2) + 1.9865875565433e-6*std::pow(-6.58143997192383*x_37 - 9.56688022613525, 2) + 9.76919935800924e-6*std::pow(-8.35695934295654*x_38 - 9.16335964202881, 2) - 2.18371265226866e-5*std::pow(-5.15975999832153*x_4 - 8.7344799041748, 2) + 1.1364667522971e-5*std::pow(-5.26968002319336*x_44 - 9.51232051849365, 2) - 1.37259381042266e-5*std::pow(-5.72951984405518*x_46 - 7.57535982131958, 2) + 1.3607827848372e-6*std::pow(-5.29848003387451*x_47 - 9.61719989776611, 2) + 3.29177636981836e-6*std::pow(-6.17368030548096*x_5 - 9.76648044586182, 2) - 1.07718214671603e-5*std::pow(-7.51959991455078*x_50 - 9.97152042388916, 2) + 6.50400597928259e-5*std::pow(-4.18656015396118*x_50 - 5.98431968688965, 2) + 6.66383927822919e-6*std::pow(-4.89456033706665*x_53 - 9.16567993164063, 2) + 0.000117682484839979*std::pow(-3.0511200428009*x_54 - 3.61879992485046, 2) - 1.51064208881063e-5*std::pow(-5.50551986694336*x_55 - 7.75392007827759, 2) + 0.000133166615553231*std::pow(-1.89527988433838*x_56 - 2.83895993232727, 2) + 5.55990136246497e-6*std::pow(-6.54728031158447*x_58 - 9.33351993560791, 2) + 2.2655998632242e-5*std::pow(-7.056960105896*x_60 - 9.21016025543213, 2) - 1.46839520478151e-5*std::pow(-5.30559968948364*x_60 - 6.09144020080566, 2) + 2.51178179813601e-6*std::pow(-4.85904026031494*x_64 - 7.49032020568848, 2) + 2.74369010954239e-5*std::pow(-4.05999994277954*x_66 - 5.80347967147827, 2) + 3.44303332854561e-5*std::pow(-6.47735977172852*x_68 - 8.89960098266602, 2) - 0.000137271019537262*std::pow(-2.09295964241028*x_69 - 3.34831976890564, 2) - 9.89595795008985e-5*std::pow(-4.50415992736816*x_7 - 7.37455987930298, 2) - 1.8657570341041e-5*std::pow(-4.27399969100952*x_7 - 6.91639995574951, 2) + 0.000102432276447829*std::pow(-3.77760004997253*x_7 - 5.96271991729736, 2) + 2.41319551007286e-5*std::pow(-5.52303981781006*x_70 - 5.93503999710083, 2) - 1.85167550533954e-5*std::pow(-6.29328012466431*x_71 - 9.53400039672852, 2) - 2.64456069090985e-5*std::pow(-4.51783990859985*x_71 - 6.98280000686646, 2) - 1.56971521410627e-5*std::pow(-6.04655981063843*x_72 - 7.45879983901978, 2) - 2.57309145791979e-5*std::pow(-5.11975955963135*x_73 - 7.37648010253906, 2) - 2.22576555513995e-5*std::pow(-4.88303995132446*x_73 - 6.30624008178711, 2) + 3.25123875994214e-5*std::pow(-5.61847972869873*x_74 - 9.03551959991455, 2) - 1.3428236232249e-5*std::pow(-6.10015964508057*x_75 - 8.54423999786377, 2) - 5.48618249824687e-5*std::pow(-4.85663986206055*x_75 - 7.2629599571228, 2) + 1.59419204883643e-5*std::pow(-6.23928022384644*x_76 - 8.45512008666992, 2) + 6.3350155525571e-7*std::pow(-5.75799989700317*x_77 - 6.99304008483887, 2) + 1.33203928977894e-6*std::pow(-6.51543998718262*x_79 - 9.14416027069092, 2) + 7.71947480922083e-6*std::pow(-4.61711978912354*x_80 - 6.62912034988403, 2) + 2.7263966869687e-6*std::pow(-9.80399990081787*x_81 - 9.96455955505371, 2) - 6.65767556301231e-5*std::pow(-5.51904010772705*x_82 - 7.76719999313354, 2) + 2.11832260108236e-6*std::pow(-6.52063989639282*x_83 - 9.15176010131836, 2) - 1.64451889520341e-5*std::pow(-5.5021595954895*x_83 - 7.13471984863281, 2) - 1.47904993866547e-5*std::pow(-7.79527997970581*x_85 - 9.79351997375488, 2) - 6.0191084742633e-6*std::pow(-3.08799982070923*x_86 - 4.93535995483398, 2) - 6.97009590259211e-7*std::pow(-7.49096012115479*x_87 - 9.92399978637695, 2) + 2.10956255984336e-5*std::pow(-5.73847961425781*x_87 - 7.79936027526855, 2) - 4.03826661930892e-5*std::pow(-4.00183963775635*x_87 - 5.6003999710083, 2) + 4.78751472903378e-6*std::pow(-6.34912014007568*x_89 - 9.13704013824463, 2) + 2.33580955601853e-5*std::pow(-5.6814398765564*x_90 - 8.55256080627441, 2) + 2.10873496585924e-6*std::pow(-5.93959999084473*x_99 - 7.78736019134521, 2) + 0.00127900525778362*std::exp(0.754959881305695*x_22) - 0.0029698288003436*std::sin(0.221119984984398*x_1 + 5.20879983901978) - 0.143164424501885*std::sin(0.241199970245361*x_10 - 7.54232025146484) + 0.00573852172733511*std::sin(0.34215983748436*x_10 - 1.05311977863312) + 0.0102530717260246*std::sin(0.320959836244583*x_101 + 5.14448022842407) - 0.000842692092257991*std::sin(0.403039842844009*x_102 + 1.98351979255676) - 0.00872984657132117*std::sin(0.376479834318161*x_104 + 5.18048000335693) - 0.00208493916179328*std::sin(0.388159841299057*x_104 - 7.40119981765747) + 0.0205818927774975*std::sin(0.322239845991135*x_105 - 1.24519991874695) + 0.0114052059768951*std::sin(0.388559848070145*x_105 + 1.97791981697083) + 0.0036325712840041*std::sin(0.345919847488403*x_106 + 1.94127976894379) - 0.00216428754791314*std::sin(0.391999840736389*x_106 - 7.40279960632324) - 0.0147781664857709*std::sin(0.314319938421249*x_107 + 5.11247968673706) + 0.00116588703782733*std::sin(0.386559844017029*x_107 - 7.42159986495972) + 0.0141317335987474*std::sin(0.37951985001564*x_108 - 7.40759992599487) - 0.00189075003177944*std::sin(0.32151985168457*x_109 - 7.4521598815918) - 0.00655024556808168*std::sin(0.435439854860306*x_109 + 5.23640012741089) - 0.0401490555266634*std::sin(0.19743999838829*x_110 + 1.78303980827332) - 0.000842235509394278*std::sin(0.364959836006165*x_110 + 5.18104028701782) - 0.00457706389309093*std::sin(0.22647999227047*x_111 + 5.04263973236084) + 0.00212533422852547*std::sin(0.326559841632843*x_111 - 4.26839971542358) - 0.0189331823806068*std::sin(0.371999859809875*x_111 + 5.18032026290894) + 0.036114340245487*std::sin(0.332879841327667*x_112 - 4.2545599937439) + 0.0023778263031075*std::sin(0.33519983291626*x_112 + 5.14775991439819) + 0.00142407035827328*std::sin(0.368799835443497*x_112 + 1.98655986785889) - 0.00126808310219649*std::sin(0.376959830522537*x_113 + 1.98927986621857) - 0.0230603459179977*std::sin(0.244079977273941*x_114 + 5.04392004013062) - 0.00722283968175975*std::sin(0.366399854421616*x_114 - 7.43375968933105) + 0.0017289250429341*std::sin(0.205520004034042*x_115 - 7.59376001358032) - 0.0435836335273261*std::sin(0.228079989552498*x_115 + 1.83607995510101) + 0.0168414684933604*std::sin(0.405839860439301*x_117 + 5.1910400390625) + 0.00886176742712623*std::sin(0.266799956560135*x_118 + 5.07727956771851) + 0.00890183514184818*std::sin(0.36575984954834*x_119 - 1.21287977695465) + 0.00313957601509622*std::sin(0.249359980225563*x_12 + 8.27031993865967) - 0.0126673393197675*std::sin(0.463279873132706*x_120 - 1.14679980278015) + 0.0506372101414023*std::sin(0.138080030679703*x_14 + 8.09639930725098) - 0.0260832535328601*std::sin(0.393119841814041*x_15 + 2.19063997268677) - 0.00172483758139889*std::sin(0.293359935283661*x_16 - 4.28935956954956) - 0.0187946584418347*std::sin(0.315119922161102*x_16 - 4.26247978210449) - 0.00925105336037378*std::sin(0.365359842777252*x_16 + 2.14367985725403) + 0.0123319060923498*std::sin(0.181920006871223*x_19 - 4.4191198348999) - 0.0133644860386499*std::sin(0.296239942312241*x_21 - 4.29503965377808) - 0.00264559385806219*std::sin(0.318959832191467*x_21 + 5.13607978820801) - 0.0332134018488421*std::sin(0.363199830055237*x_21 - 4.21568012237549) - 0.00638318528121312*std::sin(0.134160041809082*x_23 - 4.49503993988037) - 0.0566478009909866*std::sin(0.29807984828949*x_23 - 4.32223987579346) + 0.0328907562235105*std::sin(0.317679941654205*x_24 + 8.35151958465576) - 0.0258838172119084*std::sin(0.465839862823486*x_24 + 8.48311996459961) + 0.0389652585035397*std::sin(0.297679930925369*x_26 + 5.10839986801147) + 0.010978935852329*std::sin(0.310239940881729*x_27 + 5.1334400177002) - 0.0022112192153133*std::sin(0.360559850931168*x_27 + 5.16951990127563) + 0.0531158399957227*std::sin(0.36287984251976*x_27 + 5.17112016677856) - 0.00505868237009753*std::sin(0.519679844379425*x_27 - 4.07424020767212) - 0.032178794392433*std::sin(0.257439970970154*x_28 - 7.52328014373779) + 0.00444465352529572*std::sin(0.262639969587326*x_28 + 5.06967973709106) - 0.00311536434815605*std::sin(0.336719840764999*x_28 - 4.25856018066406) - 0.000145942808390403*std::sin(0.849039852619171*x_29 - 3.96919989585876) + 0.0143667491451293*std::sin(0.32847985625267*x_3 - 1.05927979946136) - 0.00768255458626088*std::sin(0.372319847345352*x_3 - 1.03087985515594) + 0.0220981256963418*std::sin(0.268079966306686*x_32 - 7.42328023910522) + 0.0260552015002664*std::sin(0.302319914102554*x_33 - 1.18495988845825) - 0.0123886179237992*std::sin(0.348319828510284*x_34 + 1.97575974464417) - 0.00175977654567786*std::sin(0.357759833335876*x_34 + 1.97135984897614) + 0.0298653077195448*std::sin(0.361279845237732*x_34 + 1.99055981636047) - 0.00588105221403146*std::sin(0.29615992307663*x_35 + 8.26560020446777) - 0.0158273376341854*std::sin(0.309519916772842*x_35 + 8.2775993347168) + 0.0192276227163299*std::sin(0.31743985414505*x_35 - 1.20303988456726) - 0.0272407402215143*std::sin(0.332799851894379*x_35 - 1.22799980640411) + 0.000818714587417258*std::sin(0.313519924879074*x_36 - 4.28071975708008) + 0.0103341978897614*std::sin(0.317359834909439*x_36 + 1.92511987686157) - 0.0382264027215746*std::sin(0.340159833431244*x_36 + 5.15488004684448) + 0.00745932459785957*std::sin(0.351599842309952*x_37 + 5.16336011886597) - 0.0538028444701773*std::sin(0.3713598549366*x_37 + 5.17824029922485) - 0.00295535313713677*std::sin(0.377359837293625*x_37 + 5.18239974975586) + 0.0539788376890953*std::sin(0.149600028991699*x_38 + 4.92015981674194) - 0.0188264630309017*std::sin(0.320479840040207*x_38 - 7.46943950653076) - 0.00272106993210229*std::sin(0.3574398458004*x_38 + 5.16215991973877) + 0.0101317611866292*std::sin(0.353839844465256*x_39 - 7.44127988815308) - 0.0551830087279277*std::sin(0.132800042629242*x_40 + 4.9093599319458) - 0.0191412811981643*std::sin(0.315199851989746*x_41 + 5.12504005432129) + 0.0208505243630858*std::sin(0.309279918670654*x_43 + 5.13111972808838) - 0.0118153199599137*std::sin(0.331439822912216*x_43 + 5.13816022872925) - 0.0169466529287474*std::sin(0.34911984205246*x_43 + 5.14328002929688) - 0.014347602870879*std::sin(0.307359933853149*x_44 - 7.48016023635864) - 0.0146714511017292*std::sin(0.27687993645668*x_45 - 7.51800012588501) - 0.00175836212093719*std::sin(0.298879951238632*x_45 - 7.48623991012573) + 0.0150103668871697*std::sin(0.321199834346771*x_45 - 7.46703958511353) + 0.0198330705113386*std::sin(0.298079937696457*x_47 + 5.12423944473267) + 0.0116697785550982*std::sin(0.306559920310974*x_47 + 5.11695957183838) - 0.0139033092339304*std::sin(0.251199960708618*x_48 + 5.06759977340698) - 0.0254754128606789*std::sin(0.273039966821671*x_49 + 1.8582398891449) + 0.0142195329268363*std::sin(0.314719915390015*x_49 - 7.46687984466553) - 0.000341274011374108*std::sin(1.0694397687912*x_5 - 6.76344013214111) + 0.00103701613685893*std::sin(0.367279857397079*x_50 + 5.15799999237061) - 0.00212055351130135*std::sin(0.323439836502075*x_51 - 4.28312015533447) - 0.0229711646600416*std::sin(0.229279980063438*x_52 + 5.04008007049561) + 0.0731893999832988*std::sin(0.20728000998497*x_53 + 4.99191951751709) - 0.00227510389379539*std::sin(0.273679941892624*x_53 + 5.08431959152222) - 0.00137752430881171*std::sin(0.270639955997467*x_54 + 5.09176015853882) + 0.00269967854863792*std::sin(0.22647999227047*x_56 + 5.04399967193604) - 0.00613133113118055*std::sin(0.157680034637451*x_57 + 4.92840003967285) - 0.0117152313101335*std::sin(0.266399949789047*x_57 - 7.50400018692017) - 0.0189330265669141*std::sin(0.347279846668243*x_59 - 4.26007986068726) + 0.0129329359563385*std::sin(0.374879837036133*x_59 + 1.95975983142853) - 0.0234059917171785*std::sin(0.247119963169098*x_60 - 7.52824020385742) - 0.00127072409031517*std::sin(0.218399986624718*x_63 + 8.20975971221924) - 0.00740372296054587*std::sin(0.149120032787323*x_65 + 4.93391990661621) - 0.0352673090453244*std::sin(0.282159924507141*x_65 + 5.1081600189209) - 0.00284176554077589*std::sin(0.287759929895401*x_65 + 5.12423992156982) - 0.0933392900048067*std::sin(0.166320025920868*x_67 + 4.94535970687866) + 0.00357070573182555*std::sin(0.20320001244545*x_69 + 4.98776006698608) + 0.00780869538306424*std::sin(0.358319848775864*x_7 + 8.53191947937012) - 0.126866450741655*std::sin(0.121280059218407*x_74 + 4.8842396736145) - 0.00235488870312801*std::sin(0.235679984092712*x_74 + 5.03487968444824) - 0.0132547756912449*std::sin(0.274879962205887*x_74 - 7.51688003540039) + 0.0438995729681131*std::sin(0.225279986858368*x_75 - 7.56712007522583) + 0.0277487790892253*std::sin(0.175280019640923*x_78 + 4.95191955566406) - 0.00675542548220221*std::sin(0.157200023531914*x_8 - 4.46224021911621) - 0.0298987605651997*std::sin(0.257999956607819*x_8 - 4.33247995376587) + 0.000975166180069662*std::sin(0.29887992143631*x_80 + 5.11567974090576) - 0.00146441757352629*std::sin(0.385439842939377*x_81 - 4.21808004379272) - 0.152831326268361*std::sin(0.13728004693985*x_84 + 4.90903997421265) + 0.0256317441218238*std::sin(0.294639945030212*x_84 - 7.47824001312256) + 0.00507400898283377*std::sin(0.186480015516281*x_85 - 7.60864019393921) - 0.0010800020510395*std::sin(0.333439826965332*x_88 - 4.27568006515503) + 0.21996256335118*std::sin(0.129600048065186*x_9 - 4.49575996398926) + 0.0373574813577332*std::sin(0.222719997167587*x_9 - 4.3692798614502) - 0.00622086753740669*std::sin(0.372239857912064*x_9 - 1.00943982601166) + 0.00200935863570953*std::sin(0.677919805049896*x_9 - 6.93639993667603) - 0.0056472272579913*std::sin(0.372079849243164*x_92 + 1.99183976650238) + 0.0436779476736915*std::sin(0.325199842453003*x_93 + 1.97279977798462) + 0.0129273266656474*std::sin(0.332959830760956*x_93 + 1.98767983913422) - 0.00427143211509701*std::sin(0.351759850978851*x_93 + 1.96647977828979) - 0.00222859964053322*std::sin(0.358479827642441*x_93 - 7.410719871521) - 0.0229408925335957*std::sin(0.362159848213196*x_93 - 7.41519975662231) - 0.00244392553688155*std::sin(0.395199835300446*x_94 - 7.40279960632324) - 0.00217931983845833*std::sin(0.279039949178696*x_95 - 7.51416015625) - 0.0100577146684153*std::sin(0.329999834299088*x_95 - 1.22255992889404) - 0.00508369506380574*std::sin(0.33111983537674*x_95 + 8.16551971435547) - 0.00137450818872672*std::sin(0.340319842100143*x_95 + 5.15104007720947) + 0.0116668858007017*std::sin(0.380959838628769*x_96 + 5.1799201965332) - 0.00247174009528549*std::sin(0.382799863815308*x_96 - 7.40703964233398) - 0.00865310382126539*std::sin(0.392399847507477*x_96 - 7.41631984710693) - 0.010186269065301*std::sin(0.319759905338287*x_98 + 1.9171998500824) + 0.000535853195799017*std::sin(0.392799854278564*x_98 - 1.18863987922668) + 0.00105600667573895*std::sin(0.374879837036133*x_99 - 1.20063984394073) + 0.00726376239426587*std::sin(0.398159861564636*x_99 - 7.40623998641968) - 0.509928692083855);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00336688444465019*x_1 - 0.00186567846729926*x_10 + 0.0017717404168671*x_100 - 0.000234868339930902*x_101 - 0.000236695967374681*x_102 + 3.59645185806389e-5*x_103 + 0.000614239783034268*x_104 - 0.000611013717005244*x_105 - 0.000214149571094084*x_106 - 3.11486146591436e-5*x_107 - 0.000212869355845981*x_108 + 0.00028407529494054*x_109 + 0.000383989135571849*x_11 + 0.00116825072916846*x_110 - 0.000108814843168167*x_111 - 0.000106238697033143*x_112 + 0.000583424602018915*x_113 - 0.000157645105281781*x_114 - 0.000401535445820616*x_115 + 0.000211583102401769*x_116 - 0.000249622579235523*x_117 + 1.95880736944986e-5*x_118 - 0.000428660325857716*x_119 - 0.000809077396328566*x_12 - 0.000862947725724323*x_120 + 0.000271853891171891*x_13 + 0.000863781375268999*x_14 - 0.000632584821432067*x_15 - 0.000223160860900903*x_16 - 0.000507014870999325*x_17 + 9.75009263505232e-5*x_18 + 0.000853643093456096*x_19 - 0.00135615075687709*x_2 - 0.000224347902210503*x_20 + 0.000282668943872645*x_21 - 0.00169409374344811*x_22 + 3.99969525108529e-5*x_23 - 9.43353202596471e-5*x_24 - 0.00415017276531128*x_25 + 3.03219829516027e-5*x_26 - 0.000838803210969092*x_27 - 8.27890567264022e-5*x_28 - 0.000926240129417895*x_29 + 0.000396737192126397*x_3 + 0.000534630870568104*x_30 - 0.00294351131377044*x_31 + 5.29313389904704e-5*x_32 - 0.00119484407467461*x_33 + 9.82829079715853e-5*x_34 + 3.85984138512517e-5*x_35 - 0.000189602879650772*x_36 + 0.0002683695752832*x_37 + 3.92865445036483e-5*x_38 + 0.000702401557830153*x_39 + 0.00295780018982377*x_4 - 0.0016207665001086*x_40 + 4.39752320137268e-5*x_41 - 0.000544463888263045*x_42 - 8.53380299048323e-6*x_43 - 2.83477817622756e-5*x_44 + 0.000119825095242063*x_45 - 4.96478310412021e-5*x_46 - 0.00047635368820603*x_47 - 0.000149604684272898*x_48 + 0.000138504495579205*x_49 + 0.000858495235739325*x_5 + 0.000764192867310364*x_50 + 0.000228776507427214*x_51 + 0.000995466266632581*x_52 - 0.000121969400445372*x_53 - 7.50611590588535e-5*x_54 + 2.38540522509749e-5*x_55 - 6.96809040029931e-5*x_56 + 7.38608059880997e-6*x_57 - 0.00160292627725337*x_58 - 0.00019874704165154*x_59 - 0.000753112339579053*x_6 - 7.4861993403292e-5*x_60 + 0.000177795723065272*x_61 - 7.88033326565527e-6*x_62 + 0.000975721404577447*x_63 + 0.000429761105382039*x_64 + 2.24936229616172e-5*x_65 + 0.000838635059539794*x_66 + 0.00115489525092024*x_67 + 0.000509081231896003*x_68 + 1.70695613329416e-5*x_69 + 1.50991350029285e-5*x_7 + 0.00157455124596864*x_70 + 1.26309601809047e-5*x_71 - 0.00057950223231113*x_72 + 0.000100079109316701*x_73 + 2.11968967359716e-5*x_74 - 1.47137821045592e-5*x_75 - 0.000511583935739896*x_76 - 5.89167319165587e-5*x_77 - 0.000501759186032504*x_78 + 0.000218031840262606*x_79 - 0.000657500002566997*x_8 + 0.000347167066507673*x_80 + 0.000159461583582674*x_81 + 0.000268256006425928*x_82 + 0.000394044799862421*x_83 - 0.00062841390560076*x_84 - 0.000288936898970698*x_85 - 0.00111548501919764*x_86 - 4.44233003024504e-5*x_87 + 0.000482622343999838*x_88 - 0.000534630740984537*x_89 + 8.10161021440821e-5*x_9 + 0.000312975806854302*x_90 + 0.000755772170985664*x_91 - 0.000537960822565003*x_92 - 5.30310669144851e-5*x_94 + 7.4763129344555e-6*x_95 - 0.000375713291671934*x_96 + 0.00153284308297253*x_97 + 0.000338150749783106*x_98 + 0.000114974225139892*x_99 - 1.06356310938735e-5*std::pow(-7.84783983230591*x_108 - 9.05935955047607, 2) + 2.41880960913511e-5*std::pow(-4.29967975616455*x_14 - 6.14551973342896, 2) - 5.38320956409784e-6*std::pow(-5.92399978637695*x_17 - 9.46343994140625, 2) + 2.48239304681919e-5*std::pow(-6.35599994659424*x_23 - 8.75072002410889, 2) - 2.60984943829188e-6*std::pow(-6.58143997192383*x_37 - 9.56688022613525, 2) - 2.71897851152996e-6*std::pow(-8.35695934295654*x_38 - 9.16335964202881, 2) + 2.8688195595219e-5*std::pow(-5.15975999832153*x_4 - 8.7344799041748, 2) + 9.79607752581829e-6*std::pow(-5.26968002319336*x_44 - 9.51232051849365, 2) - 5.55997474450405e-6*std::pow(-5.72951984405518*x_46 - 7.57535982131958, 2) + 5.71278197778613e-7*std::pow(-5.29848003387451*x_47 - 9.61719989776611, 2) + 1.38193993412772e-6*std::pow(-6.17368030548096*x_5 - 9.76648044586182, 2) - 4.36334878206072e-6*std::pow(-7.51959991455078*x_50 - 9.97152042388916, 2) - 1.81020489483955e-5*std::pow(-4.18656015396118*x_50 - 5.98431968688965, 2) + 2.69932574422578e-6*std::pow(-4.89456033706665*x_53 - 9.16567993164063, 2) - 3.27535692268397e-5*std::pow(-3.0511200428009*x_54 - 3.61879992485046, 2) - 1.30213813873935e-5*std::pow(-5.50551986694336*x_55 - 7.75392007827759, 2) + 0.000114786507143612*std::pow(-1.89527988433838*x_56 - 2.83895993232727, 2) + 2.25215288911437e-6*std::pow(-6.54728031158447*x_58 - 9.33351993560791, 2) - 6.30565220145853e-6*std::pow(-7.056960105896*x_60 - 9.21016025543213, 2) - 1.26572231308171e-5*std::pow(-5.30559968948364*x_60 - 6.09144020080566, 2) + 1.05448584068025e-6*std::pow(-4.85904026031494*x_64 - 7.49032020568848, 2) + 1.1113883510158e-5*std::pow(-4.05999994277954*x_66 - 5.80347967147827, 2) - 9.58270303607017e-6*std::pow(-6.47735977172852*x_68 - 8.89960098266602, 2) - 0.000118324407354382*std::pow(-2.09295964241028*x_69 - 3.34831976890564, 2) + 2.75425815680984e-5*std::pow(-4.50415992736816*x_7 - 7.37455987930298, 2) + 2.45111016194951e-5*std::pow(-4.27399969100952*x_7 - 6.91639995574951, 2) + 8.82942258716123e-5*std::pow(-3.77760004997253*x_7 - 5.96271991729736, 2) - 6.71644266388044e-6*std::pow(-5.52303981781006*x_70 - 5.93503999710083, 2) - 1.59610096523288e-5*std::pow(-6.29328012466431*x_71 - 9.53400039672852, 2) - 1.07123393243623e-5*std::pow(-4.51783990859985*x_71 - 6.98280000686646, 2) - 6.3584557064316e-6*std::pow(-6.04655981063843*x_72 - 7.45879983901978, 2) - 2.21794463866669e-5*std::pow(-5.11975955963135*x_73 - 7.37648010253906, 2) + 6.19478474576067e-6*std::pow(-4.88303995132446*x_73 - 6.30624008178711, 2) - 9.04889745840687e-6*std::pow(-5.61847972869873*x_74 - 9.03551959991455, 2) - 5.43938445209429e-6*std::pow(-6.10015964508057*x_75 - 8.54423999786377, 2) + 1.52692270639717e-5*std::pow(-4.85663986206055*x_75 - 7.2629599571228, 2) + 1.37415624961126e-5*std::pow(-6.23928022384644*x_76 - 8.45512008666992, 2) + 2.65954001482851e-7*std::pow(-5.75799989700317*x_77 - 6.99304008483887, 2) - 1.74994652551903e-6*std::pow(-6.51543998718262*x_79 - 9.14416027069092, 2) + 6.65400668667862e-6*std::pow(-4.61711978912354*x_80 - 6.62912034988403, 2) + 2.35009015949613e-6*std::pow(-9.80399990081787*x_81 - 9.96455955505371, 2) + 1.85297444848719e-5*std::pow(-5.51904010772705*x_82 - 7.76719999313354, 2) + 8.8930542871676e-7*std::pow(-6.52063989639282*x_83 - 9.15176010131836, 2) - 6.66146346775027e-6*std::pow(-5.5021595954895*x_83 - 7.13471984863281, 2) + 4.1165144177492e-6*std::pow(-7.79527997970581*x_85 - 9.79351997375488, 2) - 2.52691721245025e-6*std::pow(-3.08799982070923*x_86 - 4.93535995483398, 2) - 2.92615681940251e-7*std::pow(-7.49096012115479*x_87 - 9.92399978637695, 2) + 8.54521888822206e-6*std::pow(-5.73847961425781*x_87 - 7.79936027526855, 2) + 1.1239365437586e-5*std::pow(-4.00183963775635*x_87 - 5.6003999710083, 2) - 6.28952526417911e-6*std::pow(-6.34912014007568*x_89 - 9.13704013824463, 2) + 2.01341319049189e-5*std::pow(-5.6814398765564*x_90 - 8.55256080627441, 2) - 2.7703187549057e-6*std::pow(-5.93959999084473*x_99 - 7.78736019134521, 2) + 0.00110247260959044*std::exp(0.754959881305695*x_22) - 0.00124678123773758*std::sin(0.221119984984398*x_1 + 5.20879983901978) + 0.0398457416591713*std::sin(0.241199970245361*x_10 - 7.54232025146484) - 0.00753889636395941*std::sin(0.34215983748436*x_10 - 1.05311977863312) + 0.00415321848440591*std::sin(0.320959836244583*x_101 + 5.14448022842407) - 0.000353775507091698*std::sin(0.403039842844009*x_102 + 1.98351979255676) - 0.00752492350773183*std::sin(0.376479834318161*x_104 + 5.18048000335693) - 0.000875290531375891*std::sin(0.388159841299057*x_104 - 7.40119981765747) - 0.0057283838867255*std::sin(0.322239845991135*x_105 - 1.24519991874695) + 0.00983102072469445*std::sin(0.388559848070145*x_105 + 1.97791981697083) + 0.0014714480309695*std::sin(0.345919847488403*x_106 + 1.94127976894379) - 0.000908602242491207*std::sin(0.391999840736389*x_106 - 7.40279960632324) - 0.0127384337721668*std::sin(0.314319938421249*x_107 + 5.11247968673706) + 0.000489457871752195*std::sin(0.386559844017029*x_107 - 7.42159986495972) + 0.00572435059144702*std::sin(0.37951985001564*x_108 - 7.40759992599487) - 0.000793766854372746*std::sin(0.32151985168457*x_109 - 7.4521598815918) - 0.00564615843520083*std::sin(0.435439854860306*x_109 + 5.23640012741089) + 0.011174346559498*std::sin(0.19743999838829*x_110 + 1.78303980827332) - 0.000353583826363205*std::sin(0.364959836006165*x_110 + 5.18104028701782) + 0.0060130486527333*std::sin(0.22647999227047*x_111 + 5.04263973236084) + 0.000892249021135643*std::sin(0.326559841632843*x_111 - 4.26839971542358) - 0.016319960265973*std::sin(0.371999859809875*x_111 + 5.18032026290894) - 0.0100513984296018*std::sin(0.332879841327667*x_112 - 4.2545599937439) - 0.00312383344045451*std::sin(0.33519983291626*x_112 + 5.14775991439819) + 0.000597847324973052*std::sin(0.368799835443497*x_112 + 1.98655986785889) - 0.000532361400605894*std::sin(0.376959830522537*x_113 + 1.98927986621857) - 0.0198774786792739*std::sin(0.244079977273941*x_114 + 5.04392004013062) - 0.00292576040407904*std::sin(0.366399854421616*x_114 - 7.43375968933105) + 0.000725830157191376*std::sin(0.205520004034042*x_115 - 7.59376001358032) + 0.0121302635633126*std::sin(0.228079989552498*x_115 + 1.83607995510101) + 0.014516951831289*std::sin(0.405839860439301*x_117 + 5.1910400390625) + 0.00763863619911735*std::sin(0.266799956560135*x_118 + 5.07727956771851) + 0.00767317363181438*std::sin(0.36575984954834*x_119 - 1.21287977695465) + 0.00131804381101698*std::sin(0.249359980225563*x_12 + 8.27031993865967) - 0.0109189501383537*std::sin(0.463279873132706*x_120 - 1.14679980278015) + 0.0205116479019854*std::sin(0.138080030679703*x_14 + 8.09639930725098) - 0.0224831543216738*std::sin(0.393119841814041*x_15 + 2.19063997268677) - 0.000724114176003678*std::sin(0.293359935283661*x_16 - 4.28935956954956) - 0.00761316461393651*std::sin(0.315119922161102*x_16 - 4.26247978210449) - 0.00797419156614375*std::sin(0.365359842777252*x_16 + 2.14367985725403) - 0.0162008556240979*std::sin(0.181920006871223*x_19 - 4.4191198348999) - 0.00541356111938824*std::sin(0.296239942312241*x_21 - 4.29503965377808) + 0.00347560902698203*std::sin(0.318959832191467*x_21 + 5.13607978820801) + 0.00924400481680963*std::sin(0.363199830055237*x_21 - 4.21568012237549) - 0.00267976243098538*std::sin(0.134160041809082*x_23 - 4.49503993988037) + 0.0157663026390839*std::sin(0.29807984828949*x_23 - 4.32223987579346) + 0.0283510623779399*std::sin(0.317679941654205*x_24 + 8.35151958465576) + 0.00720402360689358*std::sin(0.465839862823486*x_24 + 8.48311996459961) - 0.0108448703608935*std::sin(0.297679930925369*x_26 + 5.10839986801147) - 0.0144234113784045*std::sin(0.310239940881729*x_27 + 5.1334400177002) - 0.000928304900894778*std::sin(0.360559850931168*x_27 + 5.16951990127563) - 0.0147832818512226*std::sin(0.36287984251976*x_27 + 5.17112016677856) - 0.0020491237833536*std::sin(0.519679844379425*x_27 - 4.07424020767212) + 0.00895605128666299*std::sin(0.257439970970154*x_28 - 7.52328014373779) - 0.00583909652921569*std::sin(0.262639969587326*x_28 + 5.06967973709106) - 0.00130787936919062*std::sin(0.336719840764999*x_28 - 4.25856018066406) + 0.000191730163236896*std::sin(0.849039852619171*x_29 - 3.96919989585876) + 0.0123838016497361*std::sin(0.32847985625267*x_3 - 1.05927979946136) + 0.0100928402101177*std::sin(0.372319847345352*x_3 - 1.03087985515594) + 0.0190480673595675*std::sin(0.268079966306686*x_32 - 7.42328023910522) - 0.00725172354423567*std::sin(0.302319914102554*x_33 - 1.18495988845825) - 0.00501826558247583*std::sin(0.348319828510284*x_34 + 1.97575974464417) - 0.000738782107409003*std::sin(0.357759833335876*x_34 + 1.97135984897614) + 0.0257431965485776*std::sin(0.361279845237732*x_34 + 1.99055981636047) + 0.00772614364103951*std::sin(0.29615992307663*x_35 + 8.26560020446777) - 0.00641119002946048*std::sin(0.309519916772842*x_35 + 8.2775993347168) + 0.0165737609468677*std::sin(0.31743985414505*x_35 - 1.20303988456726) + 0.00758168449492677*std::sin(0.332799851894379*x_35 - 1.22799980640411) + 0.000343709370228951*std::sin(0.313519924879074*x_36 - 4.28071975708008) + 0.00418608031272468*std::sin(0.317359834909439*x_36 + 1.92511987686157) + 0.010639230889258*std::sin(0.340159833431244*x_36 + 5.15488004684448) + 0.00302155350404692*std::sin(0.351599842309952*x_37 + 5.16336011886597) + 0.0149744899876228*std::sin(0.3713598549366*x_37 + 5.17824029922485) - 0.00124070412471073*std::sin(0.377359837293625*x_37 + 5.18239974975586) + 0.0465284952408095*std::sin(0.149600028991699*x_38 + 4.92015981674194) - 0.00762604771967611*std::sin(0.320479840040207*x_38 - 7.46943950653076) - 0.00114234831904266*std::sin(0.3574398458004*x_38 + 5.16215991973877) + 0.00410407914470039*std::sin(0.353839844465256*x_39 - 7.44127988815308) - 0.0223530175149593*std::sin(0.132800042629242*x_40 + 4.9093599319458) - 0.0164993365781884*std::sin(0.315199851989746*x_41 + 5.12504005432129) - 0.00580314984061446*std::sin(0.309279918670654*x_43 + 5.13111972808838) - 0.0101845293833466*std::sin(0.331439822912216*x_43 + 5.13816022872925) - 0.00686459180948056*std::sin(0.34911984205246*x_43 + 5.14328002929688) - 0.00581179289900026*std::sin(0.307359933853149*x_44 - 7.48016023635864) - 0.00594297431413609*std::sin(0.27687993645668*x_45 - 7.51800012588501) - 0.000738188309467299*std::sin(0.298879951238632*x_45 - 7.48623991012573) + 0.0129385850857913*std::sin(0.321199834346771*x_45 - 7.46703958511353) + 0.0170956427815763*std::sin(0.298079937696457*x_47 + 5.12423944473267) + 0.00472708484823499*std::sin(0.306559920310974*x_47 + 5.11695957183838) - 0.00563182258427057*std::sin(0.251199960708618*x_48 + 5.06759977340698) + 0.00709035588302858*std::sin(0.273039966821671*x_49 + 1.8582398891449) + 0.0122569047137244*std::sin(0.314719915390015*x_49 - 7.46687984466553) - 0.000138240087474338*std::sin(1.0694397687912*x_5 - 6.76344013214111) + 0.000435355823378517*std::sin(0.367279857397079*x_50 + 5.15799999237061) - 0.000890242000213335*std::sin(0.323439836502075*x_51 - 4.28312015533447) - 0.0198006065213315*std::sin(0.229279980063438*x_52 + 5.04008007049561) - 0.0203701857781427*std::sin(0.20728000998497*x_53 + 4.99191951751709) - 0.000955124702258802*std::sin(0.273679941892624*x_53 + 5.08431959152222) - 0.000578306555096763*std::sin(0.270639955997467*x_54 + 5.09176015853882) + 0.00113336787695471*std::sin(0.22647999227047*x_56 + 5.04399967193604) - 0.00257403006389721*std::sin(0.157680034637451*x_57 + 4.92840003967285) - 0.0100982553088327*std::sin(0.266399949789047*x_57 - 7.50400018692017) + 0.00526946892034307*std::sin(0.347279846668243*x_59 - 4.26007986068726) + 0.0111478882253842*std::sin(0.374879837036133*x_59 + 1.95975983142853) - 0.0094810804062646*std::sin(0.247119963169098*x_60 - 7.52824020385742) - 0.000533470129309407*std::sin(0.218399986624718*x_63 + 8.20975971221924) + 0.00972652936751051*std::sin(0.149120032787323*x_65 + 4.93391990661621) - 0.0303995953103495*std::sin(0.282159924507141*x_65 + 5.1081600189209) - 0.00119301825003469*std::sin(0.287759929895401*x_65 + 5.12423992156982) - 0.0804562842902144*std::sin(0.166320025920868*x_67 + 4.94535970687866) + 0.0014990389046692*std::sin(0.20320001244545*x_69 + 4.98776006698608) + 0.00316307335700382*std::sin(0.358319848775864*x_7 + 8.53191947937012) - 0.109355912469823*std::sin(0.121280059218407*x_74 + 4.8842396736145) - 0.000988619630761372*std::sin(0.235679984092712*x_74 + 5.03487968444824) - 0.00536912067705556*std::sin(0.274879962205887*x_74 - 7.51688003540039) + 0.0378404048580145*std::sin(0.225279986858368*x_75 - 7.56712007522583) + 0.0112402161335266*std::sin(0.175280019640923*x_78 + 4.95191955566406) - 0.00283603477182576*std::sin(0.157200023531914*x_8 - 4.46224021911621) - 0.0257720321188952*std::sin(0.257999956607819*x_8 - 4.33247995376587) + 0.000409390230455847*std::sin(0.29887992143631*x_80 + 5.11567974090576) - 0.00061478572592283*std::sin(0.385439842939377*x_81 - 4.21808004379272) + 0.0425362485485173*std::sin(0.13728004693985*x_84 + 4.90903997421265) + 0.0220939637725259*std::sin(0.294639945030212*x_84 - 7.47824001312256) + 0.00213014945480263*std::sin(0.186480015516281*x_85 - 7.60864019393921) - 0.00045340199199306*std::sin(0.333439826965332*x_88 - 4.27568006515503) - 0.0612203171596224*std::sin(0.129600048065186*x_9 - 4.49575996398926) + 0.0151324194594262*std::sin(0.222719997167587*x_9 - 4.3692798614502) + 0.00817257089661792*std::sin(0.372239857912064*x_9 - 1.00943982601166) + 0.0017320201345791*std::sin(0.677919805049896*x_9 - 6.93639993667603) + 0.00741895963187262*std::sin(0.372079849243164*x_92 + 1.99183976650238) - 0.0121565132208232*std::sin(0.325199842453003*x_93 + 1.97279977798462) + 0.00523648068563132*std::sin(0.332959830760956*x_93 + 1.98767983913422) + 0.00561152951430201*std::sin(0.351759850978851*x_93 + 1.96647977828979) - 0.00093560147908999*std::sin(0.358479827642441*x_93 - 7.410719871521) - 0.0197745126565585*std::sin(0.362159848213196*x_93 - 7.41519975662231) - 0.00102599870587123*std::sin(0.395199835300446*x_94 - 7.40279960632324) + 0.00286304856663631*std::sin(0.279039949178696*x_95 - 7.51416015625) + 0.00279927853413092*std::sin(0.329999834299088*x_95 - 1.22255992889404) - 0.00438202621079773*std::sin(0.33111983537674*x_95 + 8.16551971435547) - 0.000577040340043462*std::sin(0.340319842100143*x_95 + 5.15104007720947) + 0.00472591307831555*std::sin(0.380959838628769*x_96 + 5.1799201965332) - 0.00103767569868307*std::sin(0.382799863815308*x_96 - 7.40703964233398) - 0.00745877305259785*std::sin(0.392399847507477*x_96 - 7.41631984710693) - 0.00878032562420682*std::sin(0.319759905338287*x_98 + 1.9171998500824) + 0.000224959671286991*std::sin(0.392799854278564*x_98 - 1.18863987922668) + 0.000443328352827822*std::sin(0.374879837036133*x_99 - 1.20063984394073) + 0.00294233699405657*std::sin(0.398159861564636*x_99 - 7.40623998641968) - 0.0484081549781332);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00494989894360954*x_1 + 0.000333542458590738*x_10 + 7.16880924438741e-5*x_100 + 0.00061399258895543*x_101 + 0.000166648566318025*x_102 + 0.000216257482031652*x_103 + 0.00171293753708594*x_104 + 0.00127188946570886*x_105 + 0.00101791672395211*x_106 - 0.000145240422494707*x_107 - 0.00012694916286093*x_108 + 0.00110748710388306*x_109 + 0.00103562764757599*x_11 + 0.000128230578882788*x_110 + 0.000111831302470637*x_111 - 0.000149590280551821*x_112 + 0.000313401313605351*x_113 + 0.000105214270529478*x_114 - 0.00122099193801419*x_115 + 0.00317665976042022*x_116 - 0.00108155905271595*x_117 - 0.000117597402075897*x_118 - 0.000788591450622768*x_119 - 0.00862425653434455*x_12 - 0.000143606103840145*x_120 + 0.000508255982555488*x_13 - 0.00113831233644073*x_14 - 1.04137763413831e-5*x_15 + 0.00216263275893451*x_16 + 0.00352663941125249*x_17 + 0.000504088801527849*x_18 - 8.56629560748025e-5*x_19 - 0.00376152454944989*x_2 + 0.0016567150742515*x_20 - 3.91210349443965e-5*x_21 + 0.00124170259399133*x_22 - 8.95530344098248e-6*x_23 + 0.00141546120040639*x_24 - 0.000989005843308622*x_25 + 0.00018864185191478*x_26 + 0.000114492442825538*x_27 + 0.000485531890347081*x_28 + 0.000349060114338618*x_29 + 0.00118944388042626*x_3 + 3.04600559887384e-5*x_30 - 0.00200900444164388*x_31 - 0.000624992486960814*x_32 + 0.000407579430417368*x_33 - 0.00031434986040672*x_34 - 9.37776916661802e-9*x_35 + 0.000615504494660402*x_36 - 3.66311047125423e-5*x_37 - 0.000218660262528478*x_38 - 0.00243209251432251*x_39 - 0.000805736246971298*x_4 + 0.000250500277542501*x_40 - 0.0010059083185277*x_41 + 0.00279209233176663*x_42 + 3.53930216903131e-5*x_43 + 0.000136252155643275*x_44 - 0.000634805272247634*x_45 - 7.43447364315524e-6*x_46 + 0.0013068981132108*x_47 + 5.96374173471417e-5*x_48 - 0.00105579126113131*x_49 - 6.98166706704144e-5*x_5 - 0.00011334080316063*x_50 - 6.61090623713245e-5*x_51 + 0.00281364386393939*x_52 + 0.000131679488451403*x_53 + 0.000101996288873574*x_54 + 0.000139408412087123*x_55 + 0.000201293726600228*x_56 - 7.09476854731651e-5*x_57 + 0.000685324123553855*x_58 - 0.00137081868367441*x_59 + 0.00315550788309405*x_6 + 5.73070328245561e-5*x_60 - 0.0010069350020766*x_61 - 0.000201431921626289*x_62 + 1.48280041499245e-5*x_63 - 2.61366360123778e-5*x_64 + 6.83320312567299e-5*x_65 - 8.57495751004785e-5*x_66 - 0.00186678486401404*x_67 - 0.00135611045524372*x_68 - 0.000279548522633077*x_69 - 3.66844614959414e-9*x_7 - 0.000242409256881965*x_70 - 7.80786806114382e-5*x_71 - 0.000115305140080703*x_72 - 0.000679228112527762*x_73 - 0.000117977263300573*x_74 - 5.53432502718104e-5*x_75 + 0.0010569767329311*x_76 + 0.000201624102137107*x_77 + 0.000326686655170968*x_78 + 5.37664143172028e-5*x_79 + 0.00146127598205309*x_8 - 0.000325279884947198*x_80 + 0.000800226117799183*x_81 + 0.000882219014041128*x_82 + 0.000228158377537389*x_83 + 0.000180889573624869*x_84 - 0.00070529105402754*x_85 - 3.73431627407678e-6*x_86 + 0.000141844467584625*x_87 - 3.91939437321801e-5*x_88 - 0.00130170635140672*x_89 - 1.96834592119311e-8*x_9 + 0.00089820129327052*x_90 - 0.00353288492602142*x_91 - 0.000170273552292354*x_92 + 0.000882299851357685*x_94 + 2.11383421290887e-5*x_95 + 0.000437777892376444*x_96 - 0.000667566833988039*x_97 - 0.0015576724618571*x_98 - 1.64587395643794e-5*x_99 + 1.45171044770081e-6*std::pow(-7.84783983230591*x_108 - 9.05935955047607, 2) + 2.39063603459932e-7*std::pow(-4.29967975616455*x_14 - 6.14551973342896, 2) - 1.52203534704998e-5*std::pow(-5.92399978637695*x_17 - 9.46343994140625, 2) - 3.38834234617553e-6*std::pow(-6.35599994659424*x_23 - 8.75072002410889, 2) + 1.45258477309886e-5*std::pow(-6.58143997192383*x_37 - 9.56688022613525, 2) - 2.6873086589436e-8*std::pow(-8.35695934295654*x_38 - 9.16335964202881, 2) - 0.000159672184448199*std::pow(-5.15975999832153*x_4 - 8.7344799041748, 2) - 1.33711558488611e-6*std::pow(-5.26968002319336*x_44 - 9.51232051849365, 2) - 1.57201349660973e-5*std::pow(-5.72951984405518*x_46 - 7.57535982131958, 2) - 1.38796249227626e-10*std::pow(-5.29848003387451*x_47 - 9.61719989776611, 2) - 3.35752493724838e-10*std::pow(-6.17368030548096*x_5 - 9.76648044586182, 2) - 1.23368243400662e-5*std::pow(-7.51959991455078*x_50 - 9.97152042388916, 2) - 1.78912016690677e-7*std::pow(-4.18656015396118*x_50 - 5.98431968688965, 2) + 7.63200679259115e-6*std::pow(-4.89456033706665*x_53 - 9.16567993164063, 2) - 3.23720653993205e-7*std::pow(-3.0511200428009*x_54 - 3.61879992485046, 2) + 1.77735342987451e-6*std::pow(-5.50551986694336*x_55 - 7.75392007827759, 2) - 1.56677840933627e-5*std::pow(-1.89527988433838*x_56 - 2.83895993232727, 2) + 6.36768133095573e-6*std::pow(-6.54728031158447*x_58 - 9.33351993560791, 2) - 6.23220584105729e-8*std::pow(-7.056960105896*x_60 - 9.21016025543213, 2) + 1.72764764927509e-6*std::pow(-5.30559968948364*x_60 - 6.09144020080566, 2) - 2.56195107951199e-10*std::pow(-4.85904026031494*x_64 - 7.49032020568848, 2) + 3.14231191337453e-5*std::pow(-4.05999994277954*x_66 - 5.80347967147827, 2) - 9.47108656273495e-8*std::pow(-6.47735977172852*x_68 - 8.89960098266602, 2) + 1.6150689776492e-5*std::pow(-2.09295964241028*x_69 - 3.34831976890564, 2) + 2.7221773774138e-7*std::pow(-4.50415992736816*x_7 - 7.37455987930298, 2) - 0.000136423398461101*std::pow(-4.27399969100952*x_7 - 6.91639995574951, 2) - 1.20517202071168e-5*std::pow(-3.77760004997253*x_7 - 5.96271991729736, 2) - 6.63821153841629e-8*std::pow(-5.52303981781006*x_70 - 5.93503999710083, 2) + 2.17859798479533e-6*std::pow(-6.29328012466431*x_71 - 9.53400039672852, 2) - 3.02878030422831e-5*std::pow(-4.51783990859985*x_71 - 6.98280000686646, 2) - 1.79777402729861e-5*std::pow(-6.04655981063843*x_72 - 7.45879983901978, 2) + 3.0273834960571e-6*std::pow(-5.11975955963135*x_73 - 7.37648010253906, 2) + 6.12262973649137e-8*std::pow(-4.88303995132446*x_73 - 6.30624008178711, 2) - 8.94349859358995e-8*std::pow(-5.61847972869873*x_74 - 9.03551959991455, 2) - 1.53791809583194e-5*std::pow(-6.10015964508057*x_75 - 8.54423999786377, 2) + 1.50913756509601e-7*std::pow(-4.85663986206055*x_75 - 7.2629599571228, 2) - 1.8756545490593e-6*std::pow(-6.23928022384644*x_76 - 8.45512008666992, 2) - 6.46154850936623e-11*std::pow(-5.75799989700317*x_77 - 6.99304008483887, 2) + 9.73981732206699e-6*std::pow(-6.51543998718262*x_79 - 9.14416027069092, 2) - 9.082386311506e-7*std::pow(-4.61711978912354*x_80 - 6.62912034988403, 2) - 3.20775552241995e-7*std::pow(-9.80399990081787*x_81 - 9.96455955505371, 2) + 1.83139155352093e-7*std::pow(-5.51904010772705*x_82 - 7.76719999313354, 2) - 2.16063309266155e-10*std::pow(-6.52063989639282*x_83 - 9.15176010131836, 2) - 1.88344569169624e-5*std::pow(-5.5021595954895*x_83 - 7.13471984863281, 2) + 4.06856648280712e-8*std::pow(-7.79527997970581*x_85 - 9.79351997375488, 2) + 6.13933163493036e-10*std::pow(-3.08799982070923*x_86 - 4.93535995483398, 2) + 7.10931368927018e-11*std::pow(-7.49096012115479*x_87 - 9.92399978637695, 2) + 2.4160540364051e-5*std::pow(-5.73847961425781*x_87 - 7.79936027526855, 2) + 1.1108452653589e-7*std::pow(-4.00183963775635*x_87 - 5.6003999710083, 2) + 3.50061137425101e-5*std::pow(-6.34912014007568*x_89 - 9.13704013824463, 2) - 2.74820829942042e-6*std::pow(-5.6814398765564*x_90 - 8.55256080627441, 2) + 1.5418984639359e-5*std::pow(-5.93959999084473*x_99 - 7.78736019134521, 2) - 0.000150481996932777*std::exp(0.754959881305695*x_22) + 3.02914692138163e-7*std::sin(0.221119984984398*x_1 + 5.20879983901978) + 0.00039381630317655*std::sin(0.241199970245361*x_10 - 7.54232025146484) + 0.0419598383860222*std::sin(0.34215983748436*x_10 - 1.05311977863312) + 0.0117427071378495*std::sin(0.320959836244583*x_101 + 5.14448022842407) + 8.59523672421994e-8*std::sin(0.403039842844009*x_102 + 1.98351979255676) + 0.00102711442112884*std::sin(0.376479834318161*x_104 + 5.18048000335693) + 2.12658286648827e-7*std::sin(0.388159841299057*x_104 - 7.40119981765747) - 5.66166137587028e-5*std::sin(0.322239845991135*x_105 - 1.24519991874695) - 0.00134188515675607*std::sin(0.388559848070145*x_105 + 1.97791981697083) + 0.00416033573988868*std::sin(0.345919847488403*x_106 + 1.94127976894379) + 2.20751612415745e-7*std::sin(0.391999840736389*x_106 - 7.40279960632324) + 0.00173873249562518*std::sin(0.314319938421249*x_107 + 5.11247968673706) - 1.18917397895286e-7*std::sin(0.386559844017029*x_107 - 7.42159986495972) + 0.0161848871669349*std::sin(0.37951985001564*x_108 - 7.40759992599487) + 1.92851508383387e-7*std::sin(0.32151985168457*x_109 - 7.4521598815918) + 0.000770672385814195*std::sin(0.435439854860306*x_109 + 5.23640012741089) + 0.000110441910960446*std::sin(0.19743999838829*x_110 + 1.78303980827332) + 8.59057969962711e-8*std::sin(0.364959836006165*x_110 + 5.18104028701782) - 0.0334673057560731*std::sin(0.22647999227047*x_111 + 5.04263973236084) - 2.167784767425e-7*std::sin(0.326559841632843*x_111 - 4.26839971542358) + 0.00222759294818175*std::sin(0.371999859809875*x_111 + 5.18032026290894) - 9.93432273179747e-5*std::sin(0.332879841327667*x_112 - 4.2545599937439) + 0.0173865695956433*std::sin(0.33519983291626*x_112 + 5.14775991439819) - 1.45251414529189e-7*std::sin(0.368799835443497*x_112 + 1.98655986785889) + 1.29341126486151e-7*std::sin(0.376959830522537*x_113 + 1.98927986621857) + 0.00271317641783141*std::sin(0.244079977273941*x_114 + 5.04392004013062) - 0.00827222254490445*std::sin(0.366399854421616*x_114 - 7.43375968933105) - 1.76345787019693e-7*std::sin(0.205520004034042*x_115 - 7.59376001358032) + 0.000119889738630613*std::sin(0.228079989552498*x_115 + 1.83607995510101) - 0.00198149131501856*std::sin(0.405839860439301*x_117 + 5.1910400390625) - 0.00104263563474216*std::sin(0.266799956560135*x_118 + 5.07727956771851) - 0.00104734982155821*std::sin(0.36575984954834*x_119 - 1.21287977695465) - 3.20228459615989e-7*std::sin(0.249359980225563*x_12 + 8.27031993865967) + 0.00149038208018546*std::sin(0.463279873132706*x_120 - 1.14679980278015) + 0.0579941255515612*std::sin(0.138080030679703*x_14 + 8.09639930725098) + 0.0030688381101188*std::sin(0.393119841814041*x_15 + 2.19063997268677) + 1.75928876741087e-7*std::sin(0.293359935283661*x_16 - 4.28935956954956) - 0.0215252731801524*std::sin(0.315119922161102*x_16 - 4.26247978210449) + 0.0010884372639821*std::sin(0.365359842777252*x_16 + 2.14367985725403) + 0.0901703977457788*std::sin(0.181920006871223*x_19 - 4.4191198348999) - 0.0153061687066334*std::sin(0.296239942312241*x_21 - 4.29503965377808) - 0.0193444751094274*std::sin(0.318959832191467*x_21 + 5.13607978820801) + 9.13633339954226e-5*std::sin(0.363199830055237*x_21 - 4.21568012237549) + 6.5106803600794e-7*std::sin(0.134160041809082*x_23 - 4.49503993988037) + 0.000155826614376936*std::sin(0.29807984828949*x_23 - 4.32223987579346) - 0.00386977821007547*std::sin(0.317679941654205*x_24 + 8.35151958465576) + 7.12011328369996e-5*std::sin(0.465839862823486*x_24 + 8.48311996459961) - 0.000107185525381556*std::sin(0.297679930925369*x_26 + 5.10839986801147) + 0.0802775341635173*std::sin(0.310239940881729*x_27 + 5.1334400177002) + 2.25538518509593e-7*std::sin(0.360559850931168*x_27 + 5.16951990127563) - 0.000146110905834412*std::sin(0.36287984251976*x_27 + 5.17112016677856) - 0.00579364186292393*std::sin(0.519679844379425*x_27 - 4.07424020767212) + 8.85173386642531e-5*std::sin(0.257439970970154*x_28 - 7.52328014373779) + 0.0324991265110847*std::sin(0.262639969587326*x_28 + 5.06967973709106) + 3.17758933548869e-7*std::sin(0.336719840764999*x_28 - 4.25856018066406) - 0.0010671279023818*std::sin(0.849039852619171*x_29 - 3.96919989585876) - 0.00169032698468944*std::sin(0.32847985625267*x_3 - 1.05927979946136) - 0.0561745278920464*std::sin(0.372319847345352*x_3 - 1.03087985515594) - 0.00259996592118748*std::sin(0.268079966306686*x_32 - 7.42328023910522) - 7.16725762636648e-5*std::sin(0.302319914102554*x_33 - 1.18495988845825) - 0.0141885198903502*std::sin(0.348319828510284*x_34 + 1.97575974464417) + 1.79492558798101e-7*std::sin(0.357759833335876*x_34 + 1.97135984897614) - 0.00351381756822245*std::sin(0.361279845237732*x_34 + 1.99055981636047) - 0.0430020155304202*std::sin(0.29615992307663*x_35 + 8.26560020446777) - 0.0181268399925809*std::sin(0.309519916772842*x_35 + 8.2775993347168) - 0.00226223547168001*std::sin(0.31743985414505*x_35 - 1.20303988456726) + 7.493375290094e-5*std::sin(0.332799851894379*x_35 - 1.22799980640411) - 8.35067250906277e-8*std::sin(0.313519924879074*x_36 - 4.28071975708008) + 0.0118356198578065*std::sin(0.317359834909439*x_36 + 1.92511987686157) + 0.000105153082938913*std::sin(0.340159833431244*x_36 + 5.15488004684448) + 0.00854306558457914*std::sin(0.351599842309952*x_37 + 5.16336011886597) + 0.000148000715843684*std::sin(0.3713598549366*x_37 + 5.17824029922485) + 3.01438212731914e-7*std::sin(0.377359837293625*x_37 + 5.18239974975586) - 0.00635090687714709*std::sin(0.149600028991699*x_38 + 4.92015981674194) - 0.021561698554424*std::sin(0.320479840040207*x_38 - 7.46943950653076) + 2.77541944732239e-7*std::sin(0.3574398458004*x_38 + 5.16215991973877) + 0.0116037717851163*std::sin(0.353839844465256*x_39 - 7.44127988815308) - 0.0632003684157096*std::sin(0.132800042629242*x_40 + 4.9093599319458) + 0.0022520769176063*std::sin(0.315199851989746*x_41 + 5.12504005432129) - 5.73555647817725e-5*std::sin(0.309279918670654*x_43 + 5.13111972808838) + 0.0013901373205053*std::sin(0.331439822912216*x_43 + 5.13816022872925) - 0.019408776962318*std::sin(0.34911984205246*x_43 + 5.14328002929688) - 0.0164321193828443*std::sin(0.307359933853149*x_44 - 7.48016023635864) - 0.016803018468855*std::sin(0.27687993645668*x_45 - 7.51800012588501) + 1.79348291211086e-7*std::sin(0.298879951238632*x_45 - 7.48623991012573) - 0.00176605214883101*std::sin(0.321199834346771*x_45 - 7.46703958511353) - 0.00233346973180287*std::sin(0.298079937696457*x_47 + 5.12423944473267) + 0.0133652426899784*std::sin(0.306559920310974*x_47 + 5.11695957183838) - 0.0159232757697976*std::sin(0.251199960708618*x_48 + 5.06759977340698) + 7.00776952765721e-5*std::sin(0.273039966821671*x_49 + 1.8582398891449) - 0.00167300618762875*std::sin(0.314719915390015*x_49 - 7.46687984466553) - 0.000390856601456654*std::sin(1.0694397687912*x_5 - 6.76344013214111) - 1.05772906439114e-7*std::sin(0.367279857397079*x_50 + 5.15799999237061) + 2.16290856215021e-7*std::sin(0.323439836502075*x_51 - 4.28312015533447) + 0.00270268375276647*std::sin(0.229279980063438*x_52 + 5.04008007049561) - 0.000201329199159761*std::sin(0.20728000998497*x_53 + 4.99191951751709) + 2.32054586948457e-7*std::sin(0.273679941892624*x_53 + 5.08431959152222) + 1.40503840446378e-7*std::sin(0.270639955997467*x_54 + 5.09176015853882) - 2.75360080129213e-7*std::sin(0.22647999227047*x_56 + 5.04399967193604) + 6.25379578036218e-7*std::sin(0.157680034637451*x_57 + 4.92840003967285) + 0.00137836134085426*std::sin(0.266399949789047*x_57 - 7.50400018692017) + 5.20809171445196e-5*std::sin(0.347279846668243*x_59 - 4.26007986068726) - 0.00152163098397738*std::sin(0.374879837036133*x_59 + 1.95975983142853) - 0.0268065720547072*std::sin(0.247119963169098*x_60 - 7.52824020385742) + 1.29610500297469e-7*std::sin(0.218399986624718*x_63 + 8.20975971221924) - 0.0541357223411006*std::sin(0.149120032787323*x_65 + 4.93391990661621) + 0.00414939270912962*std::sin(0.282159924507141*x_65 + 5.1081600189209) + 2.89852577971287e-7*std::sin(0.287759929895401*x_65 + 5.12423992156982) + 0.0109818803845661*std::sin(0.166320025920868*x_67 + 4.94535970687866) - 3.6420255179247e-7*std::sin(0.20320001244545*x_69 + 4.98776006698608) + 0.00894319531377687*std::sin(0.358319848775864*x_7 + 8.53191947937012) + 0.0149265350827883*std::sin(0.121280059218407*x_74 + 4.8842396736145) + 2.40192426730163e-7*std::sin(0.235679984092712*x_74 + 5.03487968444824) - 0.0151805189000199*std::sin(0.274879962205887*x_74 - 7.51688003540039) - 0.00516502599542511*std::sin(0.225279986858368*x_75 - 7.56712007522583) + 0.0317803088659359*std::sin(0.175280019640923*x_78 + 4.95191955566406) + 6.89035553149336e-7*std::sin(0.157200023531914*x_8 - 4.46224021911621) + 0.00351775347934291*std::sin(0.257999956607819*x_8 - 4.33247995376587) - 9.9464374237725e-8*std::sin(0.29887992143631*x_80 + 5.11567974090576) + 1.49366723898398e-7*std::sin(0.385439842939377*x_81 - 4.21808004379272) + 0.000420407989833972*std::sin(0.13728004693985*x_84 + 4.90903997421265) - 0.00301571554678828*std::sin(0.294639945030212*x_84 - 7.47824001312256) - 5.17535512068419e-7*std::sin(0.186480015516281*x_85 - 7.60864019393921) + 1.10157356128193e-7*std::sin(0.333439826965332*x_88 - 4.27568006515503) - 0.000605072411233412*std::sin(0.129600048065186*x_9 - 4.49575996398926) + 0.0427850282055544*std::sin(0.222719997167587*x_9 - 4.3692798614502) - 0.0454867314080301*std::sin(0.372239857912064*x_9 - 1.00943982601166) - 0.000236412085263566*std::sin(0.677919805049896*x_9 - 6.93639993667603) - 0.0412922969247855*std::sin(0.372079849243164*x_92 + 1.99183976650238) - 0.000120149177723726*std::sin(0.325199842453003*x_93 + 1.97279977798462) + 0.0148054958715156*std::sin(0.332959830760956*x_93 + 1.98767983913422) - 0.0312325385774163*std::sin(0.351759850978851*x_93 + 1.96647977828979) + 2.2731127596757e-7*std::sin(0.358479827642441*x_93 - 7.410719871521) + 0.00269912207073956*std::sin(0.362159848213196*x_93 - 7.41519975662231) + 2.49273948561418e-7*std::sin(0.395199835300446*x_94 - 7.40279960632324) - 0.0159350983682045*std::sin(0.279039949178696*x_95 - 7.51416015625) + 2.76667337077705e-5*std::sin(0.329999834299088*x_95 - 1.22255992889404) + 0.000598124660038113*std::sin(0.33111983537674*x_95 + 8.16551971435547) + 1.40196204165495e-7*std::sin(0.340319842100143*x_95 + 5.15104007720947) + 0.0133619296567131*std::sin(0.380959838628769*x_96 + 5.1799201965332) + 2.52110960039964e-7*std::sin(0.382799863815308*x_96 - 7.40703964233398) + 0.00101808521487013*std::sin(0.392399847507477*x_96 - 7.41631984710693) + 0.00119847053083842*std::sin(0.319759905338287*x_98 + 1.9171998500824) - 5.46556103900434e-8*std::sin(0.392799854278564*x_98 - 1.18863987922668) - 1.07709891236929e-7*std::sin(0.374879837036133*x_99 - 1.20063984394073) + 0.00831909078508521*std::sin(0.398159861564636*x_99 - 7.40623998641968) - 0.0515424905880584);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00759749284390952*x_1 - 0.000976473892038376*x_10 - 0.000572592869665604*x_100 + 0.000466738604100179*x_101 - 0.000323104503898967*x_102 - 0.000328547533015874*x_103 - 0.00262212840161638*x_104 + 0.00146518385096671*x_105 - 3.20542159344344e-6*x_106 - 0.00026634211560054*x_107 - 0.000198857277693584*x_108 - 0.00159725065446276*x_109 - 0.000961010448832073*x_11 + 0.000274704802612569*x_110 - 0.00035069004843681*x_111 + 0.000252732195755139*x_112 + 0.000611574672281943*x_113 + 0.000367657876833803*x_114 + 0.0021272564098293*x_115 - 0.00438933388578333*x_116 + 0.00222864356612525*x_117 + 4.34841246690866e-5*x_118 + 0.00229406352113088*x_119 + 0.00379030649144335*x_12 - 0.000856701599807434*x_120 + 0.000458171925778466*x_13 + 0.000373441125990395*x_14 - 0.00134861387248315*x_15 + 0.000186028826668591*x_16 + 0.000329398510088847*x_17 - 0.000494851287205117*x_18 - 3.7878526788066e-5*x_19 + 0.00297612828485744*x_2 - 0.00510681608595283*x_20 + 3.62583274916203e-5*x_21 - 0.00071190170810874*x_22 - 0.000116206366161603*x_23 - 0.000286811694672439*x_24 - 0.00108510148965467*x_25 - 0.000533032804527956*x_26 - 0.000730407829251898*x_28 - 0.00176399503513665*x_29 - 0.00198462563040353*x_3 + 7.73864680295412e-5*x_30 + 0.00128322921007589*x_31 - 0.000820425220833058*x_32 - 0.000228660072834668*x_33 + 4.70182786417884e-5*x_34 - 0.00035434526110167*x_35 - 0.00038745295402605*x_39 + 0.00126104752519301*x_4 + 4.95060386216213e-5*x_40 + 0.000486970930739483*x_41 - 0.00119742159036007*x_42 + 1.99658549234583e-5*x_43 - 7.76657556378202e-5*x_44 + 6.48977939184277e-6*x_45 - 0.000161202805717563*x_46 - 0.000271673154673079*x_47 + 0.00110071997261203*x_48 + 0.000128982346219965*x_49 - 0.000324110380177412*x_5 + 4.86622496474824e-5*x_51 - 0.00464050637078525*x_52 + 7.15631486688966e-5*x_54 - 0.000191589913681551*x_55 - 0.00017934365916582*x_56 - 4.79511590099906e-5*x_57 + 6.00233967750177e-5*x_58 + 0.00124969681791216*x_59 + 0.000893373280128536*x_6 + 0.000592758563169148*x_60 + 3.33396116723918e-5*x_61 + 0.000403690962609989*x_62 - 0.000126031704984645*x_63 + 0.000443297000957744*x_64 - 0.000112245285290554*x_65 + 0.000341222466326127*x_66 + 0.000975057393190059*x_67 - 0.000447245683226074*x_68 + 0.000590235843766801*x_69 - 0.000138614683899726*x_7 + 0.000184543862750773*x_70 + 2.97752571501473e-6*x_71 - 0.000848919190913906*x_72 + 7.71110446266184e-5*x_73 + 0.000226371146631966*x_75 + 0.00114187092819071*x_76 - 5.93022539918381e-5*x_77 - 3.01372285398836e-6*x_78 + 0.000170422970978381*x_79 + 0.000754326770988617*x_8 + 0.000255376188510436*x_80 - 0.00103146266125832*x_81 - 0.000952029681941286*x_82 + 0.000652051868771382*x_83 + 0.0019563222918785*x_84 + 0.00115543876580159*x_85 - 0.000222339088988731*x_86 + 2.77271992474398e-5*x_88 + 0.00206122777821044*x_89 - 0.000743752631346882*x_9 - 0.0015158610082052*x_90 + 0.000227493689578893*x_91 + 7.93507616637995e-5*x_92 + 0.000110098699737917*x_94 - 3.41288449268765e-5*x_95 - 0.000334111527158744*x_96 - 0.00085292068736764*x_97 - 4.02992005627699e-5*x_98 - 5.8910636776442e-6*x_99 + 2.72535055737041e-5*std::pow(-4.29967975616455*x_14 - 6.14551973342896, 2) + 2.4573974635982e-5*std::pow(-5.92399978637695*x_17 - 9.46343994140625, 2) - 3.06356051087709e-6*std::pow(-8.35695934295654*x_38 - 9.16335964202881, 2) + 2.53808953044243e-5*std::pow(-5.72951984405518*x_46 - 7.57535982131958, 2) - 5.24450882706388e-6*std::pow(-5.29848003387451*x_47 - 9.61719989776611, 2) - 1.268663185675e-5*std::pow(-6.17368030548096*x_5 - 9.76648044586182, 2) + 1.99183815940245e-5*std::pow(-7.51959991455078*x_50 - 9.97152042388916, 2) - 2.03961605761508e-5*std::pow(-4.18656015396118*x_50 - 5.98431968688965, 2) - 1.23222329695749e-5*std::pow(-4.89456033706665*x_53 - 9.16567993164063, 2) - 3.69044995567702e-5*std::pow(-3.0511200428009*x_54 - 3.61879992485046, 2) - 1.02809202046596e-5*std::pow(-6.54728031158447*x_58 - 9.33351993560791, 2) - 7.10478107781863e-6*std::pow(-7.056960105896*x_60 - 9.21016025543213, 2) - 9.68050298605053e-6*std::pow(-4.85904026031494*x_64 - 7.49032020568848, 2) - 5.0734099840241e-5*std::pow(-4.05999994277954*x_66 - 5.80347967147827, 2) - 1.0797139618528e-5*std::pow(-6.47735977172852*x_68 - 8.89960098266602, 2) + 3.10331122154245e-5*std::pow(-4.50415992736816*x_7 - 7.37455987930298, 2) - 7.56763189976667e-6*std::pow(-5.52303981781006*x_70 - 5.93503999710083, 2) + 4.89010787550547e-5*std::pow(-4.51783990859985*x_71 - 6.98280000686646, 2) + 2.90259049723714e-5*std::pow(-6.04655981063843*x_72 - 7.45879983901978, 2) + 6.97986315081881e-6*std::pow(-4.88303995132446*x_73 - 6.30624008178711, 2) - 1.0195683710995e-5*std::pow(-5.61847972869873*x_74 - 9.03551959991455, 2) + 2.48304090653622e-5*std::pow(-6.10015964508057*x_75 - 8.54423999786377, 2) + 1.7204329076686e-5*std::pow(-4.85663986206055*x_75 - 7.2629599571228, 2) - 2.4415391901763e-6*std::pow(-5.75799989700317*x_77 - 6.99304008483887, 2) + 2.08780588885763e-5*std::pow(-5.51904010772705*x_82 - 7.76719999313354, 2) - 8.16409621266222e-6*std::pow(-6.52063989639282*x_83 - 9.15176010131836, 2) + 3.0409114181021e-5*std::pow(-5.5021595954895*x_83 - 7.13471984863281, 2) + 4.63820915067709e-6*std::pow(-7.79527997970581*x_85 - 9.79351997375488, 2) + 2.31978739561329e-5*std::pow(-3.08799982070923*x_86 - 4.93535995483398, 2) + 2.68630158273198e-6*std::pow(-7.49096012115479*x_87 - 9.92399978637695, 2) - 3.90083257427996e-5*std::pow(-5.73847961425781*x_87 - 7.79936027526855, 2) + 1.26637544121415e-5*std::pow(-4.00183963775635*x_87 - 5.6003999710083, 2) - 0.00456157931165285*std::exp(0.019174650885233*x_1 - 0.0365624117150542*x_10 + 0.0238721776855353*x_100 - 0.00216359917210018*x_101 - 0.0046961617500549*x_102 + 0.00142363937675295*x_103 - 0.000536953210640879*x_106 + 0.0153671599974188*x_11 + 0.0242296484639685*x_110 - 0.000937920899139898*x_112 - 0.00286192562498029*x_113 + 0.00154623065975776*x_115 - 0.0143094850228602*x_116 - 0.0264190172417159*x_12 - 0.00122630111184951*x_13 + 0.0132283726942749*x_14 - 0.00278968793653611*x_17 - 0.00189136170767487*x_18 + 0.0149093319266363*x_19 - 0.0171581286509935*x_2 + 0.00944102404355985*x_20 + 0.00528405744782859*x_21 - 0.057624140268795*x_25 - 0.000108580456809964*x_26 - 0.01546405423866*x_27 - 0.0044761006822818*x_28 + 0.00122651715606431*x_29 + 0.0106521455168141*x_30 + 0.0129300246809181*x_31 - 0.0226655988189007*x_33 - 0.00149334272340594*x_36 + 0.00494762253400396*x_37 + 0.00617265344675952*x_39 + 0.0514756826165806*x_4 - 0.0302059057799143*x_40 - 0.00198129916830374*x_42 - 0.000723436379961875*x_46 - 0.0311228138379804*x_48 + 0.0214340711711233*x_5 + 0.0140578784077529*x_50 + 0.00094141557999603*x_51 - 0.0018580062599505*x_53 - 0.000625476896984808*x_54 - 0.0286111008293772*x_58 - 0.00316803120994332*x_6 + 1.47094002974721e-5*x_61 + 0.00101772607586284*x_62 + 0.0183652434686187*x_63 + 0.000328569250488364*x_64 + 0.00640441464867674*x_66 + 0.00380057248348431*x_68 + 0.0300989822763186*x_70 + 0.00267458069218152*x_72 - 0.000729316174243768*x_77 - 0.00812496888074885*x_78 - 0.000155568668286476*x_79 + 0.000166394064150114*x_82 - 0.00273474259544876*x_83 - 0.00064191562074473*x_85 - 0.00113492172080592*x_86 - 0.000357919489124694*x_87 + 0.0090701116673906*x_88 - 0.000875855566126805*x_89 + 0.0432047373187651*x_91 + 0.000662186273888691*x_92 + 0.00208896248686926*x_94 + 0.0279002854475263*x_97 + 0.00221603908615717*x_99 - 0.000196076951002634*std::pow(-7.84783983230591*x_108 - 9.05935955047607, 2) + 0.000457650378726304*std::pow(-6.35599994659424*x_23 - 8.75072002410889, 2) + 0.000180599063289655*std::pow(-5.26968002319336*x_44 - 9.51232051849365, 2) - 0.000240060297103883*std::pow(-5.50551986694336*x_55 - 7.75392007827759, 2) + 0.00211618738355135*std::pow(-1.89527988433838*x_56 - 2.83895993232727, 2) - 0.000233346728346025*std::pow(-5.30559968948364*x_60 - 6.09144020080566, 2) - 0.00218141159828356*std::pow(-2.09295964241028*x_69 - 3.34831976890564, 2) + 0.00162777953158005*std::pow(-3.77760004997253*x_7 - 5.96271991729736, 2) - 0.000294254857086479*std::pow(-6.29328012466431*x_71 - 9.53400039672852, 2) - 0.000408897054066604*std::pow(-5.11975955963135*x_73 - 7.37648010253906, 2) + 0.000253337451484377*std::pow(-6.23928022384644*x_76 - 8.45512008666992, 2) + 0.000122672301395132*std::pow(-4.61711978912354*x_80 - 6.62912034988403, 2) + 4.33259210467288e-5*std::pow(-9.80399990081787*x_81 - 9.96455955505371, 2) + 0.000371189933174296*std::pow(-5.6814398765564*x_90 - 8.55256080627441, 2) + 0.020325024997993*std::exp(0.754959881305695*x_22) - 0.138728397487764*std::sin(0.376479834318161*x_104 + 5.18048000335693) + 0.18124327103186*std::sin(0.388559848070145*x_105 + 1.97791981697083) - 0.234843915941596*std::sin(0.314319938421249*x_107 + 5.11247968673706) - 0.104091757327847*std::sin(0.435439854860306*x_109 + 5.23640012741089) - 0.300872418495167*std::sin(0.371999859809875*x_111 + 5.18032026290894) - 0.366458311561502*std::sin(0.244079977273941*x_114 + 5.04392004013062) + 0.267632416713937*std::sin(0.405839860439301*x_117 + 5.1910400390625) + 0.140824788159872*std::sin(0.266799956560135*x_118 + 5.07727956771851) + 0.141461515255699*std::sin(0.36575984954834*x_119 - 1.21287977695465) - 0.201300179780723*std::sin(0.463279873132706*x_120 - 1.14679980278015) - 0.414496169470837*std::sin(0.393119841814041*x_15 + 2.19063997268677) - 0.147011038197917*std::sin(0.365359842777252*x_16 + 2.14367985725403) + 0.522676070623973*std::sin(0.317679941654205*x_24 + 8.35151958465576) + 0.228305969610055*std::sin(0.32847985625267*x_3 - 1.05927979946136) + 0.351167404866857*std::sin(0.268079966306686*x_32 - 7.42328023910522) + 0.474597834745722*std::sin(0.361279845237732*x_34 + 1.99055981636047) + 0.305551451007013*std::sin(0.31743985414505*x_35 - 1.20303988456726) + 0.857792584289029*std::sin(0.149600028991699*x_38 + 4.92015981674194) - 0.304179374149314*std::sin(0.315199851989746*x_41 + 5.12504005432129) - 0.187760505348258*std::sin(0.331439822912216*x_43 + 5.13816022872925) + 0.238533876506068*std::sin(0.321199834346771*x_45 - 7.46703958511353) + 0.31517278875652*std::sin(0.298079937696457*x_47 + 5.12423944473267) + 0.225966516117815*std::sin(0.314719915390015*x_49 - 7.46687984466553) - 0.365041107616264*std::sin(0.229279980063438*x_52 + 5.04008007049561) - 0.18616996903387*std::sin(0.266399949789047*x_57 - 7.50400018692017) + 0.205520849121086*std::sin(0.374879837036133*x_59 + 1.95975983142853) - 0.560442526405495*std::sin(0.282159924507141*x_65 + 5.1081600189209) - 1.48328037832317*std::sin(0.166320025920868*x_67 + 4.94535970687866) - 2.01606972843814*std::sin(0.121280059218407*x_74 + 4.8842396736145) + 0.697620211135259*std::sin(0.225279986858368*x_75 - 7.56712007522583) - 0.475129443134392*std::sin(0.257999956607819*x_8 - 4.33247995376587) + 0.407321109000762*std::sin(0.294639945030212*x_84 - 7.47824001312256) + 0.0319312717849973*std::sin(0.677919805049896*x_9 - 6.93639993667603) - 0.364560044913034*std::sin(0.362159848213196*x_93 - 7.41519975662231) - 0.0807863991373097*std::sin(0.33111983537674*x_95 + 8.16551971435547) - 0.137508857299164*std::sin(0.392399847507477*x_96 - 7.41631984710693) - 0.161872808675781*std::sin(0.319759905338287*x_98 + 1.9171998500824)) + 0.0114458336273955*std::sin(0.221119984984398*x_1 + 5.20879983901978) + 0.0448954782672994*std::sin(0.241199970245361*x_10 - 7.54232025146484) - 0.0189591515021368*std::sin(0.320959836244583*x_101 + 5.14448022842407) + 0.0032477675096931*std::sin(0.403039842844009*x_102 + 1.98351979255676) + 0.00803543516258122*std::sin(0.388159841299057*x_104 - 7.40119981765747) - 0.00645435430699375*std::sin(0.322239845991135*x_105 - 1.24519991874695) - 0.00671705720549447*std::sin(0.345919847488403*x_106 + 1.94127976894379) + 0.00834124687335226*std::sin(0.391999840736389*x_106 - 7.40279960632324) - 0.00449337317415894*std::sin(0.386559844017029*x_107 - 7.42159986495972) - 0.0261312595333193*std::sin(0.37951985001564*x_108 - 7.40759992599487) + 0.00728702283856779*std::sin(0.32151985168457*x_109 - 7.4521598815918) + 0.0125904955516807*std::sin(0.19743999838829*x_110 + 1.78303980827332) + 0.00324600782189744*std::sin(0.364959836006165*x_110 + 5.18104028701782) - 0.00819111929263296*std::sin(0.326559841632843*x_111 - 4.26839971542358) - 0.0113252337881452*std::sin(0.332879841327667*x_112 - 4.2545599937439) - 0.0054884215523183*std::sin(0.368799835443497*x_112 + 1.98655986785889) + 0.00488724070955649*std::sin(0.376959830522537*x_113 + 1.98927986621857) + 0.0133558913329892*std::sin(0.366399854421616*x_114 - 7.43375968933105) - 0.00666334315074722*std::sin(0.205520004034042*x_115 - 7.59376001358032) + 0.0136675579749929*std::sin(0.228079989552498*x_115 + 1.83607995510101) - 0.0121000458764476*std::sin(0.249359980225563*x_12 + 8.27031993865967) - 0.0936342360972262*std::sin(0.138080030679703*x_14 + 8.09639930725098) + 0.00664758991787232*std::sin(0.293359935283661*x_16 - 4.28935956954956) + 0.0347535632590192*std::sin(0.315119922161102*x_16 - 4.26247978210449) + 0.0247125273601492*std::sin(0.296239942312241*x_21 - 4.29503965377808) + 0.0104155174448952*std::sin(0.363199830055237*x_21 - 4.21568012237549) + 0.0246010398758178*std::sin(0.134160041809082*x_23 - 4.49503993988037) + 0.0177644001093837*std::sin(0.29807984828949*x_23 - 4.32223987579346) + 0.0081170050252022*std::sin(0.465839862823486*x_24 + 8.48311996459961) - 0.012219264125232*std::sin(0.297679930925369*x_26 + 5.10839986801147) + 0.00852212331204001*std::sin(0.360559850931168*x_27 + 5.16951990127563) - 0.0166567989811318*std::sin(0.36287984251976*x_27 + 5.17112016677856) + 0.00935410655642155*std::sin(0.519679844379425*x_27 - 4.07424020767212) + 0.0100910709440553*std::sin(0.257439970970154*x_28 - 7.52328014373779) + 0.0120067331873097*std::sin(0.336719840764999*x_28 - 4.25856018066406) - 0.00817075007827741*std::sin(0.302319914102554*x_33 - 1.18495988845825) + 0.0229080309194779*std::sin(0.348319828510284*x_34 + 1.97575974464417) + 0.00678224602067673*std::sin(0.357759833335876*x_34 + 1.97135984897614) + 0.0292666334636418*std::sin(0.309519916772842*x_35 + 8.2775993347168) + 0.00854252769048809*std::sin(0.332799851894379*x_35 - 1.22799980640411) - 0.00315535729023017*std::sin(0.313519924879074*x_36 - 4.28071975708008) - 0.0191091634468663*std::sin(0.317359834909439*x_36 + 1.92511987686157) + 0.0119875635207187*std::sin(0.340159833431244*x_36 + 5.15488004684448) - 0.0137931801252763*std::sin(0.351599842309952*x_37 + 5.16336011886597) + 0.0168722393362321*std::sin(0.3713598549366*x_37 + 5.17824029922485) + 0.0113900438685069*std::sin(0.377359837293625*x_37 + 5.18239974975586) + 0.0348123737344257*std::sin(0.320479840040207*x_38 - 7.46943950653076) + 0.0104871074479943*std::sin(0.3574398458004*x_38 + 5.16215991973877) - 0.0187348338579555*std::sin(0.353839844465256*x_39 - 7.44127988815308) + 0.102039959416354*std::sin(0.132800042629242*x_40 + 4.9093599319458) - 0.00653859551115221*std::sin(0.309279918670654*x_43 + 5.13111972808838) + 0.0313363808345097*std::sin(0.34911984205246*x_43 + 5.14328002929688) + 0.0265304275430985*std::sin(0.307359933853149*x_44 - 7.48016023635864) + 0.0271292615156341*std::sin(0.27687993645668*x_45 - 7.51800012588501) + 0.00677679477370307*std::sin(0.298879951238632*x_45 - 7.48623991012573) - 0.0215788112611085*std::sin(0.306559920310974*x_47 + 5.11695957183838) + 0.0257088756609476*std::sin(0.251199960708618*x_48 + 5.06759977340698) + 0.00798893194602287*std::sin(0.273039966821671*x_49 + 1.8582398891449) + 0.000631056317392248*std::sin(1.0694397687912*x_5 - 6.76344013214111) - 0.00399669979967818*std::sin(0.367279857397079*x_50 + 5.15799999237061) + 0.00817269422585451*std::sin(0.323439836502075*x_51 - 4.28312015533447) - 0.0229517432684794*std::sin(0.20728000998497*x_53 + 4.99191951751709) + 0.00876833730294788*std::sin(0.273679941892624*x_53 + 5.08431959152222) + 0.00530903129989433*std::sin(0.270639955997467*x_54 + 5.09176015853882) - 0.0104046642390912*std::sin(0.22647999227047*x_56 + 5.04399967193604) + 0.0236303843621706*std::sin(0.157680034637451*x_57 + 4.92840003967285) + 0.00593728005911064*std::sin(0.347279846668243*x_59 - 4.26007986068726) + 0.0432804680276827*std::sin(0.247119963169098*x_60 - 7.52824020385742) + 0.00489741917863688*std::sin(0.218399986624718*x_63 + 8.20975971221924) + 0.0109522729337204*std::sin(0.287759929895401*x_65 + 5.12423992156982) - 0.0137616362714693*std::sin(0.20320001244545*x_69 + 4.98776006698608) - 0.0144392083423913*std::sin(0.358319848775864*x_7 + 8.53191947937012) + 0.00907583100544986*std::sin(0.235679984092712*x_74 + 5.03487968444824) + 0.0245096598533781*std::sin(0.274879962205887*x_74 - 7.51688003540039) - 0.0513107994179542*std::sin(0.175280019640923*x_78 + 4.95191955566406) + 0.0260356678279262*std::sin(0.157200023531914*x_8 - 4.46224021911621) - 0.00375832770388946*std::sin(0.29887992143631*x_80 + 5.11567974090576) + 0.00564392126094168*std::sin(0.385439842939377*x_81 - 4.21808004379272) + 0.0479269588860281*std::sin(0.13728004693985*x_84 + 4.90903997421265) - 0.0195554244186421*std::sin(0.186480015516281*x_85 - 7.60864019393921) + 0.00416236915475189*std::sin(0.333439826965332*x_88 - 4.27568006515503) - 0.0689788997295367*std::sin(0.129600048065186*x_9 - 4.49575996398926) - 0.0690784350022418*std::sin(0.222719997167587*x_9 - 4.3692798614502) - 0.0136971343081021*std::sin(0.325199842453003*x_93 + 1.97279977798462) - 0.0239041675822403*std::sin(0.332959830760956*x_93 + 1.98767983913422) + 0.00858910813467276*std::sin(0.358479827642441*x_93 - 7.410719871521) + 0.00941898236344569*std::sin(0.395199835300446*x_94 - 7.40279960632324) + 0.00315403712818747*std::sin(0.329999834299088*x_95 - 1.22255992889404) + 0.00529740705788786*std::sin(0.340319842100143*x_95 + 5.15104007720947) - 0.0215734622134936*std::sin(0.380959838628769*x_96 + 5.1799201965332) + 0.00952618073389527*std::sin(0.382799863815308*x_96 - 7.40703964233398) - 0.00206519868320832*std::sin(0.392799854278564*x_98 - 1.18863987922668) - 0.00406989006185429*std::sin(0.374879837036133*x_99 - 1.20063984394073) - 0.0134315623052611*std::sin(0.398159861564636*x_99 - 7.40623998641968) + 0.146398484706879*std::sin(-0.089628471374871*x_1 - 0.000352224224655293*x_100 + 0.00596836974414921*x_101 - 0.000347116571752158*x_102 + 0.000738618080040104*x_103 + 0.000600527168108076*x_104 + 0.0189295682856285*x_105 + 0.0101266758658565*x_106 - 0.00235094446669028*x_107 - 0.00124528836208481*x_108 + 0.00140983977919266*x_109 + 0.009602644726525*x_11 + 0.00477151760151672*x_110 + 0.00159199200702597*x_113 + 0.00105933196301679*x_114 + 0.00107873616998243*x_115 + 0.00164493315269961*x_116 + 1.16489300841443e-5*x_117 - 0.00105961086304083*x_118 + 0.00317204070414258*x_119 - 0.0661385377782909*x_12 - 0.00147152871899801*x_120 + 0.00518040253154749*x_13 - 0.0103904658751237*x_14 - 0.00357538963709801*x_15 + 0.0215822656843901*x_16 + 0.0349876151771034*x_17 + 0.00107951876945004*x_18 - 0.0150405043015845*x_2 + 0.00125790468468887*x_20 + 0.0130152120383264*x_22 - 0.000808260015299712*x_23 + 0.010539807234896*x_24 - 0.0143014863341102*x_25 + 0.00154364015297845*x_26 + 0.000911117525397197*x_30 + 0.00314717708144727*x_31 - 0.00750189699283337*x_32 + 0.000920694089577765*x_33 - 0.0031435819396646*x_34 + 0.00603672101768742*x_36 - 0.00218379538294771*x_38 - 0.0238241283989731*x_39 + 0.000265825924045553*x_40 - 0.00753682755980473*x_41 + 0.0269386449990766*x_42 + 0.000353470550844193*x_43 + 0.00136187163106022*x_44 - 0.00634047139737851*x_45 - 0.000125051002952021*x_46 + 0.0130760028455861*x_47 - 0.00184844238111865*x_48 - 0.00950678782402602*x_49 + 0.000916017532247429*x_5 - 9.24748814349098e-5*x_50 - 0.00123188439807545*x_51 - 0.000675567303367512*x_52 + 0.00117771826139402*x_53 + 0.00141507472272175*x_54 + 0.000152406906281218*x_55 + 0.00137817607055875*x_56 - 0.000896110058781959*x_57 + 0.00472528969338176*x_58 - 0.00506033894641193*x_59 + 0.0336513584690514*x_6 + 0.000572177926578744*x_60 - 0.00992399907592005*x_61 + 0.000305978489506232*x_62 + 0.000906460823505812*x_63 - 0.000345253744705622*x_64 - 0.000428566247228311*x_66 - 0.0186708238268685*x_67 - 0.01369889945534*x_68 + 2.66557038498687e-5*x_69 + 0.000963865113477804*x_70 - 0.000779691281298998*x_71 - 0.000880575837427817*x_72 - 0.00640479500714129*x_73 - 0.00117825799671782*x_74 - 0.000552781817695127*x_75 + 0.0172062432548014*x_76 + 0.00161188819434595*x_77 + 0.00266307084610653*x_78 + 0.0200099552247117*x_8 - 0.00358825116992794*x_80 + 0.00180454164030181*x_81 + 4.36098702760898e-5*x_82 + 0.00201931666784717*x_83 + 0.0125013634850231*x_84 + 5.59189159075865e-5*x_85 + 0.00431437274642023*x_86 + 0.00139015807596979*x_87 + 0.000425933782275683*x_88 - 0.000251492025571498*x_90 - 0.0143772785514983*x_91 + 0.00948599834785216*x_94 + 0.00440142869555648*x_96 - 0.0019861936017906*x_97 - 0.0160373636834319*x_98 + 0.000145071989036888*std::pow(-6.58143997192383*x_37 - 9.56688022613525, 2) - 0.00159467191318193*std::pow(-5.15975999832153*x_4 - 8.7344799041748, 2) - 0.00136248252993196*std::pow(-4.27399969100952*x_7 - 6.91639995574951, 2) + 9.72731297983961e-5*std::pow(-6.51543998718262*x_79 - 9.14416027069092, 2) + 0.000349611715827331*std::pow(-6.34912014007568*x_89 - 9.13704013824463, 2) + 0.000153991891694488*std::pow(-5.93959999084473*x_99 - 7.78736019134521, 2) + 0.419059687741358*std::sin(0.34215983748436*x_10 - 1.05311977863312) - 0.334243391756164*std::sin(0.22647999227047*x_111 + 5.04263973236084) + 0.173642480664816*std::sin(0.33519983291626*x_112 + 5.14775991439819) + 0.900546336123348*std::sin(0.181920006871223*x_19 - 4.4191198348999) - 0.19319639947845*std::sin(0.318959832191467*x_21 + 5.13607978820801) + 0.80174470858821*std::sin(0.310239940881729*x_27 + 5.1334400177002) + 0.324574029154004*std::sin(0.262639969587326*x_28 + 5.06967973709106) - 0.0106575788361754*std::sin(0.849039852619171*x_29 - 3.96919989585876) - 0.56102408929442*std::sin(0.372319847345352*x_3 - 1.03087985515594) - 0.42946807932487*std::sin(0.29615992307663*x_35 + 8.26560020446777) - 0.540662208734144*std::sin(0.149120032787323*x_65 + 4.93391990661621) - 0.454283338388024*std::sin(0.372239857912064*x_9 - 1.00943982601166) - 0.41239284327626*std::sin(0.372079849243164*x_92 + 1.99183976650238) - 0.31192441074754*std::sin(0.351759850978851*x_93 + 1.96647977828979) - 0.159146402921611*std::sin(0.279039949178696*x_95 - 7.51416015625) + 10.0756833998878) + 0.586054513905802);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
