
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0402833280991362*x_1 + 0.751336706398807*x_10 + 1.02261074583535*x_100 - 7.02480428486898*x_101 + 0.233021219653565*x_102 + 3.51330900304643*x_103 + 0.0202198837236276*x_104 - 0.790239360987343*x_105 - 0.130323339168013*x_106 + 0.516047164627033*x_107 - 1.90777335732793*x_108 + 1.76163838084056*x_109 + 0.987590890845263*x_11 - 1.28587135141629*x_110 - 0.0299342922423297*x_111 - 0.00610862692413828*x_112 - 0.318037782600893*x_113 - 0.0434344647605235*x_114 - 1.30506533026906*x_115 - 0.111541106229352*x_116 - 0.0625670463061602*x_117 + 0.186014901068457*x_118 - 0.0221411235593387*x_119 + 3.3333076180299*x_12 + 0.214883419613603*x_120 - 0.147992124177945*x_13 + 4.75171716347964*x_14 + 5.06502202527817*x_15 - 0.847601538965068*x_16 + 1.15937301356485*x_17 + 0.118010829579266*x_18 - 2.3303124647987*x_19 + 1.22917990398621*x_2 + 6.91717676914882*x_20 + 1.4026026269651*x_21 + 0.464473414656332*x_22 + 4.43491278746801*x_23 + 0.0242524341194632*x_24 - 0.866166618889026*x_25 - 0.115302909658682*x_26 - 0.481376344149053*x_27 - 0.0478205102260155*x_28 - 1.04593938183066*x_29 + 1.84355533890087*x_3 - 0.381655934800036*x_30 - 6.45079021426622*x_31 - 3.58346688662203*x_32 - 1.07834784014258*x_33 - 2.23971923652551*x_34 + 1.63172899955393*x_35 - 0.0180562894283528*x_36 - 0.230216860461227*x_37 - 1.59477688249542*x_38 - 1.77028384533602*x_39 - 1.07470638099993*x_4 + 0.620781361206547*x_40 + 0.0467125572731744*x_41 - 1.20971948182137*x_42 + 0.894761806058169*x_43 + 4.62781202866102*x_44 - 1.01779170533797*x_45 + 2.95780912652121*x_46 + 0.261068534444263*x_47 - 1.07569752636362*x_48 + 0.0927298054459922*x_49 - 1.64020098969416*x_5 + 0.12099376077741*x_50 - 1.01324258527718*x_51 - 2.07392162579964*x_52 + 0.813122618337141*x_53 - 1.51067830440288*x_54 - 1.63575549854407*x_55 + 0.935067870184579*x_56 - 0.118629155693947*x_57 + 0.00467254004285587*x_58 - 0.0161682693290939*x_59 - 0.791825209139515*x_6 - 0.264525791100302*x_60 - 5.46591751569637*x_61 + 58.1134534689816*x_62 + 1.35299480957744*x_63 - 0.760445764596331*x_64 - 1.00064044989837*x_65 - 0.109181209421877*x_66 + 0.939703407738376*x_67 + 2.21687914027008*x_68 + 3.00143203865761*x_69 + 1.29880746935483*x_7 + 0.130213307003431*x_70 + 2.12901132663213*x_71 + 1.16392976165485*x_72 + 0.0441383750214403*x_73 + 6.54492935406796*x_74 + 0.0507669848965992*x_75 - 1.22627182879527*x_76 - 4.63705242260145*x_77 + 1.71494186545275*x_78 + 0.0334729507088666*x_79 - 5.29210491985888*x_8 + 1.02626135916208*x_80 - 0.187156436750173*x_81 + 0.359793096161419*x_82 - 0.0369945364185004*x_83 + 0.0274831298212634*x_84 - 0.689553353097087*x_85 - 1.76521208630454*x_86 - 0.0322776293780981*x_87 - 0.0142303394920513*x_88 + 3.48659830310171*x_89 + 4.28133655406201*x_9 - 1.49170492253241*x_90 - 3.80788871736212*x_91 + 0.0182521652370543*x_92 - 10.2311967727617*x_93 - 1.04409789050039*x_94 + 0.750281412323223*x_95 - 0.0631812958320223*x_96 + 4.0029407518092*x_97 - 0.672123578147254*x_98 - 0.0539224878122937*x_99 + 0.0233753517134464*std::pow(-7.36319971084595*x_106 - 7.55671977996826, 2) - 0.000239355786327195*std::pow(-5.29512023925781*x_108 - 7.73583984375, 2) + 0.565484536792837*std::pow(-0.582399845123291*x_108 - 0.778079867362976, 2) - 3.87298088197032e-5*std::pow(-7.56576013565063*x_109 - 9.54831981658936, 2) - 0.00619672693101985*std::pow(-6.31343984603882*x_11 - 9.7729606628418, 2) - 0.0117278425320833*std::pow(-8.15095996856689*x_116 - 8.55615997314453, 2) - 0.00124814772578027*std::pow(-7.33599996566772*x_118 - 8.55144023895264, 2) + 0.00567774661509297*std::pow(-6.34631967544556*x_120 - 8.5252799987793, 2) + 0.000357434674605454*std::pow(-4.97463989257813*x_120 - 5.7960000038147, 2) - 9.45733456980607e-5*std::pow(-5.00879955291748*x_13 - 7.81375980377197, 2) + 2.47809908556189e-5*std::pow(-5.29879999160767*x_15 - 5.5019998550415, 2) + 8.76120134264751e-5*std::pow(-5.08487987518311*x_15 - 7.32096004486084, 2) + 0.00225364367947151*std::pow(-8.73536014556885*x_18 - 9.75536060333252, 2) + 7.2822826507664e-5*std::pow(-6.31343984603882*x_19 - 9.57096099853516, 2) + 0.00490606567860041*std::pow(-7.01279973983765*x_23 - 9.21599960327148, 2) + 0.000133290892581385*std::pow(-6.67776012420654*x_24 - 9.96127986907959, 2) + 0.0164300071035951*std::pow(-4.61759996414185*x_24 - 6.62983989715576, 2) - 5.94034193965902e-5*std::pow(-7.44783973693848*x_27 - 8.82520008087158, 2) - 0.032467934108115*std::pow(-5.21519994735718*x_39 - 6.82528018951416, 2) + 2.71710682732923e-5*std::pow(-6.29800033569336*x_4 - 9.95495986938477, 2) + 0.000483997910849472*std::pow(-4.83800029754639*x_44 - 6.05071973800659, 2) - 0.00255061663015497*std::pow(-5.75367975234985*x_47 - 7.59768009185791, 2) + 9.34035967870074e-5*std::pow(-6.32687997817993*x_5 - 9.3877592086792, 2) - 5.27073250098006e-5*std::pow(-7.51128005981445*x_50 - 8.1159200668335, 2) + 0.00177769588544097*std::pow(-7.70344018936157*x_59 - 9.92232036590576, 2) - 0.000861401438753557*std::pow(-6.26208019256592*x_59 - 9.90112018585205, 2) - 9.13204852195486e-5*std::pow(-4.89711999893188*x_6 - 7.75040006637573, 2) - 0.000254986165126587*std::pow(-8.05943965911865*x_64 - 9.632080078125, 2) - 7.15071685062331e-5*std::pow(-3.31583976745605*x_66 - 4.76936006546021, 2) + 0.00547388582906871*std::pow(-5.33400011062622*x_67 - 5.12992000579834, 2) + 0.000141357761264584*std::pow(-4.89463996887207*x_7 - 6.54287958145142, 2) + 9.47276497219309e-5*std::pow(-6.32664012908936*x_70 - 8.89144039154053, 2) + 0.026772341755146*std::pow(-5.72743988037109*x_70 - 7.97160005569458, 2) - 7.66920784586603e-5*std::pow(-6.03951978683472*x_72 - 8.25783920288086, 2) + 0.000445316479797569*std::pow(-5.92343997955322*x_72 - 7.55639982223511, 2) + 0.003222648308849*std::pow(-5.51567983627319*x_72 - 6.31112003326416, 2) + 0.00370703201912903*std::pow(-5.3295202255249*x_72 - 7.79544019699097, 2) - 0.00211769165755354*std::pow(-5.7279200553894*x_73 - 7.8930401802063, 2) - 5.55233130204721e-5*std::pow(-7.48496007919312*x_74 - 9.9323205947876, 2) + 0.00975017840179615*std::pow(-5.3471999168396*x_74 - 6.92751979827881, 2) - 0.00043806887376213*std::pow(-6.85536003112793*x_77 - 8.66800022125244, 2) - 0.0171718971654208*std::pow(-4.26240015029907*x_78 - 5.81343936920166, 2) - 0.0203279579637442*std::pow(-7.15487957000732*x_81 - 9.58255958557129, 2) + 3.11499156512547e-5*std::pow(-8.56280040740967*x_84 - 8.97383975982666, 2) - 0.000484890779711713*std::pow(-8.34360027313232*x_84 - 8.74335956573486, 2) - 3.35531997576665e-6*std::pow(-7.32399988174438*x_84 - 6.70928001403809, 2) + 8.7160624750363e-5*std::pow(-5.07727956771851*x_86 - 7.30615997314453, 2) + 0.0113329609544276*std::pow(-4.13991975784302*x_87 - 5.91967964172363, 2) - 0.0169399902058748*std::pow(-8.75607967376709*x_88 - 9.97624015808105, 2) + 2.25510936855061e-6*std::pow(-8.0033597946167*x_88 - 9.20728015899658, 2) + 0.00206989288747198*std::pow(-2.1943998336792*x_88 - 2.17791986465454, 2) + 0.000240102333237448*std::pow(-3.1781599521637*x_90 - 4.56775999069214, 2) - 0.000125426651566315*std::pow(-5.24519968032837*x_99 - 6.02455997467041, 2) + 0.0308345641112821*std::exp(0.702079832553864*x_1) + 0.00129902629500065*std::exp(1.08351981639862*x_1) + 7.96391521468419e-5*std::exp(1.19423997402191*x_1) + 0.0335788333878072*std::exp(1.22735989093781*x_1) - 4.61331398237244e-6*std::exp(1.28807985782623*x_1) - 0.00653971429401251*std::exp(1.19983983039856*x_100) - 6.38134104526796e-5*std::exp(1.62295985221863*x_100) + 0.0278488100921681*std::exp(0.515199840068817*x_103) - 0.190299804429788*std::exp(0.528799831867218*x_104) - 0.0856508677060921*std::exp(1.06327986717224*x_104) + 0.203428288889481*std::exp(0.650879800319672*x_106) + 0.00517768777448834*std::exp(0.665519833564758*x_106) + 0.00852750484620114*std::exp(0.792479872703552*x_106) + 1.4543738322605*std::exp(1.33487987518311*x_106) + 0.555579825757873*std::exp(0.648639798164368*x_109) - 1.05860672672413*std::exp(0.855439901351929*x_110) - 0.00108818041014716*std::exp(1.08487975597382*x_110) + 4.19286465272104e-5*std::exp(1.55039989948273*x_110) + 0.000365268607690497*std::exp(1.59975981712341*x_110) - 0.837167744848221*std::exp(0.604959845542908*x_112) - 0.00220921655676907*std::exp(0.914159834384918*x_112) + 0.0105723085254333*std::exp(0.571999847888947*x_24) + 0.0470635534424203*std::exp(0.514479875564575*x_26) + 1.96453679464618*std::exp(0.62559986114502*x_26) - 0.0114835438413066*std::exp(0.643839836120605*x_26) + 0.000192930810137934*std::exp(0.829519867897034*x_26) - 0.0184521703480275*std::exp(0.874719858169556*x_26) + 0.000788123292419779*std::exp(0.913679838180542*x_26) - 6.29569002832456*std::exp(0.491599857807159*x_31) - 0.00593094738345671*std::exp(0.599999845027924*x_31) + 0.0303732407734866*std::exp(0.620239853858948*x_31) - 0.0156250314155156*std::exp(0.647599816322327*x_31) + 0.000576630347500279*std::exp(0.654319822788239*x_31) + 0.210483445839391*std::exp(0.655279815196991*x_31) - 0.3000006138494*std::exp(0.654959857463837*x_45) - 0.00399177725745176*std::exp(0.825759887695313*x_45) + 0.00736165511203079*std::exp(1.0123997926712*x_45) + 0.106444512901816*std::exp(1.11879980564117*x_45) + 3.97963308291097e-5*std::exp(1.23079991340637*x_45) + 0.311843095490237*std::exp(0.99375981092453*x_6) + 0.0338472833520894*std::exp(0.713119864463806*x_60) + 0.81991167615787*std::exp(0.968719840049744*x_60) + 0.0014291049225235*std::exp(1.24247992038727*x_60) + 1.57458345215895e-5*std::exp(1.45055985450745*x_66) - 0.0440784807101918*std::exp(1.66143977642059*x_66) - 9.54833831916299e-5*std::exp(0.718239843845367*x_70) - 0.00100082545715401*std::exp(0.895999848842621*x_70) - 0.0126793898211972*std::exp(0.875359892845154*x_72) - 0.00646613917337216*std::exp(0.97439980506897*x_74) + 0.0011786922150816*std::exp(1.0343998670578*x_74) - 0.00446345166006048*std::exp(1.24767982959747*x_74) + 9.99110070312481e-6*std::exp(1.71327984333038*x_74) + 1.36768431708306*std::exp(0.599999845027924*x_76) + 0.0138351668377076*std::exp(0.73831981420517*x_77) + 0.00743046559125902*std::exp(0.885519862174988*x_81) - 0.0252848268634623*std::exp(1.09175980091095*x_81) - 0.00999948746648616*std::exp(0.719999849796295*x_87) + 0.0576262655917251*std::sin(0.222879990935326*x_1 - 1.19911992549896) + 3.55624833649454*std::sin(0.184960007667542*x_10 + 1.76799988746643) + 7.41069441573927*std::sin(0.330879837274551*x_10 - 7.47408008575439) - 1.17209456925949*std::sin(0.372159838676453*x_100 - 7.40847969055176) + 0.098520505699997*std::sin(0.155280038714409*x_102 - 7.65199995040894) + 6.80473314492859*std::sin(0.298239946365356*x_102 - 7.52088022232056) - 0.0235699955215009*std::sin(0.342959851026535*x_102 - 7.44087982177734) + 0.53797440849519*std::sin(0.371279835700989*x_102 + 1.97439980506897) - 0.0753642622472982*std::sin(0.430479854345322*x_102 - 4.16527986526489) + 1.38870457558937*std::sin(0.445199847221375*x_102 + 5.23176002502441) - 0.0894559543882963*std::sin(0.314079850912094*x_103 - 7.47591972351074) - 17.8782980947382*std::sin(0.465919852256775*x_103 - 7.36799955368042) - 26.7963986418291*std::sin(0.487919867038727*x_104 - 4.14376020431519) + 2.45515600666835*std::sin(0.60919988155365*x_104 - 7.1910400390625) + 0.00911398541112702*std::sin(0.640159845352173*x_104 - 7.17999982833862) + 0.229752800933897*std::sin(0.263999968767166*x_105 + 1.85087990760803) + 3.11861754239587*std::sin(0.319519847631454*x_105 + 1.92879974842072) - 0.116564606758433*std::sin(0.355839848518372*x_105 - 7.42432022094727) - 0.0353178718259444*std::sin(0.357599824666977*x_105 - 7.44007968902588) - 0.516163180374549*std::sin(0.187360003590584*x_106 - 7.61688041687012) - 0.0237221519996053*std::sin(0.432319849729538*x_106 + 5.221360206604) + 42.4576042243218*std::sin(0.299039930105209*x_107 + 5.11175966262817) + 9.89006069024098*std::sin(0.363919854164124*x_107 - 7.4172797203064) + 0.0337707344052291*std::sin(0.44327986240387*x_107 + 5.22464036941528) - 0.829174239381871*std::sin(0.347679853439331*x_108 + 5.14847993850708) + 1.15417955298787*std::sin(0.663199841976166*x_108 + 2.2377598285675) - 0.646474119051471*std::sin(0.345519840717316*x_109 + 5.15944004058838) + 1.02562659160554*std::sin(0.375519841909409*x_110 + 5.1691198348999) + 0.00514181033029896*std::sin(0.590079843997955*x_110 - 7.21264028549194) - 5.70351955592077*std::sin(0.3572798371315*x_111 - 7.43255996704102) - 0.0137074071171624*std::sin(0.401119828224182*x_111 - 4.20544004440308) + 1.22282359434678*std::sin(0.439599871635437*x_111 - 1.17359983921051) + 0.0010701462458088*std::sin(0.456559866666794*x_111 + 8.23095989227295) + 7.23251653522949*std::sin(0.473359853029251*x_111 + 2.04543972015381) - 0.0258464098095394*std::sin(0.496959865093231*x_111 - 4.12064027786255) + 60.9374811273013*std::sin(0.198719993233681*x_112 + 4.99071979522705) + 0.0595789000538863*std::sin(0.353759855031967*x_112 - 7.41695976257324) + 0.0145308939925652*std::sin(0.411039859056473*x_112 - 0.981599867343903) + 1.89818813291254*std::sin(0.48583984375*x_112 + 5.23848009109497) - 0.577942793505534*std::sin(0.507519841194153*x_112 - 1.01695990562439) + 67.2503366181571*std::sin(0.304399937391281*x_113 - 7.4966402053833) + 10.998610384064*std::sin(0.345999836921692*x_113 - 7.43743991851807) - 0.0751961467706849*std::sin(0.268559962511063*x_114 - 7.53224039077759) + 7.00921511924368*std::sin(0.269199967384338*x_114 - 7.52320003509521) - 16.7185311326853*std::sin(0.367759823799133*x_114 - 7.42456007003784) + 0.189761139925099*std::sin(0.429439842700958*x_114 + 5.22695970535278) - 0.0016043091898416*std::sin(0.468559861183167*x_114 - 4.1592001914978) + 0.0263957745442321*std::sin(0.576479852199554*x_114 - 7.21895980834961) - 0.914870614259655*std::sin(0.665199875831604*x_114 + 5.43255996704102) + 0.116449065283597*std::sin(0.302079945802689*x_115 + 5.103919506073) - 7.93470376117966*std::sin(0.325759828090668*x_115 - 7.45439958572388) - 8.36519004337744*std::sin(0.416079849004745*x_115 + 5.22344017028809) + 0.0480053793071339*std::sin(0.48447984457016*x_115 - 4.12936019897461) + 0.0312869016547353*std::sin(0.534799814224243*x_115 + 5.36311960220337) + 1.195349805446*std::sin(0.435039848089218*x_116 + 8.42255973815918) - 2.75699176349562*std::sin(0.49839985370636*x_116 - 4.12344026565552) + 0.0858795774176888*std::sin(0.243599966168404*x_117 - 1.35351991653442) + 12.9415951025763*std::sin(0.376959830522537*x_117 + 1.97719979286194) - 0.0528637017662263*std::sin(0.378399848937988*x_117 + 5.1756796836853) + 6.45473140629988*std::sin(0.400079846382141*x_117 - 4.1864800453186) - 0.435722946588335*std::sin(0.616959869861603*x_117 - 3.99599981307983) + 0.518226865085714*std::sin(0.191840007901192*x_118 + 1.78999984264374) + 6.30837407906881*std::sin(0.408879846334457*x_118 + 5.20247983932495) + 0.0559242146085684*std::sin(0.419359862804413*x_118 + 5.21727991104126) + 0.0202779536469341*std::sin(0.289599925279617*x_119 - 4.28279972076416) - 3.22718051392457*std::sin(0.340479850769043*x_119 + 5.15120029449463) + 13.765467952343*std::sin(0.34895983338356*x_119 + 5.15208005905151) - 0.0255282933806633*std::sin(0.366079837083817*x_119 - 7.41511964797974) - 10.0814563806336*std::sin(0.434239864349365*x_119 + 1.99407982826233) + 2.15712562830817*std::sin(0.35471984744072*x_12 - 1.03167986869812) - 0.00232450288976355*std::sin(0.328399837017059*x_120 + 1.94799983501434) + 0.0437995877340892*std::sin(0.36695984005928*x_120 + 5.15912008285522) - 0.801126905706148*std::sin(0.427679866552353*x_120 + 5.2294397354126) - 20.0091089649845*std::sin(0.211919993162155*x_14 - 4.38903999328613) - 0.238433407015335*std::sin(0.272799968719482*x_16 + 5.08839988708496) + 0.0446972470779014*std::sin(0.368559837341309*x_16 + 5.15863990783691) + 1.50647603966902*std::sin(0.369679838418961*x_16 + 5.18168020248413) - 0.028654676982909*std::sin(0.427279859781265*x_18 - 0.954639852046967) + 0.0359337662498085*std::sin(0.348479837179184*x_20 - 4.25511980056763) + 9.40382971359099*std::sin(0.361199855804443*x_20 + 5.16968011856079) - 4.01214533981431*std::sin(0.357999831438065*x_21 + 8.36407947540283) + 13.9541132407999*std::sin(0.209600001573563*x_22 - 7.57504034042358) + 0.304643661941273*std::sin(0.502079844474792*x_22 + 2.10895967483521) - 0.0101908743453463*std::sin(0.589439868927002*x_22 - 7.22200012207031) - 2.59303310855835*std::sin(0.162880018353462*x_24 + 4.93567991256714) + 0.00787418146328528*std::sin(0.182560011744499*x_24 + 4.98351955413818) - 0.0754795319297211*std::sin(0.190160006284714*x_24 - 7.60288000106812) - 2.54071347957563*std::sin(0.338639855384827*x_24 - 4.25832033157349) + 0.00785795150988128*std::sin(0.46111986041069*x_25 - 4.13752031326294) + 0.0720772601744207*std::sin(0.186080008745193*x_26 - 7.6005597114563) - 0.18665429659603*std::sin(0.137440040707588*x_27 + 4.9017596244812) + 26.4785451072953*std::sin(0.171120017766953*x_27 - 7.6241602897644) + 0.267105252084509*std::sin(0.301679939031601*x_27 + 5.12080001831055) + 35.8202796686469*std::sin(0.303999930620193*x_27 + 5.13247966766357) - 0.0896603171227531*std::sin(0.319839835166931*x_28 - 4.28064012527466) - 7.33354289872068*std::sin(0.320079833269119*x_28 - 4.28864002227783) + 9.86084731128959*std::sin(0.322399854660034*x_28 - 4.28247976303101) + 0.0289936140314694*std::sin(0.326319843530655*x_28 + 5.13312005996704) - 19.8866393509786*std::sin(0.331519842147827*x_28 - 4.27248001098633) - 0.0720510113166627*std::sin(0.33247983455658*x_28 - 4.26847982406616) + 0.0602739069997766*std::sin(0.285919934511185*x_3 + 5.08111953735352) + 2.70358305800755*std::sin(0.294319927692413*x_3 + 5.10839986801147) - 3.57165789911652*std::sin(0.307759910821915*x_3 - 7.5032000541687) + 26.2999456555435*std::sin(0.261199980974197*x_30 - 7.53352022171021) - 6.18259602566695*std::sin(0.27295994758606*x_30 - 4.32471990585327) + 0.172412048262516*std::sin(0.279999971389771*x_30 - 4.29591989517212) - 15.8339328397525*std::sin(0.360319852828979*x_31 + 5.10487985610962) - 17.2858074063811*std::sin(0.255839973688126*x_32 - 4.40239953994751) - 0.20523129284287*std::sin(0.348479837179184*x_32 + 8.2469596862793) + 0.239155645660786*std::sin(0.322319835424423*x_33 + 8.19719982147217) + 0.0517078046221413*std::sin(0.351519852876663*x_34 + 2.00215983390808) - 0.18791933817317*std::sin(0.313519835472107*x_35 + 1.97631978988647) + 0.0789263167001093*std::sin(0.315679848194122*x_35 + 1.98063981533051) + 7.27290905660993*std::sin(0.317599833011627*x_35 - 7.43431997299194) - 7.81580684742625*std::sin(0.318319827318192*x_35 - 7.43311977386475) + 0.046886051746494*std::sin(0.319839835166931*x_35 - 7.42831993103027) - 0.199014007014018*std::sin(0.319919854402542*x_35 - 7.42831993103027) - 0.119597839450259*std::sin(0.321919858455658*x_35 - 7.42599964141846) - 0.0756056150298848*std::sin(0.331519842147827*x_36 - 4.25288009643555) + 3.74838534843036*std::sin(0.352959841489792*x_36 + 5.1637601852417) + 2.97812851696603*std::sin(0.373759835958481*x_36 - 7.41639995574951) + 0.0158069250198925*std::sin(0.380639851093292*x_36 - 7.39903974533081) - 8.98865636669229*std::sin(0.393519848585129*x_36 - 4.2052001953125) - 0.596433477596878*std::sin(0.418559849262238*x_36 + 5.22079992294312) - 6.48487029405873*std::sin(0.293359935283661*x_37 + 5.09615993499756) - 0.0739047321069726*std::sin(0.298719942569733*x_37 - 7.50471973419189) - 26.8008089678668*std::sin(0.36303985118866*x_37 - 4.24047994613647) - 0.209852874181628*std::sin(0.364959836006165*x_37 - 7.42208003997803) - 4.77834698781976*std::sin(0.401439845561981*x_37 - 4.20695972442627) + 0.0345043954572204*std::sin(0.48039984703064*x_38 + 5.25888013839722) - 0.0231564498340601*std::sin(0.665279865264893*x_38 + 2.20815992355347) + 7.07017185564496*std::sin(0.19743999838829*x_39 + 4.99631977081299) - 0.427858819321078*std::sin(0.350079834461212*x_39 + 5.16296005249023) - 0.193627073895494*std::sin(0.334239840507507*x_40 - 4.27408027648926) - 0.0907843534148599*std::sin(0.390239834785461*x_40 + 8.37495994567871) + 0.137149495065786*std::sin(0.312159925699234*x_41 + 1.89567983150482) + 5.86486314242052*std::sin(0.375519841909409*x_41 + 5.17112016677856) - 28.9413143517144*std::sin(0.406959861516953*x_41 - 7.39175987243652) - 0.0438372843446385*std::sin(0.431519865989685*x_41 - 7.38671970367432) - 27.3486763530855*std::sin(0.121520057320595*x_42 + 1.70983994007111) - 37.1672020110893*std::sin(0.369279831647873*x_43 - 7.41183996200562) + 0.037923402057672*std::sin(0.380639851093292*x_43 - 4.22176027297974) - 1.14057410266723*std::sin(0.383359849452972*x_43 - 7.40655994415283) + 1.91987936754145*std::sin(0.440879851579666*x_43 - 7.37831974029541) + 5.75543797239255*std::sin(0.359359860420227*x_44 + 5.16416025161743) + 0.099011139861775*std::sin(0.407279849052429*x_46 + 5.21623992919922) + 1.53603952365531*std::sin(0.585599839687347*x_46 - 7.21920013427734) + 0.00574335790639387*std::sin(0.645839810371399*x_46 + 5.4171199798584) + 28.6187596877228*std::sin(0.208159998059273*x_47 - 7.59176015853882) - 32.4894968250405*std::sin(0.260319977998734*x_47 + 1.85655987262726) - 0.0263345594733853*std::sin(0.439279854297638*x_47 - 4.15232038497925) + 6.83290434790977*std::sin(0.424719870090485*x_48 - 4.17040014266968) - 0.19092056835685*std::sin(0.259919971227646*x_49 + 1.85903990268707) - 0.625452906551079*std::sin(0.437279850244522*x_49 - 7.35431957244873) + 14.7655722236095*std::sin(0.191200003027916*x_50 + 4.98799991607666) + 44.4696745239911*std::sin(0.321759849786758*x_50 - 7.47687959671021) + 8.33560120564801*std::sin(0.36559984087944*x_51 - 4.23184013366699) + 20.1877019050585*std::sin(0.212960004806519*x_53 + 5.00816011428833) + 7.72010748498172*std::sin(0.347519844770432*x_53 + 5.15128040313721) - 0.0455035131706234*std::sin(0.359999865293503*x_53 - 4.24272012710571) + 0.0116520927178821*std::sin(0.889279901981354*x_53 - 3.95743989944458) + 0.14539533195389*std::sin(0.319359838962555*x_54 + 1.90071976184845) - 3.15689010399467*std::sin(0.417919874191284*x_54 - 7.38679981231689) - 2.20314677470583*std::sin(0.487039864063263*x_54 - 1.10911989212036) - 0.0723446353829114*std::sin(0.658959865570068*x_54 - 3.96943998336792) - 5.24292301125229*std::sin(0.348079830408096*x_55 + 5.15960025787354) + 7.13590588860095*std::sin(0.403119832277298*x_55 + 8.38576030731201) - 0.0483860616338524*std::sin(0.441839843988419*x_55 - 4.14991998672485) - 0.103506532819546*std::sin(0.465039849281311*x_55 + 5.25047969818115) + 6.61710594141965*std::sin(0.322559833526611*x_56 + 1.92327988147736) - 0.963305096892242*std::sin(0.406159847974777*x_56 + 5.19504022598267) - 6.94074907242805*std::sin(0.428879857063293*x_57 - 4.16879987716675) - 0.0334339988651609*std::sin(0.448399841785431*x_57 - 4.15232038497925) - 13.4033222528994*std::sin(0.553839862346649*x_57 + 5.35767984390259) - 0.19241117605469*std::sin(0.853919863700867*x_57 + 5.62479972839355) - 2.78226605657692*std::sin(0.170960009098053*x_58 + 4.96247959136963) + 20.3858268647009*std::sin(0.209440007805824*x_58 + 5.00848007202148) - 0.316063963989079*std::sin(0.266239941120148*x_58 - 7.51327991485596) + 9.93619302886373*std::sin(0.2743199467659*x_58 + 5.07583951950073) - 0.0391314199248001*std::sin(0.348079830408096*x_58 + 5.15759992599487) + 7.46796793821261*std::sin(0.42223984003067*x_58 - 4.189040184021) + 0.044953067358252*std::sin(0.462799847126007*x_58 + 5.25392007827759) + 0.0904801993903986*std::sin(0.168560013175011*x_59 - 7.63191986083984) + 37.4967736477233*std::sin(0.251999974250793*x_59 - 7.52784013748169) - 0.120122742081326*std::sin(0.203199997544289*x_64 + 1.78175985813141) - 0.0973598472637962*std::sin(0.222240000963211*x_64 - 4.36191987991333) + 10.9161423982869*std::sin(0.228959992527962*x_64 - 4.36199951171875) + 0.00145725280466209*std::sin(0.339199841022491*x_64 - 7.4555196762085) - 8.63038422762838*std::sin(0.43495985865593*x_66 + 8.44768047332764) - 19.8873566116965*std::sin(0.243759974837303*x_67 - 7.55679988861084) + 24.3924625488872*std::sin(0.247279971837997*x_70 - 7.52800035476685) + 0.748069880146261*std::sin(0.439999878406525*x_70 - 4.15304040908813) + 0.0157701458159798*std::sin(0.624399840831757*x_70 - 3.97263979911804) - 0.118288636095015*std::sin(0.23063999414444*x_71 + 5.04759979248047) - 0.682702063008305*std::sin(0.214000001549721*x_72 + 5.00920009613037) + 58.4607823530956*std::sin(0.24959996342659*x_73 + 5.06479978561401) - 8.44389858230153*std::sin(0.342559844255447*x_73 - 4.26151990890503) - 0.00982402835056064*std::sin(0.451039850711823*x_73 - 4.15104007720947) + 0.599432800386673*std::sin(0.123040057718754*x_75 + 4.89031982421875) + 0.0256620947745284*std::sin(0.278559952974319*x_75 + 5.09087991714478) + 1.24133715497265*std::sin(0.409119844436646*x_75 - 7.38631963729858) + 9.36270401142925*std::sin(0.476879835128784*x_75 + 2.08039975166321) - 2.12256000133052*std::sin(0.540319859981537*x_75 + 5.16431999206543) + 51.3511143846522*std::sin(0.238319978117943*x_76 - 7.53840017318726) - 4.70777097028474*std::sin(0.393599838018417*x_78 + 8.3810396194458) + 0.0106187427793828*std::sin(0.486639857292175*x_78 + 5.28744029998779) - 11.3201206966821*std::sin(0.281759947538376*x_79 - 7.4986400604248) + 8.35086919030914*std::sin(0.332239836454391*x_79 + 5.12871980667114) - 29.3301121564736*std::sin(0.355119854211807*x_79 + 1.96583986282349) - 0.115607199600783*std::sin(0.249199971556664*x_8 - 4.33576011657715) - 2.50665882420975*std::sin(0.501679837703705*x_8 - 7.30711984634399) + 0.407455028582859*std::sin(0.389359831809998*x_81 + 8.37271976470947) + 24.038576008936*std::sin(0.214159995317459*x_82 - 7.57696008682251) + 0.290692937745872*std::sin(0.197359994053841*x_83 + 5.00008010864258) - 2.85283773611836*std::sin(0.201599985361099*x_83 + 5.0053596496582) + 0.00495730213434187*std::sin(0.263119965791702*x_83 + 1.87455987930298) - 0.0466002469894141*std::sin(0.319679915904999*x_83 - 7.46343994140625) + 32.1044171005416*std::sin(0.320559918880463*x_83 - 7.46808004379272) - 4.66446103632089*std::sin(0.322239845991135*x_83 - 7.4730396270752) + 5.11601052528476*std::sin(0.393679857254028*x_83 - 1.19831991195679) + 0.272284963759897*std::sin(0.140080034732819*x_84 - 7.67984008789063) - 0.665121059231148*std::sin(0.179360002279282*x_84 + 1.77599990367889) + 11.9850725329513*std::sin(0.23871998488903*x_84 - 7.55600023269653) + 0.0669119363733787*std::sin(0.278079956769943*x_84 + 5.09272003173828) + 21.7974059227967*std::sin(0.278479933738708*x_84 - 7.49608039855957) - 0.220067158887624*std::sin(0.187040001153946*x_85 + 4.98767995834351) - 1.20802162211386*std::sin(0.19064000248909*x_85 - 7.61648035049438) - 0.0871434758336506*std::sin(0.221919998526573*x_85 - 7.56135988235474) + 13.8180385539646*std::sin(0.230239987373352*x_85 - 7.55408048629761) - 0.0352565058419569*std::sin(0.524639844894409*x_86 - 7.27040004730225) + 9.8593253606584*std::sin(0.402799844741821*x_87 + 5.20991992950439) - 3.36432962265576*std::sin(0.417919844388962*x_87 - 4.18951988220215) + 0.014624083063469*std::sin(0.499039828777313*x_87 - 4.11488008499146) + 0.00742880783447328*std::sin(0.87447988986969*x_87 - 0.751359879970551) + 1.84068932980053*std::sin(0.219119995832443*x_89 + 1.8155198097229) - 1.17645203208383*std::sin(0.41023987531662*x_90 - 7.39207983016968) - 0.0601898457121482*std::sin(0.414639860391617*x_90 - 0.994639813899994) - 0.0755319697998347*std::sin(0.505279839038849*x_90 - 4.09320020675659) - 0.0217628902536497*std::sin(0.337039858102798*x_92 + 5.18400001525879) - 5.12823729520824*std::sin(0.341039836406708*x_92 + 5.20991992950439) + 0.124725239350443*std::sin(0.360079854726791*x_92 + 1.97791981697083) - 11.9724898026163*std::sin(0.360879838466644*x_92 + 2.00343990325928) - 0.0832396931613652*std::sin(0.363839834928513*x_92 - 7.38535976409912) - 49.733586589993*std::sin(0.365199834108353*x_92 + 1.99775981903076) + 0.0180510879382843*std::sin(0.381279855966568*x_92 + 1.97519981861115) + 0.277141710281915*std::sin(0.401679873466492*x_92 - 7.59008026123047) - 0.101674673283517*std::sin(0.374559849500656*x_94 - 1.18543982505798) - 0.163599573281944*std::sin(0.376239836215973*x_94 + 1.98399984836578) + 4.65631066765582*std::sin(0.386319845914841*x_94 - 7.40639972686768) + 15.1386947110455*std::sin(0.404079854488373*x_94 - 4.21031999588013) - 0.0239896182980118*std::sin(0.367999851703644*x_95 + 1.98935985565186) + 10.5320382644436*std::sin(0.382479846477509*x_95 - 7.39607954025269) + 0.00257840129591292*std::sin(0.376959830522537*x_96 - 4.22176027297974) - 1.79046060643628*std::sin(0.386959820985794*x_96 - 4.2021598815918) + 0.0216455724926013*std::sin(0.396319836378098*x_96 + 5.20240020751953) + 5.60237166181533*std::sin(0.398799866437912*x_96 - 7.3931999206543) - 9.81947737579451*std::sin(0.411679863929749*x_96 + 1.98543977737427) - 1.8234862472793*std::sin(0.326879858970642*x_97 + 5.13624000549316) - 3.34531961097293*std::sin(0.339759826660156*x_97 + 5.16359996795654) - 0.0144384202478092*std::sin(0.362479835748672*x_97 - 4.41720008850098) + 7.94477011382355*std::sin(0.403599858283997*x_97 + 5.19040012359619) + 0.0586611788513566*std::sin(0.518239855766296*x_97 + 2.16407990455627) + 0.00253134201826155*std::sin(0.395679831504822*x_98 - 4.19135999679565) - 0.981943585436281*std::sin(0.406559854745865*x_98 - 7.38751983642578) + 0.0253304020600032*std::sin(0.414239853620529*x_98 - 7.39607954025269) + 0.0714442833331821*std::sin(0.430639863014221*x_98 - 7.37799978256226) + 2.31425550215106*std::sin(0.433199852705002*x_98 - 7.38143968582153) - 23.984941086161*std::sin(0.382719844579697*x_99 - 7.42312002182007) - 0.258686346430641*std::sin(0.398159861564636*x_99 - 7.40983963012695) - 0.20734641693421*std::sin(0.402159839868546*x_99 - 4.20552015304565) - 1.21516247721213*std::sin(0.403039842844009*x_99 + 5.20864009857178) + 3.12230264402613*std::sin(0.415279865264893*x_99 - 4.19144010543823) + 785.98718349403);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0802110390957669*x_1 + 3.00624084293489*x_10 - 2.15061288948921*x_100 + 6.50778597490786*x_101 - 0.418297705470798*x_102 - 40.0466232652605*x_103 - 0.0113134113509363*x_104 + 1.68294764378434*x_105 - 0.0727302004611567*x_106 + 0.0773774709780365*x_107 + 3.29436456736261*x_108 - 9.73417832366544*x_109 - 0.946798669087468*x_11 + 2.14403970762174*x_110 - 0.00962681660930421*x_111 + 0.00952228926481786*x_112 + 3.62848580631124*x_113 - 0.0262543563167415*x_114 + 2.21494639338464*x_115 - 0.03736685668684*x_116 - 0.0115222208452024*x_117 + 8.88004347729802*x_118 - 0.00122560510944711*x_119 - 9.73311224913274*x_12 - 1.07097650032647*x_120 - 8.75078935634559*x_13 - 8.41651470217212*x_14 - 17.2647569387013*x_15 + 3.23881216720696*x_16 - 3.32251369540516*x_17 - 8.28050162358938*x_18 + 7.35685294146152*x_19 - 4.37645462679827*x_2 - 11.4970109799805*x_20 - 5.00603971726807*x_21 + 10.629129457685*x_22 - 11.9765023790135*x_23 - 0.393639211904692*x_24 + 8.29584263332617*x_25 + 4.47544620316772*x_26 + 5.28192718856388*x_27 - 0.0121080848904116*x_28 + 7.84160346318995*x_29 - 3.51101875388028*x_3 + 3.58563787246482*x_30 - 1.60410481740632*x_31 + 80.4696168817749*x_32 - 16.4520563413213*x_33 + 2.67945533096701*x_34 - 2.78772329701256*x_35 + 0.0179343502309626*x_36 - 0.103240898239248*x_37 + 4.63795027317094*x_38 + 17.5035292726652*x_39 + 6.79002020203649*x_4 - 0.555188582072842*x_40 - 0.658909196450111*x_41 + 6.56361984287394*x_42 - 9.90496876650755*x_43 - 5.89317183902936*x_44 + 1.4936572915633*x_45 - 5.22501754761611*x_46 - 0.0125074077876017*x_47 + 13.2548305330187*x_48 - 2.96172929335515*x_49 + 4.89218135338902*x_5 - 2.90426414377468*x_50 + 1.40053806135702*x_51 + 8.11204399741076*x_52 - 1.3851070627511*x_53 + 16.8555848374391*x_54 + 2.74500182430743*x_55 - 1.57191368769523*x_56 - 0.0130959188507024*x_57 + 0.00675131408316812*x_58 + 0.00418174349749601*x_59 + 0.98963285449761*x_6 + 6.82804238386332*x_60 + 27.2596200724587*x_61 - 99.8244240145058*x_62 - 13.6202341069212*x_63 + 2.57872194349354*x_64 - 8.51131090535538*x_65 - 0.0433596704775926*x_66 - 1.81355160474494*x_67 - 14.5929075894791*x_68 - 21.8293198676931*x_69 - 7.20122691542143*x_7 + 0.024506339766854*x_70 - 1.76571265023425*x_71 - 1.98670228101019*x_72 + 0.014076191730345*x_73 - 13.4475187759118*x_74 - 0.010293817097109*x_75 + 13.5766131470589*x_76 + 5.01140731690411*x_77 - 3.13252105424183*x_78 + 0.00536364088891341*x_79 + 12.0981991132087*x_8 - 4.42963782913012*x_80 + 1.94981484435064*x_81 - 1.78024839174688*x_82 + 0.0225757344613444*x_83 - 0.0457988965478349*x_84 + 10.816421853678*x_85 + 12.086795788979*x_86 - 0.021292165368014*x_87 + 0.560848804782871*x_88 - 21.4551986988663*x_89 + 2.32125019851918*x_9 + 3.55892646612443*x_90 + 43.3663508755195*x_91 - 0.0266167027144956*x_92 + 40.0531089436455*x_93 + 11.5024795009662*x_94 - 1.56745203242175*x_95 - 0.0237129231322115*x_96 - 6.82177368504343*x_97 + 1.09887542325071*x_98 - 0.00669058606940555*x_99 - 0.0399413304365523*std::pow(-7.36319971084595*x_106 - 7.55671977996826, 2) - 1.30687361238679e-5*std::pow(-5.29512023925781*x_108 - 7.73583984375, 2) + 0.13510887165161*std::pow(-0.582399845123291*x_108 - 0.778079867362976, 2) - 1.73912486746927e-5*std::pow(-7.56576013565063*x_109 - 9.54831981658936, 2) + 0.0693237003350022*std::pow(-6.31343984603882*x_11 - 9.7729606628418, 2) + 0.0200392977878632*std::pow(-8.15095996856689*x_116 - 8.55615997314453, 2) - 0.000560341964393232*std::pow(-7.33599996566772*x_118 - 8.55144023895264, 2) - 0.00970153332743199*std::pow(-6.34631967544556*x_120 - 8.5252799987793, 2) + 1.95157991190311e-5*std::pow(-4.97463989257813*x_120 - 5.7960000038147, 2) - 4.24672525673793e-5*std::pow(-5.00879955291748*x_13 - 7.81375980377197, 2) - 2.55071396539173e-5*std::pow(-5.29879999160767*x_15 - 5.5019998550415, 2) + 3.93413331701031e-5*std::pow(-5.08487987518311*x_15 - 7.32096004486084, 2) + 0.000538453723889758*std::pow(-8.73536014556885*x_18 - 9.75536060333252, 2) + 3.27003908251797e-5*std::pow(-6.31343984603882*x_19 - 9.57096099853516, 2) + 0.0011721858953806*std::pow(-7.01279973983765*x_23 - 9.21599960327148, 2) - 0.000208331752499772*std::pow(-6.67776012420654*x_24 - 9.96127986907959, 2) - 0.0280738596297613*std::pow(-4.61759996414185*x_24 - 6.62983989715576, 2) + 6.11440972355422e-5*std::pow(-7.44783973693848*x_27 - 8.82520008087158, 2) + 0.0554777742256795*std::pow(-5.21519994735718*x_39 - 6.82528018951416, 2) + 1.22009072468615e-5*std::pow(-6.29800033569336*x_4 - 9.95495986938477, 2) - 0.00049818033411858*std::pow(-4.83800029754639*x_44 - 6.05071973800659, 2) - 0.00114507081448362*std::pow(-5.75367975234985*x_47 - 7.59768009185791, 2) - 9.61405700565106e-5*std::pow(-6.32687997817993*x_5 - 9.3877592086792, 2) - 2.36677180744812e-5*std::pow(-7.51128005981445*x_50 - 8.1159200668335, 2) + 0.000424737494297972*std::pow(-7.70344018936157*x_59 - 9.92232036590576, 2) + 0.00963662524959178*std::pow(-6.26208019256592*x_59 - 9.90112018585205, 2) - 4.1006586811211e-5*std::pow(-4.89711999893188*x_6 - 7.75040006637573, 2) - 0.000114473187515371*std::pow(-8.05943965911865*x_64 - 9.632080078125, 2) + 7.36025183162165e-5*std::pow(-3.31583976745605*x_66 - 4.76936006546021, 2) + 0.00130785280550678*std::pow(-5.33400011062622*x_67 - 5.12992000579834, 2) - 0.000145499918818755*std::pow(-4.89463996887207*x_7 - 6.54287958145142, 2) + 4.25365413073038e-5*std::pow(-6.32664012908936*x_70 - 8.89144039154053, 2) - 0.0457457479875042*std::pow(-5.72743988037109*x_70 - 7.97160005569458, 2) - 3.44378412520092e-5*std::pow(-6.03951978683472*x_72 - 8.25783920288086, 2) + 2.43141127080534e-5*std::pow(-5.92343997955322*x_72 - 7.55639982223511, 2) - 0.0360522430848799*std::pow(-5.51567983627319*x_72 - 6.31112003326416, 2) + 0.000885705763276068*std::pow(-5.3295202255249*x_72 - 7.79544019699097, 2) - 0.000505971271965843*std::pow(-5.7279200553894*x_73 - 7.8930401802063, 2) - 2.49322104448547e-5*std::pow(-7.48496007919312*x_74 - 9.9323205947876, 2) + 0.00232956962844623*std::pow(-5.3471999168396*x_74 - 6.92751979827881, 2) - 0.000196666122281279*std::pow(-6.85536003112793*x_77 - 8.66800022125244, 2) + 0.192104552375876*std::pow(-4.26240015029907*x_78 - 5.81343936920166, 2) + 0.0347342660800779*std::pow(-7.15487957000732*x_81 - 9.58255958557129, 2) + 8.02394564268297e-5*std::pow(-8.56280040740967*x_84 - 8.97383975982666, 2) - 0.00021768629338324*std::pow(-8.34360027313232*x_84 - 8.74335956573486, 2) - 3.9577686022863e-5*std::pow(-7.32399988174438*x_84 - 6.70928001403809, 2) + 3.91386414204033e-5*std::pow(-5.07727956771851*x_86 - 7.30615997314453, 2) - 0.126783509723531*std::pow(-4.13991975784302*x_87 - 5.91967964172363, 2) + 0.0289452648541582*std::pow(-8.75607967376709*x_88 - 9.97624015808105, 2) + 2.66001487727918e-5*std::pow(-8.0033597946167*x_88 - 9.20728015899658, 2) - 0.00323521288200959*std::pow(-2.1943998336792*x_88 - 2.17791986465454, 2) + 0.00061848259627664*std::pow(-3.1781599521637*x_90 - 4.56775999069214, 2) + 0.000196040056638034*std::pow(-5.24519968032837*x_99 - 6.02455997467041, 2) + 0.00736717433260384*std::exp(0.702079832553864*x_1) + 0.000583183329108008*std::exp(1.08351981639862*x_1) + 0.000205143485783365*std::exp(1.19423997402191*x_1) - 0.375651373586056*std::exp(1.22735989093781*x_1) - 5.44163577953551e-5*std::exp(1.28807985782623*x_1) - 0.000357065946661954*std::exp(1.19983983039856*x_100) - 0.000752711258891836*std::exp(1.62295985221863*x_100) - 0.0286648541357775*std::exp(0.515199840068817*x_103) - 0.0854329692193883*std::exp(0.528799831867218*x_104) + 0.958188920116386*std::exp(1.06327986717224*x_104) + 0.0486042761306213*std::exp(0.650879800319672*x_106) + 0.0133372705475064*std::exp(0.665519833564758*x_106) + 0.000465598564964984*std::exp(0.792479872703552*x_106) - 16.2702950840053*std::exp(1.33487987518311*x_106) + 0.132742380182968*std::exp(0.648639798164368*x_109) + 11.8427899620168*std::exp(0.855439901351929*x_110) + 0.00112006698408458*std::exp(1.08487975597382*x_110) + 0.000494569465685125*std::exp(1.55039989948273*x_110) + 1.99435289260745e-5*std::exp(1.59975981712341*x_110) + 9.36551933303219*std::exp(0.604959845542908*x_112) - 0.000120622395071026*std::exp(0.914159834384918*x_112) + 0.000577244078612478*std::exp(0.571999847888947*x_24) - 0.0735596587106615*std::exp(0.514479875564575*x_26) - 3.35679284023742*std::exp(0.62559986114502*x_26) + 0.011820042152014*std::exp(0.643839836120605*x_26) + 0.00227571590278244*std::exp(0.829519867897034*x_26) - 0.00100748157749313*std::exp(0.874719858169556*x_26) + 0.00203013662345308*std::exp(0.913679838180542*x_26) + 10.7574097207175*std::exp(0.491599857807159*x_31) - 0.0152776013737143*std::exp(0.599999845027924*x_31) - 0.047472939500157*std::exp(0.620239853858948*x_31) - 0.000853120852559553*std::exp(0.647599816322327*x_31) + 0.00680164485338122*std::exp(0.654319822788239*x_31) - 0.216651169404138*std::exp(0.655279815196991*x_31) + 3.35615122084938*std::exp(0.654959857463837*x_45) - 0.00179246923891369*std::exp(0.825759887695313*x_45) + 0.000401943606922205*std::exp(1.0123997926712*x_45) + 0.0254323453533059*std::exp(1.11879980564117*x_45) + 0.000469417729990598*std::exp(1.23079991340637*x_45) - 3.48863481382207*std::exp(0.99375981092453*x_6) + 0.00184804897105587*std::exp(0.713119864463806*x_60) - 1.40097841468502*std::exp(0.968719840049744*x_60) + 0.00368124920285535*std::exp(1.24247992038727*x_60) + 0.000185730034501713*std::exp(1.45055985450745*x_66) + 0.0753166491255074*std::exp(1.66143977642059*x_66) - 0.00112627450963021*std::exp(0.718239843845367*x_70) - 0.00257803878377233*std::exp(0.895999848842621*x_70) + 0.0198177043526431*std::exp(0.875359892845154*x_72) - 0.000353048772681393*std::exp(0.97439980506897*x_74) + 0.0030362079850086*std::exp(1.0343998670578*x_74) + 0.00459424263924689*std::exp(1.24767982959747*x_74) + 0.000117850055883487*std::exp(1.71327984333038*x_74) + 0.326775133241868*std::exp(0.599999845027924*x_76) - 0.0142405739431778*std::exp(0.73831981420517*x_77) - 0.00764819795278268*std::exp(0.885519862174988*x_81) - 0.011351340279179*std::exp(1.09175980091095*x_81) + 0.0102924989868767*std::exp(0.719999849796295*x_87) + 0.0258765210994206*std::sin(0.222879990935326*x_1 - 1.19911992549896) + 1.59653792382291*std::sin(0.184960007667542*x_10 + 1.76799988746643) + 1.77060643663935*std::sin(0.330879837274551*x_10 - 7.47408008575439) - 0.280043687170961*std::sin(0.372159838676453*x_100 - 7.40847969055176) + 0.25378020000981*std::sin(0.155280038714409*x_102 - 7.65199995040894) - 76.125555740932*std::sin(0.298239946365356*x_102 - 7.52088022232056) - 0.0105838801137402*std::sin(0.342959851026535*x_102 - 7.44087982177734) + 0.241517594931348*std::sin(0.371279835700989*x_102 + 1.97439980506897) + 0.117793260482861*std::sin(0.430479854345322*x_102 - 4.16527986526489) + 0.331797416299722*std::sin(0.445199847221375*x_102 + 5.23176002502441) - 0.0401693371490995*std::sin(0.314079850912094*x_103 - 7.47591972351074) + 30.5485462036644*std::sin(0.465919852256775*x_103 - 7.36799955368042) + 45.7868538528646*std::sin(0.487919867038727*x_104 - 4.14376020431519) + 0.586600227251051*std::sin(0.60919988155365*x_104 - 7.1910400390625) + 0.00409254761468884*std::sin(0.640159845352173*x_104 - 7.17999982833862) - 0.359100331112756*std::sin(0.263999968767166*x_105 + 1.85087990760803) - 34.8884355200966*std::sin(0.319519847631454*x_105 + 1.92879974842072) + 0.119980259087063*std::sin(0.355839848518372*x_105 - 7.42432022094727) - 0.0158591511371842*std::sin(0.357599824666977*x_105 - 7.44007968902588) + 0.806755644446062*std::sin(0.187360003590584*x_106 - 7.61688041687012) - 0.0106522045188643*std::sin(0.432319849729538*x_106 + 5.221360206604) - 72.5470666990007*std::sin(0.299039930105209*x_107 + 5.11175966262817) - 110.641571141882*std::sin(0.363919854164124*x_107 - 7.4172797203064) + 0.0151644239377074*std::sin(0.44327986240387*x_107 + 5.22464036941528) - 0.372248502739568*std::sin(0.347679853439331*x_108 + 5.14847993850708) - 12.9119772994337*std::sin(0.663199841976166*x_108 + 2.2377598285675) - 0.290227326715057*std::sin(0.345519840717316*x_109 + 5.15944004058838) + 0.245048701620778*std::sin(0.375519841909409*x_110 + 5.1691198348999) + 0.00230888054492127*std::sin(0.590079843997955*x_110 - 7.21264028549194) + 63.8061165113182*std::sin(0.3572798371315*x_111 - 7.43255996704102) - 0.0061551795148172*std::sin(0.401119828224182*x_111 - 4.20544004440308) + 0.292164162433473*std::sin(0.439599871635437*x_111 - 1.17359983921051) + 0.0126229129922219*std::sin(0.456559866666794*x_111 + 8.23095989227295) - 12.3581598413023*std::sin(0.473359853029251*x_111 + 2.04543972015381) + 0.0266037782107012*std::sin(0.496959865093231*x_111 - 4.12064027786255) - 104.12352718854*std::sin(0.198719993233681*x_112 + 4.99071979522705) + 0.0267533328508111*std::sin(0.353759855031967*x_112 - 7.41695976257324) + 0.0374303111575956*std::sin(0.411039859056473*x_112 - 0.981599867343903) + 0.453526206525154*std::sin(0.48583984375*x_112 + 5.23848009109497) - 0.2594609544454*std::sin(0.507519841194153*x_112 - 1.01695990562439) - 114.91026743739*std::sin(0.304399937391281*x_113 - 7.4966402053833) + 2.62785229664196*std::sin(0.345999836921692*x_113 - 7.43743991851807) - 0.0337661074950199*std::sin(0.268559962511063*x_114 - 7.53224039077759) - 78.4131258193179*std::sin(0.269199967384338*x_114 - 7.52320003509521) + 28.56685899619*std::sin(0.367759823799133*x_114 - 7.42456007003784) - 0.296593938800524*std::sin(0.429439842700958*x_114 + 5.22695970535278) - 0.0189236334709439*std::sin(0.468559861183167*x_114 - 4.1592001914978) - 0.0271692407900784*std::sin(0.576479852199554*x_114 - 7.21895980834961) - 0.218586235975398*std::sin(0.665199875831604*x_114 + 5.43255996704102) + 0.00635807527118671*std::sin(0.302079945802689*x_115 + 5.103919506073) - 1.89580581308718*std::sin(0.325759828090668*x_115 - 7.45439958572388) + 93.5826177702816*std::sin(0.416079849004745*x_115 + 5.22344017028809) - 0.049412064322226*std::sin(0.48447984457016*x_115 - 4.12936019897461) - 0.0489009783473333*std::sin(0.534799814224243*x_115 + 5.36311960220337) + 0.285599964163028*std::sin(0.435039848089218*x_116 + 8.42255973815918) + 30.8428744668251*std::sin(0.49839985370636*x_116 - 4.12344026565552) + 0.221218275108993*std::sin(0.243599966168404*x_117 - 1.35351991653442) - 22.1132298972308*std::sin(0.376959830522537*x_117 + 1.97719979286194) - 0.0237379375550524*std::sin(0.378399848937988*x_117 + 5.1756796836853) - 72.2100345447393*std::sin(0.400079846382141*x_117 - 4.1864800453186) - 0.104105473865206*std::sin(0.616959869861603*x_117 - 3.99599981307983) - 0.533412287554106*std::sin(0.191840007901192*x_118 + 1.78999984264374) + 1.50723361705555*std::sin(0.408879846334457*x_118 + 5.20247983932495) + 0.0251122314525783*std::sin(0.419359862804413*x_118 + 5.21727991104126) + 0.0522342338353299*std::sin(0.289599925279617*x_119 - 4.28279972076416) - 0.771056836187451*std::sin(0.340479850769043*x_119 + 5.15120029449463) - 153.996325144224*std::sin(0.34895983338356*x_119 + 5.15208005905151) - 0.0114632349591605*std::sin(0.366079837083817*x_119 - 7.41511964797974) + 17.226127140964*std::sin(0.434239864349365*x_119 + 1.99407982826233) + 0.515393066810343*std::sin(0.35471984744072*x_12 - 1.03167986869812) - 0.0274186802435375*std::sin(0.328399837017059*x_120 + 1.94799983501434) + 0.0196677842041153*std::sin(0.36695984005928*x_120 + 5.15912008285522) - 0.359656965918057*std::sin(0.427679866552353*x_120 + 5.2294397354126) - 4.78069329772595*std::sin(0.211919993162155*x_14 - 4.38903999328613) - 0.10704201185835*std::sin(0.272799968719482*x_16 + 5.08839988708496) + 0.0200708695109929*std::sin(0.368559837341309*x_16 + 5.15863990783691) + 0.359936063051771*std::sin(0.369679838418961*x_16 + 5.18168020248413) + 0.0294943350651059*std::sin(0.427279859781265*x_18 - 0.954639852046967) + 0.0161357126129364*std::sin(0.348479837179184*x_20 - 4.25511980056763) + 2.24681797492302*std::sin(0.361199855804443*x_20 + 5.16968011856079) - 0.958605221707707*std::sin(0.357999831438065*x_21 + 8.36407947540283) + 3.33399831860291*std::sin(0.209600001573563*x_22 - 7.57504034042358) + 0.136766365427943*std::sin(0.502079844474792*x_22 + 2.10895967483521) - 0.00457611424774965*std::sin(0.589439868927002*x_22 - 7.22200012207031) - 1.16411321815128*std::sin(0.162880018353462*x_24 + 4.93567991256714) + 0.0928799291548182*std::sin(0.182560011744499*x_24 + 4.98351955413818) - 0.194428668160725*std::sin(0.190160006284714*x_24 - 7.60288000106812) - 0.607042118892203*std::sin(0.338639855384827*x_24 - 4.25832033157349) + 0.00352853765476112*std::sin(0.46111986041069*x_25 - 4.13752031326294) + 0.032365601423939*std::sin(0.186080008745193*x_26 - 7.6005597114563) - 0.0838153191876838*std::sin(0.137440040707588*x_27 + 4.9017596244812) + 6.3264088045851*std::sin(0.171120017766953*x_27 - 7.6241602897644) + 0.0145838465422344*std::sin(0.301679939031601*x_27 + 5.12080001831055) - 61.2059080057454*std::sin(0.303999930620193*x_27 + 5.13247966766357) - 0.04026110427223*std::sin(0.319839835166931*x_28 - 4.28064012527466) - 1.75217294512478*std::sin(0.320079833269119*x_28 - 4.28864002227783) - 110.314756752489*std::sin(0.322399854660034*x_28 - 4.28247976303101) + 0.0746850121772545*std::sin(0.326319843530655*x_28 + 5.13312005996704) + 33.9801874781234*std::sin(0.331519842147827*x_28 - 4.27248001098633) + 0.112614696820461*std::sin(0.33247983455658*x_28 - 4.26847982406616) + 0.155260309161979*std::sin(0.285919934511185*x_3 + 5.08111953735352) + 0.645955870792676*std::sin(0.294319927692413*x_3 + 5.10839986801147) + 39.9566649706713*std::sin(0.307759910821915*x_3 - 7.5032000541687) - 44.9385674606629*std::sin(0.261199980974197*x_30 - 7.53352022171021) - 1.4771819891719*std::sin(0.27295994758606*x_30 - 4.32471990585327) - 0.177464178840644*std::sin(0.279999971389771*x_30 - 4.29591989517212) + 177.13654765273*std::sin(0.360319852828979*x_31 + 5.10487985610962) - 4.13002616748614*std::sin(0.255839973688126*x_32 - 4.40239953994751) + 0.32077356582816*std::sin(0.348479837179184*x_32 + 8.2469596862793) - 0.373796842498483*std::sin(0.322319835424423*x_33 + 8.19719982147217) + 0.0232188930441762*std::sin(0.351519852876663*x_34 + 2.00215983390808) - 0.0843642855124407*std::sin(0.313519835472107*x_35 + 1.97631978988647) - 0.0812390672418378*std::sin(0.315679848194122*x_35 + 1.98063981533051) + 1.73768595307024*std::sin(0.317599833011627*x_35 - 7.43431997299194) + 87.4365867333874*std::sin(0.318319827318192*x_35 - 7.43311977386475) + 0.0210537312253129*std::sin(0.319839835166931*x_35 - 7.42831993103027) + 0.311056037290148*std::sin(0.319919854402542*x_35 - 7.42831993103027) - 0.00652999715922293*std::sin(0.321919858455658*x_35 - 7.42599964141846) - 0.0041280382123607*std::sin(0.331519842147827*x_36 - 4.25288009643555) + 0.895586142486131*std::sin(0.352959841489792*x_36 + 5.1637601852417) - 33.3167640219543*std::sin(0.373759835958481*x_36 - 7.41639995574951) + 0.00709794786447074*std::sin(0.380639851093292*x_36 - 7.39903974533081) + 15.3588659765986*std::sin(0.393519848585129*x_36 - 4.2052001953125) - 0.267762140300817*std::sin(0.418559849262238*x_36 + 5.22079992294312) + 72.5472027379941*std::sin(0.293359935283661*x_37 + 5.09615993499756) - 0.0331862101435169*std::sin(0.298719942569733*x_37 - 7.50471973419189) + 45.7943897518647*std::sin(0.36303985118866*x_37 - 4.24047994613647) + 0.216002120323329*std::sin(0.364959836006165*x_37 - 7.42208003997803) - 1.14167059906841*std::sin(0.401439845561981*x_37 - 4.20695972442627) + 0.0154938673867447*std::sin(0.48039984703064*x_38 + 5.25888013839722) + 0.0238349952690602*std::sin(0.665279865264893*x_38 + 2.20815992355347) + 1.68924679570701*std::sin(0.19743999838829*x_39 + 4.99631977081299) + 0.440396218220965*std::sin(0.350079834461212*x_39 + 5.16296005249023) - 0.0869463778648064*std::sin(0.334239840507507*x_40 - 4.27408027648926) + 0.0934445759023537*std::sin(0.390239834785461*x_40 + 8.37495994567871) - 0.214362692815401*std::sin(0.312159925699234*x_41 + 1.89567983150482) + 1.40126739107252*std::sin(0.375519841909409*x_41 + 5.17112016677856) + 49.4518591189799*std::sin(0.406959861516953*x_41 - 7.39175987243652) + 0.0451218331156295*std::sin(0.431519865989685*x_41 - 7.38671970367432) - 6.5343056490758*std::sin(0.121520057320595*x_42 + 1.70983994007111) + 63.5073865465334*std::sin(0.369279831647873*x_43 - 7.41183996200562) + 0.0170291394632394*std::sin(0.380639851093292*x_43 - 4.22176027297974) - 0.512047989211427*std::sin(0.383359849452972*x_43 - 7.40655994415283) + 0.458708803121102*std::sin(0.440879851579666*x_43 - 7.37831974029541) - 64.3869355122879*std::sin(0.359359860420227*x_44 + 5.16416025161743) - 0.101912429025218*std::sin(0.407279849052429*x_46 + 5.21623992919922) - 17.1839012475374*std::sin(0.585599839687347*x_46 - 7.21920013427734) + 0.00257899970647528*std::sin(0.645839810371399*x_46 + 5.4171199798584) - 320.162295779042*std::sin(0.208159998059273*x_47 - 7.59176015853882) + 55.51461831737*std::sin(0.260319977998734*x_47 + 1.85655987262726) - 0.0118252810044115*std::sin(0.439279854297638*x_47 - 4.15232038497925) - 11.6753447711432*std::sin(0.424719870090485*x_48 - 4.17040014266968) + 0.196515047693472*std::sin(0.259919971227646*x_49 + 1.85903990268707) - 0.280790088427391*std::sin(0.437279850244522*x_49 - 7.35431957244873) + 3.52787684299329*std::sin(0.191200003027916*x_50 + 4.98799991607666) - 75.9850797687435*std::sin(0.321759849786758*x_50 - 7.47687959671021) - 93.2516030680284*std::sin(0.36559984087944*x_51 - 4.23184013366699) + 4.823363767117*std::sin(0.212960004806519*x_53 + 5.00816011428833) - 86.3659838170083*std::sin(0.347519844770432*x_53 + 5.15128040313721) - 0.0204329155562439*std::sin(0.359999865293503*x_53 - 4.24272012710571) + 0.00523107672911751*std::sin(0.889279901981354*x_53 - 3.95743989944458) - 0.149655801044559*std::sin(0.319359838962555*x_54 + 1.90071976184845) - 0.754262640492165*std::sin(0.417919874191284*x_54 - 7.38679981231689) + 3.7645043551636*std::sin(0.487039864063263*x_54 - 1.10911989212036) + 0.113073627022765*std::sin(0.658959865570068*x_54 - 3.96943998336792) - 1.25266981874354*std::sin(0.348079830408096*x_55 + 5.15960025787354) - 79.8304341867674*std::sin(0.403119832277298*x_55 + 8.38576030731201) + 0.0498039016514095*std::sin(0.441839843988419*x_55 - 4.14991998672485) - 0.0056514178548665*std::sin(0.465039849281311*x_55 + 5.25047969818115) - 74.0265424754552*std::sin(0.322559833526611*x_56 + 1.92327988147736) - 0.230158485739524*std::sin(0.406159847974777*x_56 + 5.19504022598267) + 77.6471860312001*std::sin(0.428879857063293*x_57 - 4.16879987716675) - 0.0150132160775758*std::sin(0.448399841785431*x_57 - 4.15232038497925) + 22.9021804511586*std::sin(0.553839862346649*x_57 + 5.35767984390259) - 0.08638084590051*std::sin(0.853919863700867*x_57 + 5.62479972839355) - 1.24906723411471*std::sin(0.170960009098053*x_58 + 4.96247959136963) - 34.8331463417932*std::sin(0.209440007805824*x_58 + 5.00848007202148) + 0.325325476935566*std::sin(0.266239941120148*x_58 - 7.51327991485596) + 2.3740133306849*std::sin(0.2743199467659*x_58 + 5.07583951950073) - 0.0175715882842108*std::sin(0.348079830408096*x_58 + 5.15759992599487) - 83.5452614296255*std::sin(0.42223984003067*x_58 - 4.189040184021) - 0.0702609992446915*std::sin(0.462799847126007*x_58 + 5.25392007827759) + 0.0406292645300555*std::sin(0.168560013175011*x_59 - 7.63191986083984) - 64.0705237263577*std::sin(0.251999974250793*x_59 - 7.52784013748169) + 0.123642657217846*std::sin(0.203199997544289*x_64 + 1.78175985813141) - 0.00531581112984387*std::sin(0.222240000963211*x_64 - 4.36191987991333) + 2.60814856332871*std::sin(0.228959992527962*x_64 - 4.36199951171875) + 0.0171890294742083*std::sin(0.339199841022491*x_64 - 7.4555196762085) + 96.549384317242*std::sin(0.43495985865593*x_66 + 8.44768047332764) + 222.482798669599*std::sin(0.243759974837303*x_67 - 7.55679988861084) - 272.882084848221*std::sin(0.247279971837997*x_70 - 7.52800035476685) + 0.335837607589696*std::sin(0.439999878406525*x_70 - 4.15304040908813) - 0.0162322529407507*std::sin(0.624399840831757*x_70 - 3.97263979911804) - 0.0531163759494747*std::sin(0.23063999414444*x_71 + 5.04759979248047) - 0.30649145704467*std::sin(0.214000001549721*x_72 + 5.00920009613037) - 99.8916060886979*std::sin(0.24959996342659*x_73 + 5.06479978561401) + 94.4631418319223*std::sin(0.342559844255447*x_73 - 4.26151990890503) - 0.00441138557711941*std::sin(0.451039850711823*x_73 - 4.15104007720947) - 0.616997772271674*std::sin(0.123040057718754*x_75 + 4.89031982421875) + 0.0115233171899962*std::sin(0.278559952974319*x_75 + 5.09087991714478) + 0.296587530578254*std::sin(0.409119844436646*x_75 - 7.38631963729858) - 15.997999058342*std::sin(0.476879835128784*x_75 + 2.08039975166321) + 23.7453925456551*std::sin(0.540319859981537*x_75 + 5.16431999206543) - 87.7433568942946*std::sin(0.238319978117943*x_76 - 7.53840017318726) - 1.12480816433429*std::sin(0.393599838018417*x_78 + 8.3810396194458) + 0.0273529520302145*std::sin(0.486639857292175*x_78 + 5.28744029998779) + 126.639863861758*std::sin(0.281759947538376*x_79 - 7.4986400604248) + 1.99523849053755*std::sin(0.332239836454391*x_79 + 5.12871980667114) + 50.1161957152059*std::sin(0.355119854211807*x_79 + 1.96583986282349) - 0.0519123026452744*std::sin(0.249199971556664*x_8 - 4.33576011657715) - 0.598905581530698*std::sin(0.501679837703705*x_8 - 7.30711984634399) + 0.0973515376261691*std::sin(0.389359831809998*x_81 + 8.37271976470947) - 268.923103805284*std::sin(0.214159995317459*x_82 - 7.57696008682251) + 0.130532871769393*std::sin(0.197359994053841*x_83 + 5.00008010864258) - 1.28074960049491*std::sin(0.201599985361099*x_83 + 5.0053596496582) + 0.05847387099009*std::sin(0.263119965791702*x_83 + 1.87455987930298) + 0.0479657578985188*std::sin(0.319679915904999*x_83 - 7.46343994140625) - 54.8566347837244*std::sin(0.320559918880463*x_83 - 7.46808004379272) + 52.1820152325133*std::sin(0.322239845991135*x_83 - 7.4730396270752) + 1.2223471455988*std::sin(0.393679857254028*x_83 - 1.19831991195679) - 0.280263635814656*std::sin(0.140080034732819*x_84 - 7.67984008789063) - 0.0363153602714127*std::sin(0.179360002279282*x_84 + 1.77599990367889) + 2.8635436006325*std::sin(0.23871998488903*x_84 - 7.55600023269653) + 0.0300461623808129*std::sin(0.278079956769943*x_84 + 5.09272003173828) - 243.850802704916*std::sin(0.278479933738708*x_84 - 7.49608039855957) + 0.226515710678883*std::sin(0.187040001153946*x_85 + 4.98767995834351) - 0.54232779885219*std::sin(0.19064000248909*x_85 - 7.61648035049438) - 0.0391309408640583*std::sin(0.221919998526573*x_85 - 7.56135988235474) - 23.6108038345126*std::sin(0.230239987373352*x_85 - 7.55408048629761) + 0.036289615030306*std::sin(0.524639844894409*x_86 - 7.27040004730225) - 16.8465731313472*std::sin(0.402799844741821*x_87 + 5.20991992950439) - 0.803825303091585*std::sin(0.417919844388962*x_87 - 4.18951988220215) + 0.00656680404440219*std::sin(0.499039828777313*x_87 - 4.11488008499146) + 0.0191359588003732*std::sin(0.87447988986969*x_87 - 0.751359879970551) + 0.826356891571719*std::sin(0.219119995832443*x_89 + 1.8155198097229) - 0.281084797664981*std::sin(0.41023987531662*x_90 - 7.39207983016968) + 0.0619535679292415*std::sin(0.414639860391617*x_90 - 0.994639813899994) + 0.118055384981022*std::sin(0.505279839038849*x_90 - 4.09320020675659) - 0.0560593005701852*std::sin(0.337039858102798*x_92 + 5.18400001525879) + 57.3703488078809*std::sin(0.341039836406708*x_92 + 5.20991992950439) - 0.128380019871508*std::sin(0.360079854726791*x_92 + 1.97791981697083) - 2.86053726113558*std::sin(0.360879838466644*x_92 + 2.00343990325928) - 0.00454485601392798*std::sin(0.363839834928513*x_92 - 7.38535976409912) + 84.9794963574015*std::sin(0.365199834108353*x_92 + 1.99775981903076) + 0.00810566766918145*std::sin(0.381279855966568*x_92 + 1.97519981861115) + 0.124419671764084*std::sin(0.401679873466492*x_92 - 7.59008026123047) + 0.104654011044963*std::sin(0.374559849500656*x_94 - 1.18543982505798) - 0.00893247531637463*std::sin(0.376239836215973*x_94 + 1.98399984836578) + 1.1125129679661*std::sin(0.386319845914841*x_94 - 7.40639972686768) - 25.8674014938622*std::sin(0.404079854488373*x_94 - 4.21031999588013) - 0.0107723076913159*std::sin(0.367999851703644*x_95 + 1.98935985565186) + 2.51637615799538*std::sin(0.382479846477509*x_95 - 7.39607954025269) + 0.0304135395931257*std::sin(0.376959830522537*x_96 - 4.22176027297974) - 0.427787316067469*std::sin(0.386959820985794*x_96 - 4.2021598815918) + 0.00971973643550253*std::sin(0.396319836378098*x_96 + 5.20240020751953) - 62.674560065708*std::sin(0.398799866437912*x_96 - 7.3931999206543) + 16.7784851063973*std::sin(0.411679863929749*x_96 + 1.98543977737427) - 0.818633760042926*std::sin(0.326879858970642*x_97 + 5.13624000549316) + 37.4245850781302*std::sin(0.339759826660156*x_97 + 5.16359996795654) - 0.0371921068845551*std::sin(0.362479835748672*x_97 - 4.41720008850098) + 1.89821092491407*std::sin(0.403599858283997*x_97 + 5.19040012359619) - 0.0603801070725024*std::sin(0.518239855766296*x_97 + 2.16407990455627) + 0.0298584517538733*std::sin(0.395679831504822*x_98 - 4.19135999679565) - 0.440832592346176*std::sin(0.406559854745865*x_98 - 7.38751983642578) + 0.0113743737622415*std::sin(0.414239853620529*x_98 - 7.39607954025269) - 0.0735377904407042*std::sin(0.430639863014221*x_98 - 7.37799978256226) - 25.8899184546358*std::sin(0.433199852705002*x_98 - 7.38143968582153) + 40.9829323283519*std::sin(0.382719844579697*x_99 - 7.42312002182007) + 0.266266542908305*std::sin(0.398159861564636*x_99 - 7.40983963012695) - 0.0113210365653684*std::sin(0.402159839868546*x_99 - 4.20552015304565) - 0.545533605897754*std::sin(0.403039842844009*x_99 + 5.20864009857178) - 34.9296612968597*std::sin(0.415279865264893*x_99 - 4.19144010543823) - 1452.9511556715);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.220106672533504*x_1 - 2.57174585774665*x_10 - 2.2808638548488*x_100 + 15.3818715885967*x_101 - 0.541640093960517*x_102 - 1.28823936658633*x_103 - 0.0100450645285576*x_104 + 2.27776096557494*x_105 + 0.0103682603141675*x_106 + 0.445878492204732*x_107 + 4.17707655326963*x_108 - 2.54891482383527*x_109 - 1.08028986338828*x_11 + 2.7805143925889*x_110 - 0.0162215932571962*x_111 + 0.00405720787765*x_112 + 0.0975407308077999*x_113 + 0.0146273992220028*x_114 + 2.88066675383279*x_115 - 0.0280086923581673*x_116 + 0.014160188612141*x_117 - 2.18604770689741*x_118 - 0.00775818442591516*x_119 - 6.59953170010351*x_12 + 0.0340108782115043*x_120 - 0.278445617483653*x_13 - 10.6305360583839*x_14 - 9.22628862329841*x_15 + 1.64339740394908*x_16 - 2.10335274613687*x_17 + 1.34240292017721*x_18 + 4.49995223292089*x_19 - 0.964270325599411*x_2 - 15.5219563282267*x_20 - 2.64823176240757*x_21 - 3.20491925366877*x_22 - 9.11012258496197*x_23 - 0.0146025934174039*x_24 + 2.4635153827351*x_25 + 0.445905592295058*x_26 + 0.178476660624371*x_27 + 0.00320523670714158*x_28 + 2.40474419567052*x_29 - 4.44025535375623*x_3 + 0.13858913910588*x_30 - 4.47572688604127*x_31 - 6.70339463553381*x_32 + 5.46933550564178*x_33 + 7.59643357044687*x_34 - 3.6022982411409*x_35 + 0.0200724503867125*x_36 + 0.00433285806532279*x_37 + 2.34891165166302*x_38 + 0.595100694748747*x_39 + 0.318548262326972*x_4 - 0.452113494994668*x_40 - 0.0348429124846832*x_41 + 1.43999690586806*x_42 - 0.330895783887899*x_43 - 6.96088618166715*x_44 + 1.92902754613886*x_45 - 6.58591516223932*x_46 + 0.174154706380949*x_47 + 0.516688931445793*x_48 + 1.63411477521218*x_49 + 2.72341706029244*x_5 - 0.0796640165841204*x_50 + 1.83063448166812*x_51 + 3.4760755927124*x_52 - 1.80221859521804*x_53 + 0.567151161929941*x_54 + 3.56042061473158*x_55 - 1.91683253903327*x_56 - 0.114609735520382*x_57 - 0.00685389062183641*x_58 - 0.00718158034035132*x_59 + 1.21118001815996*x_6 + 0.74716932953532*x_60 + 9.75612486330148*x_61 - 121.536476337773*x_62 - 1.53064428678125*x_63 + 1.47177725367103*x_64 + 4.34071408746561*x_65 + 0.0176871295458173*x_66 - 2.26015128234341*x_67 - 0.544607215535995*x_68 - 2.37975435911823*x_69 - 2.30758834525219*x_7 + 0.0902500448778034*x_70 - 4.04449919486185*x_71 - 2.56245257438595*x_72 - 0.00633400911664996*x_73 - 14.0165073006074*x_74 - 0.0124972437979641*x_75 + 0.437921981729558*x_76 + 9.98422752338645*x_77 - 3.96565535546159*x_78 - 0.00215652851859545*x_79 + 9.4955686486132*x_8 - 1.27955255431782*x_80 + 0.081354068767228*x_81 - 2.51425019756846*x_82 + 0.0048102894432779*x_83 - 0.0483735518376686*x_84 + 0.555265593543075*x_85 + 2.08007219803982*x_86 - 0.00357907244540576*x_87 + 0.0415839512350128*x_88 - 4.38116639310024*x_89 - 12.9140720845264*x_9 + 3.09711337573637*x_90 + 3.24923603642912*x_91 - 0.0101562756457974*x_92 + 18.5655651566105*x_93 + 0.396856041542576*x_94 - 1.76209328032185*x_95 + 0.049825091566982*x_96 - 8.70878100614897*x_97 + 1.38637273392306*x_98 - 0.0564336619913165*x_99 - 0.0516484958788446*std::pow(-7.36319971084595*x_106 - 7.55671977996826, 2) - 0.000134538850211795*std::pow(-5.29512023925781*x_108 - 7.73583984375, 2) + 0.414222482226521*std::pow(-0.582399845123291*x_108 - 0.778079867362976, 2) + 6.09825935478912e-6*std::pow(-7.56576013565063*x_109 - 9.54831981658936, 2) + 0.00230409027365054*std::pow(-6.31343984603882*x_11 - 9.7729606628418, 2) + 0.0259129973363184*std::pow(-8.15095996856689*x_116 - 8.55615997314453, 2) + 9.45411080333e-5*std::pow(-7.33599996566772*x_118 - 8.55144023895264, 2) - 0.0125451405499951*std::pow(-6.34631967544556*x_120 - 8.5252799987793, 2) + 0.000200909494962065*std::pow(-4.97463989257813*x_120 - 5.7960000038147, 2) + 1.48911860836117e-5*std::pow(-5.00879955291748*x_13 - 7.81375980377197, 2) + 2.66123266698396e-6*std::pow(-5.29879999160767*x_15 - 5.5019998550415, 2) - 1.37950792103602e-5*std::pow(-5.08487987518311*x_15 - 7.32096004486084, 2) + 0.00165081415711069*std::pow(-8.73536014556885*x_18 - 9.75536060333252, 2) - 1.14664259010394e-5*std::pow(-6.31343984603882*x_19 - 9.57096099853516, 2) + 0.00359373700098309*std::pow(-7.01279973983765*x_23 - 9.21599960327148, 2) - 8.7960609968025e-5*std::pow(-6.67776012420654*x_24 - 9.96127986907959, 2) - 0.0363025619713469*std::pow(-4.61759996414185*x_24 - 6.62983989715576, 2) - 6.37933814470175e-6*std::pow(-7.44783973693848*x_27 - 8.82520008087158, 2) + 0.0717388119560548*std::pow(-5.21519994735718*x_39 - 6.82528018951416, 2) - 4.27826075900802e-6*std::pow(-6.29800033569336*x_4 - 9.95495986938477, 2) + 5.19765758604668e-5*std::pow(-4.83800029754639*x_44 - 6.05071973800659, 2) + 0.000193196780639301*std::pow(-5.75367975234985*x_47 - 7.59768009185791, 2) + 1.003062001966e-5*std::pow(-6.32687997817993*x_5 - 9.3877592086792, 2) + 8.29910984852082e-6*std::pow(-7.51128005981445*x_50 - 8.1159200668335, 2) + 0.00130217813998509*std::pow(-7.70344018936157*x_59 - 9.92232036590576, 2) + 0.000320289517165153*std::pow(-6.26208019256592*x_59 - 9.90112018585205, 2) + 1.43790021238288e-5*std::pow(-4.89711999893188*x_6 - 7.75040006637573, 2) + 1.93139594667446e-5*std::pow(-8.05943965911865*x_64 - 9.632080078125, 2) - 7.67916076726069e-6*std::pow(-3.31583976745605*x_66 - 4.76936006546021, 2) + 0.00400967034112212*std::pow(-5.33400011062622*x_67 - 5.12992000579834, 2) + 1.51804217273151e-5*std::pow(-4.89463996887207*x_7 - 6.54287958145142, 2) - 1.49154822520082e-5*std::pow(-6.32664012908936*x_70 - 8.89144039154053, 2) - 0.0591542407471997*std::pow(-5.72743988037109*x_70 - 7.97160005569458, 2) + 1.20756646921742e-5*std::pow(-6.03951978683472*x_72 - 8.25783920288086, 2) + 0.000250306742492657*std::pow(-5.92343997955322*x_72 - 7.55639982223511, 2) - 0.00119825719391403*std::pow(-5.51567983627319*x_72 - 6.31112003326416, 2) + 0.00271543411843878*std::pow(-5.3295202255249*x_72 - 7.79544019699097, 2) - 0.00155122808478065*std::pow(-5.7279200553894*x_73 - 7.8930401802063, 2) + 8.74250540745565e-6*std::pow(-7.48496007919312*x_74 - 9.9323205947876, 2) + 0.00714209290787908*std::pow(-5.3471999168396*x_74 - 6.92751979827881, 2) + 3.31815824881474e-5*std::pow(-6.85536003112793*x_77 - 8.66800022125244, 2) + 0.00638491927745177*std::pow(-4.26240015029907*x_78 - 5.81343936920166, 2) + 0.044915193832648*std::pow(-7.15487957000732*x_81 - 9.58255958557129, 2) - 0.000136699834580336*std::pow(-8.56280040740967*x_84 - 8.97383975982666, 2) + 3.67281137017803e-5*std::pow(-8.34360027313232*x_84 - 8.74335956573486, 2) - 4.207834774553e-5*std::pow(-7.32399988174438*x_84 - 6.70928001403809, 2) - 1.37240051384596e-5*std::pow(-5.07727956771851*x_86 - 7.30615997314453, 2) - 0.00421386409267842*std::pow(-4.13991975784302*x_87 - 5.91967964172363, 2) + 0.0374293839537183*std::pow(-8.75607967376709*x_88 - 9.97624015808105, 2) + 2.8280842631825e-5*std::pow(-8.0033597946167*x_88 - 9.20728015899658, 2) - 0.00136595259754409*std::pow(-2.1943998336792*x_88 - 2.17791986465454, 2) - 0.00105367698594683*std::pow(-3.1781599521637*x_90 - 4.56775999069214, 2) + 8.27708822737738e-5*std::pow(-5.24519968032837*x_99 - 6.02455997467041, 2) + 0.0225865940684903*std::exp(0.702079832553864*x_1) - 9.8394911721671e-5*std::exp(1.08351981639862*x_1) - 0.000349492404617572*std::exp(1.19423997402191*x_1) - 0.0124854079049511*std::exp(1.22735989093781*x_1) - 5.78545806097761e-5*std::exp(1.28807985782623*x_1) - 0.00367589041957543*std::exp(1.19983983039856*x_100) - 0.000800270285769859*std::exp(1.62295985221863*x_100) + 0.00299068602969546*std::exp(0.515199840068817*x_103) + 0.0144142828590786*std::exp(0.528799831867218*x_104) + 0.0318470272142291*std::exp(1.06327986717224*x_104) + 0.149013041553361*std::exp(0.650879800319672*x_106) - 0.0227220217931049*std::exp(0.665519833564758*x_106) + 0.00479320226507954*std::exp(0.792479872703552*x_106) - 0.540770738886144*std::exp(1.33487987518311*x_106) + 0.406967192782342*std::exp(0.648639798164368*x_109) + 0.393615127763047*std::exp(0.855439901351929*x_110) - 0.000116859784660266*std::exp(1.08487975597382*x_110) + 0.000525818157974114*std::exp(1.55039989948273*x_110) + 0.000205312849341211*std::exp(1.59975981712341*x_110) + 0.311278854109726*std::exp(0.604959845542908*x_112) - 0.00124177259291433*std::exp(0.914159834384918*x_112) + 0.00594256046583213*std::exp(0.571999847888947*x_24) - 0.031057927423889*std::exp(0.514479875564575*x_26) - 4.34069920256022*std::exp(0.62559986114502*x_26) - 0.00123321872726079*std::exp(0.643839836120605*x_26) + 0.00241950388590165*std::exp(0.829519867897034*x_26) - 0.0103717308055474*std::exp(0.874719858169556*x_26) - 0.00345863933979399*std::exp(0.913679838180542*x_26) + 13.9105038704234*std::exp(0.491599857807159*x_31) + 0.0260276636155371*std::exp(0.599999845027924*x_31) - 0.020043745925929*std::exp(0.620239853858948*x_31) - 0.00878263188629582*std::exp(0.647599816322327*x_31) + 0.00723139743988161*std::exp(0.654319822788239*x_31) + 0.0226038347373075*std::exp(0.655279815196991*x_31) + 0.111547354620293*std::exp(0.654959857463837*x_45) + 0.000628531194558998*std::exp(0.825759887695313*x_45) + 0.00413789292344286*std::exp(1.0123997926712*x_45) + 0.0779715579910473*std::exp(1.11879980564117*x_45) + 0.000499077244411189*std::exp(1.23079991340637*x_45) - 0.115950670607633*std::exp(0.99375981092453*x_6) + 0.0190251284702931*std::exp(0.713119864463806*x_60) - 1.81161786766599*std::exp(0.968719840049744*x_60) - 0.00627155491186824*std::exp(1.24247992038727*x_60) + 0.000197465131590506*std::exp(1.45055985450745*x_66) + 0.0973926406419156*std::exp(1.66143977642059*x_66) - 0.00119743661733456*std::exp(0.718239843845367*x_70) + 0.00439207206749635*std::exp(0.895999848842621*x_70) + 0.00836731483371158*std::exp(0.875359892845154*x_72) - 0.00363453477788806*std::exp(0.97439980506897*x_74) - 0.00517263136846714*std::exp(1.0343998670578*x_74) - 0.000479330444632461*std::exp(1.24767982959747*x_74) + 0.000125296249771421*std::exp(1.71327984333038*x_74) + 1.00184099805363*std::exp(0.599999845027924*x_76) + 0.00148575971623558*std::exp(0.73831981420517*x_77) + 0.000797958317226657*std::exp(0.885519862174988*x_81) + 0.00191520242253977*std::exp(1.09175980091095*x_81) - 0.00107384578986178*std::exp(0.719999849796295*x_87) - 0.00907362891622436*std::sin(0.222879990935326*x_1 - 1.19911992549896) - 0.269368481974835*std::sin(0.184960007667542*x_10 + 1.76799988746643) + 5.4283999582367*std::sin(0.330879837274551*x_10 - 7.47408008575439) - 0.858569757957417*std::sin(0.372159838676453*x_100 - 7.40847969055176) - 0.432352272883866*std::sin(0.155280038714409*x_102 - 7.65199995040894) - 2.53016142691913*std::sin(0.298239946365356*x_102 - 7.52088022232056) + 0.00371124852049896*std::sin(0.342959851026535*x_102 - 7.44087982177734) - 0.0407489399068523*std::sin(0.371279835700989*x_102 + 1.97439980506897) + 0.0497339791840239*std::sin(0.430479854345322*x_102 - 4.16527986526489) + 1.01723852546421*std::sin(0.445199847221375*x_102 + 5.23176002502441) + 0.0140854196629158*std::sin(0.314079850912094*x_103 - 7.47591972351074) + 39.5026015773561*std::sin(0.465919852256775*x_103 - 7.36799955368042) + 59.2073951137283*std::sin(0.487919867038727*x_104 - 4.14376020431519) + 1.79842373958332*std::sin(0.60919988155365*x_104 - 7.1910400390625) - 0.00143505605854015*std::sin(0.640159845352173*x_104 - 7.17999982833862) - 0.15161723446085*std::sin(0.263999968767166*x_105 + 1.85087990760803) - 1.15957608373872*std::sin(0.319519847631454*x_105 + 1.92879974842072) - 0.0125178828048897*std::sin(0.355839848518372*x_105 - 7.42432022094727) + 0.00556102776691835*std::sin(0.357599824666977*x_105 - 7.44007968902588) + 0.340623633839496*std::sin(0.187360003590584*x_106 - 7.61688041687012) + 0.00373520654389926*std::sin(0.432319849729538*x_106 + 5.221360206604) - 93.8112685399327*std::sin(0.299039930105209*x_107 + 5.11175966262817) - 3.67735949895203*std::sin(0.363919854164124*x_107 - 7.4172797203064) - 0.00531742095509692*std::sin(0.44327986240387*x_107 + 5.22464036941528) + 0.0628059080865812*std::sin(0.347679853439331*x_108 + 5.14847993850708) - 0.429151374861052*std::sin(0.663199841976166*x_108 + 2.2377598285675) + 0.0489672642649491*std::sin(0.345519840717316*x_109 + 5.15944004058838) + 0.751280653971289*std::sin(0.375519841909409*x_110 + 5.1691198348999) - 0.000809611353706065*std::sin(0.590079843997955*x_110 - 7.21264028549194) + 2.12070405565053*std::sin(0.3572798371315*x_111 - 7.43255996704102) + 0.00215832006998219*std::sin(0.401119828224182*x_111 - 4.20544004440308) + 0.895729222673758*std::sin(0.439599871635437*x_111 - 1.17359983921051) + 0.0134204744092782*std::sin(0.456559866666794*x_111 + 8.23095989227295) - 15.9804483390338*std::sin(0.473359853029251*x_111 + 2.04543972015381) - 0.00277564809696885*std::sin(0.496959865093231*x_111 - 4.12064027786255) - 134.643075383551*std::sin(0.198719993233681*x_112 + 4.99071979522705) - 0.00938108386470582*std::sin(0.353759855031967*x_112 - 7.41695976257324) - 0.063768095789629*std::sin(0.411039859056473*x_112 - 0.981599867343903) + 1.39043978922452*std::sin(0.48583984375*x_112 + 5.23848009109497) + 0.0437763503063843*std::sin(0.507519841194153*x_112 - 1.01695990562439) - 148.591506825361*std::sin(0.304399937391281*x_113 - 7.4966402053833) + 8.05658050380679*std::sin(0.345999836921692*x_113 - 7.43743991851807) + 0.0118401205547686*std::sin(0.268559962511063*x_114 - 7.53224039077759) - 2.6061926823546*std::sin(0.269199967384338*x_114 - 7.52320003509521) + 36.9400639139953*std::sin(0.367759823799133*x_114 - 7.42456007003784) - 0.125226152310804*std::sin(0.429439842700958*x_114 + 5.22695970535278) - 0.020119297256018*std::sin(0.468559861183167*x_114 - 4.1592001914978) + 0.00283464442147302*std::sin(0.576479852199554*x_114 - 7.21895980834961) - 0.670150909703064*std::sin(0.665199875831604*x_114 + 5.43255996704102) + 0.0654545419264562*std::sin(0.302079945802689*x_115 + 5.103919506073) - 5.81224149174574*std::sin(0.325759828090668*x_115 - 7.45439958572388) + 3.11037636977367*std::sin(0.416079849004745*x_115 + 5.22344017028809) + 0.00515530167245648*std::sin(0.48447984457016*x_115 - 4.12936019897461) - 0.0206466841076918*std::sin(0.534799814224243*x_115 + 5.36311960220337) + 0.875604426513652*std::sin(0.435039848089218*x_116 + 8.42255973815918) + 1.02511502887209*std::sin(0.49839985370636*x_116 - 4.12344026565552) - 0.37687819634126*std::sin(0.243599966168404*x_117 - 1.35351991653442) - 28.594817717185*std::sin(0.376959830522537*x_117 + 1.97719979286194) + 0.0083237323820888*std::sin(0.378399848937988*x_117 + 5.1756796836853) - 2.40002246634975*std::sin(0.400079846382141*x_117 - 4.1864800453186) - 0.31917095650839*std::sin(0.616959869861603*x_117 - 3.99599981307983) + 0.0556524260999067*std::sin(0.191840007901192*x_118 + 1.78999984264374) + 4.62094044987584*std::sin(0.408879846334457*x_118 + 5.20247983932495) - 0.00880562996020879*std::sin(0.419359862804413*x_118 + 5.21727991104126) - 0.0889887773757734*std::sin(0.289599925279617*x_119 - 4.28279972076416) - 2.36393859795429*std::sin(0.340479850769043*x_119 + 5.15120029449463) - 5.11832797770577*std::sin(0.34895983338356*x_119 + 5.15208005905151) + 0.00401959520753514*std::sin(0.366079837083817*x_119 - 7.41511964797974) + 22.275260912048*std::sin(0.434239864349365*x_119 + 1.99407982826233) + 1.58011382114873*std::sin(0.35471984744072*x_12 - 1.03167986869812) - 0.0291510918891161*std::sin(0.328399837017059*x_120 + 1.94799983501434) - 0.00689652889532037*std::sin(0.36695984005928*x_120 + 5.15912008285522) + 0.0606814592346435*std::sin(0.427679866552353*x_120 + 5.2294397354126) - 14.6568513254557*std::sin(0.211919993162155*x_14 - 4.38903999328613) + 0.0180601687010188*std::sin(0.272799968719482*x_16 + 5.08839988708496) - 0.00703787117553405*std::sin(0.368559837341309*x_16 + 5.15863990783691) + 1.10350717652795*std::sin(0.369679838418961*x_16 + 5.18168020248413) - 0.00307722814204987*std::sin(0.427279859781265*x_18 - 0.954639852046967) - 0.00565800433474435*std::sin(0.348479837179184*x_20 - 4.25511980056763) + 6.88838939521027*std::sin(0.361199855804443*x_20 + 5.16968011856079) - 2.93893235549302*std::sin(0.357999831438065*x_21 + 8.36407947540283) + 10.2215127873454*std::sin(0.209600001573563*x_22 - 7.57504034042358) - 0.0230752728706413*std::sin(0.502079844474792*x_22 + 2.10895967483521) + 0.00160461919911086*std::sin(0.589439868927002*x_22 - 7.22200012207031) + 0.196409622183853*std::sin(0.162880018353462*x_24 + 4.93567991256714) + 0.0987484198873817*std::sin(0.182560011744499*x_24 + 4.98351955413818) + 0.331238120979583*std::sin(0.190160006284714*x_24 - 7.60288000106812) - 1.86109535391548*std::sin(0.338639855384827*x_24 - 4.25832033157349) - 0.00123728538211204*std::sin(0.46111986041069*x_25 - 4.13752031326294) - 0.0113490316508513*std::sin(0.186080008745193*x_26 - 7.6005597114563) + 0.0293899284560694*std::sin(0.137440040707588*x_27 + 4.9017596244812) + 19.3957711775748*std::sin(0.171120017766953*x_27 - 7.6241602897644) + 0.150136472789746*std::sin(0.301679939031601*x_27 + 5.12080001831055) - 79.1459135898666*std::sin(0.303999930620193*x_27 + 5.13247966766357) + 0.0141175978996578*std::sin(0.319839835166931*x_28 - 4.28064012527466) - 5.37188578179567*std::sin(0.320079833269119*x_28 - 4.28864002227783) - 3.66649727070612*std::sin(0.322399854660034*x_28 - 4.28247976303101) - 0.127237013620239*std::sin(0.326319843530655*x_28 + 5.13312005996704) + 43.9400879676283*std::sin(0.331519842147827*x_28 - 4.27248001098633) + 0.047547516424328*std::sin(0.33247983455658*x_28 - 4.26847982406616) - 0.26450900248419*std::sin(0.285919934511185*x_3 + 5.08111953735352) + 1.98039877720603*std::sin(0.294319927692413*x_3 + 5.10839986801147) + 1.32802725015464*std::sin(0.307759910821915*x_3 - 7.5032000541687) - 58.1104683025068*std::sin(0.261199980974197*x_30 - 7.53352022171021) - 4.52880690050378*std::sin(0.27295994758606*x_30 - 4.32471990585327) + 0.0185153441882566*std::sin(0.279999971389771*x_30 - 4.29591989517212) + 5.88743235837653*std::sin(0.360319852828979*x_31 + 5.10487985610962) - 12.6620085701545*std::sin(0.255839973688126*x_32 - 4.40239953994751) + 0.135435132538878*std::sin(0.348479837179184*x_32 + 8.2469596862793) - 0.15782230925324*std::sin(0.322319835424423*x_33 + 8.19719982147217) - 0.00814172888692813*std::sin(0.351519852876663*x_34 + 2.00215983390808) + 0.0142339741400959*std::sin(0.313519835472107*x_35 + 1.97631978988647) + 0.00847590370824207*std::sin(0.315679848194122*x_35 + 1.98063981533051) + 5.32747094999763*std::sin(0.317599833011627*x_35 - 7.43431997299194) + 2.90610264714735*std::sin(0.318319827318192*x_35 - 7.43311977386475) - 0.00738251265332157*std::sin(0.319839835166931*x_35 - 7.42831993103027) + 0.131332254665827*std::sin(0.319919854402542*x_35 - 7.42831993103027) - 0.0672244279294639*std::sin(0.321919858455658*x_35 - 7.42599964141846) - 0.0424969568179625*std::sin(0.331519842147827*x_36 - 4.25288009643555) + 2.74572580211359*std::sin(0.352959841489792*x_36 + 5.1637601852417) - 1.10733892682494*std::sin(0.373759835958481*x_36 - 7.41639995574951) - 0.00248890276793648*std::sin(0.380639851093292*x_36 - 7.39903974533081) + 19.8606886006512*std::sin(0.393519848585129*x_36 - 4.2052001953125) + 0.0451769295216343*std::sin(0.418559849262238*x_36 + 5.22079992294312) + 2.41122882075537*std::sin(0.293359935283661*x_37 + 5.09615993499756) + 0.0116367789480347*std::sin(0.298719942569733*x_37 - 7.50471973419189) + 59.2171398529294*std::sin(0.36303985118866*x_37 - 4.24047994613647) - 0.0225361175945875*std::sin(0.364959836006165*x_37 - 7.42208003997803) - 3.50018191736943*std::sin(0.401439845561981*x_37 - 4.20695972442627) - 0.00543294064160966*std::sin(0.48039984703064*x_38 + 5.25888013839722) - 0.00248677307169916*std::sin(0.665279865264893*x_38 + 2.20815992355347) + 5.17896413653169*std::sin(0.19743999838829*x_39 + 4.99631977081299) - 0.0459477941567565*std::sin(0.350079834461212*x_39 + 5.16296005249023) + 0.0304878374231203*std::sin(0.334239840507507*x_40 - 4.27408027648926) - 0.00974933925629781*std::sin(0.390239834785461*x_40 + 8.37495994567871) - 0.0905069581961671*std::sin(0.312159925699234*x_41 + 1.89567983150482) + 4.2960647209744*std::sin(0.375519841909409*x_41 + 5.17112016677856) + 63.9466465936857*std::sin(0.406959861516953*x_41 - 7.39175987243652) - 0.00470768960811609*std::sin(0.431519865989685*x_41 - 7.38671970367432) - 20.0331500996197*std::sin(0.121520057320595*x_42 + 1.70983994007111) + 82.1219763206252*std::sin(0.369279831647873*x_43 - 7.41183996200562) - 0.00597128538486289*std::sin(0.380639851093292*x_43 - 4.22176027297974) + 0.0863929302862263*std::sin(0.383359849452972*x_43 - 7.40655994415283) + 1.4063288126477*std::sin(0.440879851579666*x_43 - 7.37831974029541) - 2.14000855619535*std::sin(0.359359860420227*x_44 + 5.16416025161743) + 0.010632814536378*std::sin(0.407279849052429*x_46 + 5.21623992919922) - 0.571135982881618*std::sin(0.585599839687347*x_46 - 7.21920013427734) - 0.000904328917388055*std::sin(0.645839810371399*x_46 + 5.4171199798584) - 10.6411346787508*std::sin(0.208159998059273*x_47 - 7.59176015853882) + 71.7864553844794*std::sin(0.260319977998734*x_47 + 1.85655987262726) + 0.00414654702816716*std::sin(0.439279854297638*x_47 - 4.15232038497925) - 15.0974939919535*std::sin(0.424719870090485*x_48 - 4.17040014266968) - 0.0205029756990202*std::sin(0.259919971227646*x_49 + 1.85903990268707) + 0.0473750098539192*std::sin(0.437279850244522*x_49 - 7.35431957244873) + 10.8159137518541*std::sin(0.191200003027916*x_50 + 4.98799991607666) - 98.2569943563548*std::sin(0.321759849786758*x_50 - 7.47687959671021) - 3.09937453703521*std::sin(0.36559984087944*x_51 - 4.23184013366699) + 14.7876722518158*std::sin(0.212960004806519*x_53 + 5.00816011428833) - 2.87051935089152*std::sin(0.347519844770432*x_53 + 5.15128040313721) + 0.00716482299616606*std::sin(0.359999865293503*x_53 - 4.24272012710571) - 0.000882589243005398*std::sin(0.889279901981354*x_53 - 3.95743989944458) + 0.0156140167791126*std::sin(0.319359838962555*x_54 + 1.90071976184845) - 2.31245024383764*std::sin(0.417919874191284*x_54 - 7.38679981231689) + 4.8679146525281*std::sin(0.487039864063263*x_54 - 1.10911989212036) + 0.0477412832411625*std::sin(0.658959865570068*x_54 - 3.96943998336792) - 3.84048801079608*std::sin(0.348079830408096*x_55 + 5.15960025787354) - 2.65329931988871*std::sin(0.403119832277298*x_55 + 8.38576030731201) - 0.00519618317915285*std::sin(0.441839843988419*x_55 - 4.14991998672485) - 0.058179708661461*std::sin(0.465039849281311*x_55 + 5.25047969818115) - 2.46039717564752*std::sin(0.322559833526611*x_56 + 1.92327988147736) - 0.70562960154354*std::sin(0.406159847974777*x_56 + 5.19504022598267) + 2.58073537976579*std::sin(0.428879857063293*x_57 - 4.16879987716675) + 0.00526439976238021*std::sin(0.448399841785431*x_57 - 4.15232038497925) + 29.615016818912*std::sin(0.553839862346649*x_57 + 5.35767984390259) + 0.0145742089710006*std::sin(0.853919863700867*x_57 + 5.62479972839355) + 0.210743095868549*std::sin(0.170960009098053*x_58 + 4.96247959136963) - 45.0430567939937*std::sin(0.209440007805824*x_58 + 5.00848007202148) - 0.0339421353538599*std::sin(0.266239941120148*x_58 - 7.51327991485596) + 7.27835028635909*std::sin(0.2743199467659*x_58 + 5.07583951950073) + 0.00616149562559143*std::sin(0.348079830408096*x_58 + 5.15759992599487) - 2.77676787793162*std::sin(0.42223984003067*x_58 - 4.189040184021) - 0.0296651867819946*std::sin(0.462799847126007*x_58 + 5.25392007827759) - 0.0142466936752597*std::sin(0.168560013175011*x_59 - 7.63191986083984) - 82.8501741045619*std::sin(0.251999974250793*x_59 - 7.52784013748169) - 0.012899991252853*std::sin(0.203199997544289*x_64 + 1.78175985813141) - 0.0547247347083618*std::sin(0.222240000963211*x_64 - 4.36191987991333) + 7.99617196643709*std::sin(0.228959992527962*x_64 - 4.36199951171875) + 0.0182750946886101*std::sin(0.339199841022491*x_64 - 7.4555196762085) + 3.20898186705685*std::sin(0.43495985865593*x_66 + 8.44768047332764) + 7.39459160419841*std::sin(0.243759974837303*x_67 - 7.55679988861084) - 9.06969700858291*std::sin(0.247279971837997*x_70 - 7.52800035476685) - 0.0566626480941216*std::sin(0.439999878406525*x_70 - 4.15304040908813) + 0.00169355726948546*std::sin(0.624399840831757*x_70 - 3.97263979911804) + 0.0186253122237127*std::sin(0.23063999414444*x_71 + 5.04759979248047) + 0.0517113544817592*std::sin(0.214000001549721*x_72 + 5.00920009613037) - 129.170739908097*std::sin(0.24959996342659*x_73 + 5.06479978561401) + 3.13964207423459*std::sin(0.342559844255447*x_73 - 4.26151990890503) + 0.00154685692019326*std::sin(0.451039850711823*x_73 - 4.15104007720947) + 0.0643731382391027*std::sin(0.123040057718754*x_75 + 4.89031982421875) - 0.0040406631039872*std::sin(0.278559952974319*x_75 + 5.09087991714478) + 0.90929057146111*std::sin(0.409119844436646*x_75 - 7.38631963729858) - 20.6871573731649*std::sin(0.476879835128784*x_75 + 2.08039975166321) + 0.789218229033765*std::sin(0.540319859981537*x_75 + 5.16431999206543) - 113.461728926377*std::sin(0.238319978117943*x_76 - 7.53840017318726) - 3.44848435312688*std::sin(0.393599838018417*x_78 + 8.3810396194458) - 0.0465998174006066*std::sin(0.486639857292175*x_78 + 5.28744029998779) + 4.20908977983359*std::sin(0.281759947538376*x_79 - 7.4986400604248) + 6.11708639174701*std::sin(0.332239836454391*x_79 + 5.12871980667114) + 64.8057062588827*std::sin(0.355119854211807*x_79 + 1.96583986282349) + 0.0182031026728898*std::sin(0.249199971556664*x_8 - 4.33576011657715) - 1.83615001419492*std::sin(0.501679837703705*x_8 - 7.30711984634399) + 0.298464453674532*std::sin(0.389359831809998*x_81 + 8.37271976470947) - 8.93811358659998*std::sin(0.214159995317459*x_82 - 7.57696008682251) - 0.0457714866404932*std::sin(0.197359994053841*x_83 + 5.00008010864258) + 0.216088556699676*std::sin(0.201599985361099*x_83 + 5.0053596496582) + 0.0621684622018304*std::sin(0.263119965791702*x_83 + 1.87455987930298) - 0.00500440439610714*std::sin(0.319679915904999*x_83 - 7.46343994140625) - 70.9356109220039*std::sin(0.320559918880463*x_83 - 7.46808004379272) + 1.73435741565589*std::sin(0.322239845991135*x_83 - 7.4730396270752) + 3.74752347942064*std::sin(0.393679857254028*x_83 - 1.19831991195679) + 0.0292407048817454*std::sin(0.140080034732819*x_84 - 7.67984008789063) - 0.37385610740275*std::sin(0.179360002279282*x_84 + 1.77599990367889) + 8.77917285310794*std::sin(0.23871998488903*x_84 - 7.55600023269653) - 0.0105357179488174*std::sin(0.278079956769943*x_84 + 5.09272003173828) - 8.10479331050059*std::sin(0.278479933738708*x_84 - 7.49608039855957) - 0.0236330304778473*std::sin(0.187040001153946*x_85 + 4.98767995834351) + 0.0915017512141305*std::sin(0.19064000248909*x_85 - 7.61648035049438) + 0.0137213049304041*std::sin(0.221919998526573*x_85 - 7.56135988235474) - 30.5313441293643*std::sin(0.230239987373352*x_85 - 7.55408048629761) - 0.00378619909175473*std::sin(0.524639844894409*x_86 - 7.27040004730225) - 21.784456187037*std::sin(0.402799844741821*x_87 + 5.20991992950439) - 2.46440154708459*std::sin(0.417919844388962*x_87 - 4.18951988220215) - 0.00230265663747979*std::sin(0.499039828777313*x_87 - 4.11488008499146) - 0.0326009486982576*std::sin(0.87447988986969*x_87 - 0.751359879970551) - 0.139423247096514*std::sin(0.219119995832443*x_89 + 1.8155198097229) - 0.861761638459662*std::sin(0.41023987531662*x_90 - 7.39207983016968) - 0.00646379253207199*std::sin(0.414639860391617*x_90 - 0.994639813899994) + 0.0498446518513883*std::sin(0.505279839038849*x_90 - 4.09320020675659) + 0.095505346819265*std::sin(0.337039858102798*x_92 + 5.18400001525879) + 1.90680044552433*std::sin(0.341039836406708*x_92 + 5.20991992950439) + 0.013394253816995*std::sin(0.360079854726791*x_92 + 1.97791981697083) - 8.76995589056797*std::sin(0.360879838466644*x_92 + 2.00343990325928) - 0.0467879752637517*std::sin(0.363839834928513*x_92 - 7.38535976409912) + 109.88775585164*std::sin(0.365199834108353*x_92 + 1.99775981903076) - 0.00284226076085771*std::sin(0.381279855966568*x_92 + 1.97519981861115) - 0.0209921340488095*std::sin(0.401679873466492*x_92 - 7.59008026123047) - 0.0109188516118461*std::sin(0.374559849500656*x_94 - 1.18543982505798) - 0.0919572441603938*std::sin(0.376239836215973*x_94 + 1.98399984836578) + 3.41078922106902*std::sin(0.386319845914841*x_94 - 7.40639972686768) - 33.4493709861378*std::sin(0.404079854488373*x_94 - 4.21031999588013) + 0.00377732084567497*std::sin(0.367999851703644*x_95 + 1.98935985565186) + 7.71481225206472*std::sin(0.382479846477509*x_95 - 7.39607954025269) + 0.0323351773126077*std::sin(0.376959830522537*x_96 - 4.22176027297974) - 1.3115284123119*std::sin(0.386959820985794*x_96 - 4.2021598815918) - 0.00340823564498513*std::sin(0.396319836378098*x_96 + 5.20240020751953) - 2.08309486589554*std::sin(0.398799866437912*x_96 - 7.3931999206543) + 21.6964109457395*std::sin(0.411679863929749*x_96 + 1.98543977737427) + 0.138120197425748*std::sin(0.326879858970642*x_97 + 5.13624000549316) + 1.24386929804999*std::sin(0.339759826660156*x_97 + 5.16359996795654) + 0.0633622794223327*std::sin(0.362479835748672*x_97 - 4.41720008850098) + 5.81961518511456*std::sin(0.403599858283997*x_97 + 5.19040012359619) + 0.00629962887087795*std::sin(0.518239855766296*x_97 + 2.16407990455627) + 0.0317450170107678*std::sin(0.395679831504822*x_98 - 4.19135999679565) + 0.0743774416087672*std::sin(0.406559854745865*x_98 - 7.38751983642578) - 0.00398843593682805*std::sin(0.414239853620529*x_98 - 7.39607954025269) + 0.00767240752330175*std::sin(0.430639863014221*x_98 - 7.37799978256226) - 0.86049516988655*std::sin(0.433199852705002*x_98 - 7.38143968582153) + 52.9954007122092*std::sin(0.382719844579697*x_99 - 7.42312002182007) - 0.0277803482368768*std::sin(0.398159861564636*x_99 - 7.40983963012695) - 0.116546789855877*std::sin(0.402159839868546*x_99 - 4.20552015304565) + 0.0920426361906051*std::sin(0.403039842844009*x_99 + 5.20864009857178) - 1.16094629206293*std::sin(0.415279865264893*x_99 - 4.19144010543823) - 1192.26352536819);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.189218332727457*x_1 + 1.28804239369257*x_10 + 1.28371557966117*x_100 - 8.6500521992529*x_101 + 0.289420726819908*x_102 + 2.19680533000518*x_103 - 0.0299564693947988*x_104 - 1.10841772265776*x_105 - 0.0555764590284385*x_106 + 0.255471315958394*x_107 - 2.40777586503703*x_108 + 1.6904353037344*x_109 + 1.00654205202085*x_11 - 1.57439732217038*x_110 - 0.0234090768049231*x_111 - 0.0014516518107967*x_112 - 0.165422818369859*x_113 - 0.0096242743318181*x_114 - 1.60413469076782*x_115 - 0.119148063311631*x_116 - 0.0245291237587401*x_117 + 0.833245558644607*x_118 + 0.0013445773883924*x_119 + 4.03865268046813*x_12 + 0.0983617281863188*x_120 - 0.154114260429241*x_13 + 6.04031945271517*x_14 + 5.61444733564726*x_15 - 0.988711289855181*x_16 + 1.27834939227584*x_17 - 0.406631033090363*x_18 - 2.72654215034935*x_19 + 1.02275906144392*x_2 + 8.67776511518575*x_20 + 1.54471103274092*x_21 + 1.33156911205526*x_22 + 5.29557105547281*x_23 + 0.0411531696432463*x_24 - 1.0387888824811*x_25 - 0.0892683125424412*x_26 - 0.286435980447214*x_27 - 0.0040034663656541*x_28 - 1.1563406629503*x_29 + 2.459378377889*x_3 - 0.194509137346332*x_30 - 2.49099119469253*x_31 + 0.643198590670784*x_32 - 2.5979641249631*x_33 - 3.50758021128541*x_34 + 2.03029884791284*x_35 + 0.00921596378135409*x_36 - 0.0692432542775809*x_37 - 1.58099549071959*x_38 - 1.0262709700936*x_39 - 0.672758165112191*x_4 + 0.604271337515394*x_40 + 0.0150208929593498*x_41 - 1.03454396505049*x_42 + 0.531516680118931*x_43 + 4.79675016827795*x_44 - 1.08006345979233*x_45 + 3.7663993541353*x_46 + 0.106393494135607*x_47 - 0.678007572723412*x_48 - 0.413619816705296*x_49 - 1.7255295594269*x_5 + 0.133412644789023*x_50 - 1.16513947447661*x_51 - 2.19502856022312*x_52 + 1.01173893661009*x_53 - 0.929648114336355*x_54 - 2.01495974218766*x_55 + 1.02085764456192*x_56 - 0.0969807282316563*x_57 - 0.00682614593867154*x_58 - 0.0127758911560626*x_59 - 0.841614738395297*x_6 - 0.199541463413471*x_60 - 6.13469651204641*x_61 + 70.450780945986*x_62 + 1.16378602235294*x_63 - 0.886131866336612*x_64 - 1.9588490331449*x_65 - 0.08761731578358*x_66 + 1.17912717622165*x_67 + 1.2969369493605*x_68 + 2.34813023688406*x_69 + 1.41456382771761*x_7 + 0.0612813757874392*x_70 + 2.51971789568567*x_71 + 1.44975298368956*x_72 + 0.0148819171503375*x_73 + 7.97406340113427*x_74 + 0.0107491543963818*x_75 - 0.770948926835446*x_76 - 5.70699148740369*x_77 + 2.13351050299093*x_78 + 0.0147479616715689*x_79 - 5.79301147583196*x_8 + 0.977181347064917*x_80 - 0.0367098768256421*x_81 + 0.96013826204765*x_82 - 0.00607714894518217*x_83 + 0.0255291408774328*x_84 - 0.462528903801039*x_85 - 1.58189633700884*x_86 - 0.0130129018033409*x_87 + 0.0524117807892999*x_88 + 3.20981542936496*x_89 + 6.5091394414676*x_9 - 1.77481078406333*x_90 - 2.65818847876966*x_91 + 0.00475313828688315*x_92 - 12.3291138039595*x_93 - 0.620222914877512*x_94 + 0.962464889353693*x_95 - 0.0061363762749321*x_96 + 4.90566919331454*x_97 - 0.832999540990666*x_98 - 0.0255606083671431*x_99 + 0.0290307806780742*std::pow(-7.36319971084595*x_106 - 7.55671977996826, 2) - 9.5443097142835e-5*std::pow(-5.29512023925781*x_108 - 7.73583984375, 2) + 0.271396878120242*std::pow(-0.582399845123291*x_108 - 0.778079867362976, 2) + 0.000214845232899756*std::pow(-7.56576013565063*x_109 - 9.54831981658936, 2) - 0.00382307647915279*std::pow(-6.31343984603882*x_11 - 9.7729606628418, 2) - 0.0145652749335981*std::pow(-8.15095996856689*x_116 - 8.55615997314453, 2) - 0.000377790251852706*std::pow(-7.33599996566772*x_118 - 8.55144023895264, 2) + 0.00705141974970266*std::pow(-6.34631967544556*x_120 - 8.5252799987793, 2) + 0.00014252704266757*std::pow(-4.97463989257813*x_120 - 5.7960000038147, 2) + 0.000524625168618756*std::pow(-5.00879955291748*x_13 - 7.81375980377197, 2) - 3.41744335139279e-5*std::pow(-5.29879999160767*x_15 - 5.5019998550415, 2) - 0.000486008684345781*std::pow(-5.08487987518311*x_15 - 7.32096004486084, 2) + 0.00108160669162215*std::pow(-8.73536014556885*x_18 - 9.75536060333252, 2) - 0.000403968870445291*std::pow(-6.31343984603882*x_19 - 9.57096099853516, 2) + 0.00235460180145086*std::pow(-7.01279973983765*x_23 - 9.21599960327148, 2) + 2.16668432358963e-5*std::pow(-6.67776012420654*x_24 - 9.96127986907959, 2) + 0.0204050804715505*std::pow(-4.61759996414185*x_24 - 6.62983989715576, 2) + 8.19207843018288e-5*std::pow(-7.44783973693848*x_27 - 8.82520008087158, 2) - 0.0403232210457243*std::pow(-5.21519994735718*x_39 - 6.82528018951416, 2) - 0.000150725621148454*std::pow(-6.29800033569336*x_4 - 9.95495986938477, 2) - 0.000667461382862942*std::pow(-4.83800029754639*x_44 - 6.05071973800659, 2) - 0.000772022477133918*std::pow(-5.75367975234985*x_47 - 7.59768009185791, 2) - 0.000128809014415804*std::pow(-6.32687997817993*x_5 - 9.3877592086792, 2) + 0.00029238247908657*std::pow(-7.51128005981445*x_50 - 8.1159200668335, 2) + 0.000853181797493829*std::pow(-7.70344018936157*x_59 - 9.92232036590576, 2) - 0.000531442423761136*std::pow(-6.26208019256592*x_59 - 9.90112018585205, 2) + 0.000506580629066554*std::pow(-4.89711999893188*x_6 - 7.75040006637573, 2) - 7.71793959580453e-5*std::pow(-8.05943965911865*x_64 - 9.632080078125, 2) + 9.86125611410494e-5*std::pow(-3.31583976745605*x_66 - 4.76936006546021, 2) + 0.00262711962668596*std::pow(-5.33400011062622*x_67 - 5.12992000579834, 2) - 0.000194940607587484*std::pow(-4.89463996887207*x_7 - 6.54287958145142, 2) - 0.000525481136798204*std::pow(-6.32664012908936*x_70 - 8.89144039154053, 2) + 0.0332496379630943*std::pow(-5.72743988037109*x_70 - 7.97160005569458, 2) + 0.000425432708297668*std::pow(-6.03951978683472*x_72 - 8.25783920288086, 2) + 0.000177569904169873*std::pow(-5.92343997955322*x_72 - 7.55639982223511, 2) + 0.00198821588998347*std::pow(-5.51567983627319*x_72 - 6.31112003326416, 2) + 0.00177914134096291*std::pow(-5.3295202255249*x_72 - 7.79544019699097, 2) - 0.00101635830387324*std::pow(-5.7279200553894*x_73 - 7.8930401802063, 2) + 0.000308003563167105*std::pow(-7.48496007919312*x_74 - 9.9323205947876, 2) + 0.0046794700954525*std::pow(-5.3471999168396*x_74 - 6.92751979827881, 2) - 0.000132595001960979*std::pow(-6.85536003112793*x_77 - 8.66800022125244, 2) - 0.0105942180261195*std::pow(-4.26240015029907*x_78 - 5.81343936920166, 2) - 0.0252461009576638*std::pow(-7.15487957000732*x_81 - 9.58255958557129, 2) - 0.000130648436142945*std::pow(-8.56280040740967*x_84 - 8.97383975982666, 2) - 0.000146767090148585*std::pow(-8.34360027313232*x_84 - 8.74335956573486, 2) - 4.24363832251817e-5*std::pow(-7.32399988174438*x_84 - 6.70928001403809, 2) - 0.000483504703350184*std::pow(-5.07727956771851*x_86 - 7.30615997314453, 2) + 0.00699188086651713*std::pow(-4.13991975784302*x_87 - 5.91967964172363, 2) - 0.0210384488064231*std::pow(-8.75607967376709*x_88 - 9.97624015808105, 2) + 2.85214781510206e-5*std::pow(-8.0033597946167*x_88 - 9.20728015899658, 2) + 0.000336467434791683*std::pow(-2.1943998336792*x_88 - 2.17791986465454, 2) - 0.00100703304313703*std::pow(-3.1781599521637*x_90 - 4.56775999069214, 2) - 2.03884867484958e-5*std::pow(-5.24519968032837*x_99 - 6.02455997467041, 2) + 0.0147986441600368*std::exp(0.702079832553864*x_1) + 0.000393190213798443*std::exp(1.08351981639862*x_1) - 0.000334021151139646*std::exp(1.19423997402191*x_1) + 0.0207164926825634*std::exp(1.22735989093781*x_1) - 5.83468526125633e-5*std::exp(1.28807985782623*x_1) - 0.00260771045575055*std::exp(1.19983983039856*x_100) - 0.000807079611015931*std::exp(1.62295985221863*x_100) - 0.0384051353911464*std::exp(0.515199840068817*x_103) - 0.0576000817516266*std::exp(0.528799831867218*x_104) - 0.0528423829856089*std::exp(1.06327986717224*x_104) + 0.0976327360586586*std::exp(0.650879800319672*x_106) - 0.021716168292292*std::exp(0.665519833564758*x_106) + 0.00340034175029049*std::exp(0.792479872703552*x_106) + 0.897277296854411*std::exp(1.33487987518311*x_106) + 0.266643242116651*std::exp(0.648639798164368*x_109) - 0.653108410724477*std::exp(0.855439901351929*x_110) + 0.00150066433155964*std::exp(1.08487975597382*x_110) + 0.000530292229949049*std::exp(1.55039989948273*x_110) + 0.000145650822743746*std::exp(1.59975981712341*x_110) - 0.516491423627711*std::exp(0.604959845542908*x_112) - 0.000880924892908314*std::exp(0.914159834384918*x_112) + 0.00421570702384273*std::exp(0.571999847888947*x_24) + 0.00765032490076943*std::exp(0.514479875564575*x_26) + 2.43983652175693*std::exp(0.62559986114502*x_26) + 0.0158364775563454*std::exp(0.643839836120605*x_26) + 0.00244009091654142*std::exp(0.829519867897034*x_26) - 0.00735780117976966*std::exp(0.874719858169556*x_26) - 0.00330553304847635*std::exp(0.913679838180542*x_26) - 7.81886829639843*std::exp(0.491599857807159*x_31) + 0.0248754766841078*std::exp(0.599999845027924*x_31) + 0.00493726340682618*std::exp(0.620239853858948*x_31) - 0.0062304797980205*std::exp(0.647599816322327*x_31) + 0.00729292782283765*std::exp(0.654319822788239*x_31) - 0.290268963316684*std::exp(0.655279815196991*x_31) - 0.185085659462855*std::exp(0.654959857463837*x_45) + 0.0221435204742057*std::exp(0.825759887695313*x_45) + 0.00293545927913827*std::exp(1.0123997926712*x_45) + 0.0510866462563698*std::exp(1.11879980564117*x_45) + 0.00050332378378737*std::exp(1.23079991340637*x_45) + 0.192391889593675*std::exp(0.99375981092453*x_6) + 0.0134966010329849*std::exp(0.713119864463806*x_60) + 1.01828097979972*std::exp(0.968719840049744*x_60) - 0.00599392708802921*std::exp(1.24247992038727*x_60) + 0.000199145319309165*std::exp(1.45055985450745*x_66) - 0.0547428214902199*std::exp(1.66143977642059*x_66) - 0.00120762534423593*std::exp(0.718239843845367*x_70) + 0.0041976447799451*std::exp(0.895999848842621*x_70) - 0.00206107368824888*std::exp(0.875359892845154*x_72) - 0.00257837238335914*std::exp(0.97439980506897*x_74) - 0.00494365045216655*std::exp(1.0343998670578*x_74) + 0.00615536048933983*std::exp(1.24767982959747*x_74) + 0.000126362368221621*std::exp(1.71327984333038*x_74) + 0.656402129075971*std::exp(0.599999845027924*x_76) - 0.0190795029950198*std::exp(0.73831981420517*x_77) - 0.010247045963799*std::exp(0.885519862174988*x_81) - 0.00765322959093479*std::exp(1.09175980091095*x_81) + 0.0137898771517162*std::exp(0.719999849796295*x_87) - 0.319669237455643*std::sin(0.222879990935326*x_1 - 1.19911992549896) + 1.07640780569876*std::sin(0.184960007667542*x_10 + 1.76799988746643) + 3.55666547584406*std::sin(0.330879837274551*x_10 - 7.47408008575439) - 0.562531397874899*std::sin(0.372159838676453*x_100 - 7.40847969055176) - 0.413212996844768*std::sin(0.155280038714409*x_102 - 7.65199995040894) + 4.198186481812*std::sin(0.298239946365356*x_102 - 7.52088022232056) + 0.13074944936694*std::sin(0.342959851026535*x_102 - 7.44087982177734) + 0.162834481109721*std::sin(0.371279835700989*x_102 + 1.97439980506897) - 0.0122506918820742*std::sin(0.430479854345322*x_102 - 4.16527986526489) + 0.66649052613144*std::sin(0.445199847221375*x_102 + 5.23176002502441) + 0.496237547783762*std::sin(0.314079850912094*x_103 - 7.47591972351074) - 22.2037707602498*std::sin(0.465919852256775*x_103 - 7.36799955368042) - 33.2795151692069*std::sin(0.487919867038727*x_104 - 4.14376020431519) + 1.1783198870247*std::sin(0.60919988155365*x_104 - 7.1910400390625) - 0.0505578617083803*std::sin(0.640159845352173*x_104 - 7.17999982833862) + 0.0373470221741022*std::sin(0.263999968767166*x_105 + 1.85087990760803) + 1.92403401126548*std::sin(0.319519847631454*x_105 + 1.92879974842072) + 0.160749399689156*std::sin(0.355839848518372*x_105 - 7.42432022094727) + 0.195918250805011*std::sin(0.357599824666977*x_105 - 7.44007968902588) - 0.0839039074368007*std::sin(0.187360003590584*x_106 - 7.61688041687012) + 0.131593504501003*std::sin(0.432319849729538*x_106 + 5.221360206604) + 52.7297903989926*std::sin(0.299039930105209*x_107 + 5.11175966262817) + 6.10168219822317*std::sin(0.363919854164124*x_107 - 7.4172797203064) - 0.187335840779986*std::sin(0.44327986240387*x_107 + 5.22464036941528) - 0.250975055480733*std::sin(0.347679853439331*x_108 + 5.14847993850708) + 0.712072155327459*std::sin(0.663199841976166*x_108 + 2.2377598285675) - 0.195675251581324*std::sin(0.345519840717316*x_109 + 5.15944004058838) + 0.492236015254335*std::sin(0.375519841909409*x_110 + 5.1691198348999) - 0.0285230800668826*std::sin(0.590079843997955*x_110 - 7.21264028549194) - 3.51879172752898*std::sin(0.3572798371315*x_111 - 7.43255996704102) + 0.0760388745590792*std::sin(0.401119828224182*x_111 - 4.20544004440308) + 0.586878127348456*std::sin(0.439599871635437*x_111 - 1.17359983921051) + 0.0135346662977368*std::sin(0.456559866666794*x_111 + 8.23095989227295) + 8.98235046294563*std::sin(0.473359853029251*x_111 + 2.04543972015381) + 0.0356437084681608*std::sin(0.496959865093231*x_111 - 4.12064027786255) + 75.680685850957*std::sin(0.198719993233681*x_112 + 4.99071979522705) - 0.330501054564374*std::sin(0.353759855031967*x_112 - 7.41695976257324) - 0.0609452236449666*std::sin(0.411039859056473*x_112 - 0.981599867343903) + 0.911010469497739*std::sin(0.48583984375*x_112 + 5.23848009109497) - 0.174932140647389*std::sin(0.507519841194153*x_112 - 1.01695990562439) + 83.5208726192266*std::sin(0.304399937391281*x_113 - 7.4966402053833) + 5.27863863232284*std::sin(0.345999836921692*x_113 - 7.43743991851807) + 0.417134350993572*std::sin(0.268559962511063*x_114 - 7.53224039077759) + 4.32434182722531*std::sin(0.269199967384338*x_114 - 7.52320003509521) - 20.7634099594466*std::sin(0.367759823799133*x_114 - 7.42456007003784) + 0.0308462550696155*std::sin(0.429439842700958*x_114 + 5.22695970535278) - 0.0202904879664251*std::sin(0.468559861183167*x_114 - 4.1592001914978) - 0.0364013145182996*std::sin(0.576479852199554*x_114 - 7.21895980834961) - 0.439080138251384*std::sin(0.665199875831604*x_114 + 5.43255996704102) + 0.0464340537598772*std::sin(0.302079945802689*x_115 + 5.103919506073) - 3.80815688048074*std::sin(0.325759828090668*x_115 - 7.45439958572388) - 5.16091182562664*std::sin(0.416079849004745*x_115 + 5.22344017028809) - 0.0662022214124079*std::sin(0.48447984457016*x_115 - 4.12936019897461) + 0.00508578178419917*std::sin(0.534799814224243*x_115 + 5.36311960220337) + 0.573692443120741*std::sin(0.435039848089218*x_116 + 8.42255973815918) - 1.70092864855405*std::sin(0.49839985370636*x_116 - 4.12344026565552) - 0.360194634613275*std::sin(0.243599966168404*x_117 - 1.35351991653442) + 16.0726826125663*std::sin(0.376959830522537*x_117 + 1.97719979286194) + 0.293249945301309*std::sin(0.378399848937988*x_117 + 5.1756796836853) + 3.98225258162418*std::sin(0.400079846382141*x_117 - 4.1864800453186) - 0.209119506786353*std::sin(0.616959869861603*x_117 - 3.99599981307983) - 0.714665109607084*std::sin(0.191840007901192*x_118 + 1.78999984264374) + 3.02762130470271*std::sin(0.408879846334457*x_118 + 5.20247983932495) - 0.310227477967858*std::sin(0.419359862804413*x_118 + 5.21727991104126) - 0.085049441604005*std::sin(0.289599925279617*x_119 - 4.28279972076416) - 1.54884291191586*std::sin(0.340479850769043*x_119 + 5.15120029449463) + 8.4926183352851*std::sin(0.34895983338356*x_119 + 5.15208005905151) + 0.141612682944917*std::sin(0.366079837083817*x_119 - 7.41511964797974) - 12.5205623722611*std::sin(0.434239864349365*x_119 + 1.99407982826233) + 1.03528412033391*std::sin(0.35471984744072*x_12 - 1.03167986869812) - 0.0293991321693573*std::sin(0.328399837017059*x_120 + 1.94799983501434) - 0.242968734275198*std::sin(0.36695984005928*x_120 + 5.15912008285522) - 0.24248566833986*std::sin(0.427679866552353*x_120 + 5.2294397354126) - 9.60310911039812*std::sin(0.211919993162155*x_14 - 4.38903999328613) - 0.0721691952209511*std::sin(0.272799968719482*x_16 + 5.08839988708496) - 0.247948305222315*std::sin(0.368559837341309*x_16 + 5.15863990783691) + 0.723013393872698*std::sin(0.369679838418961*x_16 + 5.18168020248413) + 0.0395164728933131*std::sin(0.427279859781265*x_18 - 0.954639852046967) - 0.199334791835532*std::sin(0.348479837179184*x_20 - 4.25511980056763) + 4.51324459041388*std::sin(0.361199855804443*x_20 + 5.16968011856079) - 1.92557647281731*std::sin(0.357999831438065*x_21 + 8.36407947540283) + 6.69709342003955*std::sin(0.209600001573563*x_22 - 7.57504034042358) + 0.0922097628292965*std::sin(0.502079844474792*x_22 + 2.10895967483521) + 0.0565316700211601*std::sin(0.589439868927002*x_22 - 7.22200012207031) - 0.784861127341527*std::sin(0.162880018353462*x_24 + 4.93567991256714) + 0.0995886486457217*std::sin(0.182560011744499*x_24 + 4.98351955413818) + 0.316574944145068*std::sin(0.190160006284714*x_24 - 7.60288000106812) - 1.21938207270105*std::sin(0.338639855384827*x_24 - 4.25832033157349) - 0.0435902854598281*std::sin(0.46111986041069*x_25 - 4.13752031326294) - 0.399833002559819*std::sin(0.186080008745193*x_26 - 7.6005597114563) + 1.03542431646378*std::sin(0.137440040707588*x_27 + 4.9017596244812) + 12.7080300374661*std::sin(0.171120017766953*x_27 - 7.6241602897644) + 0.106508193987064*std::sin(0.301679939031601*x_27 + 5.12080001831055) + 44.486632570734*std::sin(0.303999930620193*x_27 + 5.13247966766357) + 0.497371205826972*std::sin(0.319839835166931*x_28 - 4.28064012527466) - 3.51963761831882*std::sin(0.320079833269119*x_28 - 4.28864002227783) + 6.08365897674047*std::sin(0.322399854660034*x_28 - 4.28247976303101) - 0.121604513275497*std::sin(0.326319843530655*x_28 + 5.13312005996704) - 24.6980097882386*std::sin(0.331519842147827*x_28 - 4.27248001098633) - 0.0117121127854458*std::sin(0.33247983455658*x_28 - 4.26847982406616) - 0.252799775701124*std::sin(0.285919934511185*x_3 + 5.08111953735352) + 1.29754918824744*std::sin(0.294319927692413*x_3 + 5.10839986801147) - 2.20353768331137*std::sin(0.307759910821915*x_3 - 7.5032000541687) + 32.6629504244915*std::sin(0.261199980974197*x_30 - 7.53352022171021) - 2.96725577954987*std::sin(0.27295994758606*x_30 - 4.32471990585327) - 0.237766282820426*std::sin(0.279999971389771*x_30 - 4.29591989517212) - 9.76875968329625*std::sin(0.360319852828979*x_31 + 5.10487985610962) - 8.29609628671108*std::sin(0.255839973688126*x_32 - 4.40239953994751) - 0.0333609758552087*std::sin(0.348479837179184*x_32 + 8.2469596862793) + 0.0388754834119515*std::sin(0.322319835424423*x_33 + 8.19719982147217) - 0.286837856042486*std::sin(0.351519852876663*x_34 + 2.00215983390808) - 0.0568795605120015*std::sin(0.313519835472107*x_35 + 1.97631978988647) - 0.108843999752961*std::sin(0.315679848194122*x_35 + 1.98063981533051) + 3.49053720197389*std::sin(0.317599833011627*x_35 - 7.43431997299194) - 4.8219693487573*std::sin(0.318319827318192*x_35 - 7.43311977386475) - 0.26009022544157*std::sin(0.319839835166931*x_35 - 7.42831993103027) - 0.0323503369826073*std::sin(0.319919854402542*x_35 - 7.42831993103027) - 0.047689627160801*std::sin(0.321919858455658*x_35 - 7.42599964141846) - 0.0301477318370607*std::sin(0.331519842147827*x_36 - 4.25288009643555) + 1.79898832835519*std::sin(0.352959841489792*x_36 + 5.1637601852417) + 1.83735917555321*std::sin(0.373759835958481*x_36 - 7.41639995574951) - 0.0876854957672836*std::sin(0.380639851093292*x_36 - 7.39903974533081) - 11.1633704925993*std::sin(0.393519848585129*x_36 - 4.2052001953125) - 0.180528914214741*std::sin(0.418559849262238*x_36 + 5.22079992294312) - 4.00084679663177*std::sin(0.293359935283661*x_37 + 5.09615993499756) + 0.409970507621996*std::sin(0.298719942569733*x_37 - 7.50471973419189) - 33.2849925288414*std::sin(0.36303985118866*x_37 - 4.24047994613647) + 0.289399368177428*std::sin(0.364959836006165*x_37 - 7.42208003997803) - 2.29330489287037*std::sin(0.401439845561981*x_37 - 4.20695972442627) - 0.191405666694138*std::sin(0.48039984703064*x_38 + 5.25888013839722) + 0.0319340965776298*std::sin(0.665279865264893*x_38 + 2.20815992355347) + 3.39323614449*std::sin(0.19743999838829*x_39 + 4.99631977081299) + 0.590042297316795*std::sin(0.350079834461212*x_39 + 5.16296005249023) + 1.07410428955209*std::sin(0.334239840507507*x_40 - 4.27408027648926) + 0.125196924850872*std::sin(0.390239834785461*x_40 + 8.37495994567871) + 0.0222940708995427*std::sin(0.312159925699234*x_41 + 1.89567983150482) + 2.81476405435029*std::sin(0.375519841909409*x_41 + 5.17112016677856) - 35.9433714529527*std::sin(0.406959861516953*x_41 - 7.39175987243652) + 0.0604541750568185*std::sin(0.431519865989685*x_41 - 7.38671970367432) - 13.1256381032881*std::sin(0.121520057320595*x_42 + 1.70983994007111) - 46.159429095603*std::sin(0.369279831647873*x_43 - 7.41183996200562) - 0.210371865902076*std::sin(0.380639851093292*x_43 - 4.22176027297974) - 0.34522979019487*std::sin(0.383359849452972*x_43 - 7.40655994415283) + 0.921420892732741*std::sin(0.440879851579666*x_43 - 7.37831974029541) + 3.55082284315786*std::sin(0.359359860420227*x_44 + 5.16416025161743) - 0.136542143777*std::sin(0.407279849052429*x_46 + 5.21623992919922) + 0.947661021585346*std::sin(0.585599839687347*x_46 - 7.21920013427734) - 0.0318600350642087*std::sin(0.645839810371399*x_46 + 5.4171199798584) + 17.6563705715288*std::sin(0.208159998059273*x_47 - 7.59176015853882) - 40.3500006430352*std::sin(0.260319977998734*x_47 + 1.85655987262726) + 0.146085269610047*std::sin(0.439279854297638*x_47 - 4.15232038497925) + 8.48605616506386*std::sin(0.424719870090485*x_48 - 4.17040014266968) + 0.263290612863977*std::sin(0.259919971227646*x_49 + 1.85903990268707) - 0.189312535854059*std::sin(0.437279850244522*x_49 - 7.35431957244873) + 7.08654250366294*std::sin(0.191200003027916*x_50 + 4.98799991607666) + 55.2286606745985*std::sin(0.321759849786758*x_50 - 7.47687959671021) + 5.14265696449946*std::sin(0.36559984087944*x_51 - 4.23184013366699) + 9.68882244690292*std::sin(0.212960004806519*x_53 + 5.00816011428833) + 4.76292753753917*std::sin(0.347519844770432*x_53 + 5.15128040313721) + 0.252420891887445*std::sin(0.359999865293503*x_53 - 4.24272012710571) + 0.00352686380912792*std::sin(0.889279901981354*x_53 - 3.95743989944458) - 0.200508653348179*std::sin(0.319359838962555*x_54 + 1.90071976184845) - 1.51510795264542*std::sin(0.417919874191284*x_54 - 7.38679981231689) - 2.73617576334903*std::sin(0.487039864063263*x_54 - 1.10911989212036) - 0.0117598422776151*std::sin(0.658959865570068*x_54 - 3.96943998336792) - 2.5162720550216*std::sin(0.348079830408096*x_55 + 5.15960025787354) + 4.40250381594083*std::sin(0.403119832277298*x_55 + 8.38576030731201) + 0.066727204571482*std::sin(0.441839843988419*x_55 - 4.14991998672485) - 0.0412732201648536*std::sin(0.465039849281311*x_55 + 5.25047969818115) + 4.08242970302069*std::sin(0.322559833526611*x_56 + 1.92327988147736) - 0.462325632203182*std::sin(0.406159847974777*x_56 + 5.19504022598267) - 4.28210163557007*std::sin(0.428879857063293*x_57 - 4.16879987716675) + 0.18546787324448*std::sin(0.448399841785431*x_57 - 4.15232038497925) - 16.6461199579573*std::sin(0.553839862346649*x_57 + 5.35767984390259) - 0.0582391532344738*std::sin(0.853919863700867*x_57 + 5.62479972839355) - 0.84213829222686*std::sin(0.170960009098053*x_58 + 4.96247959136963) + 25.3179706515342*std::sin(0.209440007805824*x_58 + 5.00848007202148) + 0.435870663381654*std::sin(0.266239941120148*x_58 - 7.51327991485596) + 4.76874537317656*std::sin(0.2743199467659*x_58 + 5.07583951950073) + 0.217073083592522*std::sin(0.348079830408096*x_58 + 5.15759992599487) + 4.60736980820114*std::sin(0.42223984003067*x_58 - 4.189040184021) + 0.00730725891740304*std::sin(0.462799847126007*x_58 + 5.25392007827759) - 0.50191932527581*std::sin(0.168560013175011*x_59 - 7.63191986083984) + 46.5687372428396*std::sin(0.251999974250793*x_59 - 7.52784013748169) + 0.165656276082204*std::sin(0.203199997544289*x_64 + 1.78175985813141) - 0.0388222298812849*std::sin(0.222240000963211*x_64 - 4.36191987991333) + 5.23905920542688*std::sin(0.228959992527962*x_64 - 4.36199951171875) + 0.0184305934817682*std::sin(0.339199841022491*x_64 - 7.4555196762085) - 5.32452362577595*std::sin(0.43495985865593*x_66 + 8.44768047332764) - 12.2695232726977*std::sin(0.243759974837303*x_67 - 7.55679988861084) + 15.0489525966442*std::sin(0.247279971837997*x_70 - 7.52800035476685) + 0.226426329661585*std::sin(0.439999878406525*x_70 - 4.15304040908813) - 0.0217479520021271*std::sin(0.624399840831757*x_70 - 3.97263979911804) + 0.656180609863975*std::sin(0.23063999414444*x_71 + 5.04759979248047) - 0.206640751729155*std::sin(0.214000001549721*x_72 + 5.00920009613037) + 72.6047749598169*std::sin(0.24959996342659*x_73 + 5.06479978561401) - 5.20947113237338*std::sin(0.342559844255447*x_73 - 4.26151990890503) + 0.0544966712543194*std::sin(0.451039850711823*x_73 - 4.15104007720947) - 0.826652836532447*std::sin(0.123040057718754*x_75 + 4.89031982421875) - 0.142354917221391*std::sin(0.278559952974319*x_75 + 5.09087991714478) + 0.595763467671375*std::sin(0.409119844436646*x_75 - 7.38631963729858) + 11.6279151664347*std::sin(0.476879835128784*x_75 + 2.08039975166321) - 1.30951537916836*std::sin(0.540319859981537*x_75 + 5.16431999206543) + 63.7749950268338*std::sin(0.238319978117943*x_76 - 7.53840017318726) - 2.25943285998014*std::sin(0.393599838018417*x_78 + 8.3810396194458) - 0.0445369468560557*std::sin(0.486639857292175*x_78 + 5.28744029998779) - 6.98395905748477*std::sin(0.281759947538376*x_79 - 7.4986400604248) + 4.00789001357026*std::sin(0.332239836454391*x_79 + 5.12871980667114) - 36.4262349382363*std::sin(0.355119854211807*x_79 + 1.96583986282349) + 0.641305921202561*std::sin(0.249199971556664*x_8 - 4.33576011657715) - 1.20303798802603*std::sin(0.501679837703705*x_8 - 7.30711984634399) + 0.195552690722458*std::sin(0.389359831809998*x_81 + 8.37271976470947) + 14.8306219646449*std::sin(0.214159995317459*x_82 - 7.57696008682251) - 1.61255616321436*std::sin(0.197359994053841*x_83 + 5.00008010864258) - 0.863498978976467*std::sin(0.201599985361099*x_83 + 5.0053596496582) + 0.0626974400818139*std::sin(0.263119965791702*x_83 + 1.87455987930298) + 0.0642644618914121*std::sin(0.319679915904999*x_83 - 7.46343994140625) + 39.8717547897731*std::sin(0.320559918880463*x_83 - 7.46808004379272) - 2.87774360148354*std::sin(0.322239845991135*x_83 - 7.4730396270752) + 2.45536207385499*std::sin(0.393679857254028*x_83 - 1.19831991195679) - 0.375496865523639*std::sin(0.140080034732819*x_84 - 7.67984008789063) - 0.265216959414409*std::sin(0.179360002279282*x_84 + 1.77599990367889) + 5.75207818755842*std::sin(0.23871998488903*x_84 - 7.55600023269653) - 0.371179486602546*std::sin(0.278079956769943*x_84 + 5.09272003173828) + 13.4479299826554*std::sin(0.278479933738708*x_84 - 7.49608039855957) + 0.303485463265843*std::sin(0.187040001153946*x_85 + 4.98767995834351) - 0.365644853918722*std::sin(0.19064000248909*x_85 - 7.61648035049438) + 0.483409573445924*std::sin(0.221919998526573*x_85 - 7.56135988235474) + 17.1611726565194*std::sin(0.230239987373352*x_85 - 7.55408048629761) + 0.048620780413878*std::sin(0.524639844894409*x_86 - 7.27040004730225) + 12.244689007798*std::sin(0.402799844741821*x_87 + 5.20991992950439) - 1.61466582576196*std::sin(0.417919844388962*x_87 - 4.18951988220215) - 0.0811239359931457*std::sin(0.499039828777313*x_87 - 4.11488008499146) - 0.0311577770176497*std::sin(0.87447988986969*x_87 - 0.751359879970551) + 0.557141170972541*std::sin(0.219119995832443*x_89 + 1.8155198097229) - 0.564622704940092*std::sin(0.41023987531662*x_90 - 7.39207983016968) + 0.0830053121155562*std::sin(0.414639860391617*x_90 - 0.994639813899994) - 0.0122779532589013*std::sin(0.505279839038849*x_90 - 4.09320020675659) + 0.0912775369738551*std::sin(0.337039858102798*x_92 + 5.18400001525879) - 3.16387079841811*std::sin(0.341039836406708*x_92 + 5.20991992950439) - 0.172003388586215*std::sin(0.360079854726791*x_92 + 1.97791981697083) - 5.74603927135655*std::sin(0.360879838466644*x_92 + 2.00343990325928) - 0.0331918197694196*std::sin(0.363839834928513*x_92 - 7.38535976409912) - 61.7661228086491*std::sin(0.365199834108353*x_92 + 1.99775981903076) - 0.100134503897207*std::sin(0.381279855966568*x_92 + 1.97519981861115) + 0.0838854523096145*std::sin(0.401679873466492*x_92 - 7.59008026123047) + 0.140215311906708*std::sin(0.374559849500656*x_94 - 1.18543982505798) - 0.0652353143614011*std::sin(0.376239836215973*x_94 + 1.98399984836578) + 2.2347351634528*std::sin(0.386319845914841*x_94 - 7.40639972686768) + 18.8013481592182*std::sin(0.404079854488373*x_94 - 4.21031999588013) + 0.133077215908965*std::sin(0.367999851703644*x_95 + 1.98935985565186) + 5.05471347001674*std::sin(0.382479846477509*x_95 - 7.39607954025269) + 0.0326103102809636*std::sin(0.376959830522537*x_96 - 4.22176027297974) - 0.859308057723425*std::sin(0.386959820985794*x_96 - 4.2021598815918) - 0.120074129078986*std::sin(0.396319836378098*x_96 + 5.20240020751953) + 3.45638843960377*std::sin(0.398799866437912*x_96 - 7.3931999206543) - 12.1952002076623*std::sin(0.411679863929749*x_96 + 1.98543977737427) - 0.551934129575037*std::sin(0.326879858970642*x_97 + 5.13624000549316) - 2.06389806462786*std::sin(0.339759826660156*x_97 + 5.16359996795654) + 0.0605573718680332*std::sin(0.362479835748672*x_97 - 4.41720008850098) + 3.81298809425203*std::sin(0.403599858283997*x_97 + 5.19040012359619) - 0.0808971912456748*std::sin(0.518239855766296*x_97 + 2.16407990455627) + 0.0320151284338858*std::sin(0.395679831504822*x_98 - 4.19135999679565) - 0.297215391082986*std::sin(0.406559854745865*x_98 - 7.38751983642578) - 0.140514923669266*std::sin(0.414239853620529*x_98 - 7.39607954025269) - 0.0985258388151358*std::sin(0.430639863014221*x_98 - 7.37799978256226) + 1.42778209779328*std::sin(0.433199852705002*x_98 - 7.38143968582153) - 29.7878540089872*std::sin(0.382719844579697*x_99 - 7.42312002182007) + 0.356743578114446*std::sin(0.398159861564636*x_99 - 7.40983963012695) - 0.0826793641270834*std::sin(0.402159839868546*x_99 - 4.20552015304565) - 0.36780625307869*std::sin(0.403039842844009*x_99 + 5.20864009857178) + 1.92630753816488*std::sin(0.415279865264893*x_99 - 4.19144010543823) + 1042.71643346541);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.082046753436217*x_1 - 0.755179763354355*x_10 - 0.513769188253435*x_100 + 3.82970993416649*x_101 - 0.117910203061842*x_102 + 0.844027417701694*x_103 - 0.00513589019813268*x_104 + 0.378457573799656*x_105 - 0.0440087841324191*x_106 - 0.372837838646092*x_107 + 0.933835145973048*x_108 - 0.341254780699726*x_109 - 0.680473677060086*x_11 + 0.620705830814481*x_110 - 0.0143406264860776*x_111 - 0.00171196362434127*x_112 - 0.0725938152868518*x_113 - 0.0212972951248702*x_114 + 0.65573308285017*x_115 - 0.0323195318200163*x_116 - 0.0224980832841521*x_117 - 0.832106547186374*x_118 + 0.00124981024302125*x_119 - 1.36639380916599*x_12 - 0.033179191411682*x_120 + 0.67103554785688*x_13 - 2.44075004492949*x_14 - 1.82844419654542*x_15 + 0.309451247073936*x_16 - 0.47121757582933*x_17 + 0.599882512555131*x_18 + 0.955181854585152*x_19 - 0.454202551330448*x_2 - 3.60046515942328*x_20 - 0.519859424499135*x_21 - 1.1621655706126*x_22 - 1.93722981734313*x_23 + 0.00676036623601781*x_24 - 0.111104403081041*x_25 - 0.353005787784223*x_26 - 0.118753624160546*x_27 - 0.0145467734034993*x_28 + 0.028756369974042*x_29 - 1.04712145198492*x_3 - 0.100405814211192*x_30 + 3.21397410159521*x_31 - 4.15242327627542*x_32 + 1.99061679787315*x_33 + 1.25150375602729*x_34 - 0.818080140782229*x_35 + 0.0016050492651695*x_36 - 0.0601671255035038*x_37 + 0.547487750103991*x_38 - 0.458383059712318*x_39 - 0.078738664396563*x_4 - 0.450372182015484*x_40 + 0.00716451227524226*x_41 + 0.0599657724709473*x_42 + 0.220034820748044*x_43 - 2.4661914645987*x_44 + 0.384976843216081*x_45 - 1.65147847507507*x_46 - 0.105110151103102*x_47 - 0.388256680996384*x_48 + 0.204642871512768*x_49 + 0.577814962501547*x_5 + 0.00769055171160765*x_50 + 0.436765649443712*x_51 + 0.508771878160546*x_52 - 0.410214790690136*x_53 - 0.385865319169827*x_54 + 0.797860586430726*x_55 - 0.407742385280152*x_56 + 0.0514887815752216*x_57 - 0.0056903637463812*x_58 - 0.00875241307554662*x_59 + 0.390582083535145*x_6 - 0.634622523628698*x_60 + 1.75765519869911*x_61 - 29.0565972526282*x_62 + 0.124719551366801*x_63 + 0.301095751163219*x_64 + 1.30002194775385*x_65 - 0.0380026704389302*x_66 - 0.524201269912028*x_67 - 0.142491117246527*x_68 - 0.180277573168788*x_69 - 0.334187720262826*x_7 - 0.0675672706661087*x_70 - 1.23665142097948*x_71 - 0.581363605684759*x_72 + 0.00354525302754156*x_73 - 3.10180233035946*x_74 + 0.0089833349456758*x_75 - 0.328997161859593*x_76 + 2.52354391789915*x_77 - 0.944184142700646*x_78 - 0.000599836140968402*x_79 + 1.7794385703617*x_8 - 0.300166048057946*x_80 - 0.0624318397323153*x_81 - 0.175255387543938*x_82 + 0.00267105327708054*x_83 - 0.0076049940824358*x_84 - 0.3898940631053*x_85 + 0.124994978181214*x_86 - 0.00933545571952216*x_87 - 0.0037560397860887*x_88 - 0.503381580703585*x_89 - 3.15178286974973*x_9 + 0.645993618210631*x_90 - 0.99426650005734*x_91 + 0.00519318830296532*x_92 + 3.21706669669628*x_93 - 0.25571227362109*x_94 - 0.410884409602938*x_95 - 0.0141776502427931*x_96 - 1.95437800577804*x_97 + 0.334915902658587*x_98 + 0.0186228943343186*x_99 - 0.0117343438961982*std::pow(-7.36319971084595*x_106 - 7.55671977996826, 2) + 5.98023792014025e-5*std::pow(-5.29512023925781*x_108 - 7.73583984375, 2) - 0.307380225012572*std::pow(-0.582399845123291*x_108 - 0.778079867362976, 2) - 2.58253989900205e-5*std::pow(-7.56576013565063*x_109 - 9.54831981658936, 2) - 0.00156974006366957*std::pow(-6.31343984603882*x_11 - 9.7729606628418, 2) + 0.00588733547708552*std::pow(-8.15095996856689*x_116 - 8.55615997314453, 2) - 0.000407832374227393*std::pow(-7.33599996566772*x_118 - 8.55144023895264, 2) - 0.00285020872214945*std::pow(-6.34631967544556*x_120 - 8.5252799987793, 2) - 8.93040618674054e-5*std::pow(-4.97463989257813*x_120 - 5.7960000038147, 2) - 6.30623920155016e-5*std::pow(-5.00879955291748*x_13 - 7.81375980377197, 2) + 4.43833367751309e-6*std::pow(-5.29879999160767*x_15 - 5.5019998550415, 2) + 5.84205105062817e-5*std::pow(-5.08487987518311*x_15 - 7.32096004486084, 2) - 0.0012250122792445*std::pow(-8.73536014556885*x_18 - 9.75536060333252, 2) + 4.85589422580547e-5*std::pow(-6.31343984603882*x_19 - 9.57096099853516, 2) - 0.00266678834538514*std::pow(-7.01279973983765*x_23 - 9.21599960327148, 2) + 3.66280549830375e-5*std::pow(-6.67776012420654*x_24 - 9.96127986907959, 2) - 0.00824780546337876*std::pow(-4.61759996414185*x_24 - 6.62983989715576, 2) - 1.06392919638861e-5*std::pow(-7.44783973693848*x_27 - 8.82520008087158, 2) + 0.0162987881035631*std::pow(-5.21519994735718*x_39 - 6.82528018951416, 2) + 1.81179226163874e-5*std::pow(-6.29800033569336*x_4 - 9.95495986938477, 2) + 8.6685162836502e-5*std::pow(-4.83800029754639*x_44 - 6.05071973800659, 2) - 0.000833414198122813*std::pow(-5.75367975234985*x_47 - 7.59768009185791, 2) + 1.67288036074083e-5*std::pow(-6.32687997817993*x_5 - 9.3877592086792, 2) - 3.51457375999828e-5*std::pow(-7.51128005981445*x_50 - 8.1159200668335, 2) - 0.000966301509091397*std::pow(-7.70344018936157*x_59 - 9.92232036590576, 2) - 0.00021820815478334*std::pow(-6.26208019256592*x_59 - 9.90112018585205, 2) - 6.08933542051805e-5*std::pow(-4.89711999893188*x_6 - 7.75040006637573, 2) - 8.33167508707389e-5*std::pow(-8.05943965911865*x_64 - 9.632080078125, 2) - 1.28071018634372e-5*std::pow(-3.31583976745605*x_66 - 4.76936006546021, 2) - 0.00297543813907801*std::pow(-5.33400011062622*x_67 - 5.12992000579834, 2) + 2.53175071188166e-5*std::pow(-4.89463996887207*x_7 - 6.54287958145142, 2) + 6.31652833827368e-5*std::pow(-6.32664012908936*x_70 - 8.89144039154053, 2) - 0.013439620884109*std::pow(-5.72743988037109*x_70 - 7.97160005569458, 2) - 5.11389956709845e-5*std::pow(-6.03951978683472*x_72 - 8.25783920288086, 2) - 0.000111261087096026*std::pow(-5.92343997955322*x_72 - 7.55639982223511, 2) + 0.00081635357146272*std::pow(-5.51567983627319*x_72 - 6.31112003326416, 2) - 0.00201503005304304*std::pow(-5.3295202255249*x_72 - 7.79544019699097, 2) + 0.00115111288789232*std::pow(-5.7279200553894*x_73 - 7.8930401802063, 2) - 3.70234647600948e-5*std::pow(-7.48496007919312*x_74 - 9.9323205947876, 2) - 0.00529990094522207*std::pow(-5.3471999168396*x_74 - 6.92751979827881, 2) - 0.000143139041294044*std::pow(-6.85536003112793*x_77 - 8.66800022125244, 2) - 0.00434994397039513*std::pow(-4.26240015029907*x_78 - 5.81343936920166, 2) + 0.0102045630105672*std::pow(-7.15487957000732*x_81 - 9.58255958557129, 2) - 7.59831679735526e-5*std::pow(-8.56280040740967*x_84 - 8.97383975982666, 2) - 0.000158438102995521*std::pow(-8.34360027313232*x_84 - 8.74335956573486, 2) - 5.0856305055533e-6*std::pow(-7.32399988174438*x_84 - 6.70928001403809, 2) + 5.81195203125413e-5*std::pow(-5.07727956771851*x_86 - 7.30615997314453, 2) + 0.00287083859724639*std::pow(-4.13991975784302*x_87 - 5.91967964172363, 2) + 0.00850381517723296*std::pow(-8.75607967376709*x_88 - 9.97624015808105, 2) + 3.4180504634106e-6*std::pow(-8.0033597946167*x_88 - 9.20728015899658, 2) + 0.000568802181627154*std::pow(-2.1943998336792*x_88 - 2.17791986465454, 2) - 0.000585675291113928*std::pow(-3.1781599521637*x_90 - 4.56775999069214, 2) - 3.44669782078637e-5*std::pow(-5.24519968032837*x_99 - 6.02455997467041, 2) - 0.0167607328547742*std::exp(0.702079832553864*x_1) + 0.000424456950993311*std::exp(1.08351981639862*x_1) - 0.00019426168412758*std::exp(1.19423997402191*x_1) + 0.00850610986200929*std::exp(1.22735989093781*x_1) - 6.99236153031521e-6*std::exp(1.28807985782623*x_1) + 0.00163392947411246*std::exp(1.19983983039856*x_100) - 9.67214540507094e-5*std::exp(1.62295985221863*x_100) + 0.00498778730967128*std::exp(0.515199840068817*x_103) - 0.0621804770802201*std::exp(0.528799831867218*x_104) - 0.0216968732078997*std::exp(1.06327986717224*x_104) - 0.110577441369858*std::exp(0.650879800319672*x_106) - 0.0126297972774033*std::exp(0.665519833564758*x_106) - 0.0021305734291178*std::exp(0.792479872703552*x_106) + 0.368418505037501*std::exp(1.33487987518311*x_106) - 0.301996324819865*std::exp(0.648639798164368*x_109) - 0.268163727255847*std::exp(0.855439901351929*x_110) - 0.00019489566780059*std::exp(1.08487975597382*x_110) + 6.35508998770293e-5*std::exp(1.55039989948273*x_110) - 9.12613483160804e-5*std::exp(1.59975981712341*x_110) - 0.21206933333173*std::exp(0.604959845542908*x_112) + 0.000551966627977482*std::exp(0.914159834384918*x_112) - 0.00264146195575114*std::exp(0.571999847888947*x_24) + 0.0129329648095315*std::exp(0.514479875564575*x_26) - 0.986190523578404*std::exp(0.62559986114502*x_26) - 0.00205672967901171*std::exp(0.643839836120605*x_26) + 0.000292423619978123*std::exp(0.829519867897034*x_26) + 0.00461022357208936*std::exp(0.874719858169556*x_26) - 0.00192244836815118*std::exp(0.913679838180542*x_26) + 3.16041413031359*std::exp(0.491599857807159*x_31) + 0.0144672035817003*std::exp(0.599999845027924*x_31) + 0.0083465022367153*std::exp(0.620239853858948*x_31) + 0.00390387075275115*std::exp(0.647599816322327*x_31) + 0.000873993808893047*std::exp(0.654319822788239*x_31) + 0.0376980796155756*std::exp(0.655279815196991*x_31) - 0.0759954388707207*std::exp(0.654959857463837*x_45) - 0.00266175443397842*std::exp(0.825759887695313*x_45) - 0.00183928910729487*std::exp(1.0123997926712*x_45) - 0.0578600053551957*std::exp(1.11879980564117*x_45) + 6.0318966755881e-5*std::exp(1.23079991340637*x_45) + 0.0789953480311255*std::exp(0.99375981092453*x_6) - 0.0084566498475704*std::exp(0.713119864463806*x_60) - 0.411592761918113*std::exp(0.968719840049744*x_60) - 0.00348597795883793*std::exp(1.24247992038727*x_60) + 2.38658300718676e-5*std::exp(1.45055985450745*x_66) + 0.0221272414385875*std::exp(1.66143977642059*x_66) - 0.00014472336761916*std::exp(0.718239843845367*x_70) + 0.00244128715064684*std::exp(0.895999848842621*x_70) - 0.00348426946903828*std::exp(0.875359892845154*x_72) + 0.00161554693433*std::exp(0.97439980506897*x_74) - 0.00287515284376241*std::exp(1.0343998670578*x_74) - 0.00079941467781569*std::exp(1.24767982959747*x_74) + 1.51434280148667e-5*std::exp(1.71327984333038*x_74) - 0.743431669264492*std::exp(0.599999845027924*x_76) + 0.00247791088207786*std::exp(0.73831981420517*x_77) + 0.0013308138429747*std::exp(0.885519862174988*x_81) - 0.00826181930124334*std::exp(1.09175980091095*x_81) - 0.00179093169595002*std::exp(0.719999849796295*x_87) + 0.0384257332159636*std::sin(0.222879990935326*x_1 - 1.19911992549896) + 1.16200444262967*std::sin(0.184960007667542*x_10 + 1.76799988746643) - 4.02822848159303*std::sin(0.330879837274551*x_10 - 7.47408008575439) + 0.637115020825019*std::sin(0.372159838676453*x_100 - 7.40847969055176) - 0.240318472038646*std::sin(0.155280038714409*x_102 - 7.65199995040894) + 1.72375874539572*std::sin(0.298239946365356*x_102 - 7.52088022232056) - 0.0157166936033541*std::sin(0.342959851026535*x_102 - 7.44087982177734) + 0.175783183158879*std::sin(0.371279835700989*x_102 + 1.97439980506897) - 0.0207099396507127*std::sin(0.430479854345322*x_102 - 4.16527986526489) - 0.754857643573423*std::sin(0.445199847221375*x_102 + 5.23176002502441) - 0.0596500675969133*std::sin(0.314079850912094*x_103 - 7.47591972351074) + 8.97484241923612*std::sin(0.465919852256775*x_103 - 7.36799955368042) + 13.4516973561499*std::sin(0.487919867038727*x_104 - 4.14376020431519) - 1.33454826201048*std::sin(0.60919988155365*x_104 - 7.1910400390625) + 0.00607729076916691*std::sin(0.640159845352173*x_104 - 7.17999982833862) + 0.0631355831005138*std::sin(0.263999968767166*x_105 + 1.85087990760803) + 0.790000746209395*std::sin(0.319519847631454*x_105 + 1.92879974842072) - 0.0208769949029183*std::sin(0.355839848518372*x_105 - 7.42432022094727) - 0.0235502874705491*std::sin(0.357599824666977*x_105 - 7.44007968902588) - 0.141840548778941*std::sin(0.187360003590584*x_106 - 7.61688041687012) - 0.0158181529669739*std::sin(0.432319849729538*x_106 + 5.221360206604) - 21.3135671747038*std::sin(0.299039930105209*x_107 + 5.11175966262817) + 2.50532654906576*std::sin(0.363919854164124*x_107 - 7.4172797203064) + 0.0225186417588863*std::sin(0.44327986240387*x_107 + 5.22464036941528) - 0.27093275235822*std::sin(0.347679853439331*x_108 + 5.14847993850708) + 0.292374007304388*std::sin(0.663199841976166*x_108 + 2.2377598285675) - 0.211235472695753*std::sin(0.345519840717316*x_109 + 5.15944004058838) - 0.557499475219219*std::sin(0.375519841909409*x_110 + 5.1691198348999) + 0.0034286072500163*std::sin(0.590079843997955*x_110 - 7.21264028549194) - 1.44480194956376*std::sin(0.3572798371315*x_111 - 7.43255996704102) - 0.00914022735220099*std::sin(0.401119828224182*x_111 - 4.20544004440308) - 0.66468977863261*std::sin(0.439599871635437*x_111 - 1.17359983921051) + 0.00162201174027973*std::sin(0.456559866666794*x_111 + 8.23095989227295) - 3.63069772381233*std::sin(0.473359853029251*x_111 + 2.04543972015381) - 0.00462915271503248*std::sin(0.496959865093231*x_111 - 4.12064027786255) - 30.5904000282703*std::sin(0.198719993233681*x_112 + 4.99071979522705) + 0.0397277681498754*std::sin(0.353759855031967*x_112 - 7.41695976257324) - 0.0354448266057664*std::sin(0.411039859056473*x_112 - 0.981599867343903) - 1.03179743644272*std::sin(0.48583984375*x_112 + 5.23848009109497) - 0.18884285631785*std::sin(0.507519841194153*x_112 - 1.01695990562439) - 33.7594311600711*std::sin(0.304399937391281*x_113 - 7.4966402053833) - 5.97851066600914*std::sin(0.345999836921692*x_113 - 7.43743991851807) - 0.0501414944211429*std::sin(0.268559962511063*x_114 - 7.53224039077759) + 1.77555763067076*std::sin(0.269199967384338*x_114 - 7.52320003509521) + 8.39264350565359*std::sin(0.367759823799133*x_114 - 7.42456007003784) + 0.0521459593540987*std::sin(0.429439842700958*x_114 + 5.22695970535278) - 0.00243163805989433*std::sin(0.468559861183167*x_114 - 4.1592001914978) + 0.00472754522957843*std::sin(0.576479852199554*x_114 - 7.21895980834961) + 0.497295888696501*std::sin(0.665199875831604*x_114 + 5.43255996704102) - 0.0290944759121844*std::sin(0.302079945802689*x_115 + 5.103919506073) + 4.31306405185225*std::sin(0.325759828090668*x_115 - 7.45439958572388) - 2.11904995935302*std::sin(0.416079849004745*x_115 + 5.22344017028809) + 0.00859787620769537*std::sin(0.48447984457016*x_115 - 4.12936019897461) + 0.00859757431182946*std::sin(0.534799814224243*x_115 + 5.36311960220337) - 0.649755861142727*std::sin(0.435039848089218*x_116 + 8.42255973815918) - 0.698394567735751*std::sin(0.49839985370636*x_116 - 4.12344026565552) - 0.209483788960537*std::sin(0.243599966168404*x_117 - 1.35351991653442) - 6.49663497519175*std::sin(0.376959830522537*x_117 + 1.97719979286194) - 0.0352500110846844*std::sin(0.378399848937988*x_117 + 5.1756796836853) + 1.63509714103662*std::sin(0.400079846382141*x_117 - 4.1864800453186) + 0.236845764386532*std::sin(0.616959869861603*x_117 - 3.99599981307983) + 0.0928156489505517*std::sin(0.191840007901192*x_118 + 1.78999984264374) - 3.42904061512476*std::sin(0.408879846334457*x_118 + 5.20247983932495) + 0.0372907896910419*std::sin(0.419359862804413*x_118 + 5.21727991104126) - 0.0494634776981442*std::sin(0.289599925279617*x_119 - 4.28279972076416) + 1.75419734401991*std::sin(0.340479850769043*x_119 + 5.15120029449463) + 3.48703545928175*std::sin(0.34895983338356*x_119 + 5.15208005905151) - 0.0170225049433895*std::sin(0.366079837083817*x_119 - 7.41511964797974) + 5.06085545129257*std::sin(0.434239864349365*x_119 + 1.99407982826233) - 1.17254799710405*std::sin(0.35471984744072*x_12 - 1.03167986869812) - 0.00352322964480526*std::sin(0.328399837017059*x_120 + 1.94799983501434) + 0.0292059750177701*std::sin(0.36695984005928*x_120 + 5.15912008285522) - 0.261768283724055*std::sin(0.427679866552353*x_120 + 5.2294397354126) + 10.876344118692*std::sin(0.211919993162155*x_14 - 4.38903999328613) - 0.0779081357676641*std::sin(0.272799968719482*x_16 + 5.08839988708496) + 0.0298045426693428*std::sin(0.368559837341309*x_16 + 5.15863990783691) - 0.818874635681071*std::sin(0.369679838418961*x_16 + 5.18168020248413) - 0.00513211996293794*std::sin(0.427279859781265*x_18 - 0.954639852046967) + 0.0239609716364861*std::sin(0.348479837179184*x_20 - 4.25511980056763) - 5.11163631411986*std::sin(0.361199855804443*x_20 + 5.16968011856079) + 2.18088039034578*std::sin(0.357999831438065*x_21 + 8.36407947540283) - 7.58503228423258*std::sin(0.209600001573563*x_22 - 7.57504034042358) + 0.099542342125542*std::sin(0.502079844474792*x_22 + 2.10895967483521) - 0.00679537038901783*std::sin(0.589439868927002*x_22 - 7.22200012207031) - 0.847273786003565*std::sin(0.162880018353462*x_24 + 4.93567991256714) + 0.0119348311771059*std::sin(0.182560011744499*x_24 + 4.98351955413818) + 0.184115232201283*std::sin(0.190160006284714*x_24 - 7.60288000106812) + 1.38105470659498*std::sin(0.338639855384827*x_24 - 4.25832033157349) + 0.00523975560869999*std::sin(0.46111986041069*x_25 - 4.13752031326294) + 0.048061791649355*std::sin(0.186080008745193*x_26 - 7.6005597114563) - 0.124462831852188*std::sin(0.137440040707588*x_27 + 4.9017596244812) - 14.3929331812439*std::sin(0.171120017766953*x_27 - 7.6241602897644) - 0.0667355062392704*std::sin(0.301679939031601*x_27 + 5.12080001831055) - 17.9816537198073*std::sin(0.303999930620193*x_27 + 5.13247966766357) - 0.0597863385808629*std::sin(0.319839835166931*x_28 - 4.28064012527466) + 3.98629125940879*std::sin(0.320079833269119*x_28 - 4.28864002227783) + 2.49792628569356*std::sin(0.322399854660034*x_28 - 4.28247976303101) - 0.070723358283789*std::sin(0.326319843530655*x_28 + 5.13312005996704) + 9.98302262762593*std::sin(0.331519842147827*x_28 - 4.27248001098633) - 0.0197994653121466*std::sin(0.33247983455658*x_28 - 4.26847982406616) - 0.1470245522094*std::sin(0.285919934511185*x_3 + 5.08111953735352) - 1.46958566439984*std::sin(0.294319927692413*x_3 + 5.10839986801147) - 0.904763847168971*std::sin(0.307759910821915*x_3 - 7.5032000541687) - 13.2024797126772*std::sin(0.261199980974197*x_30 - 7.53352022171021) + 3.36067148415687*std::sin(0.27295994758606*x_30 - 4.32471990585327) + 0.0308794028725864*std::sin(0.279999971389771*x_30 - 4.29591989517212) - 4.01101404349315*std::sin(0.360319852828979*x_31 + 5.10487985610962) + 9.39604007605944*std::sin(0.255839973688126*x_32 - 4.40239953994751) - 0.0563971246114858*std::sin(0.348479837179184*x_32 + 8.2469596862793) + 0.065719464917069*std::sin(0.322319835424423*x_33 + 8.19719982147217) + 0.0344792480510638*std::sin(0.351519852876663*x_34 + 2.00215983390808) - 0.0614026595309411*std::sin(0.313519835472107*x_35 + 1.97631978988647) + 0.0141358887339539*std::sin(0.315679848194122*x_35 + 1.98063981533051) - 3.95333254379636*std::sin(0.317599833011627*x_35 - 7.43431997299194) - 1.97988152049953*std::sin(0.318319827318192*x_35 - 7.43311977386475) + 0.0312640581072002*std::sin(0.319839835166931*x_35 - 7.42831993103027) - 0.0546886276333791*std::sin(0.319919854402542*x_35 - 7.42831993103027) + 0.0298811884025059*std::sin(0.321919858455658*x_35 - 7.42599964141846) + 0.018889853172765*std::sin(0.331519842147827*x_36 - 4.25288009643555) - 2.03750846728537*std::sin(0.352959841489792*x_36 + 5.1637601852417) + 0.75441240188214*std::sin(0.373759835958481*x_36 - 7.41639995574951) + 0.0105402055389539*std::sin(0.380639851093292*x_36 - 7.39903974533081) + 4.51227370884197*std::sin(0.393519848585129*x_36 - 4.2052001953125) - 0.194884688897681*std::sin(0.418559849262238*x_36 + 5.22079992294312) - 1.6427318520891*std::sin(0.293359935283661*x_37 + 5.09615993499756) - 0.0492803670371377*std::sin(0.298719942569733*x_37 - 7.50471973419189) + 13.4539113242242*std::sin(0.36303985118866*x_37 - 4.24047994613647) - 0.0375851427503372*std::sin(0.364959836006165*x_37 - 7.42208003997803) + 2.59736434285958*std::sin(0.401439845561981*x_37 - 4.20695972442627) + 0.0230078538146266*std::sin(0.48039984703064*x_38 + 5.25888013839722) - 0.00414737456419534*std::sin(0.665279865264893*x_38 + 2.20815992355347) - 3.84313075683952*std::sin(0.19743999838829*x_39 + 4.99631977081299) - 0.0766305196623382*std::sin(0.350079834461212*x_39 + 5.16296005249023) - 0.12911234501311*std::sin(0.334239840507507*x_40 - 4.27408027648926) - 0.0162596909663546*std::sin(0.390239834785461*x_40 + 8.37495994567871) + 0.0376883907735721*std::sin(0.312159925699234*x_41 + 1.89567983150482) - 3.18796153579985*std::sin(0.375519841909409*x_41 + 5.17112016677856) + 14.5284374572912*std::sin(0.406959861516953*x_41 - 7.39175987243652) - 0.00785136060826278*std::sin(0.431519865989685*x_41 - 7.38671970367432) + 14.8659101076129*std::sin(0.121520057320595*x_42 + 1.70983994007111) + 18.6578039724942*std::sin(0.369279831647873*x_43 - 7.41183996200562) + 0.0252876794140047*std::sin(0.380639851093292*x_43 - 4.22176027297974) - 0.372682683840377*std::sin(0.383359849452972*x_43 - 7.40655994415283) - 1.04358813299979*std::sin(0.440879851579666*x_43 - 7.37831974029541) + 1.45795379880373*std::sin(0.359359860420227*x_44 + 5.16416025161743) + 0.0177331277452868*std::sin(0.407279849052429*x_46 + 5.21623992919922) + 0.38910586290186*std::sin(0.585599839687347*x_46 - 7.21920013427734) + 0.00382972480358986*std::sin(0.645839810371399*x_46 + 5.4171199798584) + 7.2496358407319*std::sin(0.208159998059273*x_47 - 7.59176015853882) + 16.3096125112059*std::sin(0.260319977998734*x_47 + 1.85655987262726) - 0.0175601307197935*std::sin(0.439279854297638*x_47 - 4.15232038497925) - 3.43009381895539*std::sin(0.424719870090485*x_48 - 4.17040014266968) - 0.0341943223015239*std::sin(0.259919971227646*x_49 + 1.85903990268707) - 0.204366789745732*std::sin(0.437279850244522*x_49 - 7.35431957244873) - 8.02611674984703*std::sin(0.191200003027916*x_50 + 4.98799991607666) - 22.3236193497076*std::sin(0.321759849786758*x_50 - 7.47687959671021) + 2.11155458566005*std::sin(0.36559984087944*x_51 - 4.23184013366699) - 10.9734218184942*std::sin(0.212960004806519*x_53 + 5.00816011428833) + 1.95563918660794*std::sin(0.347519844770432*x_53 + 5.15128040313721) - 0.0303421684457468*std::sin(0.359999865293503*x_53 - 4.24272012710571) + 0.00380732227419701*std::sin(0.889279901981354*x_53 - 3.95743989944458) + 0.0260406455142945*std::sin(0.319359838962555*x_54 + 1.90071976184845) + 1.71598961133279*std::sin(0.417919874191284*x_54 - 7.38679981231689) + 1.10597188975457*std::sin(0.487039864063263*x_54 - 1.10911989212036) - 0.0198801525836819*std::sin(0.658959865570068*x_54 - 3.96943998336792) + 2.84989376378423*std::sin(0.348079830408096*x_55 + 5.15960025787354) + 1.80765063373044*std::sin(0.403119832277298*x_55 + 8.38576030731201) - 0.00866605730670602*std::sin(0.441839843988419*x_55 - 4.14991998672485) + 0.0258608200807621*std::sin(0.465039849281311*x_55 + 5.25047969818115) + 1.67622947039928*std::sin(0.322559833526611*x_56 + 1.92327988147736) + 0.523623402892395*std::sin(0.406159847974777*x_56 + 5.19504022598267) - 1.75821397524041*std::sin(0.428879857063293*x_57 - 4.16879987716675) - 0.0222941033492891*std::sin(0.448399841785431*x_57 - 4.15232038497925) + 6.72842037181471*std::sin(0.553839862346649*x_57 + 5.35767984390259) - 0.0628703679359858*std::sin(0.853919863700867*x_57 + 5.62479972839355) - 0.90910566766182*std::sin(0.170960009098053*x_58 + 4.96247959136963) - 10.2336129942015*std::sin(0.209440007805824*x_58 + 5.00848007202148) - 0.0566077984449497*std::sin(0.266239941120148*x_58 - 7.51327991485596) - 5.40101284873749*std::sin(0.2743199467659*x_58 + 5.07583951950073) - 0.0260931970335439*std::sin(0.348079830408096*x_58 + 5.15759992599487) + 1.89176779892137*std::sin(0.42223984003067*x_58 - 4.189040184021) + 0.012353007703425*std::sin(0.462799847126007*x_58 + 5.25392007827759) + 0.0603330437501385*std::sin(0.168560013175011*x_59 - 7.63191986083984) - 18.8232477685964*std::sin(0.251999974250793*x_59 - 7.52784013748169) - 0.0215142652979867*std::sin(0.203199997544289*x_64 + 1.78175985813141) + 0.0243250877465779*std::sin(0.222240000963211*x_64 - 4.36191987991333) - 5.93368357282586*std::sin(0.228959992527962*x_64 - 4.36199951171875) + 0.00220874592325559*std::sin(0.339199841022491*x_64 - 7.4555196762085) - 2.18622831662208*std::sin(0.43495985865593*x_66 + 8.44768047332764) - 5.0378176707435*std::sin(0.243759974837303*x_67 - 7.55679988861084) + 6.17904034513364*std::sin(0.247279971837997*x_70 - 7.52800035476685) + 0.24443189616624*std::sin(0.439999878406525*x_70 - 4.15304040908813) + 0.00282447016272091*std::sin(0.624399840831757*x_70 - 3.97263979911804) - 0.0788759696016108*std::sin(0.23063999414444*x_71 + 5.04759979248047) - 0.223072956426339*std::sin(0.214000001549721*x_72 + 5.00920009613037) - 29.3471060021485*std::sin(0.24959996342659*x_73 + 5.06479978561401) - 2.13898821841742*std::sin(0.342559844255447*x_73 - 4.26151990890503) - 0.00655075404641375*std::sin(0.451039850711823*x_73 - 4.15104007720947) + 0.107359822731177*std::sin(0.123040057718754*x_75 + 4.89031982421875) + 0.0171117249650548*std::sin(0.278559952974319*x_75 + 5.09087991714478) - 0.67475318808186*std::sin(0.409119844436646*x_75 - 7.38631963729858) - 4.70004430372811*std::sin(0.476879835128784*x_75 + 2.08039975166321) - 0.537681829249608*std::sin(0.540319859981537*x_75 + 5.16431999206543) - 25.7780778244245*std::sin(0.238319978117943*x_76 - 7.53840017318726) + 2.55900136254992*std::sin(0.393599838018417*x_78 + 8.3810396194458) - 0.0259020192961996*std::sin(0.486639857292175*x_78 + 5.28744029998779) - 2.86758593382659*std::sin(0.281759947538376*x_79 - 7.4986400604248) - 4.53927894355164*std::sin(0.332239836454391*x_79 + 5.12871980667114) + 14.7236125803465*std::sin(0.355119854211807*x_79 + 1.96583986282349) - 0.077087962651917*std::sin(0.249199971556664*x_8 - 4.33576011657715) + 1.36254362990232*std::sin(0.501679837703705*x_8 - 7.30711984634399) - 0.221480182426608*std::sin(0.389359831809998*x_81 + 8.37271976470947) + 6.08939465218338*std::sin(0.214159995317459*x_82 - 7.57696008682251) + 0.193836771459846*std::sin(0.197359994053841*x_83 + 5.00008010864258) - 0.932164969879117*std::sin(0.201599985361099*x_83 + 5.0053596496582) + 0.00751374150356348*std::sin(0.263119965791702*x_83 + 1.87455987930298) - 0.00834621370866808*std::sin(0.319679915904999*x_83 - 7.46343994140625) - 16.1163038512928*std::sin(0.320559918880463*x_83 - 7.46808004379272) - 1.18159012744064*std::sin(0.322239845991135*x_83 - 7.4730396270752) - 2.78090798971718*std::sin(0.393679857254028*x_83 - 1.19831991195679) + 0.0487668766586855*std::sin(0.140080034732819*x_84 - 7.67984008789063) + 0.166178651493333*std::sin(0.179360002279282*x_84 + 1.77599990367889) - 6.51472153927383*std::sin(0.23871998488903*x_84 - 7.55600023269653) + 0.0446175053969867*std::sin(0.278079956769943*x_84 + 5.09272003173828) + 5.52166679958111*std::sin(0.278479933738708*x_84 - 7.49608039855957) - 0.0394145451364831*std::sin(0.187040001153946*x_85 + 4.98767995834351) - 0.394721166484307*std::sin(0.19064000248909*x_85 - 7.61648035049438) - 0.0581080852543822*std::sin(0.221919998526573*x_85 - 7.56135988235474) - 6.93660648835812*std::sin(0.230239987373352*x_85 - 7.55408048629761) - 0.00631452302054796*std::sin(0.524639844894409*x_86 - 7.27040004730225) - 4.94934646480304*std::sin(0.402799844741821*x_87 + 5.20991992950439) + 1.82874743541792*std::sin(0.417919844388962*x_87 - 4.18951988220215) + 0.00975147545229175*std::sin(0.499039828777313*x_87 - 4.11488008499146) - 0.0181208950884363*std::sin(0.87447988986969*x_87 - 0.751359879970551) + 0.601445393107047*std::sin(0.219119995832443*x_89 + 1.8155198097229) + 0.639483605315458*std::sin(0.41023987531662*x_90 - 7.39207983016968) - 0.0107801427644679*std::sin(0.414639860391617*x_90 - 0.994639813899994) - 0.0207560253309599*std::sin(0.505279839038849*x_90 - 4.09320020675659) + 0.0530856444122169*std::sin(0.337039858102798*x_92 + 5.18400001525879) - 1.29907282149159*std::sin(0.341039836406708*x_92 + 5.20991992950439) + 0.022338583371029*std::sin(0.360079854726791*x_92 + 1.97791981697083) + 6.50788194909939*std::sin(0.360879838466644*x_92 + 2.00343990325928) + 0.020797206415723*std::sin(0.363839834928513*x_92 - 7.38535976409912) + 24.9660845916865*std::sin(0.365199834108353*x_92 + 1.99775981903076) + 0.0120366343758706*std::sin(0.381279855966568*x_92 + 1.97519981861115) + 0.0905560771110292*std::sin(0.401679873466492*x_92 - 7.59008026123047) - 0.0182101728382686*std::sin(0.374559849500656*x_94 - 1.18543982505798) + 0.040874899532282*std::sin(0.376239836215973*x_94 + 1.98399984836578) - 2.53102910447367*std::sin(0.386319845914841*x_94 - 7.40639972686768) - 7.59957120888058*std::sin(0.404079854488373*x_94 - 4.21031999588013) - 0.0159965019979461*std::sin(0.367999851703644*x_95 + 1.98935985565186) - 5.72489622780203*std::sin(0.382479846477509*x_95 - 7.39607954025269) + 0.00390806134161818*std::sin(0.376959830522537*x_96 - 4.22176027297974) + 0.9732400238632*std::sin(0.386959820985794*x_96 - 4.2021598815918) + 0.0144334703171696*std::sin(0.396319836378098*x_96 + 5.20240020751953) + 1.41917940664706*std::sin(0.398799866437912*x_96 - 7.3931999206543) + 4.92934291731869*std::sin(0.411679863929749*x_96 + 1.98543977737427) - 0.595824284448393*std::sin(0.326879858970642*x_97 + 5.13624000549316) - 0.847428372684395*std::sin(0.339759826660156*x_97 + 5.16359996795654) + 0.0352192578382741*std::sin(0.362479835748672*x_97 - 4.41720008850098) - 4.31853581551582*std::sin(0.403599858283997*x_97 + 5.19040012359619) + 0.0105063549385702*std::sin(0.518239855766296*x_97 + 2.16407990455627) + 0.0038367339869332*std::sin(0.395679831504822*x_98 - 4.19135999679565) - 0.3208501490122*std::sin(0.406559854745865*x_98 - 7.38751983642578) + 0.0168905491587251*std::sin(0.414239853620529*x_98 - 7.39607954025269) + 0.0127958389812145*std::sin(0.430639863014221*x_98 - 7.37799978256226) + 0.58624167560283*std::sin(0.433199852705002*x_98 - 7.38143968582153) + 12.0403556055658*std::sin(0.382719844579697*x_99 - 7.42312002182007) - 0.0463313323492712*std::sin(0.398159861564636*x_99 - 7.40983963012695) + 0.0518049270578376*std::sin(0.402159839868546*x_99 - 4.20552015304565) - 0.397054441487408*std::sin(0.403039842844009*x_99 + 5.20864009857178) + 0.790934247351549*std::sin(0.415279865264893*x_99 - 4.19144010543823) - 438.385795172996);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.133247306535869*x_1 + 0.185934675564266*x_10 + 0.162352942525862*x_100 - 1.148254792846*x_101 + 0.0324436006192324*x_102 + 0.362824059841473*x_103 - 0.00898395892798613*x_104 - 0.0916975719400875*x_105 + 0.00962014657704273*x_106 + 0.183724450565586*x_107 - 0.255907483093631*x_108 + 0.22781295794603*x_109 + 0.402954554492521*x_11 - 0.189611920040638*x_110 - 3.77645454648387e-5*x_111 + 0.0101221297894088*x_112 - 0.082195902453894*x_113 + 0.00951018594045225*x_114 - 0.20497263857804*x_115 + 0.0246963500117383*x_116 + 0.0243663551672354*x_117 + 0.102702663374136*x_118 - 0.00174719279649496*x_119 + 0.458955732312007*x_12 + 0.0300379677801692*x_120 - 0.158026075290556*x_13 + 0.750693277989234*x_14 + 0.74812481977978*x_15 - 0.158863058050108*x_16 + 0.171370480760544*x_17 - 0.0596319261147425*x_18 - 0.441027683910361*x_19 + 0.266275907350646*x_2 + 1.14570375451747*x_20 + 0.244748531127805*x_21 + 0.207286675985849*x_22 + 0.69539000966099*x_23 + 0.0113053902662052*x_24 + 0.0150372667182614*x_25 + 0.0972325612174227*x_26 - 0.06928080938569*x_27 + 0.0097320182449358*x_28 - 0.053395913032754*x_29 + 0.303526500022611*x_3 - 0.0226738614123891*x_30 - 2.0304352738988*x_31 + 0.0309918829571477*x_32 - 0.352690646027536*x_33 - 0.195572178262969*x_34 + 0.255769602423971*x_35 + 0.0232700858140871*x_36 + 0.0154062733305732*x_37 - 0.22697811586266*x_38 - 0.0993494449603246*x_39 - 0.119159879485056*x_4 + 0.177627002459468*x_40 + 0.00881538453322794*x_41 - 0.134429418348514*x_42 + 0.0876410972221337*x_43 + 0.882231548794254*x_44 - 0.0530077461345053*x_45 + 0.539260327900821*x_46 + 0.0146700898360549*x_47 - 0.0340127243572338*x_48 + 0.0788499867431828*x_49 - 0.246676708738742*x_5 + 0.0842981420934237*x_50 - 0.0994272350139441*x_51 - 0.216372078474779*x_52 + 0.123904800269623*x_53 - 0.143621884802712*x_54 - 0.258419598345832*x_55 + 0.0696090240677009*x_56 - 0.0290124975653055*x_57 + 0.00226667522872275*x_58 + 0.00645619316734303*x_59 - 0.141492673117654*x_6 + 0.193095211559763*x_60 - 0.868750532289984*x_61 + 9.42257853271855*x_62 + 0.139612943910209*x_63 - 0.147425403528673*x_64 - 0.232942502662044*x_65 + 0.0431719665544275*x_66 + 0.150484164784612*x_67 + 0.355259801037962*x_68 + 0.421091409485461*x_69 + 0.201576188816529*x_7 + 0.0330564008845*x_70 + 0.389132888039525*x_71 + 0.181984885313984*x_72 - 0.00480051326953511*x_73 + 0.999079809882078*x_74 - 0.0288909662420568*x_75 - 0.155797620162774*x_76 - 0.746141623573051*x_77 + 0.327319695884971*x_78 - 0.0101476386318559*x_79 - 0.630990250619253*x_8 + 0.145989132353565*x_80 - 0.00560354460546028*x_81 - 0.0397053934820209*x_82 + 0.0231296115701495*x_83 - 0.00999664300677675*x_84 - 0.0135650730934243*x_85 - 0.194967955083092*x_86 - 0.00211054046733446*x_87 - 0.0260972052710388*x_88 + 0.453101982240159*x_89 + 0.764478932388737*x_9 - 0.218963996660888*x_90 - 0.200714774453799*x_91 - 0.0289919304557185*x_92 - 0.671752528358759*x_93 - 0.0929710801461945*x_94 + 0.13432588503495*x_95 + 0.0290189056727986*x_96 + 0.48389000234299*x_97 - 0.11720009379718*x_98 - 0.0202505258253899*x_99 + 0.00365708402250073*std::pow(-7.36319971084595*x_106 - 7.55671977996826, 2) - 4.65342320683869e-5*std::pow(-5.29512023925781*x_108 - 7.73583984375, 2) + 0.174143849136374*std::pow(-0.582399845123291*x_108 - 0.778079867362976, 2) - 6.60262064832781e-5*std::pow(-7.56576013565063*x_109 - 9.54831981658936, 2) - 0.000603052576626134*std::pow(-6.31343984603882*x_11 - 9.7729606628418, 2) - 0.00183482610521811*std::pow(-8.15095996856689*x_116 - 8.55615997314453, 2) + 0.000151279692728978*std::pow(-7.33599996566772*x_118 - 8.55144023895264, 2) + 0.000888285946855715*std::pow(-6.34631967544556*x_120 - 8.5252799987793, 2) + 6.9490478390364e-5*std::pow(-4.97463989257813*x_120 - 5.7960000038147, 2) - 0.000161227732363551*std::pow(-5.00879955291748*x_13 - 7.81375980377197, 2) - 1.8963135675274e-5*std::pow(-5.29879999160767*x_15 - 5.5019998550415, 2) + 0.000149360119897347*std::pow(-5.08487987518311*x_15 - 7.32096004486084, 2) + 0.000694021072885332*std::pow(-8.73536014556885*x_18 - 9.75536060333252, 2) + 0.000124147655932783*std::pow(-6.31343984603882*x_19 - 9.57096099853516, 2) + 0.00151084796453121*std::pow(-7.01279973983765*x_23 - 9.21599960327148, 2) - 0.000218225498090703*std::pow(-6.67776012420654*x_24 - 9.96127986907959, 2) + 0.00257048181369469*std::pow(-4.61759996414185*x_24 - 6.62983989715576, 2) + 4.54572259905145e-5*std::pow(-7.44783973693848*x_27 - 8.82520008087158, 2) - 0.00507962252401495*std::pow(-5.21519994735718*x_39 - 6.82528018951416, 2) + 4.63209764999143e-5*std::pow(-6.29800033569336*x_4 - 9.95495986938477, 2) - 0.000370369292473494*std::pow(-4.83800029754639*x_44 - 6.05071973800659, 2) + 0.000309143294587227*std::pow(-5.75367975234985*x_47 - 7.59768009185791, 2) - 7.14751516091615e-5*std::pow(-6.32687997817993*x_5 - 9.3877592086792, 2) - 8.98549419770932e-5*std::pow(-7.51128005981445*x_50 - 8.1159200668335, 2) + 0.000547450520646149*std::pow(-7.70344018936157*x_59 - 9.92232036590576, 2) - 8.38297964284022e-5*std::pow(-6.26208019256592*x_59 - 9.90112018585205, 2) - 0.000155682287029303*std::pow(-4.89711999893188*x_6 - 7.75040006637573, 2) + 3.09051788612412e-5*std::pow(-8.05943965911865*x_64 - 9.632080078125, 2) + 5.47193671971722e-5*std::pow(-3.31583976745605*x_66 - 4.76936006546021, 2) + 0.00168571107781909*std::pow(-5.33400011062622*x_67 - 5.12992000579834, 2) - 0.0001081710744026*std::pow(-4.89463996887207*x_7 - 6.54287958145142, 2) + 0.000161490788382977*std::pow(-6.32664012908936*x_70 - 8.89144039154053, 2) + 0.00418854460364558*std::pow(-5.72743988037109*x_70 - 7.97160005569458, 2) - 0.000130743919535363*std::pow(-6.03951978683472*x_72 - 8.25783920288086, 2) + 8.65759743382596e-5*std::pow(-5.92343997955322*x_72 - 7.55639982223511, 2) + 0.000313621430772228*std::pow(-5.51567983627319*x_72 - 6.31112003326416, 2) + 0.00114159942965764*std::pow(-5.3295202255249*x_72 - 7.79544019699097, 2) - 0.000652153953885153*std::pow(-5.7279200553894*x_73 - 7.8930401802063, 2) - 9.46556113197325e-5*std::pow(-7.48496007919312*x_74 - 9.9323205947876, 2) + 0.00300261720025981*std::pow(-5.3471999168396*x_74 - 6.92751979827881, 2) + 5.30954175119263e-5*std::pow(-6.85536003112793*x_77 - 8.66800022125244, 2) - 0.00167113331706254*std::pow(-4.26240015029907*x_78 - 5.81343936920166, 2) - 0.00318031793448958*std::pow(-7.15487957000732*x_81 - 9.58255958557129, 2) + 1.98396695133811e-5*std::pow(-8.56280040740967*x_84 - 8.97383975982666, 2) + 5.87703896316007e-5*std::pow(-8.34360027313232*x_84 - 8.74335956573486, 2) - 1.53968525052755e-5*std::pow(-7.32399988174438*x_84 - 6.70928001403809, 2) + 0.000148590596813152*std::pow(-5.07727956771851*x_86 - 7.30615997314453, 2) + 0.00110290018915617*std::pow(-4.13991975784302*x_87 - 5.91967964172363, 2) - 0.00265026889360501*std::pow(-8.75607967376709*x_88 - 9.97624015808105, 2) + 1.03482191211601e-5*std::pow(-8.0033597946167*x_88 - 9.20728015899658, 2) - 0.00338885423913849*std::pow(-2.1943998336792*x_88 - 2.17791986465454, 2) + 0.0001529233977438*std::pow(-3.1781599521637*x_90 - 4.56775999069214, 2) + 0.000205350065423231*std::pow(-5.24519968032837*x_99 - 6.02455997467041, 2) + 0.00949566138666694*std::exp(0.702079832553864*x_1) - 0.000157446346049872*std::exp(1.08351981639862*x_1) + 5.07229129159961e-5*std::exp(1.19423997402191*x_1) + 0.00326782222615773*std::exp(1.22735989093781*x_1) - 2.11695204809443e-5*std::exp(1.28807985782623*x_1) - 0.00127141519028299*std::exp(1.19983983039856*x_100) - 0.000292826220954984*std::exp(1.62295985221863*x_100) - 0.0213107202714205*std::exp(0.515199840068817*x_103) + 0.0230649748790962*std::exp(0.528799831867218*x_104) - 0.00833536430367154*std::exp(1.06327986717224*x_104) + 0.0626467797888143*std::exp(0.650879800319672*x_106) + 0.00329771725353564*std::exp(0.665519833564758*x_106) + 0.00165787046791913*std::exp(0.792479872703552*x_106) + 0.141536636467209*std::exp(1.33487987518311*x_106) + 0.171093642823051*std::exp(0.648639798164368*x_109) - 0.103021404895064*std::exp(0.855439901351929*x_110) + 0.000832707331075786*std::exp(1.08487975597382*x_110) + 0.000192401675842492*std::exp(1.55039989948273*x_110) + 7.10135084611278e-5*std::exp(1.59975981712341*x_110) - 0.0814714237401326*std::exp(0.604959845542908*x_112) - 0.000429503700409744*std::exp(0.914159834384918*x_112) + 0.00205540992332051*std::exp(0.571999847888947*x_24) - 0.0770530318537681*std::exp(0.514479875564575*x_26) + 0.307352642706229*std::exp(0.62559986114502*x_26) + 0.00878754207870094*std::exp(0.643839836120605*x_26) + 0.000885318613089461*std::exp(0.829519867897034*x_26) - 0.00358736920596835*std::exp(0.874719858169556*x_26) + 0.000501963017571651*std::exp(0.913679838180542*x_26) - 0.984963464740455*std::exp(0.491599857807159*x_31) - 0.0037774752685179*std::exp(0.599999845027924*x_31) - 0.0497274454995185*std::exp(0.620239853858948*x_31) - 0.00303773244475279*std::exp(0.647599816322327*x_31) + 0.0026460344988406*std::exp(0.654319822788239*x_31) - 0.161068060761038*std::exp(0.655279815196991*x_31) - 0.029195435781697*std::exp(0.654959857463837*x_45) - 0.00680514356945857*std::exp(0.825759887695313*x_45) + 0.00143121239159174*std::exp(1.0123997926712*x_45) + 0.032780131002874*std::exp(1.11879980564117*x_45) + 0.000182616930859761*std::exp(1.23079991340637*x_45) + 0.0303479214643248*std::exp(0.99375981092453*x_6) + 0.00658040218103396*std::exp(0.713119864463806*x_60) + 0.12827554115534*std::exp(0.968719840049744*x_60) + 0.000910210148889131*std::exp(1.24247992038727*x_60) + 7.22542986816021e-5*std::exp(1.45055985450745*x_66) - 0.00689609762956514*std::exp(1.66143977642059*x_66) - 0.000438153016202373*std::exp(0.718239843845367*x_70) - 0.000637434994457661*std::exp(0.895999848842621*x_70) + 0.020758853854381*std::exp(0.875359892845154*x_72) - 0.00125711112105252*std::exp(0.97439980506897*x_74) + 0.00075071997841099*std::exp(1.0343998670578*x_74) + 0.00341556315899136*std::exp(1.24767982959747*x_74) + 4.58470443958832e-5*std::exp(1.71327984333038*x_74) + 0.421185365617789*std::exp(0.599999845027924*x_76) - 0.0105870724605838*std::exp(0.73831981420517*x_77) - 0.0056860086006428*std::exp(0.885519862174988*x_81) + 0.00306460586323528*std::exp(1.09175980091095*x_81) + 0.00765189893394369*std::exp(0.719999849796295*x_87) + 0.0982407046864586*std::sin(0.222879990935326*x_1 - 1.19911992549896) - 0.431029231957712*std::sin(0.184960007667542*x_10 + 1.76799988746643) + 2.28216116686326*std::sin(0.330879837274551*x_10 - 7.47408008575439) - 0.360952504555334*std::sin(0.372159838676453*x_100 - 7.40847969055176) + 0.0627486217061518*std::sin(0.155280038714409*x_102 - 7.65199995040894) + 0.66222247679826*std::sin(0.298239946365356*x_102 - 7.52088022232056) - 0.0401819022230972*std::sin(0.342959851026535*x_102 - 7.44087982177734) - 0.0652043035709811*std::sin(0.371279835700989*x_102 + 1.97439980506897) + 0.123387302377867*std::sin(0.430479854345322*x_102 - 4.16527986526489) + 0.427658661504697*std::sin(0.445199847221375*x_102 + 5.23176002502441) - 0.152503652757396*std::sin(0.314079850912094*x_103 - 7.47591972351074) - 2.79706757413887*std::sin(0.465919852256775*x_103 - 7.36799955368042) - 4.19230831411285*std::sin(0.487919867038727*x_104 - 4.14376020431519) + 0.756077822492514*std::sin(0.60919988155365*x_104 - 7.1910400390625) + 0.0155374348848972*std::sin(0.640159845352173*x_104 - 7.17999982833862) - 0.376154127641697*std::sin(0.263999968767166*x_105 + 1.85087990760803) + 0.30349737295004*std::sin(0.319519847631454*x_105 + 1.92879974842072) + 0.0891986307478063*std::sin(0.355839848518372*x_105 - 7.42432022094727) - 0.0602095690320948*std::sin(0.357599824666977*x_105 - 7.44007968902588) + 0.845068743646848*std::sin(0.187360003590584*x_106 - 7.61688041687012) - 0.0404412971271065*std::sin(0.432319849729538*x_106 + 5.221360206604) + 6.64251079281553*std::sin(0.299039930105209*x_107 + 5.11175966262817) + 0.962480136470541*std::sin(0.363919854164124*x_107 - 7.4172797203064) + 0.0575720240012454*std::sin(0.44327986240387*x_107 + 5.22464036941528) + 0.100498700243241*std::sin(0.347679853439331*x_108 + 5.14847993850708) + 0.112322353569319*std::sin(0.663199841976166*x_108 + 2.2377598285675) + 0.0783548325789767*std::sin(0.345519840717316*x_109 + 5.15944004058838) + 0.31584694331658*std::sin(0.375519841909409*x_110 + 5.1691198348999) + 0.00876570891807395*std::sin(0.590079843997955*x_110 - 7.21264028549194) - 0.555054660681892*std::sin(0.3572798371315*x_111 - 7.43255996704102) - 0.0233682561378328*std::sin(0.401119828224182*x_111 - 4.20544004440308) + 0.376574766733784*std::sin(0.439599871635437*x_111 - 1.17359983921051) + 0.0049106743991019*std::sin(0.456559866666794*x_111 + 8.23095989227295) + 1.13153038241752*std::sin(0.473359853029251*x_111 + 2.04543972015381) + 0.0197784252773692*std::sin(0.496959865093231*x_111 - 4.12064027786255) + 9.53369563521473*std::sin(0.198719993233681*x_112 + 4.99071979522705) + 0.10156953718303*std::sin(0.353759855031967*x_112 - 7.41695976257324) + 0.00925486084052548*std::sin(0.411039859056473*x_112 - 0.981599867343903) + 0.584556723204397*std::sin(0.48583984375*x_112 + 5.23848009109497) + 0.0700486059547061*std::sin(0.507519841194153*x_112 - 1.01695990562439) + 10.5213446440929*std::sin(0.304399937391281*x_113 - 7.4966402053833) + 3.38707820074996*std::sin(0.345999836921692*x_113 - 7.43743991851807) - 0.128193669546396*std::sin(0.268559962511063*x_114 - 7.53224039077759) + 0.682122237245509*std::sin(0.269199967384338*x_114 - 7.52320003509521) - 2.61562152452464*std::sin(0.367759823799133*x_114 - 7.42456007003784) - 0.310679285556813*std::sin(0.429439842700958*x_114 + 5.22695970535278) - 0.007361834980643*std::sin(0.468559861183167*x_114 - 4.1592001914978) - 0.020198815166534*std::sin(0.576479852199554*x_114 - 7.21895980834961) - 0.28173907483398*std::sin(0.665199875831604*x_114 + 5.43255996704102) + 0.0226393851228903*std::sin(0.302079945802689*x_115 + 5.103919506073) - 2.44353251914809*std::sin(0.325759828090668*x_115 - 7.45439958572388) - 0.814082896629399*std::sin(0.416079849004745*x_115 + 5.22344017028809) - 0.0367351138720814*std::sin(0.48447984457016*x_115 - 4.12936019897461) - 0.0512233023959283*std::sin(0.534799814224243*x_115 + 5.36311960220337) + 0.368114073225387*std::sin(0.435039848089218*x_116 + 8.42255973815918) - 0.268304704277074*std::sin(0.49839985370636*x_116 - 4.12344026565552) + 0.0546974975146407*std::sin(0.243599966168404*x_117 - 1.35351991653442) + 2.02471822693818*std::sin(0.376959830522537*x_117 + 1.97719979286194) - 0.0901215315710933*std::sin(0.378399848937988*x_117 + 5.1756796836853) + 0.628161035548188*std::sin(0.400079846382141*x_117 - 4.1864800453186) - 0.134183105176107*std::sin(0.616959869861603*x_117 - 3.99599981307983) - 0.396562284795164*std::sin(0.191840007901192*x_118 + 1.78999984264374) + 1.94269599333647*std::sin(0.408879846334457*x_118 + 5.20247983932495) + 0.095339064500675*std::sin(0.419359862804413*x_118 + 5.21727991104126) + 0.0129152163128451*std::sin(0.289599925279617*x_119 - 4.28279972076416) - 0.993826709639296*std::sin(0.340479850769043*x_119 + 5.15120029449463) + 1.33962671092862*std::sin(0.34895983338356*x_119 + 5.15208005905151) - 0.0435203896245386*std::sin(0.366079837083817*x_119 - 7.41511964797974) - 1.57724827010603*std::sin(0.434239864349365*x_119 + 1.99407982826233) + 0.664297846435935*std::sin(0.35471984744072*x_12 - 1.03167986869812) - 0.0106666512881826*std::sin(0.328399837017059*x_120 + 1.94799983501434) + 0.074669116934608*std::sin(0.36695984005928*x_120 + 5.15912008285522) + 0.0970992692843147*std::sin(0.427679866552353*x_120 + 5.2294397354126) - 6.16190722510961*std::sin(0.211919993162155*x_14 - 4.38903999328613) + 0.0288989290326627*std::sin(0.272799968719482*x_16 + 5.08839988708496) + 0.0761994379713603*std::sin(0.368559837341309*x_16 + 5.15863990783691) + 0.463926984931498*std::sin(0.369679838418961*x_16 + 5.18168020248413) + 0.0219273930781846*std::sin(0.427279859781265*x_18 - 0.954639852046967) + 0.0612595399367088*std::sin(0.348479837179184*x_20 - 4.25511980056763) + 2.89595735408708*std::sin(0.361199855804443*x_20 + 5.16968011856079) - 1.23556063395204*std::sin(0.357999831438065*x_21 + 8.36407947540283) + 4.2972403893123*std::sin(0.209600001573563*x_22 - 7.57504034042358) - 0.0369238341090563*std::sin(0.502079844474792*x_22 + 2.10895967483521) - 0.0173733048077601*std::sin(0.589439868927002*x_22 - 7.22200012207031) + 0.314284314105166*std::sin(0.162880018353462*x_24 + 4.93567991256714) + 0.0361329504981941*std::sin(0.182560011744499*x_24 + 4.98351955413818) - 0.048073612310088*std::sin(0.190160006284714*x_24 - 7.60288000106812) - 0.782425682929082*std::sin(0.338639855384827*x_24 - 4.25832033157349) + 0.0133961603410513*std::sin(0.46111986041069*x_25 - 4.13752031326294) + 0.122876621601194*std::sin(0.186080008745193*x_26 - 7.6005597114563) - 0.318206453985149*std::sin(0.137440040707588*x_27 + 4.9017596244812) + 8.15420310282466*std::sin(0.171120017766953*x_27 - 7.6241602897644) + 0.0519291301785975*std::sin(0.301679939031601*x_27 + 5.12080001831055) + 5.60409845651056*std::sin(0.303999930620193*x_27 + 5.13247966766357) - 0.152852048386343*std::sin(0.319839835166931*x_28 - 4.28064012527466) - 2.25840196344361*std::sin(0.320079833269119*x_28 - 4.28864002227783) + 0.959637151190619*std::sin(0.322399854660034*x_28 - 4.28247976303101) + 0.0184663010591398*std::sin(0.326319843530655*x_28 + 5.13312005996704) - 3.11127344406385*std::sin(0.331519842147827*x_28 - 4.27248001098633) + 0.117962806970606*std::sin(0.33247983455658*x_28 - 4.26847982406616) + 0.0383890090921536*std::sin(0.285919934511185*x_3 + 5.08111953735352) + 0.832582200835326*std::sin(0.294319927692413*x_3 + 5.10839986801147) - 0.347586318207314*std::sin(0.307759910821915*x_3 - 7.5032000541687) + 4.11463802678094*std::sin(0.261199980974197*x_30 - 7.53352022171021) - 1.90396199986512*std::sin(0.27295994758606*x_30 - 4.32471990585327) - 0.131934718926408*std::sin(0.279999971389771*x_30 - 4.29591989517212) - 1.54092541166186*std::sin(0.360319852828979*x_31 + 5.10487985610962) - 5.32325261137959*std::sin(0.255839973688126*x_32 - 4.40239953994751) + 0.336007211273557*std::sin(0.348479837179184*x_32 + 8.2469596862793) - 0.39154858133809*std::sin(0.322319835424423*x_33 + 8.19719982147217) + 0.0881509692100945*std::sin(0.351519852876663*x_34 + 2.00215983390808) + 0.0227764543807492*std::sin(0.313519835472107*x_35 + 1.97631978988647) - 0.0603967153958435*std::sin(0.315679848194122*x_35 + 1.98063981533051) + 2.23972946231214*std::sin(0.317599833011627*x_35 - 7.43431997299194) - 0.760618066637457*std::sin(0.318319827318192*x_35 - 7.43311977386475) + 0.0799308911699244*std::sin(0.319839835166931*x_35 - 7.42831993103027) + 0.325828194009155*std::sin(0.319919854402542*x_35 - 7.42831993103027) - 0.0232515524326963*std::sin(0.321919858455658*x_35 - 7.42599964141846) - 0.0146988267526752*std::sin(0.331519842147827*x_36 - 4.25288009643555) + 1.1543343984686*std::sin(0.352959841489792*x_36 + 5.1637601852417) + 0.289825273192174*std::sin(0.373759835958481*x_36 - 7.41639995574951) + 0.0269474941146151*std::sin(0.380639851093292*x_36 - 7.39903974533081) - 1.40627922887981*std::sin(0.393519848585129*x_36 - 4.2052001953125) + 0.0722897389151003*std::sin(0.418559849262238*x_36 + 5.22079992294312) - 0.631094089420328*std::sin(0.293359935283661*x_37 + 5.09615993499756) - 0.125992078218157*std::sin(0.298719942569733*x_37 - 7.50471973419189) - 4.19299831155478*std::sin(0.36303985118866*x_37 - 4.24047994613647) + 0.160585528970086*std::sin(0.364959836006165*x_37 - 7.42208003997803) - 1.47151634187475*std::sin(0.401439845561981*x_37 - 4.20695972442627) + 0.0588227623235806*std::sin(0.48039984703064*x_38 + 5.25888013839722) + 0.0177199895887694*std::sin(0.665279865264893*x_38 + 2.20815992355347) + 2.17729550657674*std::sin(0.19743999838829*x_39 + 4.99631977081299) + 0.327410025205205*std::sin(0.350079834461212*x_39 + 5.16296005249023) - 0.330093577825071*std::sin(0.334239840507507*x_40 - 4.27408027648926) + 0.0694708303242709*std::sin(0.390239834785461*x_40 + 8.37495994567871) - 0.224542849807576*std::sin(0.312159925699234*x_41 + 1.89567983150482) + 1.80611453687428*std::sin(0.375519841909409*x_41 + 5.17112016677856) - 4.52788131718001*std::sin(0.406959861516953*x_41 - 7.39175987243652) + 0.0335455662570674*std::sin(0.431519865989685*x_41 - 7.38671970367432) - 8.42216446080471*std::sin(0.121520057320595*x_42 + 1.70983994007111) - 5.81482504742905*std::sin(0.369279831647873*x_43 - 7.41183996200562) + 0.0646514519724246*std::sin(0.380639851093292*x_43 - 4.22176027297974) + 0.138241408626742*std::sin(0.383359849452972*x_43 - 7.40655994415283) + 0.591236649612683*std::sin(0.440879851579666*x_43 - 7.37831974029541) + 0.560107252990087*std::sin(0.359359860420227*x_44 + 5.16416025161743) - 0.0757662068277082*std::sin(0.407279849052429*x_46 + 5.21623992919922) + 0.14948417170086*std::sin(0.585599839687347*x_46 - 7.21920013427734) + 0.00979122145426164*std::sin(0.645839810371399*x_46 + 5.4171199798584) + 2.78511816990537*std::sin(0.208159998059273*x_47 - 7.59176015853882) - 5.08299602053027*std::sin(0.260319977998734*x_47 + 1.85655987262726) - 0.0448949043237035*std::sin(0.439279854297638*x_47 - 4.15232038497925) + 1.06901088053542*std::sin(0.424719870090485*x_48 - 4.17040014266968) + 0.146097977358741*std::sin(0.259919971227646*x_49 + 1.85903990268707) + 0.0758069910838028*std::sin(0.437279850244522*x_49 - 7.35431957244873) + 4.54713332446524*std::sin(0.191200003027916*x_50 + 4.98799991607666) + 6.95730007321964*std::sin(0.321759849786758*x_50 - 7.47687959671021) + 0.811203372482098*std::sin(0.36559984087944*x_51 - 4.23184013366699) + 6.21690583247993*std::sin(0.212960004806519*x_53 + 5.00816011428833) + 0.751304803725265*std::sin(0.347519844770432*x_53 + 5.15128040313721) - 0.0775739526705253*std::sin(0.359999865293503*x_53 - 4.24272012710571) - 0.00141227273791555*std::sin(0.889279901981354*x_53 - 3.95743989944458) - 0.111260741043692*std::sin(0.319359838962555*x_54 + 1.90071976184845) - 0.972180419164248*std::sin(0.417919874191284*x_54 - 7.38679981231689) - 0.344683278684784*std::sin(0.487039864063263*x_54 - 1.10911989212036) + 0.118443531923884*std::sin(0.658959865570068*x_54 - 3.96943998336792) - 1.61458489932082*std::sin(0.348079830408096*x_55 + 5.15960025787354) + 0.694451519420781*std::sin(0.403119832277298*x_55 + 8.38576030731201) + 0.0370264230716531*std::sin(0.441839843988419*x_55 - 4.14991998672485) - 0.0201231693318442*std::sin(0.465039849281311*x_55 + 5.25047969818115) + 0.643962987590366*std::sin(0.322559833526611*x_56 + 1.92327988147736) - 0.296654720952978*std::sin(0.406159847974777*x_56 + 5.19504022598267) - 0.675459263968941*std::sin(0.428879857063293*x_57 - 4.16879987716675) - 0.0569979604833411*std::sin(0.448399841785431*x_57 - 4.15232038497925) - 2.09695564201116*std::sin(0.553839862346649*x_57 + 5.35767984390259) + 0.0233208802050882*std::sin(0.853919863700867*x_57 + 5.62479972839355) + 0.337219982407212*std::sin(0.170960009098053*x_58 + 4.96247959136963) + 3.18937154941195*std::sin(0.209440007805824*x_58 + 5.00848007202148) + 0.241861347115215*std::sin(0.266239941120148*x_58 - 7.51327991485596) + 3.05990135401746*std::sin(0.2743199467659*x_58 + 5.07583951950073) - 0.0667108692419958*std::sin(0.348079830408096*x_58 + 5.15759992599487) + 0.726767107447686*std::sin(0.42223984003067*x_58 - 4.189040184021) - 0.0735977179308764*std::sin(0.462799847126007*x_58 + 5.25392007827759) + 0.154249775809877*std::sin(0.168560013175011*x_59 - 7.63191986083984) + 5.86638667445305*std::sin(0.251999974250793*x_59 - 7.52784013748169) + 0.0919214194882619*std::sin(0.203199997544289*x_64 + 1.78175985813141) - 0.018928164621527*std::sin(0.222240000963211*x_64 - 4.36191987991333) + 3.36168176364275*std::sin(0.228959992527962*x_64 - 4.36199951171875) + 0.0066870243846579*std::sin(0.339199841022491*x_64 - 7.4555196762085) - 0.839891043074942*std::sin(0.43495985865593*x_66 + 8.44768047332764) - 1.93539618260902*std::sin(0.243759974837303*x_67 - 7.55679988861084) + 2.37382372244406*std::sin(0.247279971837997*x_70 - 7.52800035476685) - 0.0906685797449049*std::sin(0.439999878406525*x_70 - 4.15304040908813) - 0.0120677747096409*std::sin(0.624399840831757*x_70 - 3.97263979911804) - 0.201657331896292*std::sin(0.23063999414444*x_71 + 5.04759979248047) + 0.0827457809553529*std::sin(0.214000001549721*x_72 + 5.00920009613037) + 9.14621502629262*std::sin(0.24959996342659*x_73 + 5.06479978561401) - 0.821742647935052*std::sin(0.342559844255447*x_73 - 4.26151990890503) - 0.0167479092755477*std::sin(0.451039850711823*x_73 - 4.15104007720947) - 0.458703430713082*std::sin(0.123040057718754*x_75 + 4.89031982421875) + 0.0437484929570444*std::sin(0.278559952974319*x_75 + 5.09087991714478) + 0.382276112215121*std::sin(0.409119844436646*x_75 - 7.38631963729858) + 1.46479914686824*std::sin(0.476879835128784*x_75 + 2.08039975166321) - 0.206563124709979*std::sin(0.540319859981537*x_75 + 5.16431999206543) + 8.03390435600127*std::sin(0.238319978117943*x_76 - 7.53840017318726) - 1.44978209708007*std::sin(0.393599838018417*x_78 + 8.3810396194458) + 0.00676317553309555*std::sin(0.486639857292175*x_78 + 5.28744029998779) - 1.10165060197826*std::sin(0.281759947538376*x_79 - 7.4986400604248) + 2.57169278700816*std::sin(0.332239836454391*x_79 + 5.12871980667114) - 4.58870890416988*std::sin(0.355119854211807*x_79 + 1.96583986282349) - 0.197086044687926*std::sin(0.249199971556664*x_8 - 4.33576011657715) - 0.771938378006367*std::sin(0.501679837703705*x_8 - 7.30711984634399) + 0.125477855556968*std::sin(0.389359831809998*x_81 + 8.37271976470947) + 2.33938422040911*std::sin(0.214159995317459*x_82 - 7.57696008682251) + 0.495570531220267*std::sin(0.197359994053841*x_83 + 5.00008010864258) + 0.345773506782479*std::sin(0.201599985361099*x_83 + 5.0053596496582) + 0.0227480092324457*std::sin(0.263119965791702*x_83 + 1.87455987930298) + 0.0356598657136088*std::sin(0.319679915904999*x_83 - 7.46343994140625) + 5.02275012882702*std::sin(0.320559918880463*x_83 - 7.46808004379272) - 0.453935646646701*std::sin(0.322239845991135*x_83 - 7.4730396270752) + 1.57550155155114*std::sin(0.393679857254028*x_83 - 1.19831991195679) - 0.208360381560176*std::sin(0.140080034732819*x_84 - 7.67984008789063) - 0.129309168576038*std::sin(0.179360002279282*x_84 + 1.77599990367889) + 3.69086425405014*std::sin(0.23871998488903*x_84 - 7.55600023269653) + 0.114070827143797*std::sin(0.278079956769943*x_84 + 5.09272003173828) + 2.12127820893746*std::sin(0.278479933738708*x_84 - 7.49608039855957) + 0.168401797005298*std::sin(0.187040001153946*x_85 + 4.98767995834351) + 0.146416274314888*std::sin(0.19064000248909*x_85 - 7.61648035049438) - 0.148561361504476*std::sin(0.221919998526573*x_85 - 7.56135988235474) + 2.16183818910986*std::sin(0.230239987373352*x_85 - 7.55408048629761) + 0.0269793047264502*std::sin(0.524639844894409*x_86 - 7.27040004730225) + 1.54249577465648*std::sin(0.402799844741821*x_87 + 5.20991992950439) - 1.03606247763311*std::sin(0.417919844388962*x_87 - 4.18951988220215) + 0.0249309964960631*std::sin(0.499039828777313*x_87 - 4.11488008499146) + 0.00473147644971005*std::sin(0.87447988986969*x_87 - 0.751359879970551) - 0.223097723506773*std::sin(0.219119995832443*x_89 + 1.8155198097229) - 0.362294407471024*std::sin(0.41023987531662*x_90 - 7.39207983016968) + 0.0460590223031567*std::sin(0.414639860391617*x_90 - 0.994639813899994) + 0.123661875257357*std::sin(0.505279839038849*x_90 - 4.09320020675659) - 0.0138609861780156*std::sin(0.337039858102798*x_92 + 5.18400001525879) - 0.499069387573706*std::sin(0.341039836406708*x_92 + 5.20991992950439) - 0.0954433843954701*std::sin(0.360079854726791*x_92 + 1.97791981697083) - 3.68698933802571*std::sin(0.360879838466644*x_92 + 2.00343990325928) - 0.0161830021254522*std::sin(0.363839834928513*x_92 - 7.38535976409912) - 7.78084142345954*std::sin(0.365199834108353*x_92 + 1.99775981903076) + 0.0307733215263029*std::sin(0.381279855966568*x_92 + 1.97519981861115) - 0.0335905052806326*std::sin(0.401679873466492*x_92 - 7.59008026123047) + 0.0778044201480066*std::sin(0.374559849500656*x_94 - 1.18543982505798) - 0.0318061268800255*std::sin(0.376239836215973*x_94 + 1.98399984836578) + 1.43393463425049*std::sin(0.386319845914841*x_94 - 7.40639972686768) + 2.36845542381438*std::sin(0.404079854488373*x_94 - 4.21031999588013) - 0.0408972711064287*std::sin(0.367999851703644*x_95 + 1.98935985565186) + 3.24339493529546*std::sin(0.382479846477509*x_95 - 7.39607954025269) + 0.011831737282675*std::sin(0.376959830522537*x_96 - 4.22176027297974) - 0.551381481623232*std::sin(0.386959820985794*x_96 - 4.2021598815918) + 0.0369011643072761*std::sin(0.396319836378098*x_96 + 5.20240020751953) + 0.545211158000622*std::sin(0.398799866437912*x_96 - 7.3931999206543) - 1.53626153995656*std::sin(0.411679863929749*x_96 + 1.98543977737427) + 0.221012652177435*std::sin(0.326879858970642*x_97 + 5.13624000549316) - 0.325559546756265*std::sin(0.339759826660156*x_97 + 5.16359996795654) - 0.00919596345681615*std::sin(0.362479835748672*x_97 - 4.41720008850098) + 2.44663250381985*std::sin(0.403599858283997*x_97 + 5.19040012359619) - 0.0448892419157469*std::sin(0.518239855766296*x_97 + 2.16407990455627) + 0.0116157922275876*std::sin(0.395679831504822*x_98 - 4.19135999679565) + 0.119014857627632*std::sin(0.406559854745865*x_98 - 7.38751983642578) + 0.0431830263997425*std::sin(0.414239853620529*x_98 - 7.39607954025269) - 0.0546712456319177*std::sin(0.430639863014221*x_98 - 7.37799978256226) + 0.225218532150765*std::sin(0.433199852705002*x_98 - 7.38143968582153) - 3.75245454708447*std::sin(0.382719844579697*x_99 - 7.42312002182007) + 0.19795432367035*std::sin(0.398159861564636*x_99 - 7.40983963012695) - 0.0403111469842446*std::sin(0.402159839868546*x_99 - 4.20552015304565) + 0.147281769915108*std::sin(0.403039842844009*x_99 + 5.20864009857178) + 0.303855999376216*std::sin(0.415279865264893*x_99 - 4.19144010543823) + 139.697993404935);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0703429198703925*x_1 - 0.236685059103011*x_10 + 0.0543627167027842*x_100 - 0.0382043501660111*x_101 - 0.0103225501271506*x_102 + 2.54054301224261*x_103 - 0.0164225312701208*x_104 + 0.00640505792673937*x_105 - 0.0214161453748871*x_106 + 0.159983296484407*x_107 - 0.0875123016215307*x_108 + 0.510925729913807*x_109 + 0.106919224207823*x_11 - 0.0569698126166282*x_110 - 0.00551915220918037*x_111 - 0.00272793654106057*x_112 - 0.234320953461733*x_113 + 0.0161082830887335*x_114 - 0.0588256997966757*x_115 - 0.0511896257633392*x_116 - 0.0098615753126269*x_117 - 0.62893473232496*x_118 - 0.0065568985166111*x_119 + 0.461104543387297*x_12 + 0.0857436005721181*x_120 + 0.390057054507794*x_13 + 0.269399611512753*x_14 + 0.889265876338354*x_15 - 0.122351027449264*x_16 + 0.16754848071749*x_17 + 0.579756636836469*x_18 - 0.29561975127561*x_19 + 0.340040907380532*x_2 + 0.321912090786681*x_20 + 0.241814989136043*x_21 - 0.748969618827638*x_22 + 0.507724949298703*x_23 + 0.0493288651648227*x_24 - 0.289713941672918*x_25 - 0.184794432985951*x_26 - 0.333699583520318*x_27 + 0.00985852857436191*x_28 - 0.275537890826587*x_29 + 0.0545595487357114*x_3 - 0.224371810294374*x_30 - 1.40075322842766*x_31 - 5.13908182038018*x_32 + 0.92617979833588*x_33 + 0.143360742195622*x_34 + 0.0719364632029725*x_35 - 0.00525928690980092*x_36 - 0.0328472260126399*x_37 - 0.270018177219279*x_38 - 1.13452186407852*x_39 - 0.515621757085864*x_4 + 0.125451640420634*x_40 + 0.0373077531847065*x_41 - 0.294194039776875*x_42 + 0.620261509069302*x_43 + 0.471152631212727*x_44 - 0.0166103142025828*x_45 + 0.144178372112838*x_46 + 0.00542772050831093*x_47 - 0.802669509521422*x_48 + 0.355868260385242*x_49 - 0.270639970169818*x_5 + 0.217777203515272*x_50 - 0.0814853584168147*x_51 - 0.427865880550176*x_52 + 0.0499476946002618*x_53 - 1.06029327560778*x_54 - 0.06820471439333*x_55 + 0.0280485420319697*x_56 - 0.0400798779760091*x_57 + 0.00452498527945027*x_58 - 0.00371603133053515*x_59 - 0.0806222620947908*x_6 - 0.287240012253934*x_60 - 1.48081199253849*x_61 + 3.43136617873549*x_62 + 0.785885492720892*x_63 - 0.120284919038737*x_64 + 0.739616743306407*x_65 + 0.00444904226110279*x_66 + 0.035669994280984*x_67 + 1.05622316355354*x_68 + 1.41174743593652*x_69 + 0.374046546707719*x_7 + 0.0340423848781665*x_70 + 0.0860143863235019*x_71 + 0.0476326178042459*x_72 + 0.0305739975010147*x_73 + 0.452214662913621*x_74 + 0.0155125461556868*x_75 - 0.832653307249319*x_76 - 0.0826599886133643*x_77 + 0.0478602839082549*x_78 + 0.013213301436715*x_79 - 0.530680059396346*x_8 + 0.279554421834913*x_80 - 0.0940501843975643*x_81 - 0.0791891111109525*x_82 - 0.0308586069150411*x_83 + 0.00381854137308776*x_84 - 0.614380351522316*x_85 - 0.729596208635137*x_86 - 0.00264816581256242*x_87 - 0.0122698371201024*x_88 + 1.23975355568609*x_89 - 0.588951161026078*x_9 - 0.105793323598347*x_90 - 2.49530869529628*x_91 + 0.00624127261726183*x_92 - 2.52537692459915*x_93 - 0.730803862103966*x_94 + 0.0368474696745338*x_95 - 0.0136952348308551*x_96 + 0.226806204343151*x_97 - 0.0360668942927309*x_98 - 0.0054893071241359*x_99 + 0.00104188544117123*std::pow(-7.36319971084595*x_106 - 7.55671977996826, 2) - 0.000296963082608114*std::pow(-5.29512023925781*x_108 - 7.73583984375, 2) + 0.141628213842502*std::pow(-0.582399845123291*x_108 - 0.778079867362976, 2) + 5.97692999516636e-5*std::pow(-7.56576013565063*x_109 - 9.54831981658936, 2) - 0.00439072483689039*std::pow(-6.31343984603882*x_11 - 9.7729606628418, 2) - 0.0005227330283761*std::pow(-8.15095996856689*x_116 - 8.55615997314453, 2) - 3.45046255971028e-5*std::pow(-7.33599996566772*x_118 - 8.55144023895264, 2) + 0.000253068343503115*std::pow(-6.34631967544556*x_120 - 8.5252799987793, 2) + 0.000443460776238622*std::pow(-4.97463989257813*x_120 - 5.7960000038147, 2) + 0.000145949149730481*std::pow(-5.00879955291748*x_13 - 7.81375980377197, 2) - 4.95623935642558e-5*std::pow(-5.29879999160767*x_15 - 5.5019998550415, 2) - 0.000135206159530335*std::pow(-5.08487987518311*x_15 - 7.32096004486084, 2) + 0.000564435467627867*std::pow(-8.73536014556885*x_18 - 9.75536060333252, 2) - 0.000112382929157405*std::pow(-6.31343984603882*x_19 - 9.57096099853516, 2) + 0.00122874680710983*std::pow(-7.01279973983765*x_23 - 9.21599960327148, 2) + 4.93132791576071e-5*std::pow(-6.67776012420654*x_24 - 9.96127986907959, 2) + 0.000732317759725024*std::pow(-4.61759996414185*x_24 - 6.62983989715576, 2) + 0.000118807826061111*std::pow(-7.44783973693848*x_27 - 8.82520008087158, 2) - 0.00144715973760911*std::pow(-5.21519994735718*x_39 - 6.82528018951416, 2) - 4.19314161139715e-5*std::pow(-6.29800033569336*x_4 - 9.95495986938477, 2) - 0.000968003865606529*std::pow(-4.83800029754639*x_44 - 6.05071973800659, 2) - 7.05109419722125e-5*std::pow(-5.75367975234985*x_47 - 7.59768009185791, 2) - 0.000186808745915221*std::pow(-6.32687997817993*x_5 - 9.3877592086792, 2) + 8.13399294797948e-5*std::pow(-7.51128005981445*x_50 - 8.1159200668335, 2) + 0.000445232144521759*std::pow(-7.70344018936157*x_59 - 9.92232036590576, 2) - 0.000610350711556349*std::pow(-6.26208019256592*x_59 - 9.90112018585205, 2) + 0.000140929212902334*std::pow(-4.89711999893188*x_6 - 7.75040006637573, 2) - 7.04900708338335e-6*std::pow(-8.05943965911865*x_64 - 9.632080078125, 2) + 0.000143015525441263*std::pow(-3.31583976745605*x_66 - 4.76936006546021, 2) + 0.00137095998618402*std::pow(-5.33400011062622*x_67 - 5.12992000579834, 2) - 0.000282717871854946*std::pow(-4.89463996887207*x_7 - 6.54287958145142, 2) - 0.000146187277512866*std::pow(-6.32664012908936*x_70 - 8.89144039154053, 2) + 0.00119329597443882*std::pow(-5.72743988037109*x_70 - 7.97160005569458, 2) + 0.00011835410452582*std::pow(-6.03951978683472*x_72 - 8.25783920288086, 2) + 0.000552493660613271*std::pow(-5.92343997955322*x_72 - 7.55639982223511, 2) + 0.00228342512551176*std::pow(-5.51567983627319*x_72 - 6.31112003326416, 2) + 0.000928443289544001*std::pow(-5.3295202255249*x_72 - 7.79544019699097, 2) - 0.00053038565586516*std::pow(-5.7279200553894*x_73 - 7.8930401802063, 2) + 8.56856682582545e-5*std::pow(-7.48496007919312*x_74 - 9.9323205947876, 2) + 0.00244197721041842*std::pow(-5.3471999168396*x_74 - 6.92751979827881, 2) - 1.2110267208521e-5*std::pow(-6.85536003112793*x_77 - 8.66800022125244, 2) - 0.0121672418714006*std::pow(-4.26240015029907*x_78 - 5.81343936920166, 2) - 0.000906057102832064*std::pow(-7.15487957000732*x_81 - 9.58255958557129, 2) + 2.61859441364103e-5*std::pow(-8.56280040740967*x_84 - 8.97383975982666, 2) - 1.3404643107434e-5*std::pow(-8.34360027313232*x_84 - 8.74335956573486, 2) + 1.07530960486429e-5*std::pow(-7.32399988174438*x_84 - 6.70928001403809, 2) - 0.000134509559521207*std::pow(-5.07727956771851*x_86 - 7.30615997314453, 2) + 0.00803003161056264*std::pow(-4.13991975784302*x_87 - 5.91967964172363, 2) - 0.000755048710515508*std::pow(-8.75607967376709*x_88 - 9.97624015808105, 2) - 7.22715204968749e-6*std::pow(-8.0033597946167*x_88 - 9.20728015899658, 2) + 0.000765792799563764*std::pow(-2.1943998336792*x_88 - 2.17791986465454, 2) + 0.000201840234675703*std::pow(-3.1781599521637*x_90 - 4.56775999069214, 2) - 4.64037666993419e-5*std::pow(-5.24519968032837*x_99 - 6.02455997467041, 2) + 0.00772265898632847*std::exp(0.702079832553864*x_1) + 3.59111465926589e-5*std::exp(1.08351981639862*x_1) + 6.69480589461657e-5*std::exp(1.19423997402191*x_1) + 0.0237924664731652*std::exp(1.22735989093781*x_1) + 1.4784702714877e-5*std::exp(1.28807985782623*x_1) - 0.00811366938700846*std::exp(1.19983983039856*x_100) + 0.000204508582413918*std::exp(1.62295985221863*x_100) - 0.0556980830236371*std::exp(0.515199840068817*x_103) - 0.00526077431976003*std::exp(0.528799831867218*x_104) - 0.0606883918437339*std::exp(1.06327986717224*x_104) + 0.0509495544544102*std::exp(0.650879800319672*x_106) + 0.00435258458919986*std::exp(0.665519833564758*x_106) + 0.0105798742739473*std::exp(0.792479872703552*x_106) + 1.03050455159861*std::exp(1.33487987518311*x_106) + 0.139147533220421*std::exp(0.648639798164368*x_109) - 0.750081599410076*std::exp(0.855439901351929*x_110) + 0.00217637890554316*std::exp(1.08487975597382*x_110) - 0.000134372508897211*std::exp(1.55039989948273*x_110) + 0.000453180152375617*std::exp(1.59975981712341*x_110) - 0.593179794892728*std::exp(0.604959845542908*x_112) - 0.00274092291192914*std::exp(0.914159834384918*x_112) + 0.0131168140038402*std::exp(0.571999847888947*x_24) + 0.0174119784488499*std::exp(0.514479875564575*x_26) + 0.0875632722056383*std::exp(0.62559986114502*x_26) + 0.0229672785358449*std::exp(0.643839836120605*x_26) - 0.000618302739273528*std::exp(0.829519867897034*x_26) - 0.0228931728429985*std::exp(0.874719858169556*x_26) + 0.000662529964413463*std::exp(0.913679838180542*x_26) - 0.280611297876858*std::exp(0.491599857807159*x_31) - 0.00498580665828965*std::exp(0.599999845027924*x_31) + 0.0112371075936012*std::exp(0.620239853858948*x_31) - 0.0193856082035855*std::exp(0.647599816322327*x_31) - 0.00184797919602768*std::exp(0.654319822788239*x_31) - 0.420970389853771*std::exp(0.655279815196991*x_31) - 0.212567079520178*std::exp(0.654959857463837*x_45) + 0.00616026103695834*std::exp(0.825759887695313*x_45) + 0.00913343198721768*std::exp(1.0123997926712*x_45) + 0.0266595198537537*std::exp(1.11879980564117*x_45) - 0.000127538884779896*std::exp(1.23079991340637*x_45) + 0.220958134806244*std::exp(0.99375981092453*x_6) + 0.0419935266925475*std::exp(0.713119864463806*x_60) + 0.0365450774348684*std::exp(0.968719840049744*x_60) + 0.00120136638844357*std::exp(1.24247992038727*x_60) - 5.04620936898881e-5*std::exp(1.45055985450745*x_66) - 0.00196466465548315*std::exp(1.66143977642059*x_66) + 0.000306004195702491*std::exp(0.718239843845367*x_70) - 0.000841336451910319*std::exp(0.895999848842621*x_70) - 0.00469096033263525*std::exp(0.875359892845154*x_72) - 0.00802238646895627*std::exp(0.97439980506897*x_74) + 0.000990858814633915*std::exp(1.0343998670578*x_74) + 0.00892697750141773*std::exp(1.24767982959747*x_74) - 3.20193800496829e-5*std::exp(1.71327984333038*x_74) + 0.342542853651607*std::exp(0.599999845027924*x_76) - 0.0276705636119521*std::exp(0.73831981420517*x_77) - 0.0148610546747422*std::exp(0.885519862174988*x_81) - 0.000698990565131972*std::exp(1.09175980091095*x_81) + 0.0199991411216092*std::exp(0.719999849796295*x_87) - 0.0889310238860209*std::sin(0.222879990935326*x_1 - 1.19911992549896) + 0.0983112934843949*std::sin(0.184960007667542*x_10 + 1.76799988746643) + 1.85604264156609*std::sin(0.330879837274551*x_10 - 7.47408008575439) - 0.293556498008241*std::sin(0.372159838676453*x_100 - 7.40847969055176) + 0.0828205279087845*std::sin(0.155280038714409*x_102 - 7.65199995040894) + 4.82153097279243*std::sin(0.298239946365356*x_102 - 7.52088022232056) + 0.0363741049882816*std::sin(0.342959851026535*x_102 - 7.44087982177734) + 0.0148721222356474*std::sin(0.371279835700989*x_102 + 1.97439980506897) - 0.0278823168690159*std::sin(0.430479854345322*x_102 - 4.16527986526489) + 0.347807474473321*std::sin(0.445199847221375*x_102 + 5.23176002502441) + 0.138051798685264*std::sin(0.314079850912094*x_103 - 7.47591972351074) - 0.796870940218281*std::sin(0.465919852256775*x_103 - 7.36799955368042) - 1.19436823723522*std::sin(0.487919867038727*x_104 - 4.14376020431519) + 0.614905160627783*std::sin(0.60919988155365*x_104 - 7.1910400390625) - 0.0140650456171529*std::sin(0.640159845352173*x_104 - 7.17999982833862) + 0.0850010363819691*std::sin(0.263999968767166*x_105 + 1.85087990760803) + 2.20971355565381*std::sin(0.319519847631454*x_105 + 1.92879974842072) + 0.233131150787468*std::sin(0.355839848518372*x_105 - 7.42432022094727) + 0.0545038702526561*std::sin(0.357599824666977*x_105 - 7.44007968902588) - 0.190963527302865*std::sin(0.187360003590584*x_106 - 7.61688041687012) + 0.0366089185971414*std::sin(0.432319849729538*x_106 + 5.221360206604) + 1.89241899974855*std::sin(0.299039930105209*x_107 + 5.11175966262817) + 7.00765671851988*std::sin(0.363919854164124*x_107 - 7.4172797203064) - 0.0521162695031752*std::sin(0.44327986240387*x_107 + 5.22464036941528) - 0.0229222439729628*std::sin(0.347679853439331*x_108 + 5.14847993850708) + 0.817800249381144*std::sin(0.663199841976166*x_108 + 2.2377598285675) - 0.017871560373307*std::sin(0.345519840717316*x_109 + 5.15944004058838) + 0.256872916565145*std::sin(0.375519841909409*x_110 + 5.1691198348999) - 0.00793503539758904*std::sin(0.590079843997955*x_110 - 7.21264028549194) - 4.04126004754414*std::sin(0.3572798371315*x_111 - 7.43255996704102) + 0.0211537870315655*std::sin(0.401119828224182*x_111 - 4.20544004440308) + 0.306261816625497*std::sin(0.439599871635437*x_111 - 1.17359983921051) - 0.00342959403287534*std::sin(0.456559866666794*x_111 + 8.23095989227295) + 0.322367499469584*std::sin(0.473359853029251*x_111 + 2.04543972015381) + 0.0516932491790567*std::sin(0.496959865093231*x_111 - 4.12064027786255) + 2.71610349168179*std::sin(0.198719993233681*x_112 + 4.99071979522705) - 0.0919444029452405*std::sin(0.353759855031967*x_112 - 7.41695976257324) + 0.0122152875982535*std::sin(0.411039859056473*x_112 - 0.981599867343903) + 0.475409984375794*std::sin(0.48583984375*x_112 + 5.23848009109497) - 0.0159770348449626*std::sin(0.507519841194153*x_112 - 1.01695990562439) + 2.99747988801456*std::sin(0.304399937391281*x_113 - 7.4966402053833) + 2.75465276606713*std::sin(0.345999836921692*x_113 - 7.43743991851807) + 0.116045526392062*std::sin(0.268559962511063*x_114 - 7.53224039077759) + 4.96641779664573*std::sin(0.269199967384338*x_114 - 7.52320003509521) - 0.745177843672519*std::sin(0.367759823799133*x_114 - 7.42456007003784) + 0.0702054272813765*std::sin(0.429439842700958*x_114 + 5.22695970535278) + 0.00514147411712814*std::sin(0.468559861183167*x_114 - 4.1592001914978) - 0.0527919877787276*std::sin(0.576479852199554*x_114 - 7.21895980834961) - 0.229133570529543*std::sin(0.665199875831604*x_114 + 5.43255996704102) + 0.144475610655088*std::sin(0.302079945802689*x_115 + 5.103919506073) - 1.98728320218763*std::sin(0.325759828090668*x_115 - 7.45439958572388) - 5.9272012624769*std::sin(0.416079849004745*x_115 + 5.22344017028809) - 0.0960115564500146*std::sin(0.48447984457016*x_115 - 4.12936019897461) + 0.0115751322944628*std::sin(0.534799814224243*x_115 + 5.36311960220337) + 0.299380879311859*std::sin(0.435039848089218*x_116 + 8.42255973815918) - 1.95348162761308*std::sin(0.49839985370636*x_116 - 4.12344026565552) + 0.0721940258810154*std::sin(0.243599966168404*x_117 - 1.35351991653442) + 0.576832369762838*std::sin(0.376959830522537*x_117 + 1.97719979286194) + 0.0815812559811413*std::sin(0.378399848937988*x_117 + 5.1756796836853) + 4.57353532220807*std::sin(0.400079846382141*x_117 - 4.1864800453186) - 0.109128824291981*std::sin(0.616959869861603*x_117 - 3.99599981307983) - 1.03646234295449*std::sin(0.191840007901192*x_118 + 1.78999984264374) + 1.57996142235126*std::sin(0.408879846334457*x_118 + 5.20247983932495) - 0.0863043546912698*std::sin(0.419359862804413*x_118 + 5.21727991104126) + 0.0170465104093451*std::sin(0.289599925279617*x_119 - 4.28279972076416) - 0.808262263945698*std::sin(0.340479850769043*x_119 + 5.15120029449463) + 9.75359777872671*std::sin(0.34895983338356*x_119 + 5.15208005905151) + 0.0393962240150976*std::sin(0.366079837083817*x_119 - 7.41511964797974) - 0.449350356629835*std::sin(0.434239864349365*x_119 + 1.99407982826233) + 0.54026207596034*std::sin(0.35471984744072*x_12 - 1.03167986869812) + 0.00744954371550344*std::sin(0.328399837017059*x_120 + 1.94799983501434) - 0.0675931737547381*std::sin(0.36695984005928*x_120 + 5.15912008285522) - 0.0221468848327834*std::sin(0.427679866552353*x_120 + 5.2294397354126) - 5.01137374925058*std::sin(0.211919993162155*x_14 - 4.38903999328613) - 0.00659141163259557*std::sin(0.272799968719482*x_16 + 5.08839988708496) - 0.0689784754696133*std::sin(0.368559837341309*x_16 + 5.15863990783691) + 0.377303881561333*std::sin(0.369679838418961*x_16 + 5.18168020248413) + 0.0573098301983974*std::sin(0.427279859781265*x_18 - 0.954639852046967) - 0.0554543417287705*std::sin(0.348479837179184*x_20 - 4.25511980056763) + 2.35523258189968*std::sin(0.361199855804443*x_20 + 5.16968011856079) - 1.00486032982824*std::sin(0.357999831438065*x_21 + 8.36407947540283) + 3.49487210606874*std::sin(0.209600001573563*x_22 - 7.57504034042358) + 0.00842177194149255*std::sin(0.502079844474792*x_22 + 2.10895967483521) + 0.0157269411876582*std::sin(0.589439868927002*x_22 - 7.22200012207031) - 0.0716835313029675*std::sin(0.162880018353462*x_24 + 4.93567991256714) - 0.0252350983484977*std::sin(0.182560011744499*x_24 + 4.98351955413818) - 0.0634513052517518*std::sin(0.190160006284714*x_24 - 7.60288000106812) - 0.636333424851347*std::sin(0.338639855384827*x_24 - 4.25832033157349) - 0.0121266867850065*std::sin(0.46111986041069*x_25 - 4.13752031326294) - 0.111232343105898*std::sin(0.186080008745193*x_26 - 7.6005597114563) + 0.288051941915069*std::sin(0.137440040707588*x_27 + 4.9017596244812) + 6.63167390918098*std::sin(0.171120017766953*x_27 - 7.6241602897644) + 0.331391190733127*std::sin(0.301679939031601*x_27 + 5.12080001831055) + 1.59658037846663*std::sin(0.303999930620193*x_27 + 5.13247966766357) + 0.138367178955576*std::sin(0.319839835166931*x_28 - 4.28064012527466) - 1.83671968781645*std::sin(0.320079833269119*x_28 - 4.28864002227783) + 6.98695741871869*std::sin(0.322399854660034*x_28 - 4.28247976303101) + 0.024373265271109*std::sin(0.326319843530655*x_28 + 5.13312005996704) - 0.886386663507986*std::sin(0.331519842147827*x_28 - 4.27248001098633) - 0.0266565221811915*std::sin(0.33247983455658*x_28 - 4.26847982406616) + 0.0506688101261606*std::sin(0.285919934511185*x_3 + 5.08111953735352) + 0.677124862957541*std::sin(0.294319927692413*x_3 + 5.10839986801147) - 2.53071778393593*std::sin(0.307759910821915*x_3 - 7.5032000541687) + 1.17224035034916*std::sin(0.261199980974197*x_30 - 7.53352022171021) - 1.54845972799031*std::sin(0.27295994758606*x_30 - 4.32471990585327) - 0.344826961964224*std::sin(0.279999971389771*x_30 - 4.29591989517212) - 11.2192199138447*std::sin(0.360319852828979*x_31 + 5.10487985610962) - 4.32931029675196*std::sin(0.255839973688126*x_32 - 4.40239953994751) - 0.0759288788591284*std::sin(0.348479837179184*x_32 + 8.2469596862793) + 0.0884797819880096*std::sin(0.322319835424423*x_33 + 8.19719982147217) - 0.0797974319648724*std::sin(0.351519852876663*x_34 + 2.00215983390808) - 0.00519496712784307*std::sin(0.313519835472107*x_35 + 1.97631978988647) - 0.157853945133148*std::sin(0.315679848194122*x_35 + 1.98063981533051) + 1.82153366203181*std::sin(0.317599833011627*x_35 - 7.43431997299194) - 5.53793278731495*std::sin(0.318319827318192*x_35 - 7.43311977386475) - 0.0723563212881075*std::sin(0.319839835166931*x_35 - 7.42831993103027) - 0.0736286860571814*std::sin(0.319919854402542*x_35 - 7.42831993103027) - 0.148382220548742*std::sin(0.321919858455658*x_35 - 7.42599964141846) - 0.093802104583615*std::sin(0.331519842147827*x_36 - 4.25288009643555) + 0.938800421851465*std::sin(0.352959841489792*x_36 + 5.1637601852417) + 2.11016928653692*std::sin(0.373759835958481*x_36 - 7.41639995574951) - 0.0243938421494809*std::sin(0.380639851093292*x_36 - 7.39903974533081) - 0.400642108788488*std::sin(0.393519848585129*x_36 - 4.2052001953125) - 0.0164882036100279*std::sin(0.418559849262238*x_36 + 5.22079992294312) - 4.59489039634836*std::sin(0.293359935283661*x_37 + 5.09615993499756) + 0.114052566634457*std::sin(0.298719942569733*x_37 - 7.50471973419189) - 1.19456481414862*std::sin(0.36303985118866*x_37 - 4.24047994613647) + 0.419709236058323*std::sin(0.364959836006165*x_37 - 7.42208003997803) - 1.19675907115482*std::sin(0.401439845561981*x_37 - 4.20695972442627) - 0.0532484828761732*std::sin(0.48039984703064*x_38 + 5.25888013839722) + 0.0463132845217286*std::sin(0.665279865264893*x_38 + 2.20815992355347) + 1.77075719373978*std::sin(0.19743999838829*x_39 + 4.99631977081299) + 0.855724749534009*std::sin(0.350079834461212*x_39 + 5.16296005249023) + 0.29881259451338*std::sin(0.334239840507507*x_40 - 4.27408027648926) + 0.181570215639846*std::sin(0.390239834785461*x_40 + 8.37495994567871) + 0.0507408361180749*std::sin(0.312159925699234*x_41 + 1.89567983150482) + 1.46888205998113*std::sin(0.375519841909409*x_41 + 5.17112016677856) - 1.28997135277608*std::sin(0.406959861516953*x_41 - 7.39175987243652) + 0.0876752972524714*std::sin(0.431519865989685*x_41 - 7.38671970367432) - 6.84960229825549*std::sin(0.121520057320595*x_42 + 1.70983994007111) - 1.65661535873911*std::sin(0.369279831647873*x_43 - 7.41183996200562) - 0.0585248226585464*std::sin(0.380639851093292*x_43 - 4.22176027297974) - 0.0315307888364591*std::sin(0.383359849452972*x_43 - 7.40655994415283) + 0.480842654266214*std::sin(0.440879851579666*x_43 - 7.37831974029541) + 4.07804712614745*std::sin(0.359359860420227*x_44 + 5.16416025161743) - 0.198023925260526*std::sin(0.407279849052429*x_46 + 5.21623992919922) + 1.0883692249206*std::sin(0.585599839687347*x_46 - 7.21920013427734) - 0.00886336627776942*std::sin(0.645839810371399*x_46 + 5.4171199798584) + 20.2779790622791*std::sin(0.208159998059273*x_47 - 7.59176015853882) - 1.44812083034954*std::sin(0.260319977998734*x_47 + 1.85655987262726) + 0.0406404842220378*std::sin(0.439279854297638*x_47 - 4.15232038497925) + 0.304555997628373*std::sin(0.424719870090485*x_48 - 4.17040014266968) + 0.381844309759231*std::sin(0.259919971227646*x_49 + 1.85903990268707) - 0.01729043599841*std::sin(0.437279850244522*x_49 - 7.35431957244873) + 3.69810575591103*std::sin(0.191200003027916*x_50 + 4.98799991607666) + 1.98210093384465*std::sin(0.321759849786758*x_50 - 7.47687959671021) + 5.90623592930029*std::sin(0.36559984087944*x_51 - 4.23184013366699) + 5.05610317589593*std::sin(0.212960004806519*x_53 + 5.00816011428833) + 5.47012447943933*std::sin(0.347519844770432*x_53 + 5.15128040313721) + 0.0702227356765535*std::sin(0.359999865293503*x_53 - 4.24272012710571) + 0.000322118198310148*std::sin(0.889279901981354*x_53 - 3.95743989944458) - 0.290793080336833*std::sin(0.319359838962555*x_54 + 1.90071976184845) - 0.790657706153386*std::sin(0.417919874191284*x_54 - 7.38679981231689) - 0.0981985887300651*std::sin(0.487039864063263*x_54 - 1.10911989212036) - 0.0267651535007506*std::sin(0.658959865570068*x_54 - 3.96943998336792) - 1.3131142817959*std::sin(0.348079830408096*x_55 + 5.15960025787354) + 5.05618523578156*std::sin(0.403119832277298*x_55 + 8.38576030731201) + 0.0967729274302837*std::sin(0.441839843988419*x_55 - 4.14991998672485) - 0.128418115675518*std::sin(0.465039849281311*x_55 + 5.25047969818115) + 4.68858668919021*std::sin(0.322559833526611*x_56 + 1.92327988147736) - 0.241264210392029*std::sin(0.406159847974777*x_56 + 5.19504022598267) - 4.91790580384961*std::sin(0.428879857063293*x_57 - 4.16879987716675) + 0.0515966065326603*std::sin(0.448399841785431*x_57 - 4.15232038497925) - 0.597412457780866*std::sin(0.553839862346649*x_57 + 5.35767984390259) - 0.00531914248076283*std::sin(0.853919863700867*x_57 + 5.62479972839355) - 0.076914812734767*std::sin(0.170960009098053*x_58 + 4.96247959136963) + 0.908636433664923*std::sin(0.209440007805824*x_58 + 5.00848007202148) + 0.632133180871322*std::sin(0.266239941120148*x_58 - 7.51327991485596) + 2.48856543284724*std::sin(0.2743199467659*x_58 + 5.07583951950073) + 0.0603890813380423*std::sin(0.348079830408096*x_58 + 5.15759992599487) + 5.29146962136908*std::sin(0.42223984003067*x_58 - 4.189040184021) + 0.0166311674916174*std::sin(0.462799847126007*x_58 + 5.25392007827759) - 0.13963245215659*std::sin(0.168560013175011*x_59 - 7.63191986083984) + 1.67130501535867*std::sin(0.251999974250793*x_59 - 7.52784013748169) + 0.240247480568451*std::sin(0.203199997544289*x_64 + 1.78175985813141) - 0.120792067780595*std::sin(0.222240000963211*x_64 - 4.36191987991333) + 2.73399827816363*std::sin(0.228959992527962*x_64 - 4.36199951171875) - 0.00467018927817917*std::sin(0.339199841022491*x_64 - 7.4555196762085) - 6.11510605549929*std::sin(0.43495985865593*x_66 + 8.44768047332764) - 14.091295547971*std::sin(0.243759974837303*x_67 - 7.55679988861084) + 17.2834130563651*std::sin(0.247279971837997*x_70 - 7.52800035476685) + 0.0206801411417709*std::sin(0.439999878406525*x_70 - 4.15304040908813) - 0.0315405537272966*std::sin(0.624399840831757*x_70 - 3.97263979911804) + 0.18254747924393*std::sin(0.23063999414444*x_71 + 5.04759979248047) - 0.0188730697432031*std::sin(0.214000001549721*x_72 + 5.00920009613037) + 2.6057121518361*std::sin(0.24959996342659*x_73 + 5.06479978561401) - 5.98297062920491*std::sin(0.342559844255447*x_73 - 4.26151990890503) + 0.0151608106291397*std::sin(0.451039850711823*x_73 - 4.15104007720947) - 1.19887556317595*std::sin(0.123040057718754*x_75 + 4.89031982421875) - 0.0396027113665096*std::sin(0.278559952974319*x_75 + 5.09087991714478) + 0.31089862338626*std::sin(0.409119844436646*x_75 - 7.38631963729858) + 0.417314148641974*std::sin(0.476879835128784*x_75 + 2.08039975166321) - 1.50395152463144*std::sin(0.540319859981537*x_75 + 5.16431999206543) + 2.28882025482043*std::sin(0.238319978117943*x_76 - 7.53840017318726) - 1.17908298161877*std::sin(0.393599838018417*x_78 + 8.3810396194458) + 0.00892656687526626*std::sin(0.486639857292175*x_78 + 5.28744029998779) - 8.02093357554787*std::sin(0.281759947538376*x_79 - 7.4986400604248) + 2.09151375590867*std::sin(0.332239836454391*x_79 + 5.12871980667114) - 1.30730083629803*std::sin(0.355119854211807*x_79 + 1.96583986282349) + 0.178409385434297*std::sin(0.249199971556664*x_8 - 4.33576011657715) - 0.627804279138813*std::sin(0.501679837703705*x_8 - 7.30711984634399) + 0.102048993676509*std::sin(0.389359831809998*x_81 + 8.37271976470947) + 17.0326648085075*std::sin(0.214159995317459*x_82 - 7.57696008682251) - 0.448608292151556*std::sin(0.197359994053841*x_83 + 5.00008010864258) - 0.0788657431655489*std::sin(0.201599985361099*x_83 + 5.0053596496582) - 0.0158871125191394*std::sin(0.263119965791702*x_83 + 1.87455987930298) + 0.0932012684616758*std::sin(0.319679915904999*x_83 - 7.46343994140625) + 1.43095706898398*std::sin(0.320559918880463*x_83 - 7.46808004379272) - 3.30502943745352*std::sin(0.322239845991135*x_83 - 7.4730396270752) + 1.28132846355967*std::sin(0.393679857254028*x_83 - 1.19831991195679) - 0.544574452818428*std::sin(0.140080034732819*x_84 - 7.67984008789063) - 0.825200021639979*std::sin(0.179360002279282*x_84 + 1.77599990367889) + 3.00171676707858*std::sin(0.23871998488903*x_84 - 7.55600023269653) - 0.103261020834488*std::sin(0.278079956769943*x_84 + 5.09272003173828) + 15.4446714580747*std::sin(0.278479933738708*x_84 - 7.49608039855957) + 0.440137975228821*std::sin(0.187040001153946*x_85 + 4.98767995834351) - 0.0333953529083958*std::sin(0.19064000248909*x_85 - 7.61648035049438) + 0.134483094666924*std::sin(0.221919998526573*x_85 - 7.56135988235474) + 0.615897179704759*std::sin(0.230239987373352*x_85 - 7.55408048629761) + 0.0705135976370106*std::sin(0.524639844894409*x_86 - 7.27040004730225) + 0.439449539795854*std::sin(0.402799844741821*x_87 + 5.20991992950439) - 0.842611891629339*std::sin(0.417919844388962*x_87 - 4.18951988220215) - 0.0225684358837798*std::sin(0.499039828777313*x_87 - 4.11488008499146) + 0.00624497186867373*std::sin(0.87447988986969*x_87 - 0.751359879970551) + 0.0508852396663588*std::sin(0.219119995832443*x_89 + 1.8155198097229) - 0.294647844696865*std::sin(0.41023987531662*x_90 - 7.39207983016968) + 0.120380691762409*std::sin(0.414639860391617*x_90 - 0.994639813899994) - 0.0279443631888725*std::sin(0.505279839038849*x_90 - 4.09320020675659) - 0.0182948112864616*std::sin(0.337039858102798*x_92 + 5.18400001525879) - 3.63364064806913*std::sin(0.341039836406708*x_92 + 5.20991992950439) - 0.24945255159888*std::sin(0.360079854726791*x_92 + 1.97791981697083) - 2.99856536415479*std::sin(0.360879838466644*x_92 + 2.00343990325928) - 0.103273525390199*std::sin(0.363839834928513*x_92 - 7.38535976409912) - 2.21672385684513*std::sin(0.365199834108353*x_92 + 1.99775981903076) - 0.0278571189044521*std::sin(0.381279855966568*x_92 + 1.97519981861115) + 0.00766148970438592*std::sin(0.401679873466492*x_92 - 7.59008026123047) + 0.203351036371178*std::sin(0.374559849500656*x_94 - 1.18543982505798) - 0.202974134616349*std::sin(0.376239836215973*x_94 + 1.98399984836578) + 1.16619451116392*std::sin(0.386319845914841*x_94 - 7.40639972686768) + 0.674761424389653*std::sin(0.404079854488373*x_94 - 4.21031999588013) + 0.0370216826644996*std::sin(0.367999851703644*x_95 + 1.98935985565186) + 2.63779762391714*std::sin(0.382479846477509*x_95 - 7.39607954025269) - 0.00826323479940599*std::sin(0.376959830522537*x_96 - 4.22176027297974) - 0.448429127846923*std::sin(0.386959820985794*x_96 - 4.2021598815918) - 0.0334042628756173*std::sin(0.396319836378098*x_96 + 5.20240020751953) + 3.96959115269181*std::sin(0.398799866437912*x_96 - 7.3931999206543) - 0.437673436668139*std::sin(0.411679863929749*x_96 + 1.98543977737427) - 0.0504096662151953*std::sin(0.326879858970642*x_97 + 5.13624000549316) - 2.37034454910504*std::sin(0.339759826660156*x_97 + 5.16359996795654) - 0.0121375502348084*std::sin(0.362479835748672*x_97 - 4.41720008850098) + 1.98980436669718*std::sin(0.403599858283997*x_97 + 5.19040012359619) - 0.117323332634817*std::sin(0.518239855766296*x_97 + 2.16407990455627) - 0.00811241969496895*std::sin(0.395679831504822*x_98 - 4.19135999679565) - 0.0271455013482277*std::sin(0.406559854745865*x_98 - 7.38751983642578) - 0.0390908306743398*std::sin(0.414239853620529*x_98 - 7.39607954025269) - 0.142889754050028*std::sin(0.430639863014221*x_98 - 7.37799978256226) + 1.63977842259584*std::sin(0.433199852705002*x_98 - 7.38143968582153) - 1.06905603951387*std::sin(0.382719844579697*x_99 - 7.42312002182007) + 0.517376992154764*std::sin(0.398159861564636*x_99 - 7.40983963012695) - 0.257249812445976*std::sin(0.402159839868546*x_99 - 4.20552015304565) - 0.0335927594545279*std::sin(0.403039842844009*x_99 + 5.20864009857178) + 2.21232465461534*std::sin(0.415279865264893*x_99 - 4.19144010543823) + 194.995479755429);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.233736023357095*x_1 - 2.69333186094884*x_10 - 2.38897164181429*x_100 + 16.2208491681815*x_101 - 0.555684676282689*x_102 - 0.859005186530095*x_103 - 0.00231480545587378*x_104 + 2.09964133123017*x_105 - 0.0171265794229282*x_106 - 0.294067477832322*x_107 + 4.35741069678267*x_108 - 2.52549160033502*x_109 - 1.77710383705513*x_11 + 2.86705257087192*x_110 + 0.0117419552487412*x_111 - 0.000741353430102539*x_112 + 0.0750751205109365*x_113 - 0.00341544049572237*x_114 + 2.95027196941731*x_115 + 0.00533692909303515*x_116 - 0.00802603971596267*x_117 - 2.39610983214538*x_118 + 0.00298389562167726*x_119 - 6.98576788651941*x_12 - 0.0733383845701017*x_120 + 0.707737089383193*x_13 - 10.9635641703744*x_14 - 9.40849682995169*x_15 + 1.67651093996564*x_16 - 2.21817438560786*x_17 + 1.51694493797322*x_18 + 4.69250540364818*x_19 - 1.46607829224603*x_2 - 15.993162560238*x_20 - 2.6732280388749*x_21 - 3.49607928728455*x_22 - 9.31452025692624*x_23 + 0.00257287891673609*x_24 + 1.64374684569196*x_25 - 0.105043475862619*x_26 + 0.104196379383653*x_27 + 0.00332987254222898*x_28 + 1.88796727990184*x_29 - 4.5826007309387*x_3 + 0.0672468812085778*x_30 + 2.93452121886945*x_31 - 7.86167314335208*x_32 + 6.07182063976183*x_33 + 6.88545433532336*x_34 - 3.71659800502687*x_35 - 0.0114389279621658*x_36 - 0.0200832493886391*x_37 + 2.56331265910606*x_38 + 0.349559625151715*x_39 + 0.41055296308359*x_4 - 1.02918007907518*x_40 - 0.00455599422855317*x_41 + 1.44736052836438*x_42 - 0.204602568817444*x_43 - 8.5773422683397*x_44 + 1.96734515784854*x_45 - 6.97385348883004*x_46 - 0.158260128065654*x_47 + 0.246622217197466*x_48 + 1.27367935450411*x_49 + 2.86814415389789*x_5 - 0.038057888429008*x_50 + 1.93532293406603*x_51 + 3.40568863214593*x_52 - 1.83562978833335*x_53 + 0.34694056286351*x_54 + 3.68698920039562*x_55 - 1.98842255803147*x_56 + 0.0798006759170801*x_57 + 0.0110355304367343*x_58 + 0.00877670685719668*x_59 + 1.45414217977249*x_6 - 0.211307322006485*x_60 + 9.88751406033584*x_61 - 127.818179888607*x_62 - 1.16778065526799*x_63 + 1.49883769289591*x_64 + 4.63619788505999*x_65 + 0.000281464592067868*x_66 - 2.31709063186126*x_67 - 1.12907628857484*x_68 - 2.60229629592851*x_69 - 2.21890267749985*x_7 - 0.0598249692173012*x_70 - 4.63295064427972*x_71 - 2.65118566751116*x_72 + 0.0150201871037084*x_73 - 14.4015759207316*x_74 + 0.01028039345413*x_75 + 0.292430584645622*x_76 + 10.5981768880196*x_77 - 4.13205869626786*x_78 + 0.0084106336827141*x_79 + 9.7491456455053*x_8 - 1.4718850348208*x_80 + 0.0485881145098831*x_81 - 1.90105395147792*x_82 - 0.00913154209572648*x_83 - 0.0438032566359555*x_84 + 0.089342655718766*x_85 + 2.00070139236522*x_86 - 0.00299838904405913*x_87 - 0.00565952190574697*x_88 - 4.39099877518635*x_89 - 13.0291491927003*x_9 + 3.16054750552082*x_90 + 1.8980708861441*x_91 + 0.00203104556018997*x_92 + 18.2795196677364*x_93 + 0.214672878753784*x_94 - 1.79579799277082*x_95 - 0.0382397389608424*x_96 - 8.91952310175289*x_97 + 1.50355724670039*x_98 + 0.042364282176036*x_99 - 0.0532178834152916*std::pow(-7.36319971084595*x_106 - 7.55671977996826, 2) - 3.63953197361603e-5*std::pow(-5.29512023925781*x_108 - 7.73583984375, 2) - 0.271209765756844*std::pow(-0.582399845123291*x_108 - 0.778079867362976, 2) - 1.56573086224174e-6*std::pow(-7.56576013565063*x_109 - 9.54831981658936, 2) + 0.0014309012821762*std::pow(-6.31343984603882*x_11 - 9.7729606628418, 2) + 0.026700387837428*std::pow(-8.15095996856689*x_116 - 8.55615997314453, 2) - 7.31580291445915e-5*std::pow(-7.33599996566772*x_118 - 8.55144023895264, 2) - 0.0129263363019163*std::pow(-6.34631967544556*x_120 - 8.5252799987793, 2) + 5.43498424110496e-5*std::pow(-4.97463989257813*x_120 - 5.7960000038147, 2) - 3.82331879804114e-6*std::pow(-5.00879955291748*x_13 - 7.81375980377197, 2) - 2.38068604793502e-5*std::pow(-5.29879999160767*x_15 - 5.5019998550415, 2) + 3.54189285993024e-6*std::pow(-5.08487987518311*x_15 - 7.32096004486084, 2) - 0.00108086098671301*std::pow(-8.73536014556885*x_18 - 9.75536060333252, 2) + 2.9440100639154e-6*std::pow(-6.31343984603882*x_19 - 9.57096099853516, 2) - 0.00235297844044913*std::pow(-7.01279973983765*x_23 - 9.21599960327148, 2) + 1.03765551106078e-5*std::pow(-6.67776012420654*x_24 - 9.96127986907959, 2) - 0.0374056490473495*std::pow(-4.61759996414185*x_24 - 6.62983989715576, 2) + 5.70682958486419e-5*std::pow(-7.44783973693848*x_27 - 8.82520008087158, 2) + 0.0739186624134127*std::pow(-5.21519994735718*x_39 - 6.82528018951416, 2) + 1.09844539521528e-6*std::pow(-6.29800033569336*x_4 - 9.95495986938477, 2) - 0.000464972155593921*std::pow(-4.83800029754639*x_44 - 6.05071973800659, 2) - 0.00014950000061003*std::pow(-5.75367975234985*x_47 - 7.59768009185791, 2) - 8.97319404996097e-5*std::pow(-6.32687997817993*x_5 - 9.3877592086792, 2) - 2.13080022724169e-6*std::pow(-7.51128005981445*x_50 - 8.1159200668335, 2) - 0.000852593578264324*std::pow(-7.70344018936157*x_59 - 9.92232036590576, 2) + 0.000198908300607984*std::pow(-6.26208019256592*x_59 - 9.90112018585205, 2) - 3.69181533347506e-6*std::pow(-4.89711999893188*x_6 - 7.75040006637573, 2) - 1.49455748822816e-5*std::pow(-8.05943965911865*x_64 - 9.632080078125, 2) + 6.86962516478746e-5*std::pow(-3.31583976745605*x_66 - 4.76936006546021, 2) - 0.00262530838049299*std::pow(-5.33400011062622*x_67 - 5.12992000579834, 2) - 0.000135801046847011*std::pow(-4.89463996887207*x_7 - 6.54287958145142, 2) + 3.8295568503245e-6*std::pow(-6.32664012908936*x_70 - 8.89144039154053, 2) - 0.0609516973154299*std::pow(-5.72743988037109*x_70 - 7.97160005569458, 2) - 3.10043240056225e-6*std::pow(-6.03951978683472*x_72 - 8.25783920288086, 2) + 6.77127380737669e-5*std::pow(-5.92343997955322*x_72 - 7.55639982223511, 2) - 0.000744149556445935*std::pow(-5.51567983627319*x_72 - 6.31112003326416, 2) - 0.0017779147264807*std::pow(-5.3295202255249*x_72 - 7.79544019699097, 2) + 0.00101565758393271*std::pow(-5.7279200553894*x_73 - 7.8930401802063, 2) - 2.2446422386117e-6*std::pow(-7.48496007919312*x_74 - 9.9323205947876, 2) - 0.00467624387297316*std::pow(-5.3471999168396*x_74 - 6.92751979827881, 2) - 2.56766525084149e-5*std::pow(-6.85536003112793*x_77 - 8.66800022125244, 2) + 0.00396520452569862*std::pow(-4.26240015029907*x_78 - 5.81343936920166, 2) + 0.0462799837301779*std::pow(-7.15487957000732*x_81 - 9.58255958557129, 2) + 0.000149245423869147*std::pow(-8.56280040740967*x_84 - 8.97383975982666, 2) - 2.84210378798849e-5*std::pow(-8.34360027313232*x_84 - 8.74335956573486, 2) - 1.45704655193286e-5*std::pow(-7.32399988174438*x_84 - 6.70928001403809, 2) + 3.52364455965214e-6*std::pow(-5.07727956771851*x_86 - 7.30615997314453, 2) - 0.00261692156860531*std::pow(-4.13991975784302*x_87 - 5.91967964172363, 2) + 0.0385667105626412*std::pow(-8.75607967376709*x_88 - 9.97624015808105, 2) + 9.79280472029321e-6*std::pow(-8.0033597946167*x_88 - 9.20728015899658, 2) + 0.000161138973593368*std::pow(-2.1943998336792*x_88 - 2.17791986465454, 2) + 0.00115037789819988*std::pow(-3.1781599521637*x_90 - 4.56775999069214, 2) - 9.76433225940181e-6*std::pow(-5.24519968032837*x_99 - 6.02455997467041, 2) - 0.014788441355557*std::exp(0.702079832553864*x_1) + 7.61401888465073e-5*std::exp(1.08351981639862*x_1) + 0.000381566972822802*std::exp(1.19423997402191*x_1) - 0.00775377006013829*std::exp(1.22735989093781*x_1) - 2.00333001905834e-5*std::exp(1.28807985782623*x_1) - 0.000994398323792183*std::exp(1.19983983039856*x_100) - 0.000277109516644263*std::exp(1.62295985221863*x_100) - 0.0267540850260165*std::exp(0.515199840068817*x_103) - 0.0111540952654312*std::exp(0.528799831867218*x_104) + 0.0197778501109425*std::exp(1.06327986717224*x_104) - 0.0975654239653302*std::exp(0.650879800319672*x_106) + 0.0248073290219162*std::exp(0.665519833564758*x_106) + 0.00129665244442801*std::exp(0.792479872703552*x_106) - 0.335832997727812*std::exp(1.33487987518311*x_106) - 0.266459407108812*std::exp(0.648639798164368*x_109) + 0.24444545313224*std::exp(0.855439901351929*x_110) + 0.001045404493778*std::exp(1.08487975597382*x_110) + 0.000182075004145395*std::exp(1.55039989948273*x_110) + 5.55410335821378e-5*std::exp(1.59975981712341*x_110) + 0.193312439427233*std::exp(0.604959845542908*x_112) - 0.000335923121741945*std::exp(0.914159834384918*x_112) + 0.00160757571411492*std::exp(0.571999847888947*x_24) + 0.0036638478934195*std::exp(0.514479875564575*x_26) - 4.47259538098802*std::exp(0.62559986114502*x_26) + 0.0110321305403533*std::exp(0.643839836120605*x_26) + 0.000837801383186596*std::exp(0.829519867897034*x_26) - 0.0028057505939068*std::exp(0.874719858169556*x_26) + 0.00377605500301249*std::exp(0.913679838180542*x_26) + 14.3331874554623*std::exp(0.491599857807159*x_31) - 0.0284163452029749*std::exp(0.599999845027924*x_31) + 0.00236452469234842*std::exp(0.620239853858948*x_31) - 0.00237586909003263*std::exp(0.647599816322327*x_31) + 0.00250401531190229*std::exp(0.654319822788239*x_31) - 0.202209429699824*std::exp(0.655279815196991*x_31) + 0.0692738711563823*std::exp(0.654959857463837*x_45) - 0.000161375669998332*std::exp(0.825759887695313*x_45) + 0.00111937879464273*std::exp(1.0123997926712*x_45) - 0.0510514249849043*std::exp(1.11879980564117*x_45) + 0.000172815430519067*std::exp(1.23079991340637*x_45) - 0.0720084473855196*std::exp(0.99375981092453*x_6) + 0.00514665936722225*std::exp(0.713119864463806*x_60) - 1.86666555983865*std::exp(0.968719840049744*x_60) + 0.00684712511916268*std::exp(1.24247992038727*x_60) + 6.83762325581047e-5*std::exp(1.45055985450745*x_66) + 0.100352006520133*std::exp(1.66143977642059*x_66) - 0.000414636264949547*std::exp(0.718239843845367*x_70) - 0.00479515325961939*std::exp(0.895999848842621*x_70) - 0.000987077096570572*std::exp(0.875359892845154*x_72) - 0.000983210835570481*std::exp(0.97439980506897*x_74) + 0.00564734817328571*std::exp(1.0343998670578*x_74) + 0.0042879952438742*std::exp(1.24767982959747*x_74) + 4.33863206330294e-5*std::exp(1.71327984333038*x_74) - 0.655949577983408*std::exp(0.599999845027924*x_76) - 0.0132913122212446*std::exp(0.73831981420517*x_77) - 0.00713837709954225*std::exp(0.885519862174988*x_81) - 0.0014820265761705*std::exp(1.09175980091095*x_81) + 0.00960641180034451*std::exp(0.719999849796295*x_87) + 0.00232965835005107*std::sin(0.222879990935326*x_1 - 1.19911992549896) + 0.208443370983215*std::sin(0.184960007667542*x_10 + 1.76799988746643) - 3.55421336184918*std::sin(0.330879837274551*x_10 - 7.47408008575439) + 0.562143565192108*std::sin(0.372159838676453*x_100 - 7.40847969055176) + 0.472031282447677*std::sin(0.155280038714409*x_102 - 7.65199995040894) - 1.57129747531778*std::sin(0.298239946365356*x_102 - 7.52088022232056) - 0.000952864745155653*std::sin(0.342959851026535*x_102 - 7.44087982177734) + 0.0315324433501105*std::sin(0.371279835700989*x_102 + 1.97439980506897) - 0.00586702816249734*std::sin(0.430479854345322*x_102 - 4.16527986526489) - 0.666031019675835*std::sin(0.445199847221375*x_102 + 5.23176002502441) - 0.0036164379031427*std::sin(0.314079850912094*x_103 - 7.47591972351074) + 40.7029248301021*std::sin(0.465919852256775*x_103 - 7.36799955368042) + 61.0064668267738*std::sin(0.487919867038727*x_104 - 4.14376020431519) - 1.17750750399204*std::sin(0.60919988155365*x_104 - 7.1910400390625) + 0.000368451295555141*std::sin(0.640159845352173*x_104 - 7.17999982833862) + 0.0178860127240235*std::sin(0.263999968767166*x_105 + 1.85087990760803) - 0.720127559226983*std::sin(0.319519847631454*x_105 + 1.92879974842072) + 0.111982500865138*std::sin(0.355839848518372*x_105 - 7.42432022094727) - 0.00142779640777486*std::sin(0.357599824666977*x_105 - 7.44007968902588) - 0.0401827580526769*std::sin(0.187360003590584*x_106 - 7.61688041687012) - 0.000959015978557476*std::sin(0.432319849729538*x_106 + 5.221360206604) - 96.6618110992013*std::sin(0.299039930105209*x_107 + 5.11175966262817) - 2.28373796037793*std::sin(0.363919854164124*x_107 - 7.4172797203064) + 0.00136525024807084*std::sin(0.44327986240387*x_107 + 5.22464036941528) - 0.0486006198767233*std::sin(0.347679853439331*x_108 + 5.14847993850708) - 0.26651440681768*std::sin(0.663199841976166*x_108 + 2.2377598285675) - 0.0378919670051281*std::sin(0.345519840717316*x_109 + 5.15944004058838) - 0.491896647149579*std::sin(0.375519841909409*x_110 + 5.1691198348999) + 0.000207868083197117*std::sin(0.590079843997955*x_110 - 7.21264028549194) + 1.31701356802258*std::sin(0.3572798371315*x_111 - 7.43255996704102) - 0.000554149659363533*std::sin(0.401119828224182*x_111 - 4.20544004440308) - 0.586473509011665*std::sin(0.439599871635437*x_111 - 1.17359983921051) + 0.00464710641244684*std::sin(0.456559866666794*x_111 + 8.23095989227295) - 16.4660291100391*std::sin(0.473359853029251*x_111 + 2.04543972015381) + 0.024830398260217*std::sin(0.496959865093231*x_111 - 4.12064027786255) - 138.734330332611*std::sin(0.198719993233681*x_112 + 4.99071979522705) + 0.00240859754787452*std::sin(0.353759855031967*x_112 - 7.41695976257324) + 0.0696203950404817*std::sin(0.411039859056473*x_112 - 0.981599867343903) - 0.910382380762123*std::sin(0.48583984375*x_112 + 5.23848009109497) - 0.0338751213961896*std::sin(0.507519841194153*x_112 - 1.01695990562439) - 153.106597823958*std::sin(0.304399937391281*x_113 - 7.4966402053833) - 5.27499931798413*std::sin(0.345999836921692*x_113 - 7.43743991851807) - 0.00303995633618063*std::sin(0.268559962511063*x_114 - 7.53224039077759) - 1.61851490517817*std::sin(0.269199967384338*x_114 - 7.52320003509521) + 38.0625220788598*std::sin(0.367759823799133*x_114 - 7.42456007003784) + 0.0147727041821877*std::sin(0.429439842700958*x_114 + 5.22695970535278) - 0.00696670717003317*std::sin(0.468559861183167*x_114 - 4.1592001914978) - 0.0253581676971739*std::sin(0.576479852199554*x_114 - 7.21895980834961) + 0.43877741803235*std::sin(0.665199875831604*x_114 + 5.43255996704102) + 0.0177066994243455*std::sin(0.302079945802689*x_115 + 5.103919506073) + 3.80553137778875*std::sin(0.325759828090668*x_115 - 7.45439958572388) + 1.9316263717863*std::sin(0.416079849004745*x_115 + 5.22344017028809) - 0.0461183079434488*std::sin(0.48447984457016*x_115 - 4.12936019897461) + 0.00243565222629373*std::sin(0.534799814224243*x_115 + 5.36311960220337) - 0.573296915546364*std::sin(0.435039848089218*x_116 + 8.42255973815918) + 0.636623671375147*std::sin(0.49839985370636*x_116 - 4.12344026565552) + 0.411466087963224*std::sin(0.243599966168404*x_117 - 1.35351991653442) - 29.463697822379*std::sin(0.376959830522537*x_117 + 1.97719979286194) - 0.00213712207393122*std::sin(0.378399848937988*x_117 + 5.1756796836853) - 1.49047772286739*std::sin(0.400079846382141*x_117 - 4.1864800453186) + 0.208975331048523*std::sin(0.616959869861603*x_117 - 3.99599981307983) - 0.497855583968678*std::sin(0.191840007901192*x_118 + 1.78999984264374) - 3.02553393589536*std::sin(0.408879846334457*x_118 + 5.20247983932495) + 0.00226084949623402*std::sin(0.419359862804413*x_118 + 5.21727991104126) + 0.0971556976628182*std::sin(0.289599925279617*x_119 - 4.28279972076416) + 1.54777507480664*std::sin(0.340479850769043*x_119 + 5.15120029449463) - 3.17861767381789*std::sin(0.34895983338356*x_119 + 5.15208005905151) - 0.0010320328972585*std::sin(0.366079837083817*x_119 - 7.41511964797974) + 22.9521154119057*std::sin(0.434239864349365*x_119 + 1.99407982826233) - 1.03457035214363*std::sin(0.35471984744072*x_12 - 1.03167986869812) - 0.0100941458488295*std::sin(0.328399837017059*x_120 + 1.94799983501434) + 0.00177068692974906*std::sin(0.36695984005928*x_120 + 5.15912008285522) - 0.0469566737218769*std::sin(0.427679866552353*x_120 + 5.2294397354126) + 9.59648832516997*std::sin(0.211919993162155*x_14 - 4.38903999328613) - 0.01397536347596*std::sin(0.272799968719482*x_16 + 5.08839988708496) + 0.00180697662446275*std::sin(0.368559837341309*x_16 + 5.15863990783691) - 0.722514918187076*std::sin(0.369679838418961*x_16 + 5.18168020248413) + 0.0275282736266489*std::sin(0.427279859781265*x_18 - 0.954639852046967) + 0.00145269518565976*std::sin(0.348479837179184*x_20 - 4.25511980056763) - 4.51013297075281*std::sin(0.361199855804443*x_20 + 5.16968011856079) + 1.92424889982815*std::sin(0.357999831438065*x_21 + 8.36407947540283) - 6.69247616362007*std::sin(0.209600001573563*x_22 - 7.57504034042358) + 0.0178561635283052*std::sin(0.502079844474792*x_22 + 2.10895967483521) - 0.000411986708997615*std::sin(0.589439868927002*x_22 - 7.22200012207031) - 0.15198616943376*std::sin(0.162880018353462*x_24 + 4.93567991256714) + 0.0341936060740438*std::sin(0.182560011744499*x_24 + 4.98351955413818) - 0.361637407382266*std::sin(0.190160006284714*x_24 - 7.60288000106812) + 1.21854137967949*std::sin(0.338639855384827*x_24 - 4.25832033157349) + 0.000317673584455212*std::sin(0.46111986041069*x_25 - 4.13752031326294) + 0.00291386903680003*std::sin(0.186080008745193*x_26 - 7.6005597114563) - 0.007545877494798*std::sin(0.137440040707588*x_27 + 4.9017596244812) - 12.6992685898366*std::sin(0.171120017766953*x_27 - 7.6241602897644) + 0.0406147735218501*std::sin(0.301679939031601*x_27 + 5.12080001831055) - 81.5508357126718*std::sin(0.303999930620193*x_27 + 5.13247966766357) - 0.00362469968005776*std::sin(0.319839835166931*x_28 - 4.28064012527466) + 3.51721103287822*std::sin(0.320079833269119*x_28 - 4.28864002227783) - 2.27699222801574*std::sin(0.322399854660034*x_28 - 4.28247976303101) + 0.138914155147986*std::sin(0.326319843530655*x_28 + 5.13312005996704) + 45.2752483674305*std::sin(0.331519842147827*x_28 - 4.27248001098633) - 0.00560909507936475*std::sin(0.33247983455658*x_28 - 4.26847982406616) + 0.288784242600954*std::sin(0.285919934511185*x_3 + 5.08111953735352) - 1.2966546035458*std::sin(0.294319927692413*x_3 + 5.10839986801147) + 0.824740209505966*std::sin(0.307759910821915*x_3 - 7.5032000541687) - 59.8762088751845*std::sin(0.261199980974197*x_30 - 7.53352022171021) + 2.96521002926134*std::sin(0.27295994758606*x_30 - 4.32471990585327) - 0.16563460282356*std::sin(0.279999971389771*x_30 - 4.29591989517212) + 3.65625193017257*std::sin(0.360319852828979*x_31 + 5.10487985610962) + 8.29037661081081*std::sin(0.255839973688126*x_32 - 4.40239953994751) - 0.0159770392362332*std::sin(0.348479837179184*x_32 + 8.2469596862793) + 0.0186180142480247*std::sin(0.322319835424423*x_33 + 8.19719982147217) + 0.0020903925937911*std::sin(0.351519852876663*x_34 + 2.00215983390808) - 0.0110145683359001*std::sin(0.313519835472107*x_35 + 1.97631978988647) - 0.0758237562321872*std::sin(0.315679848194122*x_35 + 1.98063981533051) - 3.48813067957792*std::sin(0.317599833011627*x_35 - 7.43431997299194) + 1.80476696225553*std::sin(0.318319827318192*x_35 - 7.43311977386475) + 0.00189546348059437*std::sin(0.319839835166931*x_35 - 7.42831993103027) - 0.0154930301055862*std::sin(0.319919854402542*x_35 - 7.42831993103027) - 0.0181854872753983*std::sin(0.321919858455658*x_35 - 7.42599964141846) - 0.0114962356878233*std::sin(0.331519842147827*x_36 - 4.25288009643555) - 1.79774803052945*std::sin(0.352959841489792*x_36 + 5.1637601852417) - 0.687686896784212*std::sin(0.373759835958481*x_36 - 7.41639995574951) + 0.000639026917380393*std::sin(0.380639851093292*x_36 - 7.39903974533081) + 20.4641740773286*std::sin(0.393519848585129*x_36 - 4.2052001953125) - 0.0349589209959624*std::sin(0.418559849262238*x_36 + 5.22079992294312) + 1.49743716671856*std::sin(0.293359935283661*x_37 + 5.09615993499756) - 0.00298774828619156*std::sin(0.298719942569733*x_37 - 7.50471973419189) + 61.0165076689298*std::sin(0.36303985118866*x_37 - 4.24047994613647) + 0.201603645549946*std::sin(0.364959836006165*x_37 - 7.42208003997803) + 2.29172379252216*std::sin(0.401439845561981*x_37 - 4.20695972442627) + 0.00139490998011019*std::sin(0.48039984703064*x_38 + 5.25888013839722) + 0.0222461794852542*std::sin(0.665279865264893*x_38 + 2.20815992355347) - 3.39089670551427*std::sin(0.19743999838829*x_39 + 4.99631977081299) + 0.411039868251548*std::sin(0.350079834461212*x_39 + 5.16296005249023) - 0.00782776612131132*std::sin(0.334239840507507*x_40 - 4.27408027648926) + 0.0872156584879063*std::sin(0.390239834785461*x_40 + 8.37495994567871) + 0.0106769432358121*std::sin(0.312159925699234*x_41 + 1.89567983150482) - 2.81282343823758*std::sin(0.375519841909409*x_41 + 5.17112016677856) + 65.8897248664224*std::sin(0.406959861516953*x_41 - 7.39175987243652) + 0.042114059049006*std::sin(0.431519865989685*x_41 - 7.38671970367432) + 13.1165887391847*std::sin(0.121520057320595*x_42 + 1.70983994007111) + 84.6173288747113*std::sin(0.369279831647873*x_43 - 7.41183996200562) + 0.00153313023772768*std::sin(0.380639851093292*x_43 - 4.22176027297974) - 0.066852786509972*std::sin(0.383359849452972*x_43 - 7.40655994415283) - 0.920785626615759*std::sin(0.440879851579666*x_43 - 7.37831974029541) - 1.32900217580294*std::sin(0.359359860420227*x_44 + 5.16416025161743) - 0.0951190534036391*std::sin(0.407279849052429*x_46 + 5.21623992919922) - 0.354690621087281*std::sin(0.585599839687347*x_46 - 7.21920013427734) + 0.000232186860740871*std::sin(0.645839810371399*x_46 + 5.4171199798584) - 6.60842738227864*std::sin(0.208159998059273*x_47 - 7.59176015853882) + 73.9677535316779*std::sin(0.260319977998734*x_47 + 1.85655987262726) - 0.0010646278349312*std::sin(0.439279854297638*x_47 - 4.15232038497925) - 15.5562453747263*std::sin(0.424719870090485*x_48 - 4.17040014266968) + 0.183415560741357*std::sin(0.259919971227646*x_49 + 1.85903990268707) - 0.0366598448412257*std::sin(0.437279850244522*x_49 - 7.35431957244873) - 7.08165674475012*std::sin(0.191200003027916*x_50 + 4.98799991607666) - 101.242624425299*std::sin(0.321759849786758*x_50 - 7.47687959671021) - 1.9247939413248*std::sin(0.36559984087944*x_51 - 4.23184013366699) - 9.68214256731422*std::sin(0.212960004806519*x_53 + 5.00816011428833) - 1.78266878979293*std::sin(0.347519844770432*x_53 + 5.15128040313721) - 0.00183957156213545*std::sin(0.359999865293503*x_53 - 4.24272012710571) + 0.000682967345165333*std::sin(0.889279901981354*x_53 - 3.95743989944458) - 0.139679902322801*std::sin(0.319359838962555*x_54 + 1.90071976184845) + 1.51406337382864*std::sin(0.417919874191284*x_54 - 7.38679981231689) + 5.01583076226508*std::sin(0.487039864063263*x_54 - 1.10911989212036) - 0.00563195340258717*std::sin(0.658959865570068*x_54 - 3.96943998336792) + 2.51453723178255*std::sin(0.348079830408096*x_55 + 5.15960025787354) - 1.64776937876256*std::sin(0.403119832277298*x_55 + 8.38576030731201) + 0.0464840258072721*std::sin(0.441839843988419*x_55 - 4.14991998672485) - 0.0157387185601568*std::sin(0.465039849281311*x_55 + 5.25047969818115) - 1.52797202156443*std::sin(0.322559833526611*x_56 + 1.92327988147736) + 0.462006885567994*std::sin(0.406159847974777*x_56 + 5.19504022598267) + 1.60270524384169*std::sin(0.428879857063293*x_57 - 4.16879987716675) - 0.00135163703273191*std::sin(0.448399841785431*x_57 - 4.15232038497925) + 30.5148966217294*std::sin(0.553839862346649*x_57 + 5.35767984390259) - 0.0112778496766113*std::sin(0.853919863700867*x_57 + 5.62479972839355) - 0.163077732748195*std::sin(0.170960009098053*x_58 + 4.96247959136963) - 46.4117319264078*std::sin(0.209440007805824*x_58 + 5.00848007202148) + 0.30363962188107*std::sin(0.266239941120148*x_58 - 7.51327991485596) - 4.76545760058535*std::sin(0.2743199467659*x_58 + 5.07583951950073) - 0.00158196680352399*std::sin(0.348079830408096*x_58 + 5.15759992599487) - 1.72444663400401*std::sin(0.42223984003067*x_58 - 4.189040184021) + 0.0034995487823668*std::sin(0.462799847126007*x_58 + 5.25392007827759) + 0.00365784507914385*std::sin(0.168560013175011*x_59 - 7.63191986083984) - 85.3676536249175*std::sin(0.251999974250793*x_59 - 7.52784013748169) + 0.11540076737806*std::sin(0.203199997544289*x_64 + 1.78175985813141) - 0.0148040823453742*std::sin(0.222240000963211*x_64 - 4.36191987991333) - 5.23544717880114*std::sin(0.228959992527962*x_64 - 4.36199951171875) + 0.0063281153203347*std::sin(0.339199841022491*x_64 - 7.4555196762085) + 1.99286300565681*std::sin(0.43495985865593*x_66 + 8.44768047332764) + 4.5922378687241*std::sin(0.243759974837303*x_67 - 7.55679988861084) - 5.63252283425909*std::sin(0.247279971837997*x_70 - 7.52800035476685) + 0.0438468275537809*std::sin(0.439999878406525*x_70 - 4.15304040908813) - 0.0151502279859367*std::sin(0.624399840831757*x_70 - 3.97263979911804) - 0.00478205738243216*std::sin(0.23063999414444*x_71 + 5.04759979248047) - 0.0400154055413686*std::sin(0.214000001549721*x_72 + 5.00920009613037) - 133.095712859119*std::sin(0.24959996342659*x_73 + 5.06479978561401) + 1.94980115187883*std::sin(0.342559844255447*x_73 - 4.26151990890503) - 0.000397156217620816*std::sin(0.451039850711823*x_73 - 4.15104007720947) - 0.575869347948851*std::sin(0.123040057718754*x_75 + 4.89031982421875) + 0.00103744208925221*std::sin(0.278559952974319*x_75 + 5.09087991714478) - 0.59535272340919*std::sin(0.409119844436646*x_75 - 7.38631963729858) - 21.3157558714081*std::sin(0.476879835128784*x_75 + 2.08039975166321) + 0.490125490635409*std::sin(0.540319859981537*x_75 + 5.16431999206543) - 116.909368982701*std::sin(0.238319978117943*x_76 - 7.53840017318726) + 2.25787511242865*std::sin(0.393599838018417*x_78 + 8.3810396194458) + 0.0508765026785101*std::sin(0.486639857292175*x_78 + 5.28744029998779) + 2.61395659346988*std::sin(0.281759947538376*x_79 - 7.4986400604248) - 4.00512680649921*std::sin(0.332239836454391*x_79 + 5.12871980667114) + 66.7748878577411*std::sin(0.355119854211807*x_79 + 1.96583986282349) - 0.00467365488827823*std::sin(0.249199971556664*x_8 - 4.33576011657715) + 1.2022085633003*std::sin(0.501679837703705*x_8 - 7.30711984634399) - 0.195417868515277*std::sin(0.389359831809998*x_81 + 8.37271976470947) - 5.55080603288994*std::sin(0.214159995317459*x_82 - 7.57696008682251) + 0.0117518500074*std::sin(0.197359994053841*x_83 + 5.00008010864258) - 0.167214170192287*std::sin(0.201599985361099*x_83 + 5.0053596496582) + 0.0215270675640462*std::sin(0.263119965791702*x_83 + 1.87455987930298) + 0.0447684107888968*std::sin(0.319679915904999*x_83 - 7.46343994140625) - 73.0910553696484*std::sin(0.320559918880463*x_83 - 7.46808004379272) + 1.07708203892632*std::sin(0.322239845991135*x_83 - 7.4730396270752) - 2.45366924450551*std::sin(0.393679857254028*x_83 - 1.19831991195679) - 0.261581555823341*std::sin(0.140080034732819*x_84 - 7.67984008789063) - 0.101135192866741*std::sin(0.179360002279282*x_84 + 1.77599990367889) - 5.74811246418097*std::sin(0.23871998488903*x_84 - 7.55600023269653) + 0.00270505037398627*std::sin(0.278079956769943*x_84 + 5.09272003173828) - 5.03329199918637*std::sin(0.278479933738708*x_84 - 7.49608039855957) + 0.211416411000238*std::sin(0.187040001153946*x_85 + 4.98767995834351) - 0.0708061066911409*std::sin(0.19064000248909*x_85 - 7.61648035049438) - 0.00352295128000608*std::sin(0.221919998526573*x_85 - 7.56135988235474) - 31.4590673889147*std::sin(0.230239987373352*x_85 - 7.55408048629761) + 0.0338705873570244*std::sin(0.524639844894409*x_86 - 7.27040004730225) - 22.4463971292942*std::sin(0.402799844741821*x_87 + 5.20991992950439) + 1.61355260758182*std::sin(0.417919844388962*x_87 - 4.18951988220215) + 0.000591208138698879*std::sin(0.499039828777313*x_87 - 4.11488008499146) + 0.0355928916954786*std::sin(0.87447988986969*x_87 - 0.751359879970551) + 0.1078888346742*std::sin(0.219119995832443*x_89 + 1.8155198097229) + 0.564233430422707*std::sin(0.41023987531662*x_90 - 7.39207983016968) + 0.0578238080749633*std::sin(0.414639860391617*x_90 - 0.994639813899994) - 0.00588008401821005*std::sin(0.505279839038849*x_90 - 4.09320020675659) - 0.104270323454081*std::sin(0.337039858102798*x_92 + 5.18400001525879) + 1.18417374247756*std::sin(0.341039836406708*x_92 + 5.20991992950439) - 0.119822342406308*std::sin(0.360079854726791*x_92 + 1.97791981697083) + 5.7420777114606*std::sin(0.360879838466644*x_92 + 2.00343990325928) - 0.0126570378507852*std::sin(0.363839834928513*x_92 - 7.38535976409912) + 113.226797415333*std::sin(0.365199834108353*x_92 + 1.99775981903076) + 0.00072975174273602*std::sin(0.381279855966568*x_92 + 1.97519981861115) + 0.0162441840009855*std::sin(0.401679873466492*x_92 - 7.59008026123047) + 0.0976778844416286*std::sin(0.374559849500656*x_94 - 1.18543982505798) - 0.0248761848195153*std::sin(0.376239836215973*x_94 + 1.98399984836578) - 2.23319444352668*std::sin(0.386319845914841*x_94 - 7.40639972686768) - 34.4657612030142*std::sin(0.404079854488373*x_94 - 4.21031999588013) - 0.000969828844687909*std::sin(0.367999851703644*x_95 + 1.98935985565186) - 5.05122853905426*std::sin(0.382479846477509*x_95 - 7.39607954025269) + 0.0111966988091821*std::sin(0.376959830522537*x_96 - 4.22176027297974) + 0.858715614793786*std::sin(0.386959820985794*x_96 - 4.2021598815918) + 0.000875066051586476*std::sin(0.396319836378098*x_96 + 5.20240020751953) - 1.29365726186676*std::sin(0.398799866437912*x_96 - 7.3931999206543) + 22.3556765515328*std::sin(0.411679863929749*x_96 + 1.98543977737427) - 0.106880505622702*std::sin(0.326879858970642*x_97 + 5.13624000549316) + 0.772475885078663*std::sin(0.339759826660156*x_97 + 5.16359996795654) - 0.0691773349889746*std::sin(0.362479835748672*x_97 - 4.41720008850098) - 3.81035926071913*std::sin(0.403599858283997*x_97 + 5.19040012359619) - 0.0563552324685113*std::sin(0.518239855766296*x_97 + 2.16407990455627) + 0.0109923440569272*std::sin(0.395679831504822*x_98 - 4.19135999679565) - 0.057554931966714*std::sin(0.406559854745865*x_98 - 7.38751983642578) + 0.00102403274033623*std::sin(0.414239853620529*x_98 - 7.39607954025269) - 0.0686358384646501*std::sin(0.430639863014221*x_98 - 7.37799978256226) - 0.534390364812521*std::sin(0.433199852705002*x_98 - 7.38143968582153) + 54.6057152034938*std::sin(0.382719844579697*x_99 - 7.42312002182007) + 0.2485174944484*std::sin(0.398159861564636*x_99 - 7.40983963012695) - 0.0315281249568452*std::sin(0.402159839868546*x_99 - 4.20552015304565) - 0.0712246556133607*std::sin(0.403039842844009*x_99 + 5.20864009857178) - 0.720978495004272*std::sin(0.415279865264893*x_99 - 4.19144010543823) - 1462.50023411892);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0973307888963437*x_1 - 0.616872995355839*x_10 - 0.624657023928119*x_100 + 3.98811435893592*x_101 - 0.13920769706328*x_102 - 0.984375372710247*x_103 - 0.00260860685643639*x_104 + 0.66882391635202*x_105 + 0.00947083639414283*x_106 + 0.312145091016806*x_107 + 1.13027096174731*x_108 - 0.824509734959285*x_109 - 0.158202712243352*x_11 + 0.753860568058218*x_110 + 0.00813509998794728*x_111 - 0.00301537367942702*x_112 + 0.113209230897596*x_113 - 0.00299240449670483*x_114 + 0.776656801713623*x_115 + 0.0168424732824794*x_116 - 0.00359279968935974*x_117 - 0.418995701163282*x_118 + 0.00858960679995405*x_119 - 1.91124958235725*x_12 + 0.0261892018212308*x_120 - 0.406013013219959*x_13 - 2.87750966636365*x_14 - 2.67050619864893*x_15 + 0.477354473675365*x_16 - 0.576818860867914*x_17 + 0.211570022646806*x_18 + 1.26503194671931*x_19 - 0.168410540881461*x_2 - 4.21012694380362*x_20 - 0.772252724619618*x_21 - 0.678946564952526*x_22 - 2.5458054475085*x_23 - 0.00934548240693294*x_24 + 0.955269839786369*x_25 + 0.314459559364435*x_26 + 0.144693778964721*x_27 + 0.00369177858911449*x_28 + 0.89095687936935*x_29 - 1.17136396845501*x_3 + 0.0938733835555258*x_30 - 2.94935689680463*x_31 - 0.319998083213593*x_32 + 1.17350977460125*x_33 + 2.26491222885635*x_34 - 0.976003649258234*x_35 - 0.00816913720792234*x_36 + 0.0268333766782995*x_37 + 0.615519407316443*x_38 + 0.455174950328571*x_39 + 0.155702064799978*x_4 + 0.0076499506490151*x_40 - 0.0132797273152732*x_41 + 0.489190426018703*x_42 - 0.257181433633715*x_43 - 1.50185624996971*x_44 + 0.507760278918909*x_45 - 1.72714504491223*x_46 + 0.132812483746872*x_47 + 0.404131318052377*x_48 + 0.469307462087404*x_49 + 0.771643682409671*x_5 - 0.076470870394666*x_50 + 0.444024569557041*x_51 + 1.05457553611103*x_52 - 0.481840489078449*x_53 + 0.428681647136465*x_54 + 0.972580573713034*x_55 - 0.50370066016134*x_56 - 0.0604850097634371*x_57 + 0.00013807766276807*x_58 + 0.00263818416256444*x_59 + 0.280156920342802*x_6 + 0.532363274782366*x_60 + 2.99487471154416*x_61 - 32.3651595350102*x_62 - 0.665008287419937*x_63 + 0.434306403838767*x_64 + 0.992709527423428*x_65 - 0.0105567872297636*x_66 - 0.587900490783536*x_67 - 0.180486221926313*x_68 - 0.862510812138485*x_69 - 0.739785411012046*x_7 + 0.0623435286240104*x_70 - 0.947597576144542*x_71 - 0.695713450887506*x_72 - 0.00510683704715885*x_73 - 3.83373616594446*x_74 + 0.00422364338021037*x_75 + 0.359866306828921*x_76 + 2.5605740383486*x_77 - 1.08886993084207*x_78 - 0.00298730262174637*x_79 + 2.71309499155649*x_8 - 0.337041412267336*x_80 + 0.040750762445664*x_81 - 0.84736656728769*x_82 + 0.00060159684916585*x_83 - 0.00789360448952204*x_84 + 0.408999770029764*x_85 + 0.757542106339863*x_86 + 0.00477396846609672*x_87 + 0.00993445512348994*x_88 - 1.44991468726988*x_89 - 3.36365911470713*x_9 + 0.844364484117419*x_90 + 1.72332968401821*x_91 + 0.00871602584621964*x_92 + 5.41793184234099*x_93 + 0.28742744567945*x_94 - 0.469497267674508*x_95 - 0.0144342904831827*x_96 - 2.31422732481401*x_97 + 0.378127270364448*x_98 - 0.0235885054066928*x_99 - 0.0139787873867506*std::pow(-7.36319971084595*x_106 - 7.55671977996826, 2) + 0.000114119760296003*std::pow(-5.29512023925781*x_108 - 7.73583984375, 2) + 0.275186470233137*std::pow(-0.582399845123291*x_108 - 0.778079867362976, 2) + 1.19844164694102e-5*std::pow(-7.56576013565063*x_109 - 9.54831981658936, 2) + 0.00177416327220428*std::pow(-6.31343984603882*x_11 - 9.7729606628418, 2) + 0.00701341392724277*std::pow(-8.15095996856689*x_116 - 8.55615997314453, 2) + 9.17028061380432e-5*std::pow(-7.33599996566772*x_118 - 8.55144023895264, 2) - 0.00339537191744464*std::pow(-6.34631967544556*x_120 - 8.5252799987793, 2) - 0.000170417268842186*std::pow(-4.97463989257813*x_120 - 5.7960000038147, 2) + 2.92644450435412e-5*std::pow(-5.00879955291748*x_13 - 7.81375980377197, 2) - 1.84868056789446e-6*std::pow(-5.29879999160767*x_15 - 5.5019998550415, 2) - 2.71103547532173e-5*std::pow(-5.08487987518311*x_15 - 7.32096004486084, 2) + 0.00109670947473526*std::pow(-8.73536014556885*x_18 - 9.75536060333252, 2) - 2.25340405218695e-5*std::pow(-6.31343984603882*x_19 - 9.57096099853516, 2) + 0.00238747977881593*std::pow(-7.01279973983765*x_23 - 9.21599960327148, 2) + 6.31331151358747e-5*std::pow(-6.67776012420654*x_24 - 9.96127986907959, 2) - 0.00982537413252445*std::pow(-4.61759996414185*x_24 - 6.62983989715576, 2) + 4.43153979373915e-6*std::pow(-7.44783973693848*x_27 - 8.82520008087158, 2) + 0.0194162788799147*std::pow(-5.21519994735718*x_39 - 6.82528018951416, 2) - 8.40772025552201e-6*std::pow(-6.29800033569336*x_4 - 9.95495986938477, 2) - 3.61066084040806e-5*std::pow(-4.83800029754639*x_44 - 6.05071973800659, 2) + 0.000187396649880807*std::pow(-5.75367975234985*x_47 - 7.59768009185791, 2) - 6.967978615449e-6*std::pow(-6.32687997817993*x_5 - 9.3877592086792, 2) + 1.63095701516776e-5*std::pow(-7.51128005981445*x_50 - 8.1159200668335, 2) + 0.000865095018578177*std::pow(-7.70344018936157*x_59 - 9.92232036590576, 2) + 0.000246624841189987*std::pow(-6.26208019256592*x_59 - 9.90112018585205, 2) + 2.82578912835459e-5*std::pow(-4.89711999893188*x_6 - 7.75040006637573, 2) + 1.87341180739394e-5*std::pow(-8.05943965911865*x_64 - 9.632080078125, 2) + 5.33448858654712e-6*std::pow(-3.31583976745605*x_66 - 4.76936006546021, 2) + 0.0026638028482686*std::pow(-5.33400011062622*x_67 - 5.12992000579834, 2) - 1.05453953755706e-5*std::pow(-4.89463996887207*x_7 - 6.54287958145142, 2) - 2.93121923405541e-5*std::pow(-6.32664012908936*x_70 - 8.89144039154053, 2) - 0.016010234961527*std::pow(-5.72743988037109*x_70 - 7.97160005569458, 2) + 2.37313283014629e-5*std::pow(-6.03951978683472*x_72 - 8.25783920288086, 2) - 0.000212317448891289*std::pow(-5.92343997955322*x_72 - 7.55639982223511, 2) - 0.000922665196068298*std::pow(-5.51567983627319*x_72 - 6.31112003326416, 2) + 0.00180398399958204*std::pow(-5.3295202255249*x_72 - 7.79544019699097, 2) - 0.00103055000511502*std::pow(-5.7279200553894*x_73 - 7.8930401802063, 2) + 1.71809396244746e-5*std::pow(-7.48496007919312*x_74 - 9.9323205947876, 2) + 0.00474481087272702*std::pow(-5.3471999168396*x_74 - 6.92751979827881, 2) + 3.21854089672008e-5*std::pow(-6.85536003112793*x_77 - 8.66800022125244, 2) + 0.00491642597843895*std::pow(-4.26240015029907*x_78 - 5.81343936920166, 2) + 0.0121564032860529*std::pow(-7.15487957000732*x_81 - 9.58255958557129, 2) + 1.75999271307979e-5*std::pow(-8.56280040740967*x_84 - 8.97383975982666, 2) + 3.5625466642765e-5*std::pow(-8.34360027313232*x_84 - 8.74335956573486, 2) - 3.2521240590168e-6*std::pow(-7.32399988174438*x_84 - 6.70928001403809, 2) - 2.69706786213446e-5*std::pow(-5.07727956771851*x_86 - 7.30615997314453, 2) - 0.00324470051924032*std::pow(-4.13991975784302*x_87 - 5.91967964172363, 2) + 0.0101303511632445*std::pow(-8.75607967376709*x_88 - 9.97624015808105, 2) + 2.1857514294153e-6*std::pow(-8.0033597946167*x_88 - 9.20728015899658, 2) + 0.00098040296266984*std::pow(-2.1943998336792*x_88 - 2.17791986465454, 2) + 0.000135659550935042*std::pow(-3.1781599521637*x_90 - 4.56775999069214, 2) - 5.94082242311379e-5*std::pow(-5.24519968032837*x_99 - 6.02455997467041, 2) + 0.015005281854541*std::exp(0.702079832553864*x_1) - 9.54409113906734e-5*std::exp(1.08351981639862*x_1) + 4.49966956647758e-5*std::exp(1.19423997402191*x_1) - 0.00961383865761367*std::exp(1.22735989093781*x_1) - 4.47142731609197e-6*std::exp(1.28807985782623*x_1) + 0.00311799701644505*std::exp(1.19983983039856*x_100) - 6.18507709905241e-5*std::exp(1.62295985221863*x_100) - 0.00207754219176836*std::exp(0.515199840068817*x_103) + 0.0139815389743414*std::exp(0.528799831867218*x_104) + 0.0245224011656694*std::exp(1.06327986717224*x_104) + 0.0989960098335482*std::exp(0.650879800319672*x_106) + 0.002925430956451*std::exp(0.665519833564758*x_106) - 0.00406573337500683*std::exp(0.792479872703552*x_106) - 0.416396698769313*std::exp(1.33487987518311*x_106) + 0.270366457852517*std::exp(0.648639798164368*x_109) + 0.303085999297574*std::exp(0.855439901351929*x_110) + 8.11790775567934e-5*std::exp(1.08487975597382*x_110) + 4.06390928787638e-5*std::exp(1.55039989948273*x_110) - 0.000174152321917602*std::exp(1.59975981712341*x_110) + 0.239686576819894*std::exp(0.604959845542908*x_112) + 0.00105330757935307*std::exp(0.914159834384918*x_112) - 0.00504065238284471*std::exp(0.571999847888947*x_24) + 0.0222916110819013*std::exp(0.514479875564575*x_26) - 1.17482049050882*std::exp(0.62559986114502*x_26) + 0.000856681013026322*std::exp(0.643839836120605*x_26) + 0.000186997047645752*std::exp(0.829519867897034*x_26) + 0.00879760330581433*std::exp(0.874719858169556*x_26) + 0.000445295347569069*std::exp(0.913679838180542*x_26) + 3.76491072466774*std::exp(0.491599857807159*x_31) - 0.00335102807128243*std::exp(0.599999845027924*x_31) + 0.014386259028398*std::exp(0.620239853858948*x_31) + 0.00744968344871621*std::exp(0.647599816322327*x_31) + 0.000558895556849657*std::exp(0.654319822788239*x_31) - 0.015702223468539*std::exp(0.655279815196991*x_31) + 0.0858921292894129*std::exp(0.654959857463837*x_45) + 0.00123520158152922*std::exp(0.825759887695313*x_45) - 0.00350988095862611*std::exp(1.0123997926712*x_45) + 0.0517999836870296*std::exp(1.11879980564117*x_45) + 3.85723584888111e-5*std::exp(1.23079991340637*x_45) - 0.0892827088990696*std::exp(0.99375981092453*x_6) - 0.016137666534333*std::exp(0.713119864463806*x_60) - 0.490318654342734*std::exp(0.968719840049744*x_60) + 0.000807454594107871*std::exp(1.24247992038727*x_60) + 1.52615570636474e-5*std::exp(1.45055985450745*x_66) + 0.0263595481998381*std::exp(1.66143977642059*x_66) - 9.25467049213002e-5*std::exp(0.718239843845367*x_70) - 0.00056547360557134*std::exp(0.895999848842621*x_70) - 0.00600558194135822*std::exp(0.875359892845154*x_72) + 0.00308291796003257*std::exp(0.97439980506897*x_74) + 0.000665969607344327*std::exp(1.0343998670578*x_74) + 0.000332976853014701*std::exp(1.24767982959747*x_74) + 9.6838153163821e-6*std::exp(1.71327984333038*x_74) + 0.665567659455181*std::exp(0.599999845027924*x_76) - 0.00103211385837901*std::exp(0.73831981420517*x_77) - 0.000554318325243814*std::exp(0.885519862174988*x_81) + 0.00185770444331384*std::exp(1.09175980091095*x_81) + 0.000745969290570381*std::exp(0.719999849796295*x_87) - 0.0178316699068428*std::sin(0.222879990935326*x_1 - 1.19911992549896) - 0.261281533463059*std::sin(0.184960007667542*x_10 + 1.76799988746643) + 3.60632821157196*std::sin(0.330879837274551*x_10 - 7.47408008575439) - 0.570386184427374*std::sin(0.372159838676453*x_100 - 7.40847969055176) + 0.055664796676246*std::sin(0.155280038714409*x_102 - 7.65199995040894) - 1.94823941046189*std::sin(0.298239946365356*x_102 - 7.52088022232056) + 0.00729341690858275*std::sin(0.342959851026535*x_102 - 7.44087982177734) - 0.039525580081975*std::sin(0.371279835700989*x_102 + 1.97439980506897) - 0.0356962171491485*std::sin(0.430479854345322*x_102 - 4.16527986526489) + 0.675796923679712*std::sin(0.445199847221375*x_102 + 5.23176002502441) + 0.0276809373898201*std::sin(0.314079850912094*x_103 - 7.47591972351074) + 10.6914724093555*std::sin(0.465919852256775*x_103 - 7.36799955368042) + 16.0246213163615*std::sin(0.487919867038727*x_104 - 4.14376020431519) + 1.19477310410392*std::sin(0.60919988155365*x_104 - 7.1910400390625) - 0.00282019974256904*std::sin(0.640159845352173*x_104 - 7.17999982833862) + 0.108822213980546*std::sin(0.263999968767166*x_105 + 1.85087990760803) - 0.892880510205105*std::sin(0.319519847631454*x_105 + 1.92879974842072) + 0.00869580739019209*std::sin(0.355839848518372*x_105 - 7.42432022094727) + 0.0109286386293763*std::sin(0.357599824666977*x_105 - 7.44007968902588) - 0.244480240655518*std::sin(0.187360003590584*x_106 - 7.61688041687012) + 0.00734049967655121*std::sin(0.432319849729538*x_106 + 5.221360206604) - 25.390241382387*std::sin(0.299039930105209*x_107 + 5.11175966262817) - 2.83158877772415*std::sin(0.363919854164124*x_107 - 7.4172797203064) - 0.0104498978415873*std::sin(0.44327986240387*x_107 + 5.22464036941528) + 0.0609203565877276*std::sin(0.347679853439331*x_108 + 5.14847993850708) - 0.330449121808119*std::sin(0.663199841976166*x_108 + 2.2377598285675) + 0.0474971748841498*std::sin(0.345519840717316*x_109 + 5.15944004058838) + 0.499109247304794*std::sin(0.375519841909409*x_110 + 5.1691198348999) - 0.00159106378995781*std::sin(0.590079843997955*x_110 - 7.21264028549194) + 1.63295478904508*std::sin(0.3572798371315*x_111 - 7.43255996704102) + 0.00424157207624168*std::sin(0.401119828224182*x_111 - 4.20544004440308) + 0.595072874237346*std::sin(0.439599871635437*x_111 - 1.17359983921051) + 0.00103723292496601*std::sin(0.456559866666794*x_111 + 8.23095989227295) - 4.32514608364046*std::sin(0.473359853029251*x_111 + 2.04543972015381) + 0.00192816162368657*std::sin(0.496959865093231*x_111 - 4.12064027786255) - 36.4414663362119*std::sin(0.198719993233681*x_112 + 4.99071979522705) - 0.0184358862797147*std::sin(0.353759855031967*x_112 - 7.41695976257324) + 0.00821005996541747*std::sin(0.411039859056473*x_112 - 0.981599867343903) + 0.923731168843602*std::sin(0.48583984375*x_112 + 5.23848009109497) + 0.0424621019267453*std::sin(0.507519841194153*x_112 - 1.01695990562439) - 40.2166422476482*std::sin(0.304399937391281*x_113 - 7.4966402053833) + 5.35234577098421*std::sin(0.345999836921692*x_113 - 7.43743991851807) + 0.0232684324363698*std::sin(0.268559962511063*x_114 - 7.53224039077759) - 2.00678393125425*std::sin(0.269199967384338*x_114 - 7.52320003509521) + 9.99791553887688*std::sin(0.367759823799133*x_114 - 7.42456007003784) + 0.0898801985881463*std::sin(0.429439842700958*x_114 + 5.22695970535278) - 0.0015549672019562*std::sin(0.468559861183167*x_114 - 4.1592001914978) - 0.00196914464634414*std::sin(0.576479852199554*x_114 - 7.21895980834961) - 0.445211139611352*std::sin(0.665199875831604*x_114 + 5.43255996704102) - 0.0555204435237328*std::sin(0.302079945802689*x_115 + 5.103919506073) - 3.86133126251082*std::sin(0.325759828090668*x_115 - 7.45439958572388) + 2.39500838187275*std::sin(0.416079849004745*x_115 + 5.22344017028809) - 0.0035812374249506*std::sin(0.48447984457016*x_115 - 4.12936019897461) + 0.014819013708736*std::sin(0.534799814224243*x_115 + 5.36311960220337) + 0.58170307453528*std::sin(0.435039848089218*x_116 + 8.42255973815918) + 0.789344694870816*std::sin(0.49839985370636*x_116 - 4.12344026565552) + 0.048522580975726*std::sin(0.243599966168404*x_117 - 1.35351991653442) - 7.73925494692179*std::sin(0.376959830522537*x_117 + 1.97719979286194) + 0.0163579588277969*std::sin(0.378399848937988*x_117 + 5.1756796836853) - 1.84803163355078*std::sin(0.400079846382141*x_117 - 4.1864800453186) - 0.212039502178558*std::sin(0.616959869861603*x_117 - 3.99599981307983) - 0.0386601141506654*std::sin(0.191840007901192*x_118 + 1.78999984264374) + 3.06989684558808*std::sin(0.408879846334457*x_118 + 5.20247983932495) - 0.0173049932085592*std::sin(0.419359862804413*x_118 + 5.21727991104126) + 0.0114571901427721*std::sin(0.289599925279617*x_119 - 4.28279972076416) - 1.57046984780312*std::sin(0.340479850769043*x_119 + 5.15120029449463) - 3.94114311274527*std::sin(0.34895983338356*x_119 + 5.15208005905151) + 0.00789938574319823*std::sin(0.366079837083817*x_119 - 7.41511964797974) + 6.02885197285016*std::sin(0.434239864349365*x_119 + 1.99407982826233) + 1.04974008815564*std::sin(0.35471984744072*x_12 - 1.03167986869812) - 0.00225301068978582*std::sin(0.328399837017059*x_120 + 1.94799983501434) - 0.0135531911101703*std::sin(0.36695984005928*x_120 + 5.15912008285522) + 0.0588596876864195*std::sin(0.427679866552353*x_120 + 5.2294397354126) - 9.73720006529817*std::sin(0.211919993162155*x_14 - 4.38903999328613) + 0.0175179684653847*std::sin(0.272799968719482*x_16 + 5.08839988708496) - 0.0138309596753079*std::sin(0.368559837341309*x_16 + 5.15863990783691) + 0.733109036364663*std::sin(0.369679838418961*x_16 + 5.18168020248413) + 0.00213766046830953*std::sin(0.427279859781265*x_18 - 0.954639852046967) - 0.0111192188439892*std::sin(0.348479837179184*x_20 - 4.25511980056763) + 4.57626431349198*std::sin(0.361199855804443*x_20 + 5.16968011856079) - 1.95246384700049*std::sin(0.357999831438065*x_21 + 8.36407947540283) + 6.79060684797463*std::sin(0.209600001573563*x_22 - 7.57504034042358) - 0.0223825097744097*std::sin(0.502079844474792*x_22 + 2.10895967483521) + 0.003153428484778*std::sin(0.589439868927002*x_22 - 7.22200012207031) + 0.190513035878828*std::sin(0.162880018353462*x_24 + 4.93567991256714) + 0.00763200385261711*std::sin(0.182560011744499*x_24 + 4.98351955413818) - 0.0426464802249414*std::sin(0.190160006284714*x_24 - 7.60288000106812) - 1.23640865280514*std::sin(0.338639855384827*x_24 - 4.25832033157349) - 0.00243153700885141*std::sin(0.46111986041069*x_25 - 4.13752031326294) - 0.0223033350855283*std::sin(0.186080008745193*x_26 - 7.6005597114563) + 0.0577576521646454*std::sin(0.137440040707588*x_27 + 4.9017596244812) + 12.8854758899533*std::sin(0.171120017766953*x_27 - 7.6241602897644) - 0.127350116783972*std::sin(0.301679939031601*x_27 + 5.12080001831055) - 21.4210284302984*std::sin(0.303999930620193*x_27 + 5.13247966766357) + 0.0277441746790089*std::sin(0.319839835166931*x_28 - 4.28064012527466) - 3.56878332349794*std::sin(0.320079833269119*x_28 - 4.28864002227783) - 2.82322479709866*std::sin(0.322399854660034*x_28 - 4.28247976303101) + 0.0163816011550512*std::sin(0.326319843530655*x_28 + 5.13312005996704) + 11.8924885807988*std::sin(0.331519842147827*x_28 - 4.27248001098633) - 0.0341268987326623*std::sin(0.33247983455658*x_28 - 4.26847982406616) + 0.0340551924108285*std::sin(0.285919934511185*x_3 + 5.08111953735352) + 1.31566723810835*std::sin(0.294319927692413*x_3 + 5.10839986801147) + 1.02258891444292*std::sin(0.307759910821915*x_3 - 7.5032000541687) - 15.727735484316*std::sin(0.261199980974197*x_30 - 7.53352022171021) - 3.00868841936875*std::sin(0.27295994758606*x_30 - 4.32471990585327) - 0.0128620685569368*std::sin(0.279999971389771*x_30 - 4.29591989517212) + 4.53335807944255*std::sin(0.360319852828979*x_31 + 5.10487985610962) - 8.41193704830602*std::sin(0.255839973688126*x_32 - 4.40239953994751) - 0.0972076230386266*std::sin(0.348479837179184*x_32 + 8.2469596862793) + 0.113275863192813*std::sin(0.322319835424423*x_33 + 8.19719982147217) - 0.0160002820616914*std::sin(0.351519852876663*x_34 + 2.00215983390808) + 0.0138066434622638*std::sin(0.313519835472107*x_35 + 1.97631978988647) - 0.00588796262542875*std::sin(0.315679848194122*x_35 + 1.98063981533051) + 3.53927656972928*std::sin(0.317599833011627*x_35 - 7.43431997299194) + 2.23771639539782*std::sin(0.318319827318192*x_35 - 7.43311977386475) - 0.0145082557301559*std::sin(0.319839835166931*x_35 - 7.42831993103027) - 0.0942628110228629*std::sin(0.319919854402542*x_35 - 7.42831993103027) + 0.0570217122360529*std::sin(0.321919858455658*x_35 - 7.42599964141846) + 0.0360471530546076*std::sin(0.331519842147827*x_36 - 4.25288009643555) + 1.82410811612705*std::sin(0.352959841489792*x_36 + 5.1637601852417) - 0.852657587387951*std::sin(0.373759835958481*x_36 - 7.41639995574951) - 0.00489123954680508*std::sin(0.380639851093292*x_36 - 7.39903974533081) + 5.37534227432713*std::sin(0.393519848585129*x_36 - 4.2052001953125) + 0.04382063311946*std::sin(0.418559849262238*x_36 + 5.22079992294312) + 1.85666059337458*std::sin(0.293359935283661*x_37 + 5.09615993499756) + 0.0228688216033631*std::sin(0.298719942569733*x_37 - 7.50471973419189) + 16.0272587530402*std::sin(0.36303985118866*x_37 - 4.24047994613647) + 0.0156551823483043*std::sin(0.364959836006165*x_37 - 7.42208003997803) - 2.32532696399616*std::sin(0.401439845561981*x_37 - 4.20695972442627) - 0.0106769193493717*std::sin(0.48039984703064*x_38 + 5.25888013839722) + 0.00172748858506371*std::sin(0.665279865264893*x_38 + 2.20815992355347) + 3.44061686979316*std::sin(0.19743999838829*x_39 + 4.99631977081299) + 0.0319185899260277*std::sin(0.350079834461212*x_39 + 5.16296005249023) + 0.0599152839643335*std::sin(0.334239840507507*x_40 - 4.27408027648926) + 0.00677258108865569*std::sin(0.390239834785461*x_40 + 8.37495994567871) + 0.0649607388406416*std::sin(0.312159925699234*x_41 + 1.89567983150482) + 2.85406740866264*std::sin(0.375519841909409*x_41 + 5.17112016677856) + 17.3073109220003*std::sin(0.406959861516953*x_41 - 7.39175987243652) + 0.00327029440385842*std::sin(0.431519865989685*x_41 - 7.38671970367432) - 13.3089151364561*std::sin(0.121520057320595*x_42 + 1.70983994007111) + 22.2265068368815*std::sin(0.369279831647873*x_43 - 7.41183996200562) - 0.0117348847837538*std::sin(0.380639851093292*x_43 - 4.22176027297974) + 0.0837992520136825*std::sin(0.383359849452972*x_43 - 7.40655994415283) + 0.934286955791173*std::sin(0.440879851579666*x_43 - 7.37831974029541) - 1.64781936976335*std::sin(0.359359860420227*x_44 + 5.16416025161743) - 0.00738630554903905*std::sin(0.407279849052429*x_46 + 5.21623992919922) - 0.439778118006389*std::sin(0.585599839687347*x_46 - 7.21920013427734) - 0.00177720456621741*std::sin(0.645839810371399*x_46 + 5.4171199798584) - 8.19373725826607*std::sin(0.208159998059273*x_47 - 7.59176015853882) + 19.4291736863363*std::sin(0.260319977998734*x_47 + 1.85655987262726) + 0.00814887390063599*std::sin(0.439279854297638*x_47 - 4.15232038497925) - 4.08617240434889*std::sin(0.424719870090485*x_48 - 4.17040014266968) + 0.0142428180854054*std::sin(0.259919971227646*x_49 + 1.85903990268707) + 0.0459527229455743*std::sin(0.437279850244522*x_49 - 7.35431957244873) + 7.18549392036891*std::sin(0.191200003027916*x_50 + 4.98799991607666) - 26.5934875739766*std::sin(0.321759849786758*x_50 - 7.47687959671021) - 2.38653690495419*std::sin(0.36559984087944*x_51 - 4.23184013366699) + 9.82411024159802*std::sin(0.212960004806519*x_53 + 5.00816011428833) - 2.21031704475474*std::sin(0.347519844770432*x_53 + 5.15128040313721) + 0.0140804478327457*std::sin(0.359999865293503*x_53 - 4.24272012710571) - 0.000856092253777462*std::sin(0.889279901981354*x_53 - 3.95743989944458) - 0.0108466011876508*std::sin(0.319359838962555*x_54 + 1.90071976184845) - 1.53626383766259*std::sin(0.417919874191284*x_54 - 7.38679981231689) + 1.31751259715601*std::sin(0.487039864063263*x_54 - 1.10911989212036) - 0.0342659735158086*std::sin(0.658959865570068*x_54 - 3.96943998336792) - 2.55140748030598*std::sin(0.348079830408096*x_55 + 5.15960025787354) - 2.04305632350632*std::sin(0.403119832277298*x_55 + 8.38576030731201) + 0.00360963661302366*std::sin(0.441839843988419*x_55 - 4.14991998672485) + 0.0493497186581068*std::sin(0.465039849281311*x_55 + 5.25047969818115) - 1.89452052030625*std::sin(0.322559833526611*x_56 + 1.92327988147736) - 0.468781217033492*std::sin(0.406159847974777*x_56 + 5.19504022598267) + 1.98718165621365*std::sin(0.428879857063293*x_57 - 4.16879987716675) + 0.0103456995747945*std::sin(0.448399841785431*x_57 - 4.15232038497925) + 8.01537424318647*std::sin(0.553839862346649*x_57 + 5.35767984390259) + 0.014136663803562*std::sin(0.853919863700867*x_57 + 5.62479972839355) + 0.204416191722204*std::sin(0.170960009098053*x_58 + 4.96247959136963) - 12.1910096985124*std::sin(0.209440007805824*x_58 + 5.00848007202148) + 0.0235786095819417*std::sin(0.266239941120148*x_58 - 7.51327991485596) + 4.83533272664857*std::sin(0.2743199467659*x_58 + 5.07583951950073) + 0.0121086896039518*std::sin(0.348079830408096*x_58 + 5.15759992599487) - 2.13812785063216*std::sin(0.42223984003067*x_58 - 4.189040184021) + 0.0212919811869848*std::sin(0.462799847126007*x_58 + 5.25392007827759) - 0.0279978761779522*std::sin(0.168560013175011*x_59 - 7.63191986083984) - 22.423595286873*std::sin(0.251999974250793*x_59 - 7.52784013748169) + 0.00896124696311701*std::sin(0.203199997544289*x_64 + 1.78175985813141) + 0.0464191094048247*std::sin(0.222240000963211*x_64 - 4.36191987991333) + 5.31221368524768*std::sin(0.228959992527962*x_64 - 4.36199951171875) + 0.001412433669617*std::sin(0.339199841022491*x_64 - 7.4555196762085) + 2.47093520371558*std::sin(0.43495985865593*x_66 + 8.44768047332764) + 5.69387970043952*std::sin(0.243759974837303*x_67 - 7.55679988861084) - 6.98372086661105*std::sin(0.247279971837997*x_70 - 7.52800035476685) - 0.0549615288157314*std::sin(0.439999878406525*x_70 - 4.15304040908813) - 0.00117646474641483*std::sin(0.624399840831757*x_70 - 3.97263979911804) + 0.0366028214897869*std::sin(0.23063999414444*x_71 + 5.04759979248047) + 0.0501588823510097*std::sin(0.214000001549721*x_72 + 5.00920009613037) - 34.9603658158834*std::sin(0.24959996342659*x_73 + 5.06479978561401) + 2.41754314910107*std::sin(0.342559844255447*x_73 - 4.26151990890503) + 0.00303991294427758*std::sin(0.451039850711823*x_73 - 4.15104007720947) - 0.0447181380393485*std::sin(0.123040057718754*x_75 + 4.89031982421875) - 0.00794078877815075*std::sin(0.278559952974319*x_75 + 5.09087991714478) + 0.60408228310461*std::sin(0.409119844436646*x_75 - 7.38631963729858) - 5.59902799946148*std::sin(0.476879835128784*x_75 + 2.08039975166321) + 0.607702750069497*std::sin(0.540319859981537*x_75 + 5.16431999206543) - 30.7086848940476*std::sin(0.238319978117943*x_76 - 7.53840017318726) - 2.29098196623774*std::sin(0.393599838018417*x_78 + 8.3810396194458) + 0.00599966629862432*std::sin(0.486639857292175*x_78 + 5.28744029998779) + 3.24102426983457*std::sin(0.281759947538376*x_79 - 7.4986400604248) + 4.06385332637612*std::sin(0.332239836454391*x_79 + 5.12871980667114) + 17.5398174492085*std::sin(0.355119854211807*x_79 + 1.96583986282349) + 0.0357730871672461*std::sin(0.249199971556664*x_8 - 4.33576011657715) - 1.21983635100836*std::sin(0.501679837703705*x_8 - 7.30711984634399) + 0.198283248787643*std::sin(0.389359831809998*x_81 + 8.37271976470947) - 6.88240084578426*std::sin(0.214159995317459*x_82 - 7.57696008682251) - 0.0899510050999928*std::sin(0.197359994053841*x_83 + 5.00008010864258) + 0.209601171764353*std::sin(0.201599985361099*x_83 + 5.0053596496582) + 0.00480483579966913*std::sin(0.263119965791702*x_83 + 1.87455987930298) + 0.00347641349655228*std::sin(0.319679915904999*x_83 - 7.46343994140625) - 19.1988906231462*std::sin(0.320559918880463*x_83 - 7.46808004379272) + 1.33546556874122*std::sin(0.322239845991135*x_83 - 7.4730396270752) + 2.48964699567807*std::sin(0.393679857254028*x_83 - 1.19831991195679) - 0.0203126632169606*std::sin(0.140080034732819*x_84 - 7.67984008789063) + 0.317115608575778*std::sin(0.179360002279282*x_84 + 1.77599990367889) + 5.83239609793125*std::sin(0.23871998488903*x_84 - 7.55600023269653) - 0.0207049953694916*std::sin(0.278079956769943*x_84 + 5.09272003173828) - 6.24073925606874*std::sin(0.278479933738708*x_84 - 7.49608039855957) + 0.0164171756745976*std::sin(0.187040001153946*x_85 + 4.98767995834351) + 0.0887546965276241*std::sin(0.19064000248909*x_85 - 7.61648035049438) + 0.026965372120586*std::sin(0.221919998526573*x_85 - 7.56135988235474) - 8.26338039383087*std::sin(0.230239987373352*x_85 - 7.55408048629761) + 0.00263016186970201*std::sin(0.524639844894409*x_86 - 7.27040004730225) - 5.89601451490296*std::sin(0.402799844741821*x_87 + 5.20991992950439) - 1.63721186579252*std::sin(0.417919844388962*x_87 - 4.18951988220215) - 0.00452522507228849*std::sin(0.499039828777313*x_87 - 4.11488008499146) + 0.00419733003515096*std::sin(0.87447988986969*x_87 - 0.751359879970551) - 0.135237498963147*std::sin(0.219119995832443*x_89 + 1.8155198097229) - 0.57250669301034*std::sin(0.41023987531662*x_90 - 7.39207983016968) + 0.00449020778874078*std::sin(0.414639860391617*x_90 - 0.994639813899994) - 0.0357756516852851*std::sin(0.505279839038849*x_90 - 4.09320020675659) - 0.0122961900413479*std::sin(0.337039858102798*x_92 + 5.18400001525879) + 1.46824773167942*std::sin(0.341039836406708*x_92 + 5.20991992950439) - 0.00930459672321242*std::sin(0.360079854726791*x_92 + 1.97791981697083) - 5.8262728586179*std::sin(0.360879838466644*x_92 + 2.00343990325928) + 0.0396869195286656*std::sin(0.363839834928513*x_92 - 7.38535976409912) + 29.7413806407947*std::sin(0.365199834108353*x_92 + 1.99775981903076) - 0.00558566546469215*std::sin(0.381279855966568*x_92 + 1.97519981861115) - 0.0203619106983995*std::sin(0.401679873466492*x_92 - 7.59008026123047) + 0.00758500714686458*std::sin(0.374559849500656*x_94 - 1.18543982505798) + 0.0780008053030411*std::sin(0.376239836215973*x_94 + 1.98399984836578) + 2.26593940872078*std::sin(0.386319845914841*x_94 - 7.40639972686768) - 9.05315125405787*std::sin(0.404079854488373*x_94 - 4.21031999588013) + 0.00742326351167774*std::sin(0.367999851703644*x_95 + 1.98935985565186) + 5.12529387768978*std::sin(0.382479846477509*x_95 - 7.39607954025269) + 0.0024991002195916*std::sin(0.376959830522537*x_96 - 4.22176027297974) - 0.871306821528854*std::sin(0.386959820985794*x_96 - 4.2021598815918) - 0.00669793018286661*std::sin(0.396319836378098*x_96 + 5.20240020751953) - 1.60399548830772*std::sin(0.398799866437912*x_96 - 7.3931999206543) + 5.87218486241126*std::sin(0.411679863929749*x_96 + 1.98543977737427) + 0.133973569294537*std::sin(0.326879858970642*x_97 + 5.13624000549316) + 0.957786788677499*std::sin(0.339759826660156*x_97 + 5.16359996795654) - 0.00815781163230992*std::sin(0.362479835748672*x_97 - 4.41720008850098) + 3.86622993589967*std::sin(0.403599858283997*x_97 + 5.19040012359619) - 0.00437616809045773*std::sin(0.518239855766296*x_97 + 2.16407990455627) + 0.00245348829281403*std::sin(0.395679831504822*x_98 - 4.19135999679565) + 0.0721444909074896*std::sin(0.406559854745865*x_98 - 7.38751983642578) - 0.00783815094564185*std::sin(0.414239853620529*x_98 - 7.39607954025269) - 0.00532979730531041*std::sin(0.430639863014221*x_98 - 7.37799978256226) - 0.662586420237391*std::sin(0.433199852705002*x_98 - 7.38143968582153) + 14.3433303608569*std::sin(0.382719844579697*x_99 - 7.42312002182007) + 0.0192981961299382*std::sin(0.398159861564636*x_99 - 7.40983963012695) + 0.0988583721407143*std::sin(0.402159839868546*x_99 - 4.20552015304565) + 0.0892793431196987*std::sin(0.403039842844009*x_99 + 5.20864009857178) - 0.893935578798499*std::sin(0.415279865264893*x_99 - 4.19144010543823) - 257.509732313481);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.189110995344613*x_1 - 1.29915810497194*x_10 - 1.11572742526618*x_100 + 7.39902816145782*x_101 - 0.258679977050725*x_102 - 0.655387671187407*x_103 - 0.00667487063299136*x_104 + 1.12253101231857*x_105 - 0.0513011252014094*x_106 + 0.249899067068742*x_107 + 2.03736345291525*x_108 - 1.25354270249099*x_109 - 0.603177866808284*x_11 + 1.345838405322*x_110 - 0.00836816254585987*x_111 - 0.00767683633020076*x_112 + 0.0698307092952397*x_113 - 0.0240793742838333*x_114 + 1.40201994937854*x_115 - 0.00495472910295927*x_116 - 0.0371686877932921*x_117 - 1.08251457822439*x_118 + 0.00534526844449551*x_119 - 3.27924919258324*x_12 + 0.0349374743169716*x_120 - 0.206475728245318*x_13 - 5.25238900271755*x_14 - 4.51149641555054*x_15 + 0.822310452188248*x_16 - 1.00539885455092*x_17 + 0.679210471135198*x_18 + 2.24009119107846*x_19 - 0.435581430413212*x_2 - 7.65782929854053*x_20 - 1.2818314055945*x_21 - 1.62629365223713*x_22 - 4.47367121364435*x_23 - 0.00779319312885495*x_24 + 1.23633717544271*x_25 + 0.210684024057271*x_26 + 0.101237644922083*x_27 - 0.0141687647543969*x_28 + 1.18937545966879*x_29 - 2.21596858635103*x_3 + 0.0294812488769941*x_30 - 3.23559826743014*x_31 - 3.15168758383787*x_32 + 2.73157287851865*x_33 + 3.77810380346757*x_34 - 1.76064480424893*x_35 - 0.0152439328531784*x_36 - 0.065855081694602*x_37 + 1.07504113047354*x_38 + 0.187644186213686*x_39 + 0.0484099107972652*x_4 - 0.231168498007049*x_40 - 0.0128403277367335*x_41 + 0.599474534549461*x_42 - 0.168182478175247*x_43 - 3.20762820628162*x_44 + 0.852075606419692*x_45 - 3.27553774969907*x_46 + 0.14551315281546*x_47 + 0.253446286146499*x_48 + 0.795679473789708*x_49 + 1.29929312630684*x_5 - 0.116114923035536*x_50 + 0.829718390983455*x_51 + 1.63817207693346*x_52 - 0.870534015406992*x_53 + 0.269337801569351*x_54 + 1.73728913064624*x_55 - 0.82375454246513*x_56 - 0.0717555148234042*x_57 - 0.00208477652360738*x_58 - 0.00782649410852104*x_59 + 0.56682239350775*x_6 + 0.323596499430757*x_60 + 4.97774883915968*x_61 - 59.2779624339747*x_62 - 0.823540500908189*x_63 + 0.756170850267737*x_64 + 2.1200774644943*x_65 - 0.0257573983296676*x_66 - 1.05330951337472*x_67 - 0.113630550526978*x_68 - 1.09190689253165*x_69 - 1.17547173486567*x_7 + 0.0612123000709137*x_70 - 1.941859448764*x_71 - 1.25322575652712*x_72 + 0.011708719965363*x_73 - 6.83962961000549*x_74 + 0.0286533239525757*x_75 + 0.230448351372819*x_76 + 4.81721211595935*x_77 - 1.97058881948264*x_78 - 0.00231861208589239*x_79 + 4.41243356089139*x_8 - 0.57873476962465*x_80 - 0.0388906988058355*x_81 - 1.32319395259127*x_82 - 0.0142818472579267*x_83 - 0.0114673013481194*x_84 + 0.300639452859856*x_85 + 1.00802997799585*x_86 - 0.0086959494932646*x_87 - 0.0140863233264466*x_88 - 2.11716259058949*x_89 - 6.46148111272297*x_9 + 1.48459795239554*x_90 + 1.56061586319121*x_91 + 0.022624216389413*x_92 + 9.40657418970424*x_93 + 0.168326223528031*x_94 - 0.876001548103076*x_95 - 0.0437240693801579*x_96 - 4.16567409889253*x_97 + 0.688272179310726*x_98 - 0.0404418599487085*x_99 - 0.025235944436006*std::pow(-7.36319971084595*x_106 - 7.55671977996826, 2) + 6.24843727197605e-5*std::pow(-5.29512023925781*x_108 - 7.73583984375, 2) + 0.257397694742565*std::pow(-0.582399845123291*x_108 - 0.778079867362976, 2) - 0.000148513986552675*std::pow(-7.56576013565063*x_109 - 9.54831981658936, 2) + 0.00112409311646288*std::pow(-6.31343984603882*x_11 - 9.7729606628418, 2) + 0.0126613360141928*std::pow(-8.15095996856689*x_116 - 8.55615997314453, 2) - 0.000449140499881388*std::pow(-7.33599996566772*x_118 - 8.55144023895264, 2) - 0.00612967453310169*std::pow(-6.34631967544556*x_120 - 8.5252799987793, 2) - 9.33091352154871e-5*std::pow(-4.97463989257813*x_120 - 5.7960000038147, 2) - 0.000362652567086721*std::pow(-5.00879955291748*x_13 - 7.81375980377197, 2) - 1.96882777803462e-6*std::pow(-5.29879999160767*x_15 - 5.5019998550415, 2) + 0.000335958523432031*std::pow(-5.08487987518311*x_15 - 7.32096004486084, 2) + 0.00102581529666058*std::pow(-8.73536014556885*x_18 - 9.75536060333252, 2) + 0.000279247654617519*std::pow(-6.31343984603882*x_19 - 9.57096099853516, 2) + 0.00223314682146647*std::pow(-7.01279973983765*x_23 - 9.21599960327148, 2) + 0.000160515328938609*std::pow(-6.67776012420654*x_24 - 9.96127986907959, 2) - 0.0177377757319904*std::pow(-4.61759996414185*x_24 - 6.62983989715576, 2) + 4.71954906483204e-6*std::pow(-7.44783973693848*x_27 - 8.82520008087158, 2) + 0.0350522632193367*std::pow(-5.21519994735718*x_39 - 6.82528018951416, 2) + 0.000104190642586097*std::pow(-6.29800033569336*x_4 - 9.95495986938477, 2) - 3.84532054001829e-5*std::pow(-4.83800029754639*x_44 - 6.05071973800659, 2) - 0.000917828238286004*std::pow(-5.75367975234985*x_47 - 7.59768009185791, 2) - 7.42083304876846e-6*std::pow(-6.32687997817993*x_5 - 9.3877592086792, 2) - 0.000202112408924434*std::pow(-7.51128005981445*x_50 - 8.1159200668335, 2) + 0.000809173006676711*std::pow(-7.70344018936157*x_59 - 9.92232036590576, 2) + 0.000156259173365694*std::pow(-6.26208019256592*x_59 - 9.90112018585205, 2) - 0.000350179092724572*std::pow(-4.89711999893188*x_6 - 7.75040006637573, 2) - 9.17556562434942e-5*std::pow(-8.05943965911865*x_64 - 9.632080078125, 2) + 5.6811812128066e-6*std::pow(-3.31583976745605*x_66 - 4.76936006546021, 2) + 0.00249160764267273*std::pow(-5.33400011062622*x_67 - 5.12992000579834, 2) - 1.12307489494673e-5*std::pow(-4.89463996887207*x_7 - 6.54287958145142, 2) + 0.000363244263932754*std::pow(-6.32664012908936*x_70 - 8.89144039154053, 2) - 0.0289033224927256*std::pow(-5.72743988037109*x_70 - 7.97160005569458, 2) - 0.000294084754250369*std::pow(-6.03951978683472*x_72 - 8.25783920288086, 2) - 0.000116250880452442*std::pow(-5.92343997955322*x_72 - 7.55639982223511, 2) - 0.000584591966223967*std::pow(-5.51567983627319*x_72 - 6.31112003326416, 2) + 0.00168736974042183*std::pow(-5.3295202255249*x_72 - 7.79544019699097, 2) - 0.000963932548750726*std::pow(-5.7279200553894*x_73 - 7.8930401802063, 2) - 0.000212910644657955*std::pow(-7.48496007919312*x_74 - 9.9323205947876, 2) + 0.00443809384812671*std::pow(-5.3471999168396*x_74 - 6.92751979827881, 2) - 0.000157637168165331*std::pow(-6.85536003112793*x_77 - 8.66800022125244, 2) + 0.00311500113126351*std::pow(-4.26240015029907*x_78 - 5.81343936920166, 2) + 0.0219459892607913*std::pow(-7.15487957000732*x_81 - 9.58255958557129, 2) - 2.88309548964901e-5*std::pow(-8.56280040740967*x_84 - 8.97383975982666, 2) - 0.000174485826228181*std::pow(-8.34360027313232*x_84 - 8.74335956573486, 2) - 1.91459702834827e-5*std::pow(-7.32399988174438*x_84 - 6.70928001403809, 2) + 0.000334227620703173*std::pow(-5.07727956771851*x_86 - 7.30615997314453, 2) - 0.0020558116469912*std::pow(-4.13991975784302*x_87 - 5.91967964172363, 2) + 0.0182883516287813*std::pow(-8.75607967376709*x_88 - 9.97624015808105, 2) + 1.28679998533994e-5*std::pow(-8.0033597946167*x_88 - 9.20728015899658, 2) + 0.002492664962067*std::pow(-2.1943998336792*x_88 - 2.17791986465454, 2) - 0.000222227874309896*std::pow(-3.1781599521637*x_90 - 4.56775999069214, 2) - 0.000151044830175045*std::pow(-5.24519968032837*x_99 - 6.02455997467041, 2) + 0.0140353010634903*std::exp(0.702079832553864*x_1) + 0.000467448930478901*std::exp(1.08351981639862*x_1) - 7.37104019557058e-5*std::exp(1.19423997402191*x_1) - 0.00609123750171058*std::exp(1.22735989093781*x_1) - 2.63242769848489e-5*std::exp(1.28807985782623*x_1) + 0.00170720729880009*std::exp(1.19983983039856*x_100) - 0.000364129105134162*std::exp(1.62295985221863*x_100) - 0.00221256329959217*std::exp(0.515199840068817*x_103) - 0.0684785522767295*std::exp(0.528799831867218*x_104) + 0.0155371620985153*std::exp(1.06327986717224*x_104) + 0.0925966480048232*std::exp(0.650879800319672*x_106) - 0.00479223392980099*std::exp(0.665519833564758*x_106) - 0.00222612454603967*std::exp(0.792479872703552*x_106) - 0.263825021145268*std::exp(1.33487987518311*x_106) + 0.252889260609334*std::exp(0.648639798164368*x_109) + 0.192032430636095*std::exp(0.855439901351929*x_110) + 8.64549699200207e-5*std::exp(1.08487975597382*x_110) + 0.000239251286385346*std::exp(1.55039989948273*x_110) - 9.53542012749237e-5*std::exp(1.59975981712341*x_110) + 0.151863154498202*std::exp(0.604959845542908*x_112) + 0.000576721009631762*std::exp(0.914159834384918*x_112) - 0.00275992519983805*std::exp(0.571999847888947*x_24) + 0.0566762035689524*std::exp(0.514479875564575*x_26) - 2.12090675682376*std::exp(0.62559986114502*x_26) + 0.000912357388643985*std::exp(0.643839836120605*x_26) + 0.00110089278648458*std::exp(0.829519867897034*x_26) + 0.00481698106073179*std::exp(0.874719858169556*x_26) - 0.000729451320222522*std::exp(0.913679838180542*x_26) + 6.79680398775447*std::exp(0.491599857807159*x_31) + 0.00548941699940073*std::exp(0.599999845027924*x_31) + 0.0365769231435748*std::exp(0.620239853858948*x_31) + 0.00407895000871393*std::exp(0.647599816322327*x_31) + 0.00329034118281733*std::exp(0.654319822788239*x_31) - 0.0167227233729065*std::exp(0.655279815196991*x_31) + 0.0544204430365706*std::exp(0.654959857463837*x_45) - 0.0153069372661832*std::exp(0.825759887695313*x_45) - 0.00192177681982447*std::exp(1.0123997926712*x_45) + 0.0484514968248549*std::exp(1.11879980564117*x_45) + 0.000227083966044606*std::exp(1.23079991340637*x_45) - 0.0565686822994087*std::exp(0.99375981092453*x_6) - 0.00883591034491319*std::exp(0.713119864463806*x_60) - 0.885173654523032*std::exp(0.968719840049744*x_60) - 0.00132271496414044*std::exp(1.24247992038727*x_60) + 8.98481462323445e-5*std::exp(1.45055985450745*x_66) + 0.0475869669753927*std::exp(1.66143977642059*x_66) - 0.00054484282582785*std::exp(0.718239843845367*x_70) + 0.000926318836221445*std::exp(0.895999848842621*x_70) - 0.01526913346047*std::exp(0.875359892845154*x_72) + 0.00168800034612292*std::exp(0.97439980506897*x_74) - 0.00109094427318274*std::exp(1.0343998670578*x_74) + 0.000354617281667302*std::exp(1.24767982959747*x_74) + 5.70107526384583e-5*std::exp(1.71327984333038*x_74) + 0.622543619582132*std::exp(0.599999845027924*x_76) - 0.00109919175316777*std::exp(0.73831981420517*x_77) - 0.00059034391098547*std::exp(0.885519862174988*x_81) - 0.00909863435417505*std::exp(1.09175980091095*x_81) + 0.000794450423908819*std::exp(0.719999849796295*x_87) + 0.220974662514121*std::sin(0.222879990935326*x_1 - 1.19911992549896) + 1.27970040930612*std::sin(0.184960007667542*x_10 + 1.76799988746643) + 3.3732056934241*std::sin(0.330879837274551*x_10 - 7.47408008575439) - 0.533514924844347*std::sin(0.372159838676453*x_100 - 7.40847969055176) - 0.0911861299406632*std::sin(0.155280038714409*x_102 - 7.65199995040894) - 1.23438611588491*std::sin(0.298239946365356*x_102 - 7.52088022232056) - 0.0903819074920398*std::sin(0.342959851026535*x_102 - 7.44087982177734) + 0.193587737864822*std::sin(0.371279835700989*x_102 + 1.97439980506897) - 0.0907572836415244*std::sin(0.430479854345322*x_102 - 4.16527986526489) + 0.632111637326886*std::sin(0.445199847221375*x_102 + 5.23176002502441) - 0.343029330945764*std::sin(0.314079850912094*x_103 - 7.47591972351074) + 19.301345402629*std::sin(0.465919852256775*x_103 - 7.36799955368042) + 28.9292942198286*std::sin(0.487919867038727*x_104 - 4.14376020431519) + 1.11753983572022*std::sin(0.60919988155365*x_104 - 7.1910400390625) + 0.0349486441590901*std::sin(0.640159845352173*x_104 - 7.17999982833862) + 0.276679416742249*std::sin(0.263999968767166*x_105 + 1.85087990760803) - 0.565720670171701*std::sin(0.319519847631454*x_105 + 1.92879974842072) + 0.00926095478016967*std::sin(0.355839848518372*x_105 - 7.42432022094727) - 0.135430514667529*std::sin(0.357599824666977*x_105 - 7.44007968902588) - 0.621588625293598*std::sin(0.187360003590584*x_106 - 7.61688041687012) - 0.0909653693223909*std::sin(0.432319849729538*x_106 + 5.221360206604) - 45.8370746342429*std::sin(0.299039930105209*x_107 + 5.11175966262817) - 1.79406794377985*std::sin(0.363919854164124*x_107 - 7.4172797203064) + 0.129497835083054*std::sin(0.44327986240387*x_107 + 5.22464036941528) - 0.298374723338082*std::sin(0.347679853439331*x_108 + 5.14847993850708) - 0.209369446986805*std::sin(0.663199841976166*x_108 + 2.2377598285675) - 0.232630884144457*std::sin(0.345519840717316*x_109 + 5.15944004058838) + 0.466845515959093*std::sin(0.375519841909409*x_110 + 5.1691198348999) + 0.019716873734268*std::sin(0.590079843997955*x_110 - 7.21264028549194) + 1.0346247533239*std::sin(0.3572798371315*x_111 - 7.43255996704102) - 0.0525626575061907*std::sin(0.401119828224182*x_111 - 4.20544004440308) + 0.556605802250232*std::sin(0.439599871635437*x_111 - 1.17359983921051) + 0.00610641857385134*std::sin(0.456559866666794*x_111 + 8.23095989227295) - 7.80819846704399*std::sin(0.473359853029251*x_111 + 2.04543972015381) + 0.00205347437041443*std::sin(0.496959865093231*x_111 - 4.12064027786255) - 65.7878823236756*std::sin(0.198719993233681*x_112 + 4.99071979522705) + 0.228462267981158*std::sin(0.353759855031967*x_112 - 7.41695976257324) - 0.0134491391243447*std::sin(0.411039859056473*x_112 - 0.981599867343903) + 0.864018762335093*std::sin(0.48583984375*x_112 + 5.23848009109497) - 0.207970186394122*std::sin(0.507519841194153*x_112 - 1.01695990562439) - 72.6032180821588*std::sin(0.304399937391281*x_113 - 7.4966402053833) + 5.00635609646537*std::sin(0.345999836921692*x_113 - 7.43743991851807) - 0.288348429043448*std::sin(0.268559962511063*x_114 - 7.53224039077759) - 1.2714793721034*std::sin(0.269199967384338*x_114 - 7.52320003509521) + 18.0492652212538*std::sin(0.367759823799133*x_114 - 7.42456007003784) + 0.228519527515691*std::sin(0.429439842700958*x_114 + 5.22695970535278) - 0.00915443424056959*std::sin(0.468559861183167*x_114 - 4.1592001914978) - 0.00209712091208168*std::sin(0.576479852199554*x_114 - 7.21895980834961) - 0.416431523368814*std::sin(0.665199875831604*x_114 + 5.43255996704102) - 0.0303992934940017*std::sin(0.302079945802689*x_115 + 5.103919506073) - 3.61172467805432*std::sin(0.325759828090668*x_115 - 7.45439958572388) + 1.51745472252346*std::sin(0.416079849004745*x_115 + 5.22344017028809) - 0.00381398487355252*std::sin(0.48447984457016*x_115 - 4.12936019897461) + 0.037677197693859*std::sin(0.534799814224243*x_115 + 5.36311960220337) + 0.544100261481582*std::sin(0.435039848089218*x_116 + 8.42255973815918) + 0.500121354061382*std::sin(0.49839985370636*x_116 - 4.12344026565552) - 0.0794862577086717*std::sin(0.243599966168404*x_117 - 1.35351991653442) - 13.9716988614992*std::sin(0.376959830522537*x_117 + 1.97719979286194) - 0.202712053906135*std::sin(0.378399848937988*x_117 + 5.1756796836853) - 1.17089541353153*std::sin(0.400079846382141*x_117 - 4.1864800453186) - 0.198332712392739*std::sin(0.616959869861603*x_117 - 3.99599981307983) - 0.0411726655019208*std::sin(0.191840007901192*x_118 + 1.78999984264374) + 2.87145065846587*std::sin(0.408879846334457*x_118 + 5.20247983932495) + 0.214447948736595*std::sin(0.419359862804413*x_118 + 5.21727991104126) - 0.0187683579478433*std::sin(0.289599925279617*x_119 - 4.28279972076416) - 1.46895055612568*std::sin(0.340479850769043*x_119 + 5.15120029449463) - 2.49707110582207*std::sin(0.34895983338356*x_119 + 5.15208005905151) - 0.0978912299179696*std::sin(0.366079837083817*x_119 - 7.41511964797974) + 10.883903531143*std::sin(0.434239864349365*x_119 + 1.99407982826233) + 0.981882134471235*std::sin(0.35471984744072*x_12 - 1.03167986869812) - 0.0132639699261808*std::sin(0.328399837017059*x_120 + 1.94799983501434) + 0.167954647388912*std::sin(0.36695984005928*x_120 + 5.15912008285522) - 0.288282012990371*std::sin(0.427679866552353*x_120 + 5.2294397354126) - 9.10776190388844*std::sin(0.211919993162155*x_14 - 4.38903999328613) - 0.0857992186368353*std::sin(0.272799968719482*x_16 + 5.08839988708496) + 0.171396827244135*std::sin(0.368559837341309*x_16 + 5.15863990783691) + 0.685718944668103*std::sin(0.369679838418961*x_16 + 5.18168020248413) + 0.00227658871040537*std::sin(0.427279859781265*x_18 - 0.954639852046967) + 0.137792233947101*std::sin(0.348479837179184*x_20 - 4.25511980056763) + 4.28044258072561*std::sin(0.361199855804443*x_20 + 5.16968011856079) - 1.8262514609107*std::sin(0.357999831438065*x_21 + 8.36407947540283) + 6.35164420362287*std::sin(0.209600001573563*x_22 - 7.57504034042358) + 0.109624689276635*std::sin(0.502079844474792*x_22 + 2.10895967483521) - 0.0390781008636119*std::sin(0.589439868927002*x_22 - 7.22200012207031) - 0.933091622515134*std::sin(0.162880018353462*x_24 + 4.93567991256714) + 0.0449312868494348*std::sin(0.182560011744499*x_24 + 4.98351955413818) + 0.0698604453712645*std::sin(0.190160006284714*x_24 - 7.60288000106812) - 1.15648395330695*std::sin(0.338639855384827*x_24 - 4.25832033157349) + 0.0301322351035304*std::sin(0.46111986041069*x_25 - 4.13752031326294) + 0.276388693218951*std::sin(0.186080008745193*x_26 - 7.6005597114563) - 0.715747754493414*std::sin(0.137440040707588*x_27 + 4.9017596244812) + 12.0525249185579*std::sin(0.171120017766953*x_27 - 7.6241602897644) - 0.0697284339048282*std::sin(0.301679939031601*x_27 + 5.12080001831055) - 38.6714432570517*std::sin(0.303999930620193*x_27 + 5.13247966766357) - 0.343812983778607*std::sin(0.319839835166931*x_28 - 4.28064012527466) - 3.33808780542824*std::sin(0.320079833269119*x_28 - 4.28864002227783) - 1.7887686045394*std::sin(0.322399854660034*x_28 - 4.28247976303101) - 0.0268351795165733*std::sin(0.326319843530655*x_28 + 5.13312005996704) + 21.4695432963902*std::sin(0.331519842147827*x_28 - 4.27248001098633) - 0.0867673068870183*std::sin(0.33247983455658*x_28 - 4.26847982406616) - 0.0557868057686314*std::sin(0.285919934511185*x_3 + 5.08111953735352) + 1.23061905569159*std::sin(0.294319927692413*x_3 + 5.10839986801147) + 0.647902691767698*std::sin(0.307759910821915*x_3 - 7.5032000541687) - 28.3933253869068*std::sin(0.261199980974197*x_30 - 7.53352022171021) - 2.81419890552058*std::sin(0.27295994758606*x_30 - 4.32471990585327) - 0.0136979845505298*std::sin(0.279999971389771*x_30 - 4.29591989517212) + 2.87229292331783*std::sin(0.360319852828979*x_31 + 5.10487985610962) - 7.86816736563821*std::sin(0.255839973688126*x_32 - 4.40239953994751) - 0.247149432652011*std::sin(0.348479837179184*x_32 + 8.2469596862793) + 0.288002776388699*std::sin(0.322319835424423*x_33 + 8.19719982147217) + 0.198279630970301*std::sin(0.351519852876663*x_34 + 2.00215983390808) - 0.0676219519061446*std::sin(0.313519835472107*x_35 + 1.97631978988647) - 0.00627062596659242*std::sin(0.315679848194122*x_35 + 1.98063981533051) + 3.31048844564521*std::sin(0.317599833011627*x_35 - 7.43431997299194) + 1.41779600337324*std::sin(0.318319827318192*x_35 - 7.43311977386475) + 0.17979005501944*std::sin(0.319839835166931*x_35 - 7.42831993103027) - 0.239662276848668*std::sin(0.319919854402542*x_35 - 7.42831993103027) + 0.031221288155836*std::sin(0.321919858455658*x_35 - 7.42599964141846) + 0.0197370178583282*std::sin(0.331519842147827*x_36 - 4.25288009643555) + 1.70619298127022*std::sin(0.352959841489792*x_36 + 5.1637601852417) - 0.540235805632371*std::sin(0.373759835958481*x_36 - 7.41639995574951) + 0.0606135047237616*std::sin(0.380639851093292*x_36 - 7.39903974533081) + 9.70412062265198*std::sin(0.393519848585129*x_36 - 4.2052001953125) - 0.214623978188473*std::sin(0.418559849262238*x_36 + 5.22079992294312) + 1.1763626410929*std::sin(0.293359935283661*x_37 + 5.09615993499756) - 0.283396348311696*std::sin(0.298719942569733*x_37 - 7.50471973419189) + 28.93405559173*std::sin(0.36303985118866*x_37 - 4.24047994613647) + 0.0166726250131162*std::sin(0.364959836006165*x_37 - 7.42208003997803) - 2.17501172767783*std::sin(0.401439845561981*x_37 - 4.20695972442627) + 0.132311144286745*std::sin(0.48039984703064*x_38 + 5.25888013839722) + 0.00183975943252589*std::sin(0.665279865264893*x_38 + 2.20815992355347) + 3.2182063675836*std::sin(0.19743999838829*x_39 + 4.99631977081299) + 0.0339930042936694*std::sin(0.350079834461212*x_39 + 5.16296005249023) - 0.742485685447533*std::sin(0.334239840507507*x_40 - 4.27408027648926) + 0.00721273648238972*std::sin(0.390239834785461*x_40 + 8.37495994567871) + 0.165162044367039*std::sin(0.312159925699234*x_41 + 1.89567983150482) + 2.66957300265261*std::sin(0.375519841909409*x_41 + 5.17112016677856) + 31.244937395518*std::sin(0.406959861516953*x_41 - 7.39175987243652) + 0.00348283341994604*std::sin(0.431519865989685*x_41 - 7.38671970367432) - 12.4485919411154*std::sin(0.121520057320595*x_42 + 1.70983994007111) + 40.1255757043483*std::sin(0.369279831647873*x_43 - 7.41183996200562) + 0.145421725406492*std::sin(0.380639851093292*x_43 - 4.22176027297974) - 0.410430602117612*std::sin(0.383359849452972*x_43 - 7.40655994415283) + 0.873892195517314*std::sin(0.440879851579666*x_43 - 7.37831974029541) - 1.0440428114735*std::sin(0.359359860420227*x_44 + 5.16416025161743) - 0.00786634738015464*std::sin(0.407279849052429*x_46 + 5.21623992919922) - 0.278639267854859*std::sin(0.585599839687347*x_46 - 7.21920013427734) + 0.0220235783462852*std::sin(0.645839810371399*x_46 + 5.4171199798584) - 5.19147464859807*std::sin(0.208159998059273*x_47 - 7.59176015853882) + 35.0755422498681*std::sin(0.260319977998734*x_47 + 1.85655987262726) - 0.100982951651217*std::sin(0.439279854297638*x_47 - 4.15232038497925) - 7.37677860740824*std::sin(0.424719870090485*x_48 - 4.17040014266968) + 0.0151684700813283*std::sin(0.259919971227646*x_49 + 1.85903990268707) - 0.225066492770322*std::sin(0.437279850244522*x_49 - 7.35431957244873) + 6.72100473952355*std::sin(0.191200003027916*x_50 + 4.98799991607666) - 48.0092983896862*std::sin(0.321759849786758*x_50 - 7.47687959671021) - 1.51208727464557*std::sin(0.36559984087944*x_51 - 4.23184013366699) + 9.1890539783509*std::sin(0.212960004806519*x_53 + 5.00816011428833) - 1.40043603321944*std::sin(0.347519844770432*x_53 + 5.15128040313721) - 0.174488548977383*std::sin(0.359999865293503*x_53 - 4.24272012710571) + 0.00419295459974676*std::sin(0.889279901981354*x_53 - 3.95743989944458) - 0.011551530365158*std::sin(0.319359838962555*x_54 + 1.90071976184845) - 1.4369557122329*std::sin(0.417919874191284*x_54 - 7.38679981231689) + 2.37850922084136*std::sin(0.487039864063263*x_54 - 1.10911989212036) - 0.0871209031655444*std::sin(0.658959865570068*x_54 - 3.96943998336792) - 2.38647780620653*std::sin(0.348079830408096*x_55 + 5.15960025787354) - 1.29446121773565*std::sin(0.403119832277298*x_55 + 8.38576030731201) + 0.00384422974728727*std::sin(0.441839843988419*x_55 - 4.14991998672485) + 0.0270206159410979*std::sin(0.465039849281311*x_55 + 5.25047969818115) - 1.2003503337255*std::sin(0.322559833526611*x_56 + 1.92327988147736) - 0.438477969141466*std::sin(0.406159847974777*x_56 + 5.19504022598267) + 1.25905955551416*std::sin(0.428879857063293*x_57 - 4.16879987716675) - 0.128206583228384*std::sin(0.448399841785431*x_57 - 4.15232038497925) + 14.4701778085966*std::sin(0.553839862346649*x_57 + 5.35767984390259) - 0.0692383201210778*std::sin(0.853919863700867*x_57 + 5.62479972839355) - 1.00118627117859*std::sin(0.170960009098053*x_58 + 4.96247959136963) - 22.0084643151571*std::sin(0.209440007805824*x_58 + 5.00848007202148) + 0.0251110020403538*std::sin(0.266239941120148*x_58 - 7.51327991485596) + 4.52276413189281*std::sin(0.2743199467659*x_58 + 5.07583951950073) - 0.150054011357327*std::sin(0.348079830408096*x_58 + 5.15759992599487) - 1.354697640667*std::sin(0.42223984003067*x_58 - 4.189040184021) + 0.0541346543193381*std::sin(0.462799847126007*x_58 + 5.25392007827759) + 0.346956918328832*std::sin(0.168560013175011*x_59 - 7.63191986083984) - 40.4813800409733*std::sin(0.251999974250793*x_59 - 7.52784013748169) + 0.00954364548057523*std::sin(0.203199997544289*x_64 + 1.78175985813141) + 0.025416009688832*std::sin(0.222240000963211*x_64 - 4.36191987991333) + 4.96881825405239*std::sin(0.228959992527962*x_64 - 4.36199951171875) + 0.00831530795724103*std::sin(0.339199841022491*x_64 - 7.4555196762085) + 1.56556124074847*std::sin(0.43495985865593*x_66 + 8.44768047332764) + 3.60758847706258*std::sin(0.243759974837303*x_67 - 7.55679988861084) - 4.42481967496831*std::sin(0.247279971837997*x_70 - 7.52800035476685) + 0.26918967440738*std::sin(0.439999878406525*x_70 - 4.15304040908813) - 0.00125292411942106*std::sin(0.624399840831757*x_70 - 3.97263979911804) - 0.453591624790365*std::sin(0.23063999414444*x_71 + 5.04759979248047) - 0.245667351320869*std::sin(0.214000001549721*x_72 + 5.00920009613037) - 63.1140473620983*std::sin(0.24959996342659*x_73 + 5.06479978561401) + 1.5317325385054*std::sin(0.342559844255447*x_73 - 4.26151990890503) - 0.0376713869448799*std::sin(0.451039850711823*x_73 - 4.15104007720947) - 0.0476244051475758*std::sin(0.123040057718754*x_75 + 4.89031982421875) + 0.098404307028722*std::sin(0.278559952974319*x_75 + 5.09087991714478) + 0.56503281928876*std::sin(0.409119844436646*x_75 - 7.38631963729858) - 10.1079410953754*std::sin(0.476879835128784*x_75 + 2.08039975166321) + 0.385034730969241*std::sin(0.540319859981537*x_75 + 5.16431999206543) - 55.4384757596021*std::sin(0.238319978117943*x_76 - 7.53840017318726) - 2.14288688069146*std::sin(0.393599838018417*x_78 + 8.3810396194458) - 0.00982822867186426*std::sin(0.486639857292175*x_78 + 5.28744029998779) + 2.05348241003982*std::sin(0.281759947538376*x_79 - 7.4986400604248) + 3.80115518431893*std::sin(0.332239836454391*x_79 + 5.12871980667114) + 31.6646820871926*std::sin(0.355119854211807*x_79 + 1.96583986282349) - 0.443309342600435*std::sin(0.249199971556664*x_8 - 4.33576011657715) - 1.14098292858195*std::sin(0.501679837703705*x_8 - 7.30711984634399) + 0.185465699315692*std::sin(0.389359831809998*x_81 + 8.37271976470947) - 4.36062426535995*std::sin(0.214159995317459*x_82 - 7.57696008682251) + 1.11469610522283*std::sin(0.197359994053841*x_83 + 5.00008010864258) - 1.02658118138995*std::sin(0.201599985361099*x_83 + 5.0053596496582) + 0.0282871261268214*std::sin(0.263119965791702*x_83 + 1.87455987930298) + 0.00370234835526077*std::sin(0.319679915904999*x_83 - 7.46343994140625) - 34.659811584079*std::sin(0.320559918880463*x_83 - 7.46808004379272) + 0.846138389072873*std::sin(0.322239845991135*x_83 - 7.4730396270752) + 2.32870968135671*std::sin(0.393679857254028*x_83 - 1.19831991195679) - 0.0216327992417657*std::sin(0.140080034732819*x_84 - 7.67984008789063) + 0.17363136612018*std::sin(0.179360002279282*x_84 + 1.77599990367889) + 5.45537471068684*std::sin(0.23871998488903*x_84 - 7.55600023269653) + 0.256581654328073*std::sin(0.278079956769943*x_84 + 5.09272003173828) - 3.95407353386967*std::sin(0.278479933738708*x_84 - 7.49608039855957) + 0.0174841408874848*std::sin(0.187040001153946*x_85 + 4.98767995834351) - 0.434701296983545*std::sin(0.19064000248909*x_85 - 7.61648035049438) - 0.334161861174179*std::sin(0.221919998526573*x_85 - 7.56135988235474) - 14.9179040143318*std::sin(0.230239987373352*x_85 - 7.55408048629761) + 0.00280109816683725*std::sin(0.524639844894409*x_86 - 7.27040004730225) - 10.6440916923169*std::sin(0.402799844741821*x_87 + 5.20991992950439) - 1.53137819494958*std::sin(0.417919844388962*x_87 - 4.18951988220215) + 0.0560777587502143*std::sin(0.499039828777313*x_87 - 4.11488008499146) - 0.00687576897505225*std::sin(0.87447988986969*x_87 - 0.751359879970551) + 0.662364004385881*std::sin(0.219119995832443*x_89 + 1.8155198097229) - 0.535498358188562*std::sin(0.41023987531662*x_90 - 7.39207983016968) + 0.00478202993916306*std::sin(0.414639860391617*x_90 - 0.994639813899994) - 0.090959245174226*std::sin(0.505279839038849*x_90 - 4.09320020675659) + 0.0201427481969751*std::sin(0.337039858102798*x_92 + 5.18400001525879) + 0.930267915191652*std::sin(0.341039836406708*x_92 + 5.20991992950439) - 0.00990930981274663*std::sin(0.360079854726791*x_92 + 1.97791981697083) - 5.44964729362931*std::sin(0.360879838466644*x_92 + 2.00343990325928) + 0.0217299113273298*std::sin(0.363839834928513*x_92 - 7.38535976409912) + 53.6921986532673*std::sin(0.365199834108353*x_92 + 1.99775981903076) + 0.0692190101894763*std::sin(0.381279855966568*x_92 + 1.97519981861115) + 0.0997282322620805*std::sin(0.401679873466492*x_92 - 7.59008026123047) + 0.00807796275175145*std::sin(0.374559849500656*x_94 - 1.18543982505798) + 0.0427080409068067*std::sin(0.376239836215973*x_94 + 1.98399984836578) + 2.11946313980093*std::sin(0.386319845914841*x_94 - 7.40639972686768) - 16.3436795837318*std::sin(0.404079854488373*x_94 - 4.21031999588013) - 0.0919910001596038*std::sin(0.367999851703644*x_95 + 1.98935985565186) + 4.79398143330911*std::sin(0.382479846477509*x_95 - 7.39607954025269) + 0.0147127531642232*std::sin(0.376959830522537*x_96 - 4.22176027297974) - 0.814983262385667*std::sin(0.386959820985794*x_96 - 4.2021598815918) + 0.0830024820689466*std::sin(0.396319836378098*x_96 + 5.20240020751953) - 1.01627641350284*std::sin(0.398799866437912*x_96 - 7.3931999206543) + 10.6010719532242*std::sin(0.411679863929749*x_96 + 1.98543977737427) - 0.656173550384728*std::sin(0.326879858970642*x_97 + 5.13624000549316) + 0.606844676056115*std::sin(0.339759826660156*x_97 + 5.16359996795654) + 0.0133635496032038*std::sin(0.362479835748672*x_97 - 4.41720008850098) + 3.61630668834181*std::sin(0.403599858283997*x_97 + 5.19040012359619) - 0.00466057871082345*std::sin(0.518239855766296*x_97 + 2.16407990455627) + 0.014444225709917*std::sin(0.395679831504822*x_98 - 4.19135999679565) - 0.35334810432192*std::sin(0.406559854745865*x_98 - 7.38751983642578) + 0.0971323924790291*std::sin(0.414239853620529*x_98 - 7.39607954025269) - 0.00567618504149729*std::sin(0.430639863014221*x_98 - 7.37799978256226) - 0.419808506758939*std::sin(0.433199852705002*x_98 - 7.38143968582153) + 25.8940548989924*std::sin(0.382719844579697*x_99 - 7.42312002182007) + 0.0205524011375619*std::sin(0.398159861564636*x_99 - 7.40983963012695) + 0.0541282539963897*std::sin(0.402159839868546*x_99 - 4.20552015304565) - 0.437270902457458*std::sin(0.403039842844009*x_99 + 5.20864009857178) - 0.566389151681724*std::sin(0.415279865264893*x_99 - 4.19144010543823) - 681.125249258249);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.253322521057322*x_1 - 2.30688475379113*x_10 - 1.56925136222935*x_100 + 11.478572300154*x_101 - 0.378209203800663*x_102 + 2.98551572549183*x_103 - 0.0101750372925954*x_104 + 1.46671289316417*x_105 + 0.01718960039512*x_106 - 0.0392506361109923*x_107 + 2.90477367782027*x_108 - 1.03308527615408*x_109 - 1.23859829141191*x_11 + 1.94746667686098*x_110 + 0.0135845999456794*x_111 - 0.0128099671723779*x_112 - 0.218200084633775*x_113 + 0.0110799529272709*x_114 + 2.00954012960591*x_115 - 0.00672411834199367*x_116 - 0.0174835744400283*x_117 - 2.5984262269881*x_118 + 0.0101559851010897*x_119 - 4.22590548227774*x_12 + 0.0711781054589549*x_120 + 1.14503007671903*x_13 - 7.38694785945372*x_14 - 5.48435091972764*x_15 + 0.997894683950671*x_16 - 1.3282966278195*x_17 + 1.89957837946779*x_18 + 2.90633524920572*x_19 - 0.599587737882642*x_2 - 10.9321160290624*x_20 - 1.58046286096023*x_21 - 3.62020272208087*x_22 - 5.87882991895945*x_23 + 0.0409267853109234*x_24 + 0.680569699218417*x_25 - 0.3622254296181*x_26 - 0.356897847022181*x_27 + 0.012978948316433*x_28 + 0.8446725833238*x_29 - 3.05541097591427*x_3 - 0.254507441257995*x_30 + 1.10047615634235*x_31 - 13.0727262799671*x_32 + 5.94777898279246*x_33 + 5.0327320091559*x_34 - 2.52336769433413*x_35 - 0.0311094384856808*x_36 + 0.0407106114002352*x_37 + 1.46395822770793*x_38 - 1.31633096984667*x_39 - 0.306446182032926*x_4 - 0.554268444065236*x_40 + 0.0505350100614864*x_41 + 0.554803094490392*x_42 + 0.721084857865994*x_43 - 5.49962904521016*x_44 + 1.29913386643971*x_45 - 4.67304902647202*x_46 - 0.0113651282592517*x_47 - 1.00876657714564*x_48 + 1.27454682947403*x_49 + 1.70663350654198*x_5 + 0.220608623790886*x_50 + 1.25584983396516*x_51 + 1.83328219411496*x_52 - 1.23821413262351*x_53 - 1.24410299622316*x_54 + 2.52114014206001*x_55 - 1.26767223188472*x_56 + 0.00441741748994819*x_57 + 0.00348492663644439*x_58 + 0.000591739552123348*x_59 + 0.951957176905901*x_6 - 0.546880712371691*x_60 + 4.84398712714155*x_61 - 85.9013125899831*x_62 + 0.296104060344302*x_63 + 0.926173981500111*x_64 + 4.2620047793114*x_65 - 0.00576444642342432*x_66 - 1.52377202871741*x_67 + 0.608785601339646*x_68 + 0.121545955287828*x_69 - 1.04380167383296*x_7 - 0.0105060155284905*x_70 - 3.17176870644713*x_71 - 1.79874328331242*x_72 + 0.0104614823239852*x_73 - 9.53541121681454*x_74 + 0.033460409969369*x_75 - 0.936428471360206*x_76 + 7.37230921199142*x_77 - 2.82690136808268*x_78 + 0.00979505807265852*x_79 + 6.27583546785159*x_8 - 0.621351324650423*x_80 - 0.143953104373953*x_81 - 1.36996426206796*x_82 - 0.0362925149943885*x_83 - 0.0143086732329849*x_84 - 0.830663191126558*x_85 + 0.401174665505598*x_86 + 0.00983416086641126*x_87 - 0.03255617221719*x_88 - 1.33291507125123*x_89 - 10.0137656961479*x_9 + 2.04658680654698*x_90 - 2.33126122600851*x_91 + 0.0369029772278062*x_92 + 9.30060109882936*x_93 - 0.875724078183075*x_94 - 1.20089249856155*x_95 - 0.0376953598891572*x_96 - 5.90610191865054*x_97 + 1.01864863629606*x_98 + 0.01781727515001*x_99 - 0.0361493340165713*std::pow(-7.36319971084595*x_106 - 7.55671977996826, 2) - 1.9189050453921e-5*std::pow(-5.29512023925781*x_108 - 7.73583984375, 2) - 0.0795668538767202*std::pow(-0.582399845123291*x_108 - 0.778079867362976, 2) + 8.10683341795823e-5*std::pow(-7.56576013565063*x_109 - 9.54831981658936, 2) - 0.00512242988306464*std::pow(-6.31343984603882*x_11 - 9.7729606628418, 2) + 0.018136783659266*std::pow(-8.15095996856689*x_116 - 8.55615997314453, 2) + 0.00022800530671889*std::pow(-7.33599996566772*x_118 - 8.55144023895264, 2) - 0.00878047788827011*std::pow(-6.34631967544556*x_120 - 8.5252799987793, 2) + 2.86553841468825e-5*std::pow(-4.97463989257813*x_120 - 5.7960000038147, 2) + 0.000197958725518705*std::pow(-5.00879955291748*x_13 - 7.81375980377197, 2) - 2.13535194856062e-5*std::pow(-5.29879999160767*x_15 - 5.5019998550415, 2) - 0.000183387426869771*std::pow(-5.08487987518311*x_15 - 7.32096004486084, 2) - 0.000317100337264209*std::pow(-8.73536014556885*x_18 - 9.75536060333252, 2) - 0.00015243104510812*std::pow(-6.31343984603882*x_19 - 9.57096099853516, 2) - 0.000690311026315116*std::pow(-7.01279973983765*x_23 - 9.21599960327148, 2) + 0.000265345381293123*std::pow(-6.67776012420654*x_24 - 9.96127986907959, 2) - 0.0254085509370473*std::pow(-4.61759996414185*x_24 - 6.62983989715576, 2) + 5.11873024362588e-5*std::pow(-7.44783973693848*x_27 - 8.82520008087158, 2) + 0.0502107608600013*std::pow(-5.21519994735718*x_39 - 6.82528018951416, 2) - 5.68738475588579e-5*std::pow(-6.29800033569336*x_4 - 9.95495986938477, 2) - 0.000417055915178368*std::pow(-4.83800029754639*x_44 - 6.05071973800659, 2) + 0.000465933731295496*std::pow(-5.75367975234985*x_47 - 7.59768009185791, 2) - 8.04848981074876e-5*std::pow(-6.32687997817993*x_5 - 9.3877592086792, 2) + 0.000110325745667833*std::pow(-7.51128005981445*x_50 - 8.1159200668335, 2) - 0.000250131806532397*std::pow(-7.70344018936157*x_59 - 9.92232036590576, 2) - 0.000712064372095849*std::pow(-6.26208019256592*x_59 - 9.90112018585205, 2) + 0.000191149913692673*std::pow(-4.89711999893188*x_6 - 7.75040006637573, 2) + 4.65795815574767e-5*std::pow(-8.05943965911865*x_64 - 9.632080078125, 2) + 6.16169758890878e-5*std::pow(-3.31583976745605*x_66 - 4.76936006546021, 2) - 0.000770206514168429*std::pow(-5.33400011062622*x_67 - 5.12992000579834, 2) - 0.000121806497859248*std::pow(-4.89463996887207*x_7 - 6.54287958145142, 2) - 0.000198281711109225*std::pow(-6.32664012908936*x_70 - 8.89144039154053, 2) - 0.0414026850323649*std::pow(-5.72743988037109*x_70 - 7.97160005569458, 2) + 0.000160530073214574*std::pow(-6.03951978683472*x_72 - 8.25783920288086, 2) + 3.57008306752063e-5*std::pow(-5.92343997955322*x_72 - 7.55639982223511, 2) + 0.00266395311325087*std::pow(-5.51567983627319*x_72 - 6.31112003326416, 2) - 0.000521600248620802*std::pow(-5.3295202255249*x_72 - 7.79544019699097, 2) + 0.000297971123362903*std::pow(-5.7279200553894*x_73 - 7.8930401802063, 2) + 0.000116220106214707*std::pow(-7.48496007919312*x_74 - 9.9323205947876, 2) - 0.0013719049234619*std::pow(-5.3471999168396*x_74 - 6.92751979827881, 2) + 8.00242037565649e-5*std::pow(-6.85536003112793*x_77 - 8.66800022125244, 2) - 0.0141948871022121*std::pow(-4.26240015029907*x_78 - 5.81343936920166, 2) + 0.031436623983865*std::pow(-7.15487957000732*x_81 - 9.58255958557129, 2) + 3.97489073422097e-5*std::pow(-8.56280040740967*x_84 - 8.97383975982666, 2) + 8.85773924590673e-5*std::pow(-8.34360027313232*x_84 - 8.74335956573486, 2) - 1.99995337981493e-5*std::pow(-7.32399988174438*x_84 - 6.70928001403809, 2) - 0.0001824425906014*std::pow(-5.07727956771851*x_86 - 7.30615997314453, 2) + 0.00936821946533804*std::pow(-4.13991975784302*x_87 - 5.91967964172363, 2) + 0.026197225680132*std::pow(-8.75607967376709*x_88 - 9.97624015808105, 2) + 1.34416795896034e-5*std::pow(-8.0033597946167*x_88 - 9.20728015899658, 2) + 0.00412058548656522*std::pow(-2.1943998336792*x_88 - 2.17791986465454, 2) + 0.000306383025345985*std::pow(-3.1781599521637*x_90 - 4.56775999069214, 2) - 0.000249689847818092*std::pow(-5.24519968032837*x_99 - 6.02455997467041, 2) - 0.00433859654396446*std::exp(0.702079832553864*x_1) - 0.000237299546127338*std::exp(1.08351981639862*x_1) + 0.00010162368704101*std::exp(1.19423997402191*x_1) + 0.0277574308984185*std::exp(1.22735989093781*x_1) - 2.74978629693436e-5*std::exp(1.28807985782623*x_1) - 0.00052428608252023*std::exp(1.19983983039856*x_100) - 0.000380362668341918*std::exp(1.62295985221863*x_100) - 0.0239970270930156*std::exp(0.515199840068817*x_103) + 0.0347630047159956*std::exp(0.528799831867218*x_104) - 0.0708019845205434*std::exp(1.06327986717224*x_104) - 0.0286235040630125*std::exp(0.650879800319672*x_106) + 0.00660699803810671*std::exp(0.665519833564758*x_106) + 0.000683646396231775*std::exp(0.792479872703552*x_106) + 1.20223596463889*std::exp(1.33487987518311*x_106) - 0.0781732053428809*std::exp(0.648639798164368*x_109) - 0.875081118104466*std::exp(0.855439901351929*x_110) + 0.00093767362763316*std::exp(1.08487975597382*x_110) + 0.000249917560586752*std::exp(1.55039989948273*x_110) + 2.92834271932956e-5*std::exp(1.59975981712341*x_110) - 0.692031958336203*std::exp(0.604959845542908*x_112) - 0.000177111941273603*std::exp(0.914159834384918*x_112) + 0.000847577427819674*std::exp(0.571999847888947*x_24) + 0.0936905462281553*std::exp(0.514479875564575*x_26) - 3.03810174272832*std::exp(0.62559986114502*x_26) + 0.00989524908861963*std::exp(0.643839836120605*x_26) + 0.00114997266607228*std::exp(0.829519867897034*x_26) - 0.0014793025613704*std::exp(0.874719858169556*x_26) + 0.00100568618147668*std::exp(0.913679838180542*x_26) + 9.73611026215218*std::exp(0.491599857807159*x_31) - 0.00756819635198743*std::exp(0.599999845027924*x_31) + 0.0604647399238305*std::exp(0.620239853858948*x_31) - 0.00125265204897352*std::exp(0.647599816322327*x_31) + 0.00343703080694575*std::exp(0.654319822788239*x_31) - 0.181371374063111*std::exp(0.655279815196991*x_31) - 0.247990935606225*std::exp(0.654959857463837*x_45) + 0.00835549522549994*std::exp(0.825759887695313*x_45) + 0.000590180724421761*std::exp(1.0123997926712*x_45) - 0.0149773414708601*std::exp(1.11879980564117*x_45) + 0.000237207798125798*std::exp(1.23079991340637*x_45) + 0.257780342582188*std::exp(0.99375981092453*x_6) + 0.00271352215017502*std::exp(0.713119864463806*x_60) - 1.26797069874538*std::exp(0.968719840049744*x_60) + 0.0018236119732605*std::exp(1.24247992038727*x_60) + 9.38537462802316e-5*std::exp(1.45055985450745*x_66) + 0.0681661496121631*std::exp(1.66143977642059*x_66) - 0.000569132948003363*std::exp(0.718239843845367*x_70) - 0.00127710517124746*std::exp(0.895999848842621*x_70) - 0.0252411658554652*std::exp(0.875359892845154*x_72) - 0.000518387596739774*std::exp(0.97439980506897*x_74) + 0.00150407237588701*std::exp(1.0343998670578*x_74) + 0.00384610940504633*std::exp(1.24767982959747*x_74) + 5.9552399662629e-5*std::exp(1.71327984333038*x_74) - 0.192440873492348*std::exp(0.599999845027924*x_76) - 0.0119216179198346*std::exp(0.73831981420517*x_77) - 0.00640275413983697*std::exp(0.885519862174988*x_81) + 0.00461890414512736*std::exp(1.09175980091095*x_81) + 0.00861645330107018*std::exp(0.719999849796295*x_87) - 0.120621957579473*std::sin(0.222879990935326*x_1 - 1.19911992549896) - 0.649637439529916*std::sin(0.184960007667542*x_10 + 1.76799988746643) - 1.04272637240683*std::sin(0.330879837274551*x_10 - 7.47408008575439) + 0.164920296231075*std::sin(0.372159838676453*x_100 - 7.40847969055176) + 0.125717273080933*std::sin(0.155280038714409*x_102 - 7.65199995040894) + 5.62502895413626*std::sin(0.298239946365356*x_102 - 7.52088022232056) + 0.0493361659088856*std::sin(0.342959851026535*x_102 - 7.44087982177734) - 0.0982744409834814*std::sin(0.371279835700989*x_102 + 1.97439980506897) - 0.150029446983215*std::sin(0.430479854345322*x_102 - 4.16527986526489) - 0.195398542054797*std::sin(0.445199847221375*x_102 + 5.23176002502441) + 0.187247121163544*std::sin(0.314079850912094*x_103 - 7.47591972351074) + 27.648292842702*std::sin(0.465919852256775*x_103 - 7.36799955368042) + 41.4398883413361*std::sin(0.487919867038727*x_104 - 4.14376020431519) - 0.345454254744189*std::sin(0.60919988155365*x_104 - 7.1910400390625) - 0.0190771820861972*std::sin(0.640159845352173*x_104 - 7.17999982833862) + 0.457374419109278*std::sin(0.263999968767166*x_105 + 1.85087990760803) + 2.5779576655299*std::sin(0.319519847631454*x_105 + 1.92879974842072) + 0.100442497083761*std::sin(0.355839848518372*x_105 - 7.42432022094727) + 0.0739265470951854*std::sin(0.357599824666977*x_105 - 7.44007968902588) - 1.02753844057523*std::sin(0.187360003590584*x_106 - 7.61688041687012) + 0.0496546563066041*std::sin(0.432319849729538*x_106 + 5.221360206604) - 65.6595090188745*std::sin(0.299039930105209*x_107 + 5.11175966262817) + 8.17546795089702*std::sin(0.363919854164124*x_107 - 7.4172797203064) - 0.0706881150639774*std::sin(0.44327986240387*x_107 + 5.22464036941528) + 0.151469351639029*std::sin(0.347679853439331*x_108 + 5.14847993850708) + 0.954084938461897*std::sin(0.663199841976166*x_108 + 2.2377598285675) + 0.118094618734341*std::sin(0.345519840717316*x_109 + 5.15944004058838) - 0.144311428229651*std::sin(0.375519841909409*x_110 + 5.1691198348999) - 0.0107627176804613*std::sin(0.590079843997955*x_110 - 7.21264028549194) - 4.71472752262843*std::sin(0.3572798371315*x_111 - 7.43255996704102) + 0.0286920254650052*std::sin(0.401119828224182*x_111 - 4.20544004440308) - 0.172058155294952*std::sin(0.439599871635437*x_111 - 1.17359983921051) + 0.00637865424656723*std::sin(0.456559866666794*x_111 + 8.23095989227295) - 11.1848865085521*std::sin(0.473359853029251*x_111 + 2.04543972015381) + 0.0222715798055275*std::sin(0.496959865093231*x_111 - 4.12064027786255) - 94.2381268270784*std::sin(0.198719993233681*x_112 + 4.99071979522705) - 0.12470916657774*std::sin(0.353759855031967*x_112 - 7.41695976257324) + 0.0185421740904997*std::sin(0.411039859056473*x_112 - 0.981599867343903) - 0.26708574324342*std::sin(0.48583984375*x_112 + 5.23848009109497) + 0.105575663182677*std::sin(0.507519841194153*x_112 - 1.01695990562439) - 104.000783001617*std::sin(0.304399937391281*x_113 - 7.4966402053833) - 1.54756632292564*std::sin(0.345999836921692*x_113 - 7.43743991851807) + 0.157398823831052*std::sin(0.268559962511063*x_114 - 7.53224039077759) + 5.79406086201917*std::sin(0.269199967384338*x_114 - 7.52320003509521) + 25.8547453570178*std::sin(0.367759823799133*x_114 - 7.42456007003784) + 0.377762059004138*std::sin(0.429439842700958*x_114 + 5.22695970535278) - 0.00956255620824582*std::sin(0.468559861183167*x_114 - 4.1592001914978) - 0.0227449616261057*std::sin(0.576479852199554*x_114 - 7.21895980834961) + 0.128727439469438*std::sin(0.665199875831604*x_114 + 5.43255996704102) + 0.0093356714843914*std::sin(0.302079945802689*x_115 + 5.103919506073) + 1.1164574336577*std::sin(0.325759828090668*x_115 - 7.45439958572388) - 6.9149568687964*std::sin(0.416079849004745*x_115 + 5.22344017028809) - 0.0413657310323558*std::sin(0.48447984457016*x_115 - 4.12936019897461) + 0.0622835865847868*std::sin(0.534799814224243*x_115 + 5.36311960220337) - 0.168192438719736*std::sin(0.435039848089218*x_116 + 8.42255973815918) - 2.27902522636555*std::sin(0.49839985370636*x_116 - 4.12344026565552) + 0.109586793222226*std::sin(0.243599966168404*x_117 - 1.35351991653442) - 20.0138183932069*std::sin(0.376959830522537*x_117 + 1.97719979286194) + 0.110653069853884*std::sin(0.378399848937988*x_117 + 5.1756796836853) + 5.33570535071887*std::sin(0.400079846382141*x_117 - 4.1864800453186) + 0.0613086685244391*std::sin(0.616959869861603*x_117 - 3.99599981307983) - 0.446550645454247*std::sin(0.191840007901192*x_118 + 1.78999984264374) - 0.887623703020619*std::sin(0.408879846334457*x_118 + 5.20247983932495) - 0.117059264085798*std::sin(0.419359862804413*x_118 + 5.21727991104126) + 0.0258757201664891*std::sin(0.289599925279617*x_119 - 4.28279972076416) + 0.454082443777422*std::sin(0.340479850769043*x_119 + 5.15120029449463) + 11.3790143051931*std::sin(0.34895983338356*x_119 + 5.15208005905151) + 0.0534352293979098*std::sin(0.366079837083817*x_119 - 7.41511964797974) + 15.5906930746792*std::sin(0.434239864349365*x_119 + 1.99407982826233) - 0.303519704773469*std::sin(0.35471984744072*x_12 - 1.03167986869812) - 0.0138553027560657*std::sin(0.328399837017059*x_120 + 1.94799983501434) - 0.0916802773771681*std::sin(0.36695984005928*x_120 + 5.15912008285522) + 0.146345806737017*std::sin(0.427679866552353*x_120 + 5.2294397354126) + 2.81539413659253*std::sin(0.211919993162155*x_14 - 4.38903999328613) + 0.0435558075183579*std::sin(0.272799968719482*x_16 + 5.08839988708496) - 0.0935592370178511*std::sin(0.368559837341309*x_16 + 5.15863990783691) - 0.211969649244428*std::sin(0.369679838418961*x_16 + 5.18168020248413) + 0.0246914341267981*std::sin(0.427279859781265*x_18 - 0.954639852046967) - 0.0752157229650068*std::sin(0.348479837179184*x_20 - 4.25511980056763) - 1.32317171561663*std::sin(0.361199855804443*x_20 + 5.16968011856079) + 0.564531408401923*std::sin(0.357999831438065*x_21 + 8.36407947540283) - 1.96342219277462*std::sin(0.209600001573563*x_22 - 7.57504034042358) - 0.0556507616415865*std::sin(0.502079844474792*x_22 + 2.10895967483521) + 0.0213313009330005*std::sin(0.589439868927002*x_22 - 7.22200012207031) + 0.473682158800141*std::sin(0.162880018353462*x_24 + 4.93567991256714) + 0.0469344084752313*std::sin(0.182560011744499*x_24 + 4.98351955413818) - 0.0963157959879418*std::sin(0.190160006284714*x_24 - 7.60288000106812) + 0.357492672246256*std::sin(0.338639855384827*x_24 - 4.25832033157349) - 0.0164480811649638*std::sin(0.46111986041069*x_25 - 4.13752031326294) - 0.150870443016388*std::sin(0.186080008745193*x_26 - 7.6005597114563) + 0.390700428265573*std::sin(0.137440040707588*x_27 + 4.9017596244812) - 3.72568017751497*std::sin(0.171120017766953*x_27 - 7.6241602897644) + 0.0214137131899141*std::sin(0.301679939031601*x_27 + 5.12080001831055) - 55.3950704221512*std::sin(0.303999930620193*x_27 + 5.13247966766357) + 0.187674888481682*std::sin(0.319839835166931*x_28 - 4.28064012527466) + 1.03187072016247*std::sin(0.320079833269119*x_28 - 4.28864002227783) + 8.15131915638152*std::sin(0.322399854660034*x_28 - 4.28247976303101) + 0.0369973546816409*std::sin(0.326319843530655*x_28 + 5.13312005996704) + 30.754136972069*std::sin(0.331519842147827*x_28 - 4.27248001098633) - 0.143433678776678*std::sin(0.33247983455658*x_28 - 4.26847982406616) + 0.0769126302398376*std::sin(0.285919934511185*x_3 + 5.08111953735352) - 0.380409337698424*std::sin(0.294319927692413*x_3 + 5.10839986801147) - 2.95245657234524*std::sin(0.307759910821915*x_3 - 7.5032000541687) - 40.6721375479036*std::sin(0.261199980974197*x_30 - 7.53352022171021) + 0.869926023694703*std::sin(0.27295994758606*x_30 - 4.32471990585327) - 0.148565650727083*std::sin(0.279999971389771*x_30 - 4.29591989517212) - 13.0888792821855*std::sin(0.360319852828979*x_31 + 5.10487985610962) + 2.43221029498905*std::sin(0.255839973688126*x_32 - 4.40239953994751) - 0.408558863985561*std::sin(0.348479837179184*x_32 + 8.2469596862793) + 0.476092887948198*std::sin(0.322319835424423*x_33 + 8.19719982147217) - 0.108233572861526*std::sin(0.351519852876663*x_34 + 2.00215983390808) + 0.0343281531934045*std::sin(0.313519835472107*x_35 + 1.97631978988647) - 0.068009977946494*std::sin(0.315679848194122*x_35 + 1.98063981533051) - 1.02333919765158*std::sin(0.317599833011627*x_35 - 7.43431997299194) - 6.46081762213917*std::sin(0.318319827318192*x_35 - 7.43311977386475) - 0.0981407919941055*std::sin(0.319839835166931*x_35 - 7.42831993103027) - 0.39618196375693*std::sin(0.319919854402542*x_35 - 7.42831993103027) - 0.0095881073551896*std::sin(0.321919858455658*x_35 - 7.42599964141846) - 0.00606126964244337*std::sin(0.331519842147827*x_36 - 4.25288009643555) - 0.527418894570868*std::sin(0.352959841489792*x_36 + 5.1637601852417) + 2.4618245536282*std::sin(0.373759835958481*x_36 - 7.41639995574951) - 0.0330866874615796*std::sin(0.380639851093292*x_36 - 7.39903974533081) + 13.90070811952*std::sin(0.393519848585129*x_36 - 4.2052001953125) + 0.108953447727414*std::sin(0.418559849262238*x_36 + 5.22079992294312) - 5.36061920298585*std::sin(0.293359935283661*x_37 + 5.09615993499756) + 0.154695664721499*std::sin(0.298719942569733*x_37 - 7.50471973419189) + 41.4467087884042*std::sin(0.36303985118866*x_37 - 4.24047994613647) + 0.180828017090035*std::sin(0.364959836006165*x_37 - 7.42208003997803) + 0.672340288398381*std::sin(0.401439845561981*x_37 - 4.20695972442627) - 0.0722237972981515*std::sin(0.48039984703064*x_38 + 5.25888013839722) + 0.0199536695538123*std::sin(0.665279865264893*x_38 + 2.20815992355347) - 0.994812933545326*std::sin(0.19743999838829*x_39 + 4.99631977081299) + 0.368681449773003*std::sin(0.350079834461212*x_39 + 5.16296005249023) + 0.405295683380419*std::sin(0.334239840507507*x_40 - 4.27408027648926) + 0.0782279236099559*std::sin(0.390239834785461*x_40 + 8.37495994567871) + 0.273026793936203*std::sin(0.312159925699234*x_41 + 1.89567983150482) - 0.825219220505211*std::sin(0.375519841909409*x_41 + 5.17112016677856) + 44.7569410806723*std::sin(0.406959861516953*x_41 - 7.39175987243652) + 0.0377741273907556*std::sin(0.431519865989685*x_41 - 7.38671970367432) + 3.8481125362847*std::sin(0.121520057320595*x_42 + 1.70983994007111) + 57.478048520116*std::sin(0.369279831647873*x_43 - 7.41183996200562) - 0.0793803823186953*std::sin(0.380639851093292*x_43 - 4.22176027297974) + 0.208354301933044*std::sin(0.383359849452972*x_43 - 7.40655994415283) - 0.270137821919016*std::sin(0.440879851579666*x_43 - 7.37831974029541) + 4.75764509039878*std::sin(0.359359860420227*x_44 + 5.16416025161743) - 0.0853168590654279*std::sin(0.407279849052429*x_46 + 5.21623992919922) + 1.26974366389345*std::sin(0.585599839687347*x_46 - 7.21920013427734) - 0.0120218630625312*std::sin(0.645839810371399*x_46 + 5.4171199798584) + 23.6572615628408*std::sin(0.208159998059273*x_47 - 7.59176015853882) + 50.2441070045213*std::sin(0.260319977998734*x_47 + 1.85655987262726) + 0.0551228868130737*std::sin(0.439279854297638*x_47 - 4.15232038497925) - 10.5668973285987*std::sin(0.424719870090485*x_48 - 4.17040014266968) + 0.164514248052621*std::sin(0.259919971227646*x_49 + 1.85903990268707) + 0.114254570072826*std::sin(0.437279850244522*x_49 - 7.35431957244873) - 2.07759903424645*std::sin(0.191200003027916*x_50 + 4.98799991607666) - 68.7711200106239*std::sin(0.321759849786758*x_50 - 7.47687959671021) + 6.8904977070038*std::sin(0.36559984087944*x_51 - 4.23184013366699) - 2.84052316743548*std::sin(0.212960004806519*x_53 + 5.00816011428833) + 6.38170920257623*std::sin(0.347519844770432*x_53 + 5.15128040313721) + 0.0952468944330151*std::sin(0.359999865293503*x_53 - 4.24272012710571) - 0.00212854529891228*std::sin(0.889279901981354*x_53 - 3.95743989944458) - 0.125285630105852*std::sin(0.319359838962555*x_54 + 1.90071976184845) + 0.444192187878389*std::sin(0.417919874191284*x_54 - 7.38679981231689) + 3.4071054683023*std::sin(0.487039864063263*x_54 - 1.10911989212036) - 0.144018203257734*std::sin(0.658959865570068*x_54 - 3.96943998336792) + 0.737708747066996*std::sin(0.348079830408096*x_55 + 5.15960025787354) + 5.89878785581577*std::sin(0.403119832277298*x_55 + 8.38576030731201) + 0.041693760994062*std::sin(0.441839843988419*x_55 - 4.14991998672485) - 0.00829807422273725*std::sin(0.465039849281311*x_55 + 5.25047969818115) + 5.46992978568349*std::sin(0.322559833526611*x_56 + 1.92327988147736) + 0.135542443508414*std::sin(0.406159847974777*x_56 + 5.19504022598267) - 5.73746444780119*std::sin(0.428879857063293*x_57 - 4.16879987716675) + 0.0699832680708133*std::sin(0.448399841785431*x_57 - 4.15232038497925) + 20.7278666430969*std::sin(0.553839862346649*x_57 + 5.35767984390259) + 0.0351486993937891*std::sin(0.853919863700867*x_57 + 5.62479972839355) + 0.50825027558882*std::sin(0.170960009098053*x_58 + 4.96247959136963) - 31.5261166364463*std::sin(0.209440007805824*x_58 + 5.00848007202148) + 0.272348997385165*std::sin(0.266239941120148*x_58 - 7.51327991485596) - 1.39807822739478*std::sin(0.2743199467659*x_58 + 5.07583951950073) + 0.0819089771951415*std::sin(0.348079830408096*x_58 + 5.15759992599487) + 6.17328188869749*std::sin(0.42223984003067*x_58 - 4.189040184021) + 0.0894891508899439*std::sin(0.462799847126007*x_58 + 5.25392007827759) - 0.189391046957207*std::sin(0.168560013175011*x_59 - 7.63191986083984) - 57.9877219282905*std::sin(0.251999974250793*x_59 - 7.52784013748169) + 0.103508504911798*std::sin(0.203199997544289*x_64 + 1.78175985813141) - 0.00780529708513992*std::sin(0.222240000963211*x_64 - 4.36191987991333) - 1.53596261363404*std::sin(0.228959992527962*x_64 - 4.36199951171875) + 0.00868602009041725*std::sin(0.339199841022491*x_64 - 7.4555196762085) - 7.13417559980451*std::sin(0.43495985865593*x_66 + 8.44768047332764) - 16.4395802714759*std::sin(0.243759974837303*x_67 - 7.55679988861084) + 20.1636574392977*std::sin(0.247279971837997*x_70 - 7.52800035476685) - 0.136653617954786*std::sin(0.439999878406525*x_70 - 4.15304040908813) - 0.0135889689776477*std::sin(0.624399840831757*x_70 - 3.97263979911804) + 0.247599019278381*std::sin(0.23063999414444*x_71 + 5.04759979248047) + 0.124712556101097*std::sin(0.214000001549721*x_72 + 5.00920009613037) - 90.4079807678987*std::sin(0.24959996342659*x_73 + 5.06479978561401) - 6.9800200830263*std::sin(0.342559844255447*x_73 - 4.26151990890503) + 0.0205634274370024*std::sin(0.451039850711823*x_73 - 4.15104007720947) - 0.516524946800746*std::sin(0.123040057718754*x_75 + 4.89031982421875) - 0.0537152993606107*std::sin(0.278559952974319*x_75 + 5.09087991714478) - 0.174663117371212*std::sin(0.409119844436646*x_75 - 7.38631963729858) - 14.4791624424096*std::sin(0.476879835128784*x_75 + 2.08039975166321) - 1.75458187853757*std::sin(0.540319859981537*x_75 + 5.16431999206543) - 79.4130761654436*std::sin(0.238319978117943*x_76 - 7.53840017318726) + 0.662409845903422*std::sin(0.393599838018417*x_78 + 8.3810396194458) + 0.013550066316518*std::sin(0.486639857292175*x_78 + 5.28744029998779) - 9.35760526195064*std::sin(0.281759947538376*x_79 - 7.4986400604248) - 1.17501424950962*std::sin(0.332239836454391*x_79 + 5.12871980667114) + 45.3582061175131*std::sin(0.355119854211807*x_79 + 1.96583986282349) + 0.241986298833318*std::sin(0.249199971556664*x_8 - 4.33576011657715) + 0.352700990757162*std::sin(0.501679837703705*x_8 - 7.30711984634399) - 0.0573312135190429*std::sin(0.389359831809998*x_81 + 8.37271976470947) + 19.8711225240691*std::sin(0.214159995317459*x_82 - 7.57696008682251) - 0.608471689868969*std::sin(0.197359994053841*x_83 + 5.00008010864258) + 0.521141952677326*std::sin(0.201599985361099*x_83 + 5.0053596496582) + 0.0295482196331379*std::sin(0.263119965791702*x_83 + 1.87455987930298) + 0.0401549432756798*std::sin(0.319679915904999*x_83 - 7.46343994140625) - 49.6485918758266*std::sin(0.320559918880463*x_83 - 7.46808004379272) - 3.85580563204008*std::sin(0.322239845991135*x_83 - 7.4730396270752) - 0.719851446700517*std::sin(0.393679857254028*x_83 - 1.19831991195679) - 0.234625092804399*std::sin(0.140080034732819*x_84 - 7.67984008789063) - 0.0533224692805422*std::sin(0.179360002279282*x_84 + 1.77599990367889) - 1.68636709385492*std::sin(0.23871998488903*x_84 - 7.55600023269653) - 0.140058507486368*std::sin(0.278079956769943*x_84 + 5.09272003173828) + 18.0184934264721*std::sin(0.278479933738708*x_84 - 7.49608039855957) + 0.189629558915856*std::sin(0.187040001153946*x_85 + 4.98767995834351) + 0.220675273274192*std::sin(0.19064000248909*x_85 - 7.61648035049438) + 0.18240669488817*std::sin(0.221919998526573*x_85 - 7.56135988235474) - 21.3692139166312*std::sin(0.230239987373352*x_85 - 7.55408048629761) + 0.0303801606996644*std::sin(0.524639844894409*x_86 - 7.27040004730225) - 15.2471736044713*std::sin(0.402799844741821*x_87 + 5.20991992950439) + 0.473380094524209*std::sin(0.417919844388962*x_87 - 4.18951988220215) - 0.0306107902153172*std::sin(0.499039828777313*x_87 - 4.11488008499146) + 0.00947954394424391*std::sin(0.87447988986969*x_87 - 0.751359879970551) - 0.336247806687302*std::sin(0.219119995832443*x_89 + 1.8155198097229) + 0.165533415751167*std::sin(0.41023987531662*x_90 - 7.39207983016968) + 0.0518649577306375*std::sin(0.414639860391617*x_90 - 0.994639813899994) - 0.150363306436113*std::sin(0.505279839038849*x_90 - 4.09320020675659) - 0.0277705762633793*std::sin(0.337039858102798*x_92 + 5.18400001525879) - 4.23917920877271*std::sin(0.341039836406708*x_92 + 5.20991992950439) - 0.107474428457436*std::sin(0.360079854726791*x_92 + 1.97791981697083) + 1.68459663294787*std::sin(0.360879838466644*x_92 + 2.00343990325928) - 0.00667329040317777*std::sin(0.363839834928513*x_92 - 7.38535976409912) + 76.9116142303666*std::sin(0.365199834108353*x_92 + 1.99775981903076) - 0.0377841170375565*std::sin(0.381279855966568*x_92 + 1.97519981861115) - 0.0506268443648554*std::sin(0.401679873466492*x_92 - 7.59008026123047) + 0.0876119978334094*std::sin(0.374559849500656*x_94 - 1.18543982505798) - 0.013115707433351*std::sin(0.376239836215973*x_94 + 1.98399984836578) - 0.655169091977683*std::sin(0.386319845914841*x_94 - 7.40639972686768) - 23.4115720864078*std::sin(0.404079854488373*x_94 - 4.21031999588013) + 0.0502145105357313*std::sin(0.367999851703644*x_95 + 1.98935985565186) - 1.48191700229994*std::sin(0.382479846477509*x_95 - 7.39607954025269) + 0.0153686754870585*std::sin(0.376959830522537*x_96 - 4.22176027297974) + 0.251927874548636*std::sin(0.386959820985794*x_96 - 4.2021598815918) - 0.0453080084259508*std::sin(0.396319836378098*x_96 + 5.20240020751953) + 4.63111515740041*std::sin(0.398799866437912*x_96 - 7.3931999206543) + 15.1855497995168*std::sin(0.411679863929749*x_96 + 1.98543977737427) + 0.333105234677798*std::sin(0.326879858970642*x_97 + 5.13624000549316) - 2.76535747571333*std::sin(0.339759826660156*x_97 + 5.16359996795654) - 0.0184241727978783*std::sin(0.362479835748672*x_97 - 4.41720008850098) - 1.11787382607478*std::sin(0.403599858283997*x_97 + 5.19040012359619) - 0.0505477215559785*std::sin(0.518239855766296*x_97 + 2.16407990455627) + 0.0150881765716934*std::sin(0.395679831504822*x_98 - 4.19135999679565) + 0.179376482249394*std::sin(0.406559854745865*x_98 - 7.38751983642578) - 0.0530210078924747*std::sin(0.414239853620529*x_98 - 7.39607954025269) - 0.0615627883961049*std::sin(0.430639863014221*x_98 - 7.37799978256226) + 1.91304404296452*std::sin(0.433199852705002*x_98 - 7.38143968582153) + 37.092047098169*std::sin(0.382719844579697*x_99 - 7.42312002182007) + 0.222907307110945*std::sin(0.398159861564636*x_99 - 7.40983963012695) - 0.016622873075445*std::sin(0.402159839868546*x_99 - 4.20552015304565) + 0.221979728526793*std::sin(0.403039842844009*x_99 + 5.20864009857178) + 2.58100389863378*std::sin(0.415279865264893*x_99 - 4.19144010543823) - 857.749808623121);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0267807827254663*x_1 - 0.324655488292177*x_10 - 0.00984453697736598*x_100 + 0.670610904447615*x_101 + 0.00226986880680306*x_102 + 2.29575613661038*x_103 + 5.50698906426161e-5*x_104 - 0.0120662803322872*x_105 + 0.0241371454053186*x_106 - 0.15593092725376*x_107 + 0.076667300306137*x_108 + 0.436251334347897*x_109 - 0.0437526177838617*x_11 + 0.0489659693201788*x_110 + 0.00237101077692639*x_111 + 0.00719658117066732*x_112 - 0.223693170913708*x_113 - 0.00241429608456462*x_114 + 0.047992723335989*x_115 + 0.032393327073948*x_116 + 0.0213952278806083*x_117 - 0.660367851995882*x_118 + 0.0055680992303301*x_119 + 0.132525121010786*x_12 + 0.0323894177707132*x_120 + 0.698022913378058*x_13 - 0.165901120649976*x_14 + 0.419531193060714*x_15 - 0.137055617020537*x_16 + 0.0374491722426044*x_17 + 0.555373872878456*x_18 - 0.230419724588369*x_19 + 0.0937670756042804*x_2 - 0.276456113380501*x_20 + 0.14271063523053*x_21 - 0.817360510973486*x_22 + 0.158606997406725*x_23 + 0.0169129495689215*x_24 - 0.523948493430163*x_25 - 0.337909045845294*x_26 - 0.318429290295675*x_27 + 0.00286865447660108*x_28 - 0.453982754945123*x_29 - 0.0377052975861845*x_3 - 0.19884266146931*x_30 + 1.55786185227588*x_31 - 5.25660833243248*x_32 + 1.45576269274864*x_33 + 0.174910291689297*x_34 - 0.0562481691273014*x_35 + 0.0187977724895689*x_36 + 0.0436353461954237*x_37 - 0.0683371325374774*x_38 - 0.95021607788549*x_39 - 0.306894481954655*x_4 - 0.116229847086684*x_40 + 0.0395300667221451*x_41 - 0.345809725768107*x_42 + 0.571309305320641*x_43 - 0.477791885857031*x_44 + 0.0719171979521445*x_45 - 0.0996578294738416*x_46 - 0.0569336837215958*x_47 - 0.77224232411787*x_48 + 0.172720406657503*x_49 - 0.08574303098568*x_5 + 0.18277142633404*x_50 + 0.0860340521699629*x_51 - 0.258213290952216*x_52 - 0.0388065634493634*x_53 - 0.972348810757769*x_54 + 0.0506930550637265*x_55 - 0.0838842585825847*x_56 + 0.034394536712477*x_57 - 0.00443168770659808*x_58 + 0.0043370720064258*x_59 + 0.0732128200413305*x_6 - 0.517140534632057*x_60 - 1.04275347537575*x_61 - 2.2029068087477*x_62 + 0.783470754741561*x_63 - 0.0861416828347668*x_64 + 0.720377636183663*x_65 + 0.0109730893794852*x_66 - 0.0456002783487144*x_67 + 0.63260196320365*x_68 + 1.04718151238651*x_69 + 0.324504632416428*x_7 - 0.0362165168586176*x_70 - 0.255155005721093*x_71 - 0.0385913286370625*x_72 - 0.0240479005985833*x_73 - 0.0730150801110993*x_74 - 0.0293316588356325*x_75 - 0.825283237796049*x_76 + 0.404558546956688*x_77 - 0.0368098323860819*x_78 - 0.0144093487889847*x_79 - 0.0705151046840721*x_8 + 0.126495922481391*x_80 - 0.103367099262789*x_81 + 0.106336719133593*x_82 + 0.0345943445543666*x_83 - 0.00963285517344391*x_84 - 0.686801467789138*x_85 - 0.574954226115891*x_86 + 0.00324185288695728*x_87 - 0.0409855826109145*x_88 + 0.991664954560624*x_89 - 0.803621236682314*x_9 - 0.0377676748578033*x_90 - 2.52302682478732*x_91 - 0.0201963880967782*x_92 - 0.867690529395438*x_93 - 0.646558556985485*x_94 - 0.00207070223230816*x_95 + 0.0300132299095954*x_96 - 0.231189513386306*x_97 + 0.0228044220318589*x_98 + 0.00866370942170901*x_99 - 0.000814705164263883*std::pow(-7.36319971084595*x_106 - 7.55671977996826, 2) + 0.000180245482478587*std::pow(-5.29512023925781*x_108 - 7.73583984375, 2) - 0.141563532289002*std::pow(-0.582399845123291*x_108 - 0.778079867362976, 2) - 4.31934534061969e-6*std::pow(-7.56576013565063*x_109 - 9.54831981658936, 2) - 0.00398438521756397*std::pow(-6.31343984603882*x_11 - 9.7729606628418, 2) + 0.000408752518194865*std::pow(-8.15095996856689*x_116 - 8.55615997314453, 2) + 0.000172999284848662*std::pow(-7.33599996566772*x_118 - 8.55144023895264, 2) - 0.000197887481882771*std::pow(-6.34631967544556*x_120 - 8.5252799987793, 2) - 0.000269164102390939*std::pow(-4.97463989257813*x_120 - 5.7960000038147, 2) - 1.05473007106588e-5*std::pow(-5.00879955291748*x_13 - 7.81375980377197, 2) + 1.37093027396578e-5*std::pow(-5.29879999160767*x_15 - 5.5019998550415, 2) + 9.77093751579369e-6*std::pow(-5.08487987518311*x_15 - 7.32096004486084, 2) - 0.00056417769015609*std::pow(-8.73536014556885*x_18 - 9.75536060333252, 2) + 8.12157214178175e-6*std::pow(-6.31343984603882*x_19 - 9.57096099853516, 2) - 0.0012281856388921*std::pow(-7.01279973983765*x_23 - 9.21599960327148, 2) - 0.000149717543619375*std::pow(-6.67776012420654*x_24 - 9.96127986907959, 2) - 0.000572637870877095*std::pow(-4.61759996414185*x_24 - 6.62983989715576, 2) - 3.28630709330197e-5*std::pow(-7.44783973693848*x_27 - 8.82520008087158, 2) + 0.00113161050644832*std::pow(-5.21519994735718*x_39 - 6.82528018951416, 2) + 3.03025578288419e-6*std::pow(-6.29800033569336*x_4 - 9.95495986938477, 2) + 0.000267756601172904*std::pow(-4.83800029754639*x_44 - 6.05071973800659, 2) + 0.000353527746616747*std::pow(-5.75367975234985*x_47 - 7.59768009185791, 2) + 5.16725982744823e-5*std::pow(-6.32687997817993*x_5 - 9.3877592086792, 2) - 5.87818906510561e-6*std::pow(-7.51128005981445*x_50 - 8.1159200668335, 2) - 0.000445028807164079*std::pow(-7.70344018936157*x_59 - 9.92232036590576, 2) - 0.000553865806443265*std::pow(-6.26208019256592*x_59 - 9.90112018585205, 2) - 1.01845251592236e-5*std::pow(-4.89711999893188*x_6 - 7.75040006637573, 2) + 3.53423102907358e-5*std::pow(-8.05943965911865*x_64 - 9.632080078125, 2) - 3.95590889330963e-5*std::pow(-3.31583976745605*x_66 - 4.76936006546021, 2) - 0.00137033386925938*std::pow(-5.33400011062622*x_67 - 5.12992000579834, 2) + 7.82017295057859e-5*std::pow(-4.89463996887207*x_7 - 6.54287958145142, 2) + 1.05645094805147e-5*std::pow(-6.32664012908936*x_70 - 8.89144039154053, 2) - 0.000933101043985925*std::pow(-5.72743988037109*x_70 - 7.97160005569458, 2) - 8.55309080648834e-6*std::pow(-6.03951978683472*x_72 - 8.25783920288086, 2) - 0.000335342984552111*std::pow(-5.92343997955322*x_72 - 7.55639982223511, 2) + 0.00207210555283776*std::pow(-5.51567983627319*x_72 - 6.31112003326416, 2) - 0.000928019269832991*std::pow(-5.3295202255249*x_72 - 7.79544019699097, 2) + 0.000530143428929971*std::pow(-5.7279200553894*x_73 - 7.8930401802063, 2) - 6.19224237607746e-6*std::pow(-7.48496007919312*x_74 - 9.9323205947876, 2) - 0.00244086196031891*std::pow(-5.3471999168396*x_74 - 6.92751979827881, 2) + 6.07184552837532e-5*std::pow(-6.85536003112793*x_77 - 8.66800022125244, 2) - 0.0110412245020729*std::pow(-4.26240015029907*x_78 - 5.81343936920166, 2) + 0.000708493824393445*std::pow(-7.15487957000732*x_81 - 9.58255958557129, 2) - 3.91376757438244e-5*std::pow(-8.56280040740967*x_84 - 8.97383975982666, 2) + 6.72081969042537e-5*std::pow(-8.34360027313232*x_84 - 8.74335956573486, 2) - 3.38793286569396e-6*std::pow(-7.32399988174438*x_84 - 6.70928001403809, 2) + 9.72059635392403e-6*std::pow(-5.07727956771851*x_86 - 7.30615997314453, 2) + 0.00728689235473854*std::pow(-4.13991975784302*x_87 - 5.91967964172363, 2) + 0.000590412399885598*std::pow(-8.75607967376709*x_88 - 9.97624015808105, 2) + 2.27702848033184e-6*std::pow(-8.0033597946167*x_88 - 9.20728015899658, 2) - 0.00232498464573116*std::pow(-2.1943998336792*x_88 - 2.17791986465454, 2) - 0.000301671676058115*std::pow(-3.1781599521637*x_90 - 4.56775999069214, 2) + 0.000140884120536939*std::pow(-5.24519968032837*x_99 - 6.02455997467041, 2) - 0.00771913205079187*std::exp(0.702079832553864*x_1) - 0.000180051299532058*std::exp(1.08351981639862*x_1) - 0.000100060987263401*std::exp(1.19423997402191*x_1) + 0.0215905927214068*std::exp(1.22735989093781*x_1) - 4.6581542665164e-6*std::exp(1.28807985782623*x_1) + 0.00492469380533405*std::exp(1.19983983039856*x_100) - 6.44336612025368e-5*std::exp(1.62295985221863*x_100) + 0.0154064771145421*std::exp(0.515199840068817*x_103) + 0.0263764692217124*std::exp(0.528799831867218*x_104) - 0.0550719847685002*std::exp(1.06327986717224*x_104) - 0.0509262858115118*std::exp(0.650879800319672*x_106) - 0.00650540012658194*std::exp(0.665519833564758*x_106) - 0.00642158791699693*std::exp(0.792479872703552*x_106) + 0.935136510383053*std::exp(1.33487987518311*x_106) - 0.139083984592855*std::exp(0.648639798164368*x_109) - 0.680665299621201*std::exp(0.855439901351929*x_110) - 0.000602001540817721*std::exp(1.08487975597382*x_110) + 4.23361827216328e-5*std::exp(1.55039989948273*x_110) - 0.000275063400127942*std::exp(1.59975981712341*x_110) - 0.53828397222042*std::exp(0.604959845542908*x_112) + 0.00166363767630079*std::exp(0.914159834384918*x_112) - 0.00796141543231496*std::exp(0.571999847888947*x_24) - 0.0528636239051072*std::exp(0.514479875564575*x_26) - 0.0684703396810913*std::exp(0.62559986114502*x_26) - 0.00635290896808145*std::exp(0.643839836120605*x_26) + 0.000194806050448862*std::exp(0.829519867897034*x_26) + 0.0138952995379474*std::exp(0.874719858169556*x_26) - 0.0009902214250021*std::exp(0.913679838180542*x_26) + 0.219424770226245*std::exp(0.491599857807159*x_31) + 0.00745181778808647*std::exp(0.599999845027924*x_31) - 0.0341164119490738*std::exp(0.620239853858948*x_31) + 0.0117663390112608*std::exp(0.647599816322327*x_31) + 0.000582235053515681*std::exp(0.654319822788239*x_31) + 0.11644333745615*std::exp(0.655279815196991*x_31) - 0.192895059664174*std::exp(0.654959857463837*x_45) - 0.000445183310303209*std::exp(0.825759887695313*x_45) - 0.00554365155682968*std::exp(1.0123997926712*x_45) - 0.02664734446078*std::exp(1.11879980564117*x_45) + 4.01831414362097e-5*std::exp(1.23079991340637*x_45) + 0.200509564759246*std::exp(0.99375981092453*x_6) - 0.0254884998269776*std::exp(0.713119864463806*x_60) - 0.028576523039943*std::exp(0.968719840049744*x_60) - 0.00179556971157883*std::exp(1.24247992038727*x_60) + 1.58988801839332e-5*std::exp(1.45055985450745*x_66) + 0.00153627488936741*std::exp(1.66143977642059*x_66) - 9.64114583345095e-5*std::exp(0.718239843845367*x_70) + 0.00125746671858743*std::exp(0.895999848842621*x_70) + 0.0142419865443026*std::exp(0.875359892845154*x_72) + 0.00486928848874767*std::exp(0.97439980506897*x_74) - 0.00148094377628839*std::exp(1.0343998670578*x_74) - 0.00246926405921831*std::exp(1.24767982959747*x_74) + 1.00882117595478e-5*std::exp(1.71327984333038*x_74) - 0.342386414455536*std::exp(0.599999845027924*x_76) + 0.00765387032895021*std::exp(0.73831981420517*x_77) + 0.00411067107367432*std::exp(0.885519862174988*x_81) + 0.0035045987542594*std::exp(1.09175980091095*x_81) - 0.00553190151750488*std::exp(0.719999849796295*x_87) + 0.00642677434685148*std::sin(0.222879990935326*x_1 - 1.19911992549896) - 0.492913143412729*std::sin(0.184960007667542*x_10 + 1.76799988746643) - 1.85519498757003*std::sin(0.330879837274551*x_10 - 7.47408008575439) + 0.293422430862889*std::sin(0.372159838676453*x_100 - 7.40847969055176) - 0.123784078562947*std::sin(0.155280038714409*x_102 - 7.65199995040894) + 4.37532240066917*std::sin(0.298239946365356*x_102 - 7.52088022232056) - 0.00262864582699487*std::sin(0.342959851026535*x_102 - 7.44087982177734) - 0.0745658434608521*std::sin(0.371279835700989*x_102 + 1.97439980506897) + 0.0846520868893013*std::sin(0.430479854345322*x_102 - 4.16527986526489) - 0.347648630926845*std::sin(0.445199847221375*x_102 + 5.23176002502441) - 0.00997658319400752*std::sin(0.314079850912094*x_103 - 7.47591972351074) + 0.623115406543966*std::sin(0.465919852256775*x_103 - 7.36799955368042) + 0.933939502806015*std::sin(0.487919867038727*x_104 - 4.14376020431519) - 0.614624333665659*std::sin(0.60919988155365*x_104 - 7.1910400390625) + 0.00101643802589597*std::sin(0.640159845352173*x_104 - 7.17999982833862) - 0.258067331753305*std::sin(0.263999968767166*x_105 + 1.85087990760803) + 2.00521562003262*std::sin(0.319519847631454*x_105 + 1.92879974842072) - 0.0644856976095522*std::sin(0.355839848518372*x_105 - 7.42432022094727) - 0.00393882876680736*std::sin(0.357599824666977*x_105 - 7.44007968902588) + 0.579774671590989*std::sin(0.187360003590584*x_106 - 7.61688041687012) - 0.00264561509162008*std::sin(0.432319849729538*x_106 + 5.221360206604) - 1.47978220169108*std::sin(0.299039930105209*x_107 + 5.11175966262817) + 6.35913314458756*std::sin(0.363919854164124*x_107 - 7.4172797203064) + 0.00376628412966303*std::sin(0.44327986240387*x_107 + 5.22464036941528) + 0.114927542201243*std::sin(0.347679853439331*x_108 + 5.14847993850708) + 0.74211692729578*std::sin(0.663199841976166*x_108 + 2.2377598285675) + 0.0896044257895498*std::sin(0.345519840717316*x_109 + 5.15944004058838) - 0.256755602798031*std::sin(0.375519841909409*x_110 + 5.1691198348999) + 0.00057344085006762*std::sin(0.590079843997955*x_110 - 7.21264028549194) - 3.66726164629586*std::sin(0.3572798371315*x_111 - 7.43255996704102) - 0.00152871978633088*std::sin(0.401119828224182*x_111 - 4.20544004440308) - 0.306121946965776*std::sin(0.439599871635437*x_111 - 1.17359983921051) + 0.00108054780571151*std::sin(0.456559866666794*x_111 + 8.23095989227295) - 0.252076146023757*std::sin(0.473359853029251*x_111 + 2.04543972015381) - 0.0142987122216662*std::sin(0.496959865093231*x_111 - 4.12064027786255) - 2.12386453817877*std::sin(0.198719993233681*x_112 + 4.99071979522705) + 0.00664454207726638*std::sin(0.353759855031967*x_112 - 7.41695976257324) - 0.0182570451784192*std::sin(0.411039859056473*x_112 - 0.981599867343903) - 0.475192864809681*std::sin(0.48583984375*x_112 + 5.23848009109497) + 0.0801056540782395*std::sin(0.507519841194153*x_112 - 1.01695990562439) - 2.34388757923074*std::sin(0.304399937391281*x_113 - 7.4966402053833) - 2.75339471715563*std::sin(0.345999836921692*x_113 - 7.43743991851807) - 0.00838625689319892*std::sin(0.268559962511063*x_114 - 7.53224039077759) + 4.50680067376216*std::sin(0.269199967384338*x_114 - 7.52320003509521) + 0.582693848617904*std::sin(0.367759823799133*x_114 - 7.42456007003784) - 0.213147134014813*std::sin(0.429439842700958*x_114 + 5.22695970535278) - 0.00161990268297953*std::sin(0.468559861183167*x_114 - 4.1592001914978) + 0.0146026309594711*std::sin(0.576479852199554*x_114 - 7.21895980834961) + 0.229028925311625*std::sin(0.665199875831604*x_114 + 5.43255996704102) - 0.0876912911874636*std::sin(0.302079945802689*x_115 + 5.103919506073) + 1.98637561067549*std::sin(0.325759828090668*x_115 - 7.45439958572388) - 5.37866843609017*std::sin(0.416079849004745*x_115 + 5.22344017028809) + 0.0265574642227988*std::sin(0.48447984457016*x_115 - 4.12936019897461) - 0.035142671584616*std::sin(0.534799814224243*x_115 + 5.36311960220337) - 0.299244152173694*std::sin(0.435039848089218*x_116 + 8.42255973815918) - 1.77269667514777*std::sin(0.49839985370636*x_116 - 4.12344026565552) - 0.107901642226591*std::sin(0.243599966168404*x_117 - 1.35351991653442) - 0.451055645841513*std::sin(0.376959830522537*x_117 + 1.97719979286194) - 0.00589562899664239*std::sin(0.378399848937988*x_117 + 5.1756796836853) + 4.15027750696358*std::sin(0.400079846382141*x_117 - 4.1864800453186) + 0.109078985197811*std::sin(0.616959869861603*x_117 - 3.99599981307983) + 0.286692692099233*std::sin(0.191840007901192*x_118 + 1.78999984264374) - 1.57923985454711*std::sin(0.408879846334457*x_118 + 5.20247983932495) + 0.00623695296100837*std::sin(0.419359862804413*x_118 + 5.21727991104126) - 0.0254778209824797*std::sin(0.289599925279617*x_119 - 4.28279972076416) + 0.807893130865156*std::sin(0.340479850769043*x_119 + 5.15120029449463) + 8.85095109607153*std::sin(0.34895983338356*x_119 + 5.15208005905151) - 0.00284704516825925*std::sin(0.366079837083817*x_119 - 7.41511964797974) + 0.351370737745034*std::sin(0.434239864349365*x_119 + 1.99407982826233) - 0.540015338467703*std::sin(0.35471984744072*x_12 - 1.03167986869812) - 0.00234709648960712*std::sin(0.328399837017059*x_120 + 1.94799983501434) + 0.00488475288068183*std::sin(0.36695984005928*x_120 + 5.15912008285522) + 0.111040046700838*std::sin(0.427679866552353*x_120 + 5.2294397354126) + 5.00908505669084*std::sin(0.211919993162155*x_14 - 4.38903999328613) + 0.0330480183120124*std::sin(0.272799968719482*x_16 + 5.08839988708496) + 0.0049848644180821*std::sin(0.368559837341309*x_16 + 5.15863990783691) - 0.37713156701652*std::sin(0.369679838418961*x_16 + 5.18168020248413) - 0.0158522975919154*std::sin(0.427279859781265*x_18 - 0.954639852046967) + 0.00400751644668761*std::sin(0.348479837179184*x_20 - 4.25511980056763) - 2.35415694804031*std::sin(0.361199855804443*x_20 + 5.16968011856079) + 1.00440141048286*std::sin(0.357999831438065*x_21 + 8.36407947540283) - 3.4932759992552*std::sin(0.209600001573563*x_22 - 7.57504034042358) - 0.042225078459019*std::sin(0.502079844474792*x_22 + 2.10895967483521) - 0.00113653815915608*std::sin(0.589439868927002*x_22 - 7.22200012207031) + 0.359406874766418*std::sin(0.162880018353462*x_24 + 4.93567991256714) + 0.00795071658219631*std::sin(0.182560011744499*x_24 + 4.98351955413818) + 0.0948347173403046*std::sin(0.190160006284714*x_24 - 7.60288000106812) + 0.636042811608784*std::sin(0.338639855384827*x_24 - 4.25832033157349) + 0.000876358734405993*std::sin(0.46111986041069*x_25 - 4.13752031326294) + 0.0080384227907842*std::sin(0.186080008745193*x_26 - 7.6005597114563) - 0.0208166368716634*std::sin(0.137440040707588*x_27 + 4.9017596244812) - 6.62864522613038*std::sin(0.171120017766953*x_27 - 7.6241602897644) - 0.201142056238926*std::sin(0.301679939031601*x_27 + 5.12080001831055) - 1.24845038436945*std::sin(0.303999930620193*x_27 + 5.13247966766357) - 0.00999937476597169*std::sin(0.319839835166931*x_28 - 4.28064012527466) + 1.83588085860631*std::sin(0.320079833269119*x_28 - 4.28864002227783) + 6.340349461436*std::sin(0.322399854660034*x_28 - 4.28247976303101) - 0.0364284345842054*std::sin(0.326319843530655*x_28 + 5.13312005996704) + 0.693112470678923*std::sin(0.331519842147827*x_28 - 4.27248001098633) + 0.0809305138611481*std::sin(0.33247983455658*x_28 - 4.26847982406616) - 0.0757299202470126*std::sin(0.285919934511185*x_3 + 5.08111953735352) - 0.676815620280102*std::sin(0.294319927692413*x_3 + 5.10839986801147) - 2.2965125127909*std::sin(0.307759910821915*x_3 - 7.5032000541687) - 0.916636541263475*std::sin(0.261199980974197*x_30 - 7.53352022171021) + 1.54775254699846*std::sin(0.27295994758606*x_30 - 4.32471990585327) + 0.0953815357653218*std::sin(0.279999971389771*x_30 - 4.29591989517212) - 10.1809372342679*std::sin(0.360319852828979*x_31 + 5.10487985610962) + 4.3273331023217*std::sin(0.255839973688126*x_32 - 4.40239953994751) + 0.230523814817295*std::sin(0.348479837179184*x_32 + 8.2469596862793) - 0.268628974700401*std::sin(0.322319835424423*x_33 + 8.19719982147217) + 0.00576671746581658*std::sin(0.351519852876663*x_34 + 2.00215983390808) + 0.0260465251361725*std::sin(0.313519835472107*x_35 + 1.97631978988647) + 0.0436634990130981*std::sin(0.315679848194122*x_35 + 1.98063981533051) - 1.82070176827409*std::sin(0.317599833011627*x_35 - 7.43431997299194) - 5.02542481101313*std::sin(0.318319827318192*x_35 - 7.43311977386475) + 0.00522897105157527*std::sin(0.319839835166931*x_35 - 7.42831993103027) + 0.223540316213241*std::sin(0.319919854402542*x_35 - 7.42831993103027) + 0.0900624572561643*std::sin(0.321919858455658*x_35 - 7.42599964141846) + 0.0569343685743334*std::sin(0.331519842147827*x_36 - 4.25288009643555) - 0.938371672041916*std::sin(0.352959841489792*x_36 + 5.1637601852417) + 1.91488367505848*std::sin(0.373759835958481*x_36 - 7.41639995574951) + 0.0017628687053953*std::sin(0.380639851093292*x_36 - 7.39903974533081) + 0.313283190409713*std::sin(0.393519848585129*x_36 - 4.2052001953125) + 0.0826685519292654*std::sin(0.418559849262238*x_36 + 5.22079992294312) - 4.16965627581961*std::sin(0.293359935283661*x_37 + 5.09615993499756) - 0.00824223175905791*std::sin(0.298719942569733*x_37 - 7.50471973419189) + 0.934093216659951*std::sin(0.36303985118866*x_37 - 4.24047994613647) - 0.116094493545682*std::sin(0.364959836006165*x_37 - 7.42208003997803) + 1.19621251172441*std::sin(0.401439845561981*x_37 - 4.20695972442627) + 0.00384810574312012*std::sin(0.48039984703064*x_38 + 5.25888013839722) - 0.0128105765826893*std::sin(0.665279865264893*x_38 + 2.20815992355347) - 1.76994848957657*std::sin(0.19743999838829*x_39 + 4.99631977081299) - 0.236699416826395*std::sin(0.350079834461212*x_39 + 5.16296005249023) - 0.0215942764742709*std::sin(0.334239840507507*x_40 - 4.27408027648926) - 0.0502235843691537*std::sin(0.390239834785461*x_40 + 8.37495994567871) - 0.154051676841684*std::sin(0.312159925699234*x_41 + 1.89567983150482) - 1.46821122208118*std::sin(0.375519841909409*x_41 + 5.17112016677856) + 1.00869661992563*std::sin(0.406959861516953*x_41 - 7.39175987243652) - 0.0242515969545602*std::sin(0.431519865989685*x_41 - 7.38671970367432) + 6.84647408738925*std::sin(0.121520057320595*x_42 + 1.70983994007111) + 1.2953949010425*std::sin(0.369279831647873*x_43 - 7.41183996200562) + 0.00422941075544168*std::sin(0.380639851093292*x_43 - 4.22176027297974) + 0.158089062698875*std::sin(0.383359849452972*x_43 - 7.40655994415283) - 0.480623053601748*std::sin(0.440879851579666*x_43 - 7.37831974029541) + 3.7006442647995*std::sin(0.359359860420227*x_44 + 5.16416025161743) + 0.0547747948769329*std::sin(0.407279849052429*x_46 + 5.21623992919922) + 0.987646097653522*std::sin(0.585599839687347*x_46 - 7.21920013427734) + 0.000640528496486489*std::sin(0.645839810371399*x_46 + 5.4171199798584) + 18.4013535393937*std::sin(0.208159998059273*x_47 - 7.59176015853882) + 1.13236203553974*std::sin(0.260319977998734*x_47 + 1.85655987262726) - 0.00293696406528016*std::sin(0.439279854297638*x_47 - 4.15232038497925) - 0.238148393547422*std::sin(0.424719870090485*x_48 - 4.17040014266968) - 0.105620791601161*std::sin(0.259919971227646*x_49 + 1.85903990268707) + 0.0866907845160811*std::sin(0.437279850244522*x_49 - 7.35431957244873) - 3.69641683236388*std::sin(0.191200003027916*x_50 + 4.98799991607666) - 1.54990923481972*std::sin(0.321759849786758*x_50 - 7.47687959671021) + 5.35964333962128*std::sin(0.36559984087944*x_51 - 4.23184013366699) - 5.05379405542339*std::sin(0.212960004806519*x_53 + 5.00816011428833) + 4.96389182282455*std::sin(0.347519844770432*x_53 + 5.15128040313721) - 0.00507478331510301*std::sin(0.359999865293503*x_53 - 4.24272012710571) - 0.00161503615761807*std::sin(0.889279901981354*x_53 - 3.95743989944458) + 0.0804353883306067*std::sin(0.319359838962555*x_54 + 1.90071976184845) + 0.790296613067953*std::sin(0.417919874191284*x_54 - 7.38679981231689) + 0.0767866544635411*std::sin(0.487039864063263*x_54 - 1.10911989212036) + 0.0812603238961393*std::sin(0.658959865570068*x_54 - 3.96943998336792) + 1.31251458298332*std::sin(0.348079830408096*x_55 + 5.15960025787354) + 4.588260585462*std::sin(0.403119832277298*x_55 + 8.38576030731201) - 0.0267680647308668*std::sin(0.441839843988419*x_55 - 4.14991998672485) + 0.0779449924065826*std::sin(0.465039849281311*x_55 + 5.25047969818115) + 4.25468144546883*std::sin(0.322559833526611*x_56 + 1.92327988147736) + 0.24115402511532*std::sin(0.406159847974777*x_56 + 5.19504022598267) - 4.4627782232211*std::sin(0.428879857063293*x_57 - 4.16879987716675) - 0.00372872966889134*std::sin(0.448399841785431*x_57 - 4.15232038497925) + 0.467148301834906*std::sin(0.553839862346649*x_57 + 5.35767984390259) + 0.0266691154955576*std::sin(0.853919863700867*x_57 + 5.62479972839355) + 0.385635472552431*std::sin(0.170960009098053*x_58 + 4.96247959136963) - 0.710510739177774*std::sin(0.209440007805824*x_58 + 5.00848007202148) - 0.174852433975218*std::sin(0.266239941120148*x_58 - 7.51327991485596) - 2.48742890592357*std::sin(0.2743199467659*x_58 + 5.07583951950073) - 0.00436413505449659*std::sin(0.348079830408096*x_58 + 5.15759992599487) + 4.80177057815889*std::sin(0.42223984003067*x_58 - 4.189040184021) - 0.0504930433932269*std::sin(0.462799847126007*x_58 + 5.25392007827759) + 0.0100908122081005*std::sin(0.168560013175011*x_59 - 7.63191986083984) - 1.30688151812754*std::sin(0.251999974250793*x_59 - 7.52784013748169) - 0.0664541239172175*std::sin(0.203199997544289*x_64 + 1.78175985813141) + 0.0733162666062135*std::sin(0.222240000963211*x_64 - 4.36191987991333) - 2.7327496621492*std::sin(0.228959992527962*x_64 - 4.36199951171875) + 0.00147141694568529*std::sin(0.339199841022491*x_64 - 7.4555196762085) - 5.54918358050036*std::sin(0.43495985865593*x_66 + 8.44768047332764) - 12.7872166358354*std::sin(0.243759974837303*x_67 - 7.55679988861084) + 15.6839196371968*std::sin(0.247279971837997*x_70 - 7.52800035476685) - 0.103686087479128*std::sin(0.439999878406525*x_70 - 4.15304040908813) + 0.00872433650855386*std::sin(0.624399840831757*x_70 - 3.97263979911804) - 0.0131921505614387*std::sin(0.23063999414444*x_71 + 5.04759979248047) + 0.0946257932660252*std::sin(0.214000001549721*x_72 + 5.00920009613037) - 2.03754372870361*std::sin(0.24959996342659*x_73 + 5.06479978561401) - 5.42927662691029*std::sin(0.342559844255447*x_73 - 4.26151990890503) - 0.00109562562726936*std::sin(0.451039850711823*x_73 - 4.15104007720947) + 0.331617318309064*std::sin(0.123040057718754*x_75 + 4.89031982421875) + 0.00286196738049763*std::sin(0.278559952974319*x_75 + 5.09087991714478) - 0.310756636098586*std::sin(0.409119844436646*x_75 - 7.38631963729858) - 0.326319937474898*std::sin(0.476879835128784*x_75 + 2.08039975166321) - 1.36476833445072*std::sin(0.540319859981537*x_75 + 5.16431999206543) - 1.78974924496284*std::sin(0.238319978117943*x_76 - 7.53840017318726) + 1.178544494852*std::sin(0.393599838018417*x_78 + 8.3810396194458) - 0.0133417026344282*std::sin(0.486639857292175*x_78 + 5.28744029998779) - 7.27863629735203*std::sin(0.281759947538376*x_79 - 7.4986400604248) - 2.09055856234075*std::sin(0.332239836454391*x_79 + 5.12871980667114) + 1.02224745686168*std::sin(0.355119854211807*x_79 + 1.96583986282349) - 0.0128931031201914*std::sin(0.249199971556664*x_8 - 4.33576011657715) + 0.627517561153978*std::sin(0.501679837703705*x_8 - 7.30711984634399) - 0.102002387938394*std::sin(0.389359831809998*x_81 + 8.37271976470947) + 15.456376885326*std::sin(0.214159995317459*x_82 - 7.57696008682251) + 0.0324195554914517*std::sin(0.197359994053841*x_83 + 5.00008010864258) + 0.395417047152189*std::sin(0.201599985361099*x_83 + 5.0053596496582) + 0.00500548589923207*std::sin(0.263119965791702*x_83 + 1.87455987930298) - 0.0257801190211831*std::sin(0.319679915904999*x_83 - 7.46343994140625) - 1.11894078549617*std::sin(0.320559918880463*x_83 - 7.46808004379272) - 2.99916549622131*std::sin(0.322239845991135*x_83 - 7.4730396270752) - 1.28074328131866*std::sin(0.393679857254028*x_83 - 1.19831991195679) + 0.150633080871937*std::sin(0.140080034732819*x_84 - 7.67984008789063) + 0.500865544415569*std::sin(0.179360002279282*x_84 + 1.77599990367889) - 3.00034588412812*std::sin(0.23871998488903*x_84 - 7.55600023269653) + 0.00746235959882049*std::sin(0.278079956769943*x_84 + 5.09272003173828) + 14.0153443756378*std::sin(0.278479933738708*x_84 - 7.49608039855957) - 0.121745224871133*std::sin(0.187040001153946*x_85 + 4.98767995834351) + 0.167437613666101*std::sin(0.19064000248909*x_85 - 7.61648035049438) - 0.0097186838194769*std::sin(0.221919998526573*x_85 - 7.56135988235474) - 0.481602480592264*std::sin(0.230239987373352*x_85 - 7.55408048629761) - 0.0195045514905352*std::sin(0.524639844894409*x_86 - 7.27040004730225) - 0.343628767000143*std::sin(0.402799844741821*x_87 + 5.20991992950439) + 0.842227071086388*std::sin(0.417919844388962*x_87 - 4.18951988220215) + 0.00163095215199966*std::sin(0.499039828777313*x_87 - 4.11488008499146) - 0.00933377398012592*std::sin(0.87447988986969*x_87 - 0.751359879970551) - 0.255128404360139*std::sin(0.219119995832443*x_89 + 1.8155198097229) + 0.294513279133879*std::sin(0.41023987531662*x_90 - 7.39207983016968) - 0.0332981365244335*std::sin(0.414639860391617*x_90 - 0.994639813899994) + 0.0848404625714347*std::sin(0.505279839038849*x_90 - 4.09320020675659) + 0.0273435392741255*std::sin(0.337039858102798*x_92 + 5.18400001525879) - 3.29736538315158*std::sin(0.341039836406708*x_92 + 5.20991992950439) + 0.0690003105805511*std::sin(0.360079854726791*x_92 + 1.97791981697083) + 2.99719592044889*std::sin(0.360879838466644*x_92 + 2.00343990325928) + 0.062683166701181*std::sin(0.363839834928513*x_92 - 7.38535976409912) + 1.73337326979874*std::sin(0.365199834108353*x_92 + 1.99775981903076) + 0.00201314917257425*std::sin(0.381279855966568*x_92 + 1.97519981861115) - 0.0384131755321942*std::sin(0.401679873466492*x_92 - 7.59008026123047) - 0.0562483108573311*std::sin(0.374559849500656*x_94 - 1.18543982505798) + 0.123197706944863*std::sin(0.376239836215973*x_94 + 1.98399984836578) - 1.16566191055689*std::sin(0.386319845914841*x_94 - 7.40639972686768) - 0.527631537377398*std::sin(0.404079854488373*x_94 - 4.21031999588013) - 0.002675444294113*std::sin(0.367999851703644*x_95 + 1.98935985565186) - 2.63659294270635*std::sin(0.382479846477509*x_95 - 7.39607954025269) + 0.00260346272619658*std::sin(0.376959830522537*x_96 - 4.22176027297974) + 0.448224330428126*std::sin(0.386959820985794*x_96 - 4.2021598815918) + 0.00241402437915984*std::sin(0.396319836378098*x_96 + 5.20240020751953) + 3.60222534914292*std::sin(0.398799866437912*x_96 - 7.3931999206543) + 0.342239938312041*std::sin(0.411679863929749*x_96 + 1.98543977737427) + 0.252743974286763*std::sin(0.326879858970642*x_97 + 5.13624000549316) - 2.15098101858649*std::sin(0.339759826660156*x_97 + 5.16359996795654) + 0.0181408584292286*std::sin(0.362479835748672*x_97 - 4.41720008850098) - 1.98889562377014*std::sin(0.403599858283997*x_97 + 5.19040012359619) + 0.0324524497274536*std::sin(0.518239855766296*x_97 + 2.16407990455627) + 0.00255594604387049*std::sin(0.395679831504822*x_98 - 4.19135999679565) + 0.136102109176229*std::sin(0.406559854745865*x_98 - 7.38751983642578) + 0.00282497532128889*std::sin(0.414239853620529*x_98 - 7.39607954025269) + 0.0395242996916082*std::sin(0.430639863014221*x_98 - 7.37799978256226) + 1.48802513247412*std::sin(0.433199852705002*x_98 - 7.38143968582153) + 0.835951287792596*std::sin(0.382719844579697*x_99 - 7.42312002182007) - 0.14311007410866*std::sin(0.398159861564636*x_99 - 7.40983963012695) + 0.156141013066734*std::sin(0.402159839868546*x_99 - 4.20552015304565) + 0.168427370567221*std::sin(0.403039842844009*x_99 + 5.20864009857178) + 2.00758507484712*std::sin(0.415279865264893*x_99 - 4.19144010543823) - 58.1383178733963);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
