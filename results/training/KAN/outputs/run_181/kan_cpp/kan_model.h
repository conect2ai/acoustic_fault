
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000273538487128399*x_1 + 0.000548949918432487*x_10 - 0.000232860673205737*x_100 - 0.000991982708235064*x_101 + 0.000681997334210967*x_102 - 0.00111727496397405*x_103 - 0.00340807678498396*x_104 - 0.00196113573078472*x_105 + 0.000199846784493354*x_106 - 0.000791365549418106*x_107 - 0.00355406524366619*x_108 - 0.00311658110018668*x_109 - 0.0055201421835612*x_11 - 0.00220001443768788*x_110 - 0.00171306997889967*x_111 - 0.00260963867394658*x_112 + 0.000636843065431415*x_113 - 0.00174414796134488*x_114 - 0.0023646689514093*x_115 + 0.000348069707147878*x_116 - 0.00364021927367523*x_117 + 0.000771214964985117*x_118 - 0.00119705897429582*x_119 + 0.00029159359421843*x_12 + 0.000140509648698791*x_120 + 0.000633165120658956*x_13 + 0.000715505873868541*x_14 - 0.000983530658455382*x_15 + 0.00109691005557341*x_16 - 5.14453853896518e-5*x_17 - 0.00172395206824674*x_18 + 0.000898848185512729*x_19 - 0.0144820181097518*x_2 + 0.00130853924270158*x_20 + 0.00103654515928114*x_21 + 5.41100979223841e-5*x_22 - 0.000660446895973681*x_23 - 0.000380928941837003*x_24 - 0.000181472159680414*x_25 - 0.000205899033712733*x_26 + 0.000294294688015163*x_27 - 0.000324777164952581*x_28 - 0.0017223104920766*x_29 + 1.80715450940379e-5*x_3 + 0.0004035732316421*x_30 + 9.30779171715549e-5*x_31 + 0.000219443753730435*x_32 + 0.00601926172729324*x_33 - 0.00108669098448144*x_34 - 3.44037132057095e-6*x_35 - 0.000805644631203819*x_36 - 0.00209508228005579*x_37 + 0.0032119666334718*x_38 + 0.00195024036789863*x_39 + 0.00111232638119883*x_4 - 0.000645017047512068*x_40 - 0.00183443808657451*x_41 + 0.003002164575485*x_42 - 0.000483016524932716*x_43 + 5.94132101174441e-5*x_44 + 0.000474492685658037*x_45 + 0.0011648626425322*x_46 - 0.000965730194172466*x_47 - 0.000880339328037702*x_48 - 0.00166414867817977*x_49 + 0.00160043589627494*x_5 - 0.000149380672062426*x_50 - 0.00150748076809431*x_51 - 0.00311405201107549*x_52 - 0.0046899433327143*x_53 - 0.00145741377171509*x_54 - 0.000408582557603976*x_55 - 0.00117497968408168*x_56 - 0.00834386872976056*x_57 + 1.33974964735824e-6*x_58 - 0.000386176202469408*x_59 + 0.000835364892534286*x_6 - 0.00242830439312033*x_60 + 0.00100162405243474*x_61 - 0.00111059138471965*x_62 - 0.00208142897241572*x_63 + 0.00497611015319031*x_64 + 0.000580669948722514*x_65 - 0.00260348062750163*x_66 - 1.477049956971e-5*x_67 - 3.35236370127561e-5*x_68 + 0.000835738339929247*x_69 + 0.000267002867406743*x_7 + 0.000438944247885577*x_70 - 0.00331977896295003*x_71 - 0.000679058172243736*x_72 + 0.000204345476107442*x_73 + 0.0016604122885603*x_74 - 0.000299699376902232*x_75 + 0.000654809924271499*x_76 + 0.00147176112669649*x_77 - 0.000749363368782232*x_78 - 0.00069734902503688*x_79 + 0.000429387995894351*x_8 - 0.00061828932644097*x_80 + 8.6681849356952e-6*x_81 - 0.00112082336151937*x_82 + 7.76807444855187e-5*x_83 + 4.92097575134952e-7*x_84 - 0.000133155642197521*x_85 - 0.00229410518427102*x_86 + 0.000384625892691113*x_87 + 0.00477810296971965*x_88 + 0.00326146952226561*x_89 + 0.000143450197846436*x_9 + 0.000156953142731081*x_90 - 0.00105651916822573*x_91 - 0.00460381824000986*x_92 - 0.00215147022037658*x_93 + 1.84425419169937e-5*x_94 - 0.00483829013695412*x_95 + 0.00289190655364367*x_96 - 0.00142501983454987*x_97 + 0.00470931931252478*x_98 - 0.00210672994213645*x_99 - 1.88136007220812e-7*std::pow(-2.20879983901978*x_24 - 4.21663999557495, 2) + 8.46108306830443e-6*std::pow(-2.59999990463257*x_29 - 1.67199993133545, 2) + 1.63710455894241e-6*std::pow(-3.28383994102478*x_60 - 6.97959995269775, 2) + 1.78889620198571e-7*std::pow(-5.24360036849976*x_61 - 6.25415992736816, 2) - 4.99858718404986e-7*std::pow(-1.86063992977142*x_63 - 6.39928007125854, 2) + 2.66790162577216e-6*std::pow(-2.94071984291077*x_67 - 7.45536041259766, 2) - 3.14837629588762e-6*std::pow(-2.85191988945007*x_7 - 7.12160015106201, 2) + 7.78502456839856e-8*std::pow(-7.80344009399414*x_8 - 3.79063987731934, 2) - 6.76881049422461e-7*std::pow(-2.31807994842529*x_9 - 5.01559972763062, 2) + 0.000183923239239124*std::exp(0.314239859580994*x_22) + 0.000700448830833988*std::exp(0.570879817008972*x_22) - 0.0001655797561933*std::exp(0.315199851989746*x_25) - 8.53566448605831e-6*std::exp(0.524799883365631*x_26) - 0.000389607487362889*std::exp(0.263759851455688*x_30) + 0.0121451340612404*std::exp(0.199119850993156*x_9) + 0.0016592286335011*std::sin(0.286159932613373*x_1 + 8.28927993774414) + 0.0012874422147019*std::sin(0.304639935493469*x_1 - 4.26056003570557) + 0.00151931199445024*std::sin(0.315999925136566*x_1 - 4.27895975112915) + 0.00352588583705688*std::sin(0.320719838142395*x_1 - 4.25712013244629) + 0.043011104988057*std::sin(0.327199846506119*x_1 - 4.26064014434814) - 0.0247757152840277*std::sin(0.330479830503464*x_1 - 4.24128007888794) - 0.00230449689394989*std::sin(0.337999850511551*x_1 - 4.2513599395752) - 0.000391896455670004*std::sin(0.226879999041557*x_100 + 1.99143981933594) + 0.000196420527335915*std::sin(0.230639979243279*x_100 - 1.18671989440918) + 0.000338473253094275*std::sin(0.246559977531433*x_100 + 8.17727947235107) - 0.0025042138419335*std::sin(0.361279845237732*x_100 - 1.57759976387024) - 0.00214158229213739*std::sin(0.204479992389679*x_102 - 1.18623995780945) - 0.000109940466828332*std::sin(0.187440007925034*x_104 + 8.40816020965576) + 0.00081642018598891*std::sin(0.217280000448227*x_105 + 1.96951985359192) - 0.000103554236107348*std::sin(0.240399971604347*x_107 + 1.78271985054016) - 0.00125106766063483*std::sin(0.242399975657463*x_107 - 4.23863983154297) - 0.000150283595573938*std::sin(0.291279941797256*x_107 + 4.76240015029907) + 0.001199591547281*std::sin(0.176640018820763*x_108 + 5.21304035186768) + 0.000760921612289474*std::sin(0.245119974017143*x_108 - 1.19279980659485) - 0.000106536642077797*std::sin(0.243519976735115*x_109 + 5.15503978729248) + 0.000804390105967399*std::sin(0.250159978866577*x_11 - 7.40879964828491) - 0.000113538760781071*std::sin(0.290879935026169*x_11 - 1.21463990211487) - 0.00109991932361976*std::sin(0.297759920358658*x_11 - 4.26287984848022) - 0.00243140454064139*std::sin(0.268799960613251*x_112 - 7.42655992507935) - 0.00670515250555292*std::sin(0.276559948921204*x_112 - 7.4332799911499) - 0.00185081117764313*std::sin(0.28263995051384*x_112 + 1.95687973499298) - 0.00685972956422113*std::sin(0.282719939947128*x_113 - 7.41199970245361) - 0.00180626039620436*std::sin(0.284879922866821*x_113 + 5.15928030014038) + 0.00143611155717771*std::sin(0.217600002884865*x_114 - 4.22240018844604) + 0.000987126149762968*std::sin(0.243279978632927*x_116 + 1.97951984405518) - 0.00604401924528209*std::sin(0.230959981679916*x_118 + 5.17176008224487) - 0.00209893274474893*std::sin(0.239599987864494*x_119 + 5.15503978729248) - 0.0187765186089176*std::sin(0.25231996178627*x_119 - 7.4456000328064) + 0.00179872575536362*std::sin(0.300079941749573*x_12 + 5.13064002990723) - 5.48583005920551e-5*std::sin(0.7290398478508*x_12 - 4.77559995651245) - 0.00179755447284668*std::sin(0.251999974250793*x_120 + 5.16232013702393) + 0.00773846361072076*std::sin(0.263759940862656*x_120 + 5.16455984115601) - 0.00745250642798778*std::sin(0.270239949226379*x_120 - 7.43232011795044) + 0.000868203671281603*std::sin(0.277679949998856*x_13 + 5.16752004623413) - 0.00650539168415382*std::sin(0.305919945240021*x_13 - 7.44199991226196) - 5.5934276797607e-5*std::sin(0.679199814796448*x_13 - 8.21103954315186) - 0.013395168740865*std::sin(0.307679921388626*x_14 + 5.12720012664795) + 0.00375843660993438*std::sin(0.332079827785492*x_15 + 8.26583957672119) - 0.00187597427840684*std::sin(0.316639930009842*x_16 + 1.99335980415344) - 0.00251885780472453*std::sin(0.336479842662811*x_17 - 1.1490398645401) - 0.000897859826017681*std::sin(0.339519828557968*x_17 + 1.9948798418045) + 0.00219208475451978*std::sin(0.343039840459824*x_17 + 2.01007986068726) - 0.000237997927746953*std::sin(0.491839855909348*x_17 + 1.9327198266983) + 0.00165188396788438*std::sin(0.651039838790894*x_17 - 7.63024044036865) - 0.00705332019382199*std::sin(0.336559861898422*x_18 - 1.15495979785919) + 0.00105328976049228*std::sin(0.382799834012985*x_18 + 1.98943984508514) + 0.00263546501847602*std::sin(0.5204798579216*x_18 - 4.33296012878418) - 0.00310746525562722*std::sin(0.291519939899445*x_19 - 1.18711996078491) - 0.00963168649873719*std::sin(0.312159925699234*x_19 - 7.41224002838135) - 0.000121428556785568*std::sin(0.346159845590591*x_19 + 5.02383995056152) + 0.000604036827274185*std::sin(0.353759855031967*x_2 - 7.41535997390747) - 0.00766112544612821*std::sin(0.37391984462738*x_2 - 7.3951997756958) - 0.00224890243060668*std::sin(0.379999846220016*x_2 - 4.21528005599976) + 0.00405690860715217*std::sin(0.188640013337135*x_20 + 1.97775971889496) - 5.24283751685435e-5*std::sin(0.359199851751328*x_20 - 1.15183985233307) + 0.00445149338755927*std::sin(0.293759942054749*x_21 + 2.00879979133606) - 0.00294861612080498*std::sin(0.315199911594391*x_21 + 1.99711978435516) + 0.0305359006376213*std::sin(0.0824000835418701*x_22 - 4.54647970199585) + 0.000479915837659413*std::sin(0.349839836359024*x_22 + 1.99503982067108) + 0.00662769458014024*std::sin(0.192320004105568*x_23 - 4.40319967269897) - 0.0020219966951142*std::sin(0.316399931907654*x_23 - 1.16175985336304) - 0.00797994527830781*std::sin(0.334399849176407*x_23 - 1.15567982196808) + 0.000178356078100713*std::sin(0.487599849700928*x_23 + 1.95495975017548) - 0.00299599861717343*std::sin(0.164080023765564*x_24 - 1.23895978927612) - 0.00355631868495858*std::sin(0.224479988217354*x_24 - 1.19663989543915) - 0.000642388856850101*std::sin(0.402799844741821*x_24 - 1.20791983604431) + 0.00111735513310618*std::sin(0.343439847230911*x_25 - 1.15567982196808) + 0.000690210382217064*std::sin(0.406719863414764*x_25 + 5.00271987915039) - 0.000262994381046305*std::sin(0.784239888191223*x_26 - 4.60712003707886) - 0.00102972226953404*std::sin(0.172560006380081*x_27 - 1.21567988395691) - 0.00465763697214227*std::sin(0.669999837875366*x_27 - 1.0791198015213) - 0.000567651127098608*std::sin(0.299039930105209*x_28 - 7.40471982955933) + 0.0016431269903455*std::sin(0.112880066037178*x_29 + 4.91199970245361) + 0.003378630545639*std::sin(0.148480042815208*x_29 + 1.75919997692108) - 0.000177486259480798*std::sin(0.176480010151863*x_29 + 4.97535943984985) + 0.000156310294810638*std::sin(0.333439826965332*x_29 - 4.36719989776611) - 0.00141109357474682*std::sin(0.205520004034042*x_3 - 7.59863996505737) + 0.008674460362461*std::sin(0.346959829330444*x_3 - 7.38855981826782) - 0.00176802674561774*std::sin(0.348559856414795*x_3 - 7.39647960662842) + 0.0856516210609785*std::sin(0.367279827594757*x_3 - 4.18991994857788) - 0.000183721241332295*std::sin(0.415519863367081*x_3 - 1.18831992149353) + 0.00371605684152688*std::sin(0.418559849262238*x_3 + 2.00775980949402) + 4.75690027193972e-5*std::sin(0.213119998574257*x_30 + 1.35935986042023) - 0.0041961404914226*std::sin(0.239439979195595*x_30 - 1.17183983325958) + 0.00371765518026717*std::sin(0.332799851894379*x_30 - 1.1497597694397) + 0.0211673203289494*std::sin(0.358399868011475*x_30 + 2.01263976097107) + 0.000853497329466947*std::sin(0.371919840574265*x_30 + 1.99511981010437) + 0.00109250681928899*std::sin(0.347519844770432*x_31 + 5.17407989501953) + 0.000839335576865283*std::sin(0.360239863395691*x_31 + 5.18207979202271) - 0.00331532280377648*std::sin(0.368399828672409*x_31 + 5.17768001556396) + 0.00319984321464479*std::sin(0.369359821081161*x_31 + 5.17328023910522) - 0.070465379632071*std::sin(0.392399847507477*x_31 - 7.40079975128174) - 0.000323677600845826*std::sin(0.412079870700836*x_31 + 5.19288015365601) - 0.0096263849347607*std::sin(0.415039867162704*x_31 - 7.40055990219116) + 6.51982772106325e-5*std::sin(0.893119871616364*x_31 - 7.76775979995728) - 8.52023524975449e-5*std::sin(0.240959972143173*x_32 + 2.01855969429016) + 0.0125639822734201*std::sin(0.309279918670654*x_32 - 1.13791990280151) - 0.00195025762304293*std::sin(0.311119943857193*x_32 + 2.01319980621338) - 0.00148188865596185*std::sin(0.238159984350204*x_33 - 1.21919989585876) + 0.000671041604666798*std::sin(0.238559976220131*x_33 + 1.97919988632202) + 0.000237760740490707*std::sin(0.236399978399277*x_34 - 1.21151983737946) + 0.0183141480745809*std::sin(0.228479996323586*x_35 + 8.19143962860107) + 0.00012699306437834*std::sin(0.244719967246056*x_39 - 7.60920000076294) - 0.00471738086937566*std::sin(0.292799949645996*x_4 + 2.00839972496033) - 7.92251532362137e-5*std::sin(0.302479922771454*x_40 - 1.62287986278534) + 0.00016457058258805*std::sin(0.525999844074249*x_43 + 1.85743987560272) - 7.50206620521802e-5*std::sin(0.553839862346649*x_43 - 1.35583984851837) + 0.00221163010924083*std::sin(0.110400065779686*x_44 + 1.74895989894867) + 0.031257945797608*std::sin(0.297119915485382*x_44 + 5.08871984481812) + 5.85672725374059e-5*std::sin(0.539039850234985*x_44 + 1.61799991130829) + 4.46830503437613e-5*std::sin(0.612319827079773*x_45 - 4.80423974990845) - 0.000365689014911645*std::sin(0.145360037684441*x_47 + 5.00600004196167) - 0.00010170996312972*std::sin(0.236719980835915*x_47 - 1.83063983917236) - 0.00636446972567162*std::sin(0.159360021352768*x_48 - 7.40391969680786) - 0.000573985672288405*std::sin(0.191600009799004*x_49 - 4.60928010940552) - 0.000152596222794157*std::sin(0.249119967222214*x_49 + 5.13367986679077) - 0.018178855416183*std::sin(0.3572798371315*x_5 + 2.02199983596802) - 0.0117388628304686*std::sin(0.358079850673676*x_5 + 2.00535988807678) - 0.000312061512994868*std::sin(0.5065598487854*x_5 - 1.25143992900848) - 3.93364977033004e-5*std::sin(0.773199856281281*x_5 - 4.792799949646) - 0.000319312245217035*std::sin(0.166880026459694*x_51 + 4.99487972259521) + 0.00985004350035898*std::sin(0.246079966425896*x_52 - 7.42615985870361) - 0.000163598859134956*std::sin(0.562079846858978*x_52 - 1.55815982818604) + 0.000495136456510513*std::sin(0.225839987397194*x_53 + 1.98495984077454) - 0.000557903286567991*std::sin(0.230319991707802*x_54 - 7.43327951431274) - 0.000241241864019476*std::sin(0.261679977178574*x_57 - 7.46247959136963) + 4.41036355258786e-5*std::sin(0.537599861621857*x_58 - 4.48936033248901) - 0.00710954001591319*std::sin(0.559359848499298*x_58 - 1.54263985157013) + 0.0426832473509615*std::sin(0.143680036067963*x_59 + 1.79303991794586) - 0.000245469390755038*std::sin(0.184000000357628*x_59 - 4.97879981994629) - 0.000527796259601947*std::sin(0.491999864578247*x_59 + 1.80147981643677) + 0.000123530276836629*std::sin(0.244319975376129*x_6 + 1.80127990245819) + 0.00156559933876916*std::sin(0.299999952316284*x_6 + 2.0194399356842) - 0.0124326304634202*std::sin(0.365199834108353*x_6 + 2.01551985740662) - 0.00393909531932851*std::sin(0.391679853200912*x_6 + 2.00623965263367) + 8.13286087349111e-5*std::sin(0.206640005111694*x_60 + 2.00567984580994) + 0.000641237248312808*std::sin(0.417759865522385*x_60 + 8.17088031768799) + 0.00120464932728707*std::sin(0.464879840612411*x_60 - 4.32456016540527) + 0.000346053261365591*std::sin(0.633199870586395*x_60 - 4.6450400352478) + 0.000174753308198603*std::sin(0.972639799118042*x_64 + 7.79016017913818) + 1.53032034734634e-5*std::sin(1.046719789505*x_64 + 7.78560018539429) - 4.12153701770578e-5*std::sin(0.970799803733826*x_65 + 2.00151968002319) - 0.000125840193040224*std::sin(0.154000028967857*x_66 + 2.06791973114014) - 0.00166376529082466*std::sin(1.28911983966827*x_67 + 5.21824026107788) + 0.0154805265061006*std::sin(0.221599996089935*x_68 - 0.957519829273224) + 0.00190384443520971*std::sin(0.330159842967987*x_7 - 1.14079988002777) + 0.00494309587050412*std::sin(0.348879843950272*x_7 - 1.14639985561371) - 0.0954402314985564*std::sin(0.377519845962524*x_7 - 1.16439986228943) - 6.01463428117304e-5*std::sin(0.477439850568771*x_7 - 1.2397598028183) + 8.04133318556087e-5*std::sin(1.14047980308533*x_71 + 8.39352035522461) - 4.39957477277828e-5*std::sin(1.30631983280182*x_73 - 1.80255997180939) + 1.03087988267237e-5*std::sin(1.2772798538208*x_77 - 1.16463983058929) - 0.000252727933914845*std::sin(0.397839844226837*x_8 + 1.97663986682892) + 6.98148042752773e-5*std::sin(0.457359850406647*x_8 + 4.76743984222412) + 3.40489715799809e-5*std::sin(0.711519837379456*x_83 - 7.9987998008728) + 1.73843422414275e-5*std::sin(0.690639853477478*x_84 + 7.39631986618042) - 0.000233080672596804*std::sin(0.334639847278595*x_9 - 4.32807970046997) - 0.000899201225682311*std::sin(0.335679858922958*x_91 + 8.40248012542725) + 0.000463756208082344*std::sin(0.352079838514328*x_91 - 7.38151979446411) + 0.00546078873829132*std::sin(0.359119862318039*x_91 + 2.01399970054626) + 0.000215001322184896*std::sin(0.370799839496613*x_91 - 1.18903994560242) - 0.0114877187228638*std::sin(0.283599942922592*x_92 + 2.00687980651855) - 0.00207058658749753*std::sin(0.290319919586182*x_92 - 1.16183984279633) + 0.00175454687133061*std::sin(0.312399923801422*x_92 + 1.98295974731445) - 0.00384422353446227*std::sin(0.223199993371964*x_93 + 5.19488000869751) + 0.00100405754702529*std::sin(0.230719983577728*x_93 - 7.41183996200562) - 0.000230891761911668*std::sin(0.234959989786148*x_93 - 1.20967984199524) - 0.000480918016672573*std::sin(0.277119934558868*x_94 + 1.97791981697083) - 0.0812676852199736*std::sin(0.295439928770065*x_94 + 1.95231986045837) - 7.18992296050914e-5*std::sin(0.265919953584671*x_95 - 7.80767965316772) - 0.00134077965802857*std::sin(0.297759920358658*x_96 + 1.9340797662735) + 0.000506162845214967*std::sin(0.317119926214218*x_97 - 1.40455985069275) - 7.24094192547096e-5*std::sin(0.298399955034256*x_98 - 7.63000011444092) - 0.253674634807578);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000148375703403409*x_1 + 0.00313222448490886*x_10 - 0.000382311422034576*x_100 + 0.000470283572883459*x_101 - 0.00111294084485153*x_102 - 0.00174765611345423*x_103 - 0.00404172719658825*x_104 - 0.00201789349376096*x_105 - 0.00142059388681982*x_106 - 8.53512984585541e-5*x_107 + 0.00076325043386679*x_108 + 0.000125950205587102*x_109 - 0.000603740839073615*x_11 - 0.000184346196775932*x_110 - 0.00547419054595066*x_111 - 0.00311249460974008*x_112 + 0.021572325618868*x_113 - 0.000719873687380098*x_114 + 0.0001065419155297*x_115 + 0.00812771616450683*x_116 - 0.00218064762521066*x_117 - 0.000400811714274316*x_118 + 0.0042589767454967*x_119 - 2.57896030433589e-5*x_12 + 0.00319521394596186*x_120 + 0.000151189556263499*x_13 + 0.00320914952091871*x_14 + 0.00312755792935013*x_15 - 0.000651923376774751*x_16 + 3.30045710425371e-5*x_17 - 0.000366003983511427*x_18 - 0.00056043628114946*x_19 - 0.00305130497308963*x_2 + 0.000364014796519132*x_20 - 0.00190667341856302*x_21 - 0.000386949338100387*x_22 - 6.68032210632845e-5*x_23 - 0.00514964330258132*x_24 - 0.000637401817577457*x_25 - 0.00146023347981455*x_26 - 0.000120342106789198*x_27 - 0.00322369459131563*x_28 + 9.82373306766771e-5*x_29 - 9.93191428078265e-6*x_3 + 9.0773764723819e-5*x_30 + 3.47497525263177e-5*x_31 - 0.00110328295232843*x_32 + 0.00257418309265786*x_33 + 2.63129950496215e-5*x_34 - 0.00219827807987829*x_35 + 0.00431133726175341*x_36 - 0.000713587307168705*x_37 - 0.00146454099422411*x_38 - 0.00174723836097018*x_39 - 0.00147850512307304*x_4 - 0.000481982776233191*x_40 + 0.000279826996778436*x_41 - 0.000381461934234467*x_42 - 0.00151434289866388*x_43 - 0.000187150599260245*x_44 - 0.0013479388963153*x_45 - 0.0030657940729592*x_46 - 0.00115938563040264*x_47 + 0.00118220406916364*x_48 - 4.9765417968394e-5*x_49 - 0.00370767173258167*x_5 - 0.000409933885377766*x_50 + 0.00013126928565031*x_51 - 0.00481587741138904*x_52 - 0.00736931126910938*x_53 - 0.000694410738787645*x_54 - 0.00259499479162321*x_55 - 0.0038804735882659*x_56 - 0.000872601595012219*x_57 - 0.00096771885835579*x_58 - 0.000359078930443164*x_59 + 6.75468973981814e-6*x_6 - 0.00123175400437832*x_60 - 0.000792736557669231*x_61 - 0.00197654570200656*x_62 - 0.000263977971166351*x_63 + 0.00121212158191994*x_64 + 0.000712583452729357*x_65 - 0.000258198593714923*x_66 + 0.0015183708712541*x_67 - 0.00220019529236217*x_68 - 0.00126046729235052*x_69 - 0.00105494206859967*x_7 - 0.00309263881588334*x_70 - 0.000820709094237245*x_71 - 0.000420416569472569*x_72 - 0.00115086480609572*x_73 - 0.000741806917484915*x_74 - 0.000595249099151229*x_75 + 0.000206264660746182*x_76 - 0.000979036779771801*x_77 - 0.000248679047002683*x_78 - 0.0019496378230715*x_79 - 0.00129291929136499*x_8 - 0.000544792589556473*x_80 + 0.00048856486908096*x_81 - 0.000293801176365975*x_82 - 0.000201225499850336*x_83 + 0.000179239855108685*x_84 - 0.000362331341479739*x_85 + 3.50572848669396e-5*x_86 + 0.00134007053940032*x_87 + 0.00112953367805112*x_88 + 9.25451421285993e-5*x_89 + 1.14684514404266e-5*x_9 + 0.00112051770184816*x_90 - 0.000122992523343947*x_91 - 0.00566106794394199*x_92 - 0.000235808705170583*x_93 - 0.000355801939147321*x_94 + 9.80752374381841e-5*x_95 + 0.00110873735771373*x_96 + 0.0038030829379546*x_97 + 0.000548254704338656*x_98 + 0.00507022781881938*x_99 - 1.92624177823218e-7*std::pow(-2.20879983901978*x_24 - 4.21663999557495, 2) - 4.95951515865264e-5*std::pow(-1.86063992977142*x_63 - 6.39928007125854, 2) + 5.66175316865054e-8*std::pow(-7.80344009399414*x_8 - 3.79063987731934, 2) - 0.00109850568696856*std::pow(-0.00770089933585123*x_10 + 0.00857869990448401*x_100 + 0.00936834920650157*x_101 - 0.00566814425842851*x_102 - 0.0368035849393562*x_103 + 0.00288595427598527*x_104 + 0.0350769305514782*x_105 + 0.0152425345364305*x_106 + 0.00166087050620304*x_107 + 0.0122297969295415*x_108 + 0.0281000691766531*x_109 - 0.0409334546497981*x_110 + 0.000135467565524183*x_111 + 0.0194765226661546*x_114 - 0.00467842292172395*x_115 + 0.182211692409219*x_116 - 0.0023297908090184*x_117 + 0.0369442973381558*x_118 + 0.256842865639416*x_119 - 0.0195701347971688*x_12 + 0.000431752128573506*x_14 + 0.00543646017343505*x_15 + 0.00773651873036881*x_16 - 0.0332632974816479*x_2 - 0.0319485879573781*x_27 - 0.0146439885608913*x_28 + 0.000574435881289927*x_34 + 0.00795273041016523*x_35 - 0.010838590274658*x_36 + 0.00519346929278546*x_37 - 0.0264705118489483*x_38 - 0.049636454131084*x_39 + 0.0014239139087478*x_4 + 0.0144197110191546*x_40 + 0.00197737781819674*x_41 + 0.00178353493418951*x_42 - 0.018752254507126*x_43 + 0.00547776324348031*x_44 + 0.0171090785167168*x_45 + 0.00884433383629598*x_46 + 0.012690051169771*x_47 - 0.00293627510958652*x_48 - 0.0083876171580081*x_50 + 0.00939667748363048*x_51 + 0.0203964735975617*x_52 + 0.0223779343754444*x_53 - 0.0232005193201164*x_54 - 0.0288709072936658*x_55 + 0.0486592428277645*x_56 - 0.00892364257601455*x_57 - 0.00915369276890429*x_58 - 0.0159065292790553*x_61 + 0.000478396587633551*x_62 - 0.0104411857702593*x_63 - 0.0118430007870186*x_64 + 0.025963265773383*x_65 - 0.0235703155630548*x_66 + 0.0115395339897404*x_68 - 0.0125541525418909*x_69 - 0.011511542729618*x_70 - 0.00105031957777145*x_71 - 0.00325280308083339*x_72 - 0.0277715897623858*x_74 - 0.00235566725101431*x_75 - 0.00643673630926805*x_76 - 0.00557274170288205*x_77 - 0.00568873242519886*x_78 + 0.00194808315007519*x_79 + 0.00169155234832234*x_8 - 0.0170881831208277*x_80 + 0.00880276157262714*x_81 + 0.0223851960423131*x_82 + 0.0214325858378259*x_83 + 0.000573060772642543*x_84 - 0.0102775644358958*x_85 - 0.011300298642522*x_86 + 0.00100852675985581*x_87 - 0.00188331805043683*x_88 + 0.00310080209103507*x_89 - 0.00609560617441501*x_9 + 0.00896066841182618*x_90 + 0.0161685000178741*x_93 - 0.00484784015654844*x_94 + 0.00469062977687084*x_95 + 0.00558372408642305*x_97 + 0.00446735097833413*x_98 - 0.0899706315829526*x_99 - 0.000422303922103278*std::pow(-3.28383994102478*x_60 - 6.97959995269775, 2) - 0.000688206085674291*std::pow(-2.94071984291077*x_67 - 7.45536041259766, 2) + 0.000812148283839152*std::pow(-2.85191988945007*x_7 - 7.12160015106201, 2) - 0.909529821870038*std::sin(0.320719838142395*x_1 - 4.25712013244629) + 0.283732790202405*std::sin(0.297759920358658*x_11 - 4.26287984848022) + 1.72964651886674*std::sin(0.276559948921204*x_112 - 7.4332799911499) + 1.76952087984522*std::sin(0.282719939947128*x_113 - 7.41199970245361) + 0.463693232011913*std::sin(0.251999974250793*x_120 + 5.16232013702393) + 0.0144286840706738*std::sin(0.679199814796448*x_13 - 8.21103954315186) + 0.649759066606471*std::sin(0.336479842662811*x_17 - 1.1490398645401) + 1.81945909650726*std::sin(0.336559861898422*x_18 - 1.15495979785919) + 2.48456884605682*std::sin(0.312159925699234*x_19 - 7.41224002838135) - 1.04651129767893*std::sin(0.188640013337135*x_20 + 1.97775971889496) - 1.1482975271888*std::sin(0.293759942054749*x_21 + 2.00879979133606) - 7.87697434093889*std::sin(0.0824000835418701*x_22 - 4.54647970199585) - 1.70966564133447*std::sin(0.192320004105568*x_23 - 4.40319967269897) + 0.165709228699779*std::sin(0.402799844741821*x_24 - 1.20791983604431) - 0.178045165102324*std::sin(0.406719863414764*x_25 + 5.00271987915039) + 0.0678414570409154*std::sin(0.784239888191223*x_26 - 4.60712003707886) - 0.423857455375316*std::sin(0.112880066037178*x_29 + 4.91199970245361) + 0.364002621466817*std::sin(0.205520004034042*x_3 - 7.59863996505737) + 1.08242725093191*std::sin(0.239439979195595*x_30 - 1.17183983325958) - 0.281820676749179*std::sin(0.347519844770432*x_31 + 5.17407989501953) + 0.503084203647262*std::sin(0.311119943857193*x_32 + 2.01319980621338) - 0.173100429045494*std::sin(0.238559976220131*x_33 + 1.97919988632202) + 0.148064092372372*std::sin(0.191600009799004*x_49 - 4.60928010940552) + 0.0804987074010413*std::sin(0.5065598487854*x_5 - 1.25143992900848) + 0.136149172197854*std::sin(0.491999864578247*x_59 + 1.80147981643677) - 0.403858591433909*std::sin(0.299999952316284*x_6 + 2.0194399356842) + 0.0113490471453526*std::sin(1.30631983280182*x_73 - 1.80255997180939) + 0.231955987350636*std::sin(0.335679858922958*x_91 + 8.40248012542725) + 0.534124000924859*std::sin(0.290319919586182*x_92 - 1.16183984279633) + 0.345864596838908*std::sin(0.297759920358658*x_96 + 1.9340797662735) + 10.6556890882236, 2) - 0.00146543909795582*std::pow(0.0224361998888748*x_10 - 0.00564293692406952*x_100 - 0.0121640318712782*x_101 - 0.0247553606821264*x_102 + 0.00789885782023603*x_103 - 0.046326888270143*x_105 - 0.0154780537149201*x_106 + 0.0126546790316641*x_107 + 0.0822671474826963*x_108 + 0.0433850949218163*x_11 + 0.0418127298816252*x_110 - 0.00947258492886047*x_111 + 0.0214132903346572*x_112 - 0.0653506495425816*x_113 - 0.154877226353575*x_114 + 0.010329811627662*x_115 + 0.00258509693375631*x_116 - 0.318417631298517*x_117 - 0.293314474151515*x_118 - 0.0397640180013308*x_119 + 0.0741926880007249*x_12 - 0.182391005099278*x_120 + 0.027213327803845*x_13 + 0.0334525260042567*x_14 + 0.0237291161154561*x_15 - 0.00126100674592488*x_16 - 9.70573473675794e-5*x_17 + 0.0566610705566386*x_18 + 0.00799287052090065*x_19 - 0.0102956970755387*x_2 + 0.0200892351998236*x_20 - 0.00284738703174302*x_21 + 0.015881164542937*x_22 + 0.0198569110506852*x_23 + 0.0129493950287032*x_24 - 0.0257120154759059*x_25 - 0.0256320799999738*x_26 - 0.013018302921444*x_27 - 0.0136377936324771*x_28 - 0.0312400570003799*x_29 - 0.0138560126368489*x_3 - 0.044119485039879*x_30 + 0.0438407684700115*x_33 + 0.037344281802011*x_34 + 0.035600540103226*x_35 + 0.0393055113495979*x_36 + 0.00385595465777009*x_37 + 0.0141939658298562*x_38 + 0.0315940021359521*x_39 + 0.0280679166923946*x_4 - 0.00305931481783165*x_41 + 0.0502455047301336*x_42 - 0.00462755999286453*x_43 + 0.0178020327796439*x_44 - 0.0111237252196755*x_45 + 0.02830285101906*x_46 + 0.0332152795616688*x_48 + 0.0296497850819942*x_49 + 0.00411482498671922*x_5 - 0.0372298570836602*x_50 + 0.0154521776599371*x_51 + 0.00543928840492795*x_52 - 0.00197088910514658*x_53 - 0.00458148128281347*x_54 + 0.0528459269337193*x_55 - 0.0194598203419945*x_56 + 0.0103959266551514*x_57 - 0.022658449938219*x_58 - 0.00617452409784444*x_59 - 0.0048888240674515*x_6 + 0.00996126816742137*x_62 + 0.0205301925437444*x_63 - 0.025736597368062*x_64 + 0.00531061570672143*x_65 + 0.00261814297331952*x_66 - 0.0187999060413723*x_67 + 0.0133716437033576*x_68 + 0.0175211226048708*x_69 + 0.0055967537954251*x_7 + 0.000730914865068065*x_70 + 0.0305732059423392*x_71 + 0.000349159285641799*x_72 - 0.00892856629701938*x_73 - 0.0208995360591445*x_74 - 0.00317830501117881*x_75 + 0.00215830557107024*x_76 + 0.0143098765548335*x_78 - 0.0159636454202868*x_79 + 0.033312088675475*x_8 + 0.00650432178635988*x_80 - 0.00385886131194135*x_81 - 0.00865934014672669*x_82 - 0.0275451865053832*x_83 + 0.0099217189335309*x_84 + 0.0198903858327103*x_85 - 0.0123991812927342*x_86 - 0.0176264179627889*x_87 - 0.0050180805972538*x_88 - 0.00777260699826708*x_89 - 0.0110773938379478*x_90 - 0.0318081555264799*x_91 - 0.0125397531900485*x_93 + 0.0455250388228624*x_94 - 0.0127171929287366*x_96 - 0.0134368713056161*x_97 + 0.00981537114547135*x_98 + 0.0314034997842838*x_99 - 0.00047593223741673*std::pow(-5.24360036849976*x_61 - 6.25415992736816, 2) + 0.00180082842122994*std::pow(-2.31807994842529*x_9 - 5.01559972763062, 2) - 4.04209901083212*std::sin(0.315999925136566*x_1 - 4.27895975112915) + 0.292494401308288*std::sin(0.187440007925034*x_104 + 8.40816020965576) + 0.283438594003769*std::sin(0.243519976735115*x_109 + 5.15503978729248) - 8.51311852995258*std::sin(0.369359821081161*x_31 + 5.17328023910522) + 0.226679145566487*std::sin(0.240959972143173*x_32 + 2.01855969429016) + 0.210776927121541*std::sin(0.302479922771454*x_40 - 1.62287986278534) + 0.270597311717516*std::sin(0.236719980835915*x_47 - 1.83063983917236) - 0.216373128179436*std::sin(0.206640005111694*x_60 + 2.00567984580994) - 0.0274263519886481*std::sin(1.2772798538208*x_77 - 1.16463983058929) - 4.6679366706575*std::sin(0.312399923801422*x_92 + 1.98295974731445) + 0.191286454610985*std::sin(0.265919953584671*x_95 - 7.80767965316772) - 8.62072995948237, 2) - 0.000148408062533884*std::exp(0.314239859580994*x_22) + 8.22626479973963e-5*std::exp(0.570879817008972*x_22) + 0.000133606666091455*std::exp(0.315199851989746*x_25) + 2.03311772670877e-5*std::exp(0.524799883365631*x_26) + 0.00318992165498848*std::exp(0.263759851455688*x_30) + 0.00142635813521373*std::exp(0.199119850993156*x_9) + 0.0495276298844867*std::exp(0.000450582678160193*x_10 + 0.00246256927277371*x_100 - 0.00356735648774388*x_101 - 0.00130748417847297*x_102 + 0.0123548600483087*x_103 + 0.000973116903330601*x_104 - 0.0067711956865231*x_105 - 0.00413437303953007*x_106 + 0.00410645363362907*x_107 - 0.00948317655001846*x_108 - 0.00304692388153017*x_109 - 0.0348533171369752*x_11 - 0.0184223904839992*x_110 - 0.00121919819354449*x_111 + 0.0024532036112469*x_112 + 0.00159793574582902*x_113 + 0.00289829608663436*x_114 - 0.00646475644680047*x_115 - 0.0147805607065162*x_116 + 0.00163732543679402*x_117 - 0.00190511065567835*x_118 - 0.0130067243302255*x_119 - 0.0102713288356181*x_12 + 0.0022469795678955*x_120 - 0.0067221130330695*x_13 + 0.00226335990966709*x_14 + 0.0263393971959786*x_15 + 0.00705820892893461*x_16 + 0.00278997347939051*x_17 + 0.0438988496949283*x_18 - 0.00206830691460066*x_19 - 0.000620310794371027*x_20 - 0.00249887820424269*x_21 - 0.00101561802180025*x_22 - 0.00729425555354815*x_25 - 0.0101745315430041*x_26 - 0.0109869452203768*x_27 - 0.00018345320315135*x_28 - 0.00147423402158194*x_3 - 0.00292344407632634*x_31 + 0.0010018943231471*x_32 - 0.0100536281003119*x_33 + 0.000704781409042025*x_34 - 0.012331828884139*x_35 + 0.00842629860633665*x_36 - 0.00722126907847213*x_37 - 0.00383252227619088*x_38 + 0.00990369643172964*x_39 + 0.0017430582391497*x_4 + 0.00259272809040632*x_40 - 0.001538697639216*x_41 + 0.00840176562143851*x_42 - 0.0052189401282124*x_44 - 0.00489517245177731*x_45 - 0.00481898507349774*x_46 + 0.025126557745579*x_47 + 0.00804014927025811*x_49 - 0.00145872694936364*x_50 + 0.0034947884574529*x_51 - 0.00102929704092381*x_52 - 3.58489558607026e-5*x_53 - 0.00462360963970297*x_54 + 0.000793260740197027*x_55 + 0.00563608610013872*x_56 + 0.00845076926829009*x_57 - 0.00464880152995471*x_58 + 0.00829080545000058*x_59 + 0.00908691896182246*x_61 + 0.00245412570856058*x_62 - 0.000487943259350188*x_63 - 0.00227418832714069*x_65 + 0.000544724203120459*x_66 - 0.000864805904837379*x_67 - 0.00281546001161607*x_68 - 0.00222575235220454*x_69 - 0.00846785288019236*x_7 - 0.00178433045725161*x_70 + 0.00100629948181501*x_71 - 0.00282961091837523*x_72 - 0.00233729506788094*x_73 + 0.000927396998426396*x_74 - 0.00354294258678962*x_75 + 0.000186468455923138*x_76 - 0.000899838611112545*x_77 - 2.7647378668231e-6*x_78 - 0.00317144842391249*x_79 + 0.00201951088719229*x_8 - 0.00399755657807818*x_80 + 0.00197547942928141*x_81 - 0.00265807802269038*x_82 + 0.00714718445763286*x_83 - 0.00414991002708204*x_84 + 0.000522158651834625*x_85 + 0.000353451932267547*x_86 - 0.00770279285335874*x_87 - 0.00555091723258756*x_88 - 0.00278051372249486*x_89 - 0.00535999053126699*x_9 - 0.00230938569287649*x_90 + 0.00147266233419169*x_91 + 0.0147201548688898*x_93 + 0.00142427663597603*x_94 + 0.00520164436311657*x_95 - 0.00237878958100267*x_96 + 0.00853995913974423*x_98 + 0.0139054444038407*x_99 - 0.000546082104053845*std::pow(-2.59999990463257*x_29 - 1.67199993133545, 2) - 2.77595604722811*std::sin(0.327199846506119*x_1 - 4.26064014434814) + 0.494452479578424*std::sin(0.37391984462738*x_2 - 7.3951997756958) + 0.515029254840556*std::sin(0.334399849176407*x_23 - 1.15567982196808) + 0.229526406311168*std::sin(0.224479988217354*x_24 - 1.19663989543915) - 1.36614836766173*std::sin(0.358399868011475*x_30 + 2.01263976097107) - 0.0106214593663195*std::sin(0.525999844074249*x_43 + 1.85743987560272) + 0.410765736599515*std::sin(0.159360021352768*x_48 - 7.40391969680786) + 1.17327149902917*std::sin(0.3572798371315*x_5 + 2.02199983596802) + 0.802407557942693*std::sin(0.365199834108353*x_6 + 2.01551985740662) - 0.0777486090115649*std::sin(0.464879840612411*x_60 - 4.32456016540527) - 0.0112786570538406*std::sin(0.972639799118042*x_64 + 7.79016017913818) + 0.741422529517532*std::sin(0.283599942922592*x_92 + 2.00687980651855) - 0.0326679775245677*std::sin(0.317119926214218*x_97 - 1.40455985069275)) + 0.00169881117426805*std::sin(0.286159932613373*x_1 + 8.28927993774414) + 0.00093630790429765*std::sin(0.304639935493469*x_1 - 4.26056003570557) + 0.0199915786520767*std::sin(0.330479830503464*x_1 - 4.24128007888794) - 0.228648353180317*std::sin(0.337999850511551*x_1 - 4.2513599395752) + 0.00320866264382283*std::sin(0.226879999041557*x_100 + 1.99143981933594) + 0.000201106333362741*std::sin(0.230639979243279*x_100 - 1.18671989440918) + 0.000246158762425611*std::sin(0.246559977531433*x_100 + 8.17727947235107) - 0.000294101799761598*std::sin(0.361279845237732*x_100 - 1.57759976387024) + 0.0017280474183024*std::sin(0.204479992389679*x_102 - 1.18623995780945) + 0.000593751443474742*std::sin(0.217280000448227*x_105 + 1.96951985359192) - 0.000106024624870867*std::sin(0.240399971604347*x_107 + 1.78271985054016) + 0.0102431497133876*std::sin(0.242399975657463*x_107 - 4.23863983154297) - 0.0149108886751856*std::sin(0.291279941797256*x_107 + 4.76240015029907) - 0.000967953033561659*std::sin(0.176640018820763*x_108 + 5.21304035186768) + 0.0754973781939423*std::sin(0.245119974017143*x_108 - 1.19279980659485) + 0.0798102499191244*std::sin(0.250159978866577*x_11 - 7.40879964828491) - 0.000116247340259816*std::sin(0.290879935026169*x_11 - 1.21463990211487) - 0.00176826832610491*std::sin(0.268799960613251*x_112 - 7.42655992507935) + 0.0151535656945923*std::sin(0.28263995051384*x_112 + 1.95687973499298) - 0.00131362469466447*std::sin(0.284879922866821*x_113 + 5.15928030014038) + 0.00104442947969516*std::sin(0.217600002884865*x_114 - 4.22240018844604) + 0.000717899417936964*std::sin(0.243279978632927*x_116 + 1.97951984405518) + 0.00487693229969503*std::sin(0.230959981679916*x_118 + 5.17176008224487) - 0.00152647419593323*std::sin(0.239599987864494*x_119 + 5.15503978729248) - 0.00220516627760356*std::sin(0.25231996178627*x_119 - 7.4456000328064) + 0.178466581086161*std::sin(0.300079941749573*x_12 + 5.13064002990723) + 0.00044915379372951*std::sin(0.7290398478508*x_12 - 4.77559995651245) - 0.0633588764303861*std::sin(0.263759940862656*x_120 + 5.16455984115601) + 0.00601344367669069*std::sin(0.270239949226379*x_120 - 7.43232011795044) + 0.0861417258512307*std::sin(0.277679949998856*x_13 + 5.16752004623413) + 0.00524921472600911*std::sin(0.305919945240021*x_13 - 7.44199991226196) + 0.0108085908467587*std::sin(0.307679921388626*x_14 + 5.12720012664795) - 0.00303269069066138*std::sin(0.332079827785492*x_15 + 8.26583957672119) - 0.00192072750099083*std::sin(0.316639930009842*x_16 + 1.99335980415344) - 0.000919279160549876*std::sin(0.339519828557968*x_17 + 1.9948798418045) + 0.217495007464969*std::sin(0.343039840459824*x_17 + 2.01007986068726) + 0.000192041046526388*std::sin(0.491839855909348*x_17 + 1.9327198266983) + 0.000194001821975804*std::sin(0.651039838790894*x_17 - 7.63024044036865) + 0.104505660125002*std::sin(0.382799834012985*x_18 + 1.98943984508514) - 0.00212656246641752*std::sin(0.5204798579216*x_18 - 4.33296012878418) - 0.00225994164860266*std::sin(0.291519939899445*x_19 - 1.18711996078491) - 0.000124325355154516*std::sin(0.346159845590591*x_19 + 5.02383995056152) + 0.000618446723449779*std::sin(0.353759855031967*x_2 - 7.41535997390747) - 0.00163554146176477*std::sin(0.379999846220016*x_2 - 4.21528005599976) - 5.3679105933161e-5*std::sin(0.359199851751328*x_20 - 1.15183985233307) - 0.00214441669623861*std::sin(0.315199911594391*x_21 + 1.99711978435516) + 0.0476164520915876*std::sin(0.349839836359024*x_22 + 1.99503982067108) - 0.00207023342692984*std::sin(0.316399931907654*x_23 - 1.16175985336304) + 0.0176961937525245*std::sin(0.487599849700928*x_23 + 1.95495975017548) + 0.00241747781285445*std::sin(0.164080023765564*x_24 - 1.23895978927612) + 0.000812610019376372*std::sin(0.343439847230911*x_25 - 1.15567982196808) - 0.102167332826606*std::sin(0.172560006380081*x_27 - 1.21567988395691) - 0.000547005768119852*std::sin(0.669999837875366*x_27 - 1.0791198015213) - 0.00058119300639488*std::sin(0.299039930105209*x_28 - 7.40471982955933) - 0.00272622434973634*std::sin(0.148480042815208*x_29 + 1.75919997692108) - 0.000181720369813531*std::sin(0.176480010151863*x_29 + 4.97535943984985) + 0.0155088477608334*std::sin(0.333439826965332*x_29 - 4.36719989776611) - 0.0069994409692082*std::sin(0.346959829330444*x_3 - 7.38855981826782) - 0.175420676341794*std::sin(0.348559856414795*x_3 - 7.39647960662842) + 0.0100591632730066*std::sin(0.367279827594757*x_3 - 4.18991994857788) - 0.000188104093326264*std::sin(0.415519863367081*x_3 - 1.18831992149353) + 0.00270254723187447*std::sin(0.418559849262238*x_3 + 2.00775980949402) + 4.87038083461606e-5*std::sin(0.213119998574257*x_30 + 1.35935986042023) + 0.00270370964303296*std::sin(0.332799851894379*x_30 - 1.1497597694397) + 0.0846825870491538*std::sin(0.371919840574265*x_30 + 1.99511981010437) + 0.0832774814840222*std::sin(0.360239863395691*x_31 + 5.18207979202271) + 0.027144293546888*std::sin(0.368399828672409*x_31 + 5.17768001556396) - 0.00827564907742677*std::sin(0.392399847507477*x_31 - 7.40079975128174) - 0.000331399250275053*std::sin(0.412079870700836*x_31 + 5.19288015365601) + 0.00776755098096001*std::sin(0.415039867162704*x_31 - 7.40055990219116) - 0.000155296372490178*std::sin(0.893119871616364*x_31 - 7.76775979995728) - 0.0101379046749177*std::sin(0.309279918670654*x_32 - 1.13791990280151) - 0.00107772142782141*std::sin(0.238159984350204*x_33 - 1.21919989585876) + 0.0235902256613391*std::sin(0.236399978399277*x_34 - 1.21151983737946) + 0.00215086420322474*std::sin(0.228479996323586*x_35 + 8.19143962860107) - 0.000302485940934519*std::sin(0.244719967246056*x_39 - 7.60920000076294) + 0.00380646490326451*std::sin(0.292799949645996*x_4 + 2.00839972496033) - 7.68103541742228e-5*std::sin(0.553839862346649*x_43 - 1.35583984851837) - 0.00178456915456615*std::sin(0.110400065779686*x_44 + 1.74895989894867) + 0.00367101960782594*std::sin(0.297119915485382*x_44 + 5.08871984481812) - 0.000479521100082633*std::sin(0.539039850234985*x_44 + 1.61799991130829) - 0.000365843661956486*std::sin(0.612319827079773*x_45 - 4.80423974990845) - 0.0362830565123332*std::sin(0.145360037684441*x_47 + 5.00600004196167) - 0.0151403437058308*std::sin(0.249119967222214*x_49 + 5.13367986679077) + 0.00947211399836133*std::sin(0.358079850673676*x_5 + 2.00535988807678) + 0.000322068620150226*std::sin(0.773199856281281*x_5 - 4.792799949646) - 0.0316816304725174*std::sin(0.166880026459694*x_51 + 4.99487972259521) - 0.00794802156492136*std::sin(0.246079966425896*x_52 - 7.42615985870361) - 0.000118979246752138*std::sin(0.562079846858978*x_52 - 1.55815982818604) + 0.000360093969766298*std::sin(0.225839987397194*x_53 + 1.98495984077454) - 0.000405741905214905*std::sin(0.230319991707802*x_54 - 7.43327951431274) - 0.0239356169544061*std::sin(0.261679977178574*x_57 - 7.46247959136963) + 4.51557713894518e-5*std::sin(0.537599861621857*x_58 - 4.48936033248901) - 0.000834964043063817*std::sin(0.559359848499298*x_58 - 1.54263985157013) + 0.00501283862239772*std::sin(0.143680036067963*x_59 + 1.79303991794586) + 0.00200978715913895*std::sin(0.184000000357628*x_59 - 4.97879981994629) + 0.0122564688374096*std::sin(0.244319975376129*x_6 + 1.80127990245819) + 0.00317846459694952*std::sin(0.391679853200912*x_6 + 2.00623965263367) + 0.000466347535655706*std::sin(0.417759865522385*x_60 + 8.17088031768799) - 0.000279231130689407*std::sin(0.633199870586395*x_60 - 4.6450400352478) + 1.11294396048654e-5*std::sin(1.046719789505*x_64 + 7.78560018539429) + 0.000337451938452367*std::sin(0.970799803733826*x_65 + 2.00151968002319) - 0.000128842235357097*std::sin(0.154000028967857*x_66 + 2.06791973114014) - 0.000195397197403322*std::sin(1.28911983966827*x_67 + 5.21824026107788) + 0.00181807584898023*std::sin(0.221599996089935*x_68 - 0.957519829273224) + 0.00194926252796021*std::sin(0.330159842967987*x_7 - 1.14079988002777) - 0.0039885948295364*std::sin(0.348879843950272*x_7 - 1.14639985561371) - 0.0112087647561747*std::sin(0.377519845962524*x_7 - 1.16439986228943) - 0.00596762020804876*std::sin(0.477439850568771*x_7 - 1.2397598028183) - 6.48856927050386e-5*std::sin(1.14047980308533*x_71 + 8.39352035522461) - 0.00025875700883867*std::sin(0.397839844226837*x_8 + 1.97663986682892) + 0.00692690889150552*std::sin(0.457359850406647*x_8 + 4.76743984222412) + 0.00337828239199846*std::sin(0.711519837379456*x_83 - 7.9987998008728) - 4.14079237017201e-5*std::sin(0.690639853477478*x_84 + 7.39631986618042) - 0.0231258771002616*std::sin(0.334639847278595*x_9 - 4.32807970046997) - 0.00379701627607407*std::sin(0.352079838514328*x_91 - 7.38151979446411) - 0.00440632233267166*std::sin(0.359119862318039*x_91 + 2.01399970054626) + 0.0213320739890033*std::sin(0.370799839496613*x_91 - 1.18903994560242) + 0.00310191234700342*std::sin(0.223199993371964*x_93 + 5.19488000869751) + 0.0996209216980583*std::sin(0.230719983577728*x_93 - 7.41183996200562) + 0.00189043243564377*std::sin(0.234959989786148*x_93 - 1.20967984199524) - 0.0477158866282765*std::sin(0.277119934558868*x_94 + 1.97791981697083) - 0.00954430172273121*std::sin(0.295439928770065*x_94 + 1.95231986045837) - 0.00718434227913198*std::sin(0.298399955034256*x_98 - 7.63000011444092) + 0.23120705747758);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-5.70405137663958e-5*x_1 - 0.000623737969821329*x_10 + 0.000459388781360246*x_100 + 0.0011896238933721*x_101 + 0.00077683811143812*x_102 - 0.000259844480088844*x_103 + 0.000612593846077502*x_104 + 0.00248395127288696*x_105 - 0.000979972311349978*x_106 - 0.000177889248119207*x_107 + 0.00228677975212901*x_108 + 0.00214770648566821*x_109 + 0.00319823128297032*x_11 + 0.00484712594237063*x_110 + 0.0013483977371065*x_111 - 0.00127993326060179*x_112 + 0.000896357812497889*x_113 + 0.00178758958499443*x_114 + 0.00126362565015119*x_115 + 0.00154218150711263*x_116 + 0.00237756571394268*x_117 - 0.000316742609483701*x_118 + 0.0028921599858456*x_119 + 0.00387052542389893*x_12 - 0.000476141656434365*x_120 + 0.00217796415634074*x_13 + 0.000185860766858222*x_14 - 0.00108599522109427*x_15 - 0.000746758274266135*x_16 - 0.000217193612846289*x_17 - 0.00290300439613164*x_18 + 0.000812633373781398*x_19 + 0.00139844891869648*x_2 - 0.000439226740016203*x_20 + 0.000247943634888155*x_21 + 0.000248572276919199*x_22 + 0.000115780516897395*x_23 + 6.83992498914825e-5*x_24 - 0.000103537733711097*x_25 - 0.000465496796259517*x_26 + 0.00236047850099853*x_27 + 0.000203128219237774*x_28 + 0.000219596012942071*x_29 + 0.000132845776048277*x_3 + 0.000128587185542024*x_30 + 0.000247438453501217*x_31 + 0.00178624616424454*x_32 + 0.00119824855471003*x_33 + 0.000662209848785514*x_34 + 0.00112272262494044*x_35 + 0.00087425089963262*x_36 + 0.00197395373605535*x_37 + 0.00290180933232634*x_38 + 0.000505725906986993*x_39 + 0.000656536221022461*x_4 - 0.000738289388432987*x_40 + 0.000820757500777764*x_41 - 0.000284079880572959*x_42 - 0.000240615348035176*x_43 + 0.000799245311869932*x_44 + 0.00199575901600647*x_45 - 0.000205481547391931*x_46 - 0.00182117665628631*x_47 + 0.00272240352580031*x_48 + 0.000349789445063988*x_49 + 0.000460446095343891*x_5 + 0.00171654753697647*x_50 + 0.000730570375387029*x_51 + 0.00114202530220281*x_52 - 0.00400424856416441*x_53 + 0.000867903522050367*x_54 + 0.0026558037063221*x_55 - 0.000984297259845822*x_56 - 0.000902154095665913*x_57 + 0.000362808325547314*x_58 + 0.000667665034553287*x_59 - 0.00193971969531504*x_6 + 0.000609411456923743*x_60 + 0.000608983253730876*x_61 + 1.91526708152623e-5*x_62 - 0.000977196459177421*x_63 - 0.000617383476001959*x_64 - 0.00170441979005494*x_65 + 0.000326609442687887*x_66 + 0.000749360187243753*x_67 + 9.34029854086266e-5*x_68 - 2.81479591928489e-5*x_69 + 0.000534598944322713*x_7 - 0.000160372916078752*x_70 - 0.000942819466301833*x_71 + 0.000421530714012829*x_72 + 0.00068192510344326*x_73 + 0.00192206236030227*x_74 + 0.00048608139107843*x_75 + 0.000503712820792785*x_76 + 0.000823043857254395*x_77 - 0.000335515831744443*x_78 + 0.000405279915469886*x_79 - 0.00079673369028619*x_8 - 0.000102613631439695*x_80 + 0.00105522658768929*x_81 + 0.000242431332957157*x_82 - 0.000499187411584707*x_83 + 0.000264706965257353*x_84 - 0.00116554756702659*x_85 - 0.000100010551090555*x_86 + 0.00079404859866427*x_87 + 8.48861315648527e-5*x_88 + 1.36979027668059e-5*x_89 + 0.000665496683436907*x_9 + 0.000488325906039253*x_90 + 0.0007356036569808*x_91 - 0.000689244038781994*x_92 + 0.000924766658905625*x_93 + 0.000149791384835042*x_94 - 0.00133569883440334*x_95 + 0.00268387245268037*x_96 + 0.0028348850211147*x_97 + 0.000675713302534437*x_98 + 0.00214130829042505*x_99 + 1.44631971031725e-5*std::pow(-2.20879983901978*x_24 - 4.21663999557495, 2) + 4.62200431354141e-5*std::pow(-2.59999990463257*x_29 - 1.67199993133545, 2) + 2.57179234705132e-7*std::pow(-3.28383994102478*x_60 - 6.97959995269775, 2) - 5.13969257812065e-7*std::pow(-5.24360036849976*x_61 - 6.25415992736816, 2) + 4.19111225753294e-7*std::pow(-2.94071984291077*x_67 - 7.45536041259766, 2) - 4.94590893365558e-7*std::pow(-2.85191988945007*x_7 - 7.12160015106201, 2) + 1.94475258101919e-6*std::pow(-2.31807994842529*x_9 - 5.01559972763062, 2) - 0.000762020412277526*std::exp(0.314239859580994*x_22) - 7.85674849405938e-5*std::exp(0.570879817008972*x_22) + 0.000686020725826748*std::exp(0.315199851989746*x_25) + 1.71624204773212e-5*std::exp(0.524799883365631*x_26) + 0.000584207747740204*std::exp(0.263759851455688*x_30) - 0.0013622874297925*std::exp(0.199119850993156*x_9) - 0.12755533148627*std::sin(0.286159932613373*x_1 + 8.28927993774414) - 0.00436514794601143*std::sin(0.315999925136566*x_1 - 4.27895975112915) + 0.000553895361343165*std::sin(0.320719838142395*x_1 - 4.25712013244629) + 0.234955160208373*std::sin(0.327199846506119*x_1 - 4.26064014434814) + 0.102649349007275*std::sin(0.330479830503464*x_1 - 4.24128007888794) + 0.000587640004723762*std::sin(0.226879999041557*x_100 + 1.99143981933594) - 0.0151000802235277*std::sin(0.230639979243279*x_100 - 1.18671989440918) + 0.000280891015379206*std::sin(0.361279845237732*x_100 - 1.57759976387024) + 0.00887288320895142*std::sin(0.204479992389679*x_102 - 1.18623995780945) + 0.00031587087096807*std::sin(0.187440007925034*x_104 + 8.40816020965576) + 0.00796086485417534*std::sin(0.240399971604347*x_107 + 1.78271985054016) + 0.00187594808620636*std::sin(0.242399975657463*x_107 - 4.23863983154297) - 0.00497008017695489*std::sin(0.176640018820763*x_108 + 5.21304035186768) + 0.000306091313725939*std::sin(0.243519976735115*x_109 + 5.15503978729248) + 0.00872843800761247*std::sin(0.290879935026169*x_11 - 1.21463990211487) - 0.000172790679948175*std::sin(0.297759920358658*x_11 - 4.26287984848022) - 0.00105333894560363*std::sin(0.276559948921204*x_112 - 7.4332799911499) + 0.0027752501290515*std::sin(0.28263995051384*x_112 + 1.95687973499298) - 0.00107762206755458*std::sin(0.282719939947128*x_113 - 7.41199970245361) + 0.0250412403356772*std::sin(0.230959981679916*x_118 + 5.17176008224487) + 0.0021061122213402*std::sin(0.25231996178627*x_119 - 7.4456000328064) + 8.22587996207802e-5*std::sin(0.7290398478508*x_12 - 4.77559995651245) - 0.000282384946729452*std::sin(0.251999974250793*x_120 + 5.16232013702393) - 0.0116036537890707*std::sin(0.263759940862656*x_120 + 5.16455984115601) + 0.0308768051511575*std::sin(0.270239949226379*x_120 - 7.43232011795044) + 0.026952772655013*std::sin(0.305919945240021*x_13 - 7.44199991226196) - 8.78693692593863e-6*std::sin(0.679199814796448*x_13 - 8.21103954315186) + 0.0554981091496003*std::sin(0.307679921388626*x_14 + 5.12720012664795) - 0.0155717430101237*std::sin(0.332079827785492*x_15 + 8.26583957672119) + 0.144217931218424*std::sin(0.316639930009842*x_16 + 1.99335980415344) - 0.00039569734200031*std::sin(0.336479842662811*x_17 - 1.1490398645401) + 0.0690241268885472*std::sin(0.339519828557968*x_17 + 1.9948798418045) + 0.00098605961798628*std::sin(0.491839855909348*x_17 + 1.9327198266983) - 0.000185287437221984*std::sin(0.651039838790894*x_17 - 7.63024044036865) - 0.00110803398577622*std::sin(0.336559861898422*x_18 - 1.15495979785919) - 0.0109191103214046*std::sin(0.5204798579216*x_18 - 4.33296012878418) - 0.00151307975360181*std::sin(0.312159925699234*x_19 - 7.41224002838135) + 0.00933497620517788*std::sin(0.346159845590591*x_19 + 5.02383995056152) - 0.0464361066203978*std::sin(0.353759855031967*x_2 - 7.41535997390747) - 0.0418501444469123*std::sin(0.37391984462738*x_2 - 7.3951997756958) + 0.000637315830046967*std::sin(0.188640013337135*x_20 + 1.97775971889496) + 0.00403049865394316*std::sin(0.359199851751328*x_20 - 1.15183985233307) + 0.000699302714939003*std::sin(0.293759942054749*x_21 + 2.00879979133606) + 0.00479700549003946*std::sin(0.0824000835418701*x_22 - 4.54647970199585) + 0.00104117077352771*std::sin(0.192320004105568*x_23 - 4.40319967269897) + 0.15544359198118*std::sin(0.316399931907654*x_23 - 1.16175985336304) - 0.0435917496618484*std::sin(0.334399849176407*x_23 - 1.15567982196808) + 0.0124128528340738*std::sin(0.164080023765564*x_24 - 1.23895978927612) - 0.0194269695374831*std::sin(0.224479988217354*x_24 - 1.19663989543915) - 0.000100915408050992*std::sin(0.402799844741821*x_24 - 1.20791983604431) + 0.000108427880745011*std::sin(0.406719863414764*x_25 + 5.00271987915039) - 4.13148282312111e-5*std::sin(0.784239888191223*x_26 - 4.60712003707886) + 0.000522434768335377*std::sin(0.669999837875366*x_27 - 1.0791198015213) + 0.0436389092037509*std::sin(0.299039930105209*x_28 - 7.40471982955933) + 0.000258125322290589*std::sin(0.112880066037178*x_29 + 4.91199970245361) - 0.0139981519027836*std::sin(0.148480042815208*x_29 + 1.75919997692108) + 0.0136444840724335*std::sin(0.176480010151863*x_29 + 4.97535943984985) - 0.000221674274662795*std::sin(0.205520004034042*x_3 - 7.59863996505737) - 0.0359395359120093*std::sin(0.346959829330444*x_3 - 7.38855981826782) - 0.00960731484101912*std::sin(0.367279827594757*x_3 - 4.18991994857788) + 0.014123806307369*std::sin(0.415519863367081*x_3 - 1.18831992149353) - 0.00365692815796022*std::sin(0.213119998574257*x_30 + 1.35935986042023) - 0.000659188317816688*std::sin(0.239439979195595*x_30 - 1.17183983325958) + 0.115629931861811*std::sin(0.358399868011475*x_30 + 2.01263976097107) + 0.0001716262203047*std::sin(0.347519844770432*x_31 + 5.17407989501953) + 0.0049712526864813*std::sin(0.368399828672409*x_31 + 5.17768001556396) - 0.00919349619234692*std::sin(0.369359821081161*x_31 + 5.17328023910522) + 0.00790391447507192*std::sin(0.392399847507477*x_31 - 7.40079975128174) + 0.0248831311351298*std::sin(0.412079870700836*x_31 + 5.19288015365601) + 0.0398834962187209*std::sin(0.415039867162704*x_31 - 7.40055990219116) - 0.000131092341986201*std::sin(0.893119871616364*x_31 - 7.76775979995728) + 0.000244795588633905*std::sin(0.240959972143173*x_32 + 2.01855969429016) - 0.0520543841629041*std::sin(0.309279918670654*x_32 - 1.13791990280151) - 0.000306373688981752*std::sin(0.311119943857193*x_32 + 2.01319980621338) + 0.000105416581611011*std::sin(0.238559976220131*x_33 + 1.97919988632202) - 0.00205424934657428*std::sin(0.228479996323586*x_35 + 8.19143962860107) - 0.000255341382281893*std::sin(0.244719967246056*x_39 - 7.60920000076294) + 0.0195447868894812*std::sin(0.292799949645996*x_4 + 2.00839972496033) + 0.000227622447650482*std::sin(0.302479922771454*x_40 - 1.62287986278534) + 0.00089899358801168*std::sin(0.525999844074249*x_43 + 1.85743987560272) + 0.00576730971439024*std::sin(0.553839862346649*x_43 - 1.35583984851837) - 0.00916310138197362*std::sin(0.110400065779686*x_44 + 1.74895989894867) - 0.00350612075803368*std::sin(0.297119915485382*x_44 + 5.08871984481812) - 8.78203204254531e-5*std::sin(0.539039850234985*x_44 + 1.61799991130829) - 6.70012385546812e-5*std::sin(0.612319827079773*x_45 - 4.80423974990845) + 0.000292223742237518*std::sin(0.236719980835915*x_47 - 1.83063983917236) - 0.0347669515687108*std::sin(0.159360021352768*x_48 - 7.40391969680786) - 9.01696810533622e-5*std::sin(0.191600009799004*x_49 - 4.60928010940552) - 0.0993049559619574*std::sin(0.3572798371315*x_5 + 2.02199983596802) + 0.0486357957305929*std::sin(0.358079850673676*x_5 + 2.00535988807678) - 4.90229781931533e-5*std::sin(0.5065598487854*x_5 - 1.25143992900848) + 5.89842019792296e-5*std::sin(0.773199856281281*x_5 - 4.792799949646) - 0.0408101457985764*std::sin(0.246079966425896*x_52 - 7.42615985870361) - 0.00339052360576887*std::sin(0.537599861621857*x_58 - 4.48936033248901) + 0.000797458220423807*std::sin(0.559359848499298*x_58 - 1.54263985157013) - 0.00478766648731421*std::sin(0.143680036067963*x_59 + 1.79303991794586) + 0.000368075882942645*std::sin(0.184000000357628*x_59 - 4.97879981994629) - 8.29136034001079e-5*std::sin(0.491999864578247*x_59 + 1.80147981643677) + 0.000245946196655651*std::sin(0.299999952316284*x_6 + 2.0194399356842) - 0.0679152670724339*std::sin(0.365199834108353*x_6 + 2.01551985740662) + 0.0163202380060989*std::sin(0.391679853200912*x_6 + 2.00623965263367) - 0.000233665903164033*std::sin(0.206640005111694*x_60 + 2.00567984580994) + 0.00658059298328267*std::sin(0.464879840612411*x_60 - 4.32456016540527) - 0.0014337483940947*std::sin(0.633199870586395*x_60 - 4.6450400352478) + 0.00095461838369758*std::sin(0.972639799118042*x_64 + 7.79016017913818) + 6.18015293966632e-5*std::sin(0.970799803733826*x_65 + 2.00151968002319) + 0.00967412640636031*std::sin(0.154000028967857*x_66 + 2.06791973114014) + 0.000186620133659029*std::sin(1.28911983966827*x_67 + 5.21824026107788) - 0.00173640954142556*std::sin(0.221599996089935*x_68 - 0.957519829273224) - 0.146360485305177*std::sin(0.330159842967987*x_7 - 1.14079988002777) - 0.0204799565772742*std::sin(0.348879843950272*x_7 - 1.14639985561371) + 0.010705277274946*std::sin(0.377519845962524*x_7 - 1.16439986228943) - 0.000333163990296804*std::sin(1.14047980308533*x_71 + 8.39352035522461) - 6.91146614252953e-6*std::sin(1.30631983280182*x_73 - 1.80255997180939) - 2.96182957738058e-5*std::sin(1.2772798538208*x_77 - 1.16463983058929) + 0.0194287843974379*std::sin(0.397839844226837*x_8 + 1.97663986682892) - 3.4954207930309e-5*std::sin(0.690639853477478*x_84 + 7.39631986618042) - 0.000141259079515536*std::sin(0.335679858922958*x_91 + 8.40248012542725) - 0.000695392102595741*std::sin(0.352079838514328*x_91 - 7.38151979446411) - 0.0226248325275691*std::sin(0.359119862318039*x_91 + 2.01399970054626) - 0.0627535329238498*std::sin(0.283599942922592*x_92 + 2.00687980651855) - 0.00032527664226122*std::sin(0.290319919586182*x_92 - 1.16183984279633) - 0.00504100323011071*std::sin(0.312399923801422*x_92 + 1.98295974731445) + 0.0159271705671154*std::sin(0.223199993371964*x_93 + 5.19488000869751) + 0.000346217053248119*std::sin(0.234959989786148*x_93 - 1.20967984199524) + 0.00911558040160465*std::sin(0.295439928770065*x_94 + 1.95231986045837) + 0.000206574275446325*std::sin(0.265919953584671*x_95 - 7.80767965316772) - 0.000210628383188153*std::sin(0.297759920358658*x_96 + 1.9340797662735) + 0.00276499691003127*std::sin(0.317119926214218*x_97 - 1.40455985069275) - 0.170815214514732*std::sin(-0.0303844562882766*x_10 + 0.00470375506399899*x_100 - 0.00562278261786222*x_101 + 0.00589719820826246*x_102 + 0.00524831618437639*x_103 + 0.0340523545656884*x_104 + 0.0163742058306611*x_105 + 0.0114738228832949*x_106 - 0.00160103815597065*x_109 + 0.00178535524272038*x_110 + 0.0427557723996703*x_111 + 0.0251998569603838*x_112 - 0.205239769172235*x_113 + 0.00226687935242221*x_114 - 0.00143189447292815*x_115 - 0.0745091259512694*x_116 + 0.0243155324462558*x_117 + 0.00529209997270749*x_118 - 0.0355982016961211*x_119 - 0.0305640825655738*x_120 - 0.0291807790790186*x_14 - 0.0314347690936318*x_15 + 0.00764575137552608*x_16 + 0.00707434784589401*x_19 + 0.0100359733666793*x_2 - 0.00277114908568869*x_20 + 0.0196082790489935*x_21 + 0.0493088379262758*x_24 + 0.00828049870209127*x_25 + 0.0128559668799277*x_26 + 0.0313402219816873*x_28 + 0.0111323604439872*x_32 - 0.0176983919218082*x_33 + 0.0224215775605184*x_35 - 0.0350276085876867*x_36 + 0.005210219991613*x_37 + 0.0203978629436329*x_38 + 0.00920982965687531*x_39 + 0.0161275571016476*x_4 + 0.00278176891050833*x_40 - 0.00208128837529762*x_41 + 0.00247034838873306*x_42 + 0.0107141578821752*x_43 + 0.00175792729683854*x_44 + 0.013078121631199*x_45 + 0.0261436039721278*x_46 - 0.0104183178345379*x_48 + 0.037529775673908*x_5 + 0.0028085756262714*x_50 + 0.0428394575127487*x_52 + 0.0532824437373813*x_53 + 0.00661121328215974*x_54 + 0.024121742291088*x_55 + 0.0324335536400299*x_56 + 0.00951631133935085*x_58 + 0.00306540623698466*x_59 + 0.0116055943768481*x_60 + 0.0103406997062182*x_61 + 0.0171032294216112*x_62 - 0.0050965475257011*x_64 - 0.00682712881318926*x_65 - 0.000170831911846466*x_66 - 0.0138087003567982*x_67 + 0.0212145879270151*x_68 + 0.0118602001399919*x_69 + 0.0309374365196466*x_70 + 0.0041965531616081*x_71 + 0.00510871590898246*x_72 + 0.0113033784455119*x_73 + 0.00912927415156013*x_74 + 0.00730359780544852*x_75 - 0.000478200625169762*x_76 + 0.00993450919547571*x_77 + 0.000662508726301227*x_78 + 0.0172945205699495*x_79 + 0.00589294525691055*x_80 - 0.00564910780307455*x_81 + 0.00249009504884417*x_82 - 0.00109085751206765*x_84 + 0.00346856445642258*x_85 - 0.000620518609801722*x_86 - 0.0084105952756384*x_87 - 0.00662956379685824*x_88 + 5.44856019660415e-5*x_89 - 0.00687737497328913*x_90 + 0.045107196742218*x_92 - 0.00738737287193968*x_95 - 0.00469841692530616*x_96 - 0.0362069248629994*x_97 - 0.0459042347024105*x_99 + 0.000472254592787116*std::pow(-1.86063992977142*x_63 - 6.39928007125854, 2) + 2.17723369056*std::sin(0.337999850511551*x_1 - 4.2513599395752) + 0.141984356013277*std::sin(0.291279941797256*x_107 + 4.76240015029907) - 0.718900587152582*std::sin(0.245119974017143*x_108 - 1.19279980659485) - 0.759968583018377*std::sin(0.250159978866577*x_11 - 7.40879964828491) - 1.69939318422914*std::sin(0.300079941749573*x_12 + 5.13064002990723) - 0.820258117224995*std::sin(0.277679949998856*x_13 + 5.16752004623413) - 2.07102938287024*std::sin(0.343039840459824*x_17 + 2.01007986068726) - 0.99512303899661*std::sin(0.382799834012985*x_18 + 1.98943984508514) - 0.453413034805383*std::sin(0.349839836359024*x_22 + 1.99503982067108) - 0.168506567822464*std::sin(0.487599849700928*x_23 + 1.95495975017548) + 0.97285703575271*std::sin(0.172560006380081*x_27 - 1.21567988395691) - 0.147678237682401*std::sin(0.333439826965332*x_29 - 4.36719989776611) + 1.67038949216037*std::sin(0.348559856414795*x_3 - 7.39647960662842) - 0.806363916305123*std::sin(0.371919840574265*x_30 + 1.99511981010437) - 0.792984230282258*std::sin(0.360239863395691*x_31 + 5.18207979202271) - 0.224630675722715*std::sin(0.236399978399277*x_34 - 1.21151983737946) + 0.345494257607207*std::sin(0.145360037684441*x_47 + 5.00600004196167) + 0.144169271042143*std::sin(0.249119967222214*x_49 + 5.13367986679077) + 0.301678591939122*std::sin(0.166880026459694*x_51 + 4.99487972259521) + 0.227919558188876*std::sin(0.261679977178574*x_57 - 7.46247959136963) - 0.116708458683113*std::sin(0.244319975376129*x_6 + 1.80127990245819) + 0.0568248298695768*std::sin(0.477439850568771*x_7 - 1.2397598028183) - 0.0659593616146967*std::sin(0.457359850406647*x_8 + 4.76743984222412) - 0.032168656094733*std::sin(0.711519837379456*x_83 - 7.9987998008728) + 0.220209059221748*std::sin(0.334639847278595*x_9 - 4.32807970046997) - 0.20312812024388*std::sin(0.370799839496613*x_91 - 1.18903994560242) - 0.948609618170316*std::sin(0.230719983577728*x_93 - 7.41183996200562) + 0.45435986962957*std::sin(0.277119934558868*x_94 + 1.97791981697083) + 0.0684106919515188*std::sin(0.298399955034256*x_98 - 7.63000011444092) + 9.41428313799559) + 0.0729589313268661*std::sin(0.00467805106258489*x_10 + 0.0122606604942077*x_101 + 0.0396574579091012*x_102 + 0.0149874184700137*x_103 + 0.0132703228494092*x_104 + 0.00806989872232328*x_106 - 0.0287424990814974*x_107 + 0.0123205057285592*x_108 + 0.0600192669458066*x_109 - 0.147317885792411*x_11 + 4.70849696406814e-5*x_110 + 0.0295845701914701*x_111 + 0.119521528806809*x_115 + 0.0168706679199797*x_117 + 0.0388826026490507*x_118 - 0.106816215946755*x_12 + 0.0423444376615385*x_120 - 0.0228538694327395*x_13 + 0.00242596068482882*x_14 - 0.0044731260713709*x_15 - 0.0156611647918121*x_16 - 0.00138133934746324*x_17 + 0.0851446740608637*x_18 + 0.000201646044609163*x_20 - 0.000478720520274939*x_22 + 0.027640197149035*x_23 + 0.00316292510469592*x_24 - 0.0117244379290861*x_26 + 0.0218910218687658*x_27 + 0.000960319746773086*x_28 - 0.00741811110503635*x_29 - 0.0415067566063154*x_31 + 0.0198875177706703*x_32 - 0.075748595438983*x_34 + 0.00320316849743259*x_35 - 0.00181838302695289*x_36 + 0.00689696707113886*x_37 - 0.00711755132286774*x_38 + 0.0330846508409535*x_39 - 0.000980677887563132*x_4 + 0.00432582440172454*x_40 + 0.0351606597885758*x_41 + 0.00303031697017231*x_42 + 0.0299535223765497*x_43 - 0.00912617978762598*x_44 + 0.0328485651549716*x_45 + 0.0304887482876085*x_46 - 0.0126794224201975*x_47 + 0.120147043531096*x_48 + 0.0377701524704165*x_49 - 0.0048023348967037*x_5 + 0.0168084839083984*x_50 - 0.510711212134666*x_51 + 0.0622021552962535*x_55 + 0.0558010882704347*x_56 + 0.0638534803116875*x_57 + 0.0834772867165076*x_58 + 0.127201520863422*x_59 + 0.027694382150915*x_6 - 0.00614014028123501*x_61 + 0.0104411840023417*x_62 - 0.00316053854489197*x_63 - 0.00990043895782046*x_65 + 0.00619123313190899*x_66 - 0.0120673910348483*x_67 + 0.00289757660954618*x_68 + 0.0136622966242753*x_69 - 0.0095653325009972*x_7 - 0.00805686329384515*x_70 - 0.00616167475052857*x_71 - 0.0246880122301496*x_72 + 0.000371787747136619*x_73 + 0.0234475402183992*x_74 + 0.00849698743367963*x_75 + 0.0132273305108906*x_76 + 0.0459383461470533*x_77 + 0.0351084739710696*x_78 + 0.021254311208052*x_79 - 0.0445662551045482*x_80 + 0.00561127468934869*x_81 + 0.00334446333709648*x_82 + 0.00951507857540385*x_83 + 0.0194719628766857*x_84 - 0.0217907591970336*x_85 + 0.00230269883946512*x_86 - 0.0264230181396481*x_87 + 0.0479510899834847*x_88 + 0.00870665784701129*x_89 + 0.0198885527389022*x_9 - 0.00718998503502319*x_90 - 0.00876258306161447*x_91 + 0.0927817144019838*x_92 + 0.0156524205134161*x_93 + 0.00454613159270745*x_94 - 0.00762331259614349*x_95 + 0.0319309072362414*x_96 - 0.00730021284029238*x_97 + 0.00115326955840149*x_98 + 0.0106994550559887*x_99 - 6.76266717462909e-5*std::pow(-7.80344009399414*x_8 - 3.79063987731934, 2) - 1.118370677973*std::sin(0.304639935493469*x_1 - 4.26056003570557) - 0.29402372954379*std::sin(0.246559977531433*x_100 + 8.17727947235107) - 0.709204954201901*std::sin(0.217280000448227*x_105 + 1.96951985359192) + 2.11210376162269*std::sin(0.268799960613251*x_112 - 7.42655992507935) + 1.56905579204312*std::sin(0.284879922866821*x_113 + 5.15928030014038) - 1.24751622830511*std::sin(0.217600002884865*x_114 - 4.22240018844604) - 0.857493197557531*std::sin(0.243279978632927*x_116 + 1.97951984405518) + 1.82329335636094*std::sin(0.239599987864494*x_119 + 5.15503978729248) + 2.69938175479047*std::sin(0.291519939899445*x_19 - 1.18711996078491) + 1.95356848431062*std::sin(0.379999846220016*x_2 - 4.21528005599976) + 2.56139325901343*std::sin(0.315199911594391*x_21 + 1.99711978435516) - 0.970620042964732*std::sin(0.343439847230911*x_25 - 1.15567982196808) - 3.22805090728431*std::sin(0.418559849262238*x_3 + 2.00775980949402) - 3.22943934643925*std::sin(0.332799851894379*x_30 - 1.1497597694397) + 1.28728171402418*std::sin(0.238159984350204*x_33 - 1.21919989585876) + 0.142114469229777*std::sin(0.562079846858978*x_52 - 1.55815982818604) - 0.430113358279948*std::sin(0.225839987397194*x_53 + 1.98495984077454) + 0.484637422726484*std::sin(0.230319991707802*x_54 - 7.43327951431274) - 0.557027669240426*std::sin(0.417759865522385*x_60 + 8.17088031768799) - 0.0132935318170678*std::sin(1.046719789505*x_64 + 7.78560018539429) + 3.38328289466914) - 0.282618846857292);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-9.39887768704639e-6*x_1 - 0.000267141097981121*x_10 + 0.000303160749831969*x_100 + 0.000765140109455203*x_101 - 0.000798153456672227*x_102 - 0.00160451924936377*x_103 + 2.69332392366805e-5*x_104 - 0.00142289651666522*x_105 + 0.000766294672716295*x_106 - 0.000175312358747453*x_107 - 0.000347445094392114*x_108 - 0.000674130489262829*x_109 + 0.00103598875741313*x_11 + 0.00124065557754791*x_110 - 0.00094644754346086*x_111 - 1.95675949418956e-5*x_112 - 0.000790558147187411*x_113 + 0.00130002221743979*x_114 + 9.17272957386892e-5*x_115 - 3.3566971455649e-5*x_116 + 0.00300234890197834*x_117 + 5.81263062730144e-5*x_118 + 0.00118092134412062*x_119 - 0.00263332563482479*x_12 + 0.000110374540837714*x_120 - 0.00105275424514401*x_13 - 0.000439724203719095*x_14 - 0.00153391365718746*x_15 - 0.000212372236416352*x_16 + 3.21889041365571e-6*x_17 - 0.00151586688757068*x_18 + 0.000643780503138963*x_19 + 0.000260657892607583*x_2 - 0.0002508658620119*x_20 + 8.55904548066673e-6*x_21 - 0.00021948083687321*x_22 - 1.09625531712087e-5*x_23 - 1.37294629101582e-5*x_24 + 0.00102408848745832*x_25 + 0.00093652772520519*x_26 - 0.00109771337658808*x_27 + 0.000173761151284366*x_28 + 0.000169339327814305*x_29 + 0.000197333401531051*x_3 + 0.000150660157974459*x_30 + 0.000137430426191615*x_31 - 0.0018151234054036*x_32 - 0.000392584188608263*x_33 + 0.00066115228408747*x_34 + 0.00109135231339411*x_35 + 2.70234180556118e-5*x_36 - 0.000591330702042543*x_37 - 0.000572152337840509*x_38 - 0.00208721444253661*x_39 - 0.000778280306468642*x_4 + 0.0012738803763974*x_40 + 0.000932155492119434*x_41 - 0.00128775464814137*x_42 - 0.000320093089744823*x_43 - 0.000183262773338292*x_44 - 0.00134298170375384*x_45 - 0.000147153949556742*x_46 - 0.000542992450625749*x_47 - 0.00105065408106986*x_48 - 9.09034362243824e-5*x_49 - 0.000451763936577069*x_5 + 0.000589357905854191*x_50 - 0.000460879310888113*x_51 - 0.000596090037995477*x_52 - 0.00530057980995737*x_53 + 0.000413934638640703*x_54 - 0.00271820317504539*x_55 - 0.000223816567145125*x_56 + 0.000986467612743156*x_57 + 0.000110067443433234*x_58 - 0.00096048721269029*x_59 + 0.00171097639235578*x_6 + 7.20849852600677e-5*x_60 - 3.82906508292559e-6*x_61 + 0.000196303729540163*x_62 + 0.0013019507747425*x_63 - 3.89548236045574e-5*x_64 + 0.000906202651103007*x_65 + 0.000120427123744652*x_66 - 0.000168989727054309*x_67 + 0.000170525536019631*x_68 - 0.000169513560983559*x_69 + 0.000138763283750566*x_7 + 0.000478355011535744*x_70 + 0.00112919326999494*x_71 + 0.000429154609515716*x_72 + 0.000164006292232426*x_73 - 0.00156131974223721*x_74 + 0.000135739510484776*x_75 + 9.66390313995283e-6*x_76 - 0.000858074965504322*x_77 + 0.000392798449799986*x_78 - 0.000602005931607885*x_79 - 0.000524753476571108*x_8 + 0.000693675457325855*x_80 + 0.00130185655822031*x_81 + 0.000721883198329307*x_82 - 0.000794298621720393*x_83 + 0.000508841804565816*x_84 + 0.00106015419823099*x_85 + 0.000426595260936317*x_86 + 0.000441602690089577*x_87 - 0.000485791132097164*x_88 - 0.000563484089967192*x_89 - 0.00046793855187462*x_9 + 0.000195901135238724*x_90 - 0.000656591173491771*x_91 + 0.00112142675664467*x_92 - 0.00208910600665419*x_93 - 0.000425724031331394*x_94 + 0.000877902834234114*x_95 - 0.00157655033036934*x_96 - 0.00174875136321504*x_97 - 0.00195664826323409*x_98 - 0.00297880149863011*x_99 - 1.27160696295337e-5*std::pow(-2.20879983901978*x_24 - 4.21663999557495, 2) + 1.60364042478033e-5*std::pow(-2.59999990463257*x_29 - 1.67199993133545, 2) + 6.55640991642993e-7*std::pow(-3.28383994102478*x_60 - 6.97959995269775, 2) + 2.62742087053088e-7*std::pow(-5.24360036849976*x_61 - 6.25415992736816, 2) - 6.25924993566942e-7*std::pow(-1.86063992977142*x_63 - 6.39928007125854, 2) + 1.06846301170721e-6*std::pow(-2.94071984291077*x_67 - 7.45536041259766, 2) - 1.26088742800555e-6*std::pow(-2.85191988945007*x_7 - 7.12160015106201, 2) + 8.40384911539838e-8*std::pow(-7.80344009399414*x_8 - 3.79063987731934, 2) - 9.94161312515113e-7*std::pow(-2.31807994842529*x_9 - 5.01559972763062, 2) - 0.000536205094027543*std::exp(0.314239859580994*x_22) - 1.93495926279376e-5*std::exp(0.570879817008972*x_22) + 0.000482726974067992*std::exp(0.315199851989746*x_25) + 8.29762428361225e-5*std::exp(0.524799883365631*x_26) + 0.000472506593806829*std::exp(0.263759851455688*x_30) - 0.000335504017069862*std::exp(0.199119850993156*x_9) + 0.112146883239382*std::sin(0.286159932613373*x_1 + 8.28927993774414) + 0.00138977982947776*std::sin(0.304639935493469*x_1 - 4.26056003570557) + 0.00223147214390382*std::sin(0.315999925136566*x_1 - 4.27895975112915) + 0.00141207552932438*std::sin(0.320719838142395*x_1 - 4.25712013244629) + 0.0815195242931724*std::sin(0.327199846506119*x_1 - 4.26064014434814) + 0.0722304848393824*std::sin(0.330479830503464*x_1 - 4.24128007888794) - 0.00288569979958208*std::sin(0.337999850511551*x_1 - 4.2513599395752) + 0.000475282599538769*std::sin(0.226879999041557*x_100 + 1.99143981933594) + 0.0132760184462814*std::sin(0.230639979243279*x_100 - 1.18671989440918) + 0.000365378185208152*std::sin(0.246559977531433*x_100 + 8.17727947235107) + 6.91778122278574e-5*std::sin(0.361279845237732*x_100 - 1.57759976387024) + 0.00624351408268898*std::sin(0.204479992389679*x_102 - 1.18623995780945) - 0.000161473805321979*std::sin(0.187440007925034*x_104 + 8.40816020965576) + 0.000881316686612289*std::sin(0.217280000448227*x_105 + 1.96951985359192) - 0.00699920709611265*std::sin(0.240399971604347*x_107 + 1.78271985054016) + 0.00151726478089432*std::sin(0.242399975657463*x_107 - 4.23863983154297) - 0.000188185691534986*std::sin(0.291279941797256*x_107 + 4.76240015029907) - 0.00349725842729518*std::sin(0.176640018820763*x_108 + 5.21304035186768) + 0.000952828944940706*std::sin(0.245119974017143*x_108 - 1.19279980659485) - 0.000156474476585488*std::sin(0.243519976735115*x_109 + 5.15503978729248) + 0.001007260358506*std::sin(0.250159978866577*x_11 - 7.40879964828491) - 0.00767405883153748*std::sin(0.290879935026169*x_11 - 1.21463990211487) - 0.000440504665463287*std::sin(0.297759920358658*x_11 - 4.26287984848022) - 0.00262467468387811*std::sin(0.268799960613251*x_112 - 7.42655992507935) - 0.00268533418580069*std::sin(0.276559948921204*x_112 - 7.4332799911499) + 0.00224461929940585*std::sin(0.28263995051384*x_112 + 1.95687973499298) - 0.00274724046752038*std::sin(0.282719939947128*x_113 - 7.41199970245361) - 0.00194983839799797*std::sin(0.284879922866821*x_113 + 5.15928030014038) + 0.0015502667632408*std::sin(0.217600002884865*x_114 - 4.22240018844604) + 0.00106559191272772*std::sin(0.243279978632927*x_116 + 1.97951984405518) + 0.0176205786779736*std::sin(0.230959981679916*x_118 + 5.17176008224487) - 0.00226577500626534*std::sin(0.239599987864494*x_119 + 5.15503978729248) + 0.00051869311512857*std::sin(0.25231996178627*x_119 - 7.4456000328064) + 0.00225237125091512*std::sin(0.300079941749573*x_12 + 5.13064002990723) + 6.65308280655288e-5*std::sin(0.7290398478508*x_12 - 4.77559995651245) - 0.00071989928234691*std::sin(0.251999974250793*x_120 + 5.16232013702393) - 0.00938502262045604*std::sin(0.263759940862656*x_120 + 5.16455984115601) + 0.0217268460825912*std::sin(0.270239949226379*x_120 - 7.43232011795044) + 0.00108716794836705*std::sin(0.277679949998856*x_13 + 5.16752004623413) + 0.0189656520520093*std::sin(0.305919945240021*x_13 - 7.44199991226196) - 2.24010155650093e-5*std::sin(0.679199814796448*x_13 - 8.21103954315186) + 0.0390519313596475*std::sin(0.307679921388626*x_14 + 5.12720012664795) - 0.010957249688313*std::sin(0.332079827785492*x_15 + 8.26583957672119) - 0.126796671726096*std::sin(0.316639930009842*x_16 + 1.99335980415344) - 0.001008772726138*std::sin(0.336479842662811*x_17 - 1.1490398645401) - 0.0606861399572578*std::sin(0.339519828557968*x_17 + 1.9948798418045) + 0.002744936889866*std::sin(0.343039840459824*x_17 + 2.01007986068726) + 0.000693853053881887*std::sin(0.491839855909348*x_17 + 1.9327198266983) - 4.56325722024934e-5*std::sin(0.651039838790894*x_17 - 7.63024044036865) - 0.00282477122245658*std::sin(0.336559861898422*x_18 - 1.15495979785919) + 0.00131893345516504*std::sin(0.382799834012985*x_18 + 1.98943984508514) - 0.00768336711491338*std::sin(0.5204798579216*x_18 - 4.33296012878418) - 0.00335447485235182*std::sin(0.291519939899445*x_19 - 1.18711996078491) - 0.00385737639830775*std::sin(0.312159925699234*x_19 - 7.41224002838135) - 0.00820732833607336*std::sin(0.346159845590591*x_19 + 5.02383995056152) + 0.0408267107816642*std::sin(0.353759855031967*x_2 - 7.41535997390747) - 0.014520233834776*std::sin(0.37391984462738*x_2 - 7.3951997756958) - 0.00242766564652717*std::sin(0.379999846220016*x_2 - 4.21528005599976) + 0.00162474386114748*std::sin(0.188640013337135*x_20 + 1.97775971889496) - 0.00354362186725926*std::sin(0.359199851751328*x_20 - 1.15183985233307) + 0.0017827703936009*std::sin(0.293759942054749*x_21 + 2.00879979133606) - 0.00318299894377517*std::sin(0.315199911594391*x_21 + 1.99711978435516) + 0.0122292666436012*std::sin(0.0824000835418701*x_22 - 4.54647970199585) + 0.000600952442238417*std::sin(0.349839836359024*x_22 + 1.99503982067108) + 0.00265431320381711*std::sin(0.192320004105568*x_23 - 4.40319967269897) - 0.136666293420279*std::sin(0.316399931907654*x_23 - 1.16175985336304) - 0.0151244973397877*std::sin(0.334399849176407*x_23 - 1.15567982196808) + 0.000223338161218917*std::sin(0.487599849700928*x_23 + 1.95495975017548) + 0.00873445752083153*std::sin(0.164080023765564*x_24 - 1.23895978927612) - 0.00674033851288506*std::sin(0.224479988217354*x_24 - 1.19663989543915) - 0.000257269130933026*std::sin(0.402799844741821*x_24 - 1.20791983604431) + 0.0012061726799241*std::sin(0.343439847230911*x_25 - 1.15567982196808) + 0.000276421085609477*std::sin(0.406719863414764*x_25 + 5.00271987915039) - 0.00010532613561172*std::sin(0.784239888191223*x_26 - 4.60712003707886) - 0.00128942215310454*std::sin(0.172560006380081*x_27 - 1.21567988395691) + 0.0001286651844539*std::sin(0.669999837875366*x_27 - 1.0791198015213) - 0.0383674096420959*std::sin(0.299039930105209*x_28 - 7.40471982955933) + 0.000658052904111048*std::sin(0.112880066037178*x_29 + 4.91199970245361) - 0.00984997283053132*std::sin(0.148480042815208*x_29 + 1.75919997692108) - 0.0119962556194487*std::sin(0.176480010151863*x_29 + 4.97535943984985) + 0.000195732347304036*std::sin(0.333439826965332*x_29 - 4.36719989776611) - 0.000565126268566333*std::sin(0.205520004034042*x_3 - 7.59863996505737) - 0.025289299239909*std::sin(0.346959829330444*x_3 - 7.38855981826782) - 0.00221392983383028*std::sin(0.348559856414795*x_3 - 7.39647960662842) - 0.00236608857420624*std::sin(0.367279827594757*x_3 - 4.18991994857788) - 0.012417676614471*std::sin(0.415519863367081*x_3 - 1.18831992149353) + 0.00401144283181881*std::sin(0.418559849262238*x_3 + 2.00775980949402) + 0.00321517799661488*std::sin(0.213119998574257*x_30 + 1.35935986042023) - 0.00168050458221612*std::sin(0.239439979195595*x_30 - 1.17183983325958) + 0.00401316822105692*std::sin(0.332799851894379*x_30 - 1.1497597694397) + 0.0401187061866066*std::sin(0.358399868011475*x_30 + 2.01263976097107) + 0.00106875261105913*std::sin(0.371919840574265*x_30 + 1.99511981010437) + 0.000437536045246919*std::sin(0.347519844770432*x_31 + 5.17407989501953) + 0.0010510192104407*std::sin(0.360239863395691*x_31 + 5.18207979202271) + 0.00402074379007876*std::sin(0.368399828672409*x_31 + 5.17768001556396) + 0.00469973318477171*std::sin(0.369359821081161*x_31 + 5.17328023910522) + 0.00194657529605714*std::sin(0.392399847507477*x_31 - 7.40079975128174) - 0.0218772948925464*std::sin(0.412079870700836*x_31 + 5.19288015365601) + 0.0280645157210273*std::sin(0.415039867162704*x_31 - 7.40055990219116) - 0.000633800460545576*std::sin(0.893119871616364*x_31 - 7.76775979995728) - 0.000125139982365598*std::sin(0.240959972143173*x_32 + 2.01855969429016) - 0.0366287116524779*std::sin(0.309279918670654*x_32 - 1.13791990280151) - 0.000781055085911683*std::sin(0.311119943857193*x_32 + 2.01319980621338) - 0.0015996826421173*std::sin(0.238159984350204*x_33 - 1.21919989585876) + 0.000268744217169406*std::sin(0.238559976220131*x_33 + 1.97919988632202) + 0.000297724906023431*std::sin(0.236399978399277*x_34 - 1.21151983737946) - 0.000505920331323757*std::sin(0.228479996323586*x_35 + 8.19143962860107) - 0.00123451517636051*std::sin(0.244719967246056*x_39 - 7.60920000076294) + 0.0137529311852682*std::sin(0.292799949645996*x_4 + 2.00839972496033) - 0.000116361039199913*std::sin(0.302479922771454*x_40 - 1.62287986278534) + 0.000311912832952169*std::sin(0.525999844074249*x_43 + 1.85743987560272) - 0.00507062936224423*std::sin(0.553839862346649*x_43 - 1.35583984851837) - 0.00644772969193856*std::sin(0.110400065779686*x_44 + 1.74895989894867) - 0.000863487082774816*std::sin(0.297119915485382*x_44 + 5.08871984481812) - 7.10289800704734e-5*std::sin(0.539039850234985*x_44 + 1.61799991130829) - 5.41905291957711e-5*std::sin(0.612319827079773*x_45 - 4.80423974990845) - 0.000457917179151055*std::sin(0.145360037684441*x_47 + 5.00600004196167) - 0.00014938534699292*std::sin(0.236719980835915*x_47 - 1.83063983917236) - 0.0120626648526959*std::sin(0.159360021352768*x_48 - 7.40391969680786) - 0.000229874465447187*std::sin(0.191600009799004*x_49 - 4.60928010940552) - 0.00019108157216013*std::sin(0.249119967222214*x_49 + 5.13367986679077) - 0.0344546285461183*std::sin(0.3572798371315*x_5 + 2.02199983596802) + 0.0342231795928966*std::sin(0.358079850673676*x_5 + 2.00535988807678) - 0.000124976940975439*std::sin(0.5065598487854*x_5 - 1.25143992900848) + 4.77063586941913e-5*std::sin(0.773199856281281*x_5 - 4.792799949646) - 0.000399844011265973*std::sin(0.166880026459694*x_51 + 4.99487972259521) - 0.0287165641663071*std::sin(0.246079966425896*x_52 - 7.42615985870361) - 0.00017660318417008*std::sin(0.562079846858978*x_52 - 1.55815982818604) + 0.00053449440467255*std::sin(0.225839987397194*x_53 + 1.98495984077454) - 0.000602250513162701*std::sin(0.230319991707802*x_54 - 7.43327951431274) - 0.000302083982182597*std::sin(0.261679977178574*x_57 - 7.46247959136963) + 0.00298095462185725*std::sin(0.537599861621857*x_58 - 4.48936033248901) + 0.000196397933759341*std::sin(0.559359848499298*x_58 - 1.54263985157013) - 0.00117910604161512*std::sin(0.143680036067963*x_59 + 1.79303991794586) + 0.000297699375580708*std::sin(0.184000000357628*x_59 - 4.97879981994629) - 0.000211376152574171*std::sin(0.491999864578247*x_59 + 1.80147981643677) + 0.000154685083779302*std::sin(0.244319975376129*x_6 + 1.80127990245819) + 0.000627003997624524*std::sin(0.299999952316284*x_6 + 2.0194399356842) - 0.0235637313054905*std::sin(0.365199834108353*x_6 + 2.01551985740662) + 0.011483937455766*std::sin(0.391679853200912*x_6 + 2.00623965263367) + 0.00011945046544576*std::sin(0.206640005111694*x_60 + 2.00567984580994) + 0.000692208615997035*std::sin(0.417759865522385*x_60 + 8.17088031768799) + 0.0022831880308074*std::sin(0.464879840612411*x_60 - 4.32456016540527) - 0.00100887480188313*std::sin(0.633199870586395*x_60 - 4.6450400352478) + 0.000331212289406746*std::sin(0.972639799118042*x_64 + 7.79016017913818) + 1.65196412475397e-5*std::sin(1.046719789505*x_64 + 7.78560018539429) + 4.99850100588803e-5*std::sin(0.970799803733826*x_65 + 2.00151968002319) - 0.00850550981990034*std::sin(0.154000028967857*x_66 + 2.06791973114014) + 4.5960788552718e-5*std::sin(1.28911983966827*x_67 + 5.21824026107788) - 0.000427642774708308*std::sin(0.221599996089935*x_68 - 0.957519829273224) + 0.128680409239858*std::sin(0.330159842967987*x_7 - 1.14079988002777) - 0.0144109749099449*std::sin(0.348879843950272*x_7 - 1.14639985561371) + 0.00263649465673934*std::sin(0.377519845962524*x_7 - 1.16439986228943) - 7.53154798572618e-5*std::sin(0.477439850568771*x_7 - 1.2397598028183) - 0.000234434965081523*std::sin(1.14047980308533*x_71 + 8.39352035522461) - 1.76197760312591e-5*std::sin(1.30631983280182*x_73 - 1.80255997180939) + 1.51409305678958e-5*std::sin(1.2772798538208*x_77 - 1.16463983058929) - 0.0170818231579535*std::sin(0.397839844226837*x_8 + 1.97663986682892) + 8.74223641758619e-5*std::sin(0.457359850406647*x_8 + 4.76743984222412) + 4.26362520697167e-5*std::sin(0.711519837379456*x_83 - 7.9987998008728) - 0.000168995326108124*std::sin(0.690639853477478*x_84 + 7.39631986618042) - 0.000291864507157664*std::sin(0.334639847278595*x_9 - 4.32807970046997) - 0.000360119443851408*std::sin(0.335679858922958*x_91 + 8.40248012542725) - 0.000562432379626366*std::sin(0.352079838514328*x_91 - 7.38151979446411) - 0.0159202434178159*std::sin(0.359119862318039*x_91 + 2.01399970054626) + 0.000269225475620158*std::sin(0.370799839496613*x_91 - 1.18903994560242) - 0.0217728274072861*std::sin(0.283599942922592*x_92 + 2.00687980651855) - 0.000829245411414992*std::sin(0.290319919586182*x_92 - 1.16183984279633) + 0.00257697068334182*std::sin(0.312399923801422*x_92 + 1.98295974731445) + 0.0112073506876381*std::sin(0.223199993371964*x_93 + 5.19488000869751) + 0.00125728468969798*std::sin(0.230719983577728*x_93 - 7.41183996200562) + 0.000280019977791965*std::sin(0.234959989786148*x_93 - 1.20967984199524) - 0.000602207374620844*std::sin(0.277119934558868*x_94 + 1.97791981697083) + 0.00224498426380364*std::sin(0.295439928770065*x_94 + 1.95231986045837) - 0.000105601172516223*std::sin(0.265919953584671*x_95 - 7.80767965316772) - 0.000536966377475909*std::sin(0.297759920358658*x_96 + 1.9340797662735) + 0.000959337230890954*std::sin(0.317119926214218*x_97 - 1.40455985069275) - 9.06713509485484e-5*std::sin(0.298399955034256*x_98 - 7.63000011444092) - 0.00432059897202003);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000206703728998688*x_1 - 0.000100708981836307*x_10 - 1.37185801858641e-5*x_100 - 2.39972023609132e-5*x_101 - 0.000543120477136601*x_102 - 4.74740882550412e-5*x_103 + 0.000834168381539964*x_104 + 0.000222400059881227*x_105 - 0.000270190962227845*x_106 + 0.000278549470282909*x_107 + 0.00169406710350039*x_108 + 0.000692334636673487*x_109 + 0.00169868593562937*x_11 + 0.000780338143418656*x_110 - 5.7551171695976e-5*x_111 + 0.000758559712327421*x_112 - 0.000409058123834887*x_113 - 0.000330429334450426*x_114 + 0.000729515342104303*x_115 - 0.00157896333965641*x_116 + 0.000796366785788584*x_117 - 0.000437230112591996*x_118 - 0.00179706299247284*x_119 + 0.000265642517548693*x_12 - 0.000137260101466557*x_120 - 0.000138838458773798*x_13 - 0.00016846205466426*x_14 + 1.87459749582169e-5*x_15 - 0.00034633602273543*x_16 - 1.03017843752964e-5*x_17 - 6.1641587258282e-5*x_18 - 0.000392192484445837*x_19 + 0.00383340699371445*x_2 - 0.000331653577256572*x_20 - 0.000243642172126741*x_21 - 0.000278780852364779*x_22 + 0.000154650862929976*x_23 + 0.000173996009026371*x_24 + 0.000187637809358367*x_25 + 9.83762146670947e-5*x_26 + 0.000115438939521233*x_27 + 0.000244903381030497*x_28 + 0.000618615444534971*x_29 - 9.49864322157622e-5*x_3 - 0.000110676819924423*x_30 + 2.48211374189036e-5*x_31 + 4.28829191290663e-5*x_32 - 0.00153809451316731*x_33 + 0.000257705208158441*x_34 - 4.09789681358294e-5*x_35 + 0.000521989317703544*x_36 + 0.00057493434965674*x_37 - 0.000576834100610365*x_38 - 0.00074878673259714*x_39 - 0.00026762411016997*x_4 - 0.000151239278497559*x_40 + 0.000391267196648521*x_41 - 0.00106920105860316*x_42 + 0.000161078029465121*x_43 - 3.09623033854935e-5*x_44 - 0.000274825072785301*x_45 - 0.000629076025368251*x_46 - 0.000641037655836965*x_47 + 0.000158313262312219*x_48 + 0.000412915373025341*x_49 - 0.000419399596364012*x_5 - 0.000186276007378311*x_50 + 0.000938816532877906*x_51 + 0.000713116503895156*x_52 + 0.00161303556345319*x_53 + 0.000517787331427909*x_54 + 0.000472965754934221*x_55 - 0.000289988402611785*x_56 + 0.00210957832907566*x_57 + 2.94822640413449e-5*x_58 - 7.20807524808097e-5*x_59 - 0.000411867089498652*x_6 + 0.000701128498634953*x_60 - 0.000206375816406206*x_61 + 0.000191870181888875*x_62 + 0.000512952049792058*x_63 - 0.00116316353122307*x_64 - 0.000338336407506333*x_65 + 0.000870219870948464*x_66 - 9.94707207444327e-7*x_67 - 4.30765103793736e-5*x_68 - 0.000128660555311701*x_69 - 0.000807768217145042*x_7 + 7.93473338487674e-5*x_70 + 0.000862764890081882*x_71 + 0.000305757599800065*x_72 - 0.000101119618490123*x_73 - 0.000191755595170311*x_74 + 0.000244308237591475*x_75 - 0.00012049572295848*x_76 - 0.000412430222131164*x_77 + 0.000167910481779164*x_78 + 0.00023288690936337*x_79 - 0.000975290491182219*x_8 + 0.000440987902360416*x_80 - 0.00052601415703163*x_81 + 0.000104303181538507*x_82 - 0.000289532310622316*x_83 - 1.47255172694176e-5*x_84 + 0.000159697616071763*x_85 + 0.000855700055490932*x_86 + 0.000185331900832498*x_87 - 0.00127134044881665*x_88 - 0.000992773605181312*x_89 + 4.16222260562495e-5*x_9 + 0.000103118553828339*x_90 + 0.000279108103158872*x_91 + 0.000852948395880538*x_92 + 0.000378458962506834*x_93 - 0.000184382077634181*x_94 + 0.00113062916088772*x_95 - 0.000666828890985586*x_96 + 0.000361683625325791*x_97 - 0.00123156699029757*x_98 + 0.00167534848466468*x_99 + 1.66608958836032e-7*std::pow(-2.20879983901978*x_24 - 4.21663999557495, 2) - 1.71906334778185e-6*std::pow(-2.59999990463257*x_29 - 1.67199993133545, 2) + 3.00754137851863e-6*std::pow(-3.28383994102478*x_60 - 6.97959995269775, 2) - 6.56328212499843e-8*std::pow(-5.24360036849976*x_61 - 6.25415992736816, 2) + 6.84474912100173e-7*std::pow(-1.86063992977142*x_63 - 6.39928007125854, 2) + 4.90122911789481e-6*std::pow(-2.94071984291077*x_67 - 7.45536041259766, 2) - 5.78391400433594e-6*std::pow(-2.85191988945007*x_7 - 7.12160015106201, 2) + 5.54352680094067e-8*std::pow(-7.80344009399414*x_8 - 3.79063987731934, 2) + 2.48340920367167e-7*std::pow(-2.31807994842529*x_9 - 5.01559972763062, 2) + 2.04166391959526e-6*std::exp(0.314239859580994*x_22) - 0.000178767070194082*std::exp(0.570879817008972*x_22) - 1.8380396921768e-6*std::exp(0.315199851989746*x_25) - 2.92450391454421e-5*std::exp(0.524799883365631*x_26) + 0.00230607027981358*std::exp(0.263759851455688*x_30) - 0.00309965544614761*std::exp(0.199119850993156*x_9) - 0.0014693750504341*std::sin(0.286159932613373*x_1 + 8.28927993774414) + 0.000916756313247005*std::sin(0.304639935493469*x_1 - 4.26056003570557) - 0.000557420449794807*std::sin(0.315999925136566*x_1 - 4.27895975112915) + 0.00647744060876101*std::sin(0.320719838142395*x_1 - 4.25712013244629) - 0.0087386937979068*std::sin(0.327199846506119*x_1 - 4.26064014434814) - 0.000275026060800281*std::sin(0.330479830503464*x_1 - 4.24128007888794) + 0.00315563228336749*std::sin(0.337999850511551*x_1 - 4.2513599395752) + 0.00231961858664978*std::sin(0.226879999041557*x_100 + 1.99143981933594) - 0.00017394554097798*std::sin(0.230639979243279*x_100 - 1.18671989440918) + 0.000241018577840618*std::sin(0.246559977531433*x_100 + 8.17727947235107) + 0.000639120164036679*std::sin(0.361279845237732*x_100 - 1.57759976387024) - 2.37729137154676e-5*std::sin(0.204479992389679*x_102 - 1.18623995780945) + 4.03360630956351e-5*std::sin(0.187440007925034*x_104 + 8.40816020965576) + 0.000581352973532041*std::sin(0.217280000448227*x_105 + 1.96951985359192) + 9.17052706484636e-5*std::sin(0.240399971604347*x_107 + 1.78271985054016) + 0.00740501669963723*std::sin(0.242399975657463*x_107 - 4.23863983154297) + 0.000205788850095093*std::sin(0.291279941797256*x_107 + 4.76240015029907) + 1.33162225201506e-5*std::sin(0.176640018820763*x_108 + 5.21304035186768) - 0.00104195792632946*std::sin(0.245119974017143*x_108 - 1.19279980659485) + 3.90872336712661e-5*std::sin(0.243519976735115*x_109 + 5.15503978729248) - 0.0011014809321185*std::sin(0.250159978866577*x_11 - 7.40879964828491) + 0.000100547338070514*std::sin(0.290879935026169*x_11 - 1.21463990211487) - 0.00202067293793115*std::sin(0.297759920358658*x_11 - 4.26287984848022) - 0.00173134408460153*std::sin(0.268799960613251*x_112 - 7.42655992507935) - 0.012318103629713*std::sin(0.276559948921204*x_112 - 7.4332799911499) + 0.0109548732730955*std::sin(0.28263995051384*x_112 + 1.95687973499298) - 0.0126020787109471*std::sin(0.282719939947128*x_113 - 7.41199970245361) - 0.00128619413180559*std::sin(0.284879922866821*x_113 + 5.15928030014038) + 0.00102262013901299*std::sin(0.217600002884865*x_114 - 4.22240018844604) + 0.000702908541783325*std::sin(0.243279978632927*x_116 + 1.97951984405518) - 6.70924243911796e-5*std::sin(0.230959981679916*x_118 + 5.17176008224487) - 0.00149459899858495*std::sin(0.239599987864494*x_119 + 5.15503978729248) + 0.00479210339485371*std::sin(0.25231996178627*x_119 - 7.4456000328064) - 0.00246306127704134*std::sin(0.300079941749573*x_12 + 5.13064002990723) + 0.000324703966683747*std::sin(0.7290398478508*x_12 - 4.77559995651245) - 0.00330230554163267*std::sin(0.251999974250793*x_120 + 5.16232013702393) - 0.045803639619175*std::sin(0.263759940862656*x_120 + 5.16455984115601) - 8.27275201737406e-5*std::sin(0.270239949226379*x_120 - 7.43232011795044) - 0.00118886319214713*std::sin(0.277679949998856*x_13 + 5.16752004623413) - 7.22139493590789e-5*std::sin(0.305919945240021*x_13 - 7.44199991226196) - 0.000102757426840832*std::sin(0.679199814796448*x_13 - 8.21103954315186) - 0.000148694818709438*std::sin(0.307679921388626*x_14 + 5.12720012664795) + 4.17210160735176e-5*std::sin(0.332079827785492*x_15 + 8.26583957672119) + 0.00166132005215621*std::sin(0.316639930009842*x_16 + 1.99335980415344) - 0.00462741920357703*std::sin(0.336479842662811*x_17 - 1.1490398645401) + 0.000795124192350559*std::sin(0.339519828557968*x_17 + 1.9948798418045) - 0.00300170220988405*std::sin(0.343039840459824*x_17 + 2.01007986068726) - 2.64192705625222e-6*std::sin(0.491839855909348*x_17 + 1.9327198266983) - 0.000421590334996584*std::sin(0.651039838790894*x_17 - 7.63024044036865) - 0.0129577260187734*std::sin(0.336559861898422*x_18 - 1.15495979785919) - 0.00144230837571358*std::sin(0.382799834012985*x_18 + 1.98943984508514) + 2.92553233720633e-5*std::sin(0.5204798579216*x_18 - 4.33296012878418) - 0.00221275048989409*std::sin(0.291519939899445*x_19 - 1.18711996078491) - 0.0176944688912141*std::sin(0.312159925699234*x_19 - 7.41224002838135) + 0.0001075343615391*std::sin(0.346159845590591*x_19 + 5.02383995056152) - 0.000534921243293185*std::sin(0.353759855031967*x_2 - 7.41535997390747) + 0.00155653358451628*std::sin(0.37391984462738*x_2 - 7.3951997756958) - 0.00160138876727184*std::sin(0.379999846220016*x_2 - 4.21528005599976) + 0.00745298792201809*std::sin(0.188640013337135*x_20 + 1.97775971889496) + 4.64293737776829e-5*std::sin(0.359199851751328*x_20 - 1.15183985233307) + 0.00817788362151737*std::sin(0.293759942054749*x_21 + 2.00879979133606) - 0.00209963788139086*std::sin(0.315199911594391*x_21 + 1.99711978435516) + 0.0560978125656848*std::sin(0.0824000835418701*x_22 - 4.54647970199585) - 0.000657166392627095*std::sin(0.349839836359024*x_22 + 1.99503982067108) + 0.0121758048898431*std::sin(0.192320004105568*x_23 - 4.40319967269897) + 0.00179063417534679*std::sin(0.316399931907654*x_23 - 1.16175985336304) + 0.0016213091556366*std::sin(0.334399849176407*x_23 - 1.15567982196808) - 0.000244229532036706*std::sin(0.487599849700928*x_23 + 1.95495975017548) - 3.32574736348983e-5*std::sin(0.164080023765564*x_24 - 1.23895978927612) + 0.000722547817459164*std::sin(0.224479988217354*x_24 - 1.19663989543915) - 0.00118013908001335*std::sin(0.402799844741821*x_24 - 1.20791983604431) + 0.000795641435954638*std::sin(0.343439847230911*x_25 - 1.15567982196808) + 0.00126799248897211*std::sin(0.406719863414764*x_25 + 5.00271987915039) - 0.000483149643065944*std::sin(0.784239888191223*x_26 - 4.60712003707886) + 0.00141003654427781*std::sin(0.172560006380081*x_27 - 1.21567988395691) + 0.00118871226402953*std::sin(0.669999837875366*x_27 - 1.0791198015213) + 0.000502698896745467*std::sin(0.299039930105209*x_28 - 7.40471982955933) + 0.00301860524829112*std::sin(0.112880066037178*x_29 + 4.91199970245361) + 3.75049292912096e-5*std::sin(0.148480042815208*x_29 + 1.75919997692108) + 0.000157177785032351*std::sin(0.176480010151863*x_29 + 4.97535943984985) - 0.000214041430831221*std::sin(0.333439826965332*x_29 - 4.36719989776611) - 0.00259233430866165*std::sin(0.205520004034042*x_3 - 7.59863996505737) + 9.62919792912631e-5*std::sin(0.346959829330444*x_3 - 7.38855981826782) + 0.00242102399485804*std::sin(0.348559856414795*x_3 - 7.39647960662842) - 0.021859825700921*std::sin(0.367279827594757*x_3 - 4.18991994857788) + 0.000162699342813793*std::sin(0.415519863367081*x_3 - 1.18831992149353) + 0.00264611376802126*std::sin(0.418559849262238*x_3 + 2.00775980949402) - 4.21260243215709e-5*std::sin(0.213119998574257*x_30 + 1.35935986042023) - 0.00770877222783111*std::sin(0.239439979195595*x_30 - 1.17183983325958) + 0.00264725190619487*std::sin(0.332799851894379*x_30 - 1.1497597694397) - 0.00430062726656891*std::sin(0.358399868011475*x_30 + 2.01263976097107) - 0.00116872525786637*std::sin(0.371919840574265*x_30 + 1.99511981010437) + 0.00200705535109379*std::sin(0.347519844770432*x_31 + 5.17407989501953) - 0.00114933304960773*std::sin(0.360239863395691*x_31 + 5.18207979202271) + 0.0196232557991272*std::sin(0.368399828672409*x_31 + 5.17768001556396) - 0.00117399062897912*std::sin(0.369359821081161*x_31 + 5.17328023910522) + 0.0179840252598332*std::sin(0.392399847507477*x_31 - 7.40079975128174) + 0.000286641504048579*std::sin(0.412079870700836*x_31 + 5.19288015365601) - 0.000106858942234503*std::sin(0.415039867162704*x_31 - 7.40055990219116) + 0.000223383448629533*std::sin(0.893119871616364*x_31 - 7.76775979995728) + 3.12598951540184e-5*std::sin(0.240959972143173*x_32 + 2.01855969429016) + 0.00013946812485575*std::sin(0.309279918670654*x_32 - 1.13791990280151) - 0.00358283804661943*std::sin(0.311119943857193*x_32 + 2.01319980621338) - 0.00105521689856713*std::sin(0.238159984350204*x_33 - 1.21919989585876) + 0.00123277733344454*std::sin(0.238559976220131*x_33 + 1.97919988632202) - 0.000325574519271255*std::sin(0.236399978399277*x_34 - 1.21151983737946) - 0.00467409816430885*std::sin(0.228479996323586*x_35 + 8.19143962860107) + 0.000435105801664335*std::sin(0.244719967246056*x_39 - 7.60920000076294) - 5.23659019699583e-5*std::sin(0.292799949645996*x_4 + 2.00839972496033) + 2.9066920233176e-5*std::sin(0.302479922771454*x_40 - 1.62287986278534) - 3.34362934823327e-5*std::sin(0.525999844074249*x_43 + 1.85743987560272) + 6.64365879787891e-5*std::sin(0.553839862346649*x_43 - 1.35583984851837) + 2.45504886506315e-5*std::sin(0.110400065779686*x_44 + 1.74895989894867) - 0.00797758686222747*std::sin(0.297119915485382*x_44 + 5.08871984481812) - 0.000346657215143445*std::sin(0.539039850234985*x_44 + 1.61799991130829) - 0.000264477089766979*std::sin(0.612319827079773*x_45 - 4.80423974990845) + 0.000500751406590151*std::sin(0.145360037684441*x_47 + 5.00600004196167) + 3.7316373202791e-5*std::sin(0.236719980835915*x_47 - 1.83063983917236) + 0.00129308819510997*std::sin(0.159360021352768*x_48 - 7.40391969680786) - 0.00105447489633736*std::sin(0.191600009799004*x_49 - 4.60928010940552) + 0.000208955615532998*std::sin(0.249119967222214*x_49 + 5.13367986679077) + 0.00369345198461081*std::sin(0.3572798371315*x_5 + 2.02199983596802) - 0.000130308778799212*std::sin(0.358079850673676*x_5 + 2.00535988807678) - 0.000573291368500923*std::sin(0.5065598487854*x_5 - 1.25143992900848) + 0.000232831070263915*std::sin(0.773199856281281*x_5 - 4.792799949646) + 0.000437245991577084*std::sin(0.166880026459694*x_51 + 4.99487972259521) + 0.000109341693329903*std::sin(0.246079966425896*x_52 - 7.42615985870361) - 0.000116494771756964*std::sin(0.562079846858978*x_52 - 1.55815982818604) + 0.000352574637712859*std::sin(0.225839987397194*x_53 + 1.98495984077454) - 0.000397269372016734*std::sin(0.230319991707802*x_54 - 7.43327951431274) + 0.000330341349644779*std::sin(0.261679977178574*x_57 - 7.46247959136963) - 3.90571741390588e-5*std::sin(0.537599861621857*x_58 - 4.48936033248901) + 0.00181448177671898*std::sin(0.559359848499298*x_58 - 1.54263985157013) - 0.0108935281770913*std::sin(0.143680036067963*x_59 + 1.79303991794586) + 0.00145292296730656*std::sin(0.184000000357628*x_59 - 4.97879981994629) - 0.00096961985812664*std::sin(0.491999864578247*x_59 + 1.80147981643677) - 0.000169154547607503*std::sin(0.244319975376129*x_6 + 1.80127990245819) + 0.00287617841377918*std::sin(0.299999952316284*x_6 + 2.0194399356842) + 0.00252597441410828*std::sin(0.365199834108353*x_6 + 2.01551985740662) - 4.37264416535396e-5*std::sin(0.391679853200912*x_6 + 2.00623965263367) - 2.98386571209846e-5*std::sin(0.206640005111694*x_60 + 2.00567984580994) + 0.000456609460965996*std::sin(0.417759865522385*x_60 + 8.17088031768799) - 0.000244752177558312*std::sin(0.464879840612411*x_60 - 4.32456016540527) + 3.84140938856465e-6*std::sin(0.633199870586395*x_60 - 4.6450400352478) - 3.55051480528776e-5*std::sin(0.972639799118042*x_64 + 7.79016017913818) + 1.08970392899921e-5*std::sin(1.046719789505*x_64 + 7.78560018539429) + 0.00024395203716478*std::sin(0.970799803733826*x_65 + 2.00151968002319) + 0.000111441206028942*std::sin(0.154000028967857*x_66 + 2.06791973114014) + 0.00042462266112601*std::sin(1.28911983966827*x_67 + 5.21824026107788) - 0.00395090725651211*std::sin(0.221599996089935*x_68 - 0.957519829273224) - 0.00168600122763196*std::sin(0.330159842967987*x_7 - 1.14079988002777) + 5.48714807963308e-5*std::sin(0.348879843950272*x_7 - 1.14639985561371) + 0.0243580541683931*std::sin(0.377519845962524*x_7 - 1.16439986228943) + 8.23605974915719e-5*std::sin(0.477439850568771*x_7 - 1.2397598028183) + 8.92638684394768e-7*std::sin(1.14047980308533*x_71 + 8.39352035522461) - 8.08250340806902e-5*std::sin(1.30631983280182*x_73 - 1.80255997180939) - 3.78219569109359e-6*std::sin(1.2772798538208*x_77 - 1.16463983058929) + 0.000223810096537841*std::sin(0.397839844226837*x_8 + 1.97663986682892) - 9.55999770737111e-5*std::sin(0.457359850406647*x_8 + 4.76743984222412) - 4.66245080283394e-5*std::sin(0.711519837379456*x_83 - 7.9987998008728) + 5.95625296892484e-5*std::sin(0.690639853477478*x_84 + 7.39631986618042) + 0.000319165930319312*std::sin(0.334639847278595*x_9 - 4.32807970046997) - 0.00165193168578144*std::sin(0.335679858922958*x_91 + 8.40248012542725) - 0.00274495342935138*std::sin(0.352079838514328*x_91 - 7.38151979446411) + 6.06181980353564e-5*std::sin(0.359119862318039*x_91 + 2.01399970054626) - 0.000294409211413807*std::sin(0.370799839496613*x_91 - 1.18903994560242) + 0.00233399389258804*std::sin(0.283599942922592*x_92 + 2.00687980651855) - 0.00380389560684349*std::sin(0.290319919586182*x_92 - 1.16183984279633) - 0.00064372578494457*std::sin(0.312399923801422*x_92 + 1.98295974731445) - 4.26733050246377e-5*std::sin(0.223199993371964*x_93 + 5.19488000869751) - 0.00137489289661011*std::sin(0.230719983577728*x_93 - 7.41183996200562) + 0.00136663859722581*std::sin(0.234959989786148*x_93 - 1.20967984199524) + 0.00065853871317825*std::sin(0.277119934558868*x_94 + 1.97791981697083) + 0.020740966861108*std::sin(0.295439928770065*x_94 + 1.95231986045837) + 2.63791117642511e-5*std::sin(0.265919953584671*x_95 - 7.80767965316772) - 0.00246315989957415*std::sin(0.297759920358658*x_96 + 1.9340797662735) - 0.00010283860685372*std::sin(0.317119926214218*x_97 - 1.40455985069275) + 9.91528787128935e-5*std::sin(0.298399955034256*x_98 - 7.63000011444092) - 0.0646469569118093);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000646650724280239*x_1 + 0.00111795088311208*x_10 + 0.00027036577182725*x_100 + 0.000523103198557237*x_101 + 0.00151984678214697*x_102 + 0.00373863907615698*x_103 - 0.00139387594607408*x_104 - 0.0016365364130917*x_105 - 7.41599497961361e-5*x_106 + 0.000444578588379166*x_107 - 0.00531297258998927*x_108 - 0.00195170399280826*x_109 - 0.00421513543031754*x_11 - 0.000330254907329785*x_110 + 0.00067507644529373*x_111 - 0.0014470194805658*x_112 + 0.00706105633283199*x_113 + 0.00241707597231189*x_114 - 0.00192275154863839*x_115 + 0.000200459273316846*x_116 - 0.00202661564447389*x_117 - 0.00122593695376071*x_118 - 0.000816901724481614*x_119 - 0.000313175202029545*x_12 + 0.000665062527891276*x_120 - 0.000594150759634022*x_13 + 0.00121731265366137*x_14 + 0.00285735965771045*x_15 + 0.000495613376564213*x_16 + 6.32714471067754e-6*x_17 + 0.00282284391234514*x_18 + 0.000286601228854388*x_19 - 0.00353930952796143*x_2 + 0.00029915013234791*x_20 - 0.000633553426175232*x_21 + 0.00126221816442151*x_22 - 0.000230610692562059*x_23 - 0.00199408670361669*x_24 - 0.00180464810682053*x_25 - 0.0013275691581127*x_26 - 0.000589604633745377*x_27 - 0.00143627736700915*x_28 - 0.00155990607661623*x_29 - 0.000222901272045297*x_3 + 9.84889518385491e-5*x_30 - 0.000132086273298935*x_31 - 0.000429770520240565*x_32 + 0.00185930122704486*x_33 + 0.000255705839878055*x_34 - 0.00159942623836742*x_35 + 1.13418343781832e-5*x_36 - 0.0014598818022532*x_37 + 0.000295512989631811*x_38 + 0.00414213838169337*x_39 - 0.000408360657955052*x_4 + 0.00106708180275096*x_40 - 0.000914313531642745*x_41 + 0.00299678989698876*x_42 + 0.000332665506367249*x_43 - 0.000317977426173876*x_44 - 0.000767261093880597*x_45 + 0.000115616965426345*x_46 + 0.00588110929073399*x_47 + 8.54907634398647e-5*x_48 + 0.000387574860806909*x_49 - 0.00108474399744917*x_5 + 0.00147617228468911*x_50 + 0.000498875114566349*x_51 - 0.00254532051580505*x_52 - 0.00494921792562126*x_53 - 0.00173733189310667*x_54 - 0.000940331335225845*x_55 - 0.000255735421564843*x_56 - 0.00244003042046367*x_57 - 0.00120488880886712*x_58 + 0.00029603301064121*x_59 + 0.000354033120121405*x_6 - 0.00212053354276872*x_60 + 0.00115561224479925*x_61 - 0.00027901945908151*x_62 - 0.000598056187658631*x_63 + 0.000961333949487892*x_64 + 3.31161123969082e-5*x_65 - 0.000696252447346291*x_66 + 0.000356847512131281*x_67 - 0.00100683974321862*x_68 - 0.000138888424379838*x_69 + 0.00301669005917342*x_7 - 0.00115839913941147*x_70 - 0.000843245112635157*x_71 - 0.000918271007541712*x_72 - 0.000167487785534167*x_73 + 0.000322635118772796*x_74 - 0.00118544880043848*x_75 + 0.000353169991410703*x_76 + 0.000206047510038262*x_77 + 0.000157949908853106*x_78 - 0.00136509879879293*x_79 + 0.00430859112329686*x_8 - 0.000965072750451677*x_80 + 0.00236884411159742*x_81 - 0.000495785629966591*x_82 + 0.000963296763783476*x_83 - 0.00030700136209951*x_84 + 0.000140641066265965*x_85 - 0.00131063949759424*x_86 - 0.00127217057508016*x_87 + 0.00111108454798577*x_88 + 0.00134523696264809*x_89 - 0.000856528458940644*x_9 - 0.000957871464983552*x_90 - 0.000274113026500497*x_91 - 0.00161213490881321*x_92 + 0.000234567492812656*x_93 + 0.0014072086511261*x_94 - 0.000517607735276973*x_95 + 0.000198610623957671*x_96 + 0.000471402435001369*x_97 + 0.00208730239608784*x_98 + 0.00027017057419337*x_99 + 6.75351611022964e-8*std::pow(-2.20879983901978*x_24 - 4.21663999557495, 2) - 3.50445976521463e-5*std::pow(-2.59999990463257*x_29 - 1.67199993133545, 2) + 1.49453817069534e-6*std::pow(-3.28383994102478*x_60 - 6.97959995269775, 2) - 1.19552452549477e-6*std::pow(-5.24360036849976*x_61 - 6.25415992736816, 2) - 1.60258918098803e-5*std::pow(-1.86063992977142*x_63 - 6.39928007125854, 2) + 2.43556881788447e-6*std::pow(-2.94071984291077*x_67 - 7.45536041259766, 2) - 2.87420160442054e-6*std::pow(-2.85191988945007*x_7 - 7.12160015106201, 2) + 9.0465790379537e-8*std::pow(-7.80344009399414*x_8 - 3.79063987731934, 2) + 4.52361570519814e-6*std::pow(-2.31807994842529*x_9 - 5.01559972763062, 2) - 0.000163973896083869*std::exp(0.314239859580994*x_22) + 0.000191854475194013*std::exp(0.570879817008972*x_22) + 0.00014762004979878*std::exp(0.315199851989746*x_25) - 0.00013679677811783*std::exp(0.524799883365631*x_26) - 0.0107030526836662*std::exp(0.263759851455688*x_30) + 0.00332657892897884*std::exp(0.199119850993156*x_9) - 0.000595613113748722*std::sin(0.286159932613373*x_1 + 8.28927993774414) + 0.00149607077662631*std::sin(0.304639935493469*x_1 - 4.26056003570557) - 0.0101536061691417*std::sin(0.315999925136566*x_1 - 4.27895975112915) + 0.00321883592603261*std::sin(0.320719838142395*x_1 - 4.25712013244629) - 0.178145853989676*std::sin(0.327199846506119*x_1 - 4.26064014434814) + 0.0220884026411953*std::sin(0.330479830503464*x_1 - 4.24128007888794) - 0.0738841127278771*std::sin(0.337999850511551*x_1 - 4.2513599395752) - 0.0107659337862551*std::sin(0.226879999041557*x_100 + 1.99143981933594) - 7.0509054345242e-5*std::sin(0.230639979243279*x_100 - 1.18671989440918) + 0.000393322462819222*std::sin(0.246559977531433*x_100 + 8.17727947235107) - 0.000685909678578083*std::sin(0.361279845237732*x_100 - 1.57759976387024) + 0.00190929429950628*std::sin(0.204479992389679*x_102 - 1.18623995780945) + 0.000734735331718621*std::sin(0.187440007925034*x_104 + 8.40816020965576) + 0.000948720158278043*std::sin(0.217280000448227*x_105 + 1.96951985359192) + 3.71728523510482e-5*std::sin(0.240399971604347*x_107 + 1.78271985054016) - 0.0343685465934941*std::sin(0.242399975657463*x_107 - 4.23863983154297) - 0.00481821873819238*std::sin(0.291279941797256*x_107 + 4.76240015029907) - 0.00106947713910804*std::sin(0.176640018820763*x_108 + 5.21304035186768) + 0.0243957882204444*std::sin(0.245119974017143*x_108 - 1.19279980659485) + 0.000711987472087447*std::sin(0.243519976735115*x_109 + 5.15503978729248) + 0.0257894247644738*std::sin(0.250159978866577*x_11 - 7.40879964828491) + 4.0756996036942e-5*std::sin(0.290879935026169*x_11 - 1.21463990211487) - 0.00100413342865351*std::sin(0.297759920358658*x_11 - 4.26287984848022) - 0.0028254109099975*std::sin(0.268799960613251*x_112 - 7.42655992507935) - 0.00612123783123302*std::sin(0.276559948921204*x_112 - 7.4332799911499) - 0.0508443245685929*std::sin(0.28263995051384*x_112 + 1.95687973499298) - 0.00626235362816337*std::sin(0.282719939947128*x_113 - 7.41199970245361) - 0.00209896286053078*std::sin(0.284879922866821*x_113 + 5.15928030014038) + 0.00166883181872854*std::sin(0.217600002884865*x_114 - 4.22240018844604) + 0.00114708883135851*std::sin(0.243279978632927*x_116 + 1.97951984405518) + 0.0053884511155563*std::sin(0.230959981679916*x_118 + 5.17176008224487) - 0.00243906243376523*std::sin(0.239599987864494*x_119 + 5.15503978729248) - 0.00514292974034287*std::sin(0.25231996178627*x_119 - 7.4456000328064) + 0.0576686637437973*std::sin(0.300079941749573*x_12 + 5.13064002990723) - 0.00150703284823239*std::sin(0.7290398478508*x_12 - 4.77559995651245) - 0.00164101538835676*std::sin(0.251999974250793*x_120 + 5.16232013702393) + 0.212586221781289*std::sin(0.263759940862656*x_120 + 5.16455984115601) + 0.00664416590118039*std::sin(0.270239949226379*x_120 - 7.43232011795044) + 0.0278353414526761*std::sin(0.277679949998856*x_13 + 5.16752004623413) + 0.00579978051939067*std::sin(0.305919945240021*x_13 - 7.44199991226196) - 5.10632697634574e-5*std::sin(0.679199814796448*x_13 - 8.21103954315186) + 0.0119422538240793*std::sin(0.307679921388626*x_14 + 5.12720012664795) - 0.00335077555541492*std::sin(0.332079827785492*x_15 + 8.26583957672119) + 0.000673418273235019*std::sin(0.316639930009842*x_16 + 1.99335980415344) - 0.00229950439949089*std::sin(0.336479842662811*x_17 - 1.1490398645401) + 0.000322304639569688*std::sin(0.339519828557968*x_17 + 1.9948798418045) + 0.0702800847929986*std::sin(0.343039840459824*x_17 + 2.01007986068726) + 0.000212183341452663*std::sin(0.491839855909348*x_17 + 1.9327198266983) + 0.000452454651630327*std::sin(0.651039838790894*x_17 - 7.63024044036865) - 0.00643908551975026*std::sin(0.336559861898422*x_18 - 1.15495979785919) + 0.0337693574695798*std::sin(0.382799834012985*x_18 + 1.98943984508514) - 0.00234960774320862*std::sin(0.5204798579216*x_18 - 4.33296012878418) - 0.00361102650296574*std::sin(0.291519939899445*x_19 - 1.18711996078491) - 0.00879291615303605*std::sin(0.312159925699234*x_19 - 7.41224002838135) + 4.35891952108226e-5*std::sin(0.346159845590591*x_19 + 5.02383995056152) - 0.000216831031147606*std::sin(0.353759855031967*x_2 - 7.41535997390747) + 0.031731287431502*std::sin(0.37391984462738*x_2 - 7.3951997756958) - 0.00261333453843095*std::sin(0.379999846220016*x_2 - 4.21528005599976) + 0.00370361485788562*std::sin(0.188640013337135*x_20 + 1.97775971889496) + 1.88202078679362e-5*std::sin(0.359199851751328*x_20 - 1.15183985233307) + 0.00406383743052008*std::sin(0.293759942054749*x_21 + 2.00879979133606) - 0.00342643604462432*std::sin(0.315199911594391*x_21 + 1.99711978435516) + 0.0278766978139547*std::sin(0.0824000835418701*x_22 - 4.54647970199585) + 0.0153865062446435*std::sin(0.349839836359024*x_22 + 1.99503982067108) + 0.00605052528845756*std::sin(0.192320004105568*x_23 - 4.40319967269897) + 0.000725835923543204*std::sin(0.316399931907654*x_23 - 1.16175985336304) + 0.0330517936423573*std::sin(0.334399849176407*x_23 - 1.15567982196808) + 0.00571824618843756*std::sin(0.487599849700928*x_23 + 1.95495975017548) + 0.00267103585143529*std::sin(0.164080023765564*x_24 - 1.23895978927612) + 0.0147297640776098*std::sin(0.224479988217354*x_24 - 1.19663989543915) - 0.000586446761599662*std::sin(0.402799844741821*x_24 - 1.20791983604431) + 0.00129842127488465*std::sin(0.343439847230911*x_25 - 1.15567982196808) + 0.000630103774617801*std::sin(0.406719863414764*x_25 + 5.00271987915039) - 0.000240091653892904*std::sin(0.784239888191223*x_26 - 4.60712003707886) - 0.033013763845981*std::sin(0.172560006380081*x_27 - 1.21567988395691) - 0.00127573700975507*std::sin(0.669999837875366*x_27 - 1.0791198015213) + 0.000203769660496249*std::sin(0.299039930105209*x_28 - 7.40471982955933) + 0.00150003614183173*std::sin(0.112880066037178*x_29 + 4.91199970245361) - 0.00301216538099414*std::sin(0.148480042815208*x_29 + 1.75919997692108) + 6.37122223679982e-5*std::sin(0.176480010151863*x_29 + 4.97535943984985) + 0.00501143979522672*std::sin(0.333439826965332*x_29 - 4.36719989776611) - 0.00128820923401768*std::sin(0.205520004034042*x_3 - 7.59863996505737) - 0.00773357987789967*std::sin(0.346959829330444*x_3 - 7.38855981826782) - 0.0566844276171818*std::sin(0.348559856414795*x_3 - 7.39647960662842) + 0.0234601673738323*std::sin(0.367279827594757*x_3 - 4.18991994857788) + 6.59503930936932e-5*std::sin(0.415519863367081*x_3 - 1.18831992149353) + 0.00431823967041338*std::sin(0.418559849262238*x_3 + 2.00775980949402) - 1.70758394928597e-5*std::sin(0.213119998574257*x_30 + 1.35935986042023) - 0.00383072180684825*std::sin(0.239439979195595*x_30 - 1.17183983325958) + 0.00432009701814767*std::sin(0.332799851894379*x_30 - 1.1497597694397) - 0.0876720176735933*std::sin(0.358399868011475*x_30 + 2.01263976097107) + 0.0273638437390965*std::sin(0.371919840574265*x_30 + 1.99511981010437) + 0.000997366438358191*std::sin(0.347519844770432*x_31 + 5.17407989501953) + 0.0269098060146836*std::sin(0.360239863395691*x_31 + 5.18207979202271) - 0.0910764699938347*std::sin(0.368399828672409*x_31 + 5.17768001556396) - 0.0213846451046153*std::sin(0.369359821081161*x_31 + 5.17328023910522) - 0.0193006224488395*std::sin(0.392399847507477*x_31 - 7.40079975128174) + 0.00011619051154132*std::sin(0.412079870700836*x_31 + 5.19288015365601) + 0.00858225338725981*std::sin(0.415039867162704*x_31 - 7.40055990219116) + 0.00104489981720994*std::sin(0.893119871616364*x_31 - 7.76775979995728) + 0.000569409795423551*std::sin(0.240959972143173*x_32 + 2.01855969429016) - 0.0112012224894695*std::sin(0.309279918670654*x_32 - 1.13791990280151) - 0.00178042046514743*std::sin(0.311119943857193*x_32 + 2.01319980621338) - 0.00172202704485023*std::sin(0.238159984350204*x_33 - 1.21919989585876) + 0.00061260429996424*std::sin(0.238559976220131*x_33 + 1.97919988632202) + 0.00762280973291731*std::sin(0.236399978399277*x_34 - 1.21151983737946) + 0.00501628543414177*std::sin(0.228479996323586*x_35 + 8.19143962860107) + 0.00203525362069256*std::sin(0.244719967246056*x_39 - 7.60920000076294) + 0.00420570735739026*std::sin(0.292799949645996*x_4 + 2.00839972496033) + 0.000529463999223869*std::sin(0.302479922771454*x_40 - 1.62287986278534) - 0.000681627849014046*std::sin(0.525999844074249*x_43 + 1.85743987560272) + 2.69301585195673e-5*std::sin(0.553839862346649*x_43 - 1.35583984851837) - 0.0019717443386103*std::sin(0.110400065779686*x_44 + 1.74895989894867) + 0.00856162009650684*std::sin(0.297119915485382*x_44 + 5.08871984481812) + 0.00160892340070105*std::sin(0.539039850234985*x_44 + 1.61799991130829) + 0.00122750475134154*std::sin(0.612319827079773*x_45 - 4.80423974990845) - 0.0117242980331245*std::sin(0.145360037684441*x_47 + 5.00600004196167) + 0.000679730636544335*std::sin(0.236719980835915*x_47 - 1.83063983917236) + 0.0263607246264897*std::sin(0.159360021352768*x_48 - 7.40391969680786) - 0.000524000432337336*std::sin(0.191600009799004*x_49 - 4.60928010940552) - 0.00489236351603297*std::sin(0.249119967222214*x_49 + 5.13367986679077) + 0.0752942228192*std::sin(0.3572798371315*x_5 + 2.02199983596802) + 0.0104656001159455*std::sin(0.358079850673676*x_5 + 2.00535988807678) - 0.00028488580049955*std::sin(0.5065598487854*x_5 - 1.25143992900848) - 0.00108062760846582*std::sin(0.773199856281281*x_5 - 4.792799949646) - 0.0102374197088069*std::sin(0.166880026459694*x_51 + 4.99487972259521) - 0.00878165269397819*std::sin(0.246079966425896*x_52 - 7.42615985870361) - 0.000190109870133382*std::sin(0.562079846858978*x_52 - 1.55815982818604) + 0.000575372762030488*std::sin(0.225839987397194*x_53 + 1.98495984077454) - 0.000648310886257061*std::sin(0.230319991707802*x_54 - 7.43327951431274) - 0.00773441748725816*std::sin(0.261679977178574*x_57 - 7.46247959136963) - 1.58318770257589e-5*std::sin(0.537599861621857*x_58 - 4.48936033248901) - 0.0019473186456744*std::sin(0.559359848499298*x_58 - 1.54263985157013) + 0.0116910353185182*std::sin(0.143680036067963*x_59 + 1.79303991794586) - 0.00674338124059591*std::sin(0.184000000357628*x_59 - 4.97879981994629) - 0.000481833400326561*std::sin(0.491999864578247*x_59 + 1.80147981643677) + 0.00396048479087333*std::sin(0.244319975376129*x_6 + 1.80127990245819) + 0.00142925994495884*std::sin(0.299999952316284*x_6 + 2.0194399356842) + 0.051494179744023*std::sin(0.365199834108353*x_6 + 2.01551985740662) + 0.00351183901081832*std::sin(0.391679853200912*x_6 + 2.00623965263367) - 0.000543521453391351*std::sin(0.206640005111694*x_60 + 2.00567984580994) + 0.00074514902271337*std::sin(0.417759865522385*x_60 + 8.17088031768799) - 0.00498948546491036*std::sin(0.464879840612411*x_60 - 4.32456016540527) - 0.00030851838926603*std::sin(0.633199870586395*x_60 - 4.6450400352478) - 0.000723803244190205*std::sin(0.972639799118042*x_64 + 7.79016017913818) + 1.77830703731552e-5*std::sin(1.046719789505*x_64 + 7.78560018539429) - 0.00113224281537222*std::sin(0.970799803733826*x_65 + 2.00151968002319) + 4.51728397751152e-5*std::sin(0.154000028967857*x_66 + 2.06791973114014) - 0.000455708972113101*std::sin(1.28911983966827*x_67 + 5.21824026107788) + 0.00424015025482831*std::sin(0.221599996089935*x_68 - 0.957519829273224) - 0.00068342282025094*std::sin(0.330159842967987*x_7 - 1.14079988002777) - 0.00440694004714019*std::sin(0.348879843950272*x_7 - 1.14639985561371) - 0.0261412892998181*std::sin(0.377519845962524*x_7 - 1.16439986228943) - 0.00192834244391395*std::sin(0.477439850568771*x_7 - 1.2397598028183) - 7.16912521549608e-5*std::sin(1.14047980308533*x_71 + 8.39352035522461) - 4.01644012096158e-5*std::sin(1.30631983280182*x_73 - 1.80255997180939) - 6.88940018546606e-5*std::sin(1.2772798538208*x_77 - 1.16463983058929) + 9.07217176771333e-5*std::sin(0.397839844226837*x_8 + 1.97663986682892) + 0.00223832146734125*std::sin(0.457359850406647*x_8 + 4.76743984222412) + 0.00109163872647784*std::sin(0.711519837379456*x_83 - 7.9987998008728) + 0.00027861006160789*std::sin(0.690639853477478*x_84 + 7.39631986618042) - 0.00747276281171942*std::sin(0.334639847278595*x_9 - 4.32807970046997) - 0.000820894760556051*std::sin(0.335679858922958*x_91 + 8.40248012542725) + 0.012740019862245*std::sin(0.352079838514328*x_91 - 7.38151979446411) - 0.00486848105118663*std::sin(0.359119862318039*x_91 + 2.01399970054626) + 0.0068931235996263*std::sin(0.370799839496613*x_91 - 1.18903994560242) + 0.0475804902674791*std::sin(0.283599942922592*x_92 + 2.00687980651855) - 0.00189027064511016*std::sin(0.290319919586182*x_92 - 1.16183984279633) - 0.0117256876809145*std::sin(0.312399923801422*x_92 + 1.98295974731445) + 0.00342725755032804*std::sin(0.223199993371964*x_93 + 5.19488000869751) + 0.0321909312112551*std::sin(0.230719983577728*x_93 - 7.41183996200562) - 0.00634291375838812*std::sin(0.234959989786148*x_93 - 1.20967984199524) - 0.0154186369484758*std::sin(0.277119934558868*x_94 + 1.97791981697083) - 0.0222593977058199*std::sin(0.295439928770065*x_94 + 1.95231986045837) + 0.000480504638903319*std::sin(0.265919953584671*x_95 - 7.80767965316772) - 0.00122401856770226*std::sin(0.297759920358658*x_96 + 1.9340797662735) - 0.0020964542144105*std::sin(0.317119926214218*x_97 - 1.40455985069275) - 0.00232150701041102*std::sin(0.298399955034256*x_98 - 7.63000011444092) + 0.314513634909929);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.50801540159729e-5*x_1 + 3.94507862368728e-5*x_10 + 0.000748831938497937*x_100 - 0.000958687036632613*x_101 - 0.00033320299901919*x_102 + 0.00388184262933807*x_103 + 0.000546581205599868*x_104 - 0.0021529416064484*x_105 - 0.00125551503771823*x_106 + 0.00121655683696311*x_107 - 0.00271216826126679*x_108 - 0.000926900364666675*x_109 - 0.00996589058055558*x_11 - 0.00463561229889816*x_110 - 0.000147290113741128*x_111 + 0.000825436575591475*x_112 - 5.3307155038608e-5*x_113 + 0.00106083849245054*x_114 - 0.00160189018166837*x_115 - 0.00597955418617468*x_116 + 0.00118225217603888*x_117 - 0.000690672551613523*x_118 - 0.00566975427308502*x_119 - 0.00304782762145489*x_12 + 0.000680840437502677*x_120 - 0.00206725447195289*x_13 + 0.000524362859773164*x_14 + 0.00740882573830117*x_15 + 0.00191288328825152*x_16 + 0.000785572251117786*x_17 + 0.0126038656930515*x_18 - 0.000568156200959963*x_19 + 0.000891648771648157*x_2 - 0.000295085531955759*x_20 - 0.000717894287984409*x_21 - 0.000306118589957036*x_22 + 4.29201235806888e-5*x_23 + 0.000117236816920601*x_24 - 0.00204717789450463*x_25 - 0.00288360120885986*x_26 - 0.00296445959029176*x_27 + 0.000158729677944658*x_28 + 6.78422397812894e-5*x_29 - 0.00044766724821363*x_3 + 2.99941642333366e-5*x_30 - 0.000875494651594344*x_31 + 0.00027374197882786*x_32 - 0.00318624542720242*x_33 + 0.000229505264232967*x_34 - 0.00350685002897983*x_35 + 0.0024757590799216*x_36 - 0.00202612151430215*x_37 - 0.000902048351564059*x_38 + 0.00313959970432686*x_39 + 0.000416417210874646*x_4 + 0.000788856952490299*x_40 - 0.000298129052433431*x_41 + 0.00223461159104076*x_42 + 0.000221433258132022*x_43 - 0.00156249487392271*x_44 - 0.00155751762733437*x_45 - 0.0014799899484595*x_46 + 0.00725680875101731*x_47 + 0.000162666010180013*x_48 + 0.00247800695382788*x_49 - 4.00260543265073e-5*x_5 - 0.000144906824966853*x_50 + 0.000562109823253057*x_51 - 0.000258406907307117*x_52 - 0.000460575346264613*x_53 - 0.00112575964400972*x_54 + 0.000489313131382076*x_55 + 0.00140821532516833*x_56 + 0.00287431187812703*x_57 - 0.00118313794333225*x_58 + 0.00250893973872736*x_59 + 1.68304626289587e-5*x_6 + 7.61578215348088e-5*x_60 + 0.00281176185165651*x_61 + 0.000819148244219175*x_62 + 2.62609901612844e-5*x_63 - 0.00015118412350604*x_64 - 0.000920111880767678*x_65 + 0.000468044400117926*x_66 - 0.000275110345201714*x_67 - 0.000850736027082006*x_68 - 0.000560160617018098*x_69 - 0.00245125992894543*x_7 - 0.000338010958437244*x_70 + 0.000473612591139856*x_71 - 0.000743736236233139*x_72 - 0.000613386143617701*x_73 + 0.00044953059080871*x_74 - 0.000947495775421778*x_75 + 0.000129491113058942*x_76 - 0.000242800306614844*x_77 + 0.00013893723081265*x_78 - 0.000886739805203412*x_79 + 0.000493830575404308*x_8 - 0.000991469268063006*x_80 + 0.000669894625291937*x_81 - 0.000819623631640312*x_82 + 0.00187460283272667*x_83 - 0.00115781116337028*x_84 + 0.000283752805792262*x_85 + 0.000320314849753525*x_86 - 0.00224067550219153*x_87 - 0.00179182905804429*x_88 - 0.000980150514869796*x_89 - 0.0015510504776181*x_9 - 0.000744009872450061*x_90 + 0.000447636324916521*x_91 + 0.000431306036303484*x_92 + 0.00412470188101972*x_93 + 0.000430306408466932*x_94 + 0.0016494022060533*x_95 - 0.000808155020052803*x_96 - 0.000117629192327216*x_97 + 0.00217888963205349*x_98 + 0.00459537301189141*x_99 - 4.52211149568626e-7*std::pow(-2.20879983901978*x_24 - 4.21663999557495, 2) - 0.000157072520057556*std::pow(-2.59999990463257*x_29 - 1.67199993133545, 2) + 3.37790670182097e-6*std::pow(-3.28383994102478*x_60 - 6.97959995269775, 2) + 2.03763816790476e-7*std::pow(-5.24360036849976*x_61 - 6.25415992736816, 2) + 1.11210239554134e-6*std::pow(-1.86063992977142*x_63 - 6.39928007125854, 2) + 5.50479365063684e-6*std::pow(-2.94071984291077*x_67 - 7.45536041259766, 2) - 6.49617724881503e-6*std::pow(-2.85191988945007*x_7 - 7.12160015106201, 2) - 5.63878393013586e-8*std::pow(-7.80344009399414*x_8 - 3.79063987731934, 2) - 7.70999826543122e-7*std::pow(-2.31807994842529*x_9 - 5.01559972763062, 2) - 8.2935928516797e-5*std::exp(0.314239859580994*x_22) - 2.95581063892605e-5*std::exp(0.570879817008972*x_22) + 7.46643593288509e-5*std::exp(0.315199851989746*x_25) - 1.60457979260024e-5*std::exp(0.524799883365631*x_26) - 7.55451520170898e-6*std::exp(0.263759851455688*x_30) - 0.000512510191881607*std::exp(0.199119850993156*x_9) + 0.00398818758214675*std::sin(0.286159932613373*x_1 + 8.28927993774414) - 0.000932509384839742*std::sin(0.304639935493469*x_1 - 4.26056003570557) + 0.00173056888678667*std::sin(0.315999925136566*x_1 - 4.27895975112915) + 0.00727510856517565*std::sin(0.320719838142395*x_1 - 4.25712013244629) - 0.798463104119845*std::sin(0.327199846506119*x_1 - 4.26064014434814) + 0.0111720354657147*std::sin(0.330479830503464*x_1 - 4.24128007888794) + 0.00512712176844107*std::sin(0.337999850511551*x_1 - 4.2513599395752) - 7.59889845006329e-6*std::sin(0.226879999041557*x_100 + 1.99143981933594) + 0.000472124149850802*std::sin(0.230639979243279*x_100 - 1.18671989440918) - 0.000245160117808262*std::sin(0.246559977531433*x_100 + 8.17727947235107) + 0.000105674841477282*std::sin(0.361279845237732*x_100 - 1.57759976387024) + 0.0009656969756966*std::sin(0.204479992389679*x_102 - 1.18623995780945) - 0.000125227439779911*std::sin(0.187440007925034*x_104 + 8.40816020965576) - 0.000591342645684135*std::sin(0.217280000448227*x_105 + 1.96951985359192) - 0.000248907058486912*std::sin(0.240399971604347*x_107 + 1.78271985054016) - 2.4258285498064e-5*std::sin(0.242399975657463*x_107 - 4.23863983154297) + 0.00033435596998617*std::sin(0.291279941797256*x_107 + 4.76240015029907) - 0.000540928048169606*std::sin(0.176640018820763*x_108 + 5.21304035186768) - 0.00169292385365718*std::sin(0.245119974017143*x_108 - 1.19279980659485) - 0.000121350320905797*std::sin(0.243519976735115*x_109 + 5.15503978729248) - 0.00178963401228769*std::sin(0.250159978866577*x_11 - 7.40879964828491) - 0.000272906256977935*std::sin(0.290879935026169*x_11 - 1.21463990211487) - 0.00226950980890174*std::sin(0.297759920358658*x_11 - 4.26287984848022) + 0.00176109461581935*std::sin(0.268799960613251*x_112 - 7.42655992507935) - 0.0138350232192076*std::sin(0.276559948921204*x_112 - 7.4332799911499) - 3.58873523495066e-5*std::sin(0.28263995051384*x_112 + 1.95687973499298) - 0.0141539685666938*std::sin(0.282719939947128*x_113 - 7.41199970245361) + 0.00130829543391577*std::sin(0.284879922866821*x_113 + 5.15928030014038) - 0.00104019232044143*std::sin(0.217600002884865*x_114 - 4.22240018844604) - 0.000714986962648124*std::sin(0.243279978632927*x_116 + 1.97951984405518) + 0.00272541061235415*std::sin(0.230959981679916*x_118 + 5.17176008224487) + 0.00152028142333286*std::sin(0.239599987864494*x_119 + 5.15503978729248) + 0.000792346721460736*std::sin(0.25231996178627*x_119 - 7.4456000328064) - 0.00400186522272699*std::sin(0.300079941749573*x_12 + 5.13064002990723) - 1.06370611244592e-6*std::sin(0.7290398478508*x_12 - 4.77559995651245) - 0.00370896975855936*std::sin(0.251999974250793*x_120 + 5.16232013702393) + 0.000150049326261049*std::sin(0.263759940862656*x_120 + 5.16455984115601) + 0.00336053531320737*std::sin(0.270239949226379*x_120 - 7.43232011795044) - 0.00193160856677863*std::sin(0.277679949998856*x_13 + 5.16752004623413) + 0.0029334558369173*std::sin(0.305919945240021*x_13 - 7.44199991226196) - 0.00011541154621071*std::sin(0.679199814796448*x_13 - 8.21103954315186) + 0.00604024136242209*std::sin(0.307679921388626*x_14 + 5.12720012664795) - 0.00169478001423826*std::sin(0.332079827785492*x_15 + 8.26583957672119) - 0.00450916598864488*std::sin(0.316639930009842*x_16 + 1.99335980415344) - 0.0051972652650907*std::sin(0.336479842662811*x_17 - 1.1490398645401) - 0.00215813139692288*std::sin(0.339519828557968*x_17 + 1.9948798418045) - 0.00487702348077479*std::sin(0.343039840459824*x_17 + 2.01007986068726) + 0.000107319657942216*std::sin(0.491839855909348*x_17 + 1.9327198266983) - 6.97075359627698e-5*std::sin(0.651039838790894*x_17 - 7.63024044036865) - 0.0145534122562043*std::sin(0.336559861898422*x_18 - 1.15495979785919) - 0.00234339428865096*std::sin(0.382799834012985*x_18 + 1.98943984508514) - 0.00118840196206348*std::sin(0.5204798579216*x_18 - 4.33296012878418) + 0.00225077326255513*std::sin(0.291519939899445*x_19 - 1.18711996078491) - 0.0198734639129835*std::sin(0.312159925699234*x_19 - 7.41224002838135) - 0.000291870482772671*std::sin(0.346159845590591*x_19 + 5.02383995056152) + 0.00145188681357977*std::sin(0.353759855031967*x_2 - 7.41535997390747) + 0.142222014674248*std::sin(0.37391984462738*x_2 - 7.3951997756958) + 0.00162890621278502*std::sin(0.379999846220016*x_2 - 4.21528005599976) + 0.00837079018436509*std::sin(0.188640013337135*x_20 + 1.97775971889496) - 0.000126018916608323*std::sin(0.359199851751328*x_20 - 1.15183985233307) + 0.00918495356012084*std::sin(0.293759942054749*x_21 + 2.00879979133606) + 0.00213571698484118*std::sin(0.315199911594391*x_21 + 1.99711978435516) + 0.063006008288557*std::sin(0.0824000835418701*x_22 - 4.54647970199585) - 0.00106773280742669*std::sin(0.349839836359024*x_22 + 1.99503982067108) + 0.0136752010234098*std::sin(0.192320004105568*x_23 - 4.40319967269897) - 0.00486015124605244*std::sin(0.316399931907654*x_23 - 1.16175985336304) + 0.14814062273902*std::sin(0.334399849176407*x_23 - 1.15567982196808) - 0.000396812568055398*std::sin(0.487599849700928*x_23 + 1.95495975017548) + 0.00135097624518926*std::sin(0.164080023765564*x_24 - 1.23895978927612) + 0.0660199094447795*std::sin(0.224479988217354*x_24 - 1.19663989543915) - 0.0013254679506426*std::sin(0.402799844741821*x_24 - 1.20791983604431) - 0.000809313331442708*std::sin(0.343439847230911*x_25 - 1.15567982196808) + 0.00142414011556084*std::sin(0.406719863414764*x_25 + 5.00271987915039) - 0.000542647369360126*std::sin(0.784239888191223*x_26 - 4.60712003707886) + 0.0022909605465024*std::sin(0.172560006380081*x_27 - 1.21567988395691) + 0.000196546732730236*std::sin(0.669999837875366*x_27 - 1.0791198015213) - 0.00136442870522869*std::sin(0.299039930105209*x_28 - 7.40471982955933) + 0.00339033303787057*std::sin(0.112880066037178*x_29 + 4.91199970245361) - 0.00152351525874049*std::sin(0.148480042815208*x_29 + 1.75919997692108) - 0.000426612994599412*std::sin(0.176480010151863*x_29 + 4.97535943984985) - 0.000347764372023705*std::sin(0.333439826965332*x_29 - 4.36719989776611) - 0.00291156873090196*std::sin(0.205520004034042*x_3 - 7.59863996505737) - 0.00391154716238717*std::sin(0.346959829330444*x_3 - 7.38855981826782) + 0.00393356503905093*std::sin(0.348559856414795*x_3 - 7.39647960662842) - 0.00361439639312219*std::sin(0.367279827594757*x_3 - 4.18991994857788) - 0.000441599643631971*std::sin(0.415519863367081*x_3 - 1.18831992149353) - 0.00269158323360097*std::sin(0.418559849262238*x_3 + 2.00775980949402) + 0.000114338736754014*std::sin(0.213119998574257*x_30 + 1.35935986042023) - 0.0086580731880164*std::sin(0.239439979195595*x_30 - 1.17183983325958) - 0.00269274092895883*std::sin(0.332799851894379*x_30 - 1.1497597694397) - 0.392952571212598*std::sin(0.358399868011475*x_30 + 2.01263976097107) - 0.00189888940562463*std::sin(0.371919840574265*x_30 + 1.99511981010437) + 0.00225421527690657*std::sin(0.347519844770432*x_31 + 5.17407989501953) - 0.00186738186476662*std::sin(0.360239863395691*x_31 + 5.18207979202271) - 6.42843305944316e-5*std::sin(0.368399828672409*x_31 + 5.17768001556396) + 0.00364477416757541*std::sin(0.369359821081161*x_31 + 5.17328023910522) + 0.00297355509244618*std::sin(0.392399847507477*x_31 - 7.40079975128174) - 0.000778004285996745*std::sin(0.412079870700836*x_31 + 5.19288015365601) + 0.00434079551951831*std::sin(0.415039867162704*x_31 - 7.40055990219116) + 0.000122563203246101*std::sin(0.893119871616364*x_31 - 7.76775979995728) - 9.70495466710479e-5*std::sin(0.240959972143173*x_32 + 2.01855969429016) - 0.00566543705964165*std::sin(0.309279918670654*x_32 - 1.13791990280151) - 0.00402404859186876*std::sin(0.311119943857193*x_32 + 2.01319980621338) + 0.00107334920603946*std::sin(0.238159984350204*x_33 - 1.21919989585876) + 0.00138458837050029*std::sin(0.238559976220131*x_33 + 1.97919988632202) - 0.000528978047855455*std::sin(0.236399978399277*x_34 - 1.21151983737946) - 0.000772835235619706*std::sin(0.228479996323586*x_35 + 8.19143962860107) + 0.000238728344154919*std::sin(0.244719967246056*x_39 - 7.60920000076294) + 0.00212719373684139*std::sin(0.292799949645996*x_4 + 2.00839972496033) - 9.02412313878352e-5*std::sin(0.302479922771454*x_40 - 1.62287986278534) - 0.00305510723931767*std::sin(0.525999844074249*x_43 + 1.85743987560272) - 0.000180322631106966*std::sin(0.553839862346649*x_43 - 1.35583984851837) - 0.000997283417823662*std::sin(0.110400065779686*x_44 + 1.74895989894867) - 0.00131904808277767*std::sin(0.297119915485382*x_44 + 5.08871984481812) + 1.13562332618716e-6*std::sin(0.539039850234985*x_44 + 1.61799991130829) + 8.66407330530232e-7*std::sin(0.612319827079773*x_45 - 4.80423974990845) + 0.000813597151619349*std::sin(0.145360037684441*x_47 + 5.00600004196167) - 0.000115852503180036*std::sin(0.236719980835915*x_47 - 1.83063983917236) + 0.118150748618237*std::sin(0.159360021352768*x_48 - 7.40391969680786) - 0.00118432878253344*std::sin(0.191600009799004*x_49 - 4.60928010940552) + 0.000339501180376431*std::sin(0.249119967222214*x_49 + 5.13367986679077) + 0.337474364561938*std::sin(0.3572798371315*x_5 + 2.02199983596802) + 0.00529336854115785*std::sin(0.358079850673676*x_5 + 2.00535988807678) - 0.000643889646735042*std::sin(0.5065598487854*x_5 - 1.25143992900848) - 7.62737317737387e-7*std::sin(0.773199856281281*x_5 - 4.792799949646) + 0.000710416563233455*std::sin(0.166880026459694*x_51 + 4.99487972259521) - 0.00444164917393069*std::sin(0.246079966425896*x_52 - 7.42615985870361) + 0.00011849655833116*std::sin(0.562079846858978*x_52 - 1.55815982818604) - 0.000358633099955679*std::sin(0.225839987397194*x_53 + 1.98495984077454) + 0.00040409584571378*std::sin(0.230319991707802*x_54 - 7.43327951431274) + 0.000536722967915812*std::sin(0.261679977178574*x_57 - 7.46247959136963) + 0.000106009243078627*std::sin(0.537599861621857*x_58 - 4.48936033248901) + 0.000300014120830009*std::sin(0.559359848499298*x_58 - 1.54263985157013) - 0.00180118220018538*std::sin(0.143680036067963*x_59 + 1.79303991794586) - 4.75966788155163e-6*std::sin(0.184000000357628*x_59 - 4.97879981994629) - 0.00108902422436426*std::sin(0.491999864578247*x_59 + 1.80147981643677) - 0.000274834291637976*std::sin(0.244319975376129*x_6 + 1.80127990245819) + 0.0032303669731463*std::sin(0.299999952316284*x_6 + 2.0194399356842) + 0.230800783075763*std::sin(0.365199834108353*x_6 + 2.01551985740662) + 0.00177624387856684*std::sin(0.391679853200912*x_6 + 2.00623965263367) + 9.26371676103378e-5*std::sin(0.206640005111694*x_60 + 2.00567984580994) - 0.000464455604400822*std::sin(0.417759865522385*x_60 + 8.17088031768799) - 0.0223632487821134*std::sin(0.464879840612411*x_60 - 4.32456016540527) - 0.000156044710099451*std::sin(0.633199870586395*x_60 - 4.6450400352478) - 0.00324414052971234*std::sin(0.972639799118042*x_64 + 7.79016017913818) - 1.10842884396337e-5*std::sin(1.046719789505*x_64 + 7.78560018539429) - 7.99168780492753e-7*std::sin(0.970799803733826*x_65 + 2.00151968002319) - 0.000302474466197573*std::sin(0.154000028967857*x_66 + 2.06791973114014) + 7.02089136395601e-5*std::sin(1.28911983966827*x_67 + 5.21824026107788) - 0.000653259780424326*std::sin(0.221599996089935*x_68 - 0.957519829273224) + 0.00457615580007259*std::sin(0.330159842967987*x_7 - 1.14079988002777) - 0.00222897469326756*std::sin(0.348879843950272*x_7 - 1.14639985561371) + 0.00402746409483063*std::sin(0.377519845962524*x_7 - 1.16439986228943) + 0.00013381559520941*std::sin(0.477439850568771*x_7 - 1.2397598028183) - 3.62605311333358e-5*std::sin(1.14047980308533*x_71 + 8.39352035522461) - 9.07782769826919e-5*std::sin(1.30631983280182*x_73 - 1.80255997180939) + 1.17422139592378e-5*std::sin(1.2772798538208*x_77 - 1.16463983058929) - 0.000607466859810628*std::sin(0.397839844226837*x_8 + 1.97663986682892) - 0.000155326311655689*std::sin(0.457359850406647*x_8 + 4.76743984222412) - 7.57532908111384e-5*std::sin(0.711519837379456*x_83 - 7.9987998008728) + 3.26800149113204e-5*std::sin(0.690639853477478*x_84 + 7.39631986618042) + 0.000518565676270312*std::sin(0.334639847278595*x_9 - 4.32807970046997) - 0.00185535971415296*std::sin(0.335679858922958*x_91 + 8.40248012542725) + 8.99226384882532e-6*std::sin(0.352079838514328*x_91 - 7.38151979446411) - 0.00246241631192367*std::sin(0.359119862318039*x_91 + 2.01399970054626) - 0.00047834213277172*std::sin(0.370799839496613*x_91 - 1.18903994560242) + 0.213259332752796*std::sin(0.283599942922592*x_92 + 2.00687980651855) - 0.00427232840590638*std::sin(0.290319919586182*x_92 - 1.16183984279633) + 0.00199851264060635*std::sin(0.312399923801422*x_92 + 1.98295974731445) + 0.00173346364263538*std::sin(0.223199993371964*x_93 + 5.19488000869751) - 0.0022338608134539*std::sin(0.230719983577728*x_93 - 7.41183996200562) - 4.47700668464416e-6*std::sin(0.234959989786148*x_93 - 1.20967984199524) + 0.00106996248881517*std::sin(0.277119934558868*x_94 + 1.97791981697083) + 0.0034293995221333*std::sin(0.295439928770065*x_94 + 1.95231986045837) - 8.1896654665407e-5*std::sin(0.265919953584671*x_95 - 7.80767965316772) - 0.00276648706875859*std::sin(0.297759920358658*x_96 + 1.9340797662735) - 0.0093964653243086*std::sin(0.317119926214218*x_97 - 1.40455985069275) + 0.000161098897844325*std::sin(0.298399955034256*x_98 - 7.63000011444092) + 0.690978218153456);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-7.107112975818e-6*x_1 - 0.000688407744276406*x_10 + 0.000494305885288333*x_100 + 0.000113438285448484*x_101 - 0.00306403400658896*x_102 - 0.00352567896129765*x_103 + 0.000162591040867095*x_104 - 0.00511953503639107*x_105 + 0.00321360390199164*x_106 + 0.000691539865495589*x_107 - 0.00280650662391299*x_108 - 0.0045889266712521*x_109 + 0.00160849822022927*x_11 - 0.00169689600630961*x_110 - 0.00274016731794171*x_111 + 0.00193669793279255*x_112 - 0.00752167628798581*x_113 + 0.000685702041998003*x_114 - 0.00275818772957558*x_115 - 0.00239781016878663*x_116 + 0.00275293208913922*x_117 - 2.29552614806005e-5*x_118 + 0.000411463568810524*x_119 - 0.00765550196540249*x_12 - 0.00113310633108687*x_120 - 0.00439820790823334*x_13 - 0.00173321615104466*x_14 - 0.00398917914317797*x_15 + 0.0005388230119378*x_16 - 0.000103282089411387*x_17 - 0.0042342307885329*x_18 + 0.000359864603747617*x_19 - 0.0020037268740778*x_2 - 8.33844917379437e-5*x_20 + 0.000251060694505906*x_21 - 0.000637335513996431*x_22 - 0.000562697323887782*x_23 + 0.000832807336676235*x_24 + 0.00233876622563288*x_25 + 0.00320696452934706*x_26 - 0.00528811945718981*x_27 + 0.000466827313441025*x_28 - 0.000170132682514231*x_29 - 0.000217653840591178*x_3 + 0.000174855816002219*x_30 + 0.000739980899388272*x_31 - 0.00553251298570833*x_32 - 0.00147312159196044*x_33 + 0.00163207390340422*x_34 + 0.00195592450806452*x_35 - 0.00239470966503007*x_36 - 0.00312501356365335*x_37 - 0.00343391299803419*x_38 - 0.00555502246362189*x_39 - 0.00220830071294154*x_4 + 0.00373804121958911*x_40 - 7.84471771658083e-6*x_41 - 0.00211699502140071*x_42 - 0.000398173122081634*x_43 - 0.00074642543165181*x_44 - 0.00495327975972053*x_45 + 0.000201108200795305*x_46 + 0.000981044525350199*x_47 - 0.00702868155671472*x_48 - 0.00106305906347472*x_49 - 0.000953039328220266*x_5 - 0.000468530819529861*x_50 + 0.00611267856105389*x_51 - 0.00156851432634984*x_52 - 0.00495173644781537*x_53 - 0.00111830677312833*x_54 - 0.00859290796928365*x_55 + 0.000755205692740499*x_56 + 0.000449919630476619*x_57 - 0.00142195187067928*x_58 - 0.0049567370643876*x_59 + 0.00479308347199311*x_6 - 0.00115874458477638*x_60 - 0.000581244280104858*x_61 + 0.000467336661346771*x_62 + 0.00315737989742678*x_63 + 0.000260845630689397*x_64 + 0.00401643793368769*x_65 - 0.000539335109485637*x_66 - 0.00136047381426193*x_67 + 0.000890772400971712*x_68 - 0.000128246280440419*x_69 + 0.000104841014023116*x_7 + 0.0021224309057595*x_70 + 0.00343627353863924*x_71 + 0.000880148378899622*x_72 - 4.35012673300421e-5*x_73 - 0.00548790730637472*x_74 - 5.03667552104174e-5*x_75 - 0.000569478853047162*x_76 - 0.00305332750625109*x_77 + 0.000851648164429837*x_78 - 0.00156672723048169*x_79 - 0.000202281144002459*x_8 + 0.00234233329896472*x_80 + 0.00134866144329891*x_81 + 0.00154693872487344*x_82 - 0.0012087752582574*x_83 + 0.000611326232858627*x_84 + 0.00410312885016214*x_85 + 0.000819896263570541*x_86 + 0.00064371775694955*x_87 - 0.00150998841642023*x_88 - 0.000921949984824598*x_89 - 0.00216314575255265*x_9 - 8.0176403883652e-5*x_90 - 0.00227096809521595*x_91 + 0.00244924453540793*x_92 - 0.00638532620738569*x_93 - 0.000942121189376388*x_94 + 0.00270987040926328*x_95 - 0.00664096335980666*x_96 - 0.00761144232149301*x_97 - 0.00454518020651593*x_98 - 0.0107050270366132*x_99 - 4.22495305671185e-5*std::pow(-2.20879983901978*x_24 - 4.21663999557495, 2) + 1.8609776449627e-6*std::pow(-2.59999990463257*x_29 - 1.67199993133545, 2) - 1.56642043356908e-6*std::pow(-3.28383994102478*x_60 - 6.97959995269775, 2) + 4.96305256905285e-8*std::pow(-5.24360036849976*x_61 - 6.25415992736816, 2) + 9.54721225276229e-6*std::pow(-1.86063992977142*x_63 - 6.39928007125854, 2) - 2.55271149208783e-6*std::pow(-2.94071984291077*x_67 - 7.45536041259766, 2) + 3.01244104141327e-6*std::pow(-2.85191988945007*x_7 - 7.12160015106201, 2) + 1.18941357268932e-6*std::pow(-7.80344009399414*x_8 - 3.79063987731934, 2) - 1.87791568205597e-7*std::pow(-2.31807994842529*x_9 - 5.01559972763062, 2) - 0.000249523733096008*std::exp(0.314239859580994*x_22) + 9.59803599761231e-5*std::exp(0.570879817008972*x_22) + 0.00022463762089772*std::exp(0.315199851989746*x_25) - 0.00012040821016053*std::exp(0.524799883365631*x_26) + 9.90881939168548e-5*std::exp(0.263759851455688*x_30) + 0.0016642105573482*std::exp(0.199119850993156*x_9) + 0.37261145223873*std::sin(0.286159932613373*x_1 + 8.28927993774414) + 0.0196698318774175*std::sin(0.304639935493469*x_1 - 4.26056003570557) + 0.000421512734438087*std::sin(0.315999925136566*x_1 - 4.27895975112915) - 0.00337365111558033*std::sin(0.320719838142395*x_1 - 4.25712013244629) + 0.00946010152858102*std::sin(0.327199846506119*x_1 - 4.26064014434814) + 0.0336125494166446*std::sin(0.330479830503464*x_1 - 4.24128007888794) + 0.0440154791189325*std::sin(0.337999850511551*x_1 - 4.2513599395752) + 9.9670343241089e-5*std::sin(0.226879999041557*x_100 + 1.99143981933594) + 0.044109977650096*std::sin(0.230639979243279*x_100 - 1.18671989440918) + 0.00517127052953481*std::sin(0.246559977531433*x_100 + 8.17727947235107) - 0.000343144760081603*std::sin(0.361279845237732*x_100 - 1.57759976387024) + 0.00290542734282571*std::sin(0.204479992389679*x_102 - 1.18623995780945) - 3.05015078979737e-5*std::sin(0.187440007925034*x_104 + 8.40816020965576) + 0.012473451325697*std::sin(0.217280000448227*x_105 + 1.96951985359192) - 0.0232550798138126*std::sin(0.240399971604347*x_107 + 1.78271985054016) + 0.000318181859900001*std::sin(0.242399975657463*x_107 - 4.23863983154297) + 0.0028703898366142*std::sin(0.291279941797256*x_107 + 4.76240015029907) - 0.00162745372638206*std::sin(0.176640018820763*x_108 + 5.21304035186768) - 0.0145334669032538*std::sin(0.245119974017143*x_108 - 1.19279980659485) - 2.95571623761934e-5*std::sin(0.243519976735115*x_109 + 5.15503978729248) - 0.0153637073695504*std::sin(0.250159978866577*x_11 - 7.40879964828491) - 0.0254972953611295*std::sin(0.290879935026169*x_11 - 1.21463990211487) + 0.00105242887168338*std::sin(0.297759920358658*x_11 - 4.26287984848022) - 0.037147545726143*std::sin(0.268799960613251*x_112 - 7.42655992507935) + 0.0064156487974599*std::sin(0.276559948921204*x_112 - 7.4332799911499) + 0.000470713584369513*std::sin(0.28263995051384*x_112 + 1.95687973499298) + 0.00656355178993297*std::sin(0.282719939947128*x_113 - 7.41199970245361) - 0.0275964528073236*std::sin(0.284879922866821*x_113 + 5.15928030014038) + 0.0219412355477581*std::sin(0.217600002884865*x_114 - 4.22240018844604) + 0.0150815354552715*std::sin(0.243279978632927*x_116 + 1.97951984405518) + 0.00819975904744774*std::sin(0.230959981679916*x_118 + 5.17176008224487) - 0.0320679668102831*std::sin(0.239599987864494*x_119 + 5.15503978729248) - 0.00257288889045118*std::sin(0.25231996178627*x_119 - 7.4456000328064) - 0.0343553406965951*std::sin(0.300079941749573*x_12 + 5.13064002990723) + 1.3952016075994e-5*std::sin(0.7290398478508*x_12 - 4.77559995651245) + 0.00171994271309068*std::sin(0.251999974250793*x_120 + 5.16232013702393) - 0.00196810997670437*std::sin(0.263759940862656*x_120 + 5.16455984115601) + 0.0101106158880543*std::sin(0.270239949226379*x_120 - 7.43232011795044) - 0.0165825350707142*std::sin(0.277679949998856*x_13 + 5.16752004623413) + 0.00882569067942172*std::sin(0.305919945240021*x_13 - 7.44199991226196) + 5.35192414156379e-5*std::sin(0.679199814796448*x_13 - 8.21103954315186) + 0.0181728666997106*std::sin(0.307679921388626*x_14 + 5.12720012664795) - 0.00509897029540809*std::sin(0.332079827785492*x_15 + 8.26583957672119) - 0.421285822897544*std::sin(0.316639930009842*x_16 + 1.99335980415344) + 0.00241010283248148*std::sin(0.336479842662811*x_17 - 1.1490398645401) - 0.201631557534859*std::sin(0.339519828557968*x_17 + 1.9948798418045) - 0.0418684273312775*std::sin(0.343039840459824*x_17 + 2.01007986068726) + 0.000322885414840503*std::sin(0.491839855909348*x_17 + 1.9327198266983) + 0.000226352605496613*std::sin(0.651039838790894*x_17 - 7.63024044036865) + 0.00674878389151003*std::sin(0.336559861898422*x_18 - 1.15495979785919) - 0.020117646320482*std::sin(0.382799834012985*x_18 + 1.98943984508514) - 0.00357546481116014*std::sin(0.5204798579216*x_18 - 4.33296012878418) - 0.0474765534678823*std::sin(0.291519939899445*x_19 - 1.18711996078491) + 0.00921582586704169*std::sin(0.312159925699234*x_19 - 7.41224002838135) - 0.0272690996126627*std::sin(0.346159845590591*x_19 + 5.02383995056152) + 0.135647996226652*std::sin(0.353759855031967*x_2 - 7.41535997390747) - 0.00168503051859962*std::sin(0.37391984462738*x_2 - 7.3951997756958) - 0.0343592374194373*std::sin(0.379999846220016*x_2 - 4.21528005599976) - 0.00388174628471545*std::sin(0.188640013337135*x_20 + 1.97775971889496) - 0.0117737921198038*std::sin(0.359199851751328*x_20 - 1.15183985233307) - 0.00425929435238704*std::sin(0.293759942054749*x_21 + 2.00879979133606) - 0.0450496206392503*std::sin(0.315199911594391*x_21 + 1.99711978435516) - 0.0292174732853381*std::sin(0.0824000835418701*x_22 - 4.54647970199585) - 0.0091663067920812*std::sin(0.349839836359024*x_22 + 1.99503982067108) - 0.0063415352190415*std::sin(0.192320004105568*x_23 - 4.40319967269897) - 0.45407794307325*std::sin(0.316399931907654*x_23 - 1.16175985336304) - 0.00175515352479957*std::sin(0.334399849176407*x_23 - 1.15567982196808) - 0.00340656923946687*std::sin(0.487599849700928*x_23 + 1.95495975017548) + 0.004064591089197*std::sin(0.164080023765564*x_24 - 1.23895978927612) - 0.000782196501044082*std::sin(0.224479988217354*x_24 - 1.19663989543915) + 0.000614652879787428*std::sin(0.402799844741821*x_24 - 1.20791983604431) + 0.0170712031690346*std::sin(0.343439847230911*x_25 - 1.15567982196808) - 0.000660409648400696*std::sin(0.406719863414764*x_25 + 5.00271987915039) + 0.000251639255498082*std::sin(0.784239888191223*x_26 - 4.60712003707886) + 0.019667511452051*std::sin(0.172560006380081*x_27 - 1.21567988395691) - 0.000638221742324912*std::sin(0.669999837875366*x_27 - 1.0791198015213) - 0.127476892914303*std::sin(0.299039930105209*x_28 - 7.40471982955933) - 0.00157218283863847*std::sin(0.112880066037178*x_29 + 4.91199970245361) - 0.00458369757942319*std::sin(0.148480042815208*x_29 + 1.75919997692108) - 0.0398579264860044*std::sin(0.176480010151863*x_29 + 4.97535943984985) - 0.00298549871573895*std::sin(0.333439826965332*x_29 - 4.36719989776611) + 0.00135016776850794*std::sin(0.205520004034042*x_3 - 7.59863996505737) - 0.0117684080662613*std::sin(0.346959829330444*x_3 - 7.38855981826782) + 0.0337689950929238*std::sin(0.348559856414795*x_3 - 7.39647960662842) + 0.0117365795474068*std::sin(0.367279827594757*x_3 - 4.18991994857788) - 0.0412581106411358*std::sin(0.415519863367081*x_3 - 1.18831992149353) + 0.0567747526724414*std::sin(0.418559849262238*x_3 + 2.00775980949402) + 0.0106825273063316*std::sin(0.213119998574257*x_30 + 1.35935986042023) + 0.00401496665071725*std::sin(0.239439979195595*x_30 - 1.17183983325958) + 0.0567991724513998*std::sin(0.332799851894379*x_30 - 1.1497597694397) + 0.00465565810168002*std::sin(0.358399868011475*x_30 + 2.01263976097107) - 0.0163016465684305*std::sin(0.371919840574265*x_30 + 1.99511981010437) - 0.00104533641189868*std::sin(0.347519844770432*x_31 + 5.17407989501953) - 0.016031159622858*std::sin(0.360239863395691*x_31 + 5.18207979202271) + 0.000843180276388255*std::sin(0.368399828672409*x_31 + 5.17768001556396) + 0.000887753580637093*std::sin(0.369359821081161*x_31 + 5.17328023910522) - 0.00965565535299365*std::sin(0.392399847507477*x_31 - 7.40079975128174) - 0.0726879819171296*std::sin(0.412079870700836*x_31 + 5.19288015365601) + 0.0130598586403632*std::sin(0.415039867162704*x_31 - 7.40055990219116) + 0.000919718421138126*std::sin(0.893119871616364*x_31 - 7.76775979995728) - 2.36382498874389e-5*std::sin(0.240959972143173*x_32 + 2.01855969429016) - 0.017045218279023*std::sin(0.309279918670654*x_32 - 1.13791990280151) + 0.00186605270553508*std::sin(0.311119943857193*x_32 + 2.01319980621338) - 0.02264062836449*std::sin(0.238159984350204*x_33 - 1.21919989585876) - 0.000642068507831962*std::sin(0.238559976220131*x_33 + 1.97919988632202) - 0.00454118768215541*std::sin(0.236399978399277*x_34 - 1.21151983737946) + 0.00250953167094501*std::sin(0.228479996323586*x_35 + 8.19143962860107) + 0.00179142556617266*std::sin(0.244719967246056*x_39 - 7.60920000076294) + 0.00639994429106332*std::sin(0.292799949645996*x_4 + 2.00839972496033) - 2.19799561241248e-5*std::sin(0.302479922771454*x_40 - 1.62287986278534) + 3.61965687775976e-5*std::sin(0.525999844074249*x_43 + 1.85743987560272) - 0.0168473212616816*std::sin(0.553839862346649*x_43 - 1.35583984851837) - 0.00300045934036547*std::sin(0.110400065779686*x_44 + 1.74895989894867) + 0.00428318066602587*std::sin(0.297119915485382*x_44 + 5.08871984481812) - 1.48953124531778e-5*std::sin(0.539039850234985*x_44 + 1.61799991130829) - 1.13641623964359e-5*std::sin(0.612319827079773*x_45 - 4.80423974990845) + 0.00698459487713959*std::sin(0.145360037684441*x_47 + 5.00600004196167) - 2.82180650419459e-5*std::sin(0.236719980835915*x_47 - 1.83063983917236) - 0.00139983685137017*std::sin(0.159360021352768*x_48 - 7.40391969680786) + 0.000549203091969443*std::sin(0.191600009799004*x_49 - 4.60928010940552) + 0.0029145606035129*std::sin(0.249119967222214*x_49 + 5.13367986679077) - 0.00399835851597485*std::sin(0.3572798371315*x_5 + 2.02199983596802) + 0.015925800827987*std::sin(0.358079850673676*x_5 + 2.00535988807678) + 0.000298587850003562*std::sin(0.5065598487854*x_5 - 1.25143992900848) + 1.00043829722504e-5*std::sin(0.773199856281281*x_5 - 4.792799949646) + 0.00609880685830747*std::sin(0.166880026459694*x_51 + 4.99487972259521) - 0.0133632902265937*std::sin(0.246079966425896*x_52 - 7.42615985870361) - 0.00249950018554191*std::sin(0.562079846858978*x_52 - 1.55815982818604) + 0.00756480620623201*std::sin(0.225839987397194*x_53 + 1.98495984077454) - 0.00852377196066386*std::sin(0.230319991707802*x_54 - 7.43327951431274) + 0.00460767651986798*std::sin(0.261679977178574*x_57 - 7.46247959136963) + 0.0099043129744147*std::sin(0.537599861621857*x_58 - 4.48936033248901) - 0.00097419851380083*std::sin(0.559359848499298*x_58 - 1.54263985157013) + 0.00584875477744377*std::sin(0.143680036067963*x_59 + 1.79303991794586) + 6.24298027648846e-5*std::sin(0.184000000357628*x_59 - 4.97879981994629) + 0.000505007967442172*std::sin(0.491999864578247*x_59 + 1.80147981643677) - 0.00235940622655351*std::sin(0.244319975376129*x_6 + 1.80127990245819) - 0.0014980025445745*std::sin(0.299999952316284*x_6 + 2.0194399356842) - 0.00273450185676332*std::sin(0.365199834108353*x_6 + 2.01551985740662) + 0.00534406512828956*std::sin(0.391679853200912*x_6 + 2.00623965263367) + 2.25635316387416e-5*std::sin(0.206640005111694*x_60 + 2.00567984580994) + 0.00979696698136561*std::sin(0.417759865522385*x_60 + 8.17088031768799) + 0.000264957269654823*std::sin(0.464879840612411*x_60 - 4.32456016540527) - 0.000469481192171298*std::sin(0.633199870586395*x_60 - 4.6450400352478) + 3.84362140538644e-5*std::sin(0.972639799118042*x_64 + 7.79016017913818) + 0.000233805786443497*std::sin(1.046719789505*x_64 + 7.78560018539429) + 1.04822333372032e-5*std::sin(0.970799803733826*x_65 + 2.00151968002319) - 0.0282598167196403*std::sin(0.154000028967857*x_66 + 2.06791973114014) - 0.000227980666823296*std::sin(1.28911983966827*x_67 + 5.21824026107788) + 0.00212124917805395*std::sin(0.221599996089935*x_68 - 0.957519829273224) + 0.42754459844587*std::sin(0.330159842967987*x_7 - 1.14079988002777) - 0.006706165788305*std::sin(0.348879843950272*x_7 - 1.14639985561371) - 0.0130778828833638*std::sin(0.377519845962524*x_7 - 1.16439986228943) + 0.00114878440628848*std::sin(0.477439850568771*x_7 - 1.2397598028183) - 0.000109094613809038*std::sin(1.14047980308533*x_71 + 8.39352035522461) + 4.20961739154094e-5*std::sin(1.30631983280182*x_73 - 1.80255997180939) + 2.86003796329982e-6*std::sin(1.2772798538208*x_77 - 1.16463983058929) - 0.0567548802955504*std::sin(0.397839844226837*x_8 + 1.97663986682892) - 0.00133345029357095*std::sin(0.457359850406647*x_8 + 4.76743984222412) - 0.000650329276439616*std::sin(0.711519837379456*x_83 - 7.9987998008728) + 0.000245231936837177*std::sin(0.690639853477478*x_84 + 7.39631986618042) + 0.00445179922118586*std::sin(0.334639847278595*x_9 - 4.32807970046997) + 0.000860377039514848*std::sin(0.335679858922958*x_91 + 8.40248012542725) - 0.000117946308957371*std::sin(0.352079838514328*x_91 - 7.38151979446411) - 0.00740850583789217*std::sin(0.359119862318039*x_91 + 2.01399970054626) - 0.00410648685707361*std::sin(0.370799839496613*x_91 - 1.18903994560242) - 0.0025266727158079*std::sin(0.283599942922592*x_92 + 2.00687980651855) + 0.00198118630994802*std::sin(0.290319919586182*x_92 - 1.16183984279633) + 0.00048677549584012*std::sin(0.312399923801422*x_92 + 1.98295974731445) + 0.00521535511848744*std::sin(0.223199993371964*x_93 + 5.19488000869751) - 0.0191773198355454*std::sin(0.230719983577728*x_93 - 7.41183996200562) + 5.87222998022058e-5*std::sin(0.234959989786148*x_93 - 1.20967984199524) + 0.0091854482322554*std::sin(0.277119934558868*x_94 + 1.97791981697083) - 0.0111358622335798*std::sin(0.295439928770065*x_94 + 1.95231986045837) - 1.99474768747549e-5*std::sin(0.265919953584671*x_95 - 7.80767965316772) + 0.00128288974688732*std::sin(0.297759920358658*x_96 + 1.9340797662735) + 0.000111328269921422*std::sin(0.317119926214218*x_97 - 1.40455985069275) + 0.00138300697631099*std::sin(0.298399955034256*x_98 - 7.63000011444092) + 0.0281093405651093);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000224885622206408*x_1 + 0.000796050834888004*x_10 - 0.000919544970910771*x_100 - 9.41875281718224e-5*x_101 + 0.0019499832066622*x_102 + 0.00082850040140239*x_103 + 0.000102441621842339*x_104 + 0.00131832387704069*x_105 + 0.00103885919423413*x_106 - 0.00121494112760588*x_107 - 0.000133661559256089*x_108 + 0.0019575317472196*x_109 - 0.00160885297232913*x_11 - 0.00198815346661898*x_110 + 0.00171332422630209*x_111 + 0.000669708957623789*x_112 + 0.00127025586874863*x_113 - 0.00161262535291377*x_114 + 0.00350590882414562*x_115 + 0.00412481784320115*x_116 - 0.00380617980436523*x_117 + 0.00168504664722479*x_118 + 0.00264369638753625*x_119 - 0.00221216389149338*x_12 + 0.00133883544335793*x_120 - 0.000198178648830619*x_13 + 4.28612105084281e-5*x_14 - 0.00112366010052853*x_15 - 0.00086640226633684*x_16 - 0.000226624944331755*x_17 + 0.00050655807586089*x_18 - 0.000758948323962173*x_19 + 0.000758408307587667*x_2 + 0.000487425864680453*x_20 - 9.43173659989542e-5*x_21 + 0.000573013398061243*x_22 + 0.000834452113448867*x_23 - 0.000246574361375107*x_24 + 3.1259782646336e-6*x_25 + 0.000538811359978509*x_26 + 0.00133343746117589*x_27 - 0.000608765388877398*x_28 - 0.000501374245567054*x_29 + 0.00015004640687177*x_3 - 0.000314792850548222*x_30 - 0.00111467284405537*x_31 + 0.000598014946431387*x_32 + 0.000178524356955603*x_33 - 0.00310987605797291*x_34 + 9.12512162120324e-5*x_35 - 0.0020905871462106*x_36 + 0.00069491039089821*x_37 - 0.0021806736520634*x_38 + 0.00102972769686356*x_39 - 0.000236472867657954*x_4 - 0.000449959892444273*x_40 + 0.000217421032945702*x_41 + 0.000201699074039431*x_42 + 0.00120056727378715*x_43 + 0.000152692333962862*x_44 + 0.00165752425270688*x_45 + 0.00210956601743419*x_46 - 0.000978326534326531*x_47 + 0.00271387066399789*x_48 - 0.000105540976974635*x_49 - 0.000381295632375702*x_5 - 0.000852378818973094*x_50 - 0.0155684805659591*x_51 + 0.000333868530432993*x_52 + 0.00776148041768037*x_53 - 0.00019590874400375*x_54 + 0.00163596303611475*x_55 + 0.00254174874976054*x_56 + 0.00166023386243081*x_57 + 0.00261379023968673*x_58 + 0.00306375577019664*x_59 + 0.000755169287762589*x_6 - 0.000186810976649576*x_60 - 0.00232341409171034*x_61 - 5.80798677141644e-5*x_62 - 0.000140241601258843*x_63 - 0.000403112149679614*x_64 + 0.00068078911759825*x_65 - 0.000183733462169927*x_66 - 0.000491707895512958*x_67 + 0.000264553331101091*x_68 + 0.000565346615228983*x_69 + 0.00160156713266094*x_7 - 0.000862728854330997*x_70 - 0.000266548342697464*x_71 - 0.00109042384290803*x_72 - 0.000307642498427006*x_73 - 7.63459758326896e-5*x_74 + 3.73846145031445e-5*x_75 - 0.000234584096539114*x_76 + 0.00142837521616806*x_77 + 0.000955220796503195*x_78 + 0.00130390786750419*x_79 + 0.00203067682617366*x_8 - 0.00161625927952954*x_80 - 0.00133415957629671*x_81 + 6.5859678941235e-5*x_82 + 0.000682912386684867*x_83 + 0.000530824743228419*x_84 - 0.00112233489215867*x_85 - 0.000410804109121691*x_86 - 0.00102894306962472*x_87 + 0.00195683759871788*x_88 + 0.000917860475795648*x_89 + 0.00125735071017575*x_9 - 0.000580445749121767*x_90 - 0.000208919167275996*x_91 + 0.0029778219794316*x_92 + 0.000203494978962178*x_93 + 0.00046708602037318*x_94 + 7.97495114223962e-5*x_95 + 0.000333164696595454*x_96 - 9.54443653388291e-5*x_97 - 0.000592784067989237*x_98 - 0.00173470252989233*x_99 + 1.82281880315519e-6*std::pow(-2.20879983901978*x_24 - 4.21663999557495, 2) + 3.29465932100749e-5*std::pow(-2.59999990463257*x_29 - 1.67199993133545, 2) - 6.77168167181689e-6*std::pow(-3.28383994102478*x_60 - 6.97959995269775, 2) - 1.33968739987531e-8*std::pow(-5.24360036849976*x_61 - 6.25415992736816, 2) - 2.76687338984075e-6*std::pow(-1.86063992977142*x_63 - 6.39928007125854, 2) - 1.10354469681049e-5*std::pow(-2.94071984291077*x_67 - 7.45536041259766, 2) + 1.30228713507571e-5*std::pow(-2.85191988945007*x_7 - 7.12160015106201, 2) - 2.10350216916481e-6*std::pow(-7.80344009399414*x_8 - 3.79063987731934, 2) + 5.06909798410367e-8*std::pow(-2.31807994842529*x_9 - 5.01559972763062, 2) - 0.00762475980445743*std::pow(0.00372701641590814*x_1 + 0.00373467125858556*x_10 - 0.0150594655745154*x_100 - 0.00284291416233676*x_101 + 0.00621213878253448*x_102 - 0.0126026886091722*x_103 - 0.020413170481739*x_104 + 0.00190870023907453*x_105 - 0.00769049421010143*x_106 - 0.0268603258189297*x_107 - 0.0159516434391721*x_108 - 0.0026328606940484*x_109 + 0.00595817409905003*x_11 - 0.0335557974046645*x_110 - 0.00961395195184039*x_111 - 0.00917671212545157*x_112 + 0.000677943473197046*x_113 - 0.015151826083302*x_114 - 0.0106094940954077*x_115 + 0.0289643502202392*x_116 + 0.00287570940363006*x_117 - 0.012450001337734*x_118 - 0.00223104837276614*x_119 - 0.00179323279743742*x_12 + 0.00319599616225284*x_120 + 0.0227567769897558*x_13 - 0.00200018494302894*x_14 + 0.021261540149039*x_15 + 0.0061488985727675*x_16 + 0.01221756206425*x_17 + 0.0693542820825873*x_18 + 0.0179325233825232*x_19 - 0.000556390316130437*x_2 + 0.00659494086001934*x_20 + 0.00444092117935273*x_21 + 0.000760125155563334*x_22 - 0.000183660461040774*x_23 + 0.00686042481234588*x_24 + 0.0114959310504954*x_25 + 0.0119220439431847*x_27 + 0.0104021251639835*x_28 + 0.00816580501218896*x_29 + 0.0229654645857339*x_3 - 0.0035538950689071*x_30 - 0.0116590426465785*x_32 - 0.0088814344913939*x_33 + 0.0055489153630603*x_34 + 0.00394473891168223*x_35 + 0.0152499444331501*x_36 - 0.00531265645326712*x_37 - 0.00758770329061074*x_38 + 0.0158517966211829*x_4 - 0.0146525352162992*x_40 + 0.0170906186584125*x_41 - 0.00674463808801076*x_42 - 0.015944221159224*x_43 - 0.00339948990742662*x_44 + 0.00353272701767404*x_45 + 0.0121479882584177*x_46 - 0.0318117685080916*x_47 - 0.0091248183824669*x_48 - 0.0188659563257397*x_49 + 0.0259633358961046*x_5 - 0.0218200158485604*x_50 - 0.017042595204425*x_51 + 0.00103388316435163*x_52 - 0.0234813207491385*x_53 + 0.0483188189962903*x_54 - 0.0210482235134289*x_55 - 0.00938927974511283*x_56 + 0.0322381666874938*x_57 + 0.0122130047129173*x_58 + 0.00326478791277634*x_59 + 0.0239639497592473*x_6 + 0.032740196338772*x_60 - 0.00561122294652823*x_61 + 0.00100119255947794*x_62 + 0.0233315256607139*x_63 + 0.0197160270738854*x_64 + 0.00146939501620113*x_65 - 0.000959131034625256*x_66 + 0.0014122099845839*x_67 + 0.000167159988622323*x_68 - 0.0010552186631759*x_69 + 0.00601792886335591*x_7 - 0.00500772702228892*x_70 - 0.00365348517651453*x_71 + 0.00224553886377902*x_72 - 0.00170709547749379*x_73 - 0.00666226815012422*x_74 - 0.00444394388286789*x_75 - 0.00803621399755547*x_76 + 0.000796748864425532*x_77 - 0.0105979044422163*x_78 - 0.000292236913381965*x_79 + 0.00572723395757376*x_8 - 0.000106941442348863*x_80 - 0.0016571024393194*x_81 - 0.00811986341855361*x_82 - 0.00818731986427007*x_83 - 0.0123507444804841*x_85 - 0.00765934637150449*x_86 - 0.00765579044583432*x_87 + 0.00245370503850254*x_88 - 0.00190004119232864*x_89 + 0.0145864061667191*x_9 - 8.1374006338708e-5*x_90 + 0.00163052729492824*x_91 - 0.000903683547425542*x_92 + 0.0102247562564046*x_93 - 0.00577616777800485*x_94 + 0.00169391971591127*x_95 + 0.00357115647806287*x_96 + 0.00187293278053434*x_97 - 0.00808719030109109*x_98 - 0.0100016791663951*x_99 + 0.012419827284646*std::exp(0.524799883365631*x_26) - 0.0948668195118412*std::sin(0.893119871616364*x_31 - 7.76775979995728) - 0.184781387377992*std::sin(0.244719967246056*x_39 - 7.60920000076294) - 0.0252951048448966*std::sin(0.690639853477478*x_84 + 7.39631986618042) - 4.40782013791745, 2) + 0.000958927081160404*std::exp(0.314239859580994*x_22) - 3.73414542708482e-5*std::exp(0.570879817008972*x_22) - 0.000863289016453538*std::exp(0.315199851989746*x_25) - 0.00412728958518554*std::exp(0.263759851455688*x_30) - 0.000647466236214785*std::exp(0.199119850993156*x_9) - 0.0160759930890291*std::sin(0.286159932613373*x_1 + 8.28927993774414) - 0.0347864989699947*std::sin(0.304639935493469*x_1 - 4.26056003570557) - 0.000113779834357358*std::sin(0.315999925136566*x_1 - 4.27895975112915) - 0.0145843931404974*std::sin(0.320719838142395*x_1 - 4.25712013244629) + 0.167480849451265*std::sin(0.327199846506119*x_1 - 4.26064014434814) - 0.129174020853804*std::sin(0.330479830503464*x_1 - 4.24128007888794) - 0.0127561066718748*std::sin(0.337999850511551*x_1 - 4.2513599395752) - 0.00415153766911924*std::sin(0.226879999041557*x_100 + 1.99143981933594) - 0.001903086154759*std::sin(0.230639979243279*x_100 - 1.18671989440918) - 0.00914549743334383*std::sin(0.246559977531433*x_100 + 8.17727947235107) + 0.000133501524374944*std::sin(0.361279845237732*x_100 - 1.57759976387024) - 0.0111656431506958*std::sin(0.204479992389679*x_102 - 1.18623995780945) + 8.23333729384836e-6*std::sin(0.187440007925034*x_104 + 8.40816020965576) - 0.0220595531470606*std::sin(0.217280000448227*x_105 + 1.96951985359192) + 0.00100331994662405*std::sin(0.240399971604347*x_107 + 1.78271985054016) - 0.0132531296075713*std::sin(0.242399975657463*x_107 - 4.23863983154297) - 0.000831866417874946*std::sin(0.291279941797256*x_107 + 4.76240015029907) + 0.00625435277117589*std::sin(0.176640018820763*x_108 + 5.21304035186768) + 0.00421193766013838*std::sin(0.245119974017143*x_108 - 1.19279980659485) + 7.97842808644917e-6*std::sin(0.243519976735115*x_109 + 5.15503978729248) + 0.00445254928503448*std::sin(0.250159978866577*x_11 - 7.40879964828491) + 0.00110005836254285*std::sin(0.290879935026169*x_11 - 1.21463990211487) + 0.0045496810106282*std::sin(0.297759920358658*x_11 - 4.26287984848022) + 0.0656961924836728*std::sin(0.268799960613251*x_112 - 7.42655992507935) + 0.0277350387185544*std::sin(0.276559948921204*x_112 - 7.4332799911499) - 0.0196064858746323*std::sin(0.28263995051384*x_112 + 1.95687973499298) + 0.0283744277113645*std::sin(0.282719939947128*x_113 - 7.41199970245361) + 0.0488048897997752*std::sin(0.284879922866821*x_113 + 5.15928030014038) - 0.0388035227011157*std::sin(0.217600002884865*x_114 - 4.22240018844604) - 0.0266720031391352*std::sin(0.243279978632927*x_116 + 1.97951984405518) - 0.0315119163697438*std::sin(0.230959981679916*x_118 + 5.17176008224487) + 0.0567128535397628*std::sin(0.239599987864494*x_119 + 5.15503978729248) + 0.00100099033667572*std::sin(0.25231996178627*x_119 - 7.4456000328064) + 0.00995650619842656*std::sin(0.300079941749573*x_12 + 5.13064002990723) - 0.000581138966879447*std::sin(0.7290398478508*x_12 - 4.77559995651245) + 0.00743536300804873*std::sin(0.251999974250793*x_120 + 5.16232013702393) + 0.0819770700046031*std::sin(0.263759940862656*x_120 + 5.16455984115601) - 0.038855395685089*std::sin(0.270239949226379*x_120 - 7.43232011795044) + 0.00480577720580005*std::sin(0.277679949998856*x_13 + 5.16752004623413) - 0.0339173901313271*std::sin(0.305919945240021*x_13 - 7.44199991226196) + 0.000231365257000675*std::sin(0.679199814796448*x_13 - 8.21103954315186) - 0.0698388638405209*std::sin(0.307679921388626*x_14 + 5.12720012664795) + 0.019595493549377*std::sin(0.332079827785492*x_15 + 8.26583957672119) + 0.0181760059620167*std::sin(0.316639930009842*x_16 + 1.99335980415344) + 0.0104189455322175*std::sin(0.336479842662811*x_17 - 1.1490398645401) + 0.00869921604927967*std::sin(0.339519828557968*x_17 + 1.9948798418045) + 0.0121338705362789*std::sin(0.343039840459824*x_17 + 2.01007986068726) - 0.00124085819236737*std::sin(0.491839855909348*x_17 + 1.9327198266983) - 8.80631773973529e-5*std::sin(0.651039838790894*x_17 - 7.63024044036865) + 0.0291751915423261*std::sin(0.336559861898422*x_18 - 1.15495979785919) + 0.00583028624447565*std::sin(0.382799834012985*x_18 + 1.98943984508514) + 0.0137406169449954*std::sin(0.5204798579216*x_18 - 4.33296012878418) + 0.0839632534025612*std::sin(0.291519939899445*x_19 - 1.18711996078491) + 0.0398402866670406*std::sin(0.312159925699234*x_19 - 7.41224002838135) + 0.00117650129721817*std::sin(0.346159845590591*x_19 + 5.02383995056152) - 0.00585241338337382*std::sin(0.353759855031967*x_2 - 7.41535997390747) - 0.0298316399410461*std::sin(0.37391984462738*x_2 - 7.3951997756958) + 0.0607650123574917*std::sin(0.379999846220016*x_2 - 4.21528005599976) - 0.0167809035221524*std::sin(0.188640013337135*x_20 + 1.97775971889496) + 0.000507969896288542*std::sin(0.359199851751328*x_20 - 1.15183985233307) - 0.0184130549390337*std::sin(0.293759942054749*x_21 + 2.00879979133606) + 0.0796711731819683*std::sin(0.315199911594391*x_21 + 1.99711978435516) - 0.126307997586778*std::sin(0.0824000835418701*x_22 - 4.54647970199585) + 0.00265648334557431*std::sin(0.349839836359024*x_22 + 1.99503982067108) - 0.0274146435361032*std::sin(0.192320004105568*x_23 - 4.40319967269897) + 0.0195907931193945*std::sin(0.316399931907654*x_23 - 1.16175985336304) - 0.0310730918016801*std::sin(0.334399849176407*x_23 - 1.15567982196808) + 0.000987256335125872*std::sin(0.487599849700928*x_23 + 1.95495975017548) - 0.0156203436880074*std::sin(0.164080023765564*x_24 - 1.23895978927612) - 0.013847941698816*std::sin(0.224479988217354*x_24 - 1.19663989543915) + 0.00265716250336595*std::sin(0.402799844741821*x_24 - 1.20791983604431) - 0.0301907710832026*std::sin(0.343439847230911*x_25 - 1.15567982196808) - 0.00285497036180536*std::sin(0.406719863414764*x_25 + 5.00271987915039) + 0.00108784391332498*std::sin(0.784239888191223*x_26 - 4.60712003707886) - 0.00569983285595472*std::sin(0.172560006380081*x_27 - 1.21567988395691) + 0.000248302131932152*std::sin(0.669999837875366*x_27 - 1.0791198015213) + 0.0054998783241591*std::sin(0.299039930105209*x_28 - 7.40471982955933) - 0.00679659271865828*std::sin(0.112880066037178*x_29 + 4.91199970245361) + 0.0176152852725519*std::sin(0.148480042815208*x_29 + 1.75919997692108) + 0.00171963515045562*std::sin(0.176480010151863*x_29 + 4.97535943984985) + 0.000865226071578312*std::sin(0.333439826965332*x_29 - 4.36719989776611) + 0.00583681503123082*std::sin(0.205520004034042*x_3 - 7.59863996505737) + 0.0452263400233052*std::sin(0.346959829330444*x_3 - 7.38855981826782) - 0.00978657763654937*std::sin(0.348559856414795*x_3 - 7.39647960662842) - 0.00456615237299265*std::sin(0.367279827594757*x_3 - 4.18991994857788) + 0.00178004486321678*std::sin(0.415519863367081*x_3 - 1.18831992149353) - 0.100407308393369*std::sin(0.418559849262238*x_3 + 2.00775980949402) - 0.000460888236574981*std::sin(0.213119998574257*x_30 + 1.35935986042023) + 0.0173568190882637*std::sin(0.239439979195595*x_30 - 1.17183983325958) - 0.100450495270658*std::sin(0.332799851894379*x_30 - 1.1497597694397) + 0.0824233832235614*std::sin(0.358399868011475*x_30 + 2.01263976097107) + 0.00472437303231937*std::sin(0.371919840574265*x_30 + 1.99511981010437) - 0.00451902009807698*std::sin(0.347519844770432*x_31 + 5.17407989501953) + 0.00464598332942075*std::sin(0.360239863395691*x_31 + 5.18207979202271) - 0.0351207246353811*std::sin(0.368399828672409*x_31 + 5.17768001556396) - 0.000239633223631293*std::sin(0.369359821081161*x_31 + 5.17328023910522) + 0.00375656241452499*std::sin(0.392399847507477*x_31 - 7.40079975128174) + 0.0031360589910333*std::sin(0.412079870700836*x_31 + 5.19288015365601) - 0.0501894227494278*std::sin(0.415039867162704*x_31 - 7.40055990219116) + 6.38072337310532e-6*std::sin(0.240959972143173*x_32 + 2.01855969429016) + 0.0655052776312724*std::sin(0.309279918670654*x_32 - 1.13791990280151) + 0.00806700080892361*std::sin(0.311119943857193*x_32 + 2.01319980621338) + 0.0400404131661937*std::sin(0.238159984350204*x_33 - 1.21919989585876) - 0.00277568107090501*std::sin(0.238559976220131*x_33 + 1.97919988632202) + 0.00131607960767741*std::sin(0.236399978399277*x_34 - 1.21151983737946) - 0.000976341015548915*std::sin(0.228479996323586*x_35 + 8.19143962860107) - 0.0245951750660014*std::sin(0.292799949645996*x_4 + 2.00839972496033) + 5.93309658916666e-6*std::sin(0.302479922771454*x_40 - 1.62287986278534) + 0.00064082103852457*std::sin(0.525999844074249*x_43 + 1.85743987560272) + 0.000726862844778914*std::sin(0.553839862346649*x_43 - 1.35583984851837) + 0.0115308539259874*std::sin(0.110400065779686*x_44 + 1.74895989894867) - 0.00166638461258089*std::sin(0.297119915485382*x_44 + 5.08871984481812) + 0.000620429796184104*std::sin(0.539039850234985*x_44 + 1.61799991130829) + 0.00047334790603332*std::sin(0.612319827079773*x_45 - 4.80423974990845) - 0.00202420237371219*std::sin(0.145360037684441*x_47 + 5.00600004196167) + 7.61696267762309e-6*std::sin(0.236719980835915*x_47 - 1.83063983917236) - 0.0247825950125745*std::sin(0.159360021352768*x_48 - 7.40391969680786) + 0.00237422114286447*std::sin(0.191600009799004*x_49 - 4.60928010940552) - 0.000844667528430073*std::sin(0.249119967222214*x_49 + 5.13367986679077) - 0.0707866061102*std::sin(0.3572798371315*x_5 + 2.02199983596802) - 0.0612033232816676*std::sin(0.358079850673676*x_5 + 2.00535988807678) + 0.00129080407020058*std::sin(0.5065598487854*x_5 - 1.25143992900848) - 0.000416709438484911*std::sin(0.773199856281281*x_5 - 4.792799949646) - 0.00176749253701224*std::sin(0.166880026459694*x_51 + 4.99487972259521) + 0.0513555193034736*std::sin(0.246079966425896*x_52 - 7.42615985870361) + 0.00442041707177371*std::sin(0.562079846858978*x_52 - 1.55815982818604) - 0.0133785141093869*std::sin(0.225839987397194*x_53 + 1.98495984077454) + 0.015074464610474*std::sin(0.230319991707802*x_54 - 7.43327951431274) - 0.00133534870853302*std::sin(0.261679977178574*x_57 - 7.46247959136963) - 0.000427312864303106*std::sin(0.537599861621857*x_58 - 4.48936033248901) + 0.000379014928292326*std::sin(0.559359848499298*x_58 - 1.54263985157013) - 0.0022754760361146*std::sin(0.143680036067963*x_59 + 1.79303991794586) - 0.00260036907094001*std::sin(0.184000000357628*x_59 - 4.97879981994629) + 0.00218316431780564*std::sin(0.491999864578247*x_59 + 1.80147981643677) + 0.000683778482267082*std::sin(0.244319975376129*x_6 + 1.80127990245819) - 0.00647590912250625*std::sin(0.299999952316284*x_6 + 2.0194399356842) - 0.0484113930926782*std::sin(0.365199834108353*x_6 + 2.01551985740662) - 0.0205374002361132*std::sin(0.391679853200912*x_6 + 2.00623965263367) - 6.09062237655865e-6*std::sin(0.206640005111694*x_60 + 2.00567984580994) - 0.017326135979719*std::sin(0.417759865522385*x_60 + 8.17088031768799) + 0.0046907814314688*std::sin(0.464879840612411*x_60 - 4.32456016540527) + 0.00180423009740444*std::sin(0.633199870586395*x_60 - 4.6450400352478) + 0.000680471531936869*std::sin(0.972639799118042*x_64 + 7.79016017913818) - 0.000413490303322477*std::sin(1.046719789505*x_64 + 7.78560018539429) - 0.000436613190451586*std::sin(0.970799803733826*x_65 + 2.00151968002319) + 0.00121924491464931*std::sin(0.154000028967857*x_66 + 2.06791973114014) + 8.86965796641872e-5*std::sin(1.28911983966827*x_67 + 5.21824026107788) - 0.000825278517387108*std::sin(0.221599996089935*x_68 - 0.957519829273224) - 0.0184460353233156*std::sin(0.330159842967987*x_7 - 1.14079988002777) + 0.0257719933305212*std::sin(0.348879843950272*x_7 - 1.14639985561371) + 0.0050879905615078*std::sin(0.377519845962524*x_7 - 1.16439986228943) - 0.000332928704240754*std::sin(0.477439850568771*x_7 - 1.2397598028183) + 0.000419253825246238*std::sin(1.14047980308533*x_71 + 8.39352035522461) + 0.000181982999741061*std::sin(1.30631983280182*x_73 - 1.80255997180939) - 7.72016167326038e-7*std::sin(1.2772798538208*x_77 - 1.16463983058929) + 0.00244863934781956*std::sin(0.397839844226837*x_8 + 1.97663986682892) + 0.000386446643928894*std::sin(0.457359850406647*x_8 + 4.76743984222412) + 0.000188471641980574*std::sin(0.711519837379456*x_83 - 7.9987998008728) - 0.00129017397706321*std::sin(0.334639847278595*x_9 - 4.32807970046997) + 0.00371943528345057*std::sin(0.335679858922958*x_91 + 8.40248012542725) + 0.00491278075952529*std::sin(0.352079838514328*x_91 - 7.38151979446411) + 0.0284711068993036*std::sin(0.359119862318039*x_91 + 2.01399970054626) + 0.00119009915248091*std::sin(0.370799839496613*x_91 - 1.18903994560242) - 0.0447320032930254*std::sin(0.283599942922592*x_92 + 2.00687980651855) + 0.00856472677195696*std::sin(0.290319919586182*x_92 - 1.16183984279633) - 0.000131396351191484*std::sin(0.312399923801422*x_92 + 1.98295974731445) - 0.0200427638643169*std::sin(0.223199993371964*x_93 + 5.19488000869751) + 0.00555777063886724*std::sin(0.230719983577728*x_93 - 7.41183996200562) - 0.00244594160829246*std::sin(0.234959989786148*x_93 - 1.20967984199524) - 0.00266203071794428*std::sin(0.277119934558868*x_94 + 1.97791981697083) + 0.00433244145432597*std::sin(0.295439928770065*x_94 + 1.95231986045837) + 5.38446511629702e-6*std::sin(0.265919953584671*x_95 - 7.80767965316772) + 0.00554597016215159*std::sin(0.297759920358658*x_96 + 1.9340797662735) + 0.001970946417229*std::sin(0.317119926214218*x_97 - 1.40455985069275) - 0.000400808644388506*std::sin(0.298399955034256*x_98 - 7.63000011444092) + 0.825937561472838);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00029089445470459*x_1 - 0.000316446161511049*x_10 - 5.00779595400915e-5*x_100 - 0.00070109927037711*x_101 - 0.000277737995557651*x_102 + 0.000183797327692232*x_103 - 0.000260941780932675*x_104 + 0.00346572085797512*x_105 - 0.00248004774840098*x_106 + 0.000709898378131041*x_107 + 0.00295453549557162*x_108 + 0.00108560141123673*x_109 + 0.00435633331349107*x_11 + 0.0012507866129094*x_110 + 3.62699237155896e-6*x_111 - 0.00112838331290799*x_112 + 0.00230986078076853*x_113 - 0.000644250228212305*x_114 - 0.002384792291089*x_115 + 0.000753703222489688*x_116 - 0.000399892491885522*x_117 - 0.000356664365760715*x_118 + 3.66850040644574e-5*x_119 + 0.00864271924713251*x_12 - 0.000772342306456311*x_120 + 0.0036059139255783*x_13 + 0.000665234846107868*x_14 + 0.00203906161013453*x_15 + 0.000358514954313868*x_16 + 0.000116968218399575*x_17 - 0.00125088245786693*x_18 - 0.000219286743038648*x_19 + 0.000805475516705789*x_2 - 0.000134966311523897*x_20 + 0.000132366622910892*x_21 - 0.000235475194343523*x_22 - 0.000723063617035083*x_23 + 1.46803052840084e-5*x_24 - 0.000984247565773898*x_25 - 0.00146842676244361*x_26 + 0.00235415664111652*x_27 + 0.000203023726493264*x_28 + 0.000876919546441446*x_29 + 4.62631995309155e-5*x_3 + 7.75135651677838e-5*x_30 + 0.00111119819895686*x_31 + 0.00307073942931619*x_32 + 0.000707088846253761*x_33 + 0.00177376289209437*x_34 - 0.00103797219081601*x_35 + 0.00198528503785196*x_36 + 0.00190156328229494*x_37 + 0.00308524681463823*x_38 + 0.000852822061802688*x_39 + 0.00164475177560858*x_4 - 0.00273396390087881*x_40 - 0.0011065775328443*x_41 + 0.000477508735295516*x_42 - 0.00111183602755957*x_43 + 0.000788714297231831*x_44 + 0.00207870236649695*x_45 - 0.0017231854337369*x_46 - 0.00173138231638025*x_47 + 6.51876060409668e-6*x_48 - 0.000606113392738814*x_49 + 0.00122321350982052*x_5 - 0.000413016078665555*x_50 + 0.015627884891012*x_51 + 0.00154773711113157*x_52 + 0.00277526713075588*x_53 + 0.000824264521724138*x_54 + 0.00345234989800839*x_55 - 0.00259425022204262*x_56 - 0.00280116504232354*x_57 - 0.00201393394256742*x_58 - 0.00156938293390334*x_59 - 0.00433898031695295*x_6 + 0.00111294963460862*x_60 + 0.000918187863194521*x_61 - 0.00063323665459628*x_62 - 0.0021328717151319*x_63 - 1.40991364922158e-5*x_64 - 0.00237043304567454*x_65 + 0.000121551060805022*x_66 + 0.00127139864200857*x_67 - 0.000405558329346213*x_68 - 0.000451556585527332*x_69 - 0.00144497228689435*x_7 - 0.000484757428839513*x_70 - 0.00202533241223016*x_71 + 0.000677243340435759*x_72 + 0.000163800048118137*x_73 + 0.0028889584454105*x_74 + 0.00014668721016835*x_75 - 1.60714024580283e-5*x_76 + 0.000221145096663201*x_77 - 0.00199665711911916*x_78 + 0.000441800974177458*x_79 - 0.00202652189728191*x_8 + 0.000447714999403128*x_80 - 0.00152061647463734*x_81 - 0.000948731830110412*x_82 + 0.000227733328351651*x_83 - 0.00108766592002958*x_84 - 0.00174769826033885*x_85 - 0.000205861813762034*x_86 + 0.00117598429073366*x_87 - 0.000996005993771323*x_88 - 6.68039179505194e-5*x_89 + 0.000616570377746257*x_9 + 0.000826027464928536*x_90 + 0.0018520483406555*x_91 - 0.00513619478628213*x_92 + 0.00347911216415893*x_93 - 0.000222277656758645*x_94 - 0.00177261309953313*x_95 + 0.00342508094113724*x_96 + 0.00491271060031193*x_97 + 0.00292698998636134*x_98 + 0.00664931296666156*x_99 + 2.68072889941177e-5*std::pow(-2.20879983901978*x_24 - 4.21663999557495, 2) - 2.65272763938668e-6*std::pow(-2.59999990463257*x_29 - 1.67199993133545, 2) + 9.62604425764137e-7*std::pow(-3.28383994102478*x_60 - 6.97959995269775, 2) + 1.32757157436666e-6*std::pow(-5.24360036849976*x_61 - 6.25415992736816, 2) + 1.56870488109242e-6*std::pow(-2.94071984291077*x_67 - 7.45536041259766, 2) - 1.85122015563267e-6*std::pow(-2.85191988945007*x_7 - 7.12160015106201, 2) + 1.8336057026091e-6*std::pow(-7.80344009399414*x_8 - 3.79063987731934, 2) - 5.02325422483014e-6*std::pow(-2.31807994842529*x_9 - 5.01559972763062, 2) - 5.06225857811238e-5*std::exp(0.570879817008972*x_22) + 4.80205726133905e-5*std::exp(0.524799883365631*x_26) + 0.00496817390076212*std::exp(0.263759851455688*x_30) - 0.000877748757330865*std::exp(0.199119850993156*x_9) - 0.236421629982687*std::sin(0.286159932613373*x_1 + 8.28927993774414) + 0.0303231077296742*std::sin(0.304639935493469*x_1 - 4.26056003570557) + 0.0112750835637504*std::sin(0.315999925136566*x_1 - 4.27895975112915) + 0.00207319275543562*std::sin(0.320719838142395*x_1 - 4.25712013244629) - 0.0134848867551948*std::sin(0.327199846506119*x_1 - 4.26064014434814) + 0.00499736223253687*std::sin(0.226879999041557*x_100 + 1.99143981933594) - 0.0279877409883099*std::sin(0.230639979243279*x_100 - 1.18671989440918) + 0.00797205559984486*std::sin(0.246559977531433*x_100 + 8.17727947235107) + 0.000180983641412633*std::sin(0.361279845237732*x_100 - 1.57759976387024) - 0.000815887688016122*std::sin(0.187440007925034*x_104 + 8.40816020965576) + 0.0192291327484197*std::sin(0.217280000448227*x_105 + 1.96951985359192) + 0.0147553271428612*std::sin(0.240399971604347*x_107 + 1.78271985054016) + 0.015953291200136*std::sin(0.242399975657463*x_107 - 4.23863983154297) - 0.000790627301315539*std::sin(0.243519976735115*x_109 + 5.15503978729248) + 0.0161780108829453*std::sin(0.290879935026169*x_11 - 1.21463990211487) - 0.000646743791113662*std::sin(0.297759920358658*x_11 - 4.26287984848022) - 0.0572668357292905*std::sin(0.268799960613251*x_112 - 7.42655992507935) - 0.00394257620383047*std::sin(0.276559948921204*x_112 - 7.4332799911499) + 0.0236010653959554*std::sin(0.28263995051384*x_112 + 1.95687973499298) - 0.00403346628167116*std::sin(0.282719939947128*x_113 - 7.41199970245361) - 0.0425428248013682*std::sin(0.284879922866821*x_113 + 5.15928030014038) + 0.0338247145874527*std::sin(0.217600002884865*x_114 - 4.22240018844604) + 0.023249767826645*std::sin(0.243279978632927*x_116 + 1.97951984405518) - 0.0494361323635013*std::sin(0.239599987864494*x_119 + 5.15503978729248) + 0.00135700979444718*std::sin(0.25231996178627*x_119 - 7.4456000328064) + 0.000699538859189725*std::sin(0.7290398478508*x_12 - 4.77559995651245) - 0.00105694769565125*std::sin(0.251999974250793*x_120 + 5.16232013702393) - 0.0986788862888837*std::sin(0.263759940862656*x_120 + 5.16455984115601) - 3.28889087158096e-5*std::sin(0.679199814796448*x_13 - 8.21103954315186) + 0.267305474213447*std::sin(0.316639930009842*x_16 + 1.99335980415344) - 0.00148106830284849*std::sin(0.336479842662811*x_17 - 1.1490398645401) + 0.127935041185469*std::sin(0.339519828557968*x_17 + 1.9948798418045) - 0.000119384363544622*std::sin(0.651039838790894*x_17 - 7.63024044036865) - 0.0041472960281112*std::sin(0.336559861898422*x_18 - 1.15495979785919) - 0.0731900839016852*std::sin(0.291519939899445*x_19 - 1.18711996078491) - 0.00566335485452841*std::sin(0.312159925699234*x_19 - 7.41224002838135) + 0.0173022190806294*std::sin(0.346159845590591*x_19 + 5.02383995056152) - 0.0860685311176191*std::sin(0.353759855031967*x_2 - 7.41535997390747) + 0.00240192408651361*std::sin(0.37391984462738*x_2 - 7.3951997756958) - 0.0529683661900134*std::sin(0.379999846220016*x_2 - 4.21528005599976) + 0.00238542990967425*std::sin(0.188640013337135*x_20 + 1.97775971889496) + 0.00747046046845039*std::sin(0.359199851751328*x_20 - 1.15183985233307) + 0.00261744261398461*std::sin(0.293759942054749*x_21 + 2.00879979133606) - 0.0694487125430525*std::sin(0.315199911594391*x_21 + 1.99711978435516) + 0.0179548660700432*std::sin(0.0824000835418701*x_22 - 4.54647970199585) + 0.00389703156136675*std::sin(0.192320004105568*x_23 - 4.40319967269897) + 0.288112044854119*std::sin(0.316399931907654*x_23 - 1.16175985336304) + 0.00250188081474568*std::sin(0.334399849176407*x_23 - 1.15567982196808) + 0.00111498076474357*std::sin(0.224479988217354*x_24 - 1.19663989543915) - 0.000377719525174948*std::sin(0.402799844741821*x_24 - 1.20791983604431) + 0.0263170491743804*std::sin(0.343439847230911*x_25 - 1.15567982196808) + 0.000405838200743703*std::sin(0.406719863414764*x_25 + 5.00271987915039) - 0.000154638598838071*std::sin(0.784239888191223*x_26 - 4.60712003707886) + 0.000336615062771784*std::sin(0.669999837875366*x_27 - 1.0791198015213) + 0.0808839734443227*std::sin(0.299039930105209*x_28 - 7.40471982955933) + 0.000966145567403996*std::sin(0.112880066037178*x_29 + 4.91199970245361) + 0.0252898183642349*std::sin(0.176480010151863*x_29 + 4.97535943984985) - 0.000829711769354618*std::sin(0.205520004034042*x_3 - 7.59863996505737) - 0.00619018312770849*std::sin(0.367279827594757*x_3 - 4.18991994857788) + 0.0261782339463196*std::sin(0.415519863367081*x_3 - 1.18831992149353) + 0.0875242326594851*std::sin(0.418559849262238*x_3 + 2.00775980949402) - 0.00677805392969873*std::sin(0.213119998574257*x_30 + 1.35935986042023) - 0.00246729714733729*std::sin(0.239439979195595*x_30 - 1.17183983325958) + 0.0875618783085534*std::sin(0.332799851894379*x_30 - 1.1497597694397) - 0.00663640047439081*std::sin(0.358399868011475*x_30 + 2.01263976097107) + 0.000642385297677296*std::sin(0.347519844770432*x_31 + 5.17407989501953) + 0.0422761388334979*std::sin(0.368399828672409*x_31 + 5.17768001556396) + 0.0237466035730695*std::sin(0.369359821081161*x_31 + 5.17328023910522) + 0.00509264855332367*std::sin(0.392399847507477*x_31 - 7.40079975128174) + 0.0461204588902155*std::sin(0.412079870700836*x_31 + 5.19288015365601) - 0.00036679729037791*std::sin(0.893119871616364*x_31 - 7.76775979995728) - 0.00063230175747118*std::sin(0.240959972143173*x_32 + 2.01855969429016) - 0.00114673593025368*std::sin(0.311119943857193*x_32 + 2.01319980621338) - 0.034902901928315*std::sin(0.238159984350204*x_33 - 1.21919989585876) + 0.000394567112403264*std::sin(0.238559976220131*x_33 + 1.97919988632202) - 0.00132359351761615*std::sin(0.228479996323586*x_35 + 8.19143962860107) - 0.00071444697473028*std::sin(0.244719967246056*x_39 - 7.60920000076294) - 0.000587943902471765*std::sin(0.302479922771454*x_40 - 1.62287986278534) - 5.15963416901866e-5*std::sin(0.525999844074249*x_43 + 1.85743987560272) + 0.0106896101276479*std::sin(0.553839862346649*x_43 - 1.35583984851837) - 0.00225906300763912*std::sin(0.297119915485382*x_44 + 5.08871984481812) - 0.000746834710053053*std::sin(0.539039850234985*x_44 + 1.61799991130829) - 0.000569786700011607*std::sin(0.612319827079773*x_45 - 4.80423974990845) - 0.000754807661456345*std::sin(0.236719980835915*x_47 - 1.83063983917236) + 0.00199539522482341*std::sin(0.159360021352768*x_48 - 7.40391969680786) - 0.000337498998125665*std::sin(0.191600009799004*x_49 - 4.60928010940552) + 0.00569945381999267*std::sin(0.3572798371315*x_5 + 2.02199983596802) - 0.000183489681143866*std::sin(0.5065598487854*x_5 - 1.25143992900848) + 0.000501608843710176*std::sin(0.773199856281281*x_5 - 4.792799949646) - 0.00385324154618443*std::sin(0.562079846858978*x_52 - 1.55815982818604) + 0.0116619417479128*std::sin(0.225839987397194*x_53 + 1.98495984077454) - 0.0131402879819795*std::sin(0.230319991707802*x_54 - 7.43327951431274) - 0.00628427763881382*std::sin(0.537599861621857*x_58 - 4.48936033248901) + 0.000513818117008461*std::sin(0.559359848499298*x_58 - 1.54263985157013) - 0.00308478828905789*std::sin(0.143680036067963*x_59 + 1.79303991794586) + 0.00313016217639898*std::sin(0.184000000357628*x_59 - 4.97879981994629) - 0.00031033999179796*std::sin(0.491999864578247*x_59 + 1.80147981643677) + 0.000920559926512068*std::sin(0.299999952316284*x_6 + 2.0194399356842) + 0.00389789134492031*std::sin(0.365199834108353*x_6 + 2.01551985740662) + 0.000603554018502624*std::sin(0.206640005111694*x_60 + 2.00567984580994) + 0.0151030515690922*std::sin(0.417759865522385*x_60 + 8.17088031768799) - 0.000377682920787513*std::sin(0.464879840612411*x_60 - 4.32456016540527) - 5.47888405054498e-5*std::sin(0.972639799118042*x_64 + 7.79016017913818) + 0.000360436128500259*std::sin(1.046719789505*x_64 + 7.78560018539429) + 0.000525567739495686*std::sin(0.970799803733826*x_65 + 2.00151968002319) + 0.0179308281904033*std::sin(0.154000028967857*x_66 + 2.06791973114014) + 0.000120243046239576*std::sin(1.28911983966827*x_67 + 5.21824026107788) - 0.00111880303955818*std::sin(0.221599996089935*x_68 - 0.957519829273224) - 0.271276661647276*std::sin(0.330159842967987*x_7 - 1.14079988002777) + 0.00689762205792171*std::sin(0.377519845962524*x_7 - 1.16439986228943) - 2.58691488251215e-5*std::sin(1.30631983280182*x_73 - 1.80255997180939) + 7.65034230215894e-5*std::sin(1.2772798538208*x_77 - 1.16463983058929) + 0.0360109202986853*std::sin(0.397839844226837*x_8 + 1.97663986682892) - 9.78021184295646e-5*std::sin(0.690639853477478*x_84 + 7.39631986618042) - 0.000528723150128847*std::sin(0.335679858922958*x_91 + 8.40248012542725) - 0.00591369920764661*std::sin(0.352079838514328*x_91 - 7.38151979446411) + 0.0036016416247935*std::sin(0.283599942922592*x_92 + 2.00687980651855) - 0.00121748840180409*std::sin(0.290319919586182*x_92 - 1.16183984279633) + 0.0130208032734762*std::sin(0.312399923801422*x_92 + 1.98295974731445) + 0.00294427202412074*std::sin(0.234959989786148*x_93 - 1.20967984199524) + 0.00587334889456976*std::sin(0.295439928770065*x_94 + 1.95231986045837) - 0.000533576924902786*std::sin(0.265919953584671*x_95 - 7.80767965316772) - 0.000788367747034186*std::sin(0.297759920358658*x_96 + 1.9340797662735) - 0.000158692706204741*std::sin(0.317119926214218*x_97 - 1.40455985069275) + 0.0887115150690079*std::sin(-0.0220854506923151*x_10 + 0.00341900310965115*x_100 - 0.00408701367180021*x_101 + 0.00428647723743017*x_102 + 0.00381482647601125*x_103 + 0.0247515239562774*x_104 + 0.0119018656140447*x_105 + 0.00833994023579543*x_106 - 0.00116374138522426*x_109 + 0.00129771534521685*x_110 + 0.0310777489050907*x_111 + 0.0183169378800662*x_112 - 0.149181961959426*x_113 + 0.00164771920512084*x_114 - 0.00104079646772073*x_115 - 0.0541582054887444*x_116 + 0.0176741518032815*x_117 + 0.0038466514555052*x_118 - 0.0258751488206855*x_119 - 0.0222160150589325*x_120 - 0.0212105377630754*x_14 - 0.0228488881372408*x_15 + 0.00555744237803044*x_16 + 0.00514210815715866*x_19 + 0.00729481524488239*x_2 - 0.00201425610227705*x_20 + 0.0142526058715354*x_21 + 0.0358409542821505*x_24 + 0.00601881909808526*x_25 + 0.00934457473699237*x_26 + 0.0227801649861948*x_28 + 0.00809174254566539*x_32 - 0.0128643724414176*x_33 + 0.0162974989895676*x_35 - 0.0254604036680278*x_36 + 0.00378713562056667*x_37 + 0.0148265281430763*x_38 + 0.00669431885967369*x_39 + 0.0117225848564341*x_4 + 0.00202197529972426*x_40 - 0.0015128192965842*x_41 + 0.0017956140802577*x_42 + 0.00778776501285492*x_43 + 0.00127777888360577*x_44 + 0.0095060516368492*x_45 + 0.0190029161939824*x_46 - 0.00757272872183436*x_48 + 0.0272791457012033*x_5 + 0.00204146020982406*x_50 + 0.0311385768304299*x_52 + 0.0387292361845562*x_53 + 0.00480547104658424*x_54 + 0.017533292184929*x_55 + 0.0235748714045548*x_56 + 0.00691709020111853*x_58 + 0.00222814183859401*x_59 + 0.00843572055175407*x_60 + 0.00751631068592911*x_61 + 0.0124317686150629*x_62 - 0.00370451088582887*x_64 - 0.00496241286476308*x_65 - 0.000124172034870829*x_66 - 0.0100370850135202*x_67 + 0.0154201783693148*x_68 + 0.00862078501282399*x_69 + 0.022487393630437*x_70 + 0.00305033491628201*x_71 + 0.00371335567891702*x_72 + 0.008216049842934*x_73 + 0.00663576574212723*x_74 + 0.0053087423279307*x_75 - 0.00034758812953635*x_76 + 0.00722106431352156*x_77 + 0.000481555558181889*x_78 + 0.0125708117884677*x_79 + 0.00428338590854516*x_80 - 0.00410614857335833*x_81 + 0.00180996727072075*x_82 - 0.000792908043722577*x_84 + 0.00252118413930594*x_85 - 0.000451034339084998*x_86 - 0.00611338197039912*x_87 - 0.0048188094253825*x_88 + 3.96037718840606e-5*x_89 - 0.00499893512735798*x_90 + 0.0327869210515768*x_92 - 0.00536963563741374*x_95 - 0.00341512299418123*x_96 - 0.0263176094446246*x_97 - 0.033366261435447*x_99 + 0.000343266156361779*std::pow(-1.86063992977142*x_63 - 6.39928007125854, 2) + 1.58255875511793*std::sin(0.337999850511551*x_1 - 4.2513599395752) + 0.103203706002178*std::sin(0.291279941797256*x_107 + 4.76240015029907) - 0.522544926247726*std::sin(0.245119974017143*x_108 - 1.19279980659485) - 0.552395886525602*std::sin(0.250159978866577*x_11 - 7.40879964828491) - 1.23523238398806*std::sin(0.300079941749573*x_12 + 5.13064002990723) - 0.596218343717197*std::sin(0.277679949998856*x_13 + 5.16752004623413) - 1.50536237620169*std::sin(0.343039840459824*x_17 + 2.01007986068726) - 0.723321839365155*std::sin(0.382799834012985*x_18 + 1.98943984508514) - 0.329570854532978*std::sin(0.349839836359024*x_22 + 1.99503982067108) - 0.122481819640464*std::sin(0.487599849700928*x_23 + 1.95495975017548) + 0.707137422171954*std::sin(0.172560006380081*x_27 - 1.21567988395691) - 0.107342399209594*std::sin(0.333439826965332*x_29 - 4.36719989776611) + 1.21415056488284*std::sin(0.348559856414795*x_3 - 7.39647960662842) - 0.586119111188118*std::sin(0.371919840574265*x_30 + 1.99511981010437) - 0.576393862424965*std::sin(0.360239863395691*x_31 + 5.18207979202271) - 0.163276566991577*std::sin(0.236399978399277*x_34 - 1.21151983737946) + 0.251128284754138*std::sin(0.145360037684441*x_47 + 5.00600004196167) + 0.104791848066631*std::sin(0.249119967222214*x_49 + 5.13367986679077) + 0.219280134684169*std::sin(0.166880026459694*x_51 + 4.99487972259521) + 0.165667146268365*std::sin(0.261679977178574*x_57 - 7.46247959136963) - 0.0848314969064132*std::sin(0.244319975376129*x_6 + 1.80127990245819) + 0.0413040788446808*std::sin(0.477439850568771*x_7 - 1.2397598028183) - 0.0479436661566996*std::sin(0.457359850406647*x_8 + 4.76743984222412) - 0.0233823261893413*std::sin(0.711519837379456*x_83 - 7.9987998008728) + 0.160062641019497*std::sin(0.334639847278595*x_9 - 4.32807970046997) - 0.147647074586613*std::sin(0.370799839496613*x_91 - 1.18903994560242) - 0.68951278079772*std::sin(0.230719983577728*x_93 - 7.41183996200562) + 0.330259077275059*std::sin(0.277119934558868*x_94 + 1.97791981697083) + 0.0497254566475616*std::sin(0.298399955034256*x_98 - 7.63000011444092) - 4.72698152178132) - 0.0421951003372669*std::sin(-0.0123463249268151*x_10 + 0.0169576679959491*x_100 + 0.0222164824447375*x_101 - 0.00552245238092156*x_103 + 0.00783635518532388*x_104 - 0.00111506567545312*x_105 - 0.00502958221834593*x_106 + 0.00268898333858641*x_107 + 0.00920334693227679*x_109 - 0.0129992564463185*x_11 + 0.0539449851451185*x_110 + 0.00473795398633941*x_111 - 0.0174025974258105*x_112 - 0.000452827966353819*x_113 + 0.0530656219705895*x_114 + 0.00570028590497366*x_115 - 0.0018161059270019*x_116 + 0.0767445035012597*x_117 + 0.0434950902385808*x_119 - 0.0075688125816018*x_12 - 0.000285547207076929*x_16 + 0.018016870988608*x_19 - 0.00520710818095202*x_2 - 0.00933546091500232*x_20 + 0.00131221203903956*x_21 + 0.000516738425674692*x_23 - 0.00878207434367101*x_26 - 0.00413790468448799*x_27 + 0.00322584142754885*x_28 + 0.0055847788257967*x_30 + 0.00606371681263066*x_33 + 0.0162076839401639*x_34 + 0.0120667862802255*x_35 + 0.0190368141989391*x_36 + 0.00252480138013195*x_37 + 0.030751779404896*x_38 - 0.00239439640481573*x_39 + 0.0164379173547812*x_40 + 0.0178959776396435*x_41 - 0.00138951693820985*x_42 - 0.0061474074146432*x_43 + 0.000651560629281188*x_45 - 0.00911136694733829*x_46 + 0.015616953519099*x_47 + 0.0219441251749089*x_48 + 0.0161386574597588*x_49 + 0.0346170329086681*x_50 - 0.00307166231214353*x_51 - 0.142523921966148*x_53 + 0.000767355796936281*x_54 - 0.00299187177081079*x_55 - 0.00356579390253828*x_56 - 0.00291457518704617*x_57 - 0.00109491424956457*x_58 + 0.00957786843361915*x_59 + 0.0256973789212695*x_61 + 0.00613873590448944*x_62 - 0.00119650973089997*x_63 - 0.00253308178073095*x_64 - 0.0114213348569203*x_65 + 0.00126320950880294*x_66 + 0.00547270164671614*x_67 + 1.67155087503356e-5*x_68 - 0.00473689640491579*x_69 + 0.00350837939922052*x_70 + 0.00504670401636444*x_72 + 0.00928199561756361*x_73 + 0.00731076564074926*x_74 + 0.00223032628032263*x_75 + 0.00956303717016309*x_76 + 0.000552407277663616*x_77 + 0.0021170964338138*x_78 - 0.00965291574202182*x_79 - 0.0100303307486261*x_8 - 0.000530774487898157*x_80 + 0.0408282088201677*x_81 + 0.00999458105892641*x_82 - 0.00431820813271199*x_83 + 0.00491970794063274*x_84 + 0.00173073479301984*x_85 + 0.00080397892646436*x_86 + 0.00441963213433047*x_87 - 0.00547007145634394*x_88 - 0.00518010325969202*x_89 - 0.0086839989706845*x_9 + 0.00487428708225154*x_90 + 0.00376930947864685*x_92 - 0.000294537522376153*x_94 - 0.00554344259787735*x_95 + 0.013362317462961*x_96 + 0.00739450854393983*x_97 + 0.0033693931533917*x_98 - 0.00441198540094409*x_99 - 0.0184615150870096*std::exp(0.314239859580994*x_22) + 0.0166202660398541*std::exp(0.315199851989746*x_25) + 2.48689205018216*std::sin(0.330479830503464*x_1 - 4.24128007888794) + 0.214963883628451*std::sin(0.204479992389679*x_102 - 1.18623995780945) - 0.120410436114516*std::sin(0.176640018820763*x_108 + 5.21304035186768) + 0.606675659609717*std::sin(0.230959981679916*x_118 + 5.17176008224487) + 0.748054244942121*std::sin(0.270239949226379*x_120 - 7.43232011795044) + 0.652986469903173*std::sin(0.305919945240021*x_13 - 7.44199991226196) + 1.34455608125193*std::sin(0.307679921388626*x_14 + 5.12720012664795) - 0.377257569325762*std::sin(0.332079827785492*x_15 + 8.26583957672119) + 0.0238893266123096*std::sin(0.491839855909348*x_17 + 1.9327198266983) - 0.264537952904492*std::sin(0.5204798579216*x_18 - 4.33296012878418) + 0.300726944025252*std::sin(0.164080023765564*x_24 - 1.23895978927612) - 0.339134081423232*std::sin(0.148480042815208*x_29 + 1.75919997692108) - 0.870709332413576*std::sin(0.346959829330444*x_3 - 7.38855981826782) + 0.966259899736706*std::sin(0.415039867162704*x_31 - 7.40055990219116) - 1.26112474559074*std::sin(0.309279918670654*x_32 - 1.13791990280151) + 0.473512746140365*std::sin(0.292799949645996*x_4 + 2.00839972496033) - 0.22199501703833*std::sin(0.110400065779686*x_44 + 1.74895989894867) + 1.17830239476846*std::sin(0.358079850673676*x_5 + 2.00535988807678) - 0.988709895725322*std::sin(0.246079966425896*x_52 - 7.42615985870361) + 0.395391403325625*std::sin(0.391679853200912*x_6 + 2.00623965263367) - 0.0347355099444699*std::sin(0.633199870586395*x_60 - 4.6450400352478) - 0.496169159304554*std::sin(0.348879843950272*x_7 - 1.14639985561371) - 0.0080715843489409*std::sin(1.14047980308533*x_71 + 8.39352035522461) - 0.54813320000234*std::sin(0.359119862318039*x_91 + 2.01399970054626) + 0.385868534465304*std::sin(0.223199993371964*x_93 + 5.19488000869751) - 8.42300216525734) - 0.436427402949286);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.5296640887812e-5*x_1 - 0.000715049508228976*x_10 + 0.00137304280629457*x_100 + 0.00191330199110548*x_101 - 0.000128059527700718*x_102 - 0.000511753382499122*x_103 + 2.89886213257717e-5*x_104 - 0.00101682611321268*x_105 - 0.000608043352378558*x_106 + 0.000121712961111137*x_107 - 0.000532425396585711*x_108 + 0.000132924658442397*x_109 - 0.00148951518723295*x_11 + 0.0049010243601517*x_110 - 0.000351528102219285*x_111 - 0.0019602247654778*x_112 + 0.00181172860834591*x_113 + 0.00447986975112234*x_114 + 0.000215745047273986*x_115 - 0.00116112792895132*x_116 + 0.00670436506061675*x_117 - 0.000438735661155856*x_118 + 0.00176241607528856*x_119 - 0.000880759380390144*x_12 + 0.00028185234285407*x_120 - 9.91292198622125e-5*x_13 + 0.000265501546417707*x_14 + 0.000172916459809605*x_15 - 3.86886463004924e-5*x_16 + 5.02849624433804e-5*x_17 + 5.15082383138635e-5*x_18 + 0.00171357680955566*x_19 - 0.00129283555089096*x_2 - 0.00072019938534288*x_20 + 1.61378618219184e-6*x_21 - 4.28693633263513e-5*x_22 - 2.87394454358942e-5*x_23 - 0.000477847395873551*x_24 + 5.50204084468245e-5*x_25 - 0.000817202038548796*x_26 - 0.000305191249535045*x_27 + 0.000151096190295545*x_28 - 7.2772508898399e-5*x_29 + 7.88143211058962e-5*x_3 + 0.00052980460008356*x_30 + 4.50228880069706e-5*x_31 - 0.00043213244193952*x_32 + 0.000988952681121034*x_33 + 0.00153267816329565*x_34 + 0.000872195418560316*x_35 + 0.00215674045175708*x_36 - 0.000206261502366499*x_37 + 0.00284819315592447*x_38 - 7.13394951388135e-6*x_39 - 0.000153824347472097*x_4 + 0.00141865323534211*x_40 + 0.00158671877819231*x_41 - 0.000109505821128962*x_42 - 0.000626315509777896*x_43 - 0.000131837888364065*x_44 - 0.000474455017025262*x_45 - 0.00109821424624875*x_46 + 0.00118775078591545*x_47 + 0.00167613278818306*x_48 + 0.0012552967400351*x_49 - 0.000238570263969464*x_5 + 0.00307499356667464*x_50 - 0.000102666772151145*x_51 - 0.00093028566837435*x_52 - 0.0144759393196621*x_53 + 0.000267639416153521*x_54 - 0.000804219961995375*x_55 - 0.0012313138141814*x_56 - 0.00054153283494265*x_57 - 0.000162751752445268*x_58 + 0.000574722872488853*x_59 + 0.000383886975919779*x_6 - 0.00019332238182593*x_60 + 0.00243183373386619*x_61 + 0.000332454708828472*x_62 + 0.000114442206505015*x_63 + 0.000351636211873175*x_64 - 0.000982852379839418*x_65 + 0.000152011486555844*x_66 + 0.000584730475874909*x_67 - 0.00030039926122123*x_68 - 0.000405990194439137*x_69 - 1.48568557006707e-5*x_7 + 0.000218207718188809*x_70 - 8.13992895854527e-5*x_71 + 0.000453077480783786*x_72 + 0.000723710180432943*x_73 + 0.000639315790151517*x_74 + 0.000105582003838436*x_75 + 0.000921118729801592*x_76 - 7.47442187062225e-5*x_77 + 0.000183733311423698*x_78 - 0.00122375953651954*x_79 - 0.000935957305310781*x_8 + 0.000138809590954848*x_80 + 0.00375961810951169*x_81 + 0.000636071084250022*x_82 - 0.000684701691502368*x_83 + 0.000473554136965039*x_84 + 0.000377221490061221*x_85 + 6.41227528418979e-5*x_86 + 0.00050920299802672*x_87 - 0.000201729210426051*x_88 - 0.000370493042189743*x_89 - 0.000791743865524468*x_9 + 0.000445525528881772*x_90 - 0.000170648213166455*x_91 - 0.000343464733764722*x_92 - 0.000540538710972633*x_93 - 5.90815053788408e-5*x_94 - 0.00062504732986609*x_95 + 0.00112844257780693*x_96 + 0.000545518975988066*x_97 + 0.000322366729030457*x_98 + 0.000304448263364624*x_99 - 2.15666141895613e-6*std::pow(-2.20879983901978*x_24 - 4.21663999557495, 2) - 8.40338855349999e-7*std::pow(-2.59999990463257*x_29 - 1.67199993133545, 2) + 4.14389476110867e-6*std::pow(-3.28383994102478*x_60 - 6.97959995269775, 2) - 4.58597591236763e-6*std::pow(-1.86063992977142*x_63 - 6.39928007125854, 2) + 6.7530833689282e-6*std::pow(-2.94071984291077*x_67 - 7.45536041259766, 2) - 7.96927720179072e-6*std::pow(-2.85191988945007*x_7 - 7.12160015106201, 2) + 8.06852530355204e-8*std::pow(-7.80344009399414*x_8 - 3.79063987731934, 2) - 0.00169104284735859*std::exp(0.314239859580994*x_22) + 4.93850687112259e-5*std::exp(0.570879817008972*x_22) + 0.00152238761962005*std::exp(0.315199851989746*x_25) + 4.46859436449284e-5*std::exp(0.524799883365631*x_26) + 0.000103745730025771*std::exp(0.263759851455688*x_30) + 0.000856291357367633*std::exp(0.199119850993156*x_9) + 0.019020252592579*std::sin(0.286159932613373*x_1 + 8.28927993774414) + 0.0013343259221493*std::sin(0.304639935493469*x_1 - 4.26056003570557) + 0.00892484219693705*std::sin(0.320719838142395*x_1 - 4.25712013244629) - 0.00427178204506691*std::sin(0.327199846506119*x_1 - 4.26064014434814) + 0.22779500998662*std::sin(0.330479830503464*x_1 - 4.24128007888794) - 0.0211427086427604*std::sin(0.337999850511551*x_1 - 4.2513599395752) + 0.000104355242665363*std::sin(0.226879999041557*x_100 + 1.99143981933594) + 0.00225162944326335*std::sin(0.230639979243279*x_100 - 1.18671989440918) + 0.000350799150750595*std::sin(0.246559977531433*x_100 + 8.17727947235107) - 0.000176559324832109*std::sin(0.361279845237732*x_100 - 1.57759976387024) + 0.0196903198972062*std::sin(0.204479992389679*x_102 - 1.18623995780945) + 0.000846151077765609*std::sin(0.217280000448227*x_105 + 1.96951985359192) - 0.0011870743356431*std::sin(0.240399971604347*x_107 + 1.78271985054016) + 0.000333137662837835*std::sin(0.242399975657463*x_107 - 4.23863983154297) - 0.00137878349211405*std::sin(0.291279941797256*x_107 + 4.76240015029907) - 0.0110293876628824*std::sin(0.176640018820763*x_108 + 5.21304035186768) + 0.00698110897474078*std::sin(0.245119974017143*x_108 - 1.19279980659485) + 0.00737991259187077*std::sin(0.250159978866577*x_11 - 7.40879964828491) - 0.00130153003962305*std::sin(0.290879935026169*x_11 - 1.21463990211487) - 0.00278415321605029*std::sin(0.297759920358658*x_11 - 4.26287984848022) - 0.00251994696830764*std::sin(0.268799960613251*x_112 - 7.42655992507935) - 0.0169723101609009*std::sin(0.276559948921204*x_112 - 7.4332799911499) + 0.000492838980236532*std::sin(0.28263995051384*x_112 + 1.95687973499298) - 0.0173635808711948*std::sin(0.282719939947128*x_113 - 7.41199970245361) - 0.00187203747188389*std::sin(0.284879922866821*x_113 + 5.15928030014038) + 0.00148840923185365*std::sin(0.217600002884865*x_114 - 4.22240018844604) + 0.00102307349799396*std::sin(0.243279978632927*x_116 + 1.97951984405518) + 0.0555704409965491*std::sin(0.230959981679916*x_118 + 5.17176008224487) - 0.00217536782481143*std::sin(0.239599987864494*x_119 + 5.15503978729248) - 0.00132383640437367*std::sin(0.25231996178627*x_119 - 7.4456000328064) + 0.0165024889700325*std::sin(0.300079941749573*x_12 + 5.13064002990723) + 1.46078158852089e-5*std::sin(0.7290398478508*x_12 - 4.77559995651245) - 0.00455003104239651*std::sin(0.251999974250793*x_120 + 5.16232013702393) - 0.00206061891162865*std::sin(0.263759940862656*x_120 + 5.16455984115601) + 0.0685204748572187*std::sin(0.270239949226379*x_120 - 7.43232011795044) + 0.00796537296824883*std::sin(0.277679949998856*x_13 + 5.16752004623413) + 0.0598124311112842*std::sin(0.305919945240021*x_13 - 7.44199991226196) - 0.000141582744560764*std::sin(0.679199814796448*x_13 - 8.21103954315186) + 0.123159011238111*std::sin(0.307679921388626*x_14 + 5.12720012664795) - 0.0345561407724935*std::sin(0.332079827785492*x_15 + 8.26583957672119) - 0.0215048751643037*std::sin(0.316639930009842*x_16 + 1.99335980415344) - 0.00637581857796464*std::sin(0.336479842662811*x_17 - 1.1490398645401) - 0.0102924457418207*std::sin(0.339519828557968*x_17 + 1.9948798418045) + 0.0201113784994567*std::sin(0.343039840459824*x_17 + 2.01007986068726) + 0.00218822099408218*std::sin(0.491839855909348*x_17 + 1.9327198266983) + 0.000116465899671517*std::sin(0.651039838790894*x_17 - 7.63024044036865) - 0.017853604059647*std::sin(0.336559861898422*x_18 - 1.15495979785919) + 0.00966345347696327*std::sin(0.382799834012985*x_18 + 1.98943984508514) - 0.0242312188899815*std::sin(0.5204798579216*x_18 - 4.33296012878418) - 0.00322062722148797*std::sin(0.291519939899445*x_19 - 1.18711996078491) - 0.0243800525780358*std::sin(0.312159925699234*x_19 - 7.41224002838135) - 0.00139197321898936*std::sin(0.346159845590591*x_19 + 5.02383995056152) + 0.00692426155021959*std::sin(0.353759855031967*x_2 - 7.41535997390747) + 0.000760888569007073*std::sin(0.37391984462738*x_2 - 7.3951997756958) - 0.00233079883141618*std::sin(0.379999846220016*x_2 - 4.21528005599976) + 0.0102689851003377*std::sin(0.188640013337135*x_20 + 1.97775971889496) - 0.000601002730178317*std::sin(0.359199851751328*x_20 - 1.15183985233307) + 0.0112677715220177*std::sin(0.293759942054749*x_21 + 2.00879979133606) - 0.00305599341044475*std::sin(0.315199911594391*x_21 + 1.99711978435516) + 0.0772935106598923*std::sin(0.0824000835418701*x_22 - 4.54647970199585) + 0.0044030090712285*std::sin(0.349839836359024*x_22 + 1.99503982067108) + 0.0167762460246362*std::sin(0.192320004105568*x_23 - 4.40319967269897) - 0.0231787754296893*std::sin(0.316399931907654*x_23 - 1.16175985336304) + 0.000792553155050473*std::sin(0.334399849176407*x_23 - 1.15567982196808) + 0.00163633572423066*std::sin(0.487599849700928*x_23 + 1.95495975017548) + 0.0275460678771562*std::sin(0.164080023765564*x_24 - 1.23895978927612) + 0.000353206882482102*std::sin(0.224479988217354*x_24 - 1.19663989543915) - 0.00162603653135961*std::sin(0.402799844741821*x_24 - 1.20791983604431) + 0.00115804492141449*std::sin(0.343439847230911*x_25 - 1.15567982196808) + 0.00174708400346756*std::sin(0.406719863414764*x_25 + 5.00271987915039) - 0.000665700325532558*std::sin(0.784239888191223*x_26 - 4.60712003707886) - 0.00944723248917236*std::sin(0.172560006380081*x_27 - 1.21567988395691) - 0.000328386188648958*std::sin(0.669999837875366*x_27 - 1.0791198015213) - 0.00650716098063925*std::sin(0.299039930105209*x_28 - 7.40471982955933) + 0.00415913894438583*std::sin(0.112880066037178*x_29 + 4.91199970245361) - 0.031064095226389*std::sin(0.148480042815208*x_29 + 1.75919997692108) - 0.00203458005658542*std::sin(0.176480010151863*x_29 + 4.97535943984985) + 0.0014340757107209*std::sin(0.333439826965332*x_29 - 4.36719989776611) - 0.00357180806802281*std::sin(0.205520004034042*x_3 - 7.59863996505737) - 0.079755468701613*std::sin(0.346959829330444*x_3 - 7.38855981826782) - 0.016220839547817*std::sin(0.348559856414795*x_3 - 7.39647960662842) + 0.00603885823649384*std::sin(0.367279827594757*x_3 - 4.18991994857788) - 0.0021060535879187*std::sin(0.415519863367081*x_3 - 1.18831992149353) + 0.0038513813786801*std::sin(0.418559849262238*x_3 + 2.00775980949402) + 0.000545298236199596*std::sin(0.213119998574257*x_30 + 1.35935986042023) - 0.0106214135830855*std::sin(0.239439979195595*x_30 - 1.17183983325958) + 0.00385303792278685*std::sin(0.332799851894379*x_30 - 1.1497597694397) - 0.00210229844010037*std::sin(0.358399868011475*x_30 + 2.01263976097107) + 0.00783044898505561*std::sin(0.371919840574265*x_30 + 1.99511981010437) + 0.00276539043288217*std::sin(0.347519844770432*x_31 + 5.17407989501953) + 0.00770052135967503*std::sin(0.360239863395691*x_31 + 5.18207979202271) + 0.000882813076506698*std::sin(0.368399828672409*x_31 + 5.17768001556396) - 0.004968153934598*std::sin(0.392399847507477*x_31 - 7.40079975128174) - 0.0037104167577298*std::sin(0.412079870700836*x_31 + 5.19288015365601) + 0.0885077353856475*std::sin(0.415039867162704*x_31 - 7.40055990219116) - 0.000341326272364549*std::sin(0.893119871616364*x_31 - 7.76775979995728) - 0.11551684521054*std::sin(0.309279918670654*x_32 - 1.13791990280151) - 0.00493655845180755*std::sin(0.311119943857193*x_32 + 2.01319980621338) - 0.00153585335699647*std::sin(0.238159984350204*x_33 - 1.21919989585876) + 0.00169856334152601*std::sin(0.238559976220131*x_33 + 1.97919988632202) + 0.00218134642579878*std::sin(0.236399978399277*x_34 - 1.21151983737946) + 0.00129123702008878*std::sin(0.228479996323586*x_35 + 8.19143962860107) - 0.000664834580526938*std::sin(0.244719967246056*x_39 - 7.60920000076294) + 0.043372948467118*std::sin(0.292799949645996*x_4 + 2.00839972496033) - 1.63448407112776e-5*std::sin(0.525999844074249*x_43 + 1.85743987560272) - 0.000859985123860891*std::sin(0.553839862346649*x_43 - 1.35583984851837) - 0.0203343595551411*std::sin(0.110400065779686*x_44 + 1.74895989894867) + 0.0022038380721525*std::sin(0.297119915485382*x_44 + 5.08871984481812) - 1.55954509142994e-5*std::sin(0.539039850234985*x_44 + 1.61799991130829) - 1.18983228712286e-5*std::sin(0.612319827079773*x_45 - 4.80423974990845) - 0.003355030035594*std::sin(0.145360037684441*x_47 + 5.00600004196167) + 0.000632107161814261*std::sin(0.159360021352768*x_48 - 7.40391969680786) - 0.00145289206321917*std::sin(0.191600009799004*x_49 - 4.60928010940552) - 0.00140000079279463*std::sin(0.249119967222214*x_49 + 5.13367986679077) + 0.00180548972615981*std::sin(0.3572798371315*x_5 + 2.02199983596802) + 0.107930461140796*std::sin(0.358079850673676*x_5 + 2.00535988807678) - 0.000789900719400885*std::sin(0.5065598487854*x_5 - 1.25143992900848) + 1.04746284485155e-5*std::sin(0.773199856281281*x_5 - 4.792799949646) - 0.0029295443115647*std::sin(0.166880026459694*x_51 + 4.99487972259521) - 0.0905641161843443*std::sin(0.246079966425896*x_52 - 7.42615985870361) - 0.000169556502097742*std::sin(0.562079846858978*x_52 - 1.55815982818604) + 0.000513167427150198*std::sin(0.225839987397194*x_53 + 1.98495984077454) - 0.000578219984414856*std::sin(0.230319991707802*x_54 - 7.43327951431274) - 0.00221328414752513*std::sin(0.261679977178574*x_57 - 7.46247959136963) + 0.000505573656948766*std::sin(0.537599861621857*x_58 - 4.48936033248901) - 0.000501257346340404*std::sin(0.559359848499298*x_58 - 1.54263985157013) + 0.00300937771676441*std::sin(0.143680036067963*x_59 + 1.79303991794586) + 6.53642498383064e-5*std::sin(0.184000000357628*x_59 - 4.97879981994629) - 0.00133597585025978*std::sin(0.491999864578247*x_59 + 1.80147981643677) + 0.00113333398650837*std::sin(0.244319975376129*x_6 + 1.80127990245819) + 0.00396289831488333*std::sin(0.299999952316284*x_6 + 2.0194399356842) + 0.00123478547229459*std::sin(0.365199834108353*x_6 + 2.01551985740662) + 0.0362171685990902*std::sin(0.391679853200912*x_6 + 2.00623965263367) + 0.000664588649417233*std::sin(0.417759865522385*x_60 + 8.17088031768799) - 0.000119643505283943*std::sin(0.464879840612411*x_60 - 4.32456016540527) - 0.00318171262564906*std::sin(0.633199870586395*x_60 - 4.6450400352478) - 1.73561698655759e-5*std::sin(0.972639799118042*x_64 + 7.79016017913818) + 1.58604874482039e-5*std::sin(1.046719789505*x_64 + 7.78560018539429) + 1.0974939666184e-5*std::sin(0.970799803733826*x_65 + 2.00151968002319) - 0.00144254517406289*std::sin(0.154000028967857*x_66 + 2.06791973114014) - 0.000117303591054466*std::sin(1.28911983966827*x_67 + 5.21824026107788) + 0.00109145283928802*std::sin(0.221599996089935*x_68 - 0.957519829273224) + 0.0218243594183012*std::sin(0.330159842967987*x_7 - 1.14079988002777) - 0.0454482367220381*std::sin(0.348879843950272*x_7 - 1.14639985561371) - 0.0067290031518214*std::sin(0.377519845962524*x_7 - 1.16439986228943) - 0.000551815281389419*std::sin(0.477439850568771*x_7 - 1.2397598028183) - 0.000739343164187668*std::sin(1.14047980308533*x_71 + 8.39352035522461) - 0.00011136353357784*std::sin(1.30631983280182*x_73 - 1.80255997180939) - 0.00289709871394755*std::sin(0.397839844226837*x_8 + 1.97663986682892) + 0.000640519008560498*std::sin(0.457359850406647*x_8 + 4.76743984222412) + 0.000312383795175043*std::sin(0.711519837379456*x_83 - 7.9987998008728) - 9.10105755648457e-5*std::sin(0.690639853477478*x_84 + 7.39631986618042) - 0.00213840893598531*std::sin(0.334639847278595*x_9 - 4.32807970046997) - 0.00227608873723654*std::sin(0.335679858922958*x_91 + 8.40248012542725) - 0.000123490250885946*std::sin(0.352079838514328*x_91 - 7.38151979446411) - 0.0502080529628879*std::sin(0.359119862318039*x_91 + 2.01399970054626) + 0.00197253913628506*std::sin(0.370799839496613*x_91 - 1.18903994560242) + 0.00114093861556765*std::sin(0.283599942922592*x_92 + 2.00687980651855) - 0.00524113922075682*std::sin(0.290319919586182*x_92 - 1.16183984279633) + 0.0353448902840829*std::sin(0.223199993371964*x_93 + 5.19488000869751) + 0.00921177035779589*std::sin(0.230719983577728*x_93 - 7.41183996200562) + 6.1482479606844e-5*std::sin(0.234959989786148*x_93 - 1.20967984199524) - 0.00441220360689429*std::sin(0.277119934558868*x_94 + 1.97791981697083) - 0.00572976931635694*std::sin(0.295439928770065*x_94 + 1.95231986045837) - 0.00339382708963618*std::sin(0.297759920358658*x_96 + 1.9340797662735) - 5.02711417125801e-5*std::sin(0.317119926214218*x_97 - 1.40455985069275) - 0.00066432341840557*std::sin(0.298399955034256*x_98 - 7.63000011444092) - 1.47838294506073*std::sin(0.0016097383477674*x_10 - 0.000404865886634017*x_100 - 0.000872737302379388*x_101 - 0.00177613203662854*x_102 + 0.000566722279163739*x_103 - 0.00332383242039858*x_105 - 0.00111050965569554*x_106 + 0.000907939946018164*x_107 + 0.00590245151675613*x_108 + 0.00311276648287515*x_11 + 0.00299995342565418*x_110 - 0.000679633061213334*x_111 + 0.00153634727691417*x_112 - 0.00468873727018117*x_113 - 0.0111120337531324*x_114 + 0.000741136822840769*x_115 + 0.000185473907683756*x_116 - 0.0228456277910345*x_117 - 0.0210445422725552*x_118 - 0.00285296373517314*x_119 + 0.00532313028009392*x_12 - 0.0130860750327747*x_120 + 0.00195248471457664*x_13 + 0.00240013077996511*x_14 + 0.00170250168740099*x_15 - 9.04739183000061e-5*x_16 - 6.96360946880517e-6*x_17 + 0.00406528282651835*x_18 + 0.000573467443237271*x_19 - 0.00073868919342751*x_2 + 0.00144134980249084*x_20 - 0.000204292532542694*x_21 + 0.00113943179765688*x_22 + 0.00142468115566862*x_23 + 0.000929085043872711*x_24 - 0.00184476950263213*x_25 - 0.00183903434241818*x_26 - 0.000934029003988861*x_27 - 0.000978475833602384*x_28 - 0.00224139194645377*x_29 - 0.000994132473376*x_3 - 0.0031654570428239*x_30 + 0.00314545986179965*x_33 + 0.00267935402538189*x_34 + 0.00255424514352855*x_35 + 0.00282006708851923*x_36 + 0.000276654607759253*x_37 + 0.00101837972635239*x_38 + 0.00226678657925961*x_39 + 0.00201379922025442*x_4 - 0.000219497793946764*x_41 + 0.00360498284770277*x_42 - 0.000332015261675486*x_43 + 0.00127724904286553*x_44 - 0.000798098035533104*x_45 + 0.00203065514045095*x_46 + 0.00238310897153068*x_48 + 0.00212729411780711*x_49 + 0.000295227873181763*x_5 - 0.0026711443527112*x_50 + 0.0011086531167896*x_51 + 0.000390254640863703*x_52 - 0.000141406110993181*x_53 - 0.000328709235389741*x_54 + 0.00379155630320017*x_55 - 0.00139619094143949*x_56 + 0.000745880402218767*x_57 - 0.00162568420441846*x_58 - 0.000443005868584842*x_59 - 0.000350760272053342*x_6 + 0.000714694798625146*x_62 + 0.00147298733245379*x_63 - 0.00184653318875814*x_64 + 0.000381022713102334*x_65 + 0.0001878448741304*x_66 - 0.00134884382556367*x_67 + 0.000959380276008798*x_68 + 0.00125709447645723*x_69 + 0.000401552368588759*x_7 + 5.24412196842978e-5*x_70 + 0.00219354713647284*x_71 + 2.50512606573529e-5*x_72 - 0.000640601154833823*x_73 - 0.00149948675852343*x_74 - 0.000228035027443875*x_75 + 0.000154852749626044*x_76 + 0.00102669601609118*x_78 - 0.00114534958372962*x_79 + 0.00239005477089416*x_8 + 0.000466667985558207*x_80 - 0.000276863152553217*x_81 - 0.000621284886459747*x_82 - 0.00197629470381511*x_83 + 0.000711857245085168*x_84 + 0.00142708288325955*x_85 - 0.000889608655061566*x_86 - 0.00126464914152182*x_87 - 0.000360034088196568*x_88 - 0.000557664114654279*x_89 - 0.00079477388071894*x_90 - 0.00228215152193013*x_91 - 0.000899694319070896*x_93 + 0.00326630183095755*x_94 - 0.000912425153757639*x_96 - 0.00096406018495989*x_97 + 0.000704227070925213*x_98 + 0.00225311853643866*x_99 - 3.41468866074928e-5*std::pow(-5.24360036849976*x_61 - 6.25415992736816, 2) + 0.000129204704083631*std::pow(-2.31807994842529*x_9 - 5.01559972763062, 2) - 0.290009975639215*std::sin(0.315999925136566*x_1 - 4.27895975112915) + 0.020985704202372*std::sin(0.187440007925034*x_104 + 8.40816020965576) + 0.0203359738398206*std::sin(0.243519976735115*x_109 + 5.15503978729248) - 0.610793869934682*std::sin(0.369359821081161*x_31 + 5.17328023910522) + 0.0162636326590431*std::sin(0.240959972143173*x_32 + 2.01855969429016) + 0.0151226902992767*std::sin(0.302479922771454*x_40 - 1.62287986278534) + 0.0194146456009445*std::sin(0.236719980835915*x_47 - 1.83063983917236) - 0.015524203010401*std::sin(0.206640005111694*x_60 + 2.00567984580994) - 0.00196776863970557*std::sin(1.2772798538208*x_77 - 1.16463983058929) - 0.334912182139767*std::sin(0.312399923801422*x_92 + 1.98295974731445) + 0.0137243001453404*std::sin(0.265919953584671*x_95 - 7.80767965316772) + 7.51484619269691) + 1.12439577332539);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.77623410917702e-5*x_1 + 0.00316299447135119*x_10 - 0.00408450492233755*x_100 - 0.00558474408943943*x_101 - 6.95537719358631e-5*x_102 + 0.000845888113326502*x_103 - 0.00281946835265117*x_104 - 0.000258030210113951*x_105 + 0.00132284412848436*x_106 - 0.000545962830268957*x_107 - 0.000684087176706199*x_108 - 0.0033235652026324*x_109 + 0.00305138957824018*x_11 - 0.0128410310930682*x_110 - 0.00178440793413931*x_111 + 0.00344650734646376*x_112 + 0.000860143788510511*x_113 - 0.0132382524626224*x_114 - 0.00238337020992413*x_115 + 0.000518499507811523*x_116 - 0.019740654848101*x_117 + 5.38911119329492e-5*x_118 - 0.0107946128732766*x_119 + 0.0027112186946352*x_12 - 0.000188172512902954*x_120 + 0.00021260287735208*x_13 + 0.000247954262210924*x_14 - 0.000896568754417487*x_15 + 0.000209759096584942*x_16 - 0.000179494535740781*x_17 - 0.00245660978000873*x_18 - 0.00424453613322721*x_19 - 0.00266409725970593*x_2 + 0.00256554817648375*x_20 - 8.5659679448455e-5*x_21 + 2.96637792571915e-5*x_22 - 0.000441392164733503*x_23 - 0.000333646901326297*x_24 - 3.4290408563116e-5*x_25 + 0.00228731034460059*x_26 + 0.00111796681928917*x_27 - 0.00104082997549282*x_28 - 0.000510030956133067*x_29 - 0.000184499236539789*x_3 - 0.00120840103910234*x_30 + 0.000298486116673758*x_31 + 9.33746121610182e-6*x_32 + 0.000525228424698523*x_33 - 0.00387339187495417*x_34 - 0.00278317845288108*x_35 - 0.00498083710384161*x_36 - 0.00104034055370521*x_37 - 0.00637225275234706*x_38 + 0.000773673500645439*x_39 + 7.28729089570132e-5*x_4 - 0.00410134585626029*x_40 - 0.00511667298653456*x_41 + 0.00101921525463418*x_42 + 0.00133918854368297*x_43 + 0.000190272159588067*x_44 - 0.000200959162685535*x_45 + 0.0022470848890625*x_46 - 0.00420066664800896*x_47 - 0.00601917126803296*x_48 - 0.0045166666258678*x_49 + 9.85426402330211e-5*x_5 - 0.00823505398210479*x_50 + 0.00303047638979068*x_51 - 0.000998081203494313*x_52 + 0.0330828710190879*x_53 - 0.000929730397249226*x_54 + 0.000444033923524299*x_55 + 4.99924948693446e-5*x_56 - 0.00235558096860861*x_57 - 0.000203401600829609*x_58 - 0.00327933627825391*x_59 - 0.000139138193081972*x_6 - 0.00100479148133265*x_60 - 0.00602913214976784*x_61 - 0.00194653618883883*x_62 - 0.000451357093719783*x_63 + 0.00180747519247178*x_64 + 0.00297917950024178*x_65 - 0.00101013966141851*x_66 - 0.00121739708185182*x_67 - 5.16970722265024e-5*x_68 + 0.00133819262590726*x_69 + 0.000230920267928887*x_7 - 0.000676538390652976*x_70 - 0.000861362340580665*x_71 - 0.00124639023241248*x_72 - 0.00215520767229861*x_73 - 0.00138003066106758*x_74 - 0.000565806113253018*x_75 - 0.0021104340615625*x_76 + 1.72515839692041e-5*x_77 - 0.000784848574830563*x_78 + 0.00203534100782635*x_79 + 0.00243052342103736*x_8 + 0.000282137174947149*x_80 - 0.00988617092486668*x_81 - 0.00263961403759694*x_82 + 0.000905568742448744*x_83 - 0.00119525572243998*x_84 - 0.000224636855024774*x_85 - 0.00074464302446411*x_86 - 0.000569526451124629*x_87 + 0.00248274759354915*x_88 + 0.00215673981444457*x_89 + 0.00200901146855565*x_9 - 0.00103811434784781*x_90 - 0.000294354612711762*x_91 - 0.002766716212777*x_92 - 0.00109426023405896*x_93 + 8.86627038654312e-5*x_94 - 4.61775628760068e-5*x_95 - 0.00257282673061047*x_96 - 0.00205311569991159*x_97 + 0.000355416604311022*x_98 + 0.000521448462167716*x_99 - 8.5180658655154e-8*std::pow(-2.20879983901978*x_24 - 4.21663999557495, 2) + 1.34800333109076e-5*std::pow(-2.59999990463257*x_29 - 1.67199993133545, 2) + 1.07423267742103e-6*std::pow(-3.28383994102478*x_60 - 6.97959995269775, 2) - 2.03200986865616e-8*std::pow(-5.24360036849976*x_61 - 6.25415992736816, 2) - 1.58392657927391e-6*std::pow(-1.86063992977142*x_63 - 6.39928007125854, 2) + 1.75061946464835e-6*std::pow(-2.94071984291077*x_67 - 7.45536041259766, 2) - 2.06589657293797e-6*std::pow(-2.85191988945007*x_7 - 7.12160015106201, 2) + 3.68743107924472e-7*std::pow(-7.80344009399414*x_8 - 3.79063987731934, 2) + 7.68870195378594e-8*std::pow(-2.31807994842529*x_9 - 5.01559972763062, 2) + 0.00449749646144724*std::exp(0.314239859580994*x_22) + 0.000190532073035309*std::exp(0.570879817008972*x_22) - 0.0040489411270017*std::exp(0.315199851989746*x_25) - 0.00011979865256524*std::exp(0.524799883365631*x_26) - 8.18998170271634e-5*std::exp(0.263759851455688*x_30) + 0.00330364970018533*std::exp(0.199119850993156*x_9) + 0.00075123412019281*std::sin(0.286159932613373*x_1 + 8.28927993774414) + 0.00609805967022146*std::sin(0.304639935493469*x_1 - 4.26056003570557) - 0.000172578876452622*std::sin(0.315999925136566*x_1 - 4.27895975112915) + 0.00231361018594276*std::sin(0.320719838142395*x_1 - 4.25712013244629) + 0.0685244576016369*std::sin(0.327199846506119*x_1 - 4.26064014434814) - 0.605843461004223*std::sin(0.330479830503464*x_1 - 4.24128007888794) - 0.00730237114564849*std::sin(0.337999850511551*x_1 - 4.2513599395752) - 8.23809835642917e-5*std::sin(0.226879999041557*x_100 + 1.99143981933594) + 8.8931566790555e-5*std::sin(0.230639979243279*x_100 - 1.18671989440918) + 0.00160320212478101*std::sin(0.246559977531433*x_100 + 8.17727947235107) - 0.000681181884562799*std::sin(0.361279845237732*x_100 - 1.57759976387024) - 0.0523683620440342*std::sin(0.204479992389679*x_102 - 1.18623995780945) + 1.24881540534246e-5*std::sin(0.187440007925034*x_104 + 8.40816020965576) + 0.00386703104285455*std::sin(0.217280000448227*x_105 + 1.96951985359192) - 4.68853260386375e-5*std::sin(0.240399971604347*x_107 + 1.78271985054016) - 0.000262988304429475*std::sin(0.242399975657463*x_107 - 4.23863983154297) - 0.000476210922594237*std::sin(0.291279941797256*x_107 + 4.76240015029907) + 0.0293337522838205*std::sin(0.176640018820763*x_108 + 5.21304035186768) + 0.00241116924057083*std::sin(0.245119974017143*x_108 - 1.19279980659485) + 1.21015130914399e-5*std::sin(0.243519976735115*x_109 + 5.15503978729248) + 0.00254890996602454*std::sin(0.250159978866577*x_11 - 7.40879964828491) - 5.14059300454408e-5*std::sin(0.290879935026169*x_11 - 1.21463990211487) - 0.000721743320244911*std::sin(0.297759920358658*x_11 - 4.26287984848022) - 0.011516516859525*std::sin(0.268799960613251*x_112 - 7.42655992507935) - 0.00439977635466947*std::sin(0.276559948921204*x_112 - 7.4332799911499) - 0.000389061046610779*std::sin(0.28263995051384*x_112 + 1.95687973499298) - 0.00450120648428092*std::sin(0.282719939947128*x_113 - 7.41199970245361) - 0.00855547810241905*std::sin(0.284879922866821*x_113 + 5.15928030014038) + 0.00680224235989658*std::sin(0.217600002884865*x_114 - 4.22240018844604) + 0.00467559172330257*std::sin(0.243279978632927*x_116 + 1.97951984405518) - 0.147795108878187*std::sin(0.230959981679916*x_118 + 5.17176008224487) - 0.00994174105454846*std::sin(0.239599987864494*x_119 + 5.15503978729248) - 0.00510748088576798*std::sin(0.25231996178627*x_119 - 7.4456000328064) + 0.00569970959361497*std::sin(0.300079941749573*x_12 + 5.13064002990723) - 1.15318235060654e-5*std::sin(0.7290398478508*x_12 - 4.77559995651245) - 0.00117951644788264*std::sin(0.251999974250793*x_120 + 5.16232013702393) + 0.0016267109189282*std::sin(0.263759940862656*x_120 + 5.16455984115601) - 0.182237010545528*std::sin(0.270239949226379*x_120 - 7.43232011795044) + 0.00275111910732335*std::sin(0.277679949998856*x_13 + 5.16752004623413) - 0.159077103039551*std::sin(0.305919945240021*x_13 - 7.44199991226196) - 3.67028651870096e-5*std::sin(0.679199814796448*x_13 - 8.21103954315186) - 0.327553626511563*std::sin(0.307679921388626*x_14 + 5.12720012664795) + 0.0919054896144842*std::sin(0.332079827785492*x_15 + 8.26583957672119) - 0.000849368108823908*std::sin(0.316639930009842*x_16 + 1.99335980415344) - 0.00165282012613787*std::sin(0.336479842662811*x_17 - 1.1490398645401) - 0.000406515969430693*std::sin(0.339519828557968*x_17 + 1.9948798418045) + 0.00694616534404809*std::sin(0.343039840459824*x_17 + 2.01007986068726) - 0.00581979113842186*std::sin(0.491839855909348*x_17 + 1.9327198266983) + 0.000449336001375092*std::sin(0.651039838790894*x_17 - 7.63024044036865) - 0.00462823647709585*std::sin(0.336559861898422*x_18 - 1.15495979785919) + 0.00333761038047772*std::sin(0.382799834012985*x_18 + 1.98943984508514) + 0.0644453340638127*std::sin(0.5204798579216*x_18 - 4.33296012878418) - 0.0147187254973944*std::sin(0.291519939899445*x_19 - 1.18711996078491) - 0.00632010479666764*std::sin(0.312159925699234*x_19 - 7.41224002838135) - 5.49781224728536e-5*std::sin(0.346159845590591*x_19 + 5.02383995056152) + 0.000273484356127512*std::sin(0.353759855031967*x_2 - 7.41535997390747) - 0.012205556354802*std::sin(0.37391984462738*x_2 - 7.3951997756958) - 0.0106520829111705*std::sin(0.379999846220016*x_2 - 4.21528005599976) + 0.00266205586644316*std::sin(0.188640013337135*x_20 + 1.97775971889496) - 2.37375268830625e-5*std::sin(0.359199851751328*x_20 - 1.15183985233307) + 0.00292097388289541*std::sin(0.293759942054749*x_21 + 2.00879979133606) - 0.0139663255126437*std::sin(0.315199911594391*x_21 + 1.99711978435516) + 0.0200369989321911*std::sin(0.0824000835418701*x_22 - 4.54647970199585) + 0.00152073260522261*std::sin(0.349839836359024*x_22 + 1.99503982067108) + 0.00434895013581311*std::sin(0.192320004105568*x_23 - 4.40319967269897) - 0.000915481373463102*std::sin(0.316399931907654*x_23 - 1.16175985336304) - 0.0127134939229909*std::sin(0.334399849176407*x_23 - 1.15567982196808) + 0.000565165560341171*std::sin(0.487599849700928*x_23 + 1.95495975017548) - 0.0732615042828804*std::sin(0.164080023765564*x_24 - 1.23895978927612) - 0.00566585789909421*std::sin(0.224479988217354*x_24 - 1.19663989543915) - 0.000421521702978649*std::sin(0.402799844741821*x_24 - 1.20791983604431) + 0.00529243036829223*std::sin(0.343439847230911*x_25 - 1.15567982196808) + 0.000452901155777008*std::sin(0.406719863414764*x_25 + 5.00271987915039) - 0.000172571236549831*std::sin(0.784239888191223*x_26 - 4.60712003707886) - 0.00326293092814234*std::sin(0.172560006380081*x_27 - 1.21567988395691) - 0.00126694369193471*std::sin(0.669999837875366*x_27 - 1.0791198015213) - 0.000257010327830808*std::sin(0.299039930105209*x_28 - 7.40471982955933) + 0.00107818446692365*std::sin(0.112880066037178*x_29 + 4.91199970245361) + 0.0826180475420672*std::sin(0.148480042815208*x_29 + 1.75919997692108) - 8.0358867545593e-5*std::sin(0.176480010151863*x_29 + 4.97535943984985) + 0.000495308016942734*std::sin(0.333439826965332*x_29 - 4.36719989776611) - 0.000925929147660018*std::sin(0.205520004034042*x_3 - 7.59863996505737) + 0.212117592896514*std::sin(0.346959829330444*x_3 - 7.38855981826782) - 0.00560243215160286*std::sin(0.348559856414795*x_3 - 7.39647960662842) + 0.0232984626445194*std::sin(0.367279827594757*x_3 - 4.18991994857788) - 8.31818245576983e-5*std::sin(0.415519863367081*x_3 - 1.18831992149353) + 0.0176013619087459*std::sin(0.418559849262238*x_3 + 2.00775980949402) + 2.15373922465111e-5*std::sin(0.213119998574257*x_30 + 1.35935986042023) - 0.00275341682381464*std::sin(0.239439979195595*x_30 - 1.17183983325958) + 0.0176089325514515*std::sin(0.332799851894379*x_30 - 1.1497597694397) + 0.0337233638806563*std::sin(0.358399868011475*x_30 + 2.01263976097107) + 0.00270451840831294*std::sin(0.371919840574265*x_30 + 1.99511981010437) + 0.000716879394889537*std::sin(0.347519844770432*x_31 + 5.17407989501953) + 0.00265964337557078*std::sin(0.360239863395691*x_31 + 5.18207979202271) - 0.000696917641016411*std::sin(0.368399828672409*x_31 + 5.17768001556396) - 0.000363470668845581*std::sin(0.369359821081161*x_31 + 5.17328023910522) - 0.0191675883626402*std::sin(0.392399847507477*x_31 - 7.40079975128174) - 0.00014654861469239*std::sin(0.412079870700836*x_31 + 5.19288015365601) - 0.235395115700015*std::sin(0.415039867162704*x_31 - 7.40055990219116) + 0.000915062415136661*std::sin(0.893119871616364*x_31 - 7.76775979995728) + 9.67814795042618e-6*std::sin(0.240959972143173*x_32 + 2.01855969429016) + 0.307228526694916*std::sin(0.309279918670654*x_32 - 1.13791990280151) - 0.00127971695919996*std::sin(0.311119943857193*x_32 + 2.01319980621338) - 0.00701906877488245*std::sin(0.238159984350204*x_33 - 1.21919989585876) + 0.000440323017674446*std::sin(0.238559976220131*x_33 + 1.97919988632202) + 0.000753403996978922*std::sin(0.236399978399277*x_34 - 1.21151983737946) + 0.00498170950527653*std::sin(0.228479996323586*x_35 + 8.19143962860107) + 0.00178235660767886*std::sin(0.244719967246056*x_39 - 7.60920000076294) - 0.115354665647944*std::sin(0.292799949645996*x_4 + 2.00839972496033) + 8.99919699326795e-6*std::sin(0.302479922771454*x_40 - 1.62287986278534) + 0.00026219065778856*std::sin(0.525999844074249*x_43 + 1.85743987560272) - 3.3966434712576e-5*std::sin(0.553839862346649*x_43 - 1.35583984851837) + 0.0540812495010957*std::sin(0.110400065779686*x_44 + 1.74895989894867) + 0.00850260711343112*std::sin(0.297119915485382*x_44 + 5.08871984481812) + 1.23114905646714e-5*std::sin(0.539039850234985*x_44 + 1.61799991130829) + 9.39287299671684e-6*std::sin(0.612319827079773*x_45 - 4.80423974990845) - 0.00115877652852653*std::sin(0.145360037684441*x_47 + 5.00600004196167) + 1.15532499085655e-5*std::sin(0.236719980835915*x_47 - 1.83063983917236) - 0.0101397496296546*std::sin(0.159360021352768*x_48 - 7.40391969680786) - 0.000376637009637312*std::sin(0.191600009799004*x_49 - 4.60928010940552) - 0.000483539056699302*std::sin(0.249119967222214*x_49 + 5.13367986679077) - 0.0289621995891158*std::sin(0.3572798371315*x_5 + 2.02199983596802) - 0.287051784537168*std::sin(0.358079850673676*x_5 + 2.00535988807678) - 0.000204768029502706*std::sin(0.5065598487854*x_5 - 1.25143992900848) - 8.26896830498797e-6*std::sin(0.773199856281281*x_5 - 4.792799949646) - 0.00101182020771941*std::sin(0.166880026459694*x_51 + 4.99487972259521) + 0.240864264740191*std::sin(0.246079966425896*x_52 - 7.42615985870361) - 0.000774897384591441*std::sin(0.562079846858978*x_52 - 1.55815982818604) + 0.00234524829326203*std::sin(0.225839987397194*x_53 + 1.98495984077454) - 0.00264254775309819*std::sin(0.230319991707802*x_54 - 7.43327951431274) - 0.000764434802044294*std::sin(0.261679977178574*x_57 - 7.46247959136963) + 1.99684089116015e-5*std::sin(0.537599861621857*x_58 - 4.48936033248901) - 0.00193389629324754*std::sin(0.559359848499298*x_58 - 1.54263985157013) + 0.0116104521039382*std::sin(0.143680036067963*x_59 + 1.79303991794586) - 5.16003897273198e-5*std::sin(0.184000000357628*x_59 - 4.97879981994629) - 0.000346328513953486*std::sin(0.491999864578247*x_59 + 1.80147981643677) + 0.000391436383166323*std::sin(0.244319975376129*x_6 + 1.80127990245819) + 0.00102731249526362*std::sin(0.299999952316284*x_6 + 2.0194399356842) - 0.019807425531244*std::sin(0.365199834108353*x_6 + 2.01551985740662) - 0.0963231581461555*std::sin(0.391679853200912*x_6 + 2.00623965263367) - 9.2381288176459e-6*std::sin(0.206640005111694*x_60 + 2.00567984580994) + 0.00303726486387237*std::sin(0.417759865522385*x_60 + 8.17088031768799) + 0.00191922392543611*std::sin(0.464879840612411*x_60 - 4.32456016540527) + 0.00846208083819432*std::sin(0.633199870586395*x_60 - 4.6450400352478) + 0.000278413578579905*std::sin(0.972639799118042*x_64 + 7.79016017913818) + 7.24846885250903e-5*std::sin(1.046719789505*x_64 + 7.78560018539429) - 8.66392814741723e-6*std::sin(0.970799803733826*x_65 + 2.00151968002319) - 5.69755395939555e-5*std::sin(0.154000028967857*x_66 + 2.06791973114014) - 0.000452567890687433*std::sin(1.28911983966827*x_67 + 5.21824026107788) + 0.00421092402049344*std::sin(0.221599996089935*x_68 - 0.957519829273224) + 0.000861986630649476*std::sin(0.330159842967987*x_7 - 1.14079988002777) + 0.120874100946443*std::sin(0.348879843950272*x_7 - 1.14639985561371) - 0.0259611043061325*std::sin(0.377519845962524*x_7 - 1.16439986228943) - 0.000190588635384037*std::sin(0.477439850568771*x_7 - 1.2397598028183) + 0.00196635660055758*std::sin(1.14047980308533*x_71 + 8.39352035522461) - 2.88690600845237e-5*std::sin(1.30631983280182*x_73 - 1.80255997180939) - 1.17097799898291e-6*std::sin(1.2772798538208*x_77 - 1.16463983058929) - 0.000114425368059163*std::sin(0.397839844226837*x_8 + 1.97663986682892) + 0.000221225558436343*std::sin(0.457359850406647*x_8 + 4.76743984222412) + 0.000107892628650279*std::sin(0.711519837379456*x_83 - 7.9987998008728) + 0.000243990468423125*std::sin(0.690639853477478*x_84 + 7.39631986618042) - 0.000738574038718687*std::sin(0.334639847278595*x_9 - 4.32807970046997) - 0.00059003643654196*std::sin(0.335679858922958*x_91 + 8.40248012542725) + 9.74867008954019e-5*std::sin(0.352079838514328*x_91 - 7.38151979446411) + 0.133533305137395*std::sin(0.359119862318039*x_91 + 2.01399970054626) + 0.000681285123673246*std::sin(0.370799839496613*x_91 - 1.18903994560242) - 0.0183020104873612*std::sin(0.283599942922592*x_92 + 2.00687980651855) - 0.00135867422857612*std::sin(0.290319919586182*x_92 - 1.16183984279633) - 0.000199299241264311*std::sin(0.312399923801422*x_92 + 1.98295974731445) - 0.0940032473045878*std::sin(0.223199993371964*x_93 + 5.19488000869751) + 0.00318160587641368*std::sin(0.230719983577728*x_93 - 7.41183996200562) - 4.85360103873769e-5*std::sin(0.234959989786148*x_93 - 1.20967984199524) - 0.0015239082584976*std::sin(0.277119934558868*x_94 + 1.97791981697083) - 0.0221059695642669*std::sin(0.295439928770065*x_94 + 1.95231986045837) + 8.16704423342992e-6*std::sin(0.265919953584671*x_95 - 7.80767965316772) - 0.000879790673117501*std::sin(0.297759920358658*x_96 + 1.9340797662735) + 0.000806408820142793*std::sin(0.317119926214218*x_97 - 1.40455985069275) - 0.00022944724083896*std::sin(0.298399955034256*x_98 - 7.63000011444092) + 0.111085837841274);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
