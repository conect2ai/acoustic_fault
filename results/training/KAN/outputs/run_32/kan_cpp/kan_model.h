
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.90704717416109e-5*x_1 + 4.02393796542262e-7*x_10 + 4.73358532309916e-6*x_100 + 2.92915204543453e-7*x_101 - 7.50741181864087e-7*x_102 + 1.93718913121751e-6*x_103 - 6.91984856679575e-7*x_104 - 2.1711044532729e-6*x_105 - 3.36180275797461e-7*x_106 + 2.29575880745942e-6*x_107 - 1.09758584572026e-6*x_108 - 3.60934365684326e-6*x_109 + 3.32607725241809e-7*x_11 - 1.41777398847798e-6*x_110 - 1.29356838169844e-6*x_111 - 7.52660997377251e-7*x_112 - 5.46931129811571e-7*x_113 + 1.33224360710938e-6*x_114 - 2.89875097937968e-6*x_115 + 9.02488763408354e-8*x_116 - 2.10717154997783e-6*x_117 - 2.68031396581289e-6*x_118 - 3.55483715065089e-6*x_119 + 4.2273369077134e-6*x_12 + 1.46242517091122e-7*x_120 - 1.44585028430402e-7*x_13 - 1.13523726934528e-6*x_14 + 3.81494234629598e-7*x_15 + 5.91006955030391e-7*x_16 + 3.35658348229639e-8*x_17 + 3.06689763154564e-7*x_18 - 3.50802485819045e-7*x_19 - 6.2530532219618e-7*x_2 + 4.46217061048637e-6*x_20 - 8.23530642977629e-7*x_21 + 8.5349934072519e-7*x_22 - 2.40283634921541e-5*x_23 - 3.62912622888371e-7*x_24 - 1.8184739768534e-6*x_25 + 3.48693120862435e-7*x_26 + 5.98289430736802e-7*x_27 + 6.43596744921882e-7*x_28 + 5.84555665482597e-6*x_29 + 2.09686902010628e-6*x_3 + 2.57018642482063e-6*x_30 - 1.08832932398522e-5*x_31 + 1.4483770100264e-7*x_32 + 1.32048959137803e-6*x_33 - 4.16747325410052e-6*x_34 + 9.76418037080011e-6*x_35 + 6.52974262529147e-7*x_36 - 5.11922091216654e-6*x_37 - 1.90400763444005e-6*x_38 + 4.44505789806815e-6*x_39 - 4.10832244105892e-7*x_4 + 2.13830182133375e-6*x_40 - 7.92844141098507e-6*x_41 - 1.30237497452726e-6*x_42 + 8.88264114902146e-7*x_43 - 2.5378315432387e-7*x_44 - 2.02996590720681e-6*x_45 + 2.40662932664116e-6*x_46 - 5.14350347619938e-7*x_47 - 2.27711014726453e-7*x_48 + 7.13319333167975e-7*x_49 + 4.56334782246465e-8*x_5 + 1.53495536547324e-6*x_50 - 5.58413515642002e-7*x_51 - 1.76800873906843e-6*x_52 - 2.5090721880283e-6*x_53 - 2.70869516011194e-6*x_54 + 2.90870791344122e-6*x_55 + 4.5711909734054e-7*x_56 - 3.89561868699719e-7*x_57 - 2.0694712656962e-7*x_58 + 1.49270854091556e-8*x_59 - 3.00628376925456e-7*x_6 - 1.24085140683579e-6*x_60 - 2.8195311096291e-6*x_61 + 1.77058271238881e-6*x_62 - 3.19933461518679e-6*x_63 + 2.5281932121071e-6*x_64 + 6.45596827027383e-7*x_65 + 1.61426853666661e-8*x_66 - 2.70445464736221e-6*x_67 + 3.64773929246762e-8*x_68 - 3.93957133630544e-7*x_69 + 2.92346596997463e-7*x_7 - 8.53609865861516e-7*x_70 - 8.03527501051966e-7*x_71 - 1.31562942640724e-6*x_72 - 2.22972708297851e-6*x_73 - 2.24533871545668e-6*x_74 + 5.87426989563374e-7*x_75 - 5.67124845130262e-7*x_76 - 2.27206586473427e-6*x_77 + 1.28675188040333e-7*x_78 + 2.82146368014332e-7*x_79 - 1.07058029132963e-6*x_8 - 3.41133348006359e-6*x_80 - 3.81781382130938e-7*x_81 - 1.42472662777169e-6*x_82 + 1.53444953781953e-7*x_83 - 1.46769226119154e-6*x_84 + 1.62373619708704e-7*x_85 - 3.0457898041965e-7*x_86 + 5.90898457809157e-7*x_87 - 6.4211469084401e-7*x_88 - 3.10553684333035e-8*x_89 - 1.64747909507158e-6*x_9 - 2.1262337717543e-6*x_90 + 9.5554106521532e-6*x_91 - 1.62141712154152e-6*x_92 + 2.48164244776082e-6*x_93 - 4.53931396344543e-7*x_94 + 1.11701513893026e-6*x_95 + 5.38347595944216e-7*x_96 + 1.87138623447751e-6*x_97 + 3.87247448997418e-7*x_98 - 4.06985155148605e-6*x_99 - 3.61317998795031e-9*std::pow(-4.92423963546753*x_52 - 7.67727994918823, 2) - 5.53413785978292e-5*std::sin(0.327519834041595*x_32 - 7.75679969787598) - 8.59352206421783e-6*std::sin(0.206960007548332*x_36 - 7.58568000793457) - 8.58522848931967e-5*std::sin(0.263199955224991*x_91 + 1.55311989784241) + 1.24984053376158e-5*std::sin(0.178000003099442*x_92 + 1.79367983341217) + 0.0679049723852476);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.678347660247e-5*x_1 + 4.12147855994591e-6*x_10 + 2.21822658918084e-6*x_100 + 6.89849889701302e-6*x_101 + 1.24412832375534e-6*x_102 + 2.65928874710507e-6*x_103 + 2.79497435270537e-6*x_104 - 3.16396847137021e-6*x_105 + 4.2234749522809e-7*x_106 + 9.87967725539708e-7*x_107 + 1.14852022109025e-6*x_108 - 4.2994118591361e-6*x_109 + 5.3612587246983e-7*x_11 + 4.31019805487883e-6*x_110 - 3.65218364838234e-6*x_111 + 1.47432369590331e-6*x_112 + 2.75587014846457e-6*x_113 + 3.28606731700826e-6*x_114 + 1.77335750078397e-6*x_115 + 4.0417098807305e-6*x_116 + 2.46073515871683e-7*x_117 + 7.1560576446754e-7*x_118 + 1.09754404178991e-6*x_119 - 2.05176186109938e-6*x_12 - 2.49167581275398e-6*x_120 + 2.15418765010953e-6*x_13 - 3.74555545043239e-7*x_14 + 1.8309346663426e-6*x_15 + 2.46620642277147e-6*x_16 + 1.5368613360325e-7*x_17 + 3.577848489459e-6*x_18 - 3.38720845246344e-6*x_19 - 1.55450146622552e-7*x_2 - 1.48780915843685e-6*x_20 - 1.00728769222611e-6*x_21 + 1.98570526999475e-6*x_22 + 1.22699235939326e-5*x_23 - 7.6421905396779e-7*x_24 + 4.35483561218083e-7*x_25 - 9.97897398613199e-7*x_26 + 5.17264393270704e-6*x_27 + 2.13957034221711e-6*x_28 - 4.38517829069257e-6*x_29 + 3.84210932263593e-6*x_3 + 1.7132880993756e-6*x_30 + 4.44030513732031e-5*x_31 + 2.58744720081854e-6*x_32 - 5.40805562973851e-6*x_33 - 1.29349559477689e-5*x_34 + 1.26257235387325e-5*x_35 + 2.97688812468169e-6*x_36 - 1.22795907445068e-6*x_37 + 2.02153425182748e-6*x_38 + 6.91001309108479e-6*x_39 - 1.68076819209977e-6*x_4 - 1.43082294728263e-6*x_40 - 1.88472464589584e-6*x_41 + 2.57867017834145e-6*x_42 + 6.12505214910117e-7*x_43 + 6.64179573484715e-7*x_44 + 1.25279652124024e-6*x_45 - 1.38515681127156e-6*x_46 + 4.58277402007201e-7*x_47 - 2.9941496636075e-6*x_48 + 6.21599457632295e-6*x_49 + 5.83031286041843e-7*x_5 + 2.95380290227057e-6*x_50 - 1.36320063124701e-6*x_51 + 2.31756479625737e-6*x_52 + 2.01287561311884e-6*x_53 - 5.78731630000145e-6*x_54 + 1.91344924741005e-6*x_55 + 1.93126255554686e-6*x_56 + 5.37233608983893e-6*x_57 + 2.65913877161597e-6*x_58 + 4.22151625492581e-6*x_59 + 4.7922447827594e-7*x_6 + 2.02311535635034e-6*x_60 + 4.33289063463606e-6*x_61 + 3.52989264534469e-6*x_62 - 1.38735992840482e-6*x_63 + 8.4869173035679e-7*x_64 + 2.19519714975433e-6*x_65 - 9.71720070933955e-7*x_66 - 5.90722540866807e-6*x_67 - 5.42752909090745e-8*x_68 + 3.58368298656698e-7*x_69 - 1.47957556638906e-7*x_7 - 9.49261634778936e-7*x_70 - 1.77316410689202e-6*x_71 + 8.48709785354786e-7*x_72 + 7.16955878499958e-7*x_73 - 9.82255223913479e-7*x_74 + 2.50649176354358e-6*x_75 - 3.72519294882508e-7*x_76 - 7.85683219414118e-7*x_77 + 3.68665475793324e-6*x_78 + 2.84350287989473e-6*x_79 - 9.24934556069556e-7*x_8 + 1.58398421374956e-6*x_80 - 5.85233610231493e-7*x_81 + 1.76394940484485e-6*x_82 + 6.28432355159984e-6*x_83 + 1.09454495849225e-6*x_84 + 3.1553561256821e-6*x_85 + 2.90070127181566e-7*x_86 + 4.30463269499262e-7*x_87 + 2.03283956805714e-6*x_88 + 1.08067132133195e-6*x_89 + 1.89780030022542e-6*x_9 + 3.2351368749746e-6*x_90 + 2.09736110480048e-5*x_91 - 5.38017914753975e-6*x_92 + 1.5662731322497e-6*x_93 + 4.23790384779882e-6*x_94 - 4.75357148202158e-6*x_95 - 4.43536277217379e-7*x_96 - 6.82270769858167e-7*x_97 + 3.35835148492792e-6*x_98 + 3.0436301339735e-6*x_99 - 2.21859387299309e-9*std::pow(-4.92423963546753*x_52 - 7.67727994918823, 2) - 0.000185582073893385*std::sin(0.327519834041595*x_32 - 7.75679969787598) + 2.99920454671566e-5*std::sin(0.206960007548332*x_36 - 7.58568000793457) - 7.39863800418807e-5*std::sin(0.263199955224991*x_91 + 1.55311989784241) - 3.53794769259504e-5*std::sin(0.178000003099442*x_92 + 1.79367983341217) + 0.0586775963491142);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.40389783826851e-5*x_1 - 7.43445948375708e-6*x_10 - 2.66943310981053e-7*x_100 - 6.50244562581371e-7*x_101 - 9.05005300928117e-6*x_102 - 1.22535168808203e-6*x_103 - 2.19712313545535e-6*x_104 - 3.93018080956552e-6*x_105 - 6.04428354153107e-7*x_106 + 6.90229405958939e-6*x_107 - 5.32826329279505e-6*x_108 - 2.09918940399162e-6*x_109 - 7.23606026723537e-7*x_11 - 2.44264388971403e-6*x_110 - 1.60400369409201e-6*x_111 - 5.54122739984254e-6*x_112 - 6.4883047696594e-6*x_113 - 7.09653754007143e-6*x_114 - 1.80231793096128e-6*x_115 + 1.2021936117643e-6*x_116 - 8.2745316610099e-6*x_117 - 9.34874546891959e-6*x_118 - 9.02007528788636e-6*x_119 - 5.75724902260672e-6*x_12 - 8.28677109413811e-7*x_120 - 2.77075928532511e-6*x_13 - 3.82070119062768e-6*x_14 - 7.36304509844305e-7*x_15 - 1.22899295610227e-6*x_16 - 2.25192924843454e-6*x_17 - 1.32444191562134e-6*x_18 + 3.46381970203331e-7*x_19 - 4.44641284808156e-8*x_2 - 5.21031151912364e-7*x_20 - 1.86444690905643e-7*x_21 + 7.98676105920703e-7*x_22 - 8.75133073993633e-6*x_23 - 1.14239945931759e-6*x_24 - 4.51298252368436e-6*x_25 - 1.59805606434109e-6*x_26 + 1.55633929445719e-6*x_27 - 4.1234726718117e-6*x_28 - 6.60411578626167e-7*x_29 - 5.55390775523162e-6*x_3 - 7.30019655450577e-6*x_30 - 0.000123029662977418*x_31 - 3.29672311143083e-6*x_32 + 1.56349433570487e-5*x_33 - 1.32995767414481e-5*x_34 + 1.81632843333797e-5*x_35 + 3.68801459944883e-7*x_36 - 1.37887313582255e-5*x_37 - 2.58570723657714e-6*x_38 - 1.01844640082874e-6*x_39 - 2.05766509489679e-6*x_4 + 1.90526170293878e-6*x_40 + 2.37598985166778e-6*x_41 - 8.36636325277271e-6*x_42 - 2.65473410435506e-6*x_43 - 2.12653064331992e-6*x_44 - 2.69929460375399e-6*x_45 - 1.32334416337128e-6*x_46 - 6.11472412573373e-7*x_47 + 4.3626093434293e-6*x_48 - 8.49282197109366e-6*x_49 - 6.31365450967262e-7*x_5 + 1.3997545636951e-6*x_50 + 7.39373492410883e-7*x_51 + 1.05908503133191e-7*x_52 - 6.06462154368945e-6*x_53 - 7.60416996827799e-7*x_54 - 2.20487361570445e-6*x_55 - 2.93719563942576e-6*x_56 - 6.10181174986663e-6*x_57 - 4.52158452593548e-6*x_58 - 9.65980571311863e-6*x_59 + 9.16338973948941e-7*x_6 - 7.27707594947905e-6*x_60 - 6.81541927637048e-6*x_61 + 3.86492566043195e-6*x_62 - 1.24877354538445e-6*x_63 - 2.41992255052669e-6*x_64 - 9.470822022102e-7*x_65 - 1.05190640722134e-6*x_66 + 6.35814257135635e-6*x_67 - 1.84177979172854e-6*x_68 - 1.62031350265354e-6*x_69 - 1.71893679500192e-6*x_7 - 2.33527318180671e-6*x_70 + 1.52470138796547e-6*x_71 - 4.95880488651409e-6*x_72 - 2.18662586350926e-8*x_73 + 4.1100108481052e-6*x_74 + 1.5185609052464e-6*x_75 + 2.03753857287029e-6*x_76 - 4.12796656178157e-6*x_77 - 2.62967897440359e-6*x_78 - 4.81862489699322e-6*x_79 + 1.47145179167797e-6*x_8 - 5.08749477623979e-6*x_80 - 3.11853338511031e-6*x_81 - 2.7705872645089e-6*x_82 - 1.16819105306427e-5*x_83 - 5.05665184676895e-6*x_84 - 3.92577241770399e-6*x_85 - 1.95870467721107e-6*x_86 - 9.8067359238317e-7*x_87 - 8.49687518015606e-6*x_88 - 1.13675024200564e-7*x_89 - 1.05663412057495e-6*x_9 - 5.13674287342871e-6*x_90 - 1.53537615296206e-5*x_91 + 3.27135854999332e-6*x_92 - 3.31584329198645e-6*x_93 - 2.41086048910795e-6*x_94 + 9.31850752022541e-6*x_95 - 9.47997853319441e-7*x_96 - 5.69816242143181e-6*x_97 - 3.81124449379426e-6*x_98 - 1.23826611708435e-5*x_99 - 6.90311873830229e-9*std::pow(-4.92423963546753*x_52 - 7.67727994918823, 2) - 0.00036684582038995*std::exp(-0.000401030936375388*x_1 - 0.000149918537063522*x_10 - 0.00244944708079846*x_100 - 0.000623000317820473*x_101 + 7.90104368606832e-5*x_102 - 0.00161896156175337*x_103 - 0.00613479656983895*x_104 + 0.000773975267060467*x_105 + 0.000465599902031458*x_106 + 2.61459615074645e-5*x_107 - 0.00105520047927546*x_108 - 0.00359282403097177*x_109 - 0.000222252983331771*x_11 - 0.000580388933110546*x_110 + 0.00711009294848468*x_111 + 8.81784988070024e-5*x_112 - 0.00126773673450909*x_113 - 0.00218743899870035*x_114 - 0.000120517917535979*x_115 - 0.00768828543153298*x_116 + 0.000132651343807714*x_117 - 0.000946200501180414*x_118 - 0.000821895399323231*x_119 + 0.000857683266347265*x_12 + 0.000128534915724097*x_120 - 0.000110846719978046*x_13 + 0.000117584743618593*x_14 - 0.00196987038354517*x_15 - 0.000885716390117826*x_16 + 0.000602240260092876*x_17 - 0.00396829672513298*x_18 + 0.000383727320188639*x_19 - 0.00024739851786706*x_2 + 0.00183400657253934*x_20 + 0.00100818448868444*x_21 + 0.000376897466234779*x_22 + 0.000774538695631162*x_23 - 0.000137603180700147*x_24 - 0.00112484497249618*x_25 - 0.000415362188180405*x_26 - 0.0093630763110052*x_27 + 0.000125916868131987*x_28 + 0.000809782462825602*x_29 - 9.37863595308077e-5*x_3 + 0.000568594488246147*x_30 - 0.0086015151941084*x_31 + 0.000490892889446766*x_32 + 0.000317481742602698*x_33 - 0.00787617826190821*x_34 - 0.000193553748032706*x_35 - 0.000742447905037615*x_36 - 0.000839895170830963*x_37 + 0.000349228017704763*x_38 + 0.0029312801755397*x_39 + 0.000246077616437217*x_4 + 8.60879018114295e-6*x_40 - 0.000704615363754266*x_41 - 2.95622494833356e-5*x_42 - 0.00348968908526945*x_43 + 0.00012543844538233*x_44 + 8.70423024251845e-5*x_45 - 8.59308627126779e-5*x_46 + 0.000188528453080423*x_47 + 0.00436638162432629*x_48 - 0.000913218250662704*x_49 - 0.000313348061327995*x_5 + 0.000672459410690153*x_50 - 0.000872398750019148*x_51 - 0.00277005634373323*x_52 - 0.000109912837310617*x_53 + 0.00495125212996896*x_54 - 0.000551541926866319*x_55 - 0.00326852100816689*x_56 - 0.00296899002217486*x_57 + 0.00068327598101073*x_58 + 0.00162424729493111*x_59 + 3.58274154950566e-6*x_6 - 0.000498743770891587*x_60 + 8.74385757917741e-5*x_61 - 2.25390880127299e-5*x_62 - 0.00129138982345087*x_63 + 0.000314696425522704*x_64 - 0.000260578838144931*x_65 - 0.000331883577130318*x_66 + 6.24322312190757e-5*x_67 + 0.000605181148265108*x_68 - 0.00206349265702847*x_69 - 0.000845286295688542*x_7 - 0.00116877547803196*x_70 - 0.00133709062773584*x_71 + 0.00109785119353496*x_72 - 1.14842092974242e-5*x_73 - 0.00125238936689552*x_74 - 0.00293119400994861*x_75 + 0.000172407545120042*x_76 + 0.00204753103261141*x_77 - 0.00241177052634098*x_78 - 0.000244756675083237*x_79 + 0.000418346444638487*x_8 - 7.17425338086023e-5*x_80 - 0.000254630421815206*x_81 - 0.00132349973100622*x_82 + 7.65214629995206e-5*x_83 - 0.00119966126415042*x_84 - 4.22953213320048e-5*x_85 + 0.00046226239422191*x_86 + 0.000675449325708383*x_87 + 5.64085133472701e-5*x_88 + 0.00016390113204653*x_89 - 0.00134319676766701*x_9 - 0.000216110860647137*x_90 - 0.00104506659918147*x_91 + 3.22638797801593e-5*x_92 - 0.000522791915524967*x_93 + 0.000149110392441*x_94 - 0.000146014876613954*x_95 + 0.000989381004440789*x_96 + 0.00141992779444462*x_97 - 0.000210141574759524*x_98 - 0.00172747730747594*x_99) + 0.000178174518698677*std::sin(0.327519834041595*x_32 - 7.75679969787598) + 1.88184382973991e-5*std::sin(0.206960007548332*x_36 - 7.58568000793457) + 0.000101106696655967*std::sin(0.263199955224991*x_91 + 1.55311989784241) + 9.30162902544565e-5*std::sin(0.178000003099442*x_92 + 1.79367983341217) + 0.0495862498862274);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.68689531030527e-5*x_1 - 1.65864158151187e-7*x_10 - 7.67147012061186e-6*x_100 - 4.4661166892819e-6*x_101 - 3.92302542654117e-6*x_102 - 1.34451811113845e-6*x_103 - 1.00361685534271e-6*x_104 - 1.50129404237362e-6*x_105 + 3.06442377835704e-7*x_106 + 3.68649074904175e-6*x_107 - 4.33963538741283e-6*x_108 - 5.87441682686872e-6*x_109 - 1.08662217750933e-7*x_11 - 9.63188890598382e-6*x_110 + 1.22114653192332e-6*x_111 - 1.13636471313558e-6*x_112 - 4.74026464338619e-6*x_113 + 6.10056014672344e-7*x_114 - 4.43626340796402e-6*x_115 - 4.22439977227012e-6*x_116 - 3.78982474689118e-6*x_117 - 3.46599026117421e-6*x_118 - 4.27103458547405e-6*x_119 - 2.23631457841468e-6*x_12 + 4.54898666216503e-6*x_120 - 2.58494175315647e-6*x_13 - 3.0928706772956e-6*x_14 - 1.24492221555105e-6*x_15 - 1.08525188095761e-6*x_16 + 3.4674663188268e-6*x_17 - 3.36020089063567e-6*x_18 + 1.87436723383493e-6*x_19 + 1.3265218265925e-6*x_2 + 4.23873918205946e-6*x_20 + 1.50881292902403e-6*x_21 - 4.53685354139546e-7*x_22 - 2.97272152974926e-5*x_23 - 4.09602265964025e-7*x_24 + 2.45322249965772e-6*x_25 - 2.29945415149009e-7*x_26 - 2.63793913049102e-6*x_27 - 1.80996311849743e-6*x_28 + 7.32999095450394e-6*x_29 - 3.17666103849167e-6*x_3 - 7.73969524255486e-7*x_30 - 3.62854596638445e-5*x_31 - 5.13698460669523e-6*x_32 + 1.02752730012125e-5*x_33 + 2.20296532505108e-5*x_34 + 7.80673219964376e-6*x_35 - 2.39965961703988e-6*x_36 - 8.67171480120591e-6*x_37 - 4.45253313220662e-6*x_38 - 5.14672526074959e-6*x_39 - 1.96513130952323e-7*x_4 + 1.03535410305163e-6*x_40 + 2.05019261356809e-6*x_41 - 8.81129582033869e-6*x_42 - 1.29226690590942e-6*x_43 - 5.88540785133139e-7*x_44 - 6.95804753856655e-6*x_45 + 1.20145162830447e-6*x_46 - 1.26054731214274e-6*x_47 + 3.14364788610644e-6*x_48 - 1.0873617425925e-7*x_49 - 6.2473959251892e-7*x_5 - 2.37998758784397e-6*x_50 - 7.05846061626778e-7*x_51 - 9.95789875573142e-7*x_52 - 5.71659631671162e-6*x_53 + 3.13893471236918e-6*x_54 + 3.08934695784159e-6*x_55 - 1.7291405255527e-6*x_56 - 5.95346558754865e-6*x_57 - 2.16427882801534e-6*x_58 - 3.07043922748899e-6*x_59 - 4.0708682055399e-7*x_6 - 4.98679201818621e-6*x_60 - 5.53207230580141e-6*x_61 + 6.97610642350349e-7*x_62 - 1.45962320892812e-6*x_63 + 9.00349383136022e-8*x_64 + 8.79511911814188e-7*x_65 + 8.32320131470021e-7*x_66 - 6.50625782553612e-6*x_67 - 1.71974195263397e-6*x_68 - 3.92957788322573e-7*x_69 - 1.32473224126079e-7*x_7 - 2.24924587162359e-6*x_70 + 2.82817520017535e-6*x_71 - 3.78155437766048e-6*x_72 - 2.5372871094248e-6*x_73 - 1.666717936299e-8*x_74 - 2.56860830700991e-6*x_75 + 1.32351620732534e-6*x_76 - 1.78518046242775e-6*x_77 - 3.42778561745938e-6*x_78 - 2.56700081378283e-6*x_79 + 1.28886281235077e-6*x_8 - 3.95199444485493e-6*x_80 + 1.78605220567244e-6*x_81 - 4.78520305776059e-7*x_82 - 6.20598638602476e-6*x_83 - 3.22054197027838e-6*x_84 - 1.43247237157105e-6*x_85 - 1.37447637090951e-6*x_86 + 5.81507772490822e-7*x_87 - 2.96326377670076e-6*x_88 - 3.12088776139215e-7*x_89 - 5.33986388141069e-6*x_9 - 4.98862858994664e-6*x_90 - 2.04492375963766e-5*x_91 + 1.34052407346873e-6*x_92 + 8.8883109934361e-7*x_93 - 5.12129595218699e-6*x_94 + 5.87569685468446e-6*x_95 - 1.04954404007583e-6*x_96 - 3.68256134703008e-7*x_97 - 6.03116979925854e-6*x_98 - 7.47596877580275e-6*x_99 - 4.88823082964122e-9*std::pow(-4.92423963546753*x_52 - 7.67727994918823, 2) - 0.000135117625796478*std::sin(0.327519834041595*x_32 - 7.75679969787598) - 4.70744643151638e-5*std::sin(0.206960007548332*x_36 - 7.58568000793457) + 0.000139886545300234*std::sin(0.263199955224991*x_91 + 1.55311989784241) + 5.29251344280005e-5*std::sin(0.178000003099442*x_92 + 1.79367983341217) + 0.0303253110393842);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.20363505539246e-5*x_1 + 1.11023680738318e-6*x_10 - 7.92964672306483e-6*x_100 + 6.63236339418142e-6*x_101 + 1.14505909847204e-5*x_102 - 3.09642088073676e-6*x_103 + 5.21844447495603e-6*x_104 + 1.1636499766783e-5*x_105 + 9.53832244865863e-7*x_106 - 8.92286831315074e-6*x_107 + 8.61589496990584e-6*x_108 + 2.38886291069899e-5*x_109 - 1.16325257684649e-6*x_11 + 1.44529399526759e-5*x_110 + 3.86472751567375e-7*x_111 + 3.83320218481887e-6*x_112 + 7.05322235017671e-6*x_113 + 2.08162992490494e-6*x_114 + 5.07349189146548e-6*x_115 - 1.35943780937042e-6*x_116 + 1.39510687278631e-5*x_117 + 1.71969112189673e-5*x_118 + 1.77718510271305e-5*x_119 + 1.41283462682038e-5*x_12 + 4.97757551205992e-6*x_120 + 7.23837906281411e-6*x_13 + 6.85940979545144e-6*x_14 + 2.121666389244e-6*x_15 + 1.89286369831716e-6*x_16 - 1.93922473398098e-6*x_17 + 5.59152643288392e-6*x_18 + 2.70669139872117e-6*x_19 + 3.81601861269502e-6*x_2 - 8.41275019510163e-7*x_20 + 2.26704924193643e-6*x_21 - 2.23363917740313e-6*x_22 + 1.46471278609425e-5*x_23 + 2.86627481775153e-6*x_24 + 1.32927974730779e-6*x_25 - 1.87482847082902e-7*x_26 + 7.61953676405824e-7*x_27 + 5.89474914452882e-6*x_28 + 4.86829156573309e-7*x_29 + 9.34427955096443e-6*x_3 + 1.01567186995359e-5*x_30 + 4.72763825353984e-5*x_31 + 3.65977771665349e-6*x_32 - 2.66693603072351e-5*x_33 + 1.22065089879793e-6*x_34 - 5.95546504348967e-6*x_35 - 6.16874700818343e-6*x_36 + 2.21457368741041e-5*x_37 + 3.25595936003768e-6*x_38 + 2.32584597764296e-6*x_39 + 4.36580491295886e-6*x_4 - 3.85917621653374e-6*x_40 + 6.16540217609303e-6*x_41 + 1.25458210595689e-5*x_42 + 2.74029558651196e-6*x_43 + 2.10165581848257e-6*x_44 + 1.54531636716032e-5*x_45 + 2.18413706456806e-6*x_46 - 7.56836818263139e-7*x_47 - 1.83503258186507e-6*x_48 + 6.23625199767488e-8*x_49 + 1.19524180881406e-6*x_5 - 7.87213264071331e-6*x_50 + 9.31655991935275e-9*x_51 - 6.47904497490126e-7*x_52 + 9.02244268534408e-6*x_53 + 2.84996124704782e-6*x_54 - 5.19016239040645e-6*x_55 + 5.37124907579581e-6*x_56 + 9.12049596249688e-6*x_57 + 7.1844276639537e-6*x_58 + 7.09589549536062e-6*x_59 + 7.22536948661954e-7*x_6 + 9.94112355450443e-6*x_60 + 4.0316764299767e-6*x_61 - 5.1562372547438e-6*x_62 + 1.02782878289708e-5*x_63 + 1.35062852776568e-6*x_64 - 2.5878228629171e-6*x_65 + 1.38171931033392e-6*x_66 + 1.0560984854505e-5*x_67 - 1.79011849698178e-7*x_68 + 3.99504409299562e-6*x_69 + 3.38833282704703e-6*x_7 + 4.12819105797804e-6*x_70 + 5.33578666348922e-7*x_71 + 7.85492633823879e-6*x_72 + 6.39400621368472e-7*x_73 - 1.98303228522765e-6*x_74 + 1.27980922226591e-6*x_75 - 3.02400666324271e-6*x_76 + 5.162647981079e-6*x_77 + 5.53429712521061e-6*x_78 + 6.83164155195233e-6*x_79 + 6.75381887737597e-7*x_8 + 7.48778581003273e-6*x_80 + 2.48904897863351e-6*x_81 + 2.0484636541605e-6*x_82 + 1.36097021438117e-5*x_83 + 9.68122949003342e-6*x_84 + 4.02947072502086e-6*x_85 + 3.90872279641783e-6*x_86 - 8.40801191799087e-7*x_87 + 7.09577339250446e-6*x_88 - 5.2055283583108e-7*x_89 - 1.68878995387789e-6*x_9 + 7.29336944943747e-6*x_90 - 1.35467659453435e-5*x_91 + 1.13052305125852e-6*x_92 + 5.59626775109716e-6*x_93 + 9.53926272822371e-6*x_94 - 1.69704219762685e-5*x_95 + 1.01249327844241e-6*x_96 + 9.09525270601306e-7*x_97 + 4.61939837660495e-6*x_98 + 2.26739939312831e-5*x_99 + 1.38329869564648e-8*std::pow(-4.92423963546753*x_52 - 7.67727994918823, 2) + 0.00030239529533866*std::sin(0.327519834041595*x_32 - 7.75679969787598) + 6.40846246225402e-5*std::sin(0.206960007548332*x_36 - 7.58568000793457) + 3.58862016258286e-5*std::sin(0.263199955224991*x_91 + 1.55311989784241) - 0.000138734935465619*std::sin(0.178000003099442*x_92 + 1.79367983341217) + 0.0578755883600772);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.3914332419612e-5*x_1 - 6.99361551105244e-7*x_10 + 3.11477245987979e-6*x_100 - 2.02883349184487e-6*x_101 + 2.39530199757981e-6*x_102 + 1.84575756252675e-7*x_103 + 1.87271880784566e-7*x_104 + 2.23380166170224e-6*x_105 + 1.58814237833316e-7*x_106 - 2.78965389982185e-6*x_107 - 1.53023816425372e-6*x_108 + 6.15218382456781e-6*x_109 - 1.0947234247839e-6*x_11 + 1.4391381830865e-6*x_110 - 7.58419716430761e-8*x_111 + 8.49888816251537e-7*x_112 + 1.78400062698913e-6*x_113 + 1.57933204302749e-6*x_114 + 1.68872052910213e-7*x_115 - 5.78845049179491e-7*x_116 + 5.33520201760681e-6*x_117 + 5.59253239159963e-6*x_118 + 2.42260409127204e-6*x_119 + 6.53389804266251e-6*x_12 + 3.58568960648467e-6*x_120 + 2.26425453249906e-6*x_13 + 2.95271221346864e-6*x_14 + 2.53316835364123e-7*x_15 + 3.45850733214127e-7*x_16 - 7.34578963738495e-7*x_17 + 6.35759019272777e-7*x_18 + 3.87190352884171e-6*x_19 + 8.10167504167191e-7*x_2 - 5.49195891661491e-7*x_20 + 1.02578147629639e-6*x_21 - 8.83515538909131e-7*x_22 + 5.49831707647738e-6*x_23 + 2.35765943397437e-7*x_24 - 9.1254136317717e-7*x_25 + 6.15089245384649e-7*x_26 - 1.87701148514671e-6*x_27 + 2.02459930908671e-6*x_28 + 2.06840221335417e-7*x_29 + 9.86217349882492e-7*x_3 + 3.23092119624079e-6*x_30 + 4.22392601481405e-5*x_31 - 5.15411787382098e-6*x_32 - 9.65124748270988e-6*x_33 + 6.92659122705064e-6*x_34 - 6.31556061031244e-6*x_35 - 2.41902177726899e-6*x_36 + 1.7618637181104e-6*x_37 - 2.66133206527577e-6*x_38 - 2.21732974641274e-8*x_39 + 2.55987203103621e-6*x_4 - 1.0428166427387e-6*x_40 - 4.16840797305753e-6*x_41 + 4.47229577890871e-6*x_42 + 2.76376460437422e-6*x_43 + 1.13875356962119e-6*x_44 + 1.65660684476114e-6*x_45 + 2.14736680949567e-6*x_46 + 6.27681721102076e-7*x_47 - 8.62566837280059e-7*x_48 + 4.9943093320903e-7*x_49 + 1.03893266817062e-6*x_5 - 2.42626618763696e-6*x_50 + 3.96751244317618e-7*x_51 - 6.74792681862975e-7*x_52 + 2.94987177732088e-6*x_53 + 3.25742826933544e-6*x_54 - 2.55972606190213e-6*x_55 + 1.40057391503181e-6*x_56 + 1.5565099180826e-6*x_57 + 2.27620360319984e-6*x_58 + 2.10337686319976e-6*x_59 - 4.97556542991242e-7*x_6 + 4.46571102594539e-6*x_60 - 1.62228942959267e-6*x_61 - 2.4607610498847e-6*x_62 + 2.41331057409481e-6*x_63 + 1.96861173594328e-9*x_64 - 1.25508647586627e-6*x_65 + 1.61553259204118e-6*x_66 + 4.04400845910937e-6*x_67 + 1.31986835019925e-7*x_68 + 5.19212045779465e-7*x_69 + 1.12031440635272e-6*x_7 + 5.43428458436277e-7*x_70 - 6.90385469346324e-7*x_71 + 2.74808258014451e-6*x_72 + 3.25228108844551e-7*x_73 + 2.73758831890783e-8*x_74 + 8.68178237992852e-7*x_75 - 7.97237734404842e-7*x_76 - 3.08623653518126e-8*x_77 + 1.41751124897151e-6*x_78 + 9.48556387536177e-7*x_79 + 1.0991356432978e-7*x_8 + 1.54355022718714e-6*x_80 + 1.51616578428965e-6*x_81 - 6.11360129063859e-7*x_82 + 4.28769114596512e-6*x_83 + 1.34336591700067e-6*x_84 + 7.63799834572745e-7*x_85 + 9.51796584472863e-7*x_86 - 2.28579698890491e-7*x_87 + 3.52665194103611e-6*x_88 - 6.24213181338525e-7*x_89 + 4.28535306665983e-7*x_9 + 1.94340414736658e-6*x_90 - 2.76169721816128e-5*x_91 + 3.60247869390907e-6*x_92 + 2.81480256471703e-6*x_93 + 2.96168995022127e-8*x_94 - 5.09417047856564e-6*x_95 - 2.65696555318942e-7*x_96 - 3.19727810408058e-7*x_97 + 1.63661112970227e-6*x_98 - 3.98132905474592e-7*x_99 - 3.49086680821849e-9*std::pow(-4.92423963546753*x_52 - 7.67727994918823, 2) + 0.00011812265036046*std::sin(0.327519834041595*x_32 - 7.75679969787598) - 1.44084714890998e-5*std::sin(0.206960007548332*x_36 - 7.58568000793457) - 6.53084245178523e-5*std::sin(0.263199955224991*x_91 + 1.55311989784241) - 4.2251773728348e-5*std::sin(0.178000003099442*x_92 + 1.79367983341217) + 0.0540801580025506);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.64706897539044e-6*x_1 + 9.09280688199368e-7*x_10 + 2.1168740139125e-6*x_100 + 6.0766462822997e-6*x_101 + 3.87030992640606e-6*x_102 + 1.13260223834383e-6*x_103 + 7.04792333072575e-6*x_104 + 1.16074501149512e-6*x_105 - 9.24298831974214e-7*x_106 - 3.35463530096723e-6*x_107 + 6.0649666897761e-6*x_108 + 4.263732291314e-6*x_109 + 3.66428482519591e-7*x_11 + 6.70180315155757e-6*x_110 - 5.3423924998994e-6*x_111 + 5.14998160844624e-7*x_112 + 5.57874247092002e-6*x_113 + 7.36647893354971e-7*x_114 - 2.02559221866517e-6*x_115 + 5.86478723307582e-6*x_116 - 4.69287636473093e-7*x_117 - 4.41970137503004e-7*x_118 + 1.33732283350594e-6*x_119 + 5.3164972649306e-6*x_12 - 3.16904537031894e-6*x_120 + 1.28500324926596e-8*x_13 - 1.01319503312719e-6*x_14 + 1.27056001680835e-6*x_15 + 9.41177137908067e-7*x_16 - 1.69953275726075e-6*x_17 + 4.42211256064177e-6*x_18 - 3.25762738982996e-6*x_19 - 1.28563751142196e-6*x_2 + 5.487324540213e-6*x_20 - 2.90622334852596e-6*x_21 + 2.58008676549452e-7*x_22 - 2.66229243809299e-5*x_23 + 4.70576416214982e-7*x_24 + 1.91624326378162e-8*x_25 + 1.5266917435002e-6*x_26 + 8.02121813830817e-6*x_27 + 7.82932809161143e-7*x_28 + 7.64854670181346e-6*x_29 + 8.01475554613253e-6*x_3 + 4.54910258227143e-6*x_30 + 3.66127879247724e-5*x_31 + 3.188304634438e-6*x_32 + 1.22702710607547e-6*x_33 - 1.7230209348364e-5*x_34 - 5.51572525334676e-6*x_35 + 1.87079096670224e-6*x_36 + 7.79815478476776e-6*x_37 + 2.93083377201292e-6*x_38 - 2.576131759576e-6*x_39 - 7.37225475596428e-7*x_4 + 4.42531766589735e-6*x_40 - 2.80140565683823e-6*x_41 + 5.20907146600196e-6*x_42 + 1.26529380243395e-6*x_43 + 6.96349993735196e-8*x_44 + 4.25754928800688e-6*x_45 + 2.02991658585754e-6*x_46 - 1.19896361864905e-6*x_47 - 5.23233404599726e-6*x_48 + 8.41039844885777e-7*x_49 - 3.18621925004095e-7*x_5 + 1.13585005659211e-6*x_50 + 1.01435720885649e-6*x_51 - 1.13483358993379e-6*x_52 + 7.93863040506497e-8*x_53 - 9.49593884541043e-6*x_54 + 3.73222642459216e-6*x_55 + 3.76447651861009e-6*x_56 + 4.45278163696091e-6*x_57 + 4.88697988373218e-7*x_58 + 7.59579899686319e-7*x_59 + 6.55429691999832e-7*x_6 + 7.36188223186609e-7*x_60 - 4.32070508900708e-6*x_61 - 1.82873562623697e-6*x_62 + 2.01152008106457e-6*x_63 + 4.29941151911144e-6*x_64 + 1.02338545935228e-8*x_65 + 1.32503741499388e-6*x_66 - 4.94987879707221e-7*x_67 - 3.67041836321324e-7*x_68 + 1.90615640455278e-6*x_69 - 3.52959356226141e-7*x_7 + 3.03369043835822e-6*x_70 + 5.38283927595612e-7*x_71 + 6.94629690332116e-7*x_72 - 3.68656205078059e-6*x_73 - 2.88502578004952e-6*x_74 + 4.75295881559915e-7*x_75 - 2.2871437752384e-6*x_76 - 1.66166262723945e-6*x_77 + 3.42865519097789e-6*x_78 + 2.54383329737466e-6*x_79 - 2.73849094805319e-6*x_8 - 9.84279468853284e-7*x_80 - 1.27815934100415e-6*x_81 + 1.94047644417407e-6*x_82 + 2.32210879703611e-6*x_83 + 2.03695619932956e-6*x_84 + 1.88276904707199e-6*x_85 + 8.10878337868171e-7*x_86 - 7.72906114893771e-7*x_87 + 1.18044689535698e-6*x_88 - 7.76014514903391e-7*x_89 - 1.17660244388493e-6*x_9 - 8.13569474642375e-7*x_90 + 2.11069334304728e-5*x_91 - 9.74427170927651e-7*x_92 + 3.90186072056484e-6*x_93 + 4.11317922588093e-6*x_94 - 2.2226534833227e-6*x_95 + 1.17092452995649e-6*x_96 + 1.9990393673853e-6*x_97 + 2.73463392095386e-6*x_98 + 7.58694445571174e-6*x_99 + 5.81114046640156e-9*std::pow(-4.92423963546753*x_52 - 7.67727994918823, 2) + 2.26199050293185e-5*std::sin(0.327519834041595*x_32 - 7.75679969787598) + 5.76863101401933e-5*std::sin(0.206960007548332*x_36 - 7.58568000793457) - 2.02418086841388e-5*std::sin(0.263199955224991*x_91 + 1.55311989784241) - 1.66676426568524e-5*std::sin(0.178000003099442*x_92 + 1.79367983341217) + 0.0476686184785541);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (4.20704269416022e-5*x_1 - 2.05619364355539e-6*x_10 - 1.32210978541413e-5*x_100 + 3.93102360066832e-6*x_101 - 1.40504348608301e-7*x_102 - 3.1755249435987e-6*x_103 - 2.41381251469104e-6*x_104 + 3.74821430879277e-6*x_105 + 9.0791160295071e-7*x_106 - 1.04274332302893e-6*x_107 - 1.78739603965462e-8*x_108 + 4.57608575661886e-6*x_109 - 9.65026722197672e-7*x_11 + 4.17706444219454e-6*x_110 + 4.51528244914179e-6*x_111 - 4.60707262195576e-7*x_112 - 1.03408149451842e-6*x_113 - 4.35624777206549e-6*x_114 + 4.75560730667991e-7*x_115 - 5.51009917610776e-6*x_116 + 1.45897501400258e-6*x_117 + 2.22864939650644e-6*x_118 + 2.54196803553173e-6*x_119 - 6.37008755376276e-7*x_12 + 3.01835001934235e-6*x_120 + 1.00461488728749e-6*x_13 - 7.8665742112373e-7*x_14 - 1.29560846896242e-6*x_15 - 9.28246810188643e-7*x_16 + 3.29078501598103e-7*x_17 - 1.63333128400245e-6*x_18 + 9.07770098391063e-7*x_19 + 2.27811943725585e-6*x_2 + 1.62697903588368e-6*x_20 + 2.4327234251036e-6*x_21 - 6.52444519424471e-7*x_22 + 1.57997570037899e-6*x_23 + 2.03932269962291e-7*x_24 + 3.65547296733226e-7*x_25 - 1.34928717984189e-6*x_26 - 5.35859443371213e-6*x_27 + 1.17201607168036e-7*x_28 + 1.17987996566737e-6*x_29 + 1.33509262054872e-6*x_3 + 6.13302023140948e-7*x_30 - 2.17396489320912e-5*x_31 - 1.77849919124843e-6*x_32 + 2.50723489657353e-6*x_33 - 1.31335390537793e-5*x_34 + 2.95238105251307e-6*x_35 - 3.72135533566161e-6*x_36 + 2.2629172485896e-6*x_37 - 8.11913754422023e-7*x_38 - 2.74795829205234e-6*x_39 + 1.27771473551137e-6*x_4 - 1.4907739776257e-6*x_40 + 9.06725549592197e-6*x_41 + 5.32439289879684e-8*x_42 - 4.78027572636129e-6*x_43 - 3.55420823733118e-7*x_44 + 5.10769099143324e-6*x_45 - 1.08230754952236e-6*x_46 - 6.15946624744e-7*x_47 + 4.85317385540028e-6*x_48 - 2.65837921830352e-6*x_49 - 2.27976988885318e-7*x_5 - 3.47883297926906e-6*x_50 - 5.17320372127224e-7*x_51 - 1.56307987224614e-6*x_52 - 6.40051306505051e-8*x_53 + 5.07652301216177e-6*x_54 - 2.89385163750383e-6*x_55 - 1.68368245178348e-6*x_56 - 2.14524900138776e-6*x_57 + 1.44826935315596e-6*x_58 - 2.06662684475509e-7*x_59 + 1.28491033671366e-6*x_6 - 4.11340720893627e-7*x_60 - 2.91637580984779e-6*x_61 - 1.32665707718659e-6*x_62 + 3.54091580916158e-6*x_63 - 3.14437059089542e-7*x_64 - 1.18161171306262e-6*x_65 + 1.15496236934486e-6*x_66 + 2.87377580220476e-6*x_67 - 1.53037449587526e-6*x_68 - 5.75171991546201e-8*x_69 - 1.28485295199174e-7*x_7 - 3.60678918910713e-7*x_70 + 1.84639553120175e-6*x_71 + 1.23595346896405e-6*x_72 + 3.2958668198036e-8*x_73 + 3.49821025046669e-7*x_74 - 2.36721103737697e-6*x_75 + 5.07571303447895e-7*x_76 + 1.38863342437764e-6*x_77 - 3.01452993774916e-7*x_78 + 4.55954838902929e-7*x_79 + 2.3161616363409e-6*x_8 + 1.36743331977116e-6*x_80 + 5.66804111757635e-7*x_81 + 1.07575015744914e-6*x_82 - 1.14267091451602e-6*x_83 + 4.40992275720642e-7*x_84 + 9.13158292086996e-7*x_85 + 8.96591843740685e-7*x_86 - 2.75225789849992e-7*x_87 - 5.88899320655979e-7*x_88 - 3.7922452457609e-7*x_89 - 4.09253853069903e-6*x_9 + 2.44445578589213e-7*x_90 - 2.20202488977566e-5*x_91 + 6.53699823688883e-7*x_92 - 7.28436749808389e-8*x_93 + 3.20358401024625e-6*x_94 - 2.00790787586558e-6*x_95 - 3.74393866495282e-8*x_96 - 1.36931004813419e-6*x_97 - 1.45592101042238e-6*x_98 + 2.85979914981085e-6*x_99 + 6.71640627107328e-10*std::pow(-4.92423963546753*x_52 - 7.67727994918823, 2) + 9.65350551163438e-5*std::sin(0.327519834041595*x_32 - 7.75679969787598) + 5.44708470961159e-5*std::sin(0.206960007548332*x_36 - 7.58568000793457) + 0.000183137933225733*std::sin(0.263199955224991*x_91 + 1.55311989784241) - 6.80783627590091e-6*std::sin(0.178000003099442*x_92 + 1.79367983341217) + 0.0804615727402634);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.41375957987038e-5*x_1 + 2.58405588545707e-6*x_10 - 3.61200854689704e-6*x_100 - 1.41766884266932e-7*x_101 - 3.34460222521715e-6*x_102 + 1.90616590245812e-6*x_103 + 1.68722160911059e-6*x_104 - 4.67369439034862e-6*x_105 - 4.92998195962822e-8*x_106 + 4.40611097221641e-6*x_107 - 2.02519577650286e-7*x_108 - 6.88458412215459e-6*x_109 + 1.84816126976675e-6*x_11 - 5.49046030108839e-6*x_110 - 3.73129737382983e-6*x_111 - 2.94373475513048e-7*x_112 - 2.25407482787344e-6*x_113 + 2.13157213634188e-6*x_114 + 9.00041942352324e-7*x_115 + 4.8824713739397e-6*x_116 - 5.19754593519973e-6*x_117 - 4.01733430651204e-6*x_118 - 1.38251991585511e-6*x_119 - 9.47914893880727e-6*x_12 - 2.91436541173892e-6*x_120 - 1.73634452583298e-6*x_13 - 2.1348958221819e-6*x_14 + 1.24521195031206e-6*x_15 + 5.16912949322248e-7*x_16 + 1.88072501354281e-6*x_17 + 9.94017935861015e-7*x_18 - 4.27380359445826e-6*x_19 - 1.8607854591693e-7*x_2 - 3.45233543361739e-6*x_20 - 8.17611863867444e-7*x_21 + 8.97989116364991e-7*x_22 + 4.42763897935763e-6*x_23 - 4.69306663341919e-7*x_24 + 3.52320461880301e-6*x_25 - 9.48141325937945e-7*x_26 + 6.59936016383069e-6*x_27 - 1.45167791520646e-6*x_28 - 4.22162938120663e-6*x_29 - 4.17599779679982e-6*x_3 - 4.38912719613396e-6*x_30 - 5.54566795033926e-5*x_31 + 5.43378253132939e-6*x_32 + 6.01573961848443e-6*x_33 + 1.52505657585355e-5*x_34 + 1.16591517991396e-5*x_35 + 2.94080171130567e-6*x_36 - 4.89770357963959e-6*x_37 + 1.57978165470842e-6*x_38 + 5.44805560059213e-7*x_39 - 3.02775326075933e-6*x_4 - 1.3898434562538e-6*x_40 + 6.44986648290627e-6*x_41 - 7.02078532641515e-6*x_42 - 1.72991477936961e-7*x_43 - 1.24047081907676e-6*x_44 - 4.77416123789415e-6*x_45 - 3.6693099817619e-6*x_46 - 3.35062273713756e-7*x_47 - 8.7588635051759e-7*x_48 + 1.86304825552641e-6*x_49 - 7.3078457597377e-7*x_5 + 2.10432765136228e-6*x_50 - 9.21760675212526e-7*x_51 + 4.004666535681e-6*x_52 - 2.55449347108158e-6*x_53 - 4.564111840178e-6*x_54 + 3.06469940131067e-6*x_55 + 1.10183973539033e-7*x_56 + 4.60743524811302e-7*x_57 - 2.53329985908142e-6*x_58 - 1.75157003852071e-6*x_59 - 1.29393954057448e-8*x_6 - 4.0564639821539e-6*x_60 + 6.62857110158193e-6*x_61 + 4.33501748181033e-6*x_62 - 3.44716385769498e-6*x_63 - 1.90483174295062e-6*x_64 + 2.50156257116428e-6*x_65 - 2.57774580703566e-6*x_66 - 7.06676516893678e-6*x_67 - 1.70021831902367e-7*x_68 + 2.19629699445617e-7*x_69 + 2.72818915249558e-7*x_7 - 1.12015731951408e-6*x_70 + 1.41269351235067e-6*x_71 - 4.09488261648553e-6*x_72 + 1.17191207692374e-6*x_73 + 8.54725609718735e-7*x_74 + 1.50055449702625e-6*x_75 + 1.69776750116197e-6*x_76 - 5.67955134463609e-7*x_77 - 3.67313979447762e-7*x_78 - 7.67911317633313e-7*x_79 + 3.54061839168029e-7*x_8 - 6.9115400932169e-7*x_80 - 5.89475875388904e-7*x_81 + 1.6156553676571e-6*x_82 - 3.29559568585771e-6*x_83 - 9.39596924199796e-7*x_84 - 1.08504464187574e-6*x_85 - 1.52100588553204e-6*x_86 + 4.93735427729417e-7*x_87 - 3.080232287567e-6*x_88 + 1.27426817157083e-6*x_89 + 1.12351780005921e-6*x_9 - 6.30347853396593e-7*x_90 + 3.73729910166266e-5*x_91 - 6.98039054544319e-6*x_92 - 4.18574256503803e-6*x_93 - 1.75418285725438e-6*x_94 + 5.35602383435033e-6*x_95 - 1.07981649582239e-6*x_96 + 3.87103898728358e-7*x_97 - 2.96082882901499e-6*x_98 - 1.39285848950664e-8*x_99 + 1.06340196016669e-9*std::pow(-4.92423963546753*x_52 - 7.67727994918823, 2) - 0.000221574356856873*std::sin(0.327519834041595*x_32 - 7.75679969787598) - 2.67381995505937e-5*std::sin(0.206960007548332*x_36 - 7.58568000793457) + 7.16710719521262e-5*std::sin(0.263199955224991*x_91 + 1.55311989784241) + 3.87594732106338e-5*std::sin(0.178000003099442*x_92 + 1.79367983341217) + 0.0523467645504555);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.34562612110105e-5*x_1 - 1.17325031223432e-6*x_10 + 7.31531145423396e-6*x_100 - 2.47849686600431e-5*x_101 - 1.25858645463675e-6*x_102 - 5.91676249228985e-6*x_103 + 1.7649518575724e-6*x_104 - 6.02428799688154e-6*x_105 - 1.34099907126044e-6*x_106 + 2.26455395597467e-6*x_107 - 8.53407512491606e-6*x_108 - 4.79295901768164e-6*x_109 - 8.06804484255951e-7*x_11 - 2.74160947320031e-5*x_110 + 3.04719076149122e-6*x_111 - 3.92815958930023e-7*x_112 - 2.14837946762326e-6*x_113 + 7.06713217907757e-6*x_114 - 3.12436125985691e-6*x_115 - 6.9376210568826e-6*x_116 - 2.3504372350433e-6*x_117 - 3.93153377957234e-6*x_118 - 2.80986037896734e-6*x_119 + 5.48666620056177e-6*x_12 + 5.20565230918698e-7*x_120 - 4.39352622121713e-6*x_13 + 6.0100121977656e-6*x_14 - 2.45067007545517e-6*x_15 - 3.32940380321088e-7*x_16 + 1.8518505067414e-6*x_17 - 6.47884748735671e-6*x_18 + 5.07644338233696e-6*x_19 - 2.68012387312868e-6*x_2 - 4.84359227563706e-6*x_20 - 1.95845799412067e-6*x_21 + 4.81262719591163e-7*x_22 - 1.86568380328719e-5*x_23 - 1.81344177274825e-7*x_24 + 3.8460793245795e-6*x_25 + 1.65247228091023e-6*x_26 - 6.64092362652316e-6*x_27 - 2.52605955813815e-6*x_28 + 2.01206176498635e-6*x_29 - 1.21858190107065e-5*x_3 - 2.06292934670859e-6*x_30 - 9.5038587253639e-5*x_31 - 7.93389340706645e-6*x_32 - 1.26051245451091e-5*x_33 + 0.000110079894761474*x_34 - 4.91043913788305e-6*x_35 + 1.4644523673086e-6*x_36 - 1.19692235987863e-5*x_37 + 3.05838671222104e-6*x_38 - 5.44456385267042e-6*x_39 - 4.36527471855055e-6*x_4 + 5.41418568817983e-6*x_40 - 4.6779080878745e-6*x_41 - 9.74396002148305e-6*x_42 + 7.7012200107194e-6*x_43 + 2.94441173349211e-6*x_44 - 2.10427017405398e-5*x_45 + 1.77641656958216e-6*x_46 - 1.14060481093342e-6*x_47 + 1.31340358866359e-7*x_48 - 4.36780528536871e-6*x_49 - 1.1445012966495e-6*x_5 + 1.54070275878946e-6*x_50 + 5.18906542437687e-7*x_51 + 4.95424177855464e-7*x_52 - 1.44659190996712e-6*x_53 + 2.32086308875115e-6*x_54 + 4.41214616357765e-6*x_55 - 2.88510636138458e-6*x_56 - 4.43895737021722e-6*x_57 - 4.38961838143291e-6*x_58 - 3.17238922646254e-6*x_59 - 4.02295235892548e-6*x_6 - 4.01858076404193e-6*x_60 + 6.24317146001416e-7*x_61 + 1.78177273251387e-6*x_62 + 2.15875344319062e-6*x_63 - 5.99951873451132e-6*x_64 + 1.20662516565758e-6*x_65 - 3.96250744100041e-6*x_66 + 3.0425138115096e-6*x_67 + 3.39797313189042e-7*x_68 - 4.15309801447981e-6*x_69 - 3.32257609069537e-6*x_7 - 2.56829736245584e-6*x_70 - 5.75112258916745e-7*x_71 - 2.97015420443626e-6*x_72 - 3.2936511688996e-6*x_73 + 2.30643381412883e-6*x_74 - 2.10789812747596e-6*x_75 + 6.27296807167155e-7*x_76 + 1.52763785458654e-6*x_77 - 9.19407176974983e-6*x_78 - 6.16810157770159e-6*x_79 - 3.63887729490814e-6*x_8 - 3.77631278369542e-6*x_80 - 1.4045708886829e-6*x_81 - 6.37200653424944e-6*x_82 - 3.71324374997251e-6*x_83 - 4.04679789662282e-6*x_84 - 8.33004069279567e-6*x_85 - 1.58398392204775e-6*x_86 - 6.51487262512118e-7*x_87 - 2.9473351062763e-6*x_88 + 5.53591027916862e-7*x_89 + 1.6786962107783e-6*x_9 - 5.49117762571107e-6*x_90 - 1.37063178688422e-5*x_91 + 1.32598930033398e-5*x_92 + 1.76205195537679e-6*x_93 - 1.54907394834202e-5*x_94 + 5.23496697700386e-6*x_95 - 1.61180123760032e-6*x_96 - 3.65165433406387e-6*x_97 - 1.08418490345031e-5*x_98 - 1.16728918194677e-5*x_99 + 2.14328697455051e-9*std::pow(-4.92423963546753*x_52 - 7.67727994918823, 2) + 0.000105579868294788*std::sin(0.327519834041595*x_32 - 7.75679969787598) - 0.00025898600580315*std::sin(0.206960007548332*x_36 - 7.58568000793457) + 4.85116189490268e-6*std::sin(0.263199955224991*x_91 + 1.55311989784241) + 3.41566737237795e-5*std::sin(0.178000003099442*x_92 + 1.79367983341217) + 0.0798348785749241);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-7.05887357599762e-6*x_1 + 2.34608929089532e-6*x_10 - 1.40248190220438e-6*x_100 + 1.4212410442623e-5*x_101 + 3.63927100321084e-6*x_102 + 2.59547118873429e-6*x_103 + 3.06827902987236e-6*x_104 + 1.37620296291232e-6*x_105 + 7.90078927765062e-7*x_106 - 2.52334769229433e-6*x_107 + 2.83667692180046e-6*x_108 + 2.86571793752042e-6*x_109 - 7.60785470162566e-7*x_11 + 1.45195107404884e-5*x_110 - 3.2743475880746e-6*x_111 + 1.43621476402314e-6*x_112 + 5.30144487110118e-6*x_113 + 3.0061453510356e-7*x_114 + 2.68649753936274e-7*x_115 + 2.89136398799359e-6*x_116 + 3.83259274511462e-6*x_117 + 4.43545531126931e-6*x_118 + 2.5247866612875e-6*x_119 + 4.39470009879785e-6*x_12 + 7.04526486187812e-7*x_120 + 4.46539212937521e-6*x_13 - 1.1905591396825e-6*x_14 + 1.70369703999344e-6*x_15 + 2.36817267985896e-6*x_16 - 1.22808465723224e-6*x_17 + 5.13488073475021e-6*x_18 - 1.75669883422777e-6*x_19 + 1.27086293450156e-6*x_2 + 4.35861290771064e-6*x_20 + 1.10864669891117e-7*x_21 + 1.25589157075864e-6*x_22 - 7.05252694168656e-8*x_23 - 5.72115546263989e-7*x_24 - 2.0073606219797e-6*x_25 - 7.96430145525066e-7*x_26 + 3.77604058566586e-6*x_27 + 3.98578878261471e-6*x_28 + 1.76423028038062e-6*x_29 + 1.11226602246074e-5*x_3 + 6.78210300480444e-6*x_30 + 9.76379277066739e-5*x_31 - 1.20208981721627e-6*x_32 - 4.89215765186428e-6*x_33 - 4.76180642955614e-5*x_34 + 9.61422047669157e-6*x_35 - 2.9507953023561e-7*x_36 + 3.71855236086814e-6*x_37 - 9.31785206039285e-7*x_38 + 5.52606939098076e-6*x_39 + 1.36243858548539e-6*x_4 - 8.68552464375222e-7*x_40 - 3.54021077457421e-6*x_41 + 8.96023485957408e-6*x_42 - 1.39079126315375e-6*x_43 + 7.0600853279738e-7*x_44 + 9.58907081411993e-6*x_45 + 1.18692903477409e-6*x_46 + 2.05980583676323e-7*x_47 - 2.412779125264e-6*x_48 + 5.89502251275307e-6*x_49 + 1.24971913593917e-6*x_5 + 6.36808161757761e-8*x_50 - 9.99820981209962e-7*x_51 - 8.85323163046341e-7*x_52 + 2.92221227405884e-6*x_53 - 4.67143834443358e-6*x_54 - 1.30155777774644e-7*x_55 + 3.3310629300651e-6*x_56 + 6.2080686336262e-6*x_57 + 5.66697166434066e-6*x_58 + 5.73951533316131e-6*x_59 + 1.77380962828668e-6*x_6 + 5.03702295560463e-6*x_60 - 3.51276837765041e-6*x_61 + 6.05238335506898e-8*x_62 + 1.69626070648282e-6*x_63 + 4.39099863957448e-6*x_64 + 3.38737624985191e-7*x_65 + 2.57226961904364e-6*x_66 - 2.77943000080528e-6*x_67 - 1.16511053395087e-6*x_68 + 1.64842754465784e-6*x_69 + 5.08892962246746e-7*x_7 + 3.62827678002765e-7*x_70 - 1.2499982142589e-6*x_71 + 3.81052888877381e-6*x_72 - 9.35611000912759e-7*x_73 - 2.70040336309033e-6*x_74 + 1.79295541216093e-6*x_75 - 1.78307160386854e-6*x_76 - 2.0460695365782e-6*x_77 + 6.8500929359203e-6*x_78 + 5.20098495470793e-6*x_79 - 2.58513963077805e-7*x_8 + 2.03393343300683e-6*x_80 + 3.55110255557228e-7*x_81 + 2.97007198908628e-6*x_82 + 8.97916134945479e-6*x_83 + 2.46215316371576e-6*x_84 + 6.31159829946845e-6*x_85 + 1.81518426503384e-6*x_86 + 2.87385297658921e-8*x_87 + 4.58519615391616e-6*x_88 - 2.44334780742199e-7*x_89 - 1.72883559189003e-6*x_9 + 3.89304706924448e-6*x_90 - 6.96035152039341e-6*x_91 - 3.89540193582466e-6*x_92 + 5.73671697402637e-6*x_93 + 9.69149142455277e-6*x_94 - 1.00023590372408e-5*x_95 + 3.07794579232909e-7*x_96 - 3.34009740102616e-7*x_97 + 6.70513744237976e-6*x_98 + 5.83443457109579e-6*x_99 - 4.9929567563834e-9*std::pow(-4.92423963546753*x_52 - 7.67727994918823, 2) - 6.17255315729258e-5*std::sin(0.327519834041595*x_32 - 7.75679969787598) + 0.000120189449402437*std::sin(0.206960007548332*x_36 - 7.58568000793457) - 5.18247845634882e-5*std::sin(0.263199955224991*x_91 + 1.55311989784241) - 6.7988758257918e-5*std::sin(0.178000003099442*x_92 + 1.79367983341217) + 0.0666695699469659);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.2667976290961e-5*x_1 + 4.00715580389105e-6*x_10 + 2.96244593072279e-6*x_100 - 4.28150639080888e-6*x_101 - 1.49744251329184e-7*x_102 + 1.86364091628514e-6*x_103 + 2.98561600225439e-6*x_104 - 3.57410917886397e-6*x_105 - 2.1220559751769e-8*x_106 - 3.15556954102737e-7*x_107 - 3.13505045423352e-6*x_108 - 8.60084971216863e-6*x_109 + 8.77229411428352e-8*x_11 - 7.93121825255902e-6*x_110 - 2.48356390705029e-6*x_111 + 1.73653734561833e-6*x_112 + 1.13002777905582e-6*x_113 + 5.62554559885874e-6*x_114 - 3.04721038246267e-6*x_115 + 1.55425675839574e-6*x_116 - 5.3516870666115e-7*x_117 - 8.59322951910795e-7*x_118 - 3.23309009426919e-6*x_119 - 1.9885844651981e-6*x_12 + 1.40602164178609e-6*x_120 - 1.62483180175256e-6*x_13 - 9.89185380111298e-7*x_14 - 1.70496269261603e-7*x_15 + 3.41570360659447e-7*x_16 + 3.11250255091374e-6*x_17 - 7.8758610923651e-7*x_18 + 8.71598145327835e-7*x_19 - 8.2952621801391e-7*x_2 + 1.16817167410182e-6*x_20 - 5.99994525163031e-7*x_21 + 1.91233373923897e-7*x_22 - 9.75221272471733e-6*x_23 - 9.66447817377808e-7*x_24 + 3.56195438936313e-6*x_25 + 1.34523493644012e-6*x_26 + 1.48714330441892e-6*x_27 - 1.16093151312468e-7*x_28 + 2.37756771061969e-6*x_29 - 9.66095522936631e-7*x_3 + 7.63933350999087e-7*x_30 + 8.33771232898539e-5*x_31 - 6.50087577806762e-6*x_32 + 2.16792182741472e-6*x_33 + 2.29178416677543e-5*x_34 - 8.29085401312221e-6*x_35 + 1.38872804591192e-6*x_36 - 4.80401657449888e-6*x_37 - 2.53386090874875e-6*x_38 - 5.1547674484059e-6*x_39 - 3.22646641557451e-7*x_4 + 1.06826567331772e-6*x_40 - 4.84216145175481e-6*x_41 - 1.49448538001313e-6*x_42 + 2.68289833073563e-6*x_43 + 1.10782324670567e-6*x_44 - 8.15474165811284e-6*x_45 + 1.15153902447118e-6*x_46 + 4.34598191431309e-7*x_47 - 3.65512399305648e-6*x_48 + 6.86474387739998e-6*x_49 + 2.70538329866254e-7*x_5 + 8.23537956259393e-7*x_50 - 1.24959033068024e-7*x_51 + 1.12018492818116e-6*x_52 - 9.48629692163715e-7*x_53 - 1.30634985516291e-6*x_54 + 4.44561076734919e-6*x_55 + 8.3836499872017e-7*x_56 - 3.20862442374814e-7*x_57 - 1.84425888458154e-7*x_58 + 2.05423154883324e-6*x_59 - 1.16902608438329e-6*x_6 + 3.66175071493855e-7*x_60 - 2.11764123844825e-6*x_61 - 7.61888592420582e-7*x_62 - 1.68907174728995e-6*x_63 + 6.01876979090162e-7*x_64 + 1.98656058730262e-6*x_65 + 1.54118911144092e-6*x_66 - 1.0421261490075e-5*x_67 - 2.08544890422541e-7*x_68 - 1.26353418697687e-9*x_69 - 6.0589902010342e-7*x_7 - 9.07753924948276e-7*x_70 + 1.42891771007516e-7*x_71 - 9.75576362640291e-7*x_72 - 1.56743710483178e-6*x_73 - 5.71707658241607e-7*x_74 - 1.00657663803669e-6*x_75 + 1.42309508207152e-7*x_76 - 1.90975705445924e-6*x_77 - 2.44293387601015e-7*x_78 - 7.1496249402735e-7*x_79 - 1.21297065863091e-6*x_8 - 8.93869119471808e-7*x_80 + 2.06991207700274e-6*x_81 + 1.28705286526002e-6*x_82 + 9.7089440205713e-7*x_83 - 1.76455149026222e-6*x_84 + 8.62969211520442e-7*x_85 - 9.04868311778454e-7*x_86 + 5.2923481534985e-7*x_87 + 2.69336249808585e-6*x_88 - 1.98809367874847e-7*x_89 + 1.77371894400399e-7*x_9 - 1.10797103755545e-6*x_90 - 1.30104444062511e-5*x_91 + 1.23817632649299e-6*x_92 + 2.43660965904412e-6*x_93 - 4.76089160706925e-6*x_94 + 1.16651540551253e-6*x_95 - 1.28748014961214e-6*x_96 + 4.04736065324919e-7*x_97 - 1.34180849068944e-6*x_98 - 5.78031152411563e-6*x_99 - 6.89218759028736e-9*std::pow(-4.92423963546753*x_52 - 7.67727994918823, 2) - 0.000267264808211593*std::sin(0.327519834041595*x_32 - 7.75679969787598) - 6.2513449340105e-5*std::sin(0.206960007548332*x_36 - 7.58568000793457) - 3.60164020194267e-5*std::sin(0.263199955224991*x_91 + 1.55311989784241) + 3.74784851229222e-6*std::sin(0.178000003099442*x_92 + 1.79367983341217) + 0.0540874485624706);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
