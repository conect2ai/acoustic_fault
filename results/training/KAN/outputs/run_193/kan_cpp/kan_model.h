
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000175477471866036*x_1 + 0.00198418513469321*x_10 + 0.00369591963648741*x_100 - 0.000627446788390637*x_101 - 0.000189504027110357*x_102 + 0.000362321679168232*x_103 - 0.000825510920226256*x_104 + 7.46559062445982e-5*x_105 + 0.00248349080911949*x_106 + 0.00399884121896207*x_107 - 0.00203877376565914*x_108 - 0.00349921586602273*x_109 + 0.00349366697820928*x_11 + 0.00892203481703305*x_110 - 0.00179850563541211*x_111 - 0.00283649867036534*x_112 - 0.00363202620808578*x_113 - 0.0030581229070492*x_114 + 0.000711808841807488*x_115 - 0.00317492916133004*x_116 - 0.0043392668575064*x_117 + 0.000294144192587998*x_118 - 0.00302727694272711*x_119 + 0.00401004130470357*x_12 - 0.00743701859745446*x_120 - 0.00404604948306589*x_13 - 0.00212759299939403*x_14 + 0.000784036170065511*x_15 - 0.00597324221551385*x_16 + 0.000825342205284998*x_17 + 0.000129839302255308*x_18 - 0.000166262061305499*x_19 + 0.000979877078185421*x_2 + 0.00126764676292364*x_20 + 0.000467874083905048*x_21 + 0.00137065046296207*x_22 - 0.000953951095206143*x_23 - 0.000164257981661505*x_24 + 0.000748130287270696*x_25 + 0.000798703096159013*x_26 - 0.00148547328285168*x_27 - 0.000166550068523636*x_28 + 0.00178095364565656*x_29 + 4.18560294156653e-5*x_3 + 0.000787039247508218*x_30 + 9.97633002334613e-6*x_31 - 0.000910625962895716*x_32 + 0.00192568428563127*x_33 + 0.00267011628732167*x_34 - 0.000516798227865193*x_35 - 0.00117165738188654*x_36 + 0.00731540421877363*x_37 + 0.00390768159072991*x_38 + 0.00541333624702892*x_39 + 0.000412655823551943*x_4 - 0.00195397469037244*x_40 - 0.000717012885954774*x_41 + 0.00243540989605664*x_42 + 0.00481439919003718*x_43 + 0.0013712450726395*x_44 + 0.00222255891510697*x_45 + 0.00172583440493698*x_46 + 0.00178251890264713*x_47 - 0.000767890808136862*x_48 + 0.000907949243002377*x_49 - 0.00044190912961284*x_5 + 0.00678448573134081*x_50 + 0.0020826630379933*x_51 + 0.000839130816272324*x_52 + 0.00154064993046368*x_53 + 0.00645465661853419*x_54 + 0.00458965632578237*x_55 + 0.00103457198524787*x_56 + 0.0011538034426939*x_57 + 0.0013020811372979*x_58 + 0.0014240155193401*x_59 + 0.00103167782856508*x_6 + 0.000503855327815377*x_60 + 5.50851846571111e-5*x_61 - 0.000730162398164482*x_62 - 0.000537297360909407*x_63 - 0.000582459843005855*x_64 - 0.00106018145897404*x_65 - 0.000100624457718311*x_66 + 0.00117868750604378*x_67 - 0.00176954533717133*x_68 - 0.00125181910305077*x_69 + 0.00144375418678945*x_7 + 0.000237482722566911*x_70 + 0.00108018289127506*x_71 - 0.000418364259264328*x_72 - 0.00143232534609348*x_73 - 0.000992679316191711*x_74 - 0.000449984780408418*x_75 - 0.000466606948946037*x_76 - 0.000563673552231181*x_77 - 0.00125350257706602*x_78 - 0.000326704754598137*x_79 + 0.000671425333904909*x_8 - 0.00137107797491209*x_80 + 0.00279411294180313*x_81 - 0.000915165111423879*x_82 - 0.000311364405564727*x_83 - 0.0013989984829763*x_84 + 0.000867617621978365*x_85 + 0.0016140868693426*x_86 + 0.00127484931731758*x_87 + 0.000187747177013757*x_88 + 0.00154895691344147*x_89 + 0.00153206053850962*x_9 + 0.000239674088880864*x_90 + 0.00120019177393528*x_91 + 0.00444077730618477*x_92 + 0.000551859786109504*x_93 + 0.00252805048604861*x_94 + 0.00174501074629707*x_95 + 0.00136555162953118*x_96 + 0.0016335278941642*x_97 + 0.00206182374020441*x_98 + 0.00293547693656831*x_99 + 2.2523082481127e-6*std::pow(-6.59912014007568*x_1 - 8.60007953643799, 2) - 0.000121047423179212*std::pow(-4.72503995895386*x_1 - 6.98927974700928, 2) - 0.00174445275359616*std::sin(0.228559985756874*x_1 + 5.03671979904175) - 0.294493906752321*std::sin(0.242399975657463*x_1 + 5.05503988265991) - 0.0320057358884972*std::sin(0.259359985589981*x_1 + 5.07639980316162) + 0.0997627700655535*std::sin(0.297599911689758*x_1 - 4.29648017883301) - 0.015717135653864*std::sin(0.337439835071564*x_1 - 4.25399971008301) + 0.002046093574333*std::sin(0.224879994988441*x_104 + 1.98151981830597) - 0.00137684048044143*std::sin(0.231359988451004*x_104 - 1.1904798746109) - 0.00116117238558655*std::sin(0.263839960098267*x_107 + 1.94431984424591) + 0.000810308468908981*std::sin(0.214719995856285*x_108 + 8.3810396194458) + 0.0162660675085926*std::sin(0.252159982919693*x_108 + 1.96295976638794) - 0.00422005687452043*std::sin(0.260559976100922*x_108 + 1.96167981624603) - 0.00503292573013042*std::sin(0.224639996886253*x_109 + 1.97367978096008) + 0.00251251723072396*std::sin(0.172640010714531*x_11 + 5.20760011672974) + 0.0125509262817627*std::sin(0.280799955129623*x_11 - 7.42807960510254) - 0.0334228720321939*std::sin(0.301519930362701*x_11 + 5.14408016204834) - 0.00316799357991088*std::sin(0.216559991240501*x_111 + 1.96263980865479) + 0.00245988119979128*std::sin(0.235519990324974*x_113 - 4.19479990005493) - 0.000194724362232759*std::sin(0.259679973125458*x_113 - 7.40687990188599) - 0.0731064498607164*std::sin(0.282799929380417*x_113 - 7.41304016113281) - 0.00342076208072578*std::sin(0.289039939641953*x_113 - 7.42664003372192) + 0.0105977540858088*std::sin(0.289839953184128*x_113 - 7.42519998550415) - 0.0110259083375293*std::sin(0.293839931488037*x_113 - 7.44047975540161) - 0.00535793501232731*std::sin(0.237039983272552*x_119 + 5.1701602935791) + 9.91664937151325e-5*std::sin(0.24695996940136*x_12 + 2.14351987838745) + 0.00391891052454575*std::sin(0.26895996928215*x_12 - 4.22751998901367) + 0.0134993572947211*std::sin(0.278319954872131*x_12 + 5.14752006530762) - 0.023652492558171*std::sin(0.293199926614761*x_12 - 7.44055986404419) - 0.0126798417837573*std::sin(0.264879941940308*x_120 + 5.16535997390747) - 0.00594133468517176*std::sin(0.269759953022003*x_120 + 5.14287996292114) - 0.0600964546189853*std::sin(0.301679939031601*x_13 - 7.43824005126953) + 0.00862663413263325*std::sin(0.310639947652817*x_13 - 7.45991992950439) + 0.0257312968631116*std::sin(0.319199919700623*x_13 - 7.46647977828979) - 0.0366492109769968*std::sin(0.293279945850372*x_15 + 5.1560001373291) - 0.0217229591480918*std::sin(0.299439936876297*x_15 + 5.160560131073) - 0.0013076480189538*std::sin(0.335599839687347*x_16 - 1.15495979785919) + 0.00451334512619628*std::sin(0.383199840784073*x_16 - 7.57936000823975) + 0.00777401294889636*std::sin(0.356399834156036*x_17 + 1.99591982364655) - 0.00609617999102799*std::sin(0.361359834671021*x_17 + 1.98919987678528) + 0.0396749531812179*std::sin(0.375039845705032*x_17 + 1.98655986785889) - 0.118738773989927*std::sin(0.31415992975235*x_18 - 1.15887987613678) + 0.00132254129735123*std::sin(0.38783985376358*x_18 + 1.99743974208832) + 0.014754850292385*std::sin(0.209199994802475*x_19 - 1.17927992343903) - 0.00359048973171281*std::sin(0.225599989295006*x_19 - 1.18735992908478) + 0.122355700284742*std::sin(0.309599906206131*x_19 + 1.9851998090744) + 0.00381341347945095*std::sin(0.361839860677719*x_2 - 7.40703964233398) - 0.00114156787614349*std::sin(0.371599853038788*x_2 - 7.41815996170044) - 0.0486392250419809*std::sin(0.392399847507477*x_2 + 5.18391990661621) - 0.0253105003595247*std::sin(0.404959857463837*x_2 + 5.19816017150879) - 0.0206027682897466*std::sin(0.250399976968765*x_20 - 1.17255985736847) - 0.00673535166659019*std::sin(0.315199911594391*x_21 + 1.98335981369019) + 0.00660763114204529*std::sin(0.377199828624725*x_21 - 1.18823993206024) - 0.0414920566063906*std::sin(0.248879969120026*x_22 - 1.15287983417511) + 0.00010495125553511*std::sin(0.301199942827225*x_23 + 8.23463916778564) - 0.0106048030180073*std::sin(0.348559856414795*x_23 + 1.98695981502533) - 0.00466119787542525*std::sin(0.352319836616516*x_23 - 1.16951990127563) + 0.0174350154596537*std::sin(0.258719980716705*x_25 - 1.17999982833862) + 0.004709938845079*std::sin(0.334399849176407*x_25 - 4.35735988616943) - 0.0392001341218136*std::sin(0.354479849338531*x_25 - 1.15239989757538) + 0.000923785098152519*std::sin(0.305039942264557*x_26 - 4.39551973342896) - 0.00644915136833957*std::sin(0.336399853229523*x_26 - 1.15855991840363) - 0.00444090626913751*std::sin(0.343119859695435*x_26 + 5.04207992553711) + 0.00427615532316811*std::sin(0.348079830408096*x_3 - 7.39111995697021) - 0.000275966464894421*std::sin(0.350639849901199*x_3 - 7.41487979888916) - 0.0131427008947893*std::sin(0.354399859905243*x_3 - 7.40895986557007) + 0.00475866739283418*std::sin(0.361919850111008*x_3 - 7.39071989059448) - 0.0269780868658263*std::sin(0.372799843549728*x_3 - 7.38903999328613) - 0.00159863421958431*std::sin(0.400879859924316*x_3 - 1.17607986927032) + 0.00555722772840167*std::sin(0.460159868001938*x_3 + 8.19824028015137) - 0.00754722258892275*std::sin(0.29751992225647*x_30 + 2.00103974342346) - 0.00215970258030255*std::sin(0.355439841747284*x_31 + 8.35223960876465) - 0.0190919957761045*std::sin(0.377839833498001*x_31 + 5.16879987716675) + 0.0156795322537253*std::sin(0.381759852170944*x_31 + 5.17304039001465) - 0.0359934252621452*std::sin(0.38223984837532*x_31 - 7.39759969711304) - 0.0146135667564621*std::sin(0.388639837503433*x_31 - 7.40663957595825) - 0.0018950157650712*std::sin(0.392079830169678*x_31 + 8.40104007720947) + 0.00868479008781556*std::sin(0.409919857978821*x_31 + 5.20584011077881) + 0.0030920078384279*std::sin(0.420639842748642*x_31 + 2.00063967704773) - 0.00339794872588756*std::sin(0.278239965438843*x_32 + 2.04231977462769) - 0.00108122020425078*std::sin(0.291119933128357*x_32 + 2.01647973060608) + 0.0025221751810497*std::sin(0.30311992764473*x_32 - 1.14807987213135) + 0.0513747059627689*std::sin(0.31879985332489*x_32 + 1.9916797876358) - 0.00217545848255993*std::sin(0.320479840040207*x_32 + 2.01711988449097) + 0.00286402096597319*std::sin(0.362319827079773*x_32 + 8.21008014678955) - 0.0133893899488507*std::sin(0.23743999004364*x_33 + 1.99071979522705) - 0.00424279985814113*std::sin(0.244079977273941*x_34 + 1.97359979152679) - 0.010137242366439*std::sin(0.211040005087852*x_36 + 8.18279933929443) + 0.00223323730097839*std::sin(0.254639983177185*x_37 + 1.97111976146698) - 0.0134291071148431*std::sin(0.311999946832657*x_4 - 7.37815999984741) - 0.00434526182834196*std::sin(0.361039847135544*x_4 + 2.00863981246948) + 0.00273348605095431*std::sin(0.217840000987053*x_40 - 1.18151986598969) + 0.00485257326081228*std::sin(0.230159983038902*x_42 - 7.42208003997803) - 0.000563932752685758*std::sin(0.227999985218048*x_44 - 7.59743976593018) + 0.0034603836677862*std::sin(0.19463999569416*x_47 - 1.1743198633194) + 0.0383477496797712*std::sin(0.178720012307167*x_48 + 1.99559986591339) + 0.00593053574356897*std::sin(0.357679843902588*x_5 + 1.99735975265503) - 0.0210817252118346*std::sin(0.361199855804443*x_5 + 2.02967977523804) + 0.00681166352607571*std::sin(0.382959842681885*x_5 + 2.00695967674255) + 5.62513882523999e-5*std::sin(0.530799865722656*x_5 + 1.86231982707977) - 0.0631352970147729*std::sin(0.232719987630844*x_52 - 7.42647981643677) - 0.00014191397103156*std::sin(0.24551996588707*x_52 - 7.42375993728638) - 0.0568766294933561*std::sin(0.237919986248016*x_53 - 7.41623973846436) - 0.000250460043699152*std::sin(0.238559976220131*x_53 - 7.40831995010376) - 0.00257997666170618*std::sin(0.258159965276718*x_53 - 7.43439960479736) + 0.0369124568173313*std::sin(0.273599952459335*x_6 + 2.01239991188049) + 0.0221043405122581*std::sin(0.34487983584404*x_6 + 2.00751972198486) + 0.00567296130664762*std::sin(0.378239840269089*x_6 + 1.9968798160553) + 0.00201983493295529*std::sin(0.478239864110947*x_6 + 5.13472032546997) + 0.0445894355622403*std::sin(0.33927983045578*x_7 + 2.03287982940674) + 0.0273755616196818*std::sin(0.353279858827591*x_7 + 1.99943971633911) - 0.00682375649825993*std::sin(0.357119828462601*x_7 - 1.14767980575562) + 0.00262463097389268*std::sin(0.324799835681915*x_8 - 4.32855987548828) - 0.0194493690853846*std::sin(0.330319821834564*x_8 - 1.13239991664886) + 0.00346949434574952*std::sin(0.356479853391647*x_9 - 4.36567974090576) + 0.00115620869182652*std::sin(0.309759914875031*x_91 - 4.35207986831665) - 0.0030987142623948*std::sin(0.363919854164124*x_91 - 7.40927982330322) + 0.00801772174362948*std::sin(0.366639852523804*x_91 + 1.99207985401154) + 0.00140466657718551*std::sin(0.368159830570221*x_91 + 2.00927972793579) + 0.000146590777881361*std::sin(0.389919847249985*x_91 + 2.01271986961365) - 0.00433449693221649*std::sin(0.395359843969345*x_91 + 1.99727976322174) - 0.00311099671757032*std::sin(0.294639945030212*x_92 - 7.40287971496582) - 0.0040185512382412*std::sin(0.297439932823181*x_92 + 8.22743988037109) + 0.0195124799698004*std::sin(0.302079945802689*x_92 + 1.98719990253448) - 0.0146524054623008*std::sin(0.314319908618927*x_92 + 5.02783966064453) + 0.00187352449757471*std::sin(0.320639848709106*x_92 - 1.1794399023056) - 0.00108056122292648*std::sin(0.271519958972931*x_94 - 1.19207990169525) + 0.00849504488404728*std::sin(0.299519926309586*x_94 + 1.98151981830597) - 0.00345671012034151*std::sin(0.25943997502327*x_97 - 1.19791984558105) - 0.0301563373504461*std::sin(0.274719953536987*x_97 + 1.97767972946167) - 0.002397416143283*std::sin(0.248719975352287*x_98 - 7.43247985839844) - 0.00551371521130731*std::sin(0.262879967689514*x_98 + 1.96247982978821) - 1.22680371288323);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000223416754693273*x_1 + 0.00491729083544971*x_10 - 0.00216369897235437*x_100 + 0.00118289162396839*x_101 + 0.00365216042974098*x_102 - 0.00214197863762866*x_103 - 0.0022945743665187*x_104 - 0.00209698918443709*x_105 - 0.00972988464953973*x_106 - 0.00232654105289073*x_107 + 0.00477474862164992*x_108 + 0.000685695785434391*x_109 + 0.0061548734013667*x_11 - 0.0018423612293224*x_110 - 0.00302244397088202*x_111 - 0.00260107707885145*x_112 + 0.00634451786945352*x_113 - 0.00335457986279592*x_114 - 0.0020808528746281*x_115 + 0.00652576577698825*x_116 - 0.00070499463004304*x_117 - 0.00587107747194989*x_118 - 0.000491949745131543*x_119 + 0.00952203157642295*x_12 - 0.00352643237420824*x_120 + 0.0192251198827635*x_13 + 0.0146185070008018*x_14 + 0.00108106292775033*x_15 + 0.00133774699771376*x_16 - 0.00291760285089686*x_17 + 0.00213482302159447*x_18 + 0.00410146191354069*x_19 - 0.00113903054896499*x_2 + 0.000788111699170036*x_20 - 0.0058927411881561*x_21 - 0.000761772937586947*x_22 - 0.000772427718034604*x_23 + 0.00380151125372535*x_24 - 0.0038409348209775*x_25 + 0.00208644079565254*x_26 + 0.00134046151329806*x_27 - 0.00128966229483045*x_28 + 0.00158477427252692*x_29 - 0.000972407089041799*x_3 - 0.0295684028231463*x_30 + 8.1766573046948e-5*x_31 - 0.000900464121526139*x_32 - 0.00132551620990399*x_33 + 0.00265003247742684*x_34 - 0.000132022907942237*x_35 + 0.00680886381390512*x_36 - 0.00245710276102202*x_37 + 0.00099184304542527*x_38 - 0.0023759201220463*x_39 + 0.000326899274453176*x_4 - 0.00068989227504988*x_40 + 0.000988820513190645*x_41 + 9.08310880675916e-5*x_42 - 0.00237191141139107*x_43 - 0.00207079752239743*x_44 - 0.00277421311397443*x_45 - 0.00403093935460818*x_46 - 0.0021284450311412*x_47 + 0.00968099060404135*x_48 + 0.00250960644700841*x_49 - 0.000138003314013836*x_5 - 0.00297917622391482*x_50 - 0.00578178181874431*x_51 - 0.00385132399028184*x_52 - 0.00596080476457178*x_53 - 0.00369772132198975*x_54 + 0.00321265699644369*x_55 - 0.000996224644906278*x_56 - 0.00475800399629323*x_57 - 0.000778270568548068*x_58 + 0.00351475400172471*x_59 - 0.00360704698850503*x_6 - 0.00323372429057157*x_60 - 0.00252599642279789*x_61 - 0.00086493794762435*x_62 - 0.000178038545096617*x_63 + 0.00106285369050972*x_64 + 0.00135940561652323*x_65 + 0.00186026713605423*x_66 - 0.000806322888571625*x_67 + 0.00131859747190592*x_68 - 0.000282917165674669*x_69 - 0.00290139186915044*x_7 - 0.0017839775728931*x_70 - 0.000296677591699857*x_71 + 0.00148965346251198*x_72 + 0.00217986282780953*x_73 + 0.00406829681222271*x_74 - 0.000575476694344587*x_75 - 0.00195749240481241*x_76 - 0.00140274067420637*x_77 + 0.00143319963139287*x_78 - 0.00400659846798506*x_79 - 0.000373292674089735*x_8 - 0.00277062415310118*x_80 - 0.000165822429656395*x_81 + 0.000854761860573041*x_82 - 0.00206317624292389*x_83 + 0.000174789700202644*x_84 + 0.000317588701900842*x_85 - 0.00090086773900162*x_86 - 0.00194459494082678*x_87 - 0.000961446534064713*x_88 - 0.00153867481429883*x_89 + 0.000799634144367052*x_9 + 0.000238661825536879*x_90 - 0.00107368957275373*x_91 - 0.000180270857108243*x_92 + 0.00207079495439332*x_93 + 0.000177759615829866*x_94 - 0.00186228197001509*x_95 + 0.00166906743387187*x_96 - 0.00230221319339828*x_97 + 0.00303309745098716*x_98 + 0.00742116267113354*x_99 + 1.35778102068333e-6*std::pow(-6.59912014007568*x_1 - 8.60007953643799, 2) + 3.2788957414982e-5*std::pow(-4.72503995895386*x_1 - 6.98927974700928, 2) - 0.00268303393386304*std::pow(-0.0209373597767461*x_10 + 0.0144930141628978*x_100 + 0.0284215152498523*x_101 - 0.052164434391372*x_102 + 0.0289779620923541*x_103 - 0.00570653253337807*x_104 - 0.0260116597319705*x_105 - 0.00983429262155521*x_106 - 0.0259642965944897*x_107 + 0.0312371599381673*x_108 - 0.00240923634915673*x_109 - 0.0200500175396617*x_11 - 0.0207434372592371*x_110 + 0.0914566935847569*x_111 + 0.0698781998533599*x_112 - 0.0162133097351812*x_114 - 0.00489633192964798*x_115 - 0.0026037936292887*x_116 - 0.00343095526259798*x_117 + 0.00815593637766357*x_118 + 0.0137799143795855*x_119 - 0.147583433220751*x_12 + 0.256599519234726*x_120 - 0.115691199152149*x_14 - 0.0422843677260568*x_15 - 0.0220214691274768*x_17 - 0.0317080380647936*x_18 - 0.0390991423295939*x_19 - 0.0407324090884256*x_20 - 0.0330592459083282*x_22 - 0.00238883571600097*x_23 - 0.0461526084563871*x_24 - 0.0787116062644951*x_26 - 0.0169623167822113*x_27 - 0.000628422350463154*x_28 + 0.0100065636772168*x_29 - 0.000506690795420279*x_30 - 0.103803583333007*x_33 - 0.0697938422170752*x_34 + 0.00078344007144372*x_35 - 0.0384644674109667*x_37 - 0.0772132044097477*x_38 - 0.0038634442550121*x_39 + 0.107974919523165*x_40 - 0.00981204782920851*x_41 - 0.000418149684342438*x_43 - 0.0226981884814737*x_44 - 0.0206734968334979*x_45 - 0.00948073676554401*x_46 - 0.0717687850024843*x_47 - 0.00584029781744193*x_48 - 0.0438804832389267*x_49 + 0.0161953185509359*x_5 - 0.0758224084722303*x_50 - 0.0104212566286168*x_51 - 0.0782242566902635*x_54 - 0.0734538785810339*x_55 - 0.0170299560734046*x_56 + 0.0048648272667191*x_57 - 0.0167478528694871*x_58 - 0.00405056881095796*x_59 - 0.00267703371612198*x_60 + 0.0174702690739267*x_61 - 0.00165606956448941*x_62 - 0.0381084724831807*x_63 + 0.0103116668602655*x_64 + 0.0209057745512155*x_65 - 0.0301482396765378*x_66 - 0.01878557301683*x_67 - 0.0271276774484678*x_68 + 0.00849769800313612*x_69 - 0.0017225636780887*x_70 + 0.00179109515869978*x_71 + 0.00797930653849599*x_72 + 0.0117525564769963*x_73 - 0.0196075708278785*x_74 + 0.00708868551483089*x_75 - 0.00326035221909411*x_76 - 0.0289191528416412*x_77 - 0.0286019009289079*x_78 - 0.00348585097227042*x_79 - 0.0144002054546797*x_8 + 0.0443594407149873*x_80 + 0.00693503133289969*x_81 + 0.0133203993221789*x_82 + 0.0147729963366646*x_83 - 0.0319233544655928*x_84 - 0.0135888292001549*x_85 - 0.00894197328557929*x_86 + 0.00200823559791176*x_87 - 0.0144546979096178*x_88 - 0.00882773750908965*x_89 - 0.0234274042301547*x_9 + 0.00877053801097392*x_90 - 0.00270467617368175*x_91 - 0.125269155573485*x_92 - 0.00640189202872145*x_93 - 0.0662841757485137*x_94 - 0.0228842755997503*x_95 - 0.0762554929857865*x_96 - 0.0341646483097175*x_97 - 0.0989283062949246*x_98 - 0.046492187439954*x_99 + 10.4981589802113*std::sin(0.242399975657463*x_1 + 5.05503988265991) + 2.60610870214754*std::sin(0.282799929380417*x_113 - 7.41304016113281) - 0.917272782364044*std::sin(0.319199919700623*x_13 - 7.46647977828979) - 0.160892343036558*std::sin(0.383199840784073*x_16 - 7.57936000823975) + 0.902272171174189*std::sin(0.404959857463837*x_2 + 5.19816017150879) - 0.235549736756107*std::sin(0.377199828624725*x_21 - 1.18823993206024) - 0.621525810623396*std::sin(0.258719980716705*x_25 - 1.17999982833862) - 0.19810481250828*std::sin(0.460159868001938*x_3 + 8.19824028015137) + 0.520946422182845*std::sin(0.388639837503433*x_31 - 7.40663957595825) - 1.83141252974161*std::sin(0.31879985332489*x_32 + 1.9916797876358) + 0.361373799401953*std::sin(0.211040005087852*x_36 + 8.18279933929443) + 0.478722643224259*std::sin(0.311999946832657*x_4 - 7.37815999984741) - 0.172985193876947*std::sin(0.230159983038902*x_42 - 7.42208003997803) + 2.25065568463998*std::sin(0.232719987630844*x_52 - 7.42647981643677) + 2.02754585065833*std::sin(0.237919986248016*x_53 - 7.41623973846436) - 1.31586029840828*std::sin(0.273599952459335*x_6 + 2.01239991188049) - 1.58953028445502*std::sin(0.33927983045578*x_7 + 2.03287982940674) + 18.9010027636993, 2) + 0.00605742530664265*std::sin(0.228559985756874*x_1 + 5.03671979904175) - 0.0521784059640654*std::sin(0.259359985589981*x_1 + 5.07639980316162) - 0.679803132674201*std::sin(0.297599911689758*x_1 - 4.29648017883301) - 0.00242330302111252*std::sin(0.337439835071564*x_1 - 4.25399971008301) - 0.00678287441344689*std::sin(0.224879994988441*x_104 + 1.98151981830597) - 0.000830014219598218*std::sin(0.231359988451004*x_104 - 1.1904798746109) + 0.00138936067886786*std::sin(0.263839960098267*x_107 + 1.94431984424591) + 0.000124935166558637*std::sin(0.214719995856285*x_108 + 8.3810396194458) - 0.00440610283837965*std::sin(0.252159982919693*x_108 + 1.96295976638794) + 1.46142147604912e-5*std::sin(0.260559976100922*x_108 + 1.96167981624603) + 1.74292100037364e-5*std::sin(0.224639996886253*x_109 + 1.97367978096008) + 0.00151464534788941*std::sin(0.172640010714531*x_11 + 5.20760011672974) + 0.0204615612975247*std::sin(0.280799955129623*x_11 - 7.42807960510254) + 0.000115744655656188*std::sin(0.301519930362701*x_11 + 5.14408016204834) + 1.09708802305979e-5*std::sin(0.216559991240501*x_111 + 1.96263980865479) + 0.00401030241308126*std::sin(0.235519990324974*x_113 - 4.19479990005493) + 0.000676159487367593*std::sin(0.259679973125458*x_113 - 7.40687990188599) - 0.00206217147824887*std::sin(0.289039939641953*x_113 - 7.42664003372192) - 3.67004186896137e-5*std::sin(0.289839953184128*x_113 - 7.42519998550415) - 0.00169999913300206*std::sin(0.293839931488037*x_113 - 7.44047975540161) + 0.00641085192729297*std::sin(0.237039983272552*x_119 + 5.1701602935791) - 0.000344345025890063*std::sin(0.24695996940136*x_12 + 2.14351987838745) - 0.0129913305329617*std::sin(0.26895996928215*x_12 - 4.22751998901367) + 0.0220077722203249*std::sin(0.278319954872131*x_12 + 5.14752006530762) + 8.19094661858823e-5*std::sin(0.293199926614761*x_12 - 7.44055986404419) + 0.0151716263728741*std::sin(0.264879941940308*x_120 + 5.16535997390747) + 0.0196957399814489*std::sin(0.269759953022003*x_120 + 5.14287996292114) + 0.0162787446402388*std::sin(0.301679939031601*x_13 - 7.43824005126953) + 0.0140638546616819*std::sin(0.310639947652817*x_13 - 7.45991992950439) + 0.00992742667671935*std::sin(0.293279945850372*x_15 + 5.1560001373291) + 0.148024515258779*std::sin(0.299439936876297*x_15 + 5.160560131073) - 0.000788302250971814*std::sin(0.335599839687347*x_16 - 1.15495979785919) + 0.00468648429689974*std::sin(0.356399834156036*x_17 + 1.99591982364655) + 0.00729417343709639*std::sin(0.361359834671021*x_17 + 1.98919987678528) - 0.0107470305119537*std::sin(0.375039845705032*x_17 + 1.98655986785889) + 0.0321635975521659*std::sin(0.31415992975235*x_18 - 1.15887987613678) + 0.000797280511723084*std::sin(0.38783985376358*x_18 + 1.99743974208832) - 5.10965983026745e-5*std::sin(0.209199994802475*x_19 - 1.17927992343903) - 0.00216449005892647*std::sin(0.225599989295006*x_19 - 1.18735992908478) - 0.0331433395337713*std::sin(0.309599906206131*x_19 + 1.9851998090744) - 0.0126416040019545*std::sin(0.361839860677719*x_2 - 7.40703964233398) + 0.00136590358077735*std::sin(0.371599853038788*x_2 - 7.41815996170044) + 0.000168439455126573*std::sin(0.392399847507477*x_2 + 5.18391990661621) + 0.00558081514121202*std::sin(0.250399976968765*x_20 - 1.17255985736847) + 0.00805895221076971*std::sin(0.315199911594391*x_21 + 1.98335981369019) + 0.0112392419548887*std::sin(0.248879969120026*x_22 - 1.15287983417511) - 0.000364431991598362*std::sin(0.301199942827225*x_23 + 8.23463916778564) - 0.00163507217585937*std::sin(0.348559856414795*x_23 + 1.98695981502533) + 0.0317623189056026*std::sin(0.352319836616516*x_23 - 1.16951990127563) - 1.63106943430914e-5*std::sin(0.334399849176407*x_25 - 4.35735988616943) + 0.010618412970913*std::sin(0.354479849338531*x_25 - 1.15239989757538) + 0.000556894410217876*std::sin(0.305039942264557*x_26 - 4.39551973342896) + 0.0213791707053361*std::sin(0.336399853229523*x_26 - 1.15855991840363) + 1.53790244724516e-5*std::sin(0.343119859695435*x_26 + 5.04207992553711) - 0.0141756099981385*std::sin(0.348079830408096*x_3 - 7.39111995697021) + 0.000958263985533631*std::sin(0.350639849901199*x_3 - 7.41487979888916) - 0.0214263213675729*std::sin(0.354399859905243*x_3 - 7.40895986557007) - 1.64794431261139e-5*std::sin(0.361919850111008*x_3 - 7.39071989059448) + 0.00730774202497176*std::sin(0.372799843549728*x_3 - 7.38903999328613) - 0.000963720309680222*std::sin(0.400879859924316*x_3 - 1.17607986927032) + 0.00903036829834335*std::sin(0.29751992225647*x_30 + 2.00103974342346) - 0.00130195463978467*std::sin(0.355439841747284*x_31 + 8.35223960876465) + 0.0228438675787416*std::sin(0.377839833498001*x_31 + 5.16879987716675) - 0.10684341601526*std::sin(0.381759852170944*x_31 + 5.17304039001465) + 0.000124646577614302*std::sin(0.38223984837532*x_31 - 7.39759969711304) - 0.000292177756156474*std::sin(0.392079830169678*x_31 + 8.40104007720947) - 0.00235250949477748*std::sin(0.409919857978821*x_31 + 5.20584011077881) - 0.0102501181356218*std::sin(0.420639842748642*x_31 + 2.00063967704773) - 0.000523903311288429*std::sin(0.278239965438843*x_32 + 2.04231977462769) - 0.000651802555774156*std::sin(0.291119933128357*x_32 + 2.01647973060608) - 0.0083611022078253*std::sin(0.30311992764473*x_32 - 1.14807987213135) + 0.00260296964662272*std::sin(0.320479840040207*x_32 + 2.01711988449097) - 9.91821170183591e-6*std::sin(0.362319827079773*x_32 + 8.21008014678955) + 4.63679580732437e-5*std::sin(0.23743999004364*x_33 + 1.99071979522705) + 0.00507657550625416*std::sin(0.244079977273941*x_34 + 1.97359979152679) - 0.00740326265522803*std::sin(0.254639983177185*x_37 + 1.97111976146698) + 0.00519917283481917*std::sin(0.361039847135544*x_4 + 2.00863981246948) - 0.00906160540608516*std::sin(0.217840000987053*x_40 - 1.18151986598969) + 0.00186945752974364*std::sin(0.227999985218048*x_44 - 7.59743976593018) - 0.00414040246004482*std::sin(0.19463999569416*x_47 - 1.1743198633194) - 0.0103875216686674*std::sin(0.178720012307167*x_48 + 1.99559986591339) + 0.00357516289426612*std::sin(0.357679843902588*x_5 + 1.99735975265503) + 0.14365502112426*std::sin(0.361199855804443*x_5 + 2.02967977523804) + 0.00105023747106764*std::sin(0.382959842681885*x_5 + 2.00695967674255) - 0.000195326919592085*std::sin(0.530799865722656*x_5 + 1.86231982707977) + 0.000492781061407711*std::sin(0.24551996588707*x_52 - 7.42375993728638) + 0.000869695670392048*std::sin(0.238559976220131*x_53 - 7.40831995010376) - 0.00420609199867519*std::sin(0.258159965276718*x_53 - 7.43439960479736) + 0.00340809650834095*std::sin(0.34487983584404*x_6 + 2.00751972198486) + 0.00341988677601807*std::sin(0.378239840269089*x_6 + 1.9968798160553) - 0.00669582606484396*std::sin(0.478239864110947*x_6 + 5.13472032546997) + 0.00422082513242912*std::sin(0.353279858827591*x_7 + 1.99943971633911) - 0.00411363190223432*std::sin(0.357119828462601*x_7 - 1.14767980575562) - 0.017884751566076*std::sin(0.324799835681915*x_8 - 4.32855987548828) + 0.00526838587670543*std::sin(0.330319821834564*x_8 - 1.13239991664886) - 0.0236418167166584*std::sin(0.356479853391647*x_9 - 4.36567974090576) + 0.000178266834214854*std::sin(0.309759914875031*x_91 - 4.35207986831665) + 0.0102723501743229*std::sin(0.363919854164124*x_91 - 7.40927982330322) - 0.00959332779781499*std::sin(0.366639852523804*x_91 + 1.99207985401154) + 0.000846788897784683*std::sin(0.368159830570221*x_91 + 2.00927972793579) - 0.00050902077217538*std::sin(0.389919847249985*x_91 + 2.01271986961365) + 1.5010524959643e-5*std::sin(0.395359843969345*x_91 + 1.99727976322174) - 0.00187543259323613*std::sin(0.294639945030212*x_92 - 7.40287971496582) - 0.00655137562300845*std::sin(0.297439932823181*x_92 + 8.22743988037109) - 0.132961875467139*std::sin(0.302079945802689*x_92 + 1.98719990253448) + 0.00396899897669974*std::sin(0.314319908618927*x_92 + 5.02783966064453) - 0.00224170097406431*std::sin(0.320639848709106*x_92 - 1.1794399023056) + 0.00358209964739279*std::sin(0.271519958972931*x_94 - 1.19207990169525) - 0.0578869063137341*std::sin(0.299519926309586*x_94 + 1.98151981830597) + 0.0114591194284018*std::sin(0.25943997502327*x_97 - 1.19791984558105) + 0.00816865683882994*std::sin(0.274719953536987*x_97 + 1.97767972946167) + 0.00794752147245261*std::sin(0.248719975352287*x_98 - 7.43247985839844) + 1.90942019556049e-5*std::sin(0.262879967689514*x_98 + 1.96247982978821) + 0.982224296035041);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000300138180380814*x_1 - 0.00268599841027323*x_10 - 0.00888074598381001*x_100 - 0.00183383208654826*x_101 + 0.00815955187743761*x_102 - 0.00371702672996178*x_103 - 0.000475589461798976*x_104 + 0.00631825881944131*x_105 - 0.00106354147527534*x_106 - 0.0040811626849367*x_107 + 0.00240161432200477*x_108 + 0.00668092578623747*x_109 - 0.00583802351257198*x_11 - 0.0145571037263643*x_110 - 0.00420788413792656*x_111 + 0.00698464697893525*x_112 + 0.00427702419640587*x_113 + 0.00121709577370431*x_114 - 0.00116570663779643*x_115 + 0.00534255894520168*x_116 - 0.000689034066345153*x_117 - 0.00362060002669482*x_118 + 0.00153233419661026*x_119 + 0.00480150457265324*x_12 - 0.0123755569925629*x_120 + 0.00314089978881914*x_13 + 0.0146297552180184*x_14 + 0.00245100436922725*x_15 + 0.0108414613379611*x_16 + 0.000302713562467546*x_17 + 0.00224497747553989*x_18 + 0.00220774316871263*x_19 - 0.002805912190846*x_2 + 0.00222571058747604*x_20 - 0.00050573100388027*x_21 + 0.00242509962954249*x_22 + 0.00216100190051003*x_23 + 0.00366601123367031*x_24 - 0.00047043967319499*x_25 + 0.00519505289491085*x_26 + 0.00243555470806395*x_27 - 0.00201351353595037*x_28 - 0.0090631760190169*x_29 - 0.000351062004870407*x_3 + 0.00750061355636082*x_30 - 8.29737137843341e-6*x_31 + 0.00171727885896937*x_32 + 0.00894518737017517*x_33 + 0.000793612131721947*x_34 - 0.00356232136468629*x_35 + 0.00138969972714896*x_36 - 0.00958508945819541*x_37 - 0.00145048384347064*x_38 - 0.00924525526410178*x_39 - 0.000472521980159167*x_4 - 0.00676910472614741*x_40 + 0.00141230082110559*x_41 - 9.3704393287855e-5*x_42 - 0.00400611898816796*x_43 + 0.000339492254573416*x_44 - 0.000696830060791973*x_45 - 0.00109912289811332*x_46 + 0.00472299095462667*x_47 + 0.00405988422377736*x_48 + 0.00520142965967149*x_49 + 0.000141432698219402*x_5 - 0.00327173950688086*x_50 - 0.0052337610949021*x_51 - 0.0028384947100023*x_52 - 0.00112138998775078*x_53 - 0.00462385369984189*x_54 - 0.0011335503476458*x_55 + 0.000841237141236286*x_56 - 0.00334110287728275*x_57 - 0.00233767138798842*x_58 - 0.00543757803847326*x_59 - 0.000289061920475782*x_6 - 0.00247722111916704*x_60 - 0.00295408941270074*x_61 + 0.00194911633351792*x_62 + 0.00410677456416491*x_63 + 1.98493772671628e-5*x_64 + 0.000214767178329369*x_65 + 0.00432714161093097*x_66 + 0.00217181524261063*x_67 + 0.00651696764158099*x_68 + 0.00142970653654332*x_69 - 0.00223809927808174*x_7 + 0.000517993955407091*x_70 - 0.00254094113927006*x_71 - 0.00029755703798179*x_72 + 0.0027087975870324*x_73 + 0.0038966789434979*x_74 - 0.000166358423790339*x_75 + 0.000813129551416939*x_76 + 0.00341315718483835*x_77 + 0.00499767426566353*x_78 + 0.00234009345996212*x_79 + 0.000501594338432623*x_8 - 0.000527316451873214*x_80 - 0.00682219019495815*x_81 + 0.00025642005560365*x_82 - 2.7615764594096e-5*x_83 + 0.00708633178141957*x_84 - 0.00153193164408539*x_85 - 0.00315446805317781*x_86 - 0.00307635179652524*x_87 + 0.00188553699698749*x_88 - 0.00145281196389694*x_89 + 0.000158560134915993*x_9 + 3.12479185765974e-5*x_90 - 0.0019491816128812*x_91 + 0.00589779013912514*x_92 + 3.39369908602728e-5*x_93 + 0.00194003357762651*x_94 - 0.0043757894059626*x_95 + 0.00572503388038682*x_96 + 0.000875884322404859*x_97 + 0.00507185627889783*x_98 - 0.00391996362106303*x_99 - 1.535709052149e-5*std::pow(-6.59912014007568*x_1 - 8.60007953643799, 2) + 0.00023658752580637*std::pow(-4.72503995895386*x_1 - 6.98927974700928, 2) - 0.000994595636910561*std::sin(0.228559985756874*x_1 + 5.03671979904175) - 0.454592874588645*std::sin(0.242399975657463*x_1 + 5.05503988265991) + 0.00137273791401232*std::sin(0.259359985589981*x_1 + 5.07639980316162) - 0.150115988441124*std::sin(0.297599911689758*x_1 - 4.29648017883301) - 0.0156559908746815*std::sin(0.337439835071564*x_1 - 4.25399971008301) - 0.000419297954866188*std::sin(0.224879994988441*x_104 + 1.98151981830597) + 0.00938781976645888*std::sin(0.231359988451004*x_104 - 1.1904798746109) - 0.00107010239346973*std::sin(0.263839960098267*x_107 + 1.94431984424591) + 0.0008071561049228*std::sin(0.214719995856285*x_108 + 8.3810396194458) - 0.0317920742580353*std::sin(0.252159982919693*x_108 + 1.96295976638794) - 0.00257349942345329*std::sin(0.260559976100922*x_108 + 1.96167981624603) - 0.00306920779740576*std::sin(0.224639996886253*x_109 + 1.97367978096008) - 0.017131293898765*std::sin(0.172640010714531*x_11 + 5.20760011672974) - 0.000538313895452142*std::sin(0.280799955129623*x_11 - 7.42807960510254) - 0.0203821285974442*std::sin(0.301519930362701*x_11 + 5.14408016204834) - 0.00193192411709638*std::sin(0.216559991240501*x_111 + 1.96263980865479) - 0.00010550521939829*std::sin(0.235519990324974*x_113 - 4.19479990005493) - 0.000111021637403273*std::sin(0.259679973125458*x_113 - 7.40687990188599) - 0.112850114828027*std::sin(0.282799929380417*x_113 - 7.41304016113281) + 0.023324051212886*std::sin(0.289039939641953*x_113 - 7.42664003372192) + 0.00646278352180454*std::sin(0.289839953184128*x_113 - 7.42519998550415) - 0.0109830139612618*std::sin(0.293839931488037*x_113 - 7.44047975540161) - 0.00493771566729989*std::sin(0.237039983272552*x_119 + 5.1701602935791) + 5.65395432885551e-5*std::sin(0.24695996940136*x_12 + 2.14351987838745) - 0.00080308700875583*std::sin(0.26895996928215*x_12 - 4.22751998901367) - 0.000578992454284499*std::sin(0.278319954872131*x_12 + 5.14752006530762) - 0.014423899433489*std::sin(0.293199926614761*x_12 - 7.44055986404419) - 0.0116853700708376*std::sin(0.264879941940308*x_120 + 5.16535997390747) + 0.00121753448323113*std::sin(0.269759953022003*x_120 + 5.14287996292114) + 0.117458687963895*std::sin(0.301679939031601*x_13 - 7.43824005126953) - 0.000369999545876229*std::sin(0.310639947652817*x_13 - 7.45991992950439) + 0.0397198853344477*std::sin(0.319199919700623*x_13 - 7.46647977828979) + 0.0716309849484878*std::sin(0.293279945850372*x_15 + 5.1560001373291) + 0.0326871786162234*std::sin(0.299439936876297*x_15 + 5.160560131073) + 0.00891603936279492*std::sin(0.335599839687347*x_16 - 1.15495979785919) + 0.00696698467399462*std::sin(0.383199840784073*x_16 - 7.57936000823975) - 0.0530061640858773*std::sin(0.356399834156036*x_17 + 1.99591982364655) - 0.00561806057429278*std::sin(0.361359834671021*x_17 + 1.98919987678528) - 0.0775448065154679*std::sin(0.375039845705032*x_17 + 1.98655986785889) + 0.232075264534694*std::sin(0.31415992975235*x_18 - 1.15887987613678) - 0.00901758737457476*std::sin(0.38783985376358*x_18 + 1.99743974208832) + 0.00899788790759071*std::sin(0.209199994802475*x_19 - 1.17927992343903) + 0.0244813186084087*std::sin(0.225599989295006*x_19 - 1.18735992908478) - 0.239144557053606*std::sin(0.309599906206131*x_19 + 1.9851998090744) - 0.00078146791185451*std::sin(0.361839860677719*x_2 - 7.40703964233398) - 0.00105203545290325*std::sin(0.371599853038788*x_2 - 7.41815996170044) - 0.0296614527539934*std::sin(0.392399847507477*x_2 + 5.18391990661621) - 0.0390703265904587*std::sin(0.404959857463837*x_2 + 5.19816017150879) + 0.0402681680155765*std::sin(0.250399976968765*x_20 - 1.17255985736847) - 0.00620710243263121*std::sin(0.315199911594391*x_21 + 1.98335981369019) + 0.0101998104755699*std::sin(0.377199828624725*x_21 - 1.18823993206024) + 0.0810963402218848*std::sin(0.248879969120026*x_22 - 1.15287983417511) + 5.98377116424161e-5*std::sin(0.301199942827225*x_23 + 8.23463916778564) - 0.0105635468786515*std::sin(0.348559856414795*x_23 + 1.98695981502533) + 0.00701384219713774*std::sin(0.352319836616516*x_23 - 1.16951990127563) + 0.0269134050470095*std::sin(0.258719980716705*x_25 - 1.17999982833862) + 0.00287224207225608*std::sin(0.334399849176407*x_25 - 4.35735988616943) + 0.0766167713411556*std::sin(0.354479849338531*x_25 - 1.15239989757538) - 0.00629871661066788*std::sin(0.305039942264557*x_26 - 4.39551973342896) + 0.00132159937027747*std::sin(0.336399853229523*x_26 - 1.15855991840363) - 0.00270817907508279*std::sin(0.343119859695435*x_26 + 5.04207992553711) - 0.000876295788318989*std::sin(0.348079830408096*x_3 - 7.39111995697021) - 0.000157341631266193*std::sin(0.350639849901199*x_3 - 7.41487979888916) + 0.000563695328664043*std::sin(0.354399859905243*x_3 - 7.40895986557007) + 0.00290195799630222*std::sin(0.361919850111008*x_3 - 7.39071989059448) + 0.0527287459322911*std::sin(0.372799843549728*x_3 - 7.38903999328613) + 0.010900093466993*std::sin(0.400879859924316*x_3 - 1.17607986927032) + 0.00857836467877256*std::sin(0.460159868001938*x_3 + 8.19824028015137) - 0.00695529884856448*std::sin(0.29751992225647*x_30 + 2.00103974342346) + 0.0147256700111956*std::sin(0.355439841747284*x_31 + 8.35223960876465) - 0.0175946230118133*std::sin(0.377839833498001*x_31 + 5.16879987716675) - 0.0235934555647947*std::sin(0.381759852170944*x_31 + 5.17304039001465) - 0.0219497181944417*std::sin(0.38223984837532*x_31 - 7.39759969711304) - 0.022558101093074*std::sin(0.388639837503433*x_31 - 7.40663957595825) - 0.00188764353624691*std::sin(0.392079830169678*x_31 + 8.40104007720947) - 0.0169744464199122*std::sin(0.409919857978821*x_31 + 5.20584011077881) - 0.000633633074922135*std::sin(0.420639842748642*x_31 + 2.00063967704773) - 0.00338472959810922*std::sin(0.278239965438843*x_32 + 2.04231977462769) + 0.00737216878029757*std::sin(0.291119933128357*x_32 + 2.01647973060608) - 0.000516859496796544*std::sin(0.30311992764473*x_32 - 1.14807987213135) + 0.0793041035120755*std::sin(0.31879985332489*x_32 + 1.9916797876358) - 0.00200483869404581*std::sin(0.320479840040207*x_32 + 2.01711988449097) + 0.00174655378442683*std::sin(0.362319827079773*x_32 + 8.21008014678955) - 0.00816519500526269*std::sin(0.23743999004364*x_33 + 1.99071979522705) - 0.00391003983522774*std::sin(0.244079977273941*x_34 + 1.97359979152679) - 0.0156482631460252*std::sin(0.211040005087852*x_36 + 8.18279933929443) - 0.000457648586935412*std::sin(0.254639983177185*x_37 + 1.97111976146698) - 0.0207297206037939*std::sin(0.311999946832657*x_4 - 7.37815999984741) - 0.00400446577999919*std::sin(0.361039847135544*x_4 + 2.00863981246948) - 0.000560162607027406*std::sin(0.217840000987053*x_40 - 1.18151986598969) + 0.0074906311377095*std::sin(0.230159983038902*x_42 - 7.42208003997803) + 0.000115564533728757*std::sin(0.227999985218048*x_44 - 7.59743976593018) + 0.00318898803587295*std::sin(0.19463999569416*x_47 - 1.1743198633194) - 0.0749507835746906*std::sin(0.178720012307167*x_48 + 1.99559986591339) - 0.0404366384269279*std::sin(0.357679843902588*x_5 + 1.99735975265503) + 0.0317222949617298*std::sin(0.361199855804443*x_5 + 2.02967977523804) + 0.00678516393535257*std::sin(0.382959842681885*x_5 + 2.00695967674255) + 3.20715967862496e-5*std::sin(0.530799865722656*x_5 + 1.86231982707977) - 0.097458234278823*std::sin(0.232719987630844*x_52 - 7.42647981643677) - 8.09119169972752e-5*std::sin(0.24551996588707*x_52 - 7.42375993728638) - 0.0877970983625261*std::sin(0.237919986248016*x_53 - 7.41623973846436) - 0.000142799205177713*std::sin(0.238559976220131*x_53 - 7.40831995010376) + 0.0001106561584189*std::sin(0.258159965276718*x_53 - 7.43439960479736) + 0.0569795824904199*std::sin(0.273599952459335*x_6 + 2.01239991188049) + 0.0220183474248812*std::sin(0.34487983584404*x_6 + 2.00751972198486) - 0.0386803983797951*std::sin(0.378239840269089*x_6 + 1.9968798160553) - 0.000413916874174007*std::sin(0.478239864110947*x_6 + 5.13472032546997) + 0.068830081790357*std::sin(0.33927983045578*x_7 + 2.03287982940674) + 0.0272690617645494*std::sin(0.353279858827591*x_7 + 1.99943971633911) + 0.0465269557700166*std::sin(0.357119828462601*x_7 - 1.14767980575562) - 0.00394935979303899*std::sin(0.324799835681915*x_8 - 4.32855987548828) + 0.0380138460576193*std::sin(0.330319821834564*x_8 - 1.13239991664886) - 0.00522065067721004*std::sin(0.356479853391647*x_9 - 4.36567974090576) + 0.00115171066326027*std::sin(0.309759914875031*x_91 - 4.35207986831665) + 0.000635007396159962*std::sin(0.363919854164124*x_91 - 7.40927982330322) + 0.00738889706173834*std::sin(0.366639852523804*x_91 + 1.99207985401154) - 0.00957754863102112*std::sin(0.368159830570221*x_91 + 2.00927972793579) + 8.35783874292755e-5*std::sin(0.389919847249985*x_91 + 2.01271986961365) - 0.00264328791949915*std::sin(0.395359843969345*x_91 + 1.99727976322174) + 0.0212119536674516*std::sin(0.294639945030212*x_92 - 7.40287971496582) + 0.000172357156959402*std::sin(0.297439932823181*x_92 + 8.22743988037109) - 0.0293610052695962*std::sin(0.302079945802689*x_92 + 1.98719990253448) + 0.028638167293369*std::sin(0.314319908618927*x_92 + 5.02783966064453) + 0.00172658519438191*std::sin(0.320639848709106*x_92 - 1.1794399023056) + 0.000221435185841135*std::sin(0.271519958972931*x_94 - 1.19207990169525) - 0.0127827450940117*std::sin(0.299519926309586*x_94 + 1.98151981830597) + 0.000708370087373415*std::sin(0.25943997502327*x_97 - 1.19791984558105) + 0.0589406453581537*std::sin(0.274719953536987*x_97 + 1.97767972946167) + 0.000491293115061681*std::sin(0.248719975352287*x_98 - 7.43247985839844) - 0.0033624056118906*std::sin(0.262879967689514*x_98 + 1.96247982978821) + 0.560282717907502);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000118615114149718*x_1 + 0.00170046232590515*x_10 + 0.00332707224758222*x_100 + 0.000560917056483388*x_101 - 0.000765088170207761*x_102 - 0.000148383284775968*x_103 + 0.000663753296796977*x_104 - 0.00132322564552555*x_105 + 0.000114331040664789*x_106 + 0.0022663994588831*x_107 - 0.00198517237277939*x_108 - 0.00226649474970605*x_109 + 0.00374251365944155*x_11 + 0.00673353572298037*x_110 - 0.00178749267378767*x_111 - 0.00434378258410159*x_112 - 0.00276789279091667*x_113 - 0.00117721250531708*x_114 + 0.000152591433262402*x_115 - 0.00152041415189254*x_116 - 0.00345932616767631*x_117 + 0.000100073920782344*x_118 - 0.000718164080499613*x_119 + 0.00388723550319935*x_12 - 0.00248218311794558*x_120 - 0.000423502571593265*x_13 - 0.00172396807621426*x_14 - 0.000187968259805621*x_15 - 0.00469577701814376*x_16 + 5.34363780267387e-5*x_17 + 0.000202937946555217*x_18 + 0.000268572525951447*x_19 + 0.00104788788042979*x_2 - 3.56884764028196e-5*x_20 - 0.000947210473627597*x_21 + 0.000599661356426782*x_22 - 0.000175542338205257*x_23 - 0.00021869704894574*x_24 - 0.000658275605279278*x_25 + 0.000465855526799963*x_26 - 0.000627176727955236*x_27 - 4.42716079386972e-5*x_28 + 0.00278317881358066*x_29 - 9.57069310411339e-5*x_3 - 0.0106287371438544*x_30 - 0.000244759345167241*x_31 - 0.000733893843866298*x_32 - 3.31623185988762e-5*x_33 + 0.0012555010662956*x_34 + 0.000513004481081688*x_35 - 0.000597078973881093*x_36 + 0.00516290722471331*x_37 + 0.00272074331347091*x_38 + 0.00378366974838358*x_39 - 0.000148734570226707*x_4 - 0.000911187238965115*x_40 + 0.000147257372088487*x_41 + 0.00136234667651375*x_42 + 0.00108641500241836*x_43 + 0.000686239522331907*x_44 + 0.00128635548688539*x_45 + 0.000732807046188028*x_46 + 0.000139800651991913*x_47 - 0.000740981381803292*x_48 + 0.000900886419586606*x_49 - 0.00053160014920261*x_5 + 0.00405279964562794*x_50 + 0.0016318506863514*x_51 + 0.00156299448809065*x_52 + 0.000957389586200861*x_53 + 0.00456252249503608*x_54 + 0.00327509600941678*x_55 + 0.000874839530906546*x_56 + 0.000772158860909384*x_57 + 0.000829306850306342*x_58 + 0.00159120431801695*x_59 + 8.27280123967298e-5*x_6 + 0.000528811943948637*x_60 + 0.000422186068995027*x_61 - 0.000580341229564919*x_62 - 0.000165570011523638*x_63 - 0.000667795025947514*x_64 - 0.000905076032739644*x_65 - 0.000579937039651532*x_66 - 0.000896699805823492*x_67 - 0.00213223005897569*x_68 - 0.00103339583563125*x_69 + 0.00177511359615167*x_7 + 9.92455884018093e-5*x_70 + 0.00107374413832536*x_71 - 0.000252015429017414*x_72 - 0.00130501570522033*x_73 - 0.000696516972588126*x_74 - 0.000335418380971738*x_75 - 0.000255098066743325*x_76 - 0.000839960600949873*x_77 - 0.00131539003406289*x_78 - 0.00122315912438816*x_79 + 0.000347618219634869*x_8 - 0.0015291202808697*x_80 + 0.00284130585462237*x_81 - 0.000106115150961308*x_82 - 0.000582987453156167*x_83 - 0.00209927862229197*x_84 + 0.00133748478797763*x_85 + 0.00141927974121958*x_86 + 0.0010077876258086*x_87 - 0.000270656783287952*x_88 + 0.000887457685213413*x_89 + 0.000212477711313369*x_9 - 3.51513759265507e-5*x_90 + 0.000798906686484874*x_91 + 0.00316735706872064*x_92 - 8.13530354253857e-5*x_93 + 0.00098874052613336*x_94 + 0.00191201737402151*x_95 + 0.000161145025185327*x_96 - 1.80639001750896e-5*x_97 + 0.00107685568146442*x_98 + 0.00293727724885591*x_99 + 5.84652983933455e-6*std::pow(-6.59912014007568*x_1 - 8.60007953643799, 2) - 9.68716596228459e-5*std::pow(-4.72503995895386*x_1 - 6.98927974700928, 2) - 0.0325771566875418*std::sin(0.228559985756874*x_1 + 5.03671979904175) - 0.178574428830913*std::sin(0.242399975657463*x_1 + 5.05503988265991) + 0.00706337622852582*std::sin(0.259359985589981*x_1 + 5.07639980316162) - 0.00366780024749091*std::sin(0.297599911689758*x_1 - 4.29648017883301) + 0.0145343880026581*std::sin(0.337439835071564*x_1 - 4.25399971008301) + 0.00168292948773855*std::sin(0.224879994988441*x_104 + 1.98151981830597) - 0.00357399523784089*std::sin(0.231359988451004*x_104 - 1.1904798746109) - 0.00121408579697734*std::sin(0.263839960098267*x_107 + 1.94431984424591) - 0.00074933104532107*std::sin(0.214719995856285*x_108 + 8.3810396194458) + 0.0130173853660788*std::sin(0.252159982919693*x_108 + 1.96295976638794) - 0.000148349088933413*std::sin(0.260559976100922*x_108 + 1.96167981624603) - 0.000176924143189238*std::sin(0.224639996886253*x_109 + 1.97367978096008) + 0.0065219789403066*std::sin(0.172640010714531*x_11 + 5.20760011672974) - 0.00276987583267672*std::sin(0.280799955129623*x_11 - 7.42807960510254) - 0.00117492554317232*std::sin(0.301519930362701*x_11 + 5.14408016204834) - 0.000111365551531835*std::sin(0.216559991240501*x_111 + 1.96263980865479) - 0.000542873516551385*std::sin(0.235519990324974*x_113 - 4.19479990005493) - 0.00363642182126233*std::sin(0.259679973125458*x_113 - 7.40687990188599) - 0.0443300938606952*std::sin(0.282799929380417*x_113 - 7.41304016113281) - 0.00887959611877544*std::sin(0.289039939641953*x_113 - 7.42664003372192) + 0.00037254643956635*std::sin(0.289839953184128*x_113 - 7.42519998550415) + 0.0101961854493504*std::sin(0.293839931488037*x_113 - 7.44047975540161) - 0.00560209050812752*std::sin(0.237039983272552*x_119 + 5.1701602935791) + 0.00185190593282177*std::sin(0.24695996940136*x_12 + 2.14351987838745) + 0.00322333746818835*std::sin(0.26895996928215*x_12 - 4.22751998901367) - 0.00297918597304237*std::sin(0.278319954872131*x_12 + 5.14752006530762) - 0.000831464083622748*std::sin(0.293199926614761*x_12 - 7.44055986404419) - 0.0132576489147245*std::sin(0.264879941940308*x_120 + 5.16535997390747) - 0.00488679866044684*std::sin(0.269759953022003*x_120 + 5.14287996292114) - 0.0480939052107798*std::sin(0.301679939031601*x_13 - 7.43824005126953) - 0.00190382007390527*std::sin(0.310639947652817*x_13 - 7.45991992950439) + 0.0156028750851994*std::sin(0.319199919700623*x_13 - 7.46647977828979) - 0.0293295784244271*std::sin(0.293279945850372*x_15 + 5.1560001373291) + 0.000798649384808099*std::sin(0.299439936876297*x_15 + 5.160560131073) - 0.003394385812229*std::sin(0.335599839687347*x_16 - 1.15495979785919) + 0.00273679016627373*std::sin(0.383199840784073*x_16 - 7.57936000823975) + 0.0201797417006225*std::sin(0.356399834156036*x_17 + 1.99591982364655) - 0.00637397653853599*std::sin(0.361359834671021*x_17 + 1.98919987678528) + 0.0317510150912766*std::sin(0.375039845705032*x_17 + 1.98655986785889) - 0.0950240971338711*std::sin(0.31415992975235*x_18 - 1.15887987613678) + 0.00343304570553139*std::sin(0.38783985376358*x_18 + 1.99743974208832) + 0.000518682250810414*std::sin(0.209199994802475*x_19 - 1.17927992343903) - 0.00932017425761915*std::sin(0.225599989295006*x_19 - 1.18735992908478) + 0.0979186457637378*std::sin(0.309599906206131*x_19 + 1.9851998090744) + 0.00313656524511581*std::sin(0.361839860677719*x_2 - 7.40703964233398) - 0.0011935879305391*std::sin(0.371599853038788*x_2 - 7.41815996170044) - 0.00170983115535027*std::sin(0.392399847507477*x_2 + 5.18391990661621) - 0.0153477136249479*std::sin(0.404959857463837*x_2 + 5.19816017150879) - 0.0164879540979395*std::sin(0.250399976968765*x_20 - 1.17255985736847) - 0.00704227459898141*std::sin(0.315199911594391*x_21 + 1.98335981369019) + 0.00400671772848758*std::sin(0.377199828624725*x_21 - 1.18823993206024) - 0.0332052040354082*std::sin(0.248879969120026*x_22 - 1.15287983417511) + 0.001959934706786*std::sin(0.301199942827225*x_23 + 8.23463916778564) + 0.00980676919446101*std::sin(0.348559856414795*x_23 + 1.98695981502533) + 0.000171369968073811*std::sin(0.352319836616516*x_23 - 1.16951990127563) + 0.0105721981201612*std::sin(0.258719980716705*x_25 - 1.17999982833862) + 0.000165570075801162*std::sin(0.334399849176407*x_25 - 4.35735988616943) - 0.0313710275698821*std::sin(0.354479849338531*x_25 - 1.15239989757538) + 0.00239795647243532*std::sin(0.305039942264557*x_26 - 4.39551973342896) - 0.00530448223132032*std::sin(0.336399853229523*x_26 - 1.15855991840363) - 0.000156112682519261*std::sin(0.343119859695435*x_26 + 5.04207992553711) + 0.00351717437451791*std::sin(0.348079830408096*x_3 - 7.39111995697021) - 0.00515359487314253*std::sin(0.350639849901199*x_3 - 7.41487979888916) + 0.00290047513365389*std::sin(0.354399859905243*x_3 - 7.40895986557007) + 0.000167283046948109*std::sin(0.361919850111008*x_3 - 7.39071989059448) - 0.021589984978637*std::sin(0.372799843549728*x_3 - 7.38903999328613) - 0.00414972625297304*std::sin(0.400879859924316*x_3 - 1.17607986927032) + 0.0033697769112665*std::sin(0.460159868001938*x_3 + 8.19824028015137) - 0.00789114163028352*std::sin(0.29751992225647*x_30 + 2.00103974342346) - 0.00560614453656917*std::sin(0.355439841747284*x_31 + 8.35223960876465) - 0.0199619980594105*std::sin(0.377839833498001*x_31 + 5.16879987716675) - 0.000576461461955861*std::sin(0.381759852170944*x_31 + 5.17304039001465) - 0.00126528907168791*std::sin(0.38223984837532*x_31 - 7.39759969711304) - 0.00886133558923649*std::sin(0.388639837503433*x_31 - 7.40663957595825) + 0.00175241182663761*std::sin(0.392079830169678*x_31 + 8.40104007720947) + 0.00695025145671353*std::sin(0.409919857978821*x_31 + 5.20584011077881) + 0.00254320292721967*std::sin(0.420639842748642*x_31 + 2.00063967704773) + 0.00314224590808606*std::sin(0.278239965438843*x_32 + 2.04231977462769) - 0.00280662568826472*std::sin(0.291119933128357*x_32 + 2.01647973060608) + 0.00207451068645018*std::sin(0.30311992764473*x_32 - 1.14807987213135) + 0.0311524570230696*std::sin(0.31879985332489*x_32 + 1.9916797876358) - 0.00227459185076617*std::sin(0.320479840040207*x_32 + 2.01711988449097) + 0.000100679899257661*std::sin(0.362319827079773*x_32 + 8.21008014678955) - 0.00047068176077886*std::sin(0.23743999004364*x_33 + 1.99071979522705) - 0.00443613981104503*std::sin(0.244079977273941*x_34 + 1.97359979152679) - 0.00614699395811223*std::sin(0.211040005087852*x_36 + 8.18279933929443) + 0.0018368568056128*std::sin(0.254639983177185*x_37 + 1.97111976146698) - 0.00814310611444714*std::sin(0.311999946832657*x_4 - 7.37815999984741) - 0.00454327086608498*std::sin(0.361039847135544*x_4 + 2.00863981246948) + 0.00224831568662379*std::sin(0.217840000987053*x_40 - 1.18151986598969) + 0.00294249041674912*std::sin(0.230159983038902*x_42 - 7.42208003997803) - 0.000463839518632873*std::sin(0.227999985218048*x_44 - 7.59743976593018) + 0.00361806973305639*std::sin(0.19463999569416*x_47 - 1.1743198633194) + 0.030688882561185*std::sin(0.178720012307167*x_48 + 1.99559986591339) + 0.0153944533200862*std::sin(0.357679843902588*x_5 + 1.99735975265503) + 0.00077507427769591*std::sin(0.361199855804443*x_5 + 2.02967977523804) - 0.00629907146008498*std::sin(0.382959842681885*x_5 + 2.00695967674255) + 0.00105047860150554*std::sin(0.530799865722656*x_5 + 1.86231982707977) - 0.0382838128225356*std::sin(0.232719987630844*x_52 - 7.42647981643677) - 0.0026502028564063*std::sin(0.24551996588707*x_52 - 7.42375993728638) - 0.0344886987225364*std::sin(0.237919986248016*x_53 - 7.41623973846436) - 0.00467726974590491*std::sin(0.238559976220131*x_53 - 7.40831995010376) + 0.000569377498018919*std::sin(0.258159965276718*x_53 - 7.43439960479736) + 0.0223828770027641*std::sin(0.273599952459335*x_6 + 2.01239991188049) - 0.0204409422062251*std::sin(0.34487983584404*x_6 + 2.00751972198486) + 0.0147258429588835*std::sin(0.378239840269089*x_6 + 1.9968798160553) + 0.00166133153032504*std::sin(0.478239864110947*x_6 + 5.13472032546997) + 0.027038022875348*std::sin(0.33927983045578*x_7 + 2.03287982940674) - 0.0253154927929449*std::sin(0.353279858827591*x_7 + 1.99943971633911) - 0.0177130710314006*std::sin(0.357119828462601*x_7 - 1.14767980575562) - 9.64951367057099e-5*std::sin(0.324799835681915*x_8 - 4.32855987548828) - 0.0155649134234693*std::sin(0.330319821834564*x_8 - 1.13239991664886) - 0.000127556724935029*std::sin(0.356479853391647*x_9 - 4.36567974090576) - 0.00106920154595223*std::sin(0.309759914875031*x_91 - 4.35207986831665) - 0.0025487190183666*std::sin(0.363919854164124*x_91 - 7.40927982330322) + 0.0083830809394764*std::sin(0.366639852523804*x_91 + 1.99207985401154) + 0.00364622607261353*std::sin(0.368159830570221*x_91 + 2.00927972793579) + 0.00273754088790601*std::sin(0.389919847249985*x_91 + 2.01271986961365) - 0.000152372039050318*std::sin(0.395359843969345*x_91 + 1.99727976322174) - 0.00807550882726094*std::sin(0.294639945030212*x_92 - 7.40287971496582) + 0.00088685788660486*std::sin(0.297439932823181*x_92 + 8.22743988037109) - 0.000717380630222763*std::sin(0.302079945802689*x_92 + 1.98719990253448) - 0.0117260061992274*std::sin(0.314319908618927*x_92 + 5.02783966064453) + 0.00195889904981297*std::sin(0.320639848709106*x_92 - 1.1794399023056) - 0.000888770859838416*std::sin(0.271519958972931*x_94 - 1.19207990169525) - 0.00031232219902957*std::sin(0.299519926309586*x_94 + 1.98151981830597) - 0.00284317367742255*std::sin(0.25943997502327*x_97 - 1.19791984558105) - 0.0241334707551695*std::sin(0.274719953536987*x_97 + 1.97767972946167) - 0.00197189530944431*std::sin(0.248719975352287*x_98 - 7.43247985839844) - 0.000193825498697501*std::sin(0.262879967689514*x_98 + 1.96247982978821) - 0.778348180447174);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000741545769761295*x_1 + 0.00153191879738134*x_10 + 0.00257742251025613*x_100 - 0.000241801546488734*x_101 - 0.00200321650814858*x_102 + 0.000626216366813927*x_103 + 0.00083743472271324*x_104 - 0.00225418823816991*x_105 + 0.000199864846740843*x_106 + 0.00195287006587889*x_107 - 0.00222949946011125*x_108 - 0.00245907485011814*x_109 + 0.00242053255507463*x_11 + 0.00475328700781181*x_110 - 0.00132507605127713*x_111 - 0.00815864274551813*x_112 - 0.000942433136730406*x_113 + 0.000972172786410588*x_114 + 0.000858463464495037*x_115 - 0.00282454082963344*x_116 + 0.00603435271747675*x_117 + 0.000299945885225578*x_118 - 0.00344285107365248*x_119 + 0.00309471026608273*x_12 - 0.00697557800136024*x_120 - 0.000575088635562163*x_13 - 0.00151290479158081*x_14 + 0.000813465291073805*x_15 - 0.00357582121311642*x_16 + 0.000848301829203354*x_17 + 0.000285544909719062*x_18 + 0.000755233313688401*x_19 + 0.000644449216251738*x_2 + 0.00058312999175818*x_20 + 0.000337895298103826*x_21 - 0.00120910753667461*x_22 - 0.00127426298450027*x_23 + 0.000412676303314051*x_24 - 0.000655908776413036*x_25 + 0.000404199705870045*x_26 + 1.82706881946021e-5*x_27 + 0.00161995773563165*x_28 + 0.00409900785946883*x_29 + 0.000369608600441915*x_3 + 0.00235490745159337*x_30 + 1.80217802509857e-5*x_31 - 0.000500186271192749*x_32 - 0.000492861500084175*x_33 + 0.0021516809325746*x_34 + 0.00279536913609089*x_35 - 0.000671615728924979*x_36 + 0.00413648190789137*x_37 + 0.00276784393863628*x_38 + 0.00295845539012482*x_39 + 0.000150771062012983*x_4 - 0.00121220932519038*x_40 - 0.000215783734752107*x_41 - 0.00242400357887764*x_42 - 0.00035796221270696*x_43 + 0.000504159860549722*x_44 + 0.000375306466774764*x_45 + 7.29184878120055e-5*x_46 + 0.000710937602085828*x_47 - 0.00225448717116889*x_48 - 0.00216986125076927*x_49 - 0.000738057579593686*x_5 + 0.00211293493551517*x_50 + 0.0030103496608226*x_51 + 0.000953097901313287*x_52 - 0.000274416057105758*x_53 + 0.00361841722477946*x_54 + 0.00206661802545504*x_55 - 0.000666780073034381*x_56 + 0.00139501620915309*x_57 + 0.00151675483155675*x_58 + 0.00252880153481393*x_59 - 0.00027068299172671*x_6 + 0.0011296761911502*x_60 + 0.000805174794754091*x_61 - 0.00067747026528639*x_62 - 0.000104671621374868*x_63 + 2.9584256584805e-5*x_64 - 0.00054017349435495*x_65 - 0.00076398581308601*x_66 - 0.000381996409535067*x_67 - 0.00139587050535402*x_68 - 0.000790932092755061*x_69 + 0.000970578950167757*x_7 - 0.000350388913002965*x_70 + 0.00101321270887761*x_71 + 0.000114485945361013*x_72 - 0.00137508948287938*x_73 - 0.000549796328158334*x_74 + 0.0002987896082035*x_75 + 0.00019788674844053*x_76 + 4.14224658957525e-5*x_77 - 0.000586101895531079*x_78 - 0.000877154075338013*x_79 + 1.44812774339051e-6*x_8 - 0.0011960392301131*x_80 + 0.00233315874329362*x_81 - 0.000406034029356239*x_82 - 0.000378713339239611*x_83 - 0.00140977417871666*x_84 + 0.000943328959925917*x_85 + 0.00161703295943063*x_86 + 0.00120637860355621*x_87 - 0.000242739030974155*x_88 + 0.000483254797589524*x_89 + 0.000330500508415398*x_9 - 0.00107586536585462*x_90 + 0.000724919002243148*x_91 + 0.00065937292834601*x_92 + 3.77723073079617e-5*x_93 + 0.00126454596630614*x_94 + 0.00310035462849995*x_95 - 0.00037054491487602*x_96 + 0.00119017190085837*x_97 + 0.00138335247555281*x_98 + 0.00314027683192428*x_99 + 5.7535405606487e-6*std::pow(-6.59912014007568*x_1 - 8.60007953643799, 2) - 7.74352915941021e-5*std::pow(-4.72503995895386*x_1 - 6.98927974700928, 2) + 0.0041016107054757*std::sin(0.228559985756874*x_1 + 5.03671979904175) - 0.177888318028679*std::sin(0.242399975657463*x_1 + 5.05503988265991) + 0.0170607498327131*std::sin(0.259359985589981*x_1 + 5.07639980316162) + 0.067558342720638*std::sin(0.297599911689758*x_1 - 4.29648017883301) - 0.0037223713079395*std::sin(0.337439835071564*x_1 - 4.25399971008301) + 0.000405884691025549*std::sin(0.224879994988441*x_104 + 1.98151981830597) - 0.00351715070812387*std::sin(0.231359988451004*x_104 - 1.1904798746109) + 0.0030478079547337*std::sin(0.263839960098267*x_107 + 1.94431984424591) + 0.000191909585924178*std::sin(0.214719995856285*x_108 + 8.3810396194458) + 0.0104055720273568*std::sin(0.252159982919693*x_108 + 1.96295976638794) + 0.00491820503943902*std::sin(0.260559976100922*x_108 + 1.96167981624603) + 0.00586555144280199*std::sin(0.224639996886253*x_109 + 1.97367978096008) + 0.00641824661806938*std::sin(0.172640010714531*x_11 + 5.20760011672974) - 0.00669030745638733*std::sin(0.280799955129623*x_11 - 7.42807960510254) + 0.0389522090694433*std::sin(0.301519930362701*x_11 + 5.14408016204834) + 0.00369209289185202*std::sin(0.216559991240501*x_111 + 1.96263980865479) - 0.00131124676883046*std::sin(0.235519990324974*x_113 - 4.19479990005493) + 0.000457841880271243*std::sin(0.259679973125458*x_113 - 7.40687990188599) - 0.0441597707273049*std::sin(0.282799929380417*x_113 - 7.41304016113281) - 0.00873836580595786*std::sin(0.289039939641953*x_113 - 7.42664003372192) - 0.0123510012071776*std::sin(0.289839953184128*x_113 - 7.42519998550415) - 0.0026113234461713*std::sin(0.293839931488037*x_113 - 7.44047975540161) + 0.0140633356030668*std::sin(0.237039983272552*x_119 + 5.1701602935791) - 0.000233163295141117*std::sin(0.24695996940136*x_12 + 2.14351987838745) + 0.000777396404233638*std::sin(0.26895996928215*x_12 - 4.22751998901367) - 0.00719587134349938*std::sin(0.278319954872131*x_12 + 5.14752006530762) + 0.0275654597920817*std::sin(0.293199926614761*x_12 - 7.44055986404419) + 0.033281641152514*std::sin(0.264879941940308*x_120 + 5.16535997390747) - 0.00117858578083675*std::sin(0.269759953022003*x_120 + 5.14287996292114) - 0.0384443250832625*std::sin(0.301679939031601*x_13 - 7.43824005126953) - 0.00459845220706501*std::sin(0.310639947652817*x_13 - 7.45991992950439) + 0.0155429264060299*std::sin(0.319199919700623*x_13 - 7.46647977828979) - 0.0234448802309151*std::sin(0.293279945850372*x_15 + 5.1560001373291) - 0.0147105690636786*std::sin(0.299439936876297*x_15 + 5.160560131073) - 0.00334039797723377*std::sin(0.335599839687347*x_16 - 1.15495979785919) + 0.00272627499168339*std::sin(0.383199840784073*x_16 - 7.57936000823975) + 0.0198587821440351*std::sin(0.356399834156036*x_17 + 1.99591982364655) + 0.0160010572941399*std::sin(0.361359834671021*x_17 + 1.98919987678528) + 0.0253804788890176*std::sin(0.375039845705032*x_17 + 1.98655986785889) - 0.0759584247722773*std::sin(0.31415992975235*x_18 - 1.15887987613678) + 0.00337844298346793*std::sin(0.38783985376358*x_18 + 1.99743974208832) - 0.0171958296349792*std::sin(0.209199994802475*x_19 - 1.17927992343903) - 0.00917193653280476*std::sin(0.225599989295006*x_19 - 1.18735992908478) + 0.0782722100223669*std::sin(0.309599906206131*x_19 + 1.9851998090744) + 0.00075646889823413*std::sin(0.361839860677719*x_2 - 7.40703964233398) + 0.00299635066848499*std::sin(0.371599853038788*x_2 - 7.41815996170044) + 0.0566858904580674*std::sin(0.392399847507477*x_2 + 5.18391990661621) - 0.0152887453158982*std::sin(0.404959857463837*x_2 + 5.19816017150879) - 0.0131798044787808*std::sin(0.250399976968765*x_20 - 1.17255985736847) + 0.0176787345635962*std::sin(0.315199911594391*x_21 + 1.98335981369019) + 0.00399132329417234*std::sin(0.377199828624725*x_21 - 1.18823993206024) - 0.0265428987893287*std::sin(0.248879969120026*x_22 - 1.15287983417511) - 0.000246764604182325*std::sin(0.301199942827225*x_23 + 8.23463916778564) - 0.00251159087444002*std::sin(0.348559856414795*x_23 + 1.98695981502533) - 0.00315651623696664*std::sin(0.352319836616516*x_23 - 1.16951990127563) + 0.0105315780863686*std::sin(0.258719980716705*x_25 - 1.17999982833862) - 0.00548913098853664*std::sin(0.334399849176407*x_25 - 4.35735988616943) - 0.0250767322139234*std::sin(0.354479849338531*x_25 - 1.15239989757538) + 0.00235981688385551*std::sin(0.305039942264557*x_26 - 4.39551973342896) - 0.00127932165143953*std::sin(0.336399853229523*x_26 - 1.15855991840363) + 0.00517559081357891*std::sin(0.343119859695435*x_26 + 5.04207992553711) + 0.000848263248511076*std::sin(0.348079830408096*x_3 - 7.39111995697021) + 0.000648860798568395*std::sin(0.350639849901199*x_3 - 7.41487979888916) + 0.00700575462077598*std::sin(0.354399859905243*x_3 - 7.40895986557007) - 0.00554592097887564*std::sin(0.361919850111008*x_3 - 7.39071989059448) - 0.0172581618694469*std::sin(0.372799843549728*x_3 - 7.38903999328613) - 0.00408372469963938*std::sin(0.400879859924316*x_3 - 1.17607986927032) + 0.00335682970289476*std::sin(0.460159868001938*x_3 + 8.19824028015137) + 0.0198097072649942*std::sin(0.29751992225647*x_30 + 2.00103974342346) - 0.00551697859523473*std::sin(0.355439841747284*x_31 + 8.35223960876465) + 0.05011205684913*std::sin(0.377839833498001*x_31 + 5.16879987716675) + 0.0106180212618437*std::sin(0.381759852170944*x_31 + 5.17304039001465) + 0.041948023634414*std::sin(0.38223984837532*x_31 - 7.39759969711304) - 0.00882728895607742*std::sin(0.388639837503433*x_31 - 7.40663957595825) - 0.000448806478950244*std::sin(0.392079830169678*x_31 + 8.40104007720947) + 0.00555575026068841*std::sin(0.409919857978821*x_31 + 5.20584011077881) + 0.000613363270327458*std::sin(0.420639842748642*x_31 + 2.00063967704773) - 0.000804753940008392*std::sin(0.278239965438843*x_32 + 2.04231977462769) - 0.00276198620031803*std::sin(0.291119933128357*x_32 + 2.01647973060608) + 0.000500325257316926*std::sin(0.30311992764473*x_32 - 1.14807987213135) + 0.0310327644253131*std::sin(0.31879985332489*x_32 + 1.9916797876358) + 0.00571007350040432*std::sin(0.320479840040207*x_32 + 2.01711988449097) - 0.00333783234841096*std::sin(0.362319827079773*x_32 + 8.21008014678955) + 0.0156044733707375*std::sin(0.23743999004364*x_33 + 1.99071979522705) + 0.0111363646935623*std::sin(0.244079977273941*x_34 + 1.97359979152679) - 0.00612337624877087*std::sin(0.211040005087852*x_36 + 8.18279933929443) + 0.000443008493484875*std::sin(0.254639983177185*x_37 + 1.97111976146698) - 0.00811181903092999*std::sin(0.311999946832657*x_4 - 7.37815999984741) + 0.0114053035795641*std::sin(0.361039847135544*x_4 + 2.00863981246948) + 0.000542243109079661*std::sin(0.217840000987053*x_40 - 1.18151986598969) + 0.00293118490971982*std::sin(0.230159983038902*x_42 - 7.42208003997803) - 0.000111867645719802*std::sin(0.227999985218048*x_44 - 7.59743976593018) - 0.00908270382591113*std::sin(0.19463999569416*x_47 - 1.1743198633194) + 0.0245314530490616*std::sin(0.178720012307167*x_48 + 1.99559986591339) + 0.0151496039565601*std::sin(0.357679843902588*x_5 + 1.99735975265503) - 0.0142763319028488*std::sin(0.361199855804443*x_5 + 2.02967977523804) + 0.00161324184171997*std::sin(0.382959842681885*x_5 + 2.00695967674255) - 0.000132259985705136*std::sin(0.530799865722656*x_5 + 1.86231982707977) - 0.0381367204437431*std::sin(0.232719987630844*x_52 - 7.42647981643677) + 0.000333672472149029*std::sin(0.24551996588707*x_52 - 7.42375993728638) - 0.0343561877639213*std::sin(0.237919986248016*x_53 - 7.41623973846436) + 0.00058888932039725*std::sin(0.238559976220131*x_53 - 7.40831995010376) + 0.00137526400120757*std::sin(0.258159965276718*x_53 - 7.43439960479736) + 0.0222968784989626*std::sin(0.273599952459335*x_6 + 2.01239991188049) + 0.00523508638697318*std::sin(0.34487983584404*x_6 + 2.00751972198486) + 0.0144916278684935*std::sin(0.378239840269089*x_6 + 1.9968798160553) + 0.000400675750107088*std::sin(0.478239864110947*x_6 + 5.13472032546997) + 0.0269341385751866*std::sin(0.33927983045578*x_7 + 2.03287982940674) + 0.00648349720687059*std::sin(0.353279858827591*x_7 + 1.99943971633911) - 0.0174313439652973*std::sin(0.357119828462601*x_7 - 1.14767980575562) + 0.0017773736508412*std::sin(0.324799835681915*x_8 - 4.32855987548828) - 0.012441963049625*std::sin(0.330319821834564*x_8 - 1.13239991664886) + 0.00234950661377429*std::sin(0.356479853391647*x_9 - 4.36567974090576) + 0.000273830941924027*std::sin(0.309759914875031*x_91 - 4.35207986831665) - 0.000614693627283678*std::sin(0.363919854164124*x_91 - 7.40927982330322) - 0.0210446583232613*std::sin(0.366639852523804*x_91 + 1.99207985401154) + 0.00358823270873181*std::sin(0.368159830570221*x_91 + 2.00927972793579) - 0.000344668723553971*std::sin(0.389919847249985*x_91 + 2.01271986961365) + 0.00505157757094985*std::sin(0.395359843969345*x_91 + 1.99727976322174) - 0.00794706755329087*std::sin(0.294639945030212*x_92 - 7.40287971496582) + 0.0021421003286543*std::sin(0.297439932823181*x_92 + 8.22743988037109) + 0.013213654835999*std::sin(0.302079945802689*x_92 + 1.98719990253448) - 0.00937329568634001*std::sin(0.314319908618927*x_92 + 5.02783966064453) - 0.00491756688152055*std::sin(0.320639848709106*x_92 - 1.1794399023056) - 0.00021435151529894*std::sin(0.271519958972931*x_94 - 1.19207990169525) + 0.00575275880297385*std::sin(0.299519926309586*x_94 + 1.98151981830597) - 0.000685709459606251*std::sin(0.25943997502327*x_97 - 1.19791984558105) - 0.0192913216556843*std::sin(0.274719953536987*x_97 + 1.97767972946167) - 0.000475576739393895*std::sin(0.248719975352287*x_98 - 7.43247985839844) + 0.00642588067995289*std::sin(0.262879967689514*x_98 + 1.96247982978821) - 0.662515437831474);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000117077860325782*x_1 + 0.000521864262761091*x_10 + 0.00152150226631424*x_100 + 0.00130358760079522*x_101 - 0.00160270706443899*x_102 + 0.000308510283295994*x_103 - 0.000220304488881921*x_104 - 0.00151171129002229*x_105 - 0.00210290304236358*x_106 - 0.000708717449917327*x_107 + 0.00141571759154842*x_108 - 0.000201395556417935*x_109 + 0.00204935285508247*x_11 + 0.00108754999516994*x_110 + 0.0014713741325838*x_111 + 0.00161280136458256*x_112 + 0.00136538921184895*x_113 + 0.000439811522544101*x_114 - 0.00020578806729125*x_115 + 0.00228097245380642*x_116 + 0.000610915081515632*x_117 + 0.00112224336017737*x_118 + 0.00233717284788089*x_119 - 0.00106233020629095*x_12 + 0.00792291702716351*x_120 + 0.00412002520677848*x_13 - 0.00189231023831273*x_14 - 0.00154627304584558*x_15 - 0.00152758184511694*x_16 - 0.00114880202171085*x_17 + 0.000446142690630977*x_18 + 0.000334771878242651*x_19 + 5.71713638535259e-6*x_2 - 0.00128737165249184*x_20 - 0.00178447742984863*x_21 - 0.00137477496709802*x_22 + 8.98161740551087e-5*x_23 - 0.000796163748828676*x_24 - 0.0012808014237776*x_25 - 0.00191912036529723*x_26 - 0.000641769723780005*x_27 - 0.000342871670060795*x_28 + 0.00128559937571277*x_29 - 0.000182430356511747*x_3 - 0.0112539254009952*x_30 - 0.000118072226660803*x_31 - 0.000335576771198594*x_32 - 0.00354978289974587*x_33 - 0.00149186420255835*x_34 + 0.00024805044974511*x_35 + 0.00126889918034032*x_36 - 0.000504616776549906*x_37 - 0.00194518045987774*x_38 + 0.000143660921619701*x_39 - 0.000311080471873753*x_4 + 0.00275538656229576*x_40 - 0.000224482744995076*x_41 - 0.000308039196579821*x_42 - 0.00228902446189046*x_43 - 0.00120297374467065*x_44 - 0.00123019465787253*x_45 - 0.00101099753597261*x_46 - 0.00276821384855329*x_47 + 0.00137117076276814*x_48 - 0.000583211518644874*x_49 + 0.000215660116816593*x_5 - 0.00223663042484259*x_50 - 0.00191389207258473*x_51 - 0.000821915124111174*x_52 - 0.00143159595252416*x_53 - 0.00176064550766787*x_54 - 0.000888270622763323*x_55 - 0.000203132195845805*x_56 - 0.000948799738520099*x_57 - 0.000473363543525772*x_58 + 0.00106528348420654*x_59 - 0.000445259973272428*x_6 - 0.000262247619582538*x_60 + 0.000401305057540635*x_61 - 8.93067696601309e-5*x_62 - 0.00122865784944146*x_63 + 0.000280330522424427*x_64 + 0.000626433355973717*x_65 - 0.000947158282049033*x_66 - 0.00135769019351548*x_67 - 0.00124710616614875*x_68 - 8.09894009465766e-5*x_69 - 0.000671728935421221*x_7 - 0.000350260765942511*x_70 + 0.000257518388100359*x_71 + 0.000324766948196475*x_72 + 0.000237419999562245*x_73 - 0.000310730033860057*x_74 - 9.11869992000497e-5*x_75 - 0.000147251972164361*x_76 - 0.0015493894177883*x_77 - 0.00114821554397825*x_78 - 0.00157720562756297*x_79 - 0.000826967035670738*x_8 - 7.56396022656728e-5*x_80 + 0.00133314556547414*x_81 + 0.000729717380752938*x_82 - 0.000145297183384752*x_83 - 0.00185886121250187*x_84 + 0.000230749673613231*x_85 + 9.19711204276483e-6*x_86 - 6.14452926931117e-5*x_87 - 0.000880971955826005*x_88 - 0.000511557105479442*x_89 - 0.000672259918817595*x_9 + 0.000229105908270427*x_90 - 8.34177284680346e-5*x_91 - 0.00243432472269038*x_92 + 0.000323807666641009*x_93 - 0.00170134480836128*x_94 + 0.000110105449753807*x_95 - 0.0018187434678936*x_96 - 0.00216745639360259*x_97 - 0.00224821577391282*x_98 + 0.000587758075990063*x_99 + 1.82815926292559e-6*std::pow(-6.59912014007568*x_1 - 8.60007953643799, 2) - 2.65347632820575e-5*std::pow(-4.72503995895386*x_1 - 6.98927974700928, 2) - 0.0125403262533144*std::sin(0.228559985756874*x_1 + 5.03671979904175) + 0.254246107258304*std::sin(0.242399975657463*x_1 + 5.05503988265991) + 0.0361849275530351*std::sin(0.259359985589981*x_1 + 5.07639980316162) - 0.14295741566618*std::sin(0.297599911689758*x_1 - 4.29648017883301) + 0.0129641973739997*std::sin(0.337439835071564*x_1 - 4.25399971008301) - 0.00248869873380782*std::sin(0.224879994988441*x_104 + 1.98151981830597) - 0.00111755736809075*std::sin(0.231359988451004*x_104 - 1.1904798746109) + 0.000376806311995192*std::sin(0.263839960098267*x_107 + 1.94431984424591) - 0.000668378714551397*std::sin(0.214719995856285*x_108 + 8.3810396194458) + 0.00356567896725452*std::sin(0.252159982919693*x_108 + 1.96295976638794) - 0.000384930150494277*std::sin(0.260559976100922*x_108 + 1.96167981624603) - 0.000459075532944276*std::sin(0.224639996886253*x_109 + 1.97367978096008) + 0.00203936634892541*std::sin(0.172640010714531*x_11 + 5.20760011672974) - 0.0141897802259966*std::sin(0.280799955129623*x_11 - 7.42807960510254) - 0.00304864876086898*std::sin(0.301519930362701*x_11 + 5.14408016204834) - 0.000288966779770848*std::sin(0.216559991240501*x_111 + 1.96263980865479) - 0.00278108346933872*std::sin(0.235519990324974*x_113 - 4.19479990005493) - 0.00139981265003218*std::sin(0.259679973125458*x_113 - 7.40687990188599) + 0.0631151608450556*std::sin(0.282799929380417*x_113 - 7.41304016113281) - 0.00277657282895612*std::sin(0.289039939641953*x_113 - 7.42664003372192) + 0.000966668269279023*std::sin(0.289839953184128*x_113 - 7.42519998550415) + 0.00909466298843182*std::sin(0.293839931488037*x_113 - 7.44047975540161) + 0.00173867701037787*std::sin(0.237039983272552*x_119 + 5.1701602935791) + 0.00071287696500888*std::sin(0.24695996940136*x_12 + 2.14351987838745) - 0.00476663813556156*std::sin(0.26895996928215*x_12 - 4.22751998901367) - 0.0152620538838344*std::sin(0.278319954872131*x_12 + 5.14752006530762) - 0.00215744900855541*std::sin(0.293199926614761*x_12 - 7.44055986404419) + 0.00411467278978276*std::sin(0.264879941940308*x_120 + 5.16535997390747) + 0.00722654735521348*std::sin(0.269759953022003*x_120 + 5.14287996292114) - 0.0131737227899912*std::sin(0.301679939031601*x_13 - 7.43824005126953) - 0.00975306839384566*std::sin(0.310639947652817*x_13 - 7.45991992950439) - 0.022214660175146*std::sin(0.319199919700623*x_13 - 7.46647977828979) - 0.0080338607151433*std::sin(0.293279945850372*x_15 + 5.1560001373291) + 0.0311284269511828*std::sin(0.299439936876297*x_15 + 5.160560131073) - 0.00106139505571667*std::sin(0.335599839687347*x_16 - 1.15495979785919) - 0.00389651671134143*std::sin(0.383199840784073*x_16 - 7.57936000823975) + 0.0063100305184858*std::sin(0.356399834156036*x_17 + 1.99591982364655) + 0.00197824123979472*std::sin(0.361359834671021*x_17 + 1.98919987678528) + 0.0086971326050593*std::sin(0.375039845705032*x_17 + 1.98655986785889) - 0.0260286851010433*std::sin(0.31415992975235*x_18 - 1.15887987613678) + 0.00107348366964437*std::sin(0.38783985376358*x_18 + 1.99743974208832) + 0.00134585549731808*std::sin(0.209199994802475*x_19 - 1.17927992343903) - 0.0029143377985541*std::sin(0.225599989295006*x_19 - 1.18735992908478) + 0.0268215502486102*std::sin(0.309599906206131*x_19 + 1.9851998090744) - 0.00463832026885135*std::sin(0.361839860677719*x_2 - 7.40703964233398) + 0.000370444549527008*std::sin(0.371599853038788*x_2 - 7.41815996170044) - 0.00443659997294761*std::sin(0.392399847507477*x_2 + 5.18391990661621) + 0.021851372954148*std::sin(0.404959857463837*x_2 + 5.19816017150879) - 0.00451632562813112*std::sin(0.250399976968765*x_20 - 1.17255985736847) + 0.00218565568125917*std::sin(0.315199911594391*x_21 + 1.98335981369019) - 0.00570458151270568*std::sin(0.377199828624725*x_21 - 1.18823993206024) - 0.00909545921110847*std::sin(0.248879969120026*x_22 - 1.15287983417511) + 0.000754461811815817*std::sin(0.301199942827225*x_23 + 8.23463916778564) + 0.0087473164618284*std::sin(0.348559856414795*x_23 + 1.98695981502533) + 0.00667937349515885*std::sin(0.352319836616516*x_23 - 1.16951990127563) - 0.0150522123173619*std::sin(0.258719980716705*x_25 - 1.17999982833862) + 0.000429614463113399*std::sin(0.334399849176407*x_25 - 4.35735988616943) - 0.00859304768518084*std::sin(0.354479849338531*x_25 - 1.15239989757538) + 0.000749820228006222*std::sin(0.305039942264557*x_26 - 4.39551973342896) + 0.0078442135031648*std::sin(0.336399853229523*x_26 - 1.15855991840363) - 0.000405074805704921*std::sin(0.343119859695435*x_26 + 5.04207992553711) - 0.00520116111590997*std::sin(0.348079830408096*x_3 - 7.39111995697021) - 0.00198383676348682*std::sin(0.350639849901199*x_3 - 7.41487979888916) + 0.0148588265986435*std::sin(0.354399859905243*x_3 - 7.40895986557007) + 0.000434059210608158*std::sin(0.361919850111008*x_3 - 7.39071989059448) - 0.00591385698254521*std::sin(0.372799843549728*x_3 - 7.38903999328613) - 0.00129758347198338*std::sin(0.400879859924316*x_3 - 1.17607986927032) - 0.00479773429839529*std::sin(0.460159868001938*x_3 + 8.19824028015137) + 0.00244911190176319*std::sin(0.29751992225647*x_30 + 2.00103974342346) - 0.00175299285994838*std::sin(0.355439841747284*x_31 + 8.35223960876465) + 0.00619544919111019*std::sin(0.377839833498001*x_31 + 5.16879987716675) - 0.0224683557641214*std::sin(0.381759852170944*x_31 + 5.17304039001465) - 0.00328312035001579*std::sin(0.38223984837532*x_31 - 7.39759969711304) + 0.0126163644673119*std::sin(0.388639837503433*x_31 - 7.40663957595825) + 0.00156309387068148*std::sin(0.392079830169678*x_31 + 8.40104007720947) + 0.00190378979644502*std::sin(0.409919857978821*x_31 + 5.20584011077881) - 0.00376086220539931*std::sin(0.420639842748642*x_31 + 2.00063967704773) + 0.00280278028511558*std::sin(0.278239965438843*x_32 + 2.04231977462769) - 0.000877607553637334*std::sin(0.291119933128357*x_32 + 2.01647973060608) - 0.00306776496356775*std::sin(0.30311992764473*x_32 - 1.14807987213135) - 0.0443534440037138*std::sin(0.31879985332489*x_32 + 1.9916797876358) + 0.000705947280427261*std::sin(0.320479840040207*x_32 + 2.01711988449097) + 0.00026124008614839*std::sin(0.362319827079773*x_32 + 8.21008014678955) - 0.00122130578835466*std::sin(0.23743999004364*x_33 + 1.99071979522705) + 0.00137681001281503*std::sin(0.244079977273941*x_34 + 1.97359979152679) + 0.00875180895395817*std::sin(0.211040005087852*x_36 + 8.18279933929443) - 0.0027163248606795*std::sin(0.254639983177185*x_37 + 1.97111976146698) + 0.0115937821789134*std::sin(0.311999946832657*x_4 - 7.37815999984741) + 0.00141005944036806*std::sin(0.361039847135544*x_4 + 2.00863981246948) - 0.0033247860015928*std::sin(0.217840000987053*x_40 - 1.18151986598969) - 0.00418938332325117*std::sin(0.230159983038902*x_42 - 7.42208003997803) + 0.000685921086487608*std::sin(0.227999985218048*x_44 - 7.59743976593018) - 0.00112291200181122*std::sin(0.19463999569416*x_47 - 1.1743198633194) + 0.00840619678987991*std::sin(0.178720012307167*x_48 + 1.99559986591339) + 0.00481371227175582*std::sin(0.357679843902588*x_5 + 1.99735975265503) + 0.0302095556497488*std::sin(0.361199855804443*x_5 + 2.02967977523804) - 0.00561856513439268*std::sin(0.382959842681885*x_5 + 2.00695967674255) + 0.00040437366929701*std::sin(0.530799865722656*x_5 + 1.86231982707977) + 0.0545067423418815*std::sin(0.232719987630844*x_52 - 7.42647981643677) - 0.00102017523430798*std::sin(0.24551996588707*x_52 - 7.42375993728638) + 0.0491034324007951*std::sin(0.237919986248016*x_53 - 7.41623973846436) - 0.0018004790642406*std::sin(0.238559976220131*x_53 - 7.40831995010376) + 0.00291686055642019*std::sin(0.258159965276718*x_53 - 7.43439960479736) - 0.0318677169203359*std::sin(0.273599952459335*x_6 + 2.01239991188049) - 0.0182326499900483*std::sin(0.34487983584404*x_6 + 2.00751972198486) + 0.00460464360047373*std::sin(0.378239840269089*x_6 + 1.9968798160553) - 0.00245675989759426*std::sin(0.478239864110947*x_6 + 5.13472032546997) - 0.0384955007781507*std::sin(0.33927983045578*x_7 + 2.03287982940674) - 0.0225805892293355*std::sin(0.353279858827591*x_7 + 1.99943971633911) - 0.00553872395605524*std::sin(0.357119828462601*x_7 - 1.14767980575562) - 0.00376102689268311*std::sin(0.324799835681915*x_8 - 4.32855987548828) - 0.00426348939210363*std::sin(0.330319821834564*x_8 - 1.13239991664886) - 0.00497169379930876*std::sin(0.356479853391647*x_9 - 4.36567974090576) - 0.000953692709440214*std::sin(0.309759914875031*x_91 - 4.35207986831665) + 0.00376901934397995*std::sin(0.363919854164124*x_91 - 7.40927982330322) - 0.00260179125711347*std::sin(0.366639852523804*x_91 + 1.99207985401154) + 0.00114014332476715*std::sin(0.368159830570221*x_91 + 2.00927972793579) + 0.00105379533872144*std::sin(0.389919847249985*x_91 + 2.01271986961365) - 0.000395368736973405*std::sin(0.395359843969345*x_91 + 1.99727976322174) - 0.00252514169449187*std::sin(0.294639945030212*x_92 - 7.40287971496582) + 0.00454327892758053*std::sin(0.297439932823181*x_92 + 8.22743988037109) - 0.0279608686475711*std::sin(0.302079945802689*x_92 + 1.98719990253448) - 0.0032119486746881*std::sin(0.314319908618927*x_92 + 5.02783966064453) - 0.000607968175205238*std::sin(0.320639848709106*x_92 - 1.1794399023056) + 0.00131430516230207*std::sin(0.271519958972931*x_94 - 1.19207990169525) - 0.0121731750410861*std::sin(0.299519926309586*x_94 + 1.98151981830597) + 0.00420445585067582*std::sin(0.25943997502327*x_97 - 1.19791984558105) - 0.00661056015924656*std::sin(0.274719953536987*x_97 + 1.97767972946167) + 0.00291601840455602*std::sin(0.248719975352287*x_98 - 7.43247985839844) - 0.000502930479180401*std::sin(0.262879967689514*x_98 + 1.96247982978821) + 0.616346480860527);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-9.7417484476357e-5*x_1 + 0.00234190992561036*x_10 + 0.00887061897633139*x_100 + 0.00262479163014018*x_101 - 0.00772187131543216*x_102 + 0.00153291822970938*x_103 - 0.000562200211240833*x_104 - 0.00480639821676433*x_105 - 0.00135555636204124*x_106 + 0.00280311486395197*x_107 + 0.0010674085553157*x_108 - 0.00464037919270371*x_109 + 0.00779514828928674*x_11 + 0.0128752973208691*x_110 + 0.00385041166333512*x_111 - 0.00356414790318864*x_112 - 0.00405775609640278*x_113 - 0.00371904479357209*x_114 + 0.00107704895293028*x_115 - 0.00170180514427933*x_116 - 0.00271673712652358*x_117 + 1.30852038638987e-5*x_118 - 0.00193217645484521*x_119 - 0.00184865199623612*x_12 + 0.0101158121780011*x_120 + 0.0019537838926399*x_13 - 0.013074184606532*x_14 - 0.00361847699225776*x_15 - 0.0117207364896384*x_16 - 0.000672766621089181*x_17 + 0.00122029425590579*x_18 - 0.000505018298034728*x_19 + 0.000946716643610477*x_2 - 0.00279140901571818*x_20 - 0.00247779045436443*x_21 - 0.00173598600147846*x_22 - 0.000353557266572077*x_23 - 0.00303800826737779*x_24 - 0.00144539493809002*x_25 - 0.00563623610781977*x_26 - 0.00291040688635974*x_27 + 0.000442324038292308*x_28 + 0.00673941980580285*x_29 - 0.000111629446853452*x_3 - 0.0157784342880193*x_30 - 7.91129681912675e-5*x_31 - 0.00171832023791338*x_32 - 0.00766606468578997*x_33 - 0.00199792622451387*x_34 + 0.00293447202669115*x_35 - 6.65664026295266e-5*x_36 + 0.00689653041993872*x_37 - 0.000927223983659591*x_38 + 0.00742039876110955*x_39 + 1.84019579531824e-5*x_4 + 0.00613600790426319*x_40 - 0.00131994650514266*x_41 + 0.000492226754670127*x_42 - 0.00206488183819527*x_43 - 0.00122758828946901*x_44 + 0.000333846488505404*x_45 + 0.000281504557871934*x_46 - 0.00512981846348392*x_47 + 2.99597974051181e-5*x_48 - 0.0012092794816094*x_49 - 0.000129122955643044*x_5 + 0.0012817476410154*x_50 + 0.00276935109935557*x_51 + 0.00183442305441262*x_52 + 0.000294539650526941*x_53 + 0.00392805058123315*x_54 + 0.0019451643505992*x_55 + 0.0012421162544712*x_56 + 0.00139798871373599*x_57 + 0.00127293629453236*x_58 + 0.00489979911381209*x_59 - 0.000214196810278107*x_6 + 0.00131393841405231*x_60 + 0.00239642557624491*x_61 - 0.00113518156210734*x_62 - 0.00398777950194107*x_63 + 0.000306488071562153*x_64 + 0.000907446789519661*x_65 - 0.00325480061784397*x_66 - 0.00171899479418108*x_67 - 0.00558166609120251*x_68 - 0.00121833573135744*x_69 + 0.0015109064710819*x_7 - 4.79916061452001e-5*x_70 + 0.00255534047104376*x_71 + 0.000633112813238962*x_72 - 0.00121989375306309*x_73 - 0.00283888764315369*x_74 - 6.96492671166898e-5*x_75 + 0.000294911075271385*x_76 - 0.00394715389642862*x_77 - 0.00446301462473645*x_78 - 0.00326126368188763*x_79 - 0.00120521776295883*x_8 - 0.000223640687246208*x_80 + 0.0071165226277498*x_81 + 0.000723562713325786*x_82 + 0.0002667031315659*x_83 - 0.00658342916444128*x_84 + 0.00163918286851443*x_85 + 0.00258393174761051*x_86 + 0.00209619254453385*x_87 - 0.00204428253517371*x_88 + 0.000814719681738024*x_89 - 0.000886722647741162*x_9 - 4.45780209776644e-5*x_90 + 0.00146159346905737*x_91 - 0.00502400590521761*x_92 - 0.000236841161742439*x_93 - 0.00203854170727242*x_94 + 0.00315913745164361*x_95 - 0.00546659994703967*x_96 - 0.00322014957064084*x_97 - 0.00504779727709533*x_98 + 0.00212026782622822*x_99 + 5.57481073589229e-6*std::pow(-6.59912014007568*x_1 - 8.60007953643799, 2) - 0.000226767677018663*std::pow(-4.72503995895386*x_1 - 6.98927974700928, 2) + 0.00428444632154988*std::exp(-0.00595728802088885*x_10 - 0.00993246495781113*x_100 - 0.0131934119194067*x_101 + 0.00488234092765246*x_102 - 0.00271457218435509*x_103 - 0.0267977776293396*x_104 - 0.0015674808957861*x_105 + 0.00139543996484884*x_106 + 0.0143458045796885*x_107 - 0.0334336992677894*x_109 - 0.00983608782815585*x_11 + 0.00597217502340897*x_110 + 0.00441078678504079*x_111 - 0.0986203252208502*x_112 - 0.159080655927718*x_114 - 0.0138608257249753*x_115 - 0.0528858069352431*x_116 - 0.0586081270557858*x_117 - 0.134000479223976*x_118 - 0.190045642715544*x_119 - 0.0038167144864172*x_12 - 0.202616837977898*x_120 - 0.0121686056597596*x_13 - 0.013866688030623*x_14 - 0.0141271904216412*x_15 - 0.0274754876897279*x_16 - 6.58082753263976e-5*x_17 + 0.000141634580654692*x_18 - 0.0162734468148795*x_19 - 0.0336462663417009*x_2 + 0.000209678509062738*x_20 - 0.0035787808263525*x_21 - 0.00242922546453327*x_22 - 0.00158624900331143*x_24 - 0.0151115070302769*x_25 - 0.0375749558471377*x_26 - 0.037556469826248*x_27 - 0.0056218768867903*x_28 - 0.00771156737296208*x_29 - 0.00149567490069014*x_3 + 0.388533481113468*x_30 + 0.0155064482463509*x_33 + 0.0253453528112376*x_34 + 0.0124207411320723*x_35 + 0.0140158336937114*x_36 + 0.0137418925825652*x_37 + 0.00355285856968759*x_38 + 0.00907768648473076*x_39 + 0.00201034122657082*x_4 - 0.00487583239868128*x_40 - 0.0059362280910566*x_41 + 0.0109219391507032*x_42 - 0.0168859954048308*x_43 + 0.000133643431112746*x_44 + 0.00576124818794066*x_45 - 0.00384342668473892*x_46 + 0.0188513789047995*x_47 + 0.00656297096316456*x_48 - 0.0116935755937602*x_49 + 0.0106390078870025*x_50 + 0.0188261931635295*x_51 + 0.00363281865275189*x_52 - 0.00341078366751038*x_53 - 0.0138923415330253*x_54 - 6.8117049306889e-5*x_55 + 0.00633799995190851*x_56 + 0.00863016168061358*x_57 - 0.00286744958738782*x_58 - 0.0193849261896312*x_59 - 0.0323335350704731*x_60 + 0.00432802884921916*x_61 + 0.00331264012843566*x_62 - 0.000442149797607756*x_63 - 0.00283026597121144*x_64 + 0.0036510839631672*x_65 + 0.000920615473679458*x_66 + 0.033721015530062*x_67 - 0.00633204523989517*x_68 - 0.0061831162242455*x_69 - 0.00361041907160907*x_70 + 0.0133893958769897*x_71 + 0.0183849980110948*x_72 + 0.0147937942992395*x_73 + 0.0159589131248357*x_74 + 0.0163653851778451*x_75 + 0.0122372173606151*x_76 + 0.00600498242727774*x_77 + 0.00262738790200085*x_78 + 0.00384214514232067*x_79 - 0.0117243694881724*x_8 + 0.0135265873031823*x_80 + 0.0078923738048455*x_81 - 0.000376699288468125*x_82 + 0.00566854774387609*x_83 + 0.00414780231505318*x_84 - 0.0143225830073921*x_85 + 0.0204671506081*x_86 + 0.0112660931151883*x_87 + 0.00957343197107447*x_88 - 0.00160023418632496*x_89 - 0.00661653203072187*x_9 - 0.00313267085198616*x_90 - 0.020639476445255*x_92 + 0.0105280137553502*x_93 - 0.003369754128893*x_94 + 0.00925171447759985*x_95 - 0.00056693263835932*x_96 + 0.0125543268380248*x_97 - 0.00806694692992399*x_98 + 0.0244694563236406*x_99 - 1.37156436534121*std::sin(0.337439835071564*x_1 - 4.25399971008301) + 0.0707120079234365*std::sin(0.214719995856285*x_108 + 8.3810396194458) - 0.962181869796098*std::sin(0.293839931488037*x_113 - 7.44047975540161) - 0.9254338857466*std::sin(0.348559856414795*x_23 + 1.98695981502533) - 0.16536957829797*std::sin(0.392079830169678*x_31 + 8.40104007720947) - 0.296523838078485*std::sin(0.278239965438843*x_32 + 2.04231977462769) + 0.594423511179855*std::sin(0.382959842681885*x_5 + 2.00695967674255) + 1.92894726072609*std::sin(0.34487983584404*x_6 + 2.00751972198486) + 2.38894322894816*std::sin(0.353279858827591*x_7 + 1.99943971633911) + 0.100897178438309*std::sin(0.309759914875031*x_91 - 4.35207986831665)) + 0.00014042976939329*std::sin(0.228559985756874*x_1 + 5.03671979904175) + 0.405356055463079*std::sin(0.242399975657463*x_1 + 5.05503988265991) + 0.112441215841608*std::sin(0.259359985589981*x_1 + 5.07639980316162) - 0.071791351980807*std::sin(0.297599911689758*x_1 - 4.29648017883301) + 0.00100465313382732*std::sin(0.224879994988441*x_104 + 1.98151981830597) - 0.00340789281325401*std::sin(0.231359988451004*x_104 - 1.1904798746109) + 4.08356911484591e-5*std::sin(0.263839960098267*x_107 + 1.94431984424591) + 0.0304725061159812*std::sin(0.252159982919693*x_108 + 1.96295976638794) + 0.000687644869502169*std::sin(0.260559976100922*x_108 + 1.96167981624603) + 0.00082009926875759*std::sin(0.224639996886253*x_109 + 1.97367978096008) + 0.00621886815168005*std::sin(0.172640010714531*x_11 + 5.20760011672974) - 0.0440933905090113*std::sin(0.280799955129623*x_11 - 7.42807960510254) + 0.00544615088382606*std::sin(0.301519930362701*x_11 + 5.14408016204834) + 0.000516214495826928*std::sin(0.216559991240501*x_111 + 1.96263980865479) - 0.00864195198929489*std::sin(0.235519990324974*x_113 - 4.19479990005493) + 1.56754588092056e-5*std::sin(0.259679973125458*x_113 - 7.40687990188599) + 0.100627352434061*std::sin(0.282799929380417*x_113 - 7.41304016113281) - 0.00846691441481999*std::sin(0.289039939641953*x_113 - 7.42664003372192) - 0.00172687038161783*std::sin(0.289839953184128*x_113 - 7.42519998550415) + 0.000188425923723971*std::sin(0.237039983272552*x_119 + 5.1701602935791) - 7.98297793691982e-6*std::sin(0.24695996940136*x_12 + 2.14351987838745) + 0.00192422565080251*std::sin(0.26895996928215*x_12 - 4.22751998901367) - 0.0474253787691925*std::sin(0.278319954872131*x_12 + 5.14752006530762) + 0.00385409856837839*std::sin(0.293199926614761*x_12 - 7.44055986404419) + 0.000445920097067486*std::sin(0.264879941940308*x_120 + 5.16535997390747) - 0.00291725685738521*std::sin(0.269759953022003*x_120 + 5.14287996292114) - 0.112583424356159*std::sin(0.301679939031601*x_13 - 7.43824005126953) - 0.0303067310769945*std::sin(0.310639947652817*x_13 - 7.45991992950439) - 0.0354178363600327*std::sin(0.319199919700623*x_13 - 7.46647977828979) - 0.0686578550748343*std::sin(0.293279945850372*x_15 + 5.1560001373291) + 0.0156322905352428*std::sin(0.299439936876297*x_15 + 5.160560131073) - 0.00323663078574632*std::sin(0.335599839687347*x_16 - 1.15495979785919) - 0.00621239263478928*std::sin(0.383199840784073*x_16 - 7.57936000823975) + 0.0192418825819194*std::sin(0.356399834156036*x_17 + 1.99591982364655) + 0.00021438825654925*std::sin(0.361359834671021*x_17 + 1.98919987678528) + 0.0743262163904875*std::sin(0.375039845705032*x_17 + 1.98655986785889) - 0.222442702558611*std::sin(0.31415992975235*x_18 - 1.15887987613678) + 0.00327349394973475*std::sin(0.38783985376358*x_18 + 1.99743974208832) - 0.00240425601017146*std::sin(0.209199994802475*x_19 - 1.17927992343903) - 0.00888701656189206*std::sin(0.225599989295006*x_19 - 1.18735992908478) + 0.229218575619607*std::sin(0.309599906206131*x_19 + 1.9851998090744) + 0.00187242550916013*std::sin(0.361839860677719*x_2 - 7.40703964233398) + 4.01462468396973e-5*std::sin(0.371599853038788*x_2 - 7.41815996170044) + 0.00792560729657951*std::sin(0.392399847507477*x_2 + 5.18391990661621) + 0.0348386311305333*std::sin(0.404959857463837*x_2 + 5.19816017150879) - 0.038596789444271*std::sin(0.250399976968765*x_20 - 1.17255985736847) + 0.000236866415225851*std::sin(0.315199911594391*x_21 + 1.98335981369019) - 0.00909507203470646*std::sin(0.377199828624725*x_21 - 1.18823993206024) - 0.0777303394342223*std::sin(0.248879969120026*x_22 - 1.15287983417511) - 8.44865564971537e-6*std::sin(0.301199942827225*x_23 + 8.23463916778564) + 0.00335429436358832*std::sin(0.352319836616516*x_23 - 1.16951990127563) - 0.0239984221459867*std::sin(0.258719980716705*x_25 - 1.17999982833862) - 0.000767469581285112*std::sin(0.334399849176407*x_25 - 4.35735988616943) - 0.0734367004282527*std::sin(0.354479849338531*x_25 - 1.15239989757538) + 0.00228651077717862*std::sin(0.305039942264557*x_26 - 4.39551973342896) - 0.00316660010764229*std::sin(0.336399853229523*x_26 - 1.15855991840363) + 0.000723631577183297*std::sin(0.343119859695435*x_26 + 5.04207992553711) + 0.00209963654646326*std::sin(0.348079830408096*x_3 - 7.39111995697021) + 2.22155096751771e-5*std::sin(0.350639849901199*x_3 - 7.41487979888916) + 0.0461723883869144*std::sin(0.354399859905243*x_3 - 7.40895986557007) - 0.000775409743434216*std::sin(0.361919850111008*x_3 - 7.39071989059448) - 0.0505401761416576*std::sin(0.372799843549728*x_3 - 7.38903999328613) - 0.00395686656902812*std::sin(0.400879859924316*x_3 - 1.17607986927032) - 0.00764924455020902*std::sin(0.460159868001938*x_3 + 8.19824028015137) + 0.000265417998649909*std::sin(0.29751992225647*x_30 + 2.00103974342346) - 0.00534559740705728*std::sin(0.355439841747284*x_31 + 8.35223960876465) + 0.000671420413194603*std::sin(0.377839833498001*x_31 + 5.16879987716675) - 0.011283315591397*std::sin(0.381759852170944*x_31 + 5.17304039001465) + 0.00586501437143229*std::sin(0.38223984837532*x_31 - 7.39759969711304) + 0.0201148398687511*std::sin(0.388639837503433*x_31 - 7.40663957595825) + 0.016269901678889*std::sin(0.409919857978821*x_31 + 5.20584011077881) + 0.00151820786872265*std::sin(0.420639842748642*x_31 + 2.00063967704773) - 0.00267618697732502*std::sin(0.291119933128357*x_32 + 2.01647973060608) + 0.00123841413290645*std::sin(0.30311992764473*x_32 - 1.14807987213135) - 0.0707146996326756*std::sin(0.31879985332489*x_32 + 1.9916797876358) + 7.65057383406839e-5*std::sin(0.320479840040207*x_32 + 2.01711988449097) - 0.000466683123464282*std::sin(0.362319827079773*x_32 + 8.21008014678955) + 0.00218175858237395*std::sin(0.23743999004364*x_33 + 1.99071979522705) + 0.000149209253305019*std::sin(0.244079977273941*x_34 + 1.97359979152679) + 0.0139534044158982*std::sin(0.211040005087852*x_36 + 8.18279933929443) + 0.00109654264162351*std::sin(0.254639983177185*x_37 + 1.97111976146698) + 0.0184844907268054*std::sin(0.311999946832657*x_4 - 7.37815999984741) + 0.000152812598873274*std::sin(0.361039847135544*x_4 + 2.00863981246948) + 0.00134216995831177*std::sin(0.217840000987053*x_40 - 1.18151986598969) - 0.00667932310566551*std::sin(0.230159983038902*x_42 - 7.42208003997803) - 0.000276896821514286*std::sin(0.227999985218048*x_44 - 7.59743976593018) - 0.000121693523258831*std::sin(0.19463999569416*x_47 - 1.1743198633194) + 0.0718398614805731*std::sin(0.178720012307167*x_48 + 1.99559986591339) + 0.0146789918123086*std::sin(0.357679843902588*x_5 + 1.99735975265503) + 0.0151708453369024*std::sin(0.361199855804443*x_5 + 2.02967977523804) - 4.52827940685267e-6*std::sin(0.530799865722656*x_5 + 1.86231982707977) + 0.0869025618921285*std::sin(0.232719987630844*x_52 - 7.42647981643677) + 1.14241822741056e-5*std::sin(0.24551996588707*x_52 - 7.42375993728638) + 0.0782878207352933*std::sin(0.237919986248016*x_53 - 7.41623973846436) + 2.01622234287507e-5*std::sin(0.238559976220131*x_53 - 7.40831995010376) + 0.00906386635495157*std::sin(0.258159965276718*x_53 - 7.43439960479736) - 0.050808140847236*std::sin(0.273599952459335*x_6 + 2.01239991188049) + 0.0140414553039537*std::sin(0.378239840269089*x_6 + 1.9968798160553) + 0.000991759868982983*std::sin(0.478239864110947*x_6 + 5.13472032546997) - 0.0613751160903857*std::sin(0.33927983045578*x_7 + 2.03287982940674) - 0.0168898511193974*std::sin(0.357119828462601*x_7 - 1.14767980575562) - 0.00188873871427833*std::sin(0.324799835681915*x_8 - 4.32855987548828) - 0.0364360358207833*std::sin(0.330319821834564*x_8 - 1.13239991664886) - 0.00249671986460936*std::sin(0.356479853391647*x_9 - 4.36567974090576) - 0.00152150079234044*std::sin(0.363919854164124*x_91 - 7.40927982330322) - 0.000281964343021946*std::sin(0.366639852523804*x_91 + 1.99207985401154) + 0.00347676669985318*std::sin(0.368159830570221*x_91 + 2.00927972793579) - 1.18006687716966e-5*std::sin(0.389919847249985*x_91 + 2.01271986961365) + 0.000706292513569567*std::sin(0.395359843969345*x_91 + 1.99727976322174) - 0.0077001973042408*std::sin(0.294639945030212*x_92 - 7.40287971496582) + 0.0141178065307986*std::sin(0.297439932823181*x_92 + 8.22743988037109) - 0.01404158401586*std::sin(0.302079945802689*x_92 + 1.98719990253448) - 0.0274495058395605*std::sin(0.314319908618927*x_92 + 5.02783966064453) - 6.5887432987296e-5*std::sin(0.320639848709106*x_92 - 1.1794399023056) - 0.000530566750476822*std::sin(0.271519958972931*x_94 - 1.19207990169525) - 0.00611320993756138*std::sin(0.299519926309586*x_94 + 1.98151981830597) - 0.00169728046590723*std::sin(0.25943997502327*x_97 - 1.19791984558105) - 0.0564942432374406*std::sin(0.274719953536987*x_97 + 1.97767972946167) - 0.00117715615338982*std::sin(0.248719975352287*x_98 - 7.43247985839844) + 0.000898442388263407*std::sin(0.262879967689514*x_98 + 1.96247982978821) - 0.19906619508983);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00112185590757859*x_1 - 0.00134152911782277*x_10 - 0.00250203382116997*x_100 + 6.39076192088308e-5*x_101 + 0.00219374183013134*x_102 - 0.00259710078654677*x_103 + 0.00187485385572391*x_104 + 0.00190168034326181*x_105 - 0.000471886901755399*x_106 - 0.00202301730535094*x_107 + 0.00186479450994111*x_108 + 0.00391378480498938*x_109 - 0.00226738733969434*x_11 - 0.00533670451183985*x_110 - 0.00107777516115887*x_111 + 0.00116504970769043*x_112 - 0.000562612951278313*x_113 - 0.00057517920316658*x_114 - 0.00054905611893589*x_115 + 0.00282763100675028*x_116 - 0.0115602210523997*x_117 - 0.00373994037985633*x_118 + 0.00481459270658728*x_119 + 0.000115482371446607*x_12 - 0.000557314539303345*x_120 + 0.000541425502109338*x_13 + 0.0038151892637751*x_14 + 0.000775952050613969*x_15 + 0.00380364395895052*x_16 + 0.000416911763757946*x_17 + 0.000124883469424398*x_18 + 0.00016871033285557*x_19 - 6.09317011406616e-5*x_2 - 0.000267134410499568*x_20 + 0.000527992242502963*x_21 + 0.00480104822819887*x_22 + 0.00321702536441115*x_23 + 0.0014338640188508*x_24 + 0.00219656293424554*x_25 + 0.00241899777622031*x_26 + 0.0030080025879239*x_27 - 0.00064538326334005*x_28 - 0.00224724201883773*x_29 - 0.000516148459114678*x_3 - 0.00472276574532952*x_30 - 3.5945808202537e-5*x_31 + 0.000622279180590299*x_32 + 0.00486784651901962*x_33 - 0.000921023506863494*x_34 + 0.000853069447782872*x_35 - 0.000464093487705082*x_36 - 0.00386255184706313*x_37 + 0.000113232920155883*x_38 - 0.00273885402732865*x_39 - 0.000312006266611669*x_4 - 0.00148658954909898*x_40 + 0.00218020660614763*x_41 + 0.00341824761485502*x_42 + 0.000602821812625139*x_43 + 0.00123921312212022*x_44 + 0.00109550444145212*x_45 + 0.00139082004940282*x_46 + 0.000827385837024519*x_47 + 0.00146814674041678*x_48 + 0.00713462976397249*x_49 - 0.000563610168080914*x_5 + 0.000306994478055437*x_50 + 0.00338411119131921*x_51 + 0.0032177547935968*x_52 + 0.00219596506286449*x_53 + 0.000277968800073169*x_54 + 0.000689603838307668*x_55 + 0.00279973357860423*x_56 - 0.000186475137087794*x_57 + 0.000113327667740749*x_58 - 0.00180411802887431*x_59 - 0.00123392306051039*x_6 + 0.000486592317776886*x_60 - 0.000975684274343057*x_61 + 0.000587753905851048*x_62 + 0.00201312519602163*x_63 - 0.00071161723716812*x_64 + 0.000415332592392325*x_65 + 0.00151978818207062*x_66 - 0.000508618885336483*x_67 + 0.00280824979248664*x_68 + 0.00124804487650657*x_69 + 0.000150912460226327*x_7 + 0.00137288938061518*x_70 - 0.000724289813334979*x_71 - 0.00018288536393702*x_72 + 0.000657507500496549*x_73 + 0.000363343537510567*x_74 - 0.00119386299103759*x_75 + 0.000271412198671939*x_76 + 0.00156869810096831*x_77 + 0.00150630305388145*x_78 + 0.00142854942299359*x_79 + 0.000994996965759767*x_8 + 0.000300831083769999*x_80 - 0.00255981152336422*x_81 + 0.000341148588886454*x_82 + 0.000328088524280617*x_83 + 0.00237557009912251*x_84 + 0.000408186067596831*x_85 - 0.0014821356846363*x_86 - 0.00158640217810956*x_87 + 0.000559864439607111*x_88 - 0.000251729340088604*x_89 - 0.000409885200230442*x_9 + 0.000274556534920608*x_90 - 0.000541427468331077*x_91 + 0.00132484481857192*x_92 - 0.00208768362566674*x_93 + 5.46741494491194e-5*x_94 - 0.00207643697032615*x_95 + 0.00203074112468305*x_96 - 0.000291724515120982*x_97 + 0.0011567958692846*x_98 - 0.00461587654223401*x_99 - 9.70101044376952e-6*std::pow(-6.59912014007568*x_1 - 8.60007953643799, 2) + 7.14461557456934e-5*std::pow(-4.72503995895386*x_1 - 6.98927974700928, 2) - 0.0036022237650527*std::sin(0.228559985756874*x_1 + 5.03671979904175) - 0.153157927279008*std::sin(0.242399975657463*x_1 + 5.05503988265991) + 0.0132413353078352*std::sin(0.259359985589981*x_1 + 5.07639980316162) + 0.0325222696793363*std::sin(0.337439835071564*x_1 - 4.25399971008301) + 0.000399738830955056*std::sin(0.224879994988441*x_104 + 1.98151981830597) + 0.00593024684403617*std::sin(0.231359988451004*x_104 - 1.1904798746109) - 0.00633760574995399*std::sin(0.263839960098267*x_107 + 1.94431984424591) - 0.00167670949272676*std::sin(0.214719995856285*x_108 + 8.3810396194458) - 0.00960076606396076*std::sin(0.252159982919693*x_108 + 1.96295976638794) + 0.00405093256904519*std::sin(0.260559976100922*x_108 + 1.96167981624603) + 0.00483122464080245*std::sin(0.224639996886253*x_109 + 1.97367978096008) - 0.0108217673650256*std::sin(0.172640010714531*x_11 + 5.20760011672974) - 0.00519253873429823*std::sin(0.280799955129623*x_11 - 7.42807960510254) + 0.0320834066677431*std::sin(0.301519930362701*x_11 + 5.14408016204834) + 0.00304103208866004*std::sin(0.216559991240501*x_111 + 1.96263980865479) - 0.00101769607477086*std::sin(0.235519990324974*x_113 - 4.19479990005493) - 0.000402097863541198*std::sin(0.259679973125458*x_113 - 7.40687990188599) - 0.0380205908328384*std::sin(0.282799929380417*x_113 - 7.41304016113281) + 0.0147337064980242*std::sin(0.289039939641953*x_113 - 7.42664003372192) - 0.0101730352128994*std::sin(0.289839953184128*x_113 - 7.42519998550415) + 0.0228150709079496*std::sin(0.293839931488037*x_113 - 7.44047975540161) - 0.0292432718548096*std::sin(0.237039983272552*x_119 + 5.1701602935791) + 0.000204774763673706*std::sin(0.24695996940136*x_12 + 2.14351987838745) + 0.000765625155833871*std::sin(0.26895996928215*x_12 - 4.22751998901367) - 0.00558492130918056*std::sin(0.278319954872131*x_12 + 5.14752006530762) + 0.0227045879456026*std::sin(0.293199926614761*x_12 - 7.44055986404419) - 0.0692057778799608*std::sin(0.264879941940308*x_120 + 5.16535997390747) - 0.00116073976828626*std::sin(0.269759953022003*x_120 + 5.14287996292114) + 0.0354708968080653*std::sin(0.301679939031601*x_13 - 7.43824005126953) - 0.00356899011871389*std::sin(0.310639947652817*x_13 - 7.45991992950439) + 0.0133821176037761*std::sin(0.319199919700623*x_13 - 7.46647977828979) + 0.0216315652712629*std::sin(0.293279945850372*x_15 + 5.1560001373291) + 0.00563222511806501*std::sin(0.335599839687347*x_16 - 1.15495979785919) + 0.00234726277445327*std::sin(0.383199840784073*x_16 - 7.57936000823975) - 0.0334837741993962*std::sin(0.356399834156036*x_17 + 1.99591982364655) - 0.0332725664539269*std::sin(0.361359834671021*x_17 + 1.98919987678528) - 0.0234174574702983*std::sin(0.375039845705032*x_17 + 1.98655986785889) + 0.0700835153423895*std::sin(0.31415992975235*x_18 - 1.15887987613678) - 0.00569637257629882*std::sin(0.38783985376358*x_18 + 1.99743974208832) - 0.0141635303452162*std::sin(0.209199994802475*x_19 - 1.17927992343903) + 0.0154647475161448*std::sin(0.225599989295006*x_19 - 1.18735992908478) - 0.0722183437641188*std::sin(0.309599906206131*x_19 + 1.9851998090744) + 0.00074501453176251*std::sin(0.361839860677719*x_2 - 7.40703964233398) - 0.00623060557210474*std::sin(0.371599853038788*x_2 - 7.41815996170044) + 0.0466899444046166*std::sin(0.392399847507477*x_2 + 5.18391990661621) - 0.0131632732785866*std::sin(0.404959857463837*x_2 + 5.19816017150879) + 0.0121604289737121*std::sin(0.250399976968765*x_20 - 1.17255985736847) - 0.036761125204146*std::sin(0.315199911594391*x_21 + 1.98335981369019) + 0.00343644152471724*std::sin(0.377199828624725*x_21 - 1.18823993206024) + 0.0244899714562319*std::sin(0.248879969120026*x_22 - 1.15287983417511) + 0.00021672006082213*std::sin(0.301199942827225*x_23 + 8.23463916778564) + 0.0219437097982343*std::sin(0.348559856414795*x_23 + 1.98695981502533) + 0.00906745697840142*std::sin(0.258719980716705*x_25 - 1.17999982833862) - 0.00452118187812572*std::sin(0.334399849176407*x_25 - 4.35735988616943) + 0.0231372037021615*std::sin(0.354479849338531*x_25 - 1.15239989757538) - 0.00397887318153969*std::sin(0.305039942264557*x_26 - 4.39551973342896) - 0.00125995030773343*std::sin(0.336399853229523*x_26 - 1.15855991840363) + 0.00426293113496734*std::sin(0.343119859695435*x_26 + 5.04207992553711) + 0.000835418942373*std::sin(0.348079830408096*x_3 - 7.39111995697021) - 0.00056985949097845*std::sin(0.350639849901199*x_3 - 7.41487979888916) + 0.00543736628974171*std::sin(0.354399859905243*x_3 - 7.40895986557007) - 0.00456795756551883*std::sin(0.361919850111008*x_3 - 7.39071989059448) + 0.0159233509091972*std::sin(0.372799843549728*x_3 - 7.38903999328613) + 0.0068855438739124*std::sin(0.400879859924316*x_3 - 1.17607986927032) + 0.00289015650505551*std::sin(0.460159868001938*x_3 + 8.19824028015137) - 0.0411922655666479*std::sin(0.29751992225647*x_30 + 2.00103974342346) + 0.00930214472397683*std::sin(0.355439841747284*x_31 + 8.35223960876465) - 0.104202910533061*std::sin(0.377839833498001*x_31 + 5.16879987716675) + 0.0345509416108255*std::sin(0.38223984837532*x_31 - 7.39759969711304) - 0.00760010154116885*std::sin(0.388639837503433*x_31 - 7.40663957595825) + 0.00392121154359876*std::sin(0.392079830169678*x_31 + 8.40104007720947) - 0.00512604770044611*std::sin(0.409919857978821*x_31 + 5.20584011077881) + 0.000604075793082904*std::sin(0.420639842748642*x_31 + 2.00063967704773) + 0.00703111605406956*std::sin(0.278239965438843*x_32 + 2.04231977462769) + 0.00465696846878778*std::sin(0.291119933128357*x_32 + 2.01647973060608) + 0.000492749388876474*std::sin(0.30311992764473*x_32 - 1.14807987213135) + 0.0267185272748064*std::sin(0.31879985332489*x_32 + 1.9916797876358) - 0.0118735153875482*std::sin(0.320479840040207*x_32 + 2.01711988449097) - 0.00274924157528268*std::sin(0.362319827079773*x_32 + 8.21008014678955) + 0.0128527926130402*std::sin(0.23743999004364*x_33 + 1.99071979522705) - 0.0231569344144164*std::sin(0.244079977273941*x_34 + 1.97359979152679) - 0.00527209220146798*std::sin(0.211040005087852*x_36 + 8.18279933929443) + 0.000436300508997659*std::sin(0.254639983177185*x_37 + 1.97111976146698) - 0.00698409767998005*std::sin(0.311999946832657*x_4 - 7.37815999984741) - 0.0237161653947229*std::sin(0.361039847135544*x_4 + 2.00863981246948) + 0.000534032525270323*std::sin(0.217840000987053*x_40 - 1.18151986598969) + 0.00252368570471175*std::sin(0.230159983038902*x_42 - 7.42208003997803) - 0.000110173758484803*std::sin(0.227999985218048*x_44 - 7.59743976593018) + 0.0188865561239908*std::sin(0.19463999569416*x_47 - 1.1743198633194) - 0.0226340984728068*std::sin(0.178720012307167*x_48 + 1.99559986591339) - 0.0255436569278293*std::sin(0.357679843902588*x_5 + 1.99735975265503) - 0.0140948556428264*std::sin(0.382959842681885*x_5 + 2.00695967674255) + 0.000116156821766759*std::sin(0.530799865722656*x_5 + 1.86231982707977) - 0.0328348770796799*std::sin(0.232719987630844*x_52 - 7.42647981643677) - 0.000293046560297515*std::sin(0.24551996588707*x_52 - 7.42375993728638) - 0.0295799216353391*std::sin(0.237919986248016*x_53 - 7.41623973846436) - 0.000517189771834935*std::sin(0.238559976220131*x_53 - 7.40831995010376) + 0.00106738167755483*std::sin(0.258159965276718*x_53 - 7.43439960479736) + 0.0191971217308516*std::sin(0.273599952459335*x_6 + 2.01239991188049) - 0.0457388253849422*std::sin(0.34487983584404*x_6 + 2.00751972198486) - 0.0244342473677854*std::sin(0.378239840269089*x_6 + 1.9968798160553) + 0.000394608763230653*std::sin(0.478239864110947*x_6 + 5.13472032546997) + 0.0231897006106725*std::sin(0.33927983045578*x_7 + 2.03287982940674) - 0.0566461610579596*std::sin(0.353279858827591*x_7 + 1.99943971633911) + 0.0293908851556306*std::sin(0.357119828462601*x_7 - 1.14767980575562) + 0.0114796549677276*std::sin(0.330319821834564*x_8 - 1.13239991664886) - 0.0023924544337651*std::sin(0.309759914875031*x_91 - 4.35207986831665) - 0.000605386005924607*std::sin(0.363919854164124*x_91 - 7.40927982330322) + 0.0437602203210246*std::sin(0.366639852523804*x_91 + 1.99207985401154) - 0.00605009778155765*std::sin(0.368159830570221*x_91 + 2.00927972793579) + 0.000302703975635469*std::sin(0.389919847249985*x_91 + 2.01271986961365) + 0.00416078629156808*std::sin(0.395359843969345*x_91 + 1.99727976322174) + 0.0133995032309504*std::sin(0.294639945030212*x_92 - 7.40287971496582) + 0.00166254525697039*std::sin(0.297439932823181*x_92 + 8.22743988037109) + 0.00864832984638353*std::sin(0.314319908618927*x_92 + 5.02783966064453) + 0.0102255787132858*std::sin(0.320639848709106*x_92 - 1.1794399023056) - 0.000211105828905603*std::sin(0.271519958972931*x_94 - 1.19207990169525) - 0.000675326524548747*std::sin(0.25943997502327*x_97 - 1.19791984558105) + 0.0177992584928455*std::sin(0.274719953536987*x_97 + 1.97767972946167) - 0.000468375610211833*std::sin(0.248719975352287*x_98 - 7.43247985839844) + 0.00529274585392001*std::sin(0.262879967689514*x_98 + 1.96247982978821) - 1.84953010082245*std::sin(-0.00292496349056159*x_10 + 0.000637826122033621*x_100 - 0.00133963937916894*x_101 - 0.00154169287096644*x_102 + 0.00179548039749082*x_103 + 0.00133817789934719*x_104 + 0.00122876822057598*x_105 + 0.00629367956041207*x_106 + 0.00137178080014613*x_107 - 0.00313720731259266*x_108 - 0.00056345919527063*x_109 - 0.00463894502516847*x_11 + 0.000158196192537437*x_110 + 0.00160455711569195*x_111 + 0.00159978180678932*x_112 - 0.00120604023181141*x_113 + 0.00335585815231677*x_114 + 0.00123914630058786*x_115 - 0.00302291934805554*x_116 + 0.00302711036699374*x_117 + 0.00533314198527497*x_118 + 0.00162791399610074*x_119 - 0.00616985924709304*x_12 + 0.00173920854737471*x_120 - 0.011544221490679*x_13 - 0.00736182452856274*x_14 + 0.000316608929665974*x_16 + 0.00170347819237672*x_17 - 0.00191545886796234*x_18 - 0.00231814325984302*x_19 + 0.000793068949454329*x_2 + 9.89498009441376e-5*x_20 + 0.0043957775176351*x_21 + 6.20855420799691e-5*x_22 - 0.00192162248571093*x_24 + 0.00285821061818899*x_25 - 0.000885731715492671*x_26 - 0.000656131741277389*x_27 + 0.00107050242316551*x_28 - 0.000879533064331513*x_29 + 0.000698092408252957*x_3 + 0.023407739367443*x_30 + 0.000667100426587266*x_32 + 0.00115710812706204*x_33 - 0.000678808646292907*x_34 + 0.000303394914270875*x_35 - 0.00358953498207914*x_36 + 0.0011501812735945*x_37 - 0.000332288715599623*x_38 + 0.000853188337245466*x_39 - 0.000233364275047071*x_4 + 0.000193776114300328*x_40 - 0.000705999633555635*x_41 - 0.000512498802399461*x_42 + 0.00276524641818015*x_43 + 0.00133053931426186*x_44 + 0.000972620922200547*x_45 + 0.00226719322143543*x_46 + 0.00154525990540363*x_47 - 0.00623844200041581*x_48 - 0.00253573964356129*x_49 + 0.00164549524951065*x_50 + 0.00292543022466226*x_51 + 0.00136473055429368*x_52 + 0.00248712938400869*x_53 + 0.0012696125093226*x_54 - 0.00250493757830633*x_55 - 0.000204600570239491*x_56 + 0.00250143802329005*x_57 + 0.000620775849482499*x_58 - 0.00227172802082142*x_59 + 0.00226040162596897*x_6 + 0.00192088833715122*x_60 + 0.0013314060661442*x_61 + 0.000536443397424366*x_62 + 0.000227774656358802*x_63 - 0.000659948790113409*x_64 - 0.00093798871647031*x_65 - 0.00119295988181475*x_66 + 0.000538747881581366*x_67 - 0.000261502022708914*x_68 + 0.00027548264920471*x_69 + 0.00045710304885419*x_7 + 0.000764955227779669*x_70 - 0.000161683967806769*x_71 - 0.000850818160877033*x_72 - 0.00147507818173963*x_73 - 0.00250180226893732*x_74 + 0.00022174357934547*x_75 + 0.00084220313217742*x_76 + 0.00117293583758924*x_77 - 0.000689413842904883*x_78 + 0.00252960907535546*x_79 + 0.00162745517523334*x_80 - 0.000582751651979557*x_81 - 0.000738098050074643*x_82 + 0.00107842810754347*x_83 + 0.000294170213509589*x_84 - 0.000496643677682545*x_85 + 0.000367746625485706*x_86 + 0.000998832287845173*x_87 + 0.000672199696577672*x_88 + 0.000631841994866354*x_89 - 8.78679220731245e-5*x_90 + 0.000561257037058337*x_91 - 0.000590358147471903*x_93 + 0.00147216942368268*x_95 - 0.000157204823152236*x_96 + 0.00203559836867481*x_97 - 0.00152008408666913*x_98 - 0.00388008914897977*x_99 + 0.435104907449045*std::sin(0.297599911689758*x_1 - 4.29648017883301) - 0.0947424186742127*std::sin(0.299439936876297*x_15 + 5.160560131073) - 0.0203293279532628*std::sin(0.352319836616516*x_23 - 1.16951990127563) + 0.0683846431451194*std::sin(0.381759852170944*x_31 + 5.17304039001465) - 0.0919457437993563*std::sin(0.361199855804443*x_5 + 2.02967977523804) + 0.0114470540085553*std::sin(0.324799835681915*x_8 - 4.32855987548828) + 0.0151318374099916*std::sin(0.356479853391647*x_9 - 4.36567974090576) + 0.0851016444890478*std::sin(0.302079945802689*x_92 + 1.98719990253448) + 0.037050251467758*std::sin(0.299519926309586*x_94 + 1.98151981830597) - 2.3250222367736) - 1.45477125218258);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000138312325945807*x_1 - 0.00174390400386441*x_10 - 8.71673533271471e-5*x_100 - 0.00195622916220252*x_101 - 0.000916355109994677*x_102 + 0.00260804651151358*x_103 - 0.000530607835537497*x_104 + 0.00123333787053389*x_105 + 0.00557197092675307*x_106 + 0.00188970560994867*x_107 - 0.00485929072234813*x_108 - 0.00101827922217885*x_109 - 0.00279078183116104*x_11 + 0.00318329424051375*x_110 - 0.000331218424142965*x_111 + 0.00899346402561242*x_112 - 0.000266748831719578*x_113 + 0.00778578484810608*x_114 + 0.000572696257987709*x_115 - 0.00064875128287391*x_116 + 0.00521671430840909*x_117 + 0.0129711892469253*x_118 + 0.00750112836451525*x_119 - 0.00303496847609079*x_12 + 0.0119653225316281*x_120 - 0.00930677677097879*x_13 - 0.00584982982048658*x_14 - 0.00153381948785227*x_15 + 0.000696511320381997*x_16 + 0.000899464528880259*x_17 - 0.000254417571785459*x_18 - 0.000970697194594114*x_19 + 0.00179300966077028*x_2 + 5.20862334911705e-5*x_20 + 0.00225893952614259*x_21 - 0.00157089550870986*x_22 - 0.000798193452035805*x_23 - 0.00218619763299015*x_24 + 0.00174821623857823*x_25 + 0.000328742087143893*x_26 - 0.00265964870507112*x_27 + 3.04205123662934e-5*x_28 - 0.00298911975528074*x_29 + 0.000574760244713867*x_3 + 0.00228040534891246*x_30 + 2.2124570598772e-5*x_31 + 0.000435768132995595*x_32 - 0.0016698925936566*x_33 + 4.73828599104147e-5*x_34 - 0.00462094171891063*x_35 - 0.00139551225880627*x_36 + 0.00212461362203237*x_37 + 0.000844199544122861*x_38 + 0.000591058937930019*x_39 - 0.00013172678328452*x_4 - 0.000383891348797547*x_40 - 0.00187029344812868*x_41 - 0.000682655979980848*x_42 - 7.95092637204463e-5*x_43 - 0.000853435876819364*x_44 + 0.000181316406662537*x_45 + 0.00101979923625736*x_46 + 0.00132996645128101*x_47 - 0.00479434868977479*x_48 - 0.0058836411519369*x_49 + 0.000864845722381262*x_5 + 0.00237494232235451*x_50 - 0.00481716759402328*x_51 - 0.00211894139862729*x_52 + 0.000950656543792021*x_53 + 0.000587685128519285*x_54 - 0.00235195777168053*x_55 - 0.000908695227057504*x_56 + 0.0010444628944542*x_57 + 9.61429891624244e-5*x_58 - 0.00133126838445641*x_59 + 0.00363355197222947*x_6 + 0.00147268172415612*x_60 + 0.00148108610387287*x_61 + 0.000536982144722548*x_62 - 0.000202661216910284*x_63 - 0.000937899845726834*x_64 - 0.00249162736780937*x_65 - 0.0015177639482763*x_66 + 0.000661749823712178*x_67 - 0.00167851038394704*x_68 - 0.000378649446508848*x_69 - 0.000965358444456773*x_7 - 0.00065227622177818*x_70 - 0.000792044597790317*x_71 - 0.00161594525060971*x_72 - 0.0018353644817043*x_73 - 0.00178021953108946*x_74 + 0.000750599320462064*x_75 + 0.000238984502352025*x_76 + 0.000152199289553557*x_77 - 0.000811586847465908*x_78 + 0.00149021699266669*x_79 - 4.33022371476641e-5*x_8 + 0.000103180579657837*x_80 - 0.000459132240939789*x_81 - 0.0013190554593825*x_82 - 0.000335242539595439*x_83 - 0.000906763167009514*x_84 - 0.00046127894241591*x_85 + 0.0010027909703707*x_86 + 0.00160361224498366*x_87 + 0.000170423876180978*x_88 + 0.0010915110090384*x_89 + 0.000698221802497339*x_9 + 0.0011336802253241*x_90 + 0.00036634103183589*x_91 + 0.00329118922691334*x_92 + 0.00172279971064061*x_93 + 0.00112528119476953*x_94 + 0.00181754120689876*x_95 + 0.00118854646674322*x_96 + 0.000244607669921411*x_97 - 0.000283353409580752*x_98 + 0.00146058001298743*x_99 + 1.70363199616223e-5*std::pow(-6.59912014007568*x_1 - 8.60007953643799, 2) + 0.243509747063805*std::exp(-0.0246721515612953*x_10 + 0.00824300608485306*x_100 + 0.000268717277586081*x_101 - 0.0297266616459931*x_102 - 0.0117661408886942*x_103 + 0.00380058952678713*x_104 + 0.00490793074553804*x_105 + 0.00174333964159482*x_106 - 0.0088887285338672*x_107 + 0.00606447320788861*x_108 + 0.0185716489525306*x_109 - 0.00824635355891001*x_110 + 0.00126192480935224*x_111 + 0.0224057903005088*x_112 + 0.0150237262625328*x_114 + 0.00610250262883295*x_115 + 0.0263706829453008*x_116 + 0.0140272601379708*x_117 + 0.00926397980404628*x_118 + 0.0150071184057513*x_119 + 0.0190473384418255*x_120 - 0.0549945305955882*x_14 - 0.0311265793183594*x_15 - 0.0152343183861889*x_16 + 0.00827419530049944*x_17 + 0.0426209240636882*x_18 + 0.0137013124082049*x_19 - 0.0149928350810115*x_2 - 0.0182848007883099*x_20 - 0.0165377607174029*x_21 - 0.00509221387849368*x_22 + 0.0266134286446208*x_23 - 0.00765342702380942*x_24 - 0.014406645549166*x_25 - 0.0171755244265962*x_26 - 0.015502122842383*x_27 - 0.00345609099709398*x_28 - 0.0197407417388768*x_29 + 0.00147674614171152*x_30 - 0.00155921669603575*x_31 + 0.0049434773751477*x_32 - 0.00258404863867742*x_33 - 0.0189344111587269*x_34 + 0.0064400740702874*x_35 - 0.000320568756378834*x_36 - 0.0259897682233746*x_37 - 0.0266379059051768*x_38 - 0.0190390719304559*x_39 - 0.0101543175488869*x_4 - 0.0020204301344731*x_40 - 0.00379695808117068*x_41 - 0.021761190583177*x_42 - 0.114714144113171*x_43 - 0.0150123419658183*x_44 - 0.00516473870202132*x_45 - 0.00266061304318286*x_46 - 0.00240323829966901*x_47 - 0.00534829807122713*x_48 + 0.00619210047389847*x_49 - 0.0012760051117507*x_5 - 0.025003961548626*x_50 - 0.0143947977506458*x_51 + 0.00153519124069524*x_52 - 0.002851908197568*x_54 - 0.0156567523794879*x_55 + 0.0239336193642928*x_56 - 0.00115043733807471*x_57 - 0.00302990384701007*x_58 - 0.00820112783099146*x_59 + 0.00748399870606979*x_6 + 0.00615571792551042*x_60 + 0.0160169421467292*x_61 + 0.0146441460813159*x_62 + 0.00386822162830571*x_63 - 0.00310616232380278*x_64 + 0.00176016346879661*x_65 - 0.00697753897999562*x_66 - 0.00114280576602136*x_67 - 0.00357637508550324*x_68 + 0.00325227417806339*x_69 - 0.00910774485229841*x_7 + 0.00435534124309665*x_70 + 0.0026399227932338*x_71 - 0.00040745126720445*x_72 + 0.0023707211312904*x_73 - 0.00509076497825299*x_74 + 0.00634630247483675*x_75 + 0.0277909269356362*x_76 + 0.000602734747743057*x_77 - 0.0007487912540256*x_78 - 0.00219646457450942*x_79 - 0.0144276264267748*x_8 - 0.0034625670781722*x_80 + 0.00975261041536319*x_81 + 0.00788754314810029*x_82 + 0.00527816919026817*x_83 - 0.00722475472005368*x_84 + 0.00358732512053934*x_85 + 0.008606767635062*x_86 + 0.00381807707685516*x_87 - 0.00307742255970001*x_88 - 0.00477822532382197*x_89 - 0.0183716037278503*x_9 - 0.00464231925079209*x_90 - 0.00262099740209934*x_91 - 0.00493994118491745*x_93 - 0.00482013996165924*x_94 + 0.0185685090867953*x_95 - 0.00648750573385367*x_96 - 0.0296885128849373*x_97 - 0.0147481613263869*x_98 - 0.0244406082656008*x_99 + 2.18750113724042*std::sin(0.259359985589981*x_1 + 5.07639980316162) - 0.857820161061937*std::sin(0.280799955129623*x_11 - 7.42807960510254) - 0.168125892832656*std::sin(0.235519990324974*x_113 - 4.19479990005493) - 0.922642726825416*std::sin(0.278319954872131*x_12 + 5.14752006530762) - 0.5896059394302*std::sin(0.310639947652817*x_13 - 7.45991992950439) + 0.898266274955262*std::sin(0.354399859905243*x_3 - 7.40895986557007) + 0.176334076529212*std::sin(0.258159965276718*x_53 - 7.43439960479736) + 0.274656562634163*std::sin(0.297439932823181*x_92 + 8.22743988037109)) + 0.003006597404974*std::sin(0.228559985756874*x_1 + 5.03671979904175) + 0.016558968719605*std::sin(0.242399975657463*x_1 + 5.05503988265991) + 0.287306866354002*std::sin(0.297599911689758*x_1 - 4.29648017883301) + 0.0361960386327602*std::sin(0.337439835071564*x_1 - 4.25399971008301) - 0.000612422041958586*std::sin(0.224879994988441*x_104 + 1.98151981830597) - 0.0104143360397357*std::sin(0.231359988451004*x_104 - 1.1904798746109) + 0.000853959645584432*std::sin(0.263839960098267*x_107 + 1.94431984424591) - 0.00186611334857771*std::sin(0.214719995856285*x_108 + 8.3810396194458) - 0.0113318988368903*std::sin(0.260559976100922*x_108 + 1.96167981624603) - 0.0135146532199051*std::sin(0.224639996886253*x_109 + 1.97367978096008) + 0.0190045245749865*std::sin(0.172640010714531*x_11 + 5.20760011672974) - 0.089748696751911*std::sin(0.301519930362701*x_11 + 5.14408016204834) - 0.0085068480901807*std::sin(0.216559991240501*x_111 + 1.96263980865479) + 0.000335611131323172*std::sin(0.259679973125458*x_113 - 7.40687990188599) + 0.00411067050519013*std::sin(0.282799929380417*x_113 - 7.41304016113281) - 0.0258744323156753*std::sin(0.289039939641953*x_113 - 7.42664003372192) + 0.028457596845131*std::sin(0.289839953184128*x_113 - 7.42519998550415) + 0.0253922987582262*std::sin(0.293839931488037*x_113 - 7.44047975540161) + 0.00394037986175516*std::sin(0.237039983272552*x_119 + 5.1701602935791) - 0.00017091533264495*std::sin(0.24695996940136*x_12 + 2.14351987838745) - 0.0011729801685525*std::sin(0.26895996928215*x_12 - 4.22751998901367) - 0.0635128058410241*std::sin(0.293199926614761*x_12 - 7.44055986404419) + 0.00932512117075054*std::sin(0.264879941940308*x_120 + 5.16535997390747) + 0.00177831765149764*std::sin(0.269759953022003*x_120 + 5.14287996292114) - 0.00144683380573129*std::sin(0.319199919700623*x_13 - 7.46647977828979) - 0.0625599641697323*std::sin(0.299439936876297*x_15 + 5.160560131073) - 0.00989096855048401*std::sin(0.335599839687347*x_16 - 1.15495979785919) - 0.000253778903576168*std::sin(0.383199840784073*x_16 - 7.57936000823975) + 0.0588021520119063*std::sin(0.356399834156036*x_17 + 1.99591982364655) + 0.00448330650054812*std::sin(0.361359834671021*x_17 + 1.98919987678528) + 0.0100036203850048*std::sin(0.38783985376358*x_18 + 1.99743974208832) + 0.0396204306809891*std::sin(0.209199994802475*x_19 - 1.17927992343903) - 0.0271582417458332*std::sin(0.225599989295006*x_19 - 1.18735992908478) - 0.00114140355026484*std::sin(0.361839860677719*x_2 - 7.40703964233398) + 0.00083954192419899*std::sin(0.371599853038788*x_2 - 7.41815996170044) - 0.130608376633101*std::sin(0.392399847507477*x_2 + 5.18391990661621) + 0.0014231730236898*std::sin(0.404959857463837*x_2 + 5.19816017150879) + 0.00495337177621775*std::sin(0.315199911594391*x_21 + 1.98335981369019) - 0.000371537593420697*std::sin(0.377199828624725*x_21 - 1.18823993206024) - 0.000180885479351694*std::sin(0.301199942827225*x_23 + 8.23463916778564) + 0.0244225072676163*std::sin(0.348559856414795*x_23 + 1.98695981502533) - 0.0134237867910482*std::sin(0.352319836616516*x_23 - 1.16951990127563) - 0.000980345837392989*std::sin(0.258719980716705*x_25 - 1.17999982833862) + 0.0126473533668763*std::sin(0.334399849176407*x_25 - 4.35735988616943) + 0.00698745321431576*std::sin(0.305039942264557*x_26 - 4.39551973342896) + 0.00193031369603223*std::sin(0.336399853229523*x_26 - 1.15855991840363) - 0.0119249342087829*std::sin(0.343119859695435*x_26 + 5.04207992553711) - 0.00127990811739898*std::sin(0.348079830408096*x_3 - 7.39111995697021) + 0.000475633436045177*std::sin(0.350639849901199*x_3 - 7.41487979888916) + 0.0127782015971369*std::sin(0.361919850111008*x_3 - 7.39071989059448) - 0.0120919701329771*std::sin(0.400879859924316*x_3 - 1.17607986927032) - 0.000312474920575246*std::sin(0.460159868001938*x_3 + 8.19824028015137) + 0.00555044505637951*std::sin(0.29751992225647*x_30 + 2.00103974342346) - 0.0163358564311995*std::sin(0.355439841747284*x_31 + 8.35223960876465) + 0.0140408040604806*std::sin(0.377839833498001*x_31 + 5.16879987716675) + 0.0451554951286359*std::sin(0.381759852170944*x_31 + 5.17304039001465) - 0.0966512694002857*std::sin(0.38223984837532*x_31 - 7.39759969711304) + 0.000821699835730842*std::sin(0.388639837503433*x_31 - 7.40663957595825) + 0.00436415803444081*std::sin(0.392079830169678*x_31 + 8.40104007720947) - 0.000925477591991004*std::sin(0.420639842748642*x_31 + 2.00063967704773) + 0.00782536246190171*std::sin(0.278239965438843*x_32 + 2.04231977462769) - 0.00817828259698549*std::sin(0.291119933128357*x_32 + 2.01647973060608) - 0.000754919371201905*std::sin(0.30311992764473*x_32 - 1.14807987213135) - 0.00288872580895833*std::sin(0.31879985332489*x_32 + 1.9916797876358) + 0.00159989488021806*std::sin(0.320479840040207*x_32 + 2.01711988449097) + 0.00769060626862504*std::sin(0.362319827079773*x_32 + 8.21008014678955) - 0.0359538311685183*std::sin(0.23743999004364*x_33 + 1.99071979522705) + 0.0031202773232621*std::sin(0.244079977273941*x_34 + 1.97359979152679) + 0.000570002554891898*std::sin(0.211040005087852*x_36 + 8.18279933929443) - 0.000668436558914035*std::sin(0.254639983177185*x_37 + 1.97111976146698) + 0.000755099374038779*std::sin(0.311999946832657*x_4 - 7.37815999984741) + 0.00319563080982851*std::sin(0.361039847135544*x_4 + 2.00863981246948) - 0.000818167424007709*std::sin(0.217840000987053*x_40 - 1.18151986598969) - 0.000272853213574169*std::sin(0.230159983038902*x_42 - 7.42208003997803) + 0.000168792303665644*std::sin(0.227999985218048*x_44 - 7.59743976593018) - 0.00254486590209098*std::sin(0.19463999569416*x_47 - 1.1743198633194) + 0.0448582047132934*std::sin(0.357679843902588*x_5 + 1.99735975265503) - 0.0607132741399259*std::sin(0.361199855804443*x_5 + 2.02967977523804) - 0.0156870336665056*std::sin(0.382959842681885*x_5 + 2.00695967674255) - 9.69503344800833e-5*std::sin(0.530799865722656*x_5 + 1.86231982707977) + 0.00355000692510036*std::sin(0.232719987630844*x_52 - 7.42647981643677) + 0.000244591420520534*std::sin(0.24551996588707*x_52 - 7.42375993728638) + 0.00319809105405074*std::sin(0.237919986248016*x_53 - 7.41623973846436) + 0.000431672635377014*std::sin(0.238559976220131*x_53 - 7.40831995010376) - 0.00207553434481084*std::sin(0.273599952459335*x_6 + 2.01239991188049) - 0.0509055581598089*std::sin(0.34487983584404*x_6 + 2.00751972198486) + 0.0429099276402045*std::sin(0.378239840269089*x_6 + 1.9968798160553) - 0.000604562493904027*std::sin(0.478239864110947*x_6 + 5.13472032546997) - 0.00250719981558384*std::sin(0.33927983045578*x_7 + 2.03287982940674) - 0.0630450043698582*std::sin(0.353279858827591*x_7 + 1.99943971633911) - 0.0516144711284379*std::sin(0.357119828462601*x_7 - 1.14767980575562) + 0.00755867644762933*std::sin(0.324799835681915*x_8 - 4.32855987548828) + 0.00999179902137066*std::sin(0.356479853391647*x_9 - 4.36567974090576) - 0.00266271001272404*std::sin(0.309759914875031*x_91 - 4.35207986831665) + 0.000927484910674553*std::sin(0.363919854164124*x_91 - 7.40927982330322) - 0.00589646369787362*std::sin(0.366639852523804*x_91 + 1.99207985401154) + 0.0106248109104877*std::sin(0.368159830570221*x_91 + 2.00927972793579) - 0.000252651985823429*std::sin(0.389919847249985*x_91 + 2.01271986961365) - 0.0116391987608628*std::sin(0.395359843969345*x_91 + 1.99727976322174) - 0.0235313863120181*std::sin(0.294639945030212*x_92 - 7.40287971496582) + 0.0561940037474388*std::sin(0.302079945802689*x_92 + 1.98719990253448) - 0.00137784392378094*std::sin(0.320639848709106*x_92 - 1.1794399023056) + 0.000323425829056536*std::sin(0.271519958972931*x_94 - 1.19207990169525) + 0.0244648852830416*std::sin(0.299519926309586*x_94 + 1.98151981830597) + 0.00103463766120695*std::sin(0.25943997502327*x_97 - 1.19791984558105) + 0.000717577391528871*std::sin(0.248719975352287*x_98 - 7.43247985839844) - 0.0148056921619233*std::sin(0.262879967689514*x_98 + 1.96247982978821) + 0.681068420410156*std::sin(0.00942681195061868*x_10 + 0.0208056032993598*x_100 + 0.00365063805216074*x_101 - 0.0101613651578361*x_102 + 0.00300229329136686*x_103 - 0.00109163236515009*x_104 - 0.00767544859694076*x_105 + 0.000824139244495849*x_106 + 0.0109242134824541*x_107 - 0.0128758278555953*x_109 + 0.0194815536694982*x_11 + 0.0340631823157267*x_110 + 0.00234508911568777*x_111 - 0.0123440314129935*x_112 - 0.00933248356219463*x_113 - 0.00667777144116068*x_114 + 0.00372626287100894*x_115 - 0.00592836397810685*x_116 - 0.00639907548818486*x_117 + 0.00214499661939147*x_118 - 0.00381579811373175*x_119 + 0.00618662604109492*x_12 - 3.03913971483224e-5*x_120 - 0.0169590645523329*x_14 - 0.0273084643503069*x_16 + 0.00431320371956354*x_2 - 0.00180551505243799*x_21 - 0.00397566023056941*x_23 - 0.0029777032103969*x_24 - 0.00465293615924496*x_26 - 0.00342125209720127*x_27 + 0.00132850323666681*x_28 + 0.0168951795304696*x_29 - 0.0292642088551589*x_30 - 0.00465208765946428*x_32 - 0.00674464385956574*x_33 + 0.00285297992063452*x_34 + 0.00609977611719097*x_35 - 0.00219177398601821*x_36 + 0.0237521164017018*x_37 + 0.00628174451197794*x_38 + 0.0212946730716842*x_39 + 0.00104715888228689*x_4 + 0.00553979495343292*x_40 - 0.00244221574712744*x_41 + 0.00452712323573208*x_42 + 0.0131378675170932*x_43 + 0.00226129694491096*x_44 + 0.00359037177616635*x_45 + 0.00333802058024084*x_46 - 0.00526492477061746*x_47 + 0.0018285171883511*x_49 - 0.00171831149693832*x_5 + 0.0137940286841327*x_50 + 0.0101782877901555*x_51 + 0.00361738389408*x_52 + 0.00130271180721245*x_53 + 0.0180945864820447*x_54 + 0.0129706519542184*x_55 + 0.00185204713978843*x_56 + 0.00294455830296768*x_57 + 0.00482553603039883*x_58 + 0.0118655160289847*x_59 - 0.000256291045603389*x_6 + 0.00355198663781655*x_60 + 0.00188440146087241*x_61 - 0.0040289207478701*x_62 - 0.00714277934484558*x_63 + 0.000347173157422801*x_64 + 0.000590735060228623*x_65 - 0.00418696698281951*x_66 - 0.00197024899729068*x_67 - 0.00973028532645103*x_68 - 0.00385516828512054*x_69 + 0.00424462049452294*x_7 + 0.00052988487463024*x_70 + 0.00536408990908038*x_71 + 0.000256508362900494*x_72 - 0.0047057697427106*x_73 - 0.00623002808346533*x_74 - 0.00261687522665371*x_75 - 0.00238944910213306*x_76 - 0.0070750260024261*x_77 - 0.00879812472271162*x_78 - 0.00637785013527457*x_79 - 0.00366410797563462*x_80 + 0.0152619469488622*x_81 - 0.000430226523664957*x_82 - 0.000374046513790657*x_83 - 0.011516852995411*x_84 + 0.00449531689619733*x_85 + 0.00490491445247194*x_86 + 0.00386158220162452*x_87 - 0.00298685610932894*x_88 + 0.0033933798849523*x_89 + 0.00296717709516113*x_9 - 0.000222252137466748*x_90 + 0.0044802681630099*x_91 + 0.000303258067308444*x_93 + 0.00179281321098446*x_94 + 0.00685289141007288*x_95 - 0.0051716414253855*x_96 - 0.00228840592436807*x_98 + 0.00773216507431231*x_99 - 0.000566524268303475*std::pow(-4.72503995895386*x_1 - 6.98927974700928, 2) + 0.0761281963006954*std::sin(0.252159982919693*x_108 + 1.96295976638794) - 0.28126249271947*std::sin(0.301679939031601*x_13 - 7.43824005126953) - 0.171525067509315*std::sin(0.293279945850372*x_15 + 5.1560001373291) + 0.185686099138906*std::sin(0.375039845705032*x_17 + 1.98655986785889) - 0.55571936425531*std::sin(0.31415992975235*x_18 - 1.15887987613678) + 0.572647246475853*std::sin(0.309599906206131*x_19 + 1.9851998090744) - 0.0964247558834384*std::sin(0.250399976968765*x_20 - 1.17255985736847) - 0.194190478342861*std::sin(0.248879969120026*x_22 - 1.15287983417511) - 0.183463858358056*std::sin(0.354479849338531*x_25 - 1.15239989757538) - 0.126262422780055*std::sin(0.372799843549728*x_3 - 7.38903999328613) + 0.0406464195655341*std::sin(0.409919857978821*x_31 + 5.20584011077881) + 0.179474541942568*std::sin(0.178720012307167*x_48 + 1.99559986591339) - 0.0910266348565614*std::sin(0.330319821834564*x_8 - 1.13239991664886) - 0.0685759602757194*std::sin(0.314319908618927*x_92 + 5.02783966064453) - 0.141137221292855*std::sin(0.274719953536987*x_97 + 1.97767972946167) - 0.549048619962823) - 1.36727409766783);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00156332709008738*x_1 - 0.00504505768186918*x_10 - 0.00557830738673791*x_100 - 0.0028682957478913*x_101 + 0.000967278497633913*x_102 + 0.000267784067598279*x_103 + 0.000903767219209194*x_104 + 0.000984879730513948*x_105 + 0.00415023146757455*x_106 - 0.00132919699278635*x_107 - 0.00218401446821474*x_108 + 0.00101752370556623*x_109 - 0.00985144256412664*x_11 - 0.00791222778088988*x_110 + 0.0013908205333741*x_111 - 0.00384826156663852*x_112 + 0.00346173857286727*x_113 - 0.00751516689978622*x_114 - 0.00193290311711659*x_115 - 0.00190428186589025*x_116 - 0.0106910950890677*x_117 - 0.00559975575329106*x_118 - 0.00461783402673804*x_119 - 0.00947990501969089*x_12 - 0.00418288770498271*x_120 - 0.00853769793713302*x_13 - 0.0032990034970168*x_14 - 0.00194685239118626*x_15 + 0.00598829035356384*x_16 + 0.00081081610664223*x_17 - 0.00291591520695122*x_18 - 0.00351375199564427*x_19 - 0.00156518660276599*x_2 - 0.00127307359711276*x_20 + 0.00436162819021842*x_21 + 0.00284018728673427*x_22 + 0.00311272209049896*x_23 - 0.000833059826363113*x_24 + 0.00382328583115966*x_25 - 0.00227237587326317*x_26 - 0.00113043193755288*x_27 + 0.000282586504049627*x_28 - 0.00405854050254154*x_29 - 9.41420778069837e-6*x_3 + 0.0475381058006629*x_30 - 1.17833924672882e-5*x_31 + 0.00170044762378492*x_32 + 0.00332544905592465*x_33 + 0.00045183933047279*x_34 + 0.00141104871106989*x_35 - 8.28334710521308e-5*x_36 - 0.00471814101625161*x_37 - 0.000498197300118034*x_38 - 0.00401564629477212*x_39 - 0.000565238637443716*x_4 + 0.000587073115791291*x_40 + 0.00105420242743568*x_41 + 0.00277239366431417*x_42 - 0.000268406251110379*x_43 + 0.000561587198564618*x_44 + 0.000183054377210597*x_45 + 0.0016699820073523*x_46 + 0.00203432860373306*x_47 - 0.0043945898510303*x_48 - 0.00065860807392874*x_49 - 2.49417304515325e-5*x_5 - 0.00042399151982713*x_50 + 0.00399863591573797*x_51 + 0.00323766739788066*x_52 + 0.00193885480443608*x_53 - 0.00513796793385561*x_54 - 0.00549462641153842*x_55 + 0.00134224772654635*x_56 + 0.00219769525582933*x_57 + 0.000191216086387194*x_58 - 0.00562562192408496*x_59 + 0.000774244704676527*x_6 - 0.000753357292971227*x_60 + 0.00131191501375146*x_61 + 0.00148804056271065*x_62 + 0.00212108264605044*x_63 - 0.00188593745503242*x_64 - 0.000781475614429182*x_65 - 0.000805812249296964*x_66 + 0.00163130724352482*x_67 + 0.00167187431313182*x_68 + 0.00146088615268042*x_69 - 0.00207070162786146*x_7 + 0.000356371051799579*x_70 - 0.000604124325954674*x_71 + 0.000814722526906404*x_72 + 0.000552118822317782*x_73 - 0.000258020809504841*x_74 + 0.0010585919631796*x_75 + 0.00153176366164497*x_76 + 0.0031944306202832*x_77 + 0.00119585095116688*x_78 + 0.00386188568683226*x_79 - 0.000701717795945434*x_8 + 0.00362745085426609*x_80 - 0.00415540289026846*x_81 - 0.000481919664680831*x_82 + 0.00097945879715163*x_83 + 0.00237429072849663*x_84 - 0.00194023752341413*x_85 + 0.000678769313776334*x_86 + 0.00039991161794737*x_87 + 0.00151413286919522*x_88 - 0.000618021251448681*x_89 - 0.00145812958401169*x_9 + 0.000662834669680225*x_90 - 0.000729316920066855*x_91 - 0.0035839537603173*x_92 - 0.0003387914800044*x_93 - 0.00202875529141226*x_94 + 0.000611272195154304*x_95 + 0.00171419394095238*x_96 + 0.00130473257891149*x_97 - 0.00257399490396962*x_98 - 0.00327142410433019*x_99 + 6.33778989187566e-6*std::pow(-6.59912014007568*x_1 - 8.60007953643799, 2) + 0.000146828851067939*std::pow(-4.72503995895386*x_1 - 6.98927974700928, 2) - 0.00365615467336137*std::sin(0.228559985756874*x_1 + 5.03671979904175) + 0.175850181572959*std::sin(0.242399975657463*x_1 + 5.05503988265991) - 0.0212140702141741*std::sin(0.259359985589981*x_1 + 5.07639980316162) + 0.350205871038579*std::sin(0.297599911689758*x_1 - 4.29648017883301) - 0.0552596296593778*std::sin(0.337439835071564*x_1 - 4.25399971008301) - 0.00648870985321834*std::sin(0.224879994988441*x_104 + 1.98151981830597) - 0.00387430347821125*std::sin(0.231359988451004*x_104 - 1.1904798746109) - 0.00587136248046139*std::sin(0.263839960098267*x_107 + 1.94431984424591) + 0.00284895078135687*std::sin(0.214719995856285*x_108 + 8.3810396194458) - 0.0197305150407395*std::sin(0.252159982919693*x_108 + 1.96295976638794) + 0.00280473746519623*std::sin(0.260559976100922*x_108 + 1.96167981624603) + 0.00334498699296584*std::sin(0.224639996886253*x_109 + 1.97367978096008) + 0.00706999422543028*std::sin(0.172640010714531*x_11 + 5.20760011672974) + 0.00831901607642548*std::sin(0.280799955129623*x_11 - 7.42807960510254) + 0.0222135350708529*std::sin(0.301519930362701*x_11 + 5.14408016204834) + 0.00210551434430298*std::sin(0.216559991240501*x_111 + 1.96263980865479) + 0.00163046063595288*std::sin(0.235519990324974*x_113 - 4.19479990005493) - 0.00040811789572802*std::sin(0.259679973125458*x_113 - 7.40687990188599) + 0.0436538148579542*std::sin(0.282799929380417*x_113 - 7.41304016113281) - 0.00962571235793415*std::sin(0.289039939641953*x_113 - 7.42664003372192) - 0.00704348752048091*std::sin(0.289839953184128*x_113 - 7.42519998550415) - 0.038765817436991*std::sin(0.293839931488037*x_113 - 7.44047975540161) - 0.0270919107228322*std::sin(0.237039983272552*x_119 + 5.1701602935791) + 0.000207840561282049*std::sin(0.24695996940136*x_12 + 2.14351987838745) - 0.0124279131968784*std::sin(0.26895996928215*x_12 - 4.22751998901367) + 0.00894765596061046*std::sin(0.278319954872131*x_12 + 5.14752006530762) + 0.015719937905035*std::sin(0.293199926614761*x_12 - 7.44055986404419) - 0.0641144658893458*std::sin(0.264879941940308*x_120 + 5.16535997390747) + 0.0188415610099891*std::sin(0.269759953022003*x_120 + 5.14287996292114) + 0.0728961687346152*std::sin(0.301679939031601*x_13 - 7.43824005126953) + 0.00571791327777108*std::sin(0.310639947652817*x_13 - 7.45991992950439) - 0.0153648449823155*std::sin(0.319199919700623*x_13 - 7.46647977828979) + 0.0444549863100523*std::sin(0.293279945850372*x_15 + 5.1560001373291) - 0.0762559803120356*std::sin(0.299439936876297*x_15 + 5.160560131073) - 0.00367960220524927*std::sin(0.335599839687347*x_16 - 1.15495979785919) - 0.00269503898636026*std::sin(0.383199840784073*x_16 - 7.57936000823975) + 0.0218753630761292*std::sin(0.356399834156036*x_17 + 1.99591982364655) - 0.0308247792642613*std::sin(0.361359834671021*x_17 + 1.98919987678528) - 0.0481251697786902*std::sin(0.375039845705032*x_17 + 1.98655986785889) + 0.144028491513984*std::sin(0.31415992975235*x_18 - 1.15887987613678) + 0.00372151053167984*std::sin(0.38783985376358*x_18 + 1.99743974208832) - 0.00980638001783249*std::sin(0.209199994802475*x_19 - 1.17927992343903) - 0.0101033104805263*std::sin(0.225599989295006*x_19 - 1.18735992908478) - 0.148415773112526*std::sin(0.309599906206131*x_19 + 1.9851998090744) - 0.012093353856788*std::sin(0.361839860677719*x_2 - 7.40703964233398) - 0.00577223406282019*std::sin(0.371599853038788*x_2 - 7.41815996170044) + 0.0323266393818111*std::sin(0.392399847507477*x_2 + 5.18391990661621) + 0.0151135761449495*std::sin(0.404959857463837*x_2 + 5.19816017150879) + 0.0249908731417092*std::sin(0.250399976968765*x_20 - 1.17255985736847) - 0.0340566926657963*std::sin(0.315199911594391*x_21 + 1.98335981369019) - 0.00394559313267234*std::sin(0.377199828624725*x_21 - 1.18823993206024) + 0.0503292911154552*std::sin(0.248879969120026*x_22 - 1.15287983417511) + 0.000219964698160387*std::sin(0.301199942827225*x_23 + 8.23463916778564) - 0.0372852598775951*std::sin(0.348559856414795*x_23 + 1.98695981502533) - 0.0163626056190486*std::sin(0.352319836616516*x_23 - 1.16951990127563) - 0.010410913652234*std::sin(0.258719980716705*x_25 - 1.17999982833862) - 0.00313032319951313*std::sin(0.334399849176407*x_25 - 4.35735988616943) + 0.0475492208230956*std::sin(0.354479849338531*x_25 - 1.15239989757538) + 0.00259944697278552*std::sin(0.305039942264557*x_26 - 4.39551973342896) + 0.0204519835033855*std::sin(0.336399853229523*x_26 - 1.15855991840363) + 0.00295151856072799*std::sin(0.343119859695435*x_26 + 5.04207992553711) - 0.0135608319811952*std::sin(0.348079830408096*x_3 - 7.39111995697021) - 0.000578391176393149*std::sin(0.350639849901199*x_3 - 7.41487979888916) - 0.00871125664966051*std::sin(0.354399859905243*x_3 - 7.40895986557007) - 0.00316270920462569*std::sin(0.361919850111008*x_3 - 7.39071989059448) + 0.0327240464479431*std::sin(0.372799843549728*x_3 - 7.38903999328613) - 0.0044984108219547*std::sin(0.400879859924316*x_3 - 1.17607986927032) - 0.00331836918413259*std::sin(0.460159868001938*x_3 + 8.19824028015137) - 0.0381618440899348*std::sin(0.29751992225647*x_30 + 2.00103974342346) - 0.00607720599272715*std::sin(0.355439841747284*x_31 + 8.35223960876465) - 0.0965369389320458*std::sin(0.377839833498001*x_31 + 5.16879987716675) + 0.0550412167463397*std::sin(0.381759852170944*x_31 + 5.17304039001465) + 0.0239219781474987*std::sin(0.38223984837532*x_31 - 7.39759969711304) + 0.00872615123311772*std::sin(0.388639837503433*x_31 - 7.40663957595825) - 0.00666265607695333*std::sin(0.392079830169678*x_31 + 8.40104007720947) - 0.0105345303259556*std::sin(0.409919857978821*x_31 + 5.20584011077881) - 0.0098055836639709*std::sin(0.420639842748642*x_31 + 2.00063967704773) - 0.0119467943987579*std::sin(0.278239965438843*x_32 + 2.04231977462769) - 0.00304245499572911*std::sin(0.291119933128357*x_32 + 2.01647973060608) - 0.00799849193317317*std::sin(0.30311992764473*x_32 - 1.14807987213135) - 0.0306772098324208*std::sin(0.31879985332489*x_32 + 1.9916797876358) - 0.0110000078118046*std::sin(0.320479840040207*x_32 + 2.01711988449097) - 0.00190348783043009*std::sin(0.362319827079773*x_32 + 8.21008014678955) + 0.00889886670779318*std::sin(0.23743999004364*x_33 + 1.99071979522705) - 0.0214533313127432*std::sin(0.244079977273941*x_34 + 1.97359979152679) + 0.00605321831764301*std::sin(0.211040005087852*x_36 + 8.18279933929443) - 0.00708219265297143*std::sin(0.254639983177185*x_37 + 1.97111976146698) + 0.0080188787284281*std::sin(0.311999946832657*x_4 - 7.37815999984741) - 0.0219714209392094*std::sin(0.361039847135544*x_4 + 2.00863981246948) - 0.00866861520653773*std::sin(0.217840000987053*x_40 - 1.18151986598969) - 0.00289760117083714*std::sin(0.230159983038902*x_42 - 7.42208003997803) + 0.00178838155537314*std::sin(0.227999985218048*x_44 - 7.59743976593018) + 0.0174971150599472*std::sin(0.19463999569416*x_47 - 1.1743198633194) - 0.046515290277478*std::sin(0.178720012307167*x_48 + 1.99559986591339) + 0.0166879864336926*std::sin(0.357679843902588*x_5 + 1.99735975265503) - 0.0740050014244313*std::sin(0.361199855804443*x_5 + 2.02967977523804) + 0.0239490204897924*std::sin(0.382959842681885*x_5 + 2.00695967674255) + 0.000117895870563478*std::sin(0.530799865722656*x_5 + 1.86231982707977) + 0.0376997730314603*std::sin(0.232719987630844*x_52 - 7.42647981643677) - 0.000297433924382696*std::sin(0.24551996588707*x_52 - 7.42375993728638) + 0.0339625554021273*std::sin(0.237919986248016*x_53 - 7.41623973846436) - 0.000524932909402794*std::sin(0.238559976220131*x_53 - 7.40831995010376) - 0.00171006241640693*std::sin(0.258159965276718*x_53 - 7.43439960479736) - 0.0220414143885528*std::sin(0.273599952459335*x_6 + 2.01239991188049) + 0.0777163026058038*std::sin(0.34487983584404*x_6 + 2.00751972198486) + 0.0159631954713128*std::sin(0.378239840269089*x_6 + 1.9968798160553) - 0.00640543667980289*std::sin(0.478239864110947*x_6 + 5.13472032546997) - 0.0266255435513996*std::sin(0.33927983045578*x_7 + 2.03287982940674) + 0.0962493058618595*std::sin(0.353279858827591*x_7 + 1.99943971633911) - 0.0192014281329083*std::sin(0.357119828462601*x_7 - 1.14767980575562) + 0.00921346886982937*std::sin(0.324799835681915*x_8 - 4.32855987548828) + 0.0235918158503498*std::sin(0.330319821834564*x_8 - 1.13239991664886) + 0.012179265758341*std::sin(0.356479853391647*x_9 - 4.36567974090576) + 0.00406509592627835*std::sin(0.309759914875031*x_91 - 4.35207986831665) + 0.00982685152767945*std::sin(0.363919854164124*x_91 - 7.40927982330322) + 0.0405408802419515*std::sin(0.366639852523804*x_91 + 1.99207985401154) + 0.00395260357537725*std::sin(0.368159830570221*x_91 + 2.00927972793579) + 0.000307235926291351*std::sin(0.389919847249985*x_91 + 2.01271986961365) + 0.00288079670488974*std::sin(0.395359843969345*x_91 + 1.99727976322174) - 0.00875406089144197*std::sin(0.294639945030212*x_92 - 7.40287971496582) - 0.00266357969159971*std::sin(0.297439932823181*x_92 + 8.22743988037109) + 0.0684963442720828*std::sin(0.302079945802689*x_92 + 1.98719990253448) + 0.0177731652843702*std::sin(0.314319908618927*x_92 + 5.02783966064453) + 0.00947330609806812*std::sin(0.320639848709106*x_92 - 1.1794399023056) + 0.003426748581865*std::sin(0.271519958972931*x_94 - 1.19207990169525) + 0.029820890009116*std::sin(0.299519926309586*x_94 + 1.98151981830597) + 0.0109621521219484*std::sin(0.25943997502327*x_97 - 1.19791984558105) + 0.0365792203525701*std::sin(0.274719953536987*x_97 + 1.97767972946167) + 0.00760284766362959*std::sin(0.248719975352287*x_98 - 7.43247985839844) + 0.0036645296699546*std::sin(0.262879967689514*x_98 + 1.96247982978821) + 0.486068936137876);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00344263015619752*x_1 + 0.000376117606880786*x_10 + 0.00150005184836742*x_100 + 0.000346852623170032*x_101 - 0.002020934791125*x_102 + 0.00391360567413975*x_103 + 0.000729361167106277*x_104 - 0.00125479523278106*x_105 + 0.00109115682970328*x_106 - 0.000240864703551503*x_107 - 0.00254286412403698*x_108 - 0.0011948648545472*x_109 - 0.00034326828624363*x_11 - 0.00206421829787854*x_110 + 0.00120547394838224*x_111 + 0.00109263617016644*x_112 + 0.00457424516405305*x_113 + 0.0173001577104742*x_114 + 0.00308268183444138*x_115 - 0.00119836008231005*x_116 + 0.0402491808702325*x_117 + 0.014187979399794*x_118 + 0.00180087791155307*x_119 - 0.000193997281887165*x_12 + 0.00165007277892225*x_120 - 0.000624508572695159*x_13 - 2.31775003601795e-5*x_14 + 0.00306691207920401*x_15 + 0.00147832974256549*x_16 + 0.000442374864795159*x_17 - 0.000558550485616387*x_18 + 0.00173829817810697*x_19 + 0.000612281938373836*x_2 + 0.00223583303761207*x_20 + 0.00153637339155423*x_21 - 0.0102411266257193*x_22 - 0.00632436398547972*x_23 - 0.000482332202520901*x_24 - 0.00377954889779905*x_25 + 0.000175175281479426*x_26 + 0.000589150812953882*x_27 + 0.00312392818168049*x_28 + 0.00356420322382041*x_29 + 0.0017166364142722*x_3 + 0.00416668887304046*x_30 + 4.45581093281956e-5*x_31 + 0.000170897765444546*x_32 - 0.00555956141909125*x_33 - 0.000318336662860862*x_34 + 0.000863946126500966*x_35 - 0.00202014296153059*x_36 - 0.000197020863343586*x_37 - 0.00299270788083297*x_38 - 0.00113004052741852*x_39 - 3.39872641085236e-5*x_4 - 0.000210284663432831*x_40 - 0.00268767786363769*x_41 - 0.0128756835969969*x_42 - 0.00212998259232075*x_43 - 0.000809233688253786*x_44 - 0.00378989941443928*x_45 - 0.00318701201613227*x_46 - 0.000290390584748682*x_47 - 0.00525343370549936*x_48 - 0.0123796082597748*x_49 + 0.000411466241384346*x_5 - 0.00665993844891062*x_50 - 0.00543832569494856*x_51 - 0.00688161136003384*x_52 - 0.00508783676418139*x_53 - 0.00252754436807981*x_54 - 0.00407688821045734*x_55 - 0.00760941628944656*x_56 - 0.000640502349893943*x_57 - 0.00080076873468392*x_58 + 0.00210702569231261*x_59 + 0.0013540183239484*x_6 + 0.00149081190785715*x_60 + 0.000427747212557863*x_61 - 0.000376068484298678*x_62 - 0.00129293955458044*x_63 + 0.00258965296209743*x_64 + 0.000181097369382293*x_65 - 0.00106988851044818*x_66 - 0.00143537527439118*x_67 - 0.000388323087867901*x_68 - 0.000761741799617988*x_69 - 0.000484487011683939*x_7 - 0.00157498490183948*x_70 - 0.000681047443631756*x_71 - 0.000796418266781968*x_72 - 0.00134265629507805*x_73 - 0.000654374195222903*x_74 + 0.0012278781446047*x_75 - 0.000227077310438657*x_76 - 0.000515808128948746*x_77 - 0.000133220594085817*x_78 - 0.00124668006034065*x_79 - 0.00123775122873033*x_8 - 0.000948124985280653*x_80 + 0.000601712341530508*x_81 - 1.67152886869179e-5*x_82 + 3.18776095696531e-5*x_83 - 0.000170858530118918*x_84 - 0.000631620692556672*x_85 - 0.000943221850322546*x_86 + 0.000385190897222954*x_87 - 0.000601020423908598*x_88 - 0.00105304394500033*x_89 + 0.000609433824277227*x_9 - 0.00248083258100822*x_90 + 0.000119516545388301*x_91 - 0.00156752307400842*x_92 + 0.00165255380526885*x_93 + 0.000209636917244073*x_94 + 0.00227086270826638*x_95 - 0.00311139643593323*x_96 + 0.00235637035377907*x_97 + 0.000219766715042875*x_98 + 0.00112130957666245*x_99 - 6.82639642235528e-7*std::pow(-6.59912014007568*x_1 - 8.60007953643799, 2) + 2.88215332144121e-6*std::pow(-4.72503995895386*x_1 - 6.98927974700928, 2) + 0.00535454788329513*std::sin(0.228559985756874*x_1 + 5.03671979904175) + 0.0429542287896423*std::sin(0.242399975657463*x_1 + 5.05503988265991) - 0.00723323379170939*std::sin(0.259359985589981*x_1 + 5.07639980316162) + 0.112183487737263*std::sin(0.297599911689758*x_1 - 4.29648017883301) + 0.0153103759047663*std::sin(0.337439835071564*x_1 - 4.25399971008301) - 0.00118551424099049*std::sin(0.224879994988441*x_104 + 1.98151981830597) + 0.000417298961530465*std::sin(0.231359988451004*x_104 - 1.1904798746109) + 0.0174630374014142*std::sin(0.263839960098267*x_107 + 1.94431984424591) - 0.000789337671381755*std::sin(0.214719995856285*x_108 + 8.3810396194458) - 0.000387296972255817*std::sin(0.252159982919693*x_108 + 1.96295976638794) + 0.00435191473408624*std::sin(0.260559976100922*x_108 + 1.96167981624603) + 0.00519018209748782*std::sin(0.224639996886253*x_109 + 1.97367978096008) - 0.000761504942731173*std::sin(0.172640010714531*x_11 + 5.20760011672974) + 0.00283648482305719*std::sin(0.280799955129623*x_11 - 7.42807960510254) + 0.0344671869544206*std::sin(0.301519930362701*x_11 + 5.14408016204834) + 0.00326697917773241*std::sin(0.216559991240501*x_111 + 1.96263980865479) + 0.000555928346091105*std::sin(0.235519990324974*x_113 - 4.19479990005493) + 0.000597700866056697*std::sin(0.259679973125458*x_113 - 7.40687990188599) + 0.0106631448098407*std::sin(0.282799929380417*x_113 - 7.41304016113281) + 0.00103677984792545*std::sin(0.289039939641953*x_113 - 7.42664003372192) - 0.0109288863931472*std::sin(0.289839953184128*x_113 - 7.42519998550415) + 0.0107405576344675*std::sin(0.293839931488037*x_113 - 7.44047975540161) + 0.0805787501287801*std::sin(0.237039983272552*x_119 + 5.1701602935791) - 0.00030438871899599*std::sin(0.24695996940136*x_12 + 2.14351987838745) - 0.00227063136031353*std::sin(0.26895996928215*x_12 - 4.22751998901367) + 0.00305082837934773*std::sin(0.278319954872131*x_12 + 5.14752006530762) + 0.0243915269207046*std::sin(0.293199926614761*x_12 - 7.44055986404419) + 0.190693952131764*std::sin(0.264879941940308*x_120 + 5.16535997390747) + 0.00344243145480676*std::sin(0.269759953022003*x_120 + 5.14287996292114) + 0.0014309036222152*std::sin(0.301679939031601*x_13 - 7.43824005126953) + 0.00194960246295422*std::sin(0.310639947652817*x_13 - 7.45991992950439) - 0.00375310995293994*std::sin(0.319199919700623*x_13 - 7.46647977828979) + 0.000872622005254645*std::sin(0.293279945850372*x_15 + 5.1560001373291) - 0.0244275226079401*std::sin(0.299439936876297*x_15 + 5.160560131073) + 0.00039632780130189*std::sin(0.335599839687347*x_16 - 1.15495979785919) - 0.000658306520821502*std::sin(0.383199840784073*x_16 - 7.57936000823975) - 0.00235618256187438*std::sin(0.356399834156036*x_17 + 1.99591982364655) + 0.0916813218351714*std::sin(0.361359834671021*x_17 + 1.98919987678528) - 0.000944665281473832*std::sin(0.375039845705032*x_17 + 1.98655986785889) + 0.00282718411388453*std::sin(0.31415992975235*x_18 - 1.15887987613678) - 0.000400841722629248*std::sin(0.38783985376358*x_18 + 1.99743974208832) - 0.0152158732206575*std::sin(0.209199994802475*x_19 - 1.17927992343903) + 0.0010882216623593*std::sin(0.225599989295006*x_19 - 1.18735992908478) - 0.00291330355253277*std::sin(0.309599906206131*x_19 + 1.9851998090744) - 0.00220950597928932*std::sin(0.361839860677719*x_2 - 7.40703964233398) + 0.0171682023830395*std::sin(0.371599853038788*x_2 - 7.41815996170044) + 0.0501589827835645*std::sin(0.392399847507477*x_2 + 5.18391990661621) + 0.00369173350719854*std::sin(0.404959857463837*x_2 + 5.19816017150879) + 0.000490554325714673*std::sin(0.250399976968765*x_20 - 1.17255985736847) + 0.101293915981241*std::sin(0.315199911594391*x_21 + 1.98335981369019) - 0.000963774439216788*std::sin(0.377199828624725*x_21 - 1.18823993206024) + 0.000987930726823379*std::sin(0.248879969120026*x_22 - 1.15287983417511) - 0.000322144880115673*std::sin(0.301199942827225*x_23 + 8.23463916778564) + 0.0103303505280732*std::sin(0.348559856414795*x_23 + 1.98695981502533) - 0.00524152882237659*std::sin(0.352319836616516*x_23 - 1.16951990127563) - 0.0025430327277867*std::sin(0.258719980716705*x_25 - 1.17999982833862) - 0.00485710332017119*std::sin(0.334399849176407*x_25 - 4.35735988616943) + 0.000933359784064609*std::sin(0.354479849338531*x_25 - 1.15239989757538) - 0.0002799849130037*std::sin(0.305039942264557*x_26 - 4.39551973342896) + 0.00373666233322797*std::sin(0.336399853229523*x_26 - 1.15855991840363) + 0.00457966468225663*std::sin(0.343119859695435*x_26 + 5.04207992553711) - 0.00247762032777787*std::sin(0.348079830408096*x_3 - 7.39111995697021) + 0.000847071178863776*std::sin(0.350639849901199*x_3 - 7.41487979888916) - 0.00297022472964558*std::sin(0.354399859905243*x_3 - 7.40895986557007) - 0.00490735441660232*std::sin(0.361919850111008*x_3 - 7.39071989059448) + 0.00064235140760786*std::sin(0.372799843549728*x_3 - 7.38903999328613) + 0.000484521198480246*std::sin(0.400879859924316*x_3 - 1.17607986927032) - 0.000810564924464362*std::sin(0.460159868001938*x_3 + 8.19824028015137) + 0.113503758772716*std::sin(0.29751992225647*x_30 + 2.00103974342346) + 0.000654572302875619*std::sin(0.355439841747284*x_31 + 8.35223960876465) + 0.287127252115402*std::sin(0.377839833498001*x_31 + 5.16879987716675) + 0.0176316737512*std::sin(0.381759852170944*x_31 + 5.17304039001465) + 0.0371180584494759*std::sin(0.38223984837532*x_31 - 7.39759969711304) + 0.00213150247083962*std::sin(0.388639837503433*x_31 - 7.40663957595825) + 0.00184597272350739*std::sin(0.392079830169678*x_31 + 8.40104007720947) - 0.000206785869043729*std::sin(0.409919857978821*x_31 + 5.20584011077881) - 0.00179152086282538*std::sin(0.420639842748642*x_31 + 2.00063967704773) + 0.00331000975267847*std::sin(0.278239965438843*x_32 + 2.04231977462769) + 0.000327701048036409*std::sin(0.291119933128357*x_32 + 2.01647973060608) - 0.00146135769786674*std::sin(0.30311992764473*x_32 - 1.14807987213135) - 0.00749340079141717*std::sin(0.31879985332489*x_32 + 1.9916797876358) + 0.0327170309229989*std::sin(0.320479840040207*x_32 + 2.01711988449097) - 0.00295350878226423*std::sin(0.362319827079773*x_32 + 8.21008014678955) + 0.0138077483625032*std::sin(0.23743999004364*x_33 + 1.99071979522705) + 0.0638080732276513*std::sin(0.244079977273941*x_34 + 1.97359979152679) + 0.00147859571257715*std::sin(0.211040005087852*x_36 + 8.18279933929443) - 0.00129394601353172*std::sin(0.254639983177185*x_37 + 1.97111976146698) + 0.00195873981167536*std::sin(0.311999946832657*x_4 - 7.37815999984741) + 0.0653490134360561*std::sin(0.361039847135544*x_4 + 2.00863981246948) - 0.00158379200326241*std::sin(0.217840000987053*x_40 - 1.18151986598969) - 0.000707785584978962*std::sin(0.230159983038902*x_42 - 7.42208003997803) + 0.000326744738195992*std::sin(0.227999985218048*x_44 - 7.59743976593018) - 0.0520412043585313*std::sin(0.19463999569416*x_47 - 1.1743198633194) - 0.000913064410679086*std::sin(0.178720012307167*x_48 + 1.99559986591339) - 0.00179745325785104*std::sin(0.357679843902588*x_5 + 1.99735975265503) - 0.023706453421734*std::sin(0.361199855804443*x_5 + 2.02967977523804) - 0.00663537755337539*std::sin(0.382959842681885*x_5 + 2.00695967674255) - 0.000172662028982086*std::sin(0.530799865722656*x_5 + 1.86231982707977) + 0.00920877454675284*std::sin(0.232719987630844*x_52 - 7.42647981643677) + 0.000435600879204411*std::sin(0.24551996588707*x_52 - 7.42375993728638) + 0.00829589916811439*std::sin(0.237919986248016*x_53 - 7.41623973846436) + 0.000768779947794312*std::sin(0.238559976220131*x_53 - 7.40831995010376) - 0.000583069685892824*std::sin(0.258159965276718*x_53 - 7.43439960479736) - 0.00538396917207845*std::sin(0.273599952459335*x_6 + 2.01239991188049) - 0.0215322797882976*std::sin(0.34487983584404*x_6 + 2.00751972198486) - 0.0017193864472285*std::sin(0.378239840269089*x_6 + 1.9968798160553) - 0.00117029988633299*std::sin(0.478239864110947*x_6 + 5.13472032546997) - 0.00650371628351659*std::sin(0.33927983045578*x_7 + 2.03287982940674) - 0.0266670816000994*std::sin(0.353279858827591*x_7 + 1.99943971633911) + 0.00206817459314363*std::sin(0.357119828462601*x_7 - 1.14767980575562) + 0.00295140418094903*std::sin(0.324799835681915*x_8 - 4.32855987548828) + 0.000463091755587279*std::sin(0.330319821834564*x_8 - 1.13239991664886) + 0.0039014551834832*std::sin(0.356479853391647*x_9 - 4.36567974090576) - 0.00112628599040374*std::sin(0.309759914875031*x_91 - 4.35207986831665) + 0.00179540658986084*std::sin(0.363919854164124*x_91 - 7.40927982330322) - 0.120579662779706*std::sin(0.366639852523804*x_91 + 1.99207985401154) - 0.000425732619197931*std::sin(0.368159830570221*x_91 + 2.00927972793579) - 0.000449956204200493*std::sin(0.389919847249985*x_91 + 2.01271986961365) + 0.00446993053057092*std::sin(0.395359843969345*x_91 + 1.99727976322174) + 0.000942894778304717*std::sin(0.294639945030212*x_92 - 7.40287971496582) - 0.000908184730119221*std::sin(0.297439932823181*x_92 + 8.22743988037109) + 0.021941833170604*std::sin(0.302079945802689*x_92 + 1.98719990253448) + 0.000348875489961906*std::sin(0.314319908618927*x_92 + 5.02783966064453) - 0.0281762025860492*std::sin(0.320639848709106*x_92 - 1.1794399023056) + 0.000626081198881161*std::sin(0.271519958972931*x_94 - 1.19207990169525) + 0.00955269949852844*std::sin(0.299519926309586*x_94 + 1.98151981830597) + 0.00200283072389625*std::sin(0.25943997502327*x_97 - 1.19791984558105) + 0.000718025923843181*std::sin(0.274719953536987*x_97 + 1.97767972946167) + 0.00138907184651563*std::sin(0.248719975352287*x_98 - 7.43247985839844) + 0.00568599409465792*std::sin(0.262879967689514*x_98 + 1.96247982978821) + 0.288247897208596);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00077851308883644*x_1 - 0.00170146016739234*x_10 - 0.000870559837118123*x_100 + 0.0026913281006417*x_101 - 0.00203546099739429*x_102 - 0.000150094758277466*x_103 + 0.00108996956407675*x_104 - 0.000441347212833037*x_105 - 0.00200077416432803*x_106 - 0.00308989003234284*x_107 + 0.00237808033350352*x_108 + 0.00239924655708457*x_109 - 0.00182974718792815*x_11 - 0.00508720482730152*x_110 + 0.00465741587340053*x_111 + 0.00227674995827128*x_112 - 0.00507028773403335*x_113 - 0.00100287483572228*x_114 - 0.000269784161831599*x_115 - 0.00245199277508021*x_116 - 0.00216246527622494*x_117 - 0.0047450114670822*x_118 - 0.00186022549433351*x_119 - 0.00682368475076938*x_12 + 0.0107920603128699*x_120 + 0.000244272711390393*x_13 - 0.00394846959455504*x_14 - 0.00135044941303448*x_15 + 0.00252543977163121*x_16 - 0.000723818597732293*x_17 - 0.00155549445169161*x_18 - 0.0022976103539022*x_19 - 0.000235691910176908*x_2 - 0.00243165454641759*x_20 - 0.000586476587093685*x_21 - 0.000534508047151034*x_22 + 0.000572999183667816*x_23 - 0.00183201735070503*x_24 - 0.000704915984517834*x_25 - 0.00266453581835028*x_26 + 0.00157793933211285*x_27 + 7.11714511439979e-5*x_28 - 0.000242394250564219*x_29 - 8.71849738279358e-5*x_3 - 0.00944724855326418*x_30 - 2.27103929479248e-5*x_31 + 0.000320509366673223*x_32 - 0.00414693362134769*x_33 - 0.00569175330986304*x_34 + 0.000318181456968873*x_35 - 0.00183572517031928*x_36 - 0.00452099689840189*x_37 - 0.00459036112561016*x_38 - 0.00171077034559869*x_39 + 0.000288215604466413*x_4 + 0.00461744579914192*x_40 + 0.0007553324625302*x_41 - 0.000436965671991132*x_42 - 0.0012351619369426*x_43 - 0.000514210589262701*x_44 + 0.000260495670104375*x_45 - 0.0004148166535297*x_46 - 0.00317497794263123*x_47 + 0.000194566516292812*x_48 + 0.00049038554039931*x_49 + 0.000893372669340713*x_5 - 0.00552279879885771*x_50 + 0.0020847256884305*x_51 + 0.00251859031904531*x_52 + 0.00259019298768699*x_53 - 0.0034756628797231*x_54 - 0.00348467642379478*x_55 - 0.0002982992117079*x_56 + 0.001054409126461*x_57 - 0.00142528025023151*x_58 - 0.000727920557711857*x_59 - 0.00112881463546145*x_6 + 6.76628138523882e-5*x_60 + 0.000338040722124771*x_61 - 0.000135401978973932*x_62 - 0.000857708366087617*x_63 + 0.00101365373077161*x_64 + 0.00164845633374876*x_65 - 0.000161430416602854*x_66 - 0.0013292995160789*x_67 - 0.000205942864826824*x_68 + 0.000914144490197197*x_69 + 0.00332270858073129*x_7 + 0.000801066280526042*x_70 - 1.15517761677243e-5*x_71 + 0.000216579909128322*x_72 + 0.00142630225559431*x_73 + 8.90583177005096e-5*x_74 + 0.000554375624834787*x_75 + 0.000199105761758608*x_76 - 0.000686877696342087*x_77 - 7.76734643767281e-5*x_78 + 0.000701129753176682*x_79 + 0.000570747235824954*x_8 + 0.00285052657975789*x_80 - 0.000824834758600739*x_81 + 0.00114603474105402*x_82 + 0.00125803507155151*x_83 + 2.52760659943389e-5*x_84 - 0.000389304082722013*x_85 - 0.0015600102429322*x_86 - 0.000584331642476735*x_87 - 0.000399064287350657*x_88 - 0.000278243829050493*x_89 - 0.00220702174325476*x_9 - 0.00030639377091826*x_90 - 0.000489189790657586*x_91 - 0.00650264138294343*x_92 - 0.00274127458082367*x_93 - 0.00349112154649901*x_94 - 0.00354450544863923*x_95 - 0.00522156692693272*x_96 - 0.0015999357726286*x_97 - 0.00425333777434596*x_98 - 0.00569911991997244*x_99 - 7.42597768125679e-6*std::pow(-6.59912014007568*x_1 - 8.60007953643799, 2) + 4.06659372257255e-5*std::pow(-4.72503995895386*x_1 - 6.98927974700928, 2) - 0.00188204222777833*std::sin(0.228559985756874*x_1 + 5.03671979904175) + 0.447430459028658*std::sin(0.242399975657463*x_1 + 5.05503988265991) + 0.0124316096155023*std::sin(0.259359985589981*x_1 + 5.07639980316162) - 0.0290103131493344*std::sin(0.297599911689758*x_1 - 4.29648017883301) + 0.0155034434307802*std::sin(0.337439835071564*x_1 - 4.25399971008301) + 0.0107108969190325*std::sin(0.224879994988441*x_104 + 1.98151981830597) + 0.00453951482306046*std::sin(0.231359988451004*x_104 - 1.1904798746109) - 0.000661163686641548*std::sin(0.263839960098267*x_107 + 1.94431984424591) - 0.000799291409444828*std::sin(0.214719995856285*x_108 + 8.3810396194458) - 0.00546459282519812*std::sin(0.252159982919693*x_108 + 1.96295976638794) + 0.00538887118372639*std::sin(0.260559976100922*x_108 + 1.96167981624603) + 0.00642687746714719*std::sin(0.224639996886253*x_109 + 1.97367978096008) - 0.00828390025866287*std::sin(0.172640010714531*x_11 + 5.20760011672974) - 0.00487500791706205*std::sin(0.280799955129623*x_11 - 7.42807960510254) + 0.0426798873397014*std::sin(0.301519930362701*x_11 + 5.14408016204834) + 0.00404542161886195*std::sin(0.216559991240501*x_111 + 1.96263980865479) - 0.000955462573422943*std::sin(0.235519990324974*x_113 - 4.19479990005493) - 0.000210082773376215*std::sin(0.259679973125458*x_113 - 7.40687990188599) + 0.111072085598858*std::sin(0.282799929380417*x_113 - 7.41304016113281) + 0.0112784308655998*std::sin(0.289039939641953*x_113 - 7.42664003372192) - 0.0135329767591636*std::sin(0.289839953184128*x_113 - 7.42519998550415) + 0.0108759986519445*std::sin(0.293839931488037*x_113 - 7.44047975540161) - 0.00305077188323482*std::sin(0.237039983272552*x_119 + 5.1701602935791) + 0.000106988010060948*std::sin(0.24695996940136*x_12 + 2.14351987838745) + 0.0205147248346179*std::sin(0.26895996928215*x_12 - 4.22751998901367) - 0.00524339576295976*std::sin(0.278319954872131*x_12 + 5.14752006530762) + 0.0302034402284011*std::sin(0.293199926614761*x_12 - 7.44055986404419) - 0.00721981597551145*std::sin(0.264879941940308*x_120 + 5.16535997390747) - 0.0311017170341744*std::sin(0.269759953022003*x_120 + 5.14287996292114) + 0.0201894314380087*std::sin(0.301679939031601*x_13 - 7.43824005126953) - 0.00335074151103042*std::sin(0.310639947652817*x_13 - 7.45991992950439) - 0.0390940719073943*std::sin(0.319199919700623*x_13 - 7.46647977828979) + 0.0123123192036596*std::sin(0.293279945850372*x_15 + 5.1560001373291) + 0.00631688401396883*std::sin(0.299439936876297*x_15 + 5.160560131073) + 0.00431138367131917*std::sin(0.335599839687347*x_16 - 1.15495979785919) - 0.00685721515884248*std::sin(0.383199840784073*x_16 - 7.57936000823975) - 0.0256313258634469*std::sin(0.356399834156036*x_17 + 1.99591982364655) - 0.00347112357073709*std::sin(0.361359834671021*x_17 + 1.98919987678528) - 0.0133288186821815*std::sin(0.375039845705032*x_17 + 1.98655986785889) + 0.0398903454738161*std::sin(0.31415992975235*x_18 - 1.15887987613678) - 0.00436048758641284*std::sin(0.38783985376358*x_18 + 1.99743974208832) - 0.0188414492801987*std::sin(0.209199994802475*x_19 - 1.17927992343903) + 0.0118380317768773*std::sin(0.225599989295006*x_19 - 1.18735992908478) - 0.0411054535181838*std::sin(0.309599906206131*x_19 + 1.9851998090744) + 0.0199624685793578*std::sin(0.361839860677719*x_2 - 7.40703964233398) - 0.000650001011831961*std::sin(0.371599853038788*x_2 - 7.41815996170044) + 0.0621106601216839*std::sin(0.392399847507477*x_2 + 5.18391990661621) + 0.0384547473969693*std::sin(0.404959857463837*x_2 + 5.19816017150879) + 0.00692150943772333*std::sin(0.250399976968765*x_20 - 1.17255985736847) - 0.00383506359089016*std::sin(0.315199911594391*x_21 + 1.98335981369019) - 0.0100391056221882*std::sin(0.377199828624725*x_21 - 1.18823993206024) + 0.0139392754096355*std::sin(0.248879969120026*x_22 - 1.15287983417511) + 0.000113229030920007*std::sin(0.301199942827225*x_23 + 8.23463916778564) + 0.0104606187351843*std::sin(0.348559856414795*x_23 + 1.98695981502533) + 0.00135544361817785*std::sin(0.352319836616516*x_23 - 1.16951990127563) - 0.0264893663040895*std::sin(0.258719980716705*x_25 - 1.17999982833862) - 0.00601443404059434*std::sin(0.334399849176407*x_25 - 4.35735988616943) + 0.0131693030018293*std::sin(0.354479849338531*x_25 - 1.15239989757538) - 0.00304576761502628*std::sin(0.305039942264557*x_26 - 4.39551973342896) - 0.03376003736488*std::sin(0.336399853229523*x_26 - 1.15855991840363) + 0.00567088845837051*std::sin(0.343119859695435*x_26 + 5.04207992553711) + 0.0223848310022462*std::sin(0.348079830408096*x_3 - 7.39111995697021) - 0.000297732649572373*std::sin(0.350639849901199*x_3 - 7.41487979888916) + 0.0051048639339692*std::sin(0.354399859905243*x_3 - 7.40895986557007) - 0.00607665876282691*std::sin(0.361919850111008*x_3 - 7.39071989059448) + 0.00906330063161785*std::sin(0.372799843549728*x_3 - 7.38903999328613) + 0.00527078034060126*std::sin(0.400879859924316*x_3 - 1.17607986927032) - 0.00844320679115699*std::sin(0.460159868001938*x_3 + 8.19824028015137) - 0.00429733739170512*std::sin(0.29751992225647*x_30 + 2.00103974342346) + 0.00712065196800583*std::sin(0.355439841747284*x_31 + 8.35223960876465) - 0.0108708530011224*std::sin(0.377839833498001*x_31 + 5.16879987716675) - 0.00455949790103833*std::sin(0.381759852170944*x_31 + 5.17304039001465) + 0.04596239765627*std::sin(0.38223984837532*x_31 - 7.39759969711304) + 0.022202683084336*std::sin(0.388639837503433*x_31 - 7.40663957595825) + 0.0018692508839545*std::sin(0.392079830169678*x_31 + 8.40104007720947) - 0.00291765920540772*std::sin(0.409919857978821*x_31 + 5.20584011077881) + 0.0161860521169165*std::sin(0.420639842748642*x_31 + 2.00063967704773) + 0.00335174977251904*std::sin(0.278239965438843*x_32 + 2.04231977462769) + 0.00356483936513493*std::sin(0.291119933128357*x_32 + 2.01647973060608) + 0.0132030903741888*std::sin(0.30311992764473*x_32 - 1.14807987213135) - 0.0780546141849941*std::sin(0.31879985332489*x_32 + 1.9916797876358) - 0.00123869131605157*std::sin(0.320479840040207*x_32 + 2.01711988449097) - 0.00365725877921374*std::sin(0.362319827079773*x_32 + 8.21008014678955) + 0.0170978021880895*std::sin(0.23743999004364*x_33 + 1.99071979522705) - 0.00241582148414064*std::sin(0.244079977273941*x_34 + 1.97359979152679) + 0.0154017142674373*std::sin(0.211040005087852*x_36 + 8.18279933929443) + 0.0116905574733138*std::sin(0.254639983177185*x_37 + 1.97111976146698) + 0.0204031099556592*std::sin(0.311999946832657*x_4 - 7.37815999984741) - 0.00247416263554885*std::sin(0.361039847135544*x_4 + 2.00863981246948) + 0.0143092611641329*std::sin(0.217840000987053*x_40 - 1.18151986598969) - 0.00737261122139778*std::sin(0.230159983038902*x_42 - 7.42208003997803) - 0.00295207690354654*std::sin(0.227999985218048*x_44 - 7.59743976593018) + 0.0019703190080877*std::sin(0.19463999569416*x_47 - 1.1743198633194) - 0.0128829440583517*std::sin(0.178720012307167*x_48 + 1.99559986591339) - 0.0195532854379687*std::sin(0.357679843902588*x_5 + 1.99735975265503) + 0.00613041768709578*std::sin(0.361199855804443*x_5 + 2.02967977523804) - 0.00671905126173936*std::sin(0.382959842681885*x_5 + 2.00695967674255) + 6.06880798828896e-5*std::sin(0.530799865722656*x_5 + 1.86231982707977) + 0.0959227144485151*std::sin(0.232719987630844*x_52 - 7.42647981643677) - 0.000153107090829779*std::sin(0.24551996588707*x_52 - 7.42375993728638) + 0.0864137962067179*std::sin(0.237919986248016*x_53 - 7.41623973846436) - 0.00027021447135285*std::sin(0.238559976220131*x_53 - 7.40831995010376) + 0.00100210983391152*std::sin(0.258159965276718*x_53 - 7.43439960479736) - 0.0560818309614276*std::sin(0.273599952459335*x_6 + 2.01239991188049) - 0.0218038070201581*std::sin(0.34487983584404*x_6 + 2.00751972198486) - 0.0187040490950112*std::sin(0.378239840269089*x_6 + 1.9968798160553) + 0.0105734381026037*std::sin(0.478239864110947*x_6 + 5.13472032546997) - 0.0677456176987089*std::sin(0.33927983045578*x_7 + 2.03287982940674) - 0.0270033599189706*std::sin(0.353279858827591*x_7 + 1.99943971633911) + 0.0224982808196304*std::sin(0.357119828462601*x_7 - 1.14767980575562) - 0.000763224260954635*std::sin(0.324799835681915*x_8 - 4.32855987548828) + 0.00653402444705695*std::sin(0.330319821834564*x_8 - 1.13239991664886) - 0.00100890459811713*std::sin(0.356479853391647*x_9 - 4.36567974090576) - 0.00114048872788738*std::sin(0.309759914875031*x_91 - 4.35207986831665) - 0.0162211589256695*std::sin(0.363919854164124*x_91 - 7.40927982330322) + 0.00456523642164157*std::sin(0.366639852523804*x_91 + 1.99207985401154) - 0.00463125891428385*std::sin(0.368159830570221*x_91 + 2.00927972793579) + 0.000158152769461283*std::sin(0.389919847249985*x_91 + 2.01271986961365) + 0.00553500730167916*std::sin(0.395359843969345*x_91 + 1.99727976322174) + 0.0102571183187286*std::sin(0.294639945030212*x_92 - 7.40287971496582) + 0.00156087834967301*std::sin(0.297439932823181*x_92 + 8.22743988037109) - 0.00567409218761737*std::sin(0.302079945802689*x_92 + 1.98719990253448) + 0.0049224823221031*std::sin(0.314319908618927*x_92 + 5.02783966064453) + 0.00106677215132362*std::sin(0.320639848709106*x_92 - 1.1794399023056) - 0.00565652520425033*std::sin(0.271519958972931*x_94 - 1.19207990169525) - 0.00247029941271605*std::sin(0.299519926309586*x_94 + 1.98151981830597) - 0.0180951967409526*std::sin(0.25943997502327*x_97 - 1.19791984558105) + 0.0101310353367493*std::sin(0.274719953536987*x_97 + 1.97767972946167) - 0.0125500013806063*std::sin(0.248719975352287*x_98 - 7.43247985839844) + 0.00704082951983068*std::sin(0.262879967689514*x_98 + 1.96247982978821) + 1.25199185247407);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
