
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-36.4679751552672*x_1 - 6.09266035051418*x_10 + 2.92365576351737*x_100 - 0.139226490701273*x_101 - 0.111292055134255*x_102 - 0.000760154372412038*x_103 - 20.3270786595882*x_104 - 3.38124896318987*x_105 + 2.26370825551914*x_106 - 0.411000007609427*x_107 - 2.19599697509539*x_108 - 0.665325835514453*x_109 - 16.3647096198587*x_11 - 5.34143872344125*x_110 - 2.34849861193473*x_111 + 3.69608277542516*x_112 + 3.2989163067793*x_113 + 1.3586620130108*x_114 - 4.49136381923699*x_115 + 34.1386296860855*x_116 + 7.80924659872511*x_117 - 1.22170962422113*x_118 + 3.72994713786478*x_119 + 13.8308523163132*x_12 - 2.51234440276635*x_120 - 1.1722224680567*x_13 + 12.1345775132166*x_14 - 6.75203349568557*x_15 + 2.38194772531134*x_16 - 3.98962748792484*x_17 + 52.8393098039264*x_18 - 25.3569530912902*x_19 + 2.02333555000738*x_2 + 1.82981044358101*x_20 + 13.3083248638694*x_21 + 58.1445961485477*x_22 + 68.3371777680689*x_23 + 29.5690497228523*x_24 + 3.28686117423044*x_25 - 11.3638741260782*x_26 - 14.5841107220478*x_27 - 82.0986827685463*x_28 + 182.194288533051*x_29 + 2.18804325540588*x_3 - 2.83118904647945*x_30 - 3.13646603376646*x_31 + 2.83668775795313*x_32 - 6.65625378845315*x_33 - 367.002462431435*x_34 + 2.85257282007071*x_35 + 32.7266122371993*x_36 + 307.021930640305*x_37 + 1.18891534732681*x_38 - 140.246085553957*x_39 + 36.3409236565356*x_4 + 12.9267686576559*x_40 + 723.226939943807*x_41 + 454.830301938927*x_42 + 101.20054100843*x_43 - 3.88672863475208*x_44 - 75.7037792134103*x_45 - 178.108780915249*x_46 + 334.480678502372*x_47 + 9.20947984268527*x_48 - 123.093034336148*x_49 + 4.27774707789316*x_5 - 96.975447457625*x_50 - 15.0255087501761*x_51 - 0.383580935902764*x_52 - 8.14775625335663*x_53 + 7.75587154387247*x_54 - 56.5622853594675*x_55 + 76.5426508568697*x_56 + 31.9416281204687*x_57 - 9.15611832910378*x_58 + 215.096995643105*x_59 - 0.192475195211703*x_6 - 1.58904188181774*x_60 - 2.77692048170849*x_61 + 1.26338712919244*x_62 + 0.158217560889286*x_63 + 1.87610092834787*x_64 - 0.216586494295944*x_65 + 6.39100824822139*x_66 + 2.93137372010054*x_67 - 0.889201733184435*x_68 + 0.771844789792444*x_69 - 0.021118799280686*x_7 - 1.5142811085128*x_70 - 0.012002952338215*x_71 - 0.231074071880118*x_72 + 3.84361691698049*x_73 + 7.56350127833991*x_74 + 2.40656430491974*x_75 - 2.7484713923958*x_76 + 1.5975928439925*x_77 - 0.786663594498698*x_78 - 1.44993607395309*x_79 + 0.0843462320300172*x_8 + 0.886672937681894*x_80 - 0.0402019961935001*x_81 + 3.0391268909487*x_82 + 8.74842736956187*x_83 - 1.33134124099043*x_84 + 160.277434953679*x_85 + 7.00777104518242*x_86 - 199.533813495469*x_87 + 1.87537106333127*x_88 + 5.72527525691953*x_89 + 2.23931941444262*x_9 - 1.41470474540919*x_90 - 0.0659724434104274*x_91 + 6.16044836619043*x_92 + 2.77519489227601*x_93 - 0.534940546951013*x_94 + 1.27233537003697*x_95 - 1.45532119210812*x_96 + 0.169714145500881*x_97 + 1.08155939914415*x_98 - 0.60092224737993*x_99 - 0.00342147339488655*std::exp(0.900879800319672*x_23) + 0.00541273437475651*std::exp(0.982159852981567*x_23) - 0.0514367072034645*std::exp(0.477759838104248*x_3) - 0.00721175252208312*std::exp(0.995279788970947*x_4) + 0.000472012127797848*std::exp(1.46583986282349*x_6) + 0.0276830665389552*std::exp(1.61719989776611*x_6) + 0.159260583820093*std::exp(0.921439826488495*x_8) - 0.966507024473753*std::sin(0.235279992222786*x_109 + 1.9761598110199) + 0.228302563621781*std::sin(0.222879990935326*x_118 - 4.22839975357056) + 0.22626132455446*std::sin(0.268239974975586*x_120 - 7.43680000305176) - 0.0517609110602524*std::sin(0.34895983338356*x_13 - 1.13007986545563) + 0.356173168422912*std::sin(0.142240047454834*x_16 - 4.44736003875732) + 0.419406742353961*std::sin(0.126480057835579*x_17 + 4.92880010604858) - 0.10574822174476*std::sin(0.326399862766266*x_9 - 1.12335991859436) + 0.0592848966685685*std::sin(0.324799835681915*x_91 + 1.9955198764801) - 13.115526009565*std::sin(0.369679838418961*x_91 - 7.39503955841064) + 0.0662865314286828*std::sin(0.409759849309921*x_91 + 1.98567986488342) + 0.201884587835682*std::sin(0.289199948310852*x_95 + 1.9541597366333) + 0.232549203644258*std::sin(0.284399926662445*x_97 + 1.957359790802) + 870.460859762185);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-26.7020388949868*x_1 - 6.30965496145228*x_10 + 2.20415158709952*x_100 - 0.157237145690208*x_101 - 0.0698575858183783*x_102 + 0.0218077490882761*x_103 - 18.1254864845627*x_104 - 2.4344066701028*x_105 + 2.12034687144574*x_106 - 0.252494935403392*x_107 - 1.7160741544276*x_108 - 0.492691302016086*x_109 - 9.68738005788587*x_11 - 3.98816159640183*x_110 - 1.74071228372997*x_111 + 2.80657481019679*x_112 + 2.43087067693806*x_113 + 1.13893172800972*x_114 - 3.20456740370051*x_115 + 24.9531926607235*x_116 + 5.82981121753313*x_117 - 0.90641229538724*x_118 + 2.88621661710196*x_119 + 10.6259989144419*x_12 - 1.97069133361313*x_120 - 1.00528460724841*x_13 + 9.31340065289772*x_14 - 4.68951707720028*x_15 + 1.71018662612951*x_16 - 2.59792549328015*x_17 + 38.759871546477*x_18 - 20.3693102094776*x_19 + 1.58425669321622*x_2 + 1.15425452520548*x_20 + 10.9379558633093*x_21 + 41.1966189494067*x_22 + 48.8719793975949*x_23 + 19.0057745740809*x_24 + 2.47652544382831*x_25 - 7.49848370894536*x_26 - 11.4788127595671*x_27 - 69.801977679066*x_28 + 135.033899407841*x_29 + 1.56285298265289*x_3 - 1.95738065778967*x_30 - 2.32993959603529*x_31 + 2.12045616616418*x_32 - 4.50452213569982*x_33 - 283.839705943435*x_34 + 1.93717067388593*x_35 + 24.9099154705789*x_36 + 231.098945198155*x_37 + 0.915758721794673*x_38 - 105.496621400327*x_39 + 25.8750535570534*x_4 + 10.0072226121732*x_40 + 506.148422725189*x_41 + 350.933165516287*x_42 + 75.4556278343907*x_43 - 2.84212082736416*x_44 - 41.3457657603807*x_45 - 123.281676288058*x_46 + 251.223377905784*x_47 + 6.40967596380045*x_48 - 86.8990641375969*x_49 + 3.21750442854982*x_5 - 76.1381950846592*x_50 - 10.9980659262353*x_51 - 1.8561472499208*x_52 - 4.29068108200663*x_53 + 5.47964072766113*x_54 - 46.7420668720607*x_55 + 60.765285077697*x_56 + 24.2751335477144*x_57 - 1.42630680726681*x_58 + 172.814404706491*x_59 + 0.0658803786149537*x_6 - 1.67546961477559*x_60 - 2.03910701134384*x_61 + 1.24186329147306*x_62 + 0.0570520147794886*x_63 + 1.35874629825115*x_64 - 0.174102923439482*x_65 + 4.77717871465604*x_66 + 2.19602462563477*x_67 - 0.651414997669778*x_68 + 0.541825180478456*x_69 - 0.0713476224250923*x_7 - 1.25216508351553*x_70 - 0.0548651572579679*x_71 - 0.0917848230601401*x_72 + 2.73420480881743*x_73 + 5.42128644779971*x_74 + 1.89935475172404*x_75 - 1.91743036211784*x_76 + 1.22191800089939*x_77 - 0.349673664311549*x_78 - 1.07912002419762*x_79 - 0.0675959262297456*x_8 + 0.701053577659156*x_80 - 0.0469150717458229*x_81 + 2.18349759058592*x_82 + 6.73035764933281*x_83 - 0.268110687789137*x_84 + 116.823214885757*x_85 + 5.22973713817528*x_86 - 148.708855069089*x_87 + 1.40658537619953*x_88 + 4.07591557665856*x_89 + 1.90897291653542*x_9 - 1.31075933926657*x_90 - 0.00778213218182453*x_91 + 4.80309744976828*x_92 + 2.15526337659081*x_93 - 0.41715846937317*x_94 + 0.956750718805937*x_95 - 1.23847531260664*x_96 + 0.0187451883520288*x_97 + 0.805780516313263*x_98 - 0.560609857140833*x_99 - 0.00334912160608307*std::exp(0.900879800319672*x_23) - 0.00212114775072853*std::exp(0.982159852981567*x_23) - 0.0395394695145912*std::exp(0.477759838104248*x_3) - 0.005543684354944*std::exp(0.995279788970947*x_4) + 0.000362836389657603*std::exp(1.46583986282349*x_6) + 0.020765826542208*std::exp(1.61719989776611*x_6) + 0.119465726600954*std::exp(0.921439826488495*x_8) + 0.264282639611885*std::sin(0.235279992222786*x_109 + 1.9761598110199) + 0.175496503279635*std::sin(0.222879990935326*x_118 - 4.22839975357056) + 0.173927399924027*std::sin(0.268239974975586*x_120 - 7.43680000305176) - 0.0506663549807271*std::sin(0.34895983338356*x_13 - 1.13007986545563) + 0.348641393983948*std::sin(0.142240047454834*x_16 - 4.44736003875732) - 0.164357532919672*std::sin(0.126480057835579*x_17 + 4.92880010604858) - 0.103512029285262*std::sin(0.326399862766266*x_9 - 1.12335991859436) - 0.0232326244951498*std::sin(0.324799835681915*x_91 + 1.9955198764801) - 9.83831533768814*std::sin(0.369679838418961*x_91 - 7.39503955841064) + 0.0648848110091668*std::sin(0.409759849309921*x_91 + 1.98567986488342) + 0.155188967960552*std::sin(0.289199948310852*x_95 + 1.9541597366333) + 0.178760901466011*std::sin(0.284399926662445*x_97 + 1.957359790802) + 880.284793592179);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-16.9635610824933*x_1 + 5.36484675262322*x_10 + 1.06350534452521*x_100 + 0.185291206652058*x_101 - 0.202250761488083*x_102 - 0.0269194421203596*x_103 + 3.53541189062602*x_104 - 1.81064120910762*x_105 - 0.468736716431006*x_106 - 0.541545074177906*x_107 - 0.56287758250032*x_108 - 0.232333116945067*x_109 - 16.9623920229839*x_11 - 1.91906707485983*x_110 - 0.916267533692058*x_111 + 1.31194105161435*x_112 + 1.42265233448624*x_113 + 0.0907027763419695*x_114 - 2.35166786783502*x_115 + 15.4102893008666*x_116 + 3.29419638042021*x_117 - 0.512178455848418*x_118 + 1.18987006068388*x_119 + 4.83933011471472*x_12 - 0.688703173219957*x_120 + 0.0501117103555945*x_13 + 3.69484058941334*x_14 - 3.41494003720686*x_15 + 1.28236202435133*x_16 - 3.00067314327466*x_17 + 20.8514169616504*x_18 - 4.31369016991482*x_19 + 0.493423765406808*x_2 + 1.35952633455434*x_20 + 1.71215655251625*x_21 + 30.8324479261371*x_22 + 34.8144624173586*x_23 + 22.4984943472989*x_24 + 1.09941016136671*x_25 - 8.10236454113282*x_26 - 4.40977512165485*x_27 - 5.80438998738769*x_28 + 75.8861105441831*x_29 + 1.00507496513578*x_3 - 2.70043636128038*x_30 - 1.30346250141222*x_31 + 1.19891160009339*x_32 - 4.27316444116943*x_33 - 118.186988536363*x_34 + 1.83590065463622*x_35 + 10.9877114683011*x_36 + 118.260364760804*x_37 + 0.650871265143447*x_38 - 55.0813478525774*x_39 + 18.9598551924519*x_4 + 3.91832850495823*x_40 + 344.453163481361*x_41 + 154.331051092708*x_42 + 43.4401592858061*x_43 - 1.77435460401111*x_44 - 89.570823935802*x_45 - 101.780236978027*x_46 + 126.573104370737*x_47 + 5.45593798398082*x_48 - 66.6225054299732*x_49 + 1.66416390417296*x_5 - 21.3352943045085*x_50 - 8.07313340179032*x_51 + 4.76044354353607*x_52 - 11.5062534370146*x_53 + 6.0013801576572*x_54 - 6.34193386335743*x_55 + 13.0262675835831*x_56 + 10.7758257248863*x_57 - 18.4320287200533*x_58 + 47.0393108612811*x_59 - 0.537281081303799*x_6 + 1.0507035519014*x_60 - 1.199266101173*x_61 - 0.922399999234022*x_62 + 0.289042371498632*x_63 + 0.884321290228956*x_64 + 0.0398506692571024*x_65 + 2.50492662168959*x_66 + 1.1442074803793*x_67 - 0.373758265547806*x_68 + 0.327323079339281*x_69 + 0.387519995463453*x_7 - 0.0847241269469568*x_70 + 0.141561465034561*x_71 - 0.416447021182436*x_72 + 2.00970705472132*x_73 + 3.91283053272945*x_74 + 0.629145934910402*x_75 - 1.50352598672393*x_76 + 0.466290773684817*x_77 - 1.07981797748638*x_78 - 0.635317185429848*x_79 + 0.371555819986747*x_8 + 0.113583145518518*x_80 + 0.00421391164223271*x_81 + 1.52712450033992*x_82 + 3.02769991294724*x_83 - 3.14849688757527*x_84 + 75.2243625322474*x_85 + 2.65365059075588*x_86 - 84.0098126339899*x_87 + 0.70409246769963*x_88 + 2.72979394068578*x_89 - 0.0362530998343067*x_9 + 0.474873818454237*x_90 - 0.158729641456111*x_91 + 1.53538048338342*x_92 + 0.747478568528282*x_93 - 0.103535467948973*x_94 + 0.580267883397044*x_95 + 0.0518824836724195*x_96 + 0.373855158681644*x_97 + 0.455993324772946*x_98 + 0.0670880568472904*x_99 - 0.0134154317378386*std::exp(0.900879800319672*x_23) + 0.00489463067577155*std::exp(0.982159852981567*x_23) + 0.0423532540728416*std::exp(0.477759838104248*x_3) + 0.00593819479287488*std::exp(0.995279788970947*x_4) - 0.000388657257841309*std::exp(1.46583986282349*x_6) + 0.0107468503824042*std::exp(1.61719989776611*x_6) + 0.061826592213706*std::exp(0.921439826488495*x_8) - 4.20274900105767*std::sin(0.235279992222786*x_109 + 1.9761598110199) - 0.1879855264511*std::sin(0.222879990935326*x_118 - 4.22839975357056) - 0.186304759513596*std::sin(0.268239974975586*x_120 - 7.43680000305176) - 0.202952029396147*std::sin(0.34895983338356*x_13 - 1.13007986545563) + 1.39653777082364*std::sin(0.142240047454834*x_16 - 4.44736003875732) + 0.37926137966884*std::sin(0.126480057835579*x_17 + 4.92880010604858) - 0.414633664062639*std::sin(0.326399862766266*x_9 - 1.12335991859436) + 0.0536101817959569*std::sin(0.324799835681915*x_91 + 1.9955198764801) - 5.09158172607004*std::sin(0.369679838418961*x_91 - 7.39503955841064) + 0.259906284482177*std::sin(0.409759849309921*x_91 + 1.98567986488342) - 0.166232826844321*std::sin(0.289199948310852*x_95 + 1.9541597366333) - 0.191482232084227*std::sin(0.284399926662445*x_97 + 1.957359790802) + 33.7731118652982);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-27.8766085159508*x_1 - 0.123994259690987*x_10 + 2.214845875993*x_100 - 0.0268810281716081*x_101 - 0.135210923857659*x_102 + 0.0282567760249693*x_103 - 11.0210025878021*x_104 - 2.80464650822341*x_105 + 1.22163482403108*x_106 - 0.528930391144279*x_107 - 1.58320288112465*x_108 - 0.527247643970314*x_109 - 15.7277989798827*x_11 - 3.78811975701113*x_110 - 1.81913068379477*x_111 + 2.70067341349907*x_112 + 2.54124921676386*x_113 + 0.772018712632869*x_114 - 3.50437302713496*x_115 + 25.4269504124319*x_116 + 6.01025723247241*x_117 - 0.897451055023835*x_118 + 2.79555245548502*x_119 + 10.1768486192621*x_12 - 1.79684678982364*x_120 - 0.734501319710791*x_13 + 8.78105447909207*x_14 - 5.17527921057724*x_15 + 1.99619640859116*x_16 - 3.38479159497572*x_17 + 36.8855416800615*x_18 - 17.3806630584356*x_19 + 1.43722647829223*x_2 + 1.18057890106327*x_20 + 8.37144258797623*x_21 + 46.7301569483948*x_22 + 51.7233253429714*x_23 + 24.5593603506678*x_24 + 2.08341577525189*x_25 - 10.0928671206097*x_26 - 9.65777045119361*x_27 - 52.0751047953539*x_28 + 134.435210580189*x_29 + 1.69694021985371*x_3 - 3.03788198660687*x_30 - 2.35561129028686*x_31 + 2.30644857524871*x_32 - 5.33443330603811*x_33 - 272.682474517347*x_34 + 2.4839451379562*x_35 + 22.7700352944074*x_36 + 230.104901876732*x_37 + 1.29657218865316*x_38 - 105.797297758157*x_39 + 28.6616871286311*x_4 + 8.85911831633058*x_40 + 488.629088466626*x_41 + 331.629857644992*x_42 + 78.4067672681846*x_43 - 2.83266216307358*x_44 - 78.7110570337958*x_45 - 137.954260069548*x_46 + 238.734515247094*x_47 + 7.5178061494648*x_48 - 97.7493527865176*x_49 + 3.2062727985387*x_5 - 66.4256205869902*x_50 - 12.4591562021682*x_51 - 0.179924293696363*x_52 - 10.0776987136925*x_53 + 7.79388917589188*x_54 - 39.1064894468036*x_55 + 45.3300194961996*x_56 + 22.6310310084642*x_57 - 8.85252085289347*x_58 + 157.556030647145*x_59 - 0.106695897167777*x_6 - 1.02640580614549*x_60 - 2.04665921435902*x_61 + 0.122763735074652*x_62 + 0.252396937414191*x_63 + 1.45825638343331*x_64 - 0.158309159923567*x_65 + 4.78395856775211*x_66 + 2.12818266063485*x_67 - 0.598080763752745*x_68 + 0.478145117825065*x_69 + 0.244018573699627*x_7 - 0.774424723915405*x_70 - 0.0779279794803783*x_71 - 0.281591790245564*x_72 + 3.02406616569204*x_73 + 5.83792211353987*x_74 + 1.7596649993755*x_75 - 2.10471395430282*x_76 + 1.13619290482056*x_77 - 0.722155400658178*x_78 - 1.12775353034141*x_79 + 0.156178338080865*x_8 + 0.64449127220722*x_80 - 0.0269943417958828*x_81 + 2.33251371566335*x_82 + 6.42474682698375*x_83 - 1.74069666308514*x_84 + 122.753479625654*x_85 + 4.86930494936155*x_86 - 152.756416536253*x_87 + 1.42470712258249*x_88 + 4.22225066291955*x_89 + 1.32472209043374*x_9 - 0.645014789981653*x_90 - 0.0401830497407767*x_91 + 4.13341593720156*x_92 + 1.85301055607339*x_93 - 0.339331642734038*x_94 + 0.997189657524848*x_95 - 0.912047492475513*x_96 + 0.212499257106193*x_97 + 0.936376031115437*x_98 - 0.341381743244173*x_99 - 0.00522161861252921*std::exp(0.900879800319672*x_23) - 0.00692246475313495*std::exp(0.982159852981567*x_23) + 0.0931023621491427*std::exp(0.477759838104248*x_3) + 0.0130535415571032*std::exp(0.995279788970947*x_4) - 0.000854359589683507*std::exp(1.46583986282349*x_6) + 0.0205663877611463*std::exp(1.61719989776611*x_6) + 0.118318355999378*std::exp(0.921439826488495*x_8) - 1.99498683350033*std::sin(0.235279992222786*x_109 + 1.9761598110199) - 0.413236171472133*std::sin(0.222879990935326*x_118 - 4.22839975357056) - 0.409541452482307*std::sin(0.268239974975586*x_120 - 7.43680000305176) - 0.0789939611974229*std::sin(0.34895983338356*x_13 - 1.13007986545563) + 0.543567121784457*std::sin(0.142240047454834*x_16 - 4.44736003875732) - 0.536388485034988*std::sin(0.126480057835579*x_17 + 4.92880010604858) - 0.161385701180534*std::sin(0.326399862766266*x_9 - 1.12335991859436) - 0.0758207551243219*std::sin(0.324799835681915*x_91 + 1.9955198764801) - 9.74382636492027*std::sin(0.369679838418961*x_91 - 7.39503955841064) + 0.101161969222178*std::sin(0.409759849309921*x_91 + 1.98567986488342) - 0.365418648100049*std::sin(0.289199948310852*x_95 + 1.9541597366333) - 0.420922748603242*std::sin(0.284399926662445*x_97 + 1.957359790802) + 1653.05544852506);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (19.778670111947*x_1 + 8.30213436178247*x_10 - 1.55877852373679*x_100 + 0.144747537674911*x_101 - 0.0466103370832593*x_102 - 0.0500655851581961*x_103 + 15.810596531031*x_104 + 1.68162884085565*x_105 - 1.08763337924203*x_106 - 0.116831789581598*x_107 + 1.09561162645756*x_108 + 0.322886853589856*x_109 + 6.72165506925615*x_11 + 3.15890752483158*x_110 + 1.1090473253979*x_111 - 1.97456763686342*x_112 - 1.80564505463504*x_113 - 0.980614775122311*x_114 + 2.28545250866743*x_115 - 19.0065657386797*x_116 - 4.06508035005823*x_117 + 0.636044712635389*x_118 - 2.01052313406634*x_119 - 8.04417888439462*x_12 + 1.46561098974143*x_120 + 0.611764921444065*x_13 - 6.53106314127776*x_14 + 4.10998015140285*x_15 - 1.09223946471689*x_16 + 2.07051190213077*x_17 - 32.2472837806539*x_18 + 15.1155165483734*x_19 - 1.21586862825563*x_2 - 0.993590503705174*x_20 - 9.04623486108747*x_21 - 31.2459839168516*x_22 - 39.1894182556108*x_23 - 15.82730753873*x_24 - 2.22913596379832*x_25 + 6.0859709253508*x_26 + 11.1791658495629*x_27 + 59.8498826618324*x_28 - 106.41190699918*x_29 - 1.2419550647988*x_3 + 1.04221180981003*x_30 + 1.74152702318065*x_31 - 1.34854527890754*x_32 + 3.41916058789193*x_33 + 195.561494124159*x_34 - 1.21709281364208*x_35 - 19.776954705449*x_36 - 175.954463383455*x_37 - 0.276987978186342*x_38 + 75.1792477638742*x_39 - 19.4049204567636*x_4 - 8.04745585508319*x_40 - 496.222729455951*x_41 - 262.659707605498*x_42 - 50.8478723805479*x_43 + 2.33045883641679*x_44 + 30.0630473880221*x_45 + 96.0670651041822*x_46 - 195.861763230683*x_47 - 4.83925416499271*x_48 + 61.7723361514516*x_49 - 2.37952106631671*x_5 + 56.6087778259319*x_50 + 6.16206425891294*x_51 + 0.305887382139193*x_52 + 1.16284651486546*x_53 - 2.39348393157534*x_54 + 29.2599419803813*x_55 - 54.4754240574015*x_56 - 18.5159254333894*x_57 + 7.84906410976897*x_58 - 120.791518501289*x_59 - 0.170470015378975*x_6 + 0.600867201840716*x_60 + 1.50750700000839*x_61 - 1.29996867553927*x_62 + 0.0317837691983521*x_63 - 1.00048315849999*x_64 + 0.0411770520104535*x_65 - 3.64257254931839*x_66 - 1.76107688312023*x_67 + 0.521885897622483*x_68 - 0.552441878688624*x_69 + 0.161757969257703*x_7 + 1.21329499643035*x_70 - 0.259505837010936*x_71 + 0.119843399953208*x_72 - 1.94653303746828*x_73 - 4.23697733765471*x_74 - 1.30097154667307*x_75 + 1.38138440264674*x_76 - 0.90950911489349*x_77 + 0.320517006182335*x_78 + 0.797841828770289*x_79 + 0.136947556220482*x_8 - 0.349335531524262*x_80 + 0.00305708305403395*x_81 - 1.63266647589213*x_82 - 4.76072736324237*x_83 + 0.167323490374049*x_84 - 85.3687324630517*x_85 - 4.10219902557292*x_86 + 109.377667525547*x_87 - 0.969859194652241*x_88 - 2.92433953826752*x_89 - 1.45650616899489*x_9 + 1.18734467745283*x_90 + 0.0978117962611467*x_91 - 3.73186600460405*x_92 - 1.64632323055575*x_93 + 0.453528030640446*x_94 - 0.700146429939317*x_95 + 0.84006069429885*x_96 - 0.0408869679410664*x_97 - 0.515899628112999*x_98 + 0.429566824331288*x_99 - 0.00547026436525755*std::exp(0.900879800319672*x_23) + 0.00984874864083723*std::exp(0.982159852981567*x_23) + 0.215254321650393*std::exp(0.477759838104248*x_3) + 0.0301800208732443*std::exp(0.995279788970947*x_4) - 0.00197529460775904*std::exp(1.46583986282349*x_6) - 0.0152978249298325*std::exp(1.61719989776611*x_6) - 0.0880083326778234*std::exp(0.921439826488495*x_8) - 0.13791128409683*std::sin(0.235279992222786*x_109 + 1.9761598110199) - 0.955409397982267*std::sin(0.222879990935326*x_118 - 4.22839975357056) - 0.946867141787202*std::sin(0.268239974975586*x_120 - 7.43680000305176) - 0.0827555367548174*std::sin(0.34895983338356*x_13 - 1.13007986545563) + 0.569450983893835*std::sin(0.142240047454834*x_16 - 4.44736003875732) + 0.763132143151281*std::sin(0.126480057835579*x_17 + 4.92880010604858) - 0.169070649493943*std::sin(0.326399862766266*x_9 - 1.12335991859436) + 0.107871919266869*std::sin(0.324799835681915*x_91 + 1.9955198764801) + 7.2477165950764*std::sin(0.369679838418961*x_91 - 7.39503955841064) + 0.105979152523228*std::sin(0.409759849309921*x_91 + 1.98567986488342) - 0.844854431181626*std::sin(0.289199948310852*x_95 + 1.9541597366333) - 0.973180901389665*std::sin(0.284399926662445*x_97 + 1.957359790802) + 989.956897205779);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (134.69531322018*x_1 + 27.8435983539487*x_10 - 11.2226953124279*x_100 + 0.771466194185464*x_101 + 0.20116895755749*x_102 - 0.0941815824924116*x_103 + 87.4945522057756*x_104 + 12.4996183661238*x_105 - 9.45434784398981*x_106 + 1.23682658665608*x_107 + 8.59306387735864*x_108 + 2.62408491697077*x_109 + 51.8759769243203*x_11 + 20.183336099356*x_110 + 8.97125196683095*x_111 - 14.0093831358803*x_112 - 12.4262365108002*x_113 - 5.37172899945088*x_114 + 16.3040560929713*x_115 - 125.845101029216*x_116 - 29.3458526731336*x_117 + 4.51514830004158*x_118 - 14.4692928400271*x_119 - 52.767030846416*x_12 + 9.78336099894037*x_120 + 4.90362237655737*x_13 - 46.867497100594*x_14 + 25.0136974537045*x_15 - 8.80735906285346*x_16 + 13.6949741123348*x_17 - 196.259892759549*x_18 + 101.643379301133*x_19 - 7.99591298318689*x_2 - 5.59949160856543*x_20 - 52.8629193459504*x_21 - 214.317127462033*x_22 - 248.090834693814*x_23 - 100.458050906187*x_24 - 12.1270138435354*x_25 + 40.7519400822641*x_26 + 55.3177951858135*x_27 + 334.162245287734*x_28 - 680.288553287742*x_29 - 8.24239731519528*x_3 + 9.60911032661328*x_30 + 11.7611387454045*x_31 - 10.8633019268494*x_32 + 23.3284160861909*x_33 + 1415.80533302686*x_34 - 10.3023237755249*x_35 - 123.635143375688*x_36 - 1165.74893792654*x_37 - 4.81017306996436*x_38 + 529.993816127182*x_39 - 133.146474393379*x_4 - 49.1939121137871*x_40 - 2596.71357668916*x_41 - 1735.0655450895*x_42 - 379.374257523448*x_43 + 14.2191867496001*x_44 + 236.12216240641*x_45 + 635.939669269426*x_46 - 1251.49744690015*x_47 - 33.2177250359621*x_48 + 447.378213376058*x_49 - 16.1867097875325*x_5 + 381.541667316632*x_50 + 54.6880994726569*x_51 + 8.33343042902652*x_52 + 24.6390333684631*x_53 - 27.5582007621734*x_54 + 230.032464937951*x_55 - 296.219068792228*x_56 - 121.189445032025*x_57 + 19.6572722494928*x_58 - 860.430737021721*x_59 - 0.0247744528801481*x_6 + 8.0419767576385*x_60 + 10.2665130197993*x_61 - 5.55214810374052*x_62 - 0.49193838585159*x_63 - 6.97535882380415*x_64 + 1.00453580728605*x_65 - 24.2150543826787*x_66 - 11.0026732846865*x_67 + 3.20327426362923*x_68 - 2.76395111005745*x_69 + 0.268999392895888*x_7 + 5.91016795742052*x_70 + 0.300935183620433*x_71 + 0.595402680425565*x_72 - 14.021014826116*x_73 - 27.5245939222838*x_74 - 9.45440119706947*x_75 + 9.82989517989948*x_76 - 6.19347696736242*x_77 + 2.09006612018183*x_78 + 5.44953337703879*x_79 + 0.00596415171491197*x_8 - 3.65351054100805*x_80 + 0.150048286001954*x_81 - 11.0843524036872*x_82 - 33.2738802454033*x_83 + 2.4341449417227*x_84 - 591.430291215532*x_85 - 25.9884776314045*x_86 + 750.934776885557*x_87 - 7.16449382825259*x_88 - 20.8040555197369*x_89 - 9.2145167463554*x_9 + 6.23132265089048*x_90 + 0.0608346764921383*x_91 - 23.8092266424469*x_92 - 10.5976224241577*x_93 + 2.13398017597937*x_94 - 4.7380294507713*x_95 + 6.11460970756366*x_96 - 0.376227864395887*x_97 - 4.27027793420557*x_98 + 2.4923844500205*x_99 - 0.0090819372967525*std::exp(0.900879800319672*x_23) + 0.00339792099948385*std::exp(0.982159852981567*x_23) + 0.107307314052057*std::exp(0.477759838104248*x_3) + 0.015045165890805*std::exp(0.995279788970947*x_4) - 0.000984712210165971*std::exp(1.46583986282349*x_6) - 0.104456746458211*std::exp(1.61719989776611*x_6) - 0.600939292670931*std::exp(0.921439826488495*x_8) + 0.214529780599588*std::sin(0.235279992222786*x_109 + 1.9761598110199) - 0.476285054495132*std::sin(0.222879990935326*x_118 - 4.22839975357056) - 0.472026619351025*std::sin(0.268239974975586*x_120 - 7.43680000305176) - 0.137393834297981*std::sin(0.34895983338356*x_13 - 1.13007986545563) + 0.945423801113557*std::sin(0.142240047454834*x_16 - 4.44736003875732) + 0.263288548541373*std::sin(0.126480057835579*x_17 + 4.92880010604858) - 0.2806974096494*std::sin(0.326399862766266*x_9 - 1.12335991859436) + 0.0372169372067922*std::sin(0.324799835681915*x_91 + 1.9955198764801) + 49.4889239643791*std::sin(0.369679838418961*x_91 - 7.39503955841064) + 0.175950548951871*std::sin(0.409759849309921*x_91 + 1.98567986488342) - 0.421171844913403*std::sin(0.289199948310852*x_95 + 1.9541597366333) - 0.485144399490826*std::sin(0.284399926662445*x_97 + 1.957359790802) - 4389.9522798588);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (18.5805221517552*x_1 + 6.68894398285584*x_10 - 1.56080567471374*x_100 + 0.156444860628022*x_101 + 0.0427934481074893*x_102 + 0.00751529070278655*x_103 + 15.2320289920176*x_104 + 1.57319412181077*x_105 - 1.95837092049441*x_106 + 0.104263469724393*x_107 + 1.29687279421519*x_108 + 0.335077205150505*x_109 + 4.61518897829325*x_11 + 2.91644745335157*x_110 + 1.22733104426316*x_111 - 2.06185578868603*x_112 - 1.67329534977508*x_113 - 0.95039423258842*x_114 + 2.19416801428654*x_115 - 17.6662367845444*x_116 - 4.09179047268474*x_117 + 0.663058250722005*x_118 - 2.08063234432569*x_119 - 7.66133434759474*x_12 + 1.45933556762532*x_120 + 0.840268130547114*x_13 - 6.88758411041391*x_14 + 3.0602209621689*x_15 - 1.10921137487078*x_16 + 1.53201058979658*x_17 - 28.3791378743493*x_18 + 15.5413829731721*x_19 - 1.16666368986601*x_2 - 0.906453200409152*x_20 - 8.6791616221551*x_21 - 26.7960452826669*x_22 - 33.5909368349936*x_23 - 11.3471402149761*x_24 - 1.92394426440109*x_25 + 4.09116242915884*x_26 + 8.50066595230923*x_27 + 54.6952060121302*x_28 - 95.7582223010936*x_29 - 1.03981674921585*x_3 + 0.912218647560709*x_30 + 1.64543988970701*x_31 - 1.43222228446503*x_32 + 2.92281662389241*x_33 + 206.775140183439*x_34 - 1.17763739358923*x_35 - 18.571898906116*x_36 - 163.015460045462*x_37 - 0.476405955641643*x_38 + 75.1175087623836*x_39 - 17.2756075920793*x_4 - 7.54065757679603*x_40 - 363.988516608916*x_41 - 255.82718499933*x_42 - 53.0115155143358*x_43 + 2.02099778270324*x_44 + 14.2655984050874*x_45 + 82.7792735551946*x_46 - 184.172210043986*x_47 - 4.09630397201375*x_48 + 58.2312724078862*x_49 - 2.28524560707722*x_5 + 58.0513619331926*x_50 + 7.48804148914313*x_51 + 1.70712050852316*x_52 + 0.826066635359192*x_53 - 2.99885947153927*x_54 + 36.667815564017*x_55 - 49.1002908934312*x_56 - 17.9763395828981*x_57 - 2.29113420625972*x_58 - 127.231423184651*x_59 - 0.0197192079298043*x_6 + 1.45601656385564*x_60 + 1.46719631606861*x_61 - 1.34872231032278*x_62 + 0.0368751777992073*x_63 - 0.926504892393062*x_64 + 0.139601599725839*x_65 - 3.36651462235347*x_66 - 1.5755070829637*x_67 + 0.498457149893229*x_68 - 0.412464886178205*x_69 + 0.193684910748328*x_7 + 1.07163520560533*x_70 + 0.0586912342153574*x_71 - 0.0204104138881629*x_72 - 1.85272736131521*x_73 - 3.67960656700593*x_74 - 1.40480540228651*x_75 + 1.32848892437919*x_76 - 0.903411361662926*x_77 + 0.1315585163627*x_78 + 0.740085031663193*x_79 + 0.105569273923214*x_8 - 0.541356871847067*x_80 + 0.0456040317618817*x_81 - 1.50551725085231*x_82 - 4.93386419073346*x_83 - 0.33145352990171*x_84 - 81.2730649779214*x_85 - 3.91199060778957*x_86 + 103.615246997308*x_87 - 0.998163108808758*x_88 - 2.93425737663821*x_89 - 1.58804782559583*x_9 + 1.16578359568093*x_90 - 0.0101218260514859*x_91 - 3.69238399541542*x_92 - 1.67150962416234*x_93 + 0.30397363246007*x_94 - 0.657132970651154*x_95 + 1.01528226947857*x_96 + 0.0597643745914735*x_97 - 0.503047075047149*x_98 + 0.478985111875529*x_99 + 0.00336273075801342*std::exp(0.900879800319672*x_23) - 0.00636404822235965*std::exp(0.982159852981567*x_23) + 0.0745128082744024*std::exp(0.477759838104248*x_3) + 0.0104471682231677*std::exp(0.995279788970947*x_4) - 0.000683771397781559*std::exp(1.46583986282349*x_6) - 0.0148711816174329*std::exp(1.61719989776611*x_6) - 0.0855538552116047*std::exp(0.921439826488495*x_8) - 1.07960185476532*std::sin(0.235279992222786*x_109 + 1.9761598110199) - 0.330726169628496*std::sin(0.222879990935326*x_118 - 4.22839975357056) - 0.327769167449802*std::sin(0.268239974975586*x_120 - 7.43680000305176) + 0.0508722376579751*std::sin(0.34895983338356*x_13 - 1.13007986545563) - 0.350058097901571*std::sin(0.142240047454834*x_16 - 4.44736003875732) - 0.493119474986882*std::sin(0.126480057835579*x_17 + 4.92880010604858) + 0.103932650301412*std::sin(0.326399862766266*x_9 - 1.12335991859436) - 0.0697044996362585*std::sin(0.324799835681915*x_91 + 1.9955198764801) + 7.04558395009974*std::sin(0.369679838418961*x_91 - 7.39503955841064) - 0.0651484703667105*std::sin(0.409759849309921*x_91 + 1.98567986488342) - 0.292456271111065*std::sin(0.289199948310852*x_95 + 1.9541597366333) - 0.336877983984605*std::sin(0.284399926662445*x_97 + 1.957359790802) - 414.226022610857);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.29443210661894*x_1 - 0.806112137184779*x_10 + 0.00308374097838879*x_100 + 0.0263189762310512*x_101 - 0.10341272221931*x_102 - 0.00715330685764556*x_103 - 0.359505324227915*x_104 - 0.040312166148631*x_105 + 0.451677132595414*x_106 - 0.0915506250379033*x_107 - 0.0411811261425902*x_108 + 0.0555763467840006*x_109 - 0.659591307930928*x_11 - 0.0773353864074497*x_110 + 0.0295640248442203*x_111 + 0.143131728344273*x_112 + 0.0147867540642712*x_113 + 0.139467524902314*x_114 - 0.147307006025035*x_115 + 1.20745263776981*x_116 + 0.246031569432283*x_117 - 0.0671221747808782*x_118 + 0.0769695656473128*x_119 + 0.584458196362434*x_12 - 0.0799826125309371*x_120 - 0.0312802552381752*x_13 + 0.188147162742961*x_14 + 0.37102362876091*x_15 + 0.0219441572560421*x_16 - 0.0453353772184588*x_17 + 1.11000912201259*x_18 - 0.168893977291786*x_19 - 0.00929823820726075*x_2 + 0.30555869094634*x_20 + 0.81484317854876*x_21 - 0.556794213429692*x_22 + 2.21638495914419*x_23 + 0.340638091711539*x_24 + 0.237667022169997*x_25 + 0.626118441526548*x_26 - 1.2277004105871*x_27 - 5.37392537176183*x_28 + 5.33088956110216*x_29 - 0.098824811519873*x_3 - 0.384585741027868*x_30 - 0.0808907802378377*x_31 - 0.00813444046327259*x_32 - 0.162478159236899*x_33 - 11.6825794975058*x_34 - 0.0678926568163266*x_35 + 1.47802065990907*x_36 + 6.0709968990753*x_37 - 0.0630621588789755*x_38 - 4.29273400295932*x_39 + 0.359966775811291*x_4 + 0.729412478757928*x_40 + 9.74254209056759*x_41 + 22.5122129240888*x_42 + 3.60513974042696*x_43 - 0.191025217824606*x_44 + 1.98510843026427*x_45 - 3.31220340693007*x_46 + 15.1520741520179*x_47 + 0.0806299147106051*x_48 - 1.83924439722925*x_49 + 0.113820437839806*x_5 - 0.921443152374891*x_50 - 1.1067491366618*x_51 + 0.474534569541537*x_52 - 0.0341017018603729*x_53 + 0.612456817829025*x_54 - 1.55202638280862*x_55 + 4.22015269987371*x_56 + 1.12138027624149*x_57 + 3.17837347834141*x_58 + 3.23772683821472*x_59 + 0.016734216395074*x_6 + 0.0536224883557924*x_60 - 0.102386583233794*x_61 + 0.170227880647709*x_62 - 0.0589406239500943*x_63 + 0.0102531403868916*x_64 + 0.0706104177371871*x_65 + 0.0836292582077072*x_66 + 0.100627529674986*x_67 - 0.0726493713198031*x_68 + 0.0152773299372855*x_69 + 0.00310429065325157*x_7 - 0.15253985490705*x_70 + 0.0296082678552052*x_71 + 0.00957487716892783*x_72 + 0.0714273105196248*x_73 + 0.243600311359634*x_74 + 0.0612765235701852*x_75 - 0.0777405869295269*x_76 - 0.000363276966805091*x_77 - 0.00634947321774844*x_78 - 0.0366580768744563*x_79 - 0.0864985617647622*x_8 - 0.064723114093618*x_80 - 0.038985131390454*x_81 + 0.0977017037672328*x_82 + 0.460850818676227*x_83 + 0.0314558408076652*x_84 + 4.92892091228547*x_85 + 0.369383448465609*x_86 - 4.84653271621101*x_87 + 0.00700411240528065*x_88 + 0.145890414731655*x_89 + 0.105096733702151*x_9 - 0.0429370942329104*x_90 - 0.0142923831416061*x_91 + 0.216914254039978*x_92 + 0.152489937034336*x_93 + 0.0247918604931376*x_94 + 0.0783859699436053*x_95 + 0.00040910590491438*x_96 - 0.075622703720875*x_97 - 0.0787070762381004*x_98 - 0.119342199300895*x_99 - 0.0145675930460904*std::exp(0.900879800319672*x_23) + 0.000273225387700409*std::exp(0.982159852981567*x_23) - 0.0386175617939279*std::exp(0.477759838104248*x_3) - 0.00541442704647513*std::exp(0.995279788970947*x_4) + 0.00035437644638903*std::exp(1.46583986282349*x_6) + 0.000777563763707122*std::exp(1.61719989776611*x_6) + 0.00447332158058016*std::exp(0.921439826488495*x_8) + 0.101121267930516*std::sin(0.235279992222786*x_109 + 1.9761598110199) + 0.171404602621656*std::sin(0.222879990935326*x_118 - 4.22839975357056) + 0.169872084696147*std::sin(0.268239974975586*x_120 - 7.43680000305176) - 0.220382215786787*std::sin(0.34895983338356*x_13 - 1.13007986545563) + 1.51647701813962*std::sin(0.142240047454834*x_16 - 4.44736003875732) + 0.0211709206197619*std::sin(0.126480057835579*x_17 + 4.92880010604858) - 0.450243763995857*std::sin(0.326399862766266*x_9 - 1.12335991859436) + 0.00299259815013128*std::sin(0.324799835681915*x_91 + 1.9955198764801) - 0.368389742973211*std::sin(0.369679838418961*x_91 - 7.39503955841064) + 0.282227889228393*std::sin(0.409759849309921*x_91 + 1.98567986488342) + 0.151570560594925*std::sin(0.289199948310852*x_95 + 1.9541597366333) + 0.174592887650008*std::sin(0.284399926662445*x_97 + 1.957359790802) - 83.3239065411008);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (25.6821222709151*x_1 + 11.6572012473306*x_10 - 2.29503286933342*x_100 + 0.310823625809853*x_101 + 0.00145392890720345*x_102 - 0.039496284551435*x_103 + 26.124535197883*x_104 + 2.165379156027*x_105 - 3.2193185170451*x_106 + 0.0448384878197034*x_107 + 1.95888714129425*x_108 + 0.503084522112573*x_109 + 2.9733977363702*x_11 + 4.16912096860269*x_110 + 1.76480497766499*x_111 - 2.98467246951906*x_112 - 2.38309213486517*x_113 - 1.48771842607884*x_114 + 2.89844016562931*x_115 - 24.2639655628488*x_116 - 5.84542427339299*x_117 + 0.917555524503866*x_118 - 3.14233286506704*x_119 - 11.3525028707786*x_12 + 2.22331938255556*x_120 + 1.3755563093248*x_13 - 10.2234980024336*x_14 + 4.08772638223672*x_15 - 1.51697868775839*x_16 + 1.6754458214066*x_17 - 39.2879899941192*x_18 + 24.4869310084678*x_19 - 1.80370965951101*x_2 - 0.810833133049705*x_20 - 13.6587152951881*x_21 - 36.1831406495583*x_22 - 44.6743126490397*x_23 - 11.9358637297535*x_24 - 2.68593969712367*x_25 + 4.95467458682081*x_26 + 12.8084595335117*x_27 + 90.0200092894418*x_28 - 135.250933276286*x_29 - 1.45012940272799*x_3 + 1.08319279518002*x_30 + 2.33699044453009*x_31 - 2.10300601343956*x_32 + 3.48722341611569*x_33 + 309.534503296529*x_34 - 1.47084389688107*x_35 - 26.8672541711551*x_36 - 237.580341916005*x_37 - 0.815484706968049*x_38 + 108.391381798513*x_39 - 23.1646768876894*x_4 - 11.1127876182249*x_40 - 467.533193793882*x_41 - 379.146185818647*x_42 - 75.3507722179223*x_43 + 2.76013414154731*x_44 + 1.21792805804472*x_45 + 104.073177361852*x_46 - 261.796858667653*x_47 - 5.28268138628859*x_48 + 76.3697290598376*x_49 - 3.30775661034427*x_5 + 88.5916561751692*x_50 + 10.1304236645983*x_51 + 5.14377577915985*x_52 - 1.08662046760116*x_53 - 3.88013632360656*x_54 + 58.7571293459226*x_55 - 73.7356471710004*x_56 - 26.0851261783304*x_57 - 9.93614640124913*x_58 - 201.978181490483*x_59 - 0.39316259194669*x_6 + 2.84305639048774*x_60 + 2.02164871782327*x_61 - 2.23363370951817*x_62 + 0.108698381822709*x_63 - 1.2807540060202*x_64 + 0.240638392715801*x_65 - 4.86665501262768*x_66 - 2.25500479846309*x_67 + 0.661520641294333*x_68 - 0.52672189682109*x_69 + 0.32525025681428*x_7 + 1.64215216567857*x_70 + 0.158271381686187*x_71 - 0.129829558666263*x_72 - 2.45740059861582*x_73 - 4.92524552442068*x_74 - 2.16258407936643*x_75 + 1.67744029135926*x_76 - 1.34463987957082*x_77 - 0.170922915303861*x_78 + 1.06236505750938*x_79 + 0.324363944902088*x_8 - 0.852998035325881*x_80 + 0.0750549275958826*x_81 - 2.01609814561715*x_82 - 7.25013796323219*x_83 - 1.50889382353815*x_84 - 111.652468986262*x_85 - 5.45725468338697*x_86 + 148.550996769334*x_87 - 1.45207695492232*x_88 - 3.83959188468466*x_89 - 2.5784690407516*x_9 + 2.02331039758358*x_90 - 0.0820899784651291*x_91 - 5.51296206675409*x_92 - 2.45470681466349*x_93 + 0.480597971042457*x_94 - 0.942724651377374*x_95 + 1.67575104278473*x_96 + 0.214478197283477*x_97 - 0.778223235014019*x_98 + 0.810553861680894*x_99 + 0.000303708977631392*std::exp(0.900879800319672*x_23) + 0.0045897600541667*std::exp(0.982159852981567*x_23) + 0.0833024567101233*std::exp(0.477759838104248*x_3) + 0.0116795326710666*std::exp(0.995279788970947*x_4) - 0.000764430150767601*std::exp(1.46583986282349*x_6) - 0.0213669952975168*std::exp(1.61719989776611*x_6) - 0.122924248322532*std::exp(0.921439826488495*x_8) - 2.86744259937763*std::sin(0.235279992222786*x_109 + 1.9761598110199) - 0.36973915044143*std::sin(0.222879990935326*x_118 - 4.22839975357056) - 0.366433335619966*std::sin(0.268239974975586*x_120 - 7.43680000305176) + 0.00459458588889595*std::sin(0.34895983338356*x_13 - 1.13007986545563) - 0.031615908223376*std::sin(0.142240047454834*x_16 - 4.44736003875732) + 0.355638422140564*std::sin(0.126480057835579*x_17 + 4.92880010604858) + 0.00938679937141638*std::sin(0.326399862766266*x_9 - 1.12335991859436) + 0.0502709779762722*std::sin(0.324799835681915*x_91 + 1.9955198764801) + 10.1231336556044*std::sin(0.369679838418961*x_91 - 7.39503955841064) - 0.00588396061212217*std::sin(0.409759849309921*x_91 + 1.98567986488342) - 0.326954874309882*std::sin(0.289199948310852*x_95 + 1.9541597366333) - 0.376616642525761*std::sin(0.284399926662445*x_97 + 1.957359790802) - 1060.55114118891);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (74.3970654577547*x_1 + 15.3002259004562*x_10 - 6.33847490104145*x_100 + 0.481615137218194*x_101 + 0.142190851607166*x_102 - 0.0734402185404272*x_103 + 51.0528322251445*x_104 + 6.95666125187579*x_105 - 6.01147591362489*x_106 + 0.799849580881892*x_107 + 4.98252556451025*x_108 + 1.49233920443883*x_109 + 26.1091104987964*x_11 + 11.1140959422808*x_110 + 5.09763979514632*x_111 - 7.91442713544137*x_112 - 6.89942551948549*x_113 - 3.04696678385039*x_114 + 8.9424339735412*x_115 - 69.0511384404183*x_116 - 16.5151556924674*x_117 + 2.51996667146217*x_118 - 8.28172037502797*x_119 - 29.7023753581614*x_12 + 5.57116697643084*x_120 + 2.96411040357568*x_13 - 26.6429589367886*x_14 + 13.190235633189*x_15 - 4.94535337214099*x_16 + 7.08819755841482*x_17 - 106.118020258079*x_18 + 58.4884856480962*x_19 - 4.53474430640626*x_2 - 2.67946640675946*x_20 - 30.0841264755923*x_21 - 116.717986977004*x_22 - 133.704112542614*x_23 - 51.1510427933042*x_24 - 6.50216993741318*x_25 + 21.4130053622078*x_26 + 29.9792535063651*x_27 + 192.281431922435*x_28 - 374.072443761924*x_29 - 4.47730632165694*x_3 + 5.4760869972757*x_30 + 6.53287922260813*x_31 - 6.2176062197109*x_32 + 12.3555709005915*x_33 + 810.478679194085*x_34 - 5.65767109143226*x_35 - 68.5365806776992*x_36 - 650.37984920409*x_37 - 3.01544280059079*x_38 + 298.208506666271*x_39 - 72.6179318626147*x_4 - 27.4157369347439*x_40 - 1327.18930953234*x_41 - 979.439139014629*x_42 - 214.334053383794*x_43 + 7.6995707118434*x_44 + 114.481963807545*x_45 + 339.038257954532*x_46 - 691.910571533976*x_47 - 17.9292338011735*x_48 + 244.694491399788*x_49 - 9.06035328316083*x_5 + 217.035209762881*x_50 + 31.338819318022*x_51 + 7.50415949049329*x_52 + 12.9395904714268*x_53 - 16.0956438810443*x_54 + 136.933351225373*x_55 - 163.01132097364*x_56 - 67.6324657060169*x_57 + 0.370366068122998*x_58 - 500.705842728375*x_59 - 0.258473196543555*x_6 + 5.50250206443339*x_60 + 5.66608837153577*x_61 - 3.163172607536*x_62 - 0.256006439776248*x_63 - 3.8452247876494*x_64 + 0.631216621960726*x_65 - 13.4627638293773*x_66 - 6.05994421247002*x_67 + 1.72930682140096*x_68 - 1.39497531379316*x_69 + 0.126473303648714*x_7 + 3.24379512192302*x_70 + 0.405561720904057*x_71 + 0.210087312897313*x_72 - 7.69142835243951*x_73 - 14.9304694107483*x_74 - 5.46622558127379*x_75 + 5.31335196072246*x_76 - 3.48625954667626*x_77 + 0.815727374251733*x_78 + 3.04173549394904*x_79 + 0.12011695112138*x_8 - 2.18748026767746*x_80 + 0.119663894991508*x_81 - 6.0560931883847*x_82 - 18.9038785344982*x_83 + 0.467851814300226*x_84 - 326.62595073312*x_85 - 14.2758511999028*x_86 + 419.307972280831*x_87 - 4.04910920945418*x_88 - 11.3480603738713*x_89 - 5.38767774625517*x_9 + 3.65290804262177*x_90 - 0.0768207613427592*x_91 - 13.3829310146547*x_92 - 5.95213008077169*x_93 + 1.13361773864311*x_94 - 2.65877400832959*x_95 + 3.64006462139561*x_96 - 0.0643419230205093*x_97 - 2.45535079479571*x_98 + 1.51232780667195*x_99 - 0.000933595836773973*std::exp(0.900879800319672*x_23) + 0.00856428113994247*std::exp(0.982159852981567*x_23) - 0.0632347812561754*std::exp(0.477759838104248*x_3) - 0.00886591731861252*std::exp(0.995279788970947*x_4) + 0.000580277884692207*std::exp(1.46583986282349*x_6) - 0.0583808664106843*std::exp(1.61719989776611*x_6) - 0.335864917833606*std::exp(0.921439826488495*x_8) - 1.08768911230156*std::sin(0.235279992222786*x_109 + 1.9761598110199) + 0.280668484740699*std::sin(0.222879990935326*x_118 - 4.22839975357056) + 0.278159045219171*std::sin(0.268239974975586*x_120 - 7.43680000305176) - 0.0141236729023526*std::sin(0.34895983338356*x_13 - 1.13007986545563) + 0.097186723037854*std::sin(0.142240047454834*x_16 - 4.44736003875732) + 0.663604936953574*std::sin(0.126480057835579*x_17 + 4.92880010604858) - 0.0288548494092361*std::sin(0.326399862766266*x_9 - 1.12335991859436) + 0.0938033325244968*std::sin(0.324799835681915*x_91 + 1.9955198764801) + 27.6593552521645*std::sin(0.369679838418961*x_91 - 7.39503955841064) + 0.0180871871949942*std::sin(0.409759849309921*x_91 + 1.98567986488342) + 0.248190999091066*std::sin(0.289199948310852*x_95 + 1.9541597366333) + 0.285889179600361*std::sin(0.284399926662445*x_97 + 1.957359790802) - 3290.10604439346);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (7.06752418768681*x_1 + 12.2968093994447*x_10 - 0.917490017100507*x_100 + 0.345569434996835*x_101 - 0.0855682748229519*x_102 - 0.0398852841414043*x_103 + 21.4889124489892*x_104 + 0.30403672271487*x_105 - 2.9605054352082*x_106 - 0.278278735983454*x_107 + 1.06559927766394*x_108 + 0.179593235524616*x_109 - 9.75109828980953*x_11 + 1.66583136175804*x_110 + 0.636481978164989*x_111 - 1.30963462548792*x_112 - 0.716632391703355*x_113 - 1.06669129309006*x_114 + 0.494019848117216*x_115 - 7.05343109910356*x_116 - 2.02935139208325*x_117 + 0.334955903384837*x_118 - 1.48485797469537*x_119 - 5.02881428611309*x_12 + 1.16064110233104*x_120 + 1.07313831940772*x_13 - 4.92852040113942*x_14 + 0.263000621203848*x_15 - 0.21204170261492*x_16 - 0.946877099496919*x_17 - 13.6663071744912*x_18 + 14.8360033935804*x_19 - 0.950317208481075*x_2 + 0.267423039276102*x_20 - 8.98305679571005*x_21 - 3.75517110197058*x_22 - 8.05250509617692*x_23 + 7.63635976665865*x_24 - 1.22407055193315*x_25 - 2.60579644004515*x_26 + 6.36285845470989*x_27 + 62.8744938953704*x_28 - 45.4473978570259*x_29 - 0.275847335633046*x_3 - 0.942083477464837*x_30 + 0.79815199665558*x_31 - 0.692768494222441*x_32 - 0.481236831535008*x_33 + 147.731733337372*x_34 + 0.256994664319769*x_35 - 12.1742731289523*x_36 - 90.015549007691*x_37 - 0.14563235922735*x_38 + 41.6325436362307*x_39 - 3.32803357440526*x_4 - 5.5296639786677*x_40 - 81.157347684852*x_41 - 175.014262449655*x_42 - 25.886187609776*x_43 + 0.789371078702474*x_44 - 64.8120488159788*x_45 + 3.27984398956043*x_46 - 105.256473436234*x_47 + 0.0671001305721037*x_48 + 8.75000028578561*x_49 - 1.26329667862531*x_5 + 49.6773431156584*x_50 + 2.31617521126563*x_51 + 7.11407560245785*x_52 - 8.85385112802605*x_53 + 1.02426377988507*x_54 + 39.7366498703841*x_55 - 45.1428192280819*x_56 - 11.6978987076512*x_57 - 22.9119665435072*x_58 - 115.812661120883*x_59 - 0.664009755822719*x_6 + 2.89531237103116*x_60 + 0.65621330561423*x_61 - 2.32990124870549*x_62 + 0.305932131093904*x_63 - 0.300846561979854*x_64 + 0.184451306403564*x_65 - 1.76542935991189*x_66 - 0.846921498737063*x_67 + 0.241129949201034*x_68 - 0.135778633613937*x_69 + 0.504034858043416*x_7 + 1.17084430095564*x_70 + 0.244052418892488*x_71 - 0.407790819774587*x_72 - 0.383517342023781*x_73 - 0.846712974147055*x_74 - 1.1655284856311*x_75 + 0.17871148068947*x_76 - 0.644207110436794*x_77 - 0.910304301119386*x_78 + 0.3325283000651*x_79 + 0.532570331610878*x_8 - 0.534335627206461*x_80 + 0.0796392669654041*x_81 - 0.409934807729997*x_82 - 3.34229130706646*x_83 - 3.38990840191028*x_84 - 29.503919754411*x_85 - 2.20591835250208*x_86 + 49.9669976117986*x_87 - 0.563674832707674*x_88 - 0.910960144763992*x_89 - 1.95230997094209*x_9 + 1.81298737770919*x_90 - 0.180237851125952*x_91 - 2.99283277664014*x_92 - 1.31567251115352*x_93 + 0.245718523540771*x_94 - 0.304670368829908*x_95 + 1.27190747459032*x_96 + 0.464710929554547*x_97 - 0.212381552215775*x_98 + 0.692459859570576*x_99 - 0.00185434908304245*std::exp(0.900879800319672*x_23) + 0.00544710179256949*std::exp(0.982159852981567*x_23) + 0.0851842269043321*std::exp(0.477759838104248*x_3) + 0.0119433687850384*std::exp(0.995279788970947*x_4) - 0.000781698331444128*std::exp(1.46583986282349*x_6) - 0.00819269852763715*std::exp(1.61719989776611*x_6) - 0.0471325656331263*std::exp(0.921439826488495*x_8) - 5.19143550328959*std::sin(0.235279992222786*x_109 + 1.9761598110199) - 0.378091414473137*std::sin(0.222879990935326*x_118 - 4.22839975357056) - 0.374710922576778*std::sin(0.268239974975586*x_120 - 7.43680000305176) - 0.028053059861716*std::sin(0.34895983338356*x_13 - 1.13007986545563) + 0.193036540706829*std::sin(0.142240047454834*x_16 - 4.44736003875732) + 0.422069708195271*std::sin(0.126480057835579*x_17 + 4.92880010604858) - 0.0573127700828633*std::sin(0.326399862766266*x_9 - 1.12335991859436) + 0.0596613180247152*std::sin(0.324799835681915*x_91 + 1.9955198764801) + 3.88149016932592*std::sin(0.369679838418961*x_91 - 7.39503955841064) + 0.0359255661483577*std::sin(0.409759849309921*x_91 + 1.98567986488342) - 0.334340658134585*std::sin(0.289199948310852*x_95 + 1.9541597366333) - 0.385124266436711*std::sin(0.284399926662445*x_97 + 1.957359790802) - 1111.19706239061);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (54.1372406030227*x_1 + 10.1207773946005*x_10 - 4.52254665683855*x_100 + 0.297404750433345*x_101 + 0.125407572495273*x_102 - 0.00689269205263496*x_103 + 34.1594599081597*x_104 + 5.03102508460382*x_105 - 4.03970873003568*x_106 + 0.605393982872082*x_107 + 3.52351098753298*x_108 + 1.06167302247772*x_109 + 20.9654659836564*x_11 + 8.05914626375199*x_110 + 3.66862528516387*x_111 - 5.68090588492059*x_112 - 4.97418324517697*x_113 - 2.12505278615943*x_114 + 6.6016460358591*x_115 - 50.5209025908671*x_116 - 11.865063671442*x_117 + 1.83879302838338*x_118 - 5.83615767464983*x_119 - 21.0784444380603*x_12 + 3.91905948935019*x_120 + 2.02746892894292*x_13 - 18.9825112581721*x_14 + 9.78497558072617*x_15 - 3.58228319862613*x_16 + 5.44430748641219*x_17 - 78.046659128916*x_18 + 40.7289137920506*x_19 - 3.18328583604521*x_2 - 2.31931690045464*x_20 - 20.9178270132342*x_21 - 85.4402449464298*x_22 - 98.7984126171502*x_23 - 39.8345840927139*x_24 - 4.78714596530987*x_25 + 15.9477581443312*x_26 + 21.1656780473796*x_27 + 130.369578284765*x_28 - 271.073405788127*x_29 - 3.26574666218779*x_3 + 3.88643556509368*x_30 + 4.71760527165604*x_31 - 4.41248297098334*x_32 + 9.38519523769627*x_33 + 573.061362993975*x_34 - 4.19937365557064*x_35 - 49.3748590875206*x_36 - 465.11976485756*x_37 - 1.99885057413639*x_38 + 213.826955359161*x_39 - 53.3354794398166*x_4 - 19.5877425085817*x_40 - 1009.58051176517*x_41 - 695.055928251537*x_42 - 154.143902105312*x_43 + 5.65050303979659*x_44 + 93.887561245993*x_45 + 254.931947912504*x_46 - 501.052527506486*x_47 - 13.2713340039776*x_48 + 180.911408171355*x_49 - 6.49404067445274*x_5 + 153.417799006807*x_50 + 22.7047755181689*x_51 + 3.34282051263628*x_52 + 10.3649164401712*x_53 - 11.4647257684858*x_54 + 94.3115284502979*x_55 - 116.644429652905*x_56 - 48.6369597174252*x_57 + 5.63925825124778*x_58 - 345.787572042151*x_59 + 0.121128730067677*x_6 + 3.41012938911195*x_60 + 4.14577929904668*x_61 - 2.18031764643466*x_62 - 0.212110746924038*x_63 - 2.80048824940969*x_64 + 0.435755478692651*x_65 - 9.66798599449275*x_66 - 4.37230059337134*x_67 + 1.2931652371574*x_68 - 1.07539954212907*x_69 + 0.106202298449664*x_7 + 2.30261869481088*x_70 + 0.226924887099176*x_71 + 0.211067415119621*x_72 - 5.67041841220763*x_73 - 10.9796033020472*x_74 - 3.82486030207854*x_75 + 3.99666765787669*x_76 - 2.48822713880682*x_77 + 0.850049417528514*x_78 + 2.17930550503443*x_79 - 0.0486628211403339*x_8 - 1.53276800195922*x_80 + 0.0735024569461323*x_81 - 4.45790930031679*x_82 - 13.4553876370048*x_83 + 1.02414802705286*x_84 - 238.304340970288*x_85 - 10.4422493077252*x_86 + 301.121922343772*x_87 - 2.90040009837811*x_88 - 8.4781505496372*x_89 - 3.70016777655917*x_9 + 2.42806742501139*x_90 - 0.00227453742811405*x_91 - 9.54369667494875*x_92 - 4.27045823771*x_93 + 0.796465444917946*x_94 - 1.89659978523823*x_95 + 2.48673998674022*x_96 - 0.14428662386104*x_97 - 1.71250453746778*x_98 + 0.994892041427397*x_99 + 0.000256983475666545*std::exp(0.900879800319672*x_23) - 0.0072980288418782*std::exp(0.982159852981567*x_23) - 0.00758298885982569*std::exp(0.477759838104248*x_3) - 0.00106318312364857*std::exp(0.995279788970947*x_4) + 6.95857666906138e-5*std::exp(1.46583986282349*x_6) - 0.0420033470402743*std::exp(1.61719989776611*x_6) - 0.241645106860496*std::exp(0.921439826488495*x_8) + 0.0323363549778141*std::sin(0.235279992222786*x_109 + 1.9761598110199) + 0.0336572049560942*std::sin(0.222879990935326*x_118 - 4.22839975357056) + 0.0333562779732196*std::sin(0.268239974975586*x_120 - 7.43680000305176) + 0.00388771072947993*std::sin(0.34895983338356*x_13 - 1.13007986545563) - 0.0267518136769029*std::sin(0.142240047454834*x_16 - 4.44736003875732) - 0.565489139177475*std::sin(0.126480057835579*x_17 + 4.92880010604858) + 0.00794264412815232*std::sin(0.326399862766266*x_9 - 1.12335991859436) - 0.0799342542639449*std::sin(0.324799835681915*x_91 + 1.9955198764801) + 19.900107158298*std::sin(0.369679838418961*x_91 - 7.39503955841064) - 0.00497871567900571*std::sin(0.409759849309921*x_91 + 1.98567986488342) + 0.0297625696464754*std::sin(0.289199948310852*x_95 + 1.9541597366333) + 0.0342832602720916*std::sin(0.284399926662445*x_97 + 1.957359790802) - 1992.14617389779);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
