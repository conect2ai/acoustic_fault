
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0169928711714626*x_10 + 0.00710329760099526*x_100 + 0.0153031940764025*x_101 - 1.5479536358591e-5*x_102 - 0.0031015942302784*x_103 + 0.00390712514179159*x_104 + 0.00258394563634053*x_105 - 0.0176957542689612*x_106 - 0.00894785586325992*x_107 + 0.00556498371519991*x_108 - 9.79944132746939e-5*x_109 - 0.0324267180164631*x_11 - 0.027401529011713*x_112 - 4.84331062110395e-5*x_113 + 0.00421726121123739*x_114 - 0.0218637107008875*x_116 - 0.0211251641976437*x_117 + 0.034501637667563*x_118 - 0.000922368063616436*x_119 + 0.0604475195261151*x_12 + 0.000882143006997771*x_120 - 0.041799486660224*x_13 + 0.00892829082612269*x_14 - 0.00759530614216883*x_15 - 0.0199620430354049*x_16 + 0.000552025321108487*x_17 + 0.00510233754966448*x_18 - 0.00165518802527786*x_19 + 0.017327836261347*x_2 + 0.014201378697906*x_20 + 0.00355022806200101*x_21 + 0.104869400568689*x_22 + 0.00621351784471385*x_23 + 0.0592849800715962*x_25 + 0.0187817129297299*x_26 - 0.00336696324467177*x_27 + 5.35969371469309e-5*x_28 + 0.0154314432276242*x_29 + 0.00891100207440947*x_3 + 0.020607198933595*x_30 - 0.0977628292192297*x_31 - 0.0253401742903788*x_32 - 0.00495144011127737*x_33 + 0.0101769868279706*x_34 - 0.00196538792245536*x_35 + 0.00889437266418293*x_36 + 0.037007719356407*x_37 + 0.00761936921878692*x_38 + 0.00402767208374574*x_39 + 0.0141224467872256*x_4 + 0.0223316424806915*x_40 + 0.00998418159035105*x_41 - 0.00121351224007697*x_42 + 0.00520410910873197*x_43 + 0.0230178420108797*x_44 + 0.00324312668880379*x_45 - 0.000355590787485709*x_46 + 0.00332916463179655*x_47 - 0.011018274528637*x_48 + 0.00677481323644521*x_49 - 0.0186536486730354*x_5 + 0.0207625122655514*x_50 + 8.84961911348688e-5*x_51 - 0.0106928947836656*x_52 + 0.00267284164209135*x_53 + 0.0114608132302056*x_54 + 0.00360492960455574*x_55 - 0.000751798130463874*x_56 + 0.00963439649766171*x_57 - 0.00693203208034*x_58 - 0.00454192016152784*x_59 - 0.0151370656945143*x_6 + 0.00888063787160296*x_60 + 0.0165035349258468*x_61 - 0.0357152611604325*x_62 - 0.00730375636231157*x_63 + 0.00246551245247052*x_64 + 0.0042837497585517*x_65 - 0.0101084860965944*x_66 + 0.0076404133467621*x_67 - 0.0239260277809918*x_68 + 0.00451778041126472*x_69 - 0.0126087520721499*x_7 + 0.00770900543513264*x_71 + 0.000833855769258115*x_72 + 1.16483265244248e-5*x_73 + 0.00199440709181516*x_74 + 0.0114131033358919*x_75 + 0.0098287012453654*x_76 + 0.00933941627399531*x_77 + 0.00491617094792338*x_78 + 0.0130886922523671*x_79 + 0.00415385156602561*x_8 - 0.00235392298730059*x_80 - 0.00344702347077937*x_81 - 0.00486576923740072*x_82 + 0.00958078643236739*x_83 + 0.00269832622763228*x_84 - 0.020049575677899*x_85 + 0.00285418348211359*x_86 - 0.00833042794944133*x_87 - 0.00869261541780626*x_88 + 0.00548005740761591*x_89 - 0.0492162112633472*x_9 - 0.000854027214993262*x_90 + 0.0229085432468396*x_91 - 0.0012679549275744*x_92 - 0.0466770593892636*x_93 + 0.0123030263579594*x_94 - 0.00135582897282102*x_96 + 0.00452828323462617*x_97 + 0.00505444681393797*x_98 - 0.00671938975447418*x_99 + 4.52507281634721e-6*std::pow(-6.29120016098022*x_103 - 8.73127937316895, 2) + 7.6393475116921e-5*std::pow(-7.75808048248291*x_110 - 9.38607978820801, 2) + 4.79622511784654e-5*std::pow(-7.40000009536743*x_110 - 9.99830055236816, 2) + 4.74596943677063e-6*std::pow(-7.57424020767212*x_14 - 9.37415981292725, 2) - 3.45902571102579e-6*std::pow(-6.60400009155273*x_14 - 9.96963977813721, 2) - 3.46277859679919e-6*std::pow(-7.48759984970093*x_15 - 9.33039951324463, 2) - 0.000252152127519697*std::pow(-6.43415975570679*x_15 - 9.8625602722168, 2) - 0.00016456312452371*std::pow(-7.42991971969604*x_17 - 9.8689603805542, 2) + 0.000768191220601977*std::pow(-3.6814398765564*x_17 - 5.03768014907837, 2) + 0.000131079062895521*std::pow(-8.16792011260986*x_18 - 9.38511943817139, 2) + 5.29953183679766e-6*std::pow(-5.65367984771729*x_18 - 5.04967975616455, 2) + 0.000248026429384215*std::pow(-3.69407987594604*x_24 - 5.24943971633911, 2) + 1.00579184111892e-5*std::pow(-3.49719977378845*x_24 - 4.73023986816406, 2) + 2.81973151567349e-6*std::pow(-8.15824031829834*x_42 - 8.98200035095215, 2) + 5.2195950147787e-6*std::pow(-5.91807985305786*x_73 - 8.91327953338623, 2) - 6.93605176506368e-6*std::pow(-6.00263977050781*x_74 - 7.00984001159668, 2) - 9.19565589221089e-6*std::pow(-6.09375953674316*x_76 - 8.72231960296631, 2) + 0.000137416728276987*std::pow(-5.88271999359131*x_77 - 8.51807975769043, 2) - 2.13883563809069e-5*std::pow(-3.11719989776611*x_80 - 4.28687953948975, 2) + 0.000110341611128282*std::pow(-7.35264015197754*x_81 - 9.76879978179932, 2) - 2.10195315974334e-5*std::pow(-3.48071980476379*x_87 - 4.91408014297485, 2) - 5.50308141381501e-6*std::pow(-6.8120002746582*x_88 - 6.61999988555908, 2) + 0.000126168102321309*std::pow(-6.38272047042847*x_88 - 5.97375965118408, 2) - 0.000142970116582134*std::pow(-7.00031995773315*x_90 - 9.3840799331665, 2) + 0.000190125762943266*std::pow(-5.30272006988525*x_97 - 6.53128004074097, 2) + 0.00367884146068513*std::exp(0.63487982749939*x_1) - 0.00130832288498054*std::exp(1.13743984699249*x_1) + 0.000393763634472662*std::exp(1.20167994499207*x_1) - 7.72535567492127e-5*std::exp(1.2125598192215*x_1) - 0.000267911432827859*std::exp(1.05679976940155*x_106) + 0.000917129359722794*std::exp(1.3271199464798*x_106) - 0.0267292573670752*std::exp(0.620559811592102*x_109) - 0.000579732303273738*std::exp(0.843999862670898*x_110) + 0.000624478414596829*std::exp(0.924159824848175*x_110) - 0.00040941901253032*std::exp(1.38351988792419*x_26) + 0.0107122656053915*std::exp(0.582799851894379*x_31) - 0.00139020581731173*std::exp(0.667519807815552*x_31) - 0.000400321586954611*std::exp(0.815839886665344*x_6) - 0.00091049218275958*std::exp(0.835679888725281*x_66) - 0.000268170095058564*std::exp(0.971119821071625*x_68) - 0.000176871301304932*std::exp(1.1723198890686*x_68) - 0.00796111924047683*std::exp(0.692079842090607*x_70) - 0.00192690884609516*std::exp(0.620319843292236*x_74) + 0.0170783093077918*std::exp(0.827759861946106*x_74) - 8.46356483184514e-5*std::exp(0.861039876937866*x_81) + 2.96165814233785*std::exp(-0.0478384228488512*x_10 - 0.093678375432374*x_101 - 0.0281804631228664*x_103 + 0.0243835110180326*x_104 - 0.0117166839807085*x_105 + 0.00338553934863206*x_106 - 0.0175675985424151*x_107 - 0.0563102067993752*x_11 + 0.0210968656068131*x_113 + 0.0021881384465021*x_114 - 0.0080711734675612*x_116 - 0.0111979596430787*x_119 + 0.0193603084771188*x_12 + 0.00985405324237558*x_120 - 0.00854447804837071*x_13 + 0.013445767783971*x_17 + 0.0247832355978178*x_18 + 0.0262932776506673*x_19 + 0.000280269471715377*x_2 - 0.0140667083548637*x_20 + 0.0365854890406805*x_21 + 0.0405802762383007*x_22 + 0.007465601706111*x_23 + 0.045351376101118*x_25 - 0.0329968645788173*x_26 - 0.0122723451216745*x_27 - 0.0177239507328271*x_29 + 0.0668602251987537*x_3 + 0.019571397938948*x_30 + 0.00472292581685715*x_32 - 0.0134128428542763*x_33 + 0.0290830469429652*x_34 - 0.000523286574004465*x_36 - 0.00447305943176499*x_37 + 0.0105552879619133*x_38 + 0.0171093697415836*x_39 + 0.0304755022487304*x_40 + 0.000147703242200918*x_41 + 0.0156508302724422*x_42 + 0.00191198478165264*x_43 + 0.0282262154482822*x_44 + 0.00875568792412133*x_46 + 0.0141937426269568*x_47 - 0.00496678121687151*x_48 - 0.00465833761203851*x_49 - 0.00179863580511231*x_5 - 0.000156745681381281*x_51 + 0.0152748454183195*x_52 + 0.0111849813031539*x_54 - 0.00353597950228897*x_55 - 0.00327042088907714*x_56 - 0.00514969290361692*x_57 + 0.00291324282130839*x_6 - 0.00162307221743985*x_60 + 0.0010446720700088*x_61 - 0.0310096790956703*x_62 + 0.00904398043179694*x_63 + 0.000963354497948675*x_65 - 0.00379694191806034*x_66 + 0.0125761401587455*x_67 + 0.00371070836467596*x_68 - 0.0323955947236654*x_69 + 0.00324649766267517*x_71 - 0.00516176614223434*x_75 - 0.00907605196988704*x_76 - 0.0151134853113695*x_77 + 0.0314826087666932*x_78 - 0.023272699156885*x_8 - 0.0153581875602346*x_80 + 0.00739537859274553*x_82 + 0.0256690877801683*x_83 + 0.00457415194018473*x_86 + 0.0155290109211285*x_88 + 0.0204458488807987*x_9 + 0.00933735789089945*x_90 - 0.0121842552237497*x_91 + 0.00130741733808633*x_92 + 0.022096163228627*x_93 + 0.0190829367686421*x_94 + 0.027962588604417*x_98 + 0.0197508584324158*x_99 + 0.000275846956392593*std::pow(-7.54568004608154*x_14 - 9.38496017456055, 2) + 0.000676500748377371*std::pow(-6.26032018661499*x_15 - 8.67928028106689, 2) + 0.000782054984494282*std::pow(-3.84272003173828*x_7 - 5.66088008880615, 2) + 0.000302718604579706*std::pow(-5.1224799156189*x_70 - 7.08175992965698, 2) - 0.00539183193481524*std::exp(1.57423985004425*x_100) - 0.0367249905920104*std::exp(0.543039858341217*x_109) - 0.00305367477446646*std::exp(1.28303980827332*x_110) + 0.0173650158574583*std::exp(0.899439811706543*x_50) - 0.0119532737781561*std::exp(1.00575983524323*x_72) + 0.00643687358387513*std::exp(0.888719916343689*x_74) - 0.00153845048810457*std::exp(1.83999991416931*x_81) + 0.156375187356367*std::sin(0.355119854211807*x_1 - 1.1522399187088) - 0.161510698950011*std::sin(0.371519833803177*x_102 + 1.98631989955902) - 0.0813307031092974*std::sin(0.571119844913483*x_108 + 5.39264011383057) + 0.194875974444729*std::sin(0.379759848117828*x_111 - 4.20928001403809) + 0.0642589070468742*std::sin(0.484159857034683*x_112 - 7.34711980819702) + 1.50884396908791*std::sin(0.114000059664249*x_115 - 7.71016025543213) + 0.105831177980592*std::sin(0.541919827461243*x_117 + 2.14631986618042) - 0.0414195156229429*std::sin(0.50111985206604*x_118 - 0.914959847927094) - 0.0957364992650467*std::sin(0.428879857063293*x_16 + 2.01399970054626) + 0.155922975816448*std::sin(0.337759852409363*x_24 - 4.27648019790649) + 0.271451565558873*std::sin(0.335119843482971*x_28 - 4.26039981842041) + 0.187286496694226*std::sin(0.262719959020615*x_31 - 1.11887979507446) - 0.239036149257085*std::sin(0.312479853630066*x_35 - 7.4268798828125) + 0.38150795534883*std::sin(0.450239837169647*x_4 + 5.25072002410889) + 0.197984387050068*std::sin(0.403679847717285*x_45 + 5.20216035842896) + 0.255047689893384*std::sin(0.365519851446152*x_53 + 5.17160034179688) + 1.2199869224678*std::sin(0.219359993934631*x_58 + 5.00799989700317) - 0.290354999513017*std::sin(0.252719968557358*x_59 - 7.53144025802612) + 0.296169747193339*std::sin(0.218400001525879*x_64 - 4.37687969207764) + 0.299169536111293*std::sin(0.22639998793602*x_73 - 4.35999965667725) + 0.126398317363063*std::sin(0.429439842700958*x_79 - 1.17511987686157) - 0.218198430106892*std::sin(0.274719953536987*x_84 - 7.52063989639282) + 0.306816394073294*std::sin(0.181760013103485*x_85 + 4.96687984466553) + 0.0654803601290905*std::sin(0.369199842214584*x_87 + 5.17087984085083) - 0.777403816708919*std::sin(0.135120034217834*x_89 + 4.91599988937378) + 0.0628923912426598*std::sin(0.399759858846664*x_95 + 5.18351984024048) + 0.0589673984205374*std::sin(0.377199828624725*x_96 - 7.40903997421265) - 0.0247577540446762*std::sin(0.315919935703278*x_97 + 5.12328004837036)) + 0.0301545790967981*std::sin(0.397199839353561*x_10 - 4.18671989440918) + 0.0506200510455125*std::sin(0.472399860620499*x_100 - 4.15240001678467) - 0.0073058783227623*std::sin(0.32711985707283*x_101 + 1.96655988693237) + 0.0806252154698714*std::sin(0.362559854984283*x_102 - 7.41928005218506) - 0.00988892323506286*std::sin(0.362959831953049*x_102 - 7.41296005249023) + 0.0495407925948299*std::sin(0.367999851703644*x_102 - 4.21712017059326) + 0.00666655003124418*std::sin(0.378719836473465*x_105 - 7.40032005310059) + 0.00482419597739935*std::sin(0.407439857721329*x_105 + 5.21447992324829) - 0.0973702812670795*std::sin(0.409599840641022*x_105 + 5.19664001464844) - 0.00278684564899144*std::sin(0.579839885234833*x_106 - 7.20016002655029) - 0.00333638777133847*std::sin(0.37679985165596*x_107 + 5.16760015487671) - 0.0857728684351554*std::sin(0.422799855470657*x_108 + 5.2085599899292) + 0.119885477895158*std::sin(0.328239858150482*x_111 - 7.45631980895996) - 0.00681295944148577*std::sin(0.346959829330444*x_111 - 7.44280004501343) + 0.0707001508112954*std::sin(0.413439869880676*x_111 - 4.19479990005493) - 0.00311661985732006*std::sin(0.415359854698181*x_111 + 5.20128011703491) + 0.0561769103435788*std::sin(0.0988800674676895*x_112 - 7.72000026702881) + 0.396878931207584*std::sin(0.188320010900497*x_112 - 7.61392021179199) + 0.0941326678090902*std::sin(0.278399974107742*x_113 + 5.07871961593628) - 0.00471142382941932*std::sin(0.326799839735031*x_113 + 5.14792013168335) - 0.179446074504849*std::sin(0.38919985294342*x_113 + 5.20240020751953) + 0.0884323804336548*std::sin(0.279999971389771*x_114 + 5.07415962219238) - 0.0104547829397467*std::sin(0.176960021257401*x_115 - 7.62800025939941) + 0.0116044559895101*std::sin(0.3852798640728*x_115 + 5.18304014205933) - 0.0198165742140161*std::sin(0.462399870157242*x_115 - 4.15016031265259) + 0.00558949808200932*std::sin(0.704079866409302*x_115 - 0.953199863433838) - 0.0167118622436602*std::sin(0.276959955692291*x_117 - 7.5128002166748) + 0.00175321007830073*std::sin(0.486959844827652*x_117 + 2.04119992256165) + 0.00302652933220487*std::sin(0.493199855089188*x_117 + 8.44624042510986) + 0.00290088539910154*std::sin(0.386239856481552*x_119 - 7.41991996765137) - 0.00562531384284089*std::sin(0.361839860677719*x_120 + 5.16088008880615) - 0.277456061503465*std::sin(0.320879846811295*x_16 + 5.12936019897461) - 0.0017144185193943*std::sin(0.387919843196869*x_16 + 8.37479972839355) - 0.161746762042007*std::sin(0.362959831953049*x_2 + 8.34000015258789) - 0.145122441240863*std::sin(0.341119855642319*x_23 + 8.32808017730713) + 0.285570874003089*std::sin(0.265519946813583*x_24 - 7.50544023513794) - 0.00138990700043927*std::sin(0.429839849472046*x_24 - 4.17072010040283) - 0.163399215988852*std::sin(0.337679862976074*x_28 - 4.26599979400635) - 0.00307593707052577*std::sin(0.346559852361679*x_28 + 5.15136003494263) + 0.060361921694377*std::sin(0.35183984041214*x_28 + 5.15032005310059) - 0.0186797687376479*std::sin(0.649119853973389*x_29 + 5.44807958602905) + 0.334046389586666*std::sin(0.266879975795746*x_3 + 5.08120012283325) + 0.0116419066031293*std::sin(0.277119934558868*x_3 + 5.07439994812012) - 0.346403396404501*std::sin(0.239359974861145*x_32 - 4.39695978164673) - 0.0142873434499704*std::sin(0.244239971041679*x_32 - 1.18919992446899) - 0.00409037328304123*std::sin(0.3642398416996*x_32 + 2.00423979759216) + 0.0152386067439752*std::sin(0.281919926404953*x_33 - 1.16639983654022) - 0.00577048623820834*std::sin(0.298799932003021*x_33 - 1.17119991779327) - 0.0136686135650742*std::sin(0.351039856672287*x_34 + 2.00447988510132) - 0.101417347131654*std::sin(0.363679856061935*x_34 + 1.98031985759735) + 0.0702980379492682*std::sin(0.316559851169586*x_35 - 7.42767953872681) + 0.00470134045275321*std::sin(0.338959842920303*x_36 + 5.13944005966187) - 0.00708258108685683*std::sin(0.348479837179184*x_36 + 5.1482400894165) + 0.0563809085773687*std::sin(0.528879821300507*x_38 + 2.14799976348877) + 0.011235181762018*std::sin(0.138880044221878*x_39 - 7.67199993133545) - 0.0155025571739396*std::sin(0.142080038785934*x_40 + 1.71799993515015) - 0.00254617000615656*std::sin(0.303359925746918*x_41 + 5.1200795173645) + 0.00446544482276894*std::sin(0.383839845657349*x_43 + 8.36983966827393) - 0.013826428047195*std::sin(0.585359811782837*x_45 - 0.991279780864716) - 0.105797331398816*std::sin(0.392799854278564*x_46 - 4.20968008041382) - 0.0069152117117516*std::sin(0.206560000777245*x_48 - 7.60423994064331) - 0.00936990864444409*std::sin(0.346159845590591*x_48 - 7.44863986968994) + 0.0432983406496374*std::sin(0.411759853363037*x_48 - 1.19631993770599) - 0.0242627140335703*std::sin(0.565599858760834*x_49 - 4.01488018035889) + 0.00798718774462372*std::sin(0.331519842147827*x_50 - 7.47583961486816) + 0.0112260308597482*std::sin(0.312879920005798*x_51 - 7.46560001373291) + 0.182877625675677*std::sin(0.328079849481583*x_51 - 7.46679973602295) - 0.0674799869081595*std::sin(0.398239850997925*x_51 + 2.0032799243927) + 0.0405823975640053*std::sin(0.225839987397194*x_53 + 5.02431964874268) - 0.00721250716020386*std::sin(0.245759963989258*x_53 + 5.05375957489014) - 0.0182557723410401*std::sin(0.337839841842651*x_54 + 5.14088010787964) - 0.201830066278531*std::sin(0.233839988708496*x_55 - 4.34647989273071) - 0.00373550513235418*std::sin(0.302159935235977*x_55 + 5.13935995101929) + 0.0116142796037061*std::sin(0.237999975681305*x_56 + 1.84207987785339) - 0.0100278180371134*std::sin(0.348079830408096*x_56 - 4.24767971038818) - 0.00186726146703051*std::sin(0.453039854764938*x_58 - 7.33599948883057) + 0.00605960990168502*std::sin(0.202479988336563*x_59 - 7.59496021270752) + 0.00235984379169875*std::sin(0.434399873018265*x_59 - 4.15543985366821) + 0.00894110366050162*std::sin(0.284879922866821*x_63 - 4.28927946090698) + 0.00638405794535267*std::sin(0.265199959278107*x_64 + 5.0732798576355) + 0.0134334310156051*std::sin(0.549919843673706*x_64 + 8.54447937011719) - 0.132629786958167*std::sin(0.209519997239113*x_66 + 5.01255941390991) + 0.0081404729098108*std::sin(0.185360014438629*x_67 + 4.98880004882813) + 0.00191506173250251*std::sin(0.215919986367226*x_67 - 1.38919985294342) + 0.0124034496628395*std::sin(0.14264003932476*x_70 + 4.91504001617432) + 0.179347030559307*std::sin(0.252799987792969*x_70 + 5.05615997314453) - 0.00263726849397247*std::sin(0.45839986205101*x_70 - 4.14351987838745) + 0.00665042728177056*std::sin(0.265119969844818*x_71 + 5.10031986236572) - 0.00312680495411293*std::sin(0.417279869318008*x_72 - 4.16544008255005) - 0.228199341667444*std::sin(0.241039976477623*x_73 + 5.03599977493286) - 0.0412002513629408*std::sin(0.441279858350754*x_73 + 8.44567966461182) + 0.15478319617056*std::sin(0.286959916353226*x_75 + 5.10399961471558) - 0.000903125634311183*std::sin(0.50631982088089*x_75 + 5.28976011276245) - 0.034907241400335*std::sin(0.201439991593361*x_77 + 5.00008010864258) - 0.224390807300868*std::sin(0.177760004997253*x_78 - 7.61360025405884) + 0.00914450326095474*std::sin(0.305519849061966*x_79 + 5.10823965072632) + 0.0118885800137983*std::sin(0.354479849338531*x_79 + 5.14448022842407) - 0.0295488397873195*std::sin(0.473759859800339*x_79 + 2.05039978027344) + 0.0511258544223561*std::sin(0.389599829912186*x_80 - 4.22240018844604) + 0.00274498887634779*std::sin(0.34639984369278*x_81 + 5.13544034957886) - 0.0125094274750211*std::sin(0.201279997825623*x_83 + 5.00423955917358) - 0.19165984689098*std::sin(0.329919844865799*x_83 - 7.47191953659058) + 0.114902617014703*std::sin(0.262319952249527*x_84 - 7.53927993774414) - 0.00259941263885213*std::sin(0.285919934511185*x_84 - 7.49776029586792) - 0.407995134602451*std::sin(0.207039996981621*x_85 - 7.60423994064331) - 0.0160036651153675*std::sin(0.218719989061356*x_85 + 1.81463992595673) - 0.683194051848998*std::sin(0.239359974861145*x_86 + 5.04375982284546) + 0.00465073694174028*std::sin(0.274719953536987*x_86 + 5.07567977905273) - 0.01046929884863*std::sin(0.263039976358414*x_87 + 5.06744003295898) + 0.0157266734405434*std::sin(0.851599872112274*x_87 - 0.74703985452652) - 0.62993756810619*std::sin(0.136560037732124*x_89 - 7.68688011169434) - 0.0136275025142303*std::sin(0.167120009660721*x_89 + 1.74775993824005) - 0.00842755468707497*std::sin(0.231359988451004*x_89 - 7.56800031661987) + 0.00990170847231244*std::sin(0.257439970970154*x_90 + 5.07199954986572) - 0.0404411810639894*std::sin(0.615919828414917*x_90 + 5.41048002243042) - 0.00486382464257048*std::sin(0.346959829330444*x_92 + 5.19504022598267) - 0.00635006739398418*std::sin(0.362319827079773*x_92 - 7.40927982330322) + 0.0558538202567172*std::sin(0.374959826469421*x_92 + 2.00839972496033) + 0.155207607964528*std::sin(0.2882399559021*x_93 - 1.32551980018616) - 0.117966325702521*std::sin(0.359519839286804*x_94 - 1.19071984291077) - 0.00598203288369908*std::sin(0.384239852428436*x_94 + 2.00543975830078) + 0.00374323751366786*std::sin(0.359839856624603*x_95 - 4.23415994644165) + 0.00516863958536302*std::sin(0.380559861660004*x_95 - 7.42167997360229) + 0.0422491523062048*std::sin(0.38623982667923*x_95 - 4.19471979141235) - 0.0778078760818775*std::sin(0.402799844741821*x_95 + 2.00415992736816) - 0.029112954830393*std::sin(0.378239840269089*x_96 + 8.36672019958496) + 0.00208647615600903*std::sin(0.381439834833145*x_96 - 7.39928007125854) + 0.00917221290827183*std::sin(0.396879822015762*x_96 + 5.18616008758545) + 0.00673256882453459*std::sin(0.417759865522385*x_98 - 7.40039968490601) + 0.0987673814461914*std::sin(0.42223984003067*x_98 - 7.3790397644043) - 0.00457307423570935*std::sin(0.324319928884506*x_99 + 1.9210399389267) - 0.121404019239778*std::sin(0.333199828863144*x_99 + 1.93759977817535) + 0.0048242038564713*std::sin(0.359599858522415*x_99 + 1.94671976566315) - 0.0973997015595596 + 1.96346292576374e-5*std::exp(-2.02751994132996*x_30));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.178362765484069*x_10 - 0.00111351325912677*x_100 + 0.352285475661683*x_101 + 2.19551349314537e-5*x_102 + 0.107735816883943*x_103 - 0.0939800621044364*x_104 + 0.044102227164855*x_105 - 0.00858123265825702*x_106 + 0.0696450982490096*x_107 - 7.35981920048649e-5*x_108 - 0.000482085161725454*x_109 + 0.220518978377741*x_11 + 0.00694245215643645*x_112 - 0.0800372394990488*x_113 - 0.00851648315818117*x_114 + 0.036155154568687*x_116 + 0.00510210647323146*x_117 - 0.00521522386170481*x_118 + 0.042831989679875*x_119 - 0.0835853150673976*x_12 - 0.0371959556818713*x_120 + 0.0411992573274398*x_13 - 0.00284717834130849*x_14 + 0.00109615483223623*x_15 + 0.00247505636530975*x_16 - 0.0510042580062995*x_17 - 0.0948980709055965*x_18 - 0.0998497904836589*x_19 - 0.00258480948775498*x_2 + 0.0505722715774323*x_20 - 0.139573552687781*x_21 - 0.181787868321297*x_22 - 0.0292863695414506*x_23 - 0.185128484124204*x_25 + 0.123714299564263*x_26 + 0.0477226308449453*x_27 - 7.60182966539846e-5*x_28 + 0.0643166244534093*x_29 - 0.258103795078484*x_3 - 0.0790404562293776*x_30 + 0.0145412736038876*x_31 - 0.0118130963353527*x_32 + 0.0518172754029798*x_33 - 0.113093865843034*x_34 + 0.00063968161481951*x_35 + 0.000344265528859169*x_36 + 0.0093955413138792*x_37 - 0.0417299614083538*x_38 - 0.0658457444359815*x_39 - 0.000458872458962418*x_4 - 0.119556801308744*x_40 - 0.001863299911273*x_41 - 0.0607205665508984*x_42 - 0.00832613878797463*x_43 - 0.108036790319285*x_44 - 5.29307966754884e-6*x_45 - 0.0333463496672136*x_46 - 0.054893876784155*x_47 + 0.0215202466444435*x_48 + 0.0169768318519341*x_49 + 0.0109128130694877*x_5 - 0.00369501361312167*x_50 + 0.000469654730399833*x_51 - 0.0535724162660281*x_52 - 0.000406424824851506*x_53 - 0.0435791877784841*x_54 + 0.0125390003769179*x_55 + 0.012832701990857*x_56 + 0.0183470723980387*x_57 + 0.00164124377558702*x_58 + 0.000211581337563052*x_59 - 0.00870962214554096*x_6 + 0.00518650204647608*x_60 - 0.00601130449006084*x_61 + 0.124862549205337*x_62 - 0.0343248093532518*x_63 - 0.000391116955914527*x_64 - 0.00360573416751822*x_65 + 0.0159395165183926*x_66 - 0.0490037925597862*x_67 - 0.00807795791098167*x_68 + 0.122588331544773*x_69 + 0.00256134747475161*x_7 - 0.0135128049182561*x_71 - 0.000529183652414715*x_72 - 1.65212041656172e-5*x_73 - 0.000298435873603884*x_74 + 0.0183540408744867*x_75 + 0.0323821801083359*x_76 + 0.0557988419532038*x_77 - 0.120916723513647*x_78 - 0.00316115419705875*x_79 + 0.0866216456985612*x_8 + 0.0586620892638263*x_80 + 0.000515800141835073*x_81 - 0.0264105764506414*x_82 - 0.09834775384249*x_83 - 0.000303988290180855*x_84 + 0.00519619453971369*x_85 - 0.0174731782810112*x_86 + 0.00201194792939757*x_87 - 0.0574974807637268*x_88 - 0.000820015997011337*x_89 - 0.0674855252305853*x_9 - 0.0342431554267256*x_90 + 0.0383847867270223*x_91 - 0.00465810009233555*x_92 - 0.075571482186964*x_93 - 0.0749148706349883*x_94 + 0.000327457041947938*x_96 - 0.00112590480347736*x_97 - 0.106921001028956*x_98 - 0.0739896068924173*x_99 + 2.04965988563677e-7*std::pow(-6.29120016098022*x_103 - 8.73127937316895, 2) - 1.14312436902766e-5*std::pow(-7.75808048248291*x_110 - 9.38607978820801, 2) - 1.15837448608185e-5*std::pow(-7.40000009536743*x_110 - 9.99830055236816, 2) + 2.14971638420161e-7*std::pow(-7.57424020767212*x_14 - 9.37415981292725, 2) - 0.00104740573456701*std::pow(-7.54568004608154*x_14 - 9.38496017456055, 2) + 4.90604979746638e-6*std::pow(-6.60400009155273*x_14 - 9.96963977813721, 2) + 4.91137263864382e-6*std::pow(-7.48759984970093*x_15 - 9.33039951324463, 2) + 6.08992663924868e-5*std::pow(-6.43415975570679*x_15 - 9.8625602722168, 2) - 0.00256870973874686*std::pow(-6.26032018661499*x_15 - 8.67928028106689, 2) + 2.46246315668284e-5*std::pow(-7.42991971969604*x_17 - 9.8689603805542, 2) - 0.000185531973273376*std::pow(-3.6814398765564*x_17 - 5.03768014907837, 2) - 3.16579473204259e-5*std::pow(-8.16792011260986*x_18 - 9.38511943817139, 2) - 7.51650009761779e-6*std::pow(-5.65367984771729*x_18 - 5.04967975616455, 2) - 5.99028362125032e-5*std::pow(-3.69407987594604*x_24 - 5.24943971633911, 2) - 1.42654760925483e-5*std::pow(-3.49719977378845*x_24 - 4.73023986816406, 2) + 1.27721493343993e-7*std::pow(-8.15824031829834*x_42 - 8.98200035095215, 2) - 0.00296950485232188*std::pow(-3.84272003173828*x_7 - 5.66088008880615, 2) - 0.00114943882848447*std::pow(-5.1224799156189*x_70 - 7.08175992965698, 2) + 2.36424803649849e-7*std::pow(-5.91807985305786*x_73 - 8.91327953338623, 2) + 9.83763007275122e-6*std::pow(-6.00263977050781*x_74 - 7.00984001159668, 2) - 4.16522954863715e-7*std::pow(-6.09375953674316*x_76 - 8.72231960296631, 2) - 3.31886073079851e-5*std::pow(-5.88271999359131*x_77 - 8.51807975769043, 2) + 3.03358084781535e-5*std::pow(-3.11719989776611*x_80 - 4.28687953948975, 2) - 2.66494803608291e-5*std::pow(-7.35264015197754*x_81 - 9.76879978179932, 2) - 9.52092761347252e-7*std::pow(-3.48071980476379*x_87 - 4.91408014297485, 2) + 7.80520114945362e-6*std::pow(-6.8120002746582*x_88 - 6.61999988555908, 2) - 3.04718621614634e-5*std::pow(-6.38272047042847*x_88 - 5.97375965118408, 2) + 3.45298502992808e-5*std::pow(-7.00031995773315*x_90 - 9.3840799331665, 2) - 4.59187856134678e-5*std::pow(-5.30272006988525*x_97 - 6.53128004074097, 2) - 0.000550488548539271*std::exp(0.63487982749939*x_1) + 0.000315983468724026*std::exp(1.13743984699249*x_1) - 0.000558487898195281*std::exp(1.20167994499207*x_1) - 3.49924791750524e-6*std::exp(1.2125598192215*x_1) + 0.020473075948351*std::exp(1.57423985004425*x_100) + 0.000379987586265804*std::exp(1.05679976940155*x_106) - 0.000137235924801861*std::exp(1.3271199464798*x_106) + 0.139446765159321*std::exp(0.543039858341217*x_109) + 0.00399966952878517*std::exp(0.620559811592102*x_109) - 2.62593353666117e-5*std::exp(0.843999862670898*x_110) - 0.000885718249994256*std::exp(0.924159824848175*x_110) + 0.0115949674127515*std::exp(1.28303980827332*x_110) + 9.88820429773496e-5*std::exp(1.38351988792419*x_26) - 0.00258720449114137*std::exp(0.582799851894379*x_31) + 0.00197177457996869*std::exp(0.667519807815552*x_31) - 0.0659358994850135*std::exp(0.899439811706543*x_50) - 1.81328153476583e-5*std::exp(0.815839886665344*x_6) + 0.00129138097314046*std::exp(0.835679888725281*x_66) + 0.000380354455404855*std::exp(0.971119821071625*x_68) - 8.01149563594732e-6*std::exp(1.1723198890686*x_68) + 0.00119127312831306*std::exp(0.692079842090607*x_70) + 0.0453872236468382*std::exp(1.00575983524323*x_72) - 8.72805350413804e-5*std::exp(0.620319843292236*x_74) - 0.00412471835276209*std::exp(0.827759861946106*x_74) - 0.0244411553152622*std::exp(0.888719916343689*x_74) - 3.83362434802156e-6*std::exp(0.861039876937866*x_81) + 0.00584157927519339*std::exp(1.83999991416931*x_81) - 0.593764999704917*std::sin(0.355119854211807*x_1 - 1.1522399187088) - 0.00451222230047325*std::sin(0.397199839353561*x_10 - 4.18671989440918) - 0.012225651251668*std::sin(0.472399860620499*x_100 - 4.15240001678467) - 0.000330924304099865*std::sin(0.32711985707283*x_101 + 1.96655988693237) - 0.0194724372272758*std::sin(0.362559854984283*x_102 - 7.41928005218506) - 0.000447924930485683*std::sin(0.362959831953049*x_102 - 7.41296005249023) - 0.00741310526709515*std::sin(0.367999851703644*x_102 - 4.21712017059326) + 0.613264813527266*std::sin(0.371519833803177*x_102 + 1.98631989955902) - 0.00945538691034642*std::sin(0.378719836473465*x_105 - 7.40032005310059) + 0.000218514958247846*std::sin(0.407439857721329*x_105 + 5.21447992324829) + 0.0235166712885737*std::sin(0.409599840641022*x_105 + 5.19664001464844) - 0.000126231907552156*std::sin(0.579839885234833*x_106 - 7.20016002655029) - 0.000151123759890383*std::sin(0.37679985165596*x_107 + 5.16760015487671) + 0.0207156878486866*std::sin(0.422799855470657*x_108 + 5.2085599899292) + 0.308817055468271*std::sin(0.571119844913483*x_108 + 5.39264011383057) - 0.0179392298968903*std::sin(0.328239858150482*x_111 - 7.45631980895996) - 0.000308597236694991*std::sin(0.346959829330444*x_111 - 7.44280004501343) - 0.739954559702456*std::sin(0.379759848117828*x_111 - 4.20928001403809) - 0.0170753558996235*std::sin(0.413439869880676*x_111 - 4.19479990005493) + 0.0044204043268734*std::sin(0.415359854698181*x_111 + 5.20128011703491) + 0.00254456810538565*std::sin(0.0988800674676895*x_112 - 7.72000026702881) - 0.0593875297756353*std::sin(0.188320010900497*x_112 - 7.61392021179199) - 0.243994527320846*std::sin(0.484159857034683*x_112 - 7.34711980819702) - 0.0140856724123972*std::sin(0.278399974107742*x_113 + 5.07871961593628) - 0.000213406873642075*std::sin(0.326799839735031*x_113 + 5.14792013168335) + 0.0433394490931002*std::sin(0.38919985294342*x_113 + 5.20240020751953) - 0.0213580077500246*std::sin(0.279999971389771*x_114 + 5.07415962219238) - 5.72916172959435*std::sin(0.114000059664249*x_115 - 7.71016025543213) + 0.0148283620906907*std::sin(0.176960021257401*x_115 - 7.62800025939941) + 0.000525631053944816*std::sin(0.3852798640728*x_115 + 5.18304014205933) + 0.00478605849538818*std::sin(0.462399870157242*x_115 - 4.15016031265259) - 0.000836392304237897*std::sin(0.704079866409302*x_115 - 0.953199863433838) + 0.00250070270442897*std::sin(0.276959955692291*x_117 - 7.5128002166748) + 7.94127412846343e-5*std::sin(0.486959844827652*x_117 + 2.04119992256165) - 0.00429262597556304*std::sin(0.493199855089188*x_117 + 8.44624042510986) - 0.401846676731471*std::sin(0.541919827461243*x_117 + 2.14631986618042) + 0.157272129277056*std::sin(0.50111985206604*x_118 - 0.914959847927094) + 0.000131397408985068*std::sin(0.386239856481552*x_119 - 7.41991996765137) - 0.000254802090391456*std::sin(0.361839860677719*x_120 + 5.16088008880615) + 0.0670106208022767*std::sin(0.320879846811295*x_16 + 5.12936019897461) - 7.76556534891717e-5*std::sin(0.387919843196869*x_16 + 8.37479972839355) + 0.363516638533674*std::sin(0.428879857063293*x_16 + 2.01399970054626) + 0.039064747327777*std::sin(0.362959831953049*x_2 + 8.34000015258789) + 0.035049675351103*std::sin(0.341119855642319*x_23 + 8.32808017730713) - 0.0427317941300397*std::sin(0.265519946813583*x_24 - 7.50544023513794) - 0.592047928157916*std::sin(0.337759852409363*x_24 - 4.27648019790649) - 6.2956702338014e-5*std::sin(0.429839849472046*x_24 - 4.17072010040283) - 1.03071619909014*std::sin(0.335119843482971*x_28 - 4.26039981842041) + 0.024450468497603*std::sin(0.337679862976074*x_28 - 4.26599979400635) - 0.000139326483353456*std::sin(0.346559852361679*x_28 + 5.15136003494263) - 0.0145784879365776*std::sin(0.35183984041214*x_28 + 5.15032005310059) + 0.00279517312429169*std::sin(0.649119853973389*x_29 + 5.44807958602905) - 0.0499854951928537*std::sin(0.266879975795746*x_3 + 5.08120012283325) + 0.000527327402789203*std::sin(0.277119934558868*x_3 + 5.07439994812012) - 0.711136904353987*std::sin(0.262719959020615*x_31 - 1.11887979507446) + 0.0518345530607002*std::sin(0.239359974861145*x_32 - 4.39695978164673) - 0.000647154110668185*std::sin(0.244239971041679*x_32 - 1.18919992446899) + 0.00580151079908429*std::sin(0.3642398416996*x_32 + 2.00423979759216) - 0.0216134165443304*std::sin(0.281919926404953*x_33 - 1.16639983654022) - 0.000261377764360978*std::sin(0.298799932003021*x_33 - 1.17119991779327) + 0.0193866436432737*std::sin(0.351039856672287*x_34 + 2.00447988510132) + 0.0151757255146326*std::sin(0.363679856061935*x_34 + 1.98031985759735) + 0.907633119374923*std::sin(0.312479853630066*x_35 - 7.4268798828125) - 0.0169782384231805*std::sin(0.316559851169586*x_35 - 7.42767953872681) - 0.0066680656066041*std::sin(0.338959842920303*x_36 + 5.13944005966187) - 0.000320809916871541*std::sin(0.348479837179184*x_36 + 5.1482400894165) - 0.0136170017864926*std::sin(0.528879821300507*x_38 + 2.14799976348877) + 0.000508904548060632*std::sin(0.138880044221878*x_39 - 7.67199993133545) - 1.44860623238702*std::sin(0.450239837169647*x_4 + 5.25072002410889) + 0.0219877861101131*std::sin(0.142080038785934*x_40 + 1.71799993515015) - 0.000115330354569706*std::sin(0.303359925746918*x_41 + 5.1200795173645) + 0.000202265101496029*std::sin(0.383839845657349*x_43 + 8.36983966827393) - 0.751757369604042*std::sin(0.403679847717285*x_45 + 5.20216035842896) + 0.00333933063815574*std::sin(0.585359811782837*x_45 - 0.991279780864716) + 0.0158311305402696*std::sin(0.392799854278564*x_46 - 4.20968008041382) - 0.000313228816894586*std::sin(0.206560000777245*x_48 - 7.60423994064331) + 0.0132896492387508*std::sin(0.346159845590591*x_48 - 7.44863986968994) - 0.00647900730517994*std::sin(0.411759853363037*x_48 - 1.19631993770599) + 0.00585988109586623*std::sin(0.565599858760834*x_49 - 4.01488018035889) + 0.000361784638250753*std::sin(0.331519842147827*x_50 - 7.47583961486816) + 0.000508490052248936*std::sin(0.312879920005798*x_51 - 7.46560001373291) - 0.0273651473689119*std::sin(0.328079849481583*x_51 - 7.46679973602295) + 0.0162976284963549*std::sin(0.398239850997925*x_51 + 2.0032799243927) - 0.00980137770165397*std::sin(0.225839987397194*x_53 + 5.02431964874268) + 0.01022973584144*std::sin(0.245759963989258*x_53 + 5.05375957489014) - 0.968429800625392*std::sin(0.365519851446152*x_53 + 5.17160034179688) - 0.000826906566311398*std::sin(0.337839841842651*x_54 + 5.14088010787964) + 0.0302011221262472*std::sin(0.233839988708496*x_55 - 4.34647989273071) + 0.00529818964328716*std::sin(0.302159935235977*x_55 + 5.13935995101929) - 0.0164729142994957*std::sin(0.237999975681305*x_56 + 1.84207987785339) - 0.000454216256960209*std::sin(0.348079830408096*x_56 - 4.24767971038818) - 4.63235598246334*std::sin(0.219359993934631*x_58 + 5.00799989700317) + 0.00264839827959102*std::sin(0.453039854764938*x_58 - 7.33599948883057) + 0.000274473800581117*std::sin(0.202479988336563*x_59 - 7.59496021270752) + 1.10249355485839*std::sin(0.252719968557358*x_59 - 7.53144025802612) - 0.00334704397235676*std::sin(0.434399873018265*x_59 - 4.15543985366821) + 0.000404992853154656*std::sin(0.284879922866821*x_63 - 4.28927946090698) - 1.12457246464618*std::sin(0.218400001525879*x_64 - 4.37687969207764) - 0.00905471910485535*std::sin(0.265199959278107*x_64 + 5.0732798576355) - 0.00324441479844553*std::sin(0.549919843673706*x_64 + 8.54447937011719) + 0.0320324750260664*std::sin(0.209519997239113*x_66 + 5.01255941390991) + 0.000368727785176746*std::sin(0.185360014438629*x_67 + 4.98880004882813) - 0.00271619496638355*std::sin(0.215919986367226*x_67 - 1.38919985294342) + 0.000561821969485109*std::sin(0.14264003932476*x_70 + 4.91504001617432) - 0.0433155282018372*std::sin(0.252799987792969*x_70 + 5.05615997314453) + 0.00374052454119547*std::sin(0.45839986205101*x_70 - 4.14351987838745) - 0.00943251948512391*std::sin(0.265119969844818*x_71 + 5.10031986236572) + 0.00443485018424259*std::sin(0.417279869318008*x_72 - 4.16544008255005) - 1.13596282456258*std::sin(0.22639998793602*x_73 - 4.35999965667725) + 0.0551142385174212*std::sin(0.241039976477623*x_73 + 5.03599977493286) + 0.00616505680242456*std::sin(0.441279858350754*x_73 + 8.44567966461182) - 0.037382921133335*std::sin(0.286959916353226*x_75 + 5.10399961471558) - 4.09076375003435e-5*std::sin(0.50631982088089*x_75 + 5.28976011276245) - 0.00158114521733292*std::sin(0.201439991593361*x_77 + 5.00008010864258) + 0.0541944090825618*std::sin(0.177760004997253*x_78 - 7.61360025405884) + 0.000414205964605531*std::sin(0.305519849061966*x_79 + 5.10823965072632) - 0.0168619635820981*std::sin(0.354479849338531*x_79 + 5.14448022842407) - 0.479941211521913*std::sin(0.429439842700958*x_79 - 1.17511987686157) + 0.00442158165807765*std::sin(0.473759859800339*x_79 + 2.05039978027344) - 0.0123478118492867*std::sin(0.389599829912186*x_80 - 4.22240018844604) - 0.00389330789821155*std::sin(0.34639984369278*x_81 + 5.13544034957886) - 0.000566622300423682*std::sin(0.201279997825623*x_83 + 5.00423955917358) + 0.0462892944325653*std::sin(0.329919844865799*x_83 - 7.47191953659058) - 0.0277510451789691*std::sin(0.262319952249527*x_84 - 7.53927993774414) + 0.828511178648678*std::sin(0.274719953536987*x_84 - 7.52063989639282) + 0.00368683233828583*std::sin(0.285919934511185*x_84 - 7.49776029586792) - 1.16499835566128*std::sin(0.181760013103485*x_85 + 4.96687984466553) + 0.061050918300937*std::sin(0.207039996981621*x_85 - 7.60423994064331) - 0.000724895968339627*std::sin(0.218719989061356*x_85 + 1.81463992595673) + 0.165003630826254*std::sin(0.239359974861145*x_86 + 5.04375982284546) + 0.000210658023307325*std::sin(0.274719953536987*x_86 + 5.07567977905273) + 0.0148489504811181*std::sin(0.263039976358414*x_87 + 5.06744003295898) - 0.248632450390757*std::sin(0.369199842214584*x_87 + 5.17087984085083) - 0.0023532826103421*std::sin(0.851599872112274*x_87 - 0.74703985452652) + 2.95184411799828*std::sin(0.135120034217834*x_89 + 4.91599988937378) + 0.152141233738896*std::sin(0.136560037732124*x_89 - 7.68688011169434) - 0.000617266204953129*std::sin(0.167120009660721*x_89 + 1.74775993824005) + 0.0119530776639991*std::sin(0.231359988451004*x_89 - 7.56800031661987) + 0.000448504045761445*std::sin(0.257439970970154*x_90 + 5.07199954986572) + 0.00605147226458171*std::sin(0.615919828414917*x_90 + 5.41048002243042) + 0.00689852227074614*std::sin(0.346959829330444*x_92 + 5.19504022598267) - 0.000287630253407634*std::sin(0.362319827079773*x_92 - 7.40927982330322) - 0.00835776392434357*std::sin(0.374959826469421*x_92 + 2.00839972496033) - 0.0232247058601794*std::sin(0.2882399559021*x_93 - 1.32551980018616) + 0.0284909858384577*std::sin(0.359519839286804*x_94 - 1.19071984291077) - 0.000270959901285648*std::sin(0.384239852428436*x_94 + 2.00543975830078) + 0.000169552272097339*std::sin(0.359839856624603*x_95 - 4.23415994644165) - 0.00733085131750207*std::sin(0.380559861660004*x_95 - 7.42167997360229) - 0.0102039288998318*std::sin(0.38623982667923*x_95 - 4.19471979141235) - 0.238805793290829*std::sin(0.399759858846664*x_95 + 5.18351984024048) + 0.0116428895419862*std::sin(0.402799844741821*x_95 + 2.00415992736816) - 0.223902384372392*std::sin(0.377199828624725*x_96 - 7.40903997421265) + 0.00435635740749962*std::sin(0.378239840269089*x_96 + 8.36672019958496) + 9.45082356213114e-5*std::sin(0.381439834833145*x_96 - 7.39928007125854) - 0.0130092508816885*std::sin(0.396879822015762*x_96 + 5.18616008758545) + 0.094006524126687*std::sin(0.315919935703278*x_97 + 5.12328004837036) - 0.00954902353363573*std::sin(0.417759865522385*x_98 - 7.40039968490601) - 0.023854096067899*std::sin(0.42223984003067*x_98 - 7.3790397644043) - 0.000207140242718545*std::sin(0.324319928884506*x_99 + 1.9210399389267) + 0.0293212505542882*std::sin(0.333199828863144*x_99 + 1.93759977817535) - 0.00684232680824993*std::sin(0.359599858522415*x_99 + 1.94671976566315) - 6.11725754868526 - 2.93805500363437e-6*std::exp(-2.02751994132996*x_30));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0599620347975293*x_10 + 0.00441538318338986*x_100 - 0.127169080553425*x_101 + 4.30593985572398e-5*x_102 - 0.0411463993244173*x_103 + 0.034872935024332*x_104 - 0.0150394582179096*x_105 - 0.0012731843928632*x_106 - 0.0255902975433211*x_107 + 0.00542772398988259*x_108 - 0.00139055953384729*x_109 - 0.0942996481147348*x_11 - 0.00857411213685719*x_112 + 0.0301740226840227*x_113 + 0.00681302494591557*x_114 - 0.0198429433865037*x_116 - 0.00727473172972169*x_117 + 0.0216203813484325*x_118 - 0.0157052652693693*x_119 + 0.062042478680484*x_12 + 0.0157074399754619*x_120 - 0.0307178201777436*x_13 + 0.00088111856321895*x_14 - 0.00481126189056581*x_15 - 0.0140770195956339*x_16 + 0.0194995633833021*x_17 + 0.0385493501098229*x_18 + 0.0360089485032653*x_19 + 0.0140243001228393*x_2 - 0.0136010101502119*x_20 + 0.0540670071359103*x_21 + 0.0869204594073007*x_22 + 0.0138624675562481*x_23 + 0.0890832278575314*x_25 - 0.0319995272903668*x_26 - 0.0183723210471299*x_27 - 0.000149090504043178*x_28 - 0.0174574477600018*x_29 + 0.09274460455517*x_3 + 0.0354366692924033*x_30 - 0.0621428500095543*x_31 - 0.00200137130952481*x_32 - 0.0217808223185279*x_33 + 0.0447752255335269*x_34 - 0.000375227651098381*x_35 + 0.00392270435167516*x_36 + 0.0113070792713014*x_37 + 0.0185701360958209*x_38 + 0.0259475910532135*x_39 + 0.0129373168653733*x_4 + 0.056083265106087*x_40 + 0.00725236774016457*x_41 + 0.0170460314121297*x_42 + 0.00511446599591942*x_43 + 0.0600973113736581*x_44 + 0.00258561331292867*x_45 + 0.0118201120327628*x_46 + 0.0204722949791835*x_47 - 0.0108663644954187*x_48 - 0.00170333664658382*x_49 - 0.0102906792317442*x_5 + 0.0112912577345113*x_50 - 0.000469355930260316*x_51 + 0.0228167366527244*x_52 + 0.0017033957799643*x_53 + 0.0247443914020023*x_54 - 0.00380469685863573*x_55 - 0.00417524422079103*x_56 - 0.00103767451773779*x_57 - 0.002638383299935*x_58 - 0.00437520176975552*x_59 - 0.00552639908322557*x_6 + 0.00435296990895804*x_60 + 0.0125946355059351*x_61 - 0.0613980369349455*x_62 + 0.00563587192121751*x_63 + 0.00157932636538484*x_64 + 0.00569912618438625*x_65 - 0.0118411563367551*x_66 + 0.0224232421787991*x_67 - 0.00221511943570171*x_68 - 0.0422371778796504*x_69 - 0.00648190171226273*x_7 + 0.00954266278332155*x_71 + 0.000560611991758425*x_72 - 3.24021290251181e-5*x_73 + 0.00126863126348719*x_74 + 0.00115565313690809*x_75 - 0.00857592669604914*x_76 - 0.0160917750589156*x_77 + 0.0460924058341948*x_78 + 0.00450726555012897*x_79 - 0.0336228630326417*x_8 - 0.023362468287139*x_80 - 0.00219263246653664*x_81 + 0.0111212272435812*x_82 + 0.0441330309047683*x_83 + 0.00166679597957657*x_84 - 0.00596434834524662*x_85 + 0.00919657127690143*x_86 - 0.00286869384583153*x_87 + 0.0164993972762513*x_88 + 0.0034858340514016*x_89 + 0.00639746907569168*x_9 + 0.0156708750614531*x_90 - 0.0149958357717724*x_91 + 0.00142496149758628*x_92 + 0.00888438392667124*x_93 + 0.0333409548035219*x_94 - 0.000466897769710931*x_96 + 0.00155199635685367*x_97 + 0.0430249734014432*x_98 + 0.0238485841652948*x_99 + 2.43994447201404e-6*std::pow(-6.29120016098022*x_103 - 8.73127937316895, 2) + 4.85934648234488e-5*std::pow(-7.75808048248291*x_110 - 9.38607978820801, 2) + 1.65164401664523e-5*std::pow(-7.40000009536743*x_110 - 9.99830055236816, 2) + 2.55905316037406e-6*std::pow(-7.57424020767212*x_14 - 9.37415981292725, 2) + 0.000392771544282397*std::pow(-7.54568004608154*x_14 - 9.38496017456055, 2) + 9.62196562354641e-6*std::pow(-6.60400009155273*x_14 - 9.96963977813721, 2) + 9.632405019179e-6*std::pow(-7.48759984970093*x_15 - 9.33039951324463, 2) - 8.6831944387394e-5*std::pow(-6.43415975570679*x_15 - 9.8625602722168, 2) + 0.000963252403155793*std::pow(-6.26032018661499*x_15 - 8.67928028106689, 2) - 0.000104677688644753*std::pow(-7.42991971969604*x_17 - 9.8689603805542, 2) + 0.000264536880978665*std::pow(-3.6814398765564*x_17 - 5.03768014907837, 2) + 4.51388215981105e-5*std::pow(-8.16792011260986*x_18 - 9.38511943817139, 2) - 1.47416982163555e-5*std::pow(-5.65367984771729*x_18 - 5.04967975616455, 2) + 8.54112052701666e-5*std::pow(-3.69407987594604*x_24 - 5.24943971633911, 2) - 2.79780936257329e-5*std::pow(-3.49719977378845*x_24 - 4.73023986816406, 2) + 1.52041494213679e-6*std::pow(-8.15824031829834*x_42 - 8.98200035095215, 2) + 0.00111354842551314*std::pow(-3.84272003173828*x_7 - 5.66088008880615, 2) + 0.00043103340837505*std::pow(-5.1224799156189*x_70 - 7.08175992965698, 2) + 2.81443471063121e-6*std::pow(-5.91807985305786*x_73 - 8.91327953338623, 2) + 1.92940027690021e-5*std::pow(-6.00263977050781*x_74 - 7.00984001159668, 2) - 4.95834888660535e-6*std::pow(-6.09375953674316*x_76 - 8.72231960296631, 2) + 4.73212811052442e-5*std::pow(-5.88271999359131*x_77 - 8.51807975769043, 2) + 5.9495952627717e-5*std::pow(-3.11719989776611*x_80 - 4.28687953948975, 2) + 3.79976038090657e-5*std::pow(-7.35264015197754*x_81 - 9.76879978179932, 2) - 1.13338485383496e-5*std::pow(-3.48071980476379*x_87 - 4.91408014297485, 2) + 1.53079117100874e-5*std::pow(-6.8120002746582*x_88 - 6.61999988555908, 2) + 4.34476668985123e-5*std::pow(-6.38272047042847*x_88 - 5.97375965118408, 2) - 4.92336643526808e-5*std::pow(-7.00031995773315*x_90 - 9.3840799331665, 2) + 6.54723394043579e-5*std::pow(-5.30272006988525*x_97 - 6.53128004074097, 2) + 0.00234009060115726*std::exp(0.63487982749939*x_1) - 0.00045053841546711*std::exp(1.13743984699249*x_1) - 0.00109533159658853*std::exp(1.20167994499207*x_1) - 4.16555481831613e-5*std::exp(1.2125598192215*x_1) - 0.00767729389964509*std::exp(1.57423985004425*x_100) + 0.000745248752736288*std::exp(1.05679976940155*x_106) + 0.000583380887072257*std::exp(1.3271199464798*x_106) - 0.0522917905537845*std::exp(0.543039858341217*x_109) - 0.0170023320137741*std::exp(0.620559811592102*x_109) - 0.000312594887647039*std::exp(0.843999862670898*x_110) - 0.00173711048713643*std::exp(0.924159824848175*x_110) - 0.00434805071837144*std::exp(1.28303980827332*x_110) - 0.000140988891415947*std::exp(1.38351988792419*x_26) + 0.00368891137449431*std::exp(0.582799851894379*x_31) + 0.00386713303147458*std::exp(0.667519807815552*x_31) + 0.0247256093886898*std::exp(0.899439811706543*x_50) - 0.000215855629900398*std::exp(0.815839886665344*x_6) + 0.00253271447364361*std::exp(0.835679888725281*x_66) + 0.000745968273000047*std::exp(0.971119821071625*x_68) - 9.53699910237613e-5*std::exp(1.1723198890686*x_68) - 0.00506402369018168*std::exp(0.692079842090607*x_70) - 0.0170199659350047*std::exp(1.00575983524323*x_72) - 0.00103899998473397*std::exp(0.620319843292236*x_74) + 0.00588114333450965*std::exp(0.827759861946106*x_74) + 0.00916530242331535*std::exp(0.888719916343689*x_74) - 4.56360130833494e-5*std::exp(0.861039876937866*x_81) - 0.00219056096147328*std::exp(1.83999991416931*x_81) + 0.222658696795607*std::sin(0.355119854211807*x_1 - 1.1522399187088) + 0.0191811601234724*std::sin(0.397199839353561*x_10 - 4.18671989440918) + 0.0174316889589902*std::sin(0.472399860620499*x_100 - 4.15240001678467) - 0.00393937029309968*std::sin(0.32711985707283*x_101 + 1.96655988693237) + 0.0277643670698541*std::sin(0.362559854984283*x_102 - 7.41928005218506) - 0.00533216250010317*std::sin(0.362959831953049*x_102 - 7.41296005249023) + 0.0315126227547334*std::sin(0.367999851703644*x_102 - 4.21712017059326) - 0.229971022607332*std::sin(0.371519833803177*x_102 + 1.98631989955902) - 0.0185443302788464*std::sin(0.378719836473465*x_105 - 7.40032005310059) + 0.0026012333468856*std::sin(0.407439857721329*x_105 + 5.21447992324829) - 0.033530753561885*std::sin(0.409599840641022*x_105 + 5.19664001464844) - 0.00150268269961279*std::sin(0.579839885234833*x_106 - 7.20016002655029) - 0.00179899887351292*std::sin(0.37679985165596*x_107 + 5.16760015487671) - 0.029537029947633*std::sin(0.422799855470657*x_108 + 5.2085599899292) - 0.115804742874696*std::sin(0.571119844913483*x_108 + 5.39264011383057) + 0.0762584860032155*std::sin(0.328239858150482*x_111 - 7.45631980895996) - 0.00367358568623608*std::sin(0.346959829330444*x_111 - 7.44280004501343) + 0.277478999323294*std::sin(0.379759848117828*x_111 - 4.20928001403809) + 0.0243465388288156*std::sin(0.413439869880676*x_111 - 4.19479990005493) + 0.00866949587371023*std::sin(0.415359854698181*x_111 + 5.20128011703491) + 0.0302909030220402*std::sin(0.0988800674676895*x_112 - 7.72000026702881) + 0.252452481750394*std::sin(0.188320010900497*x_112 - 7.61392021179199) + 0.0914966417783446*std::sin(0.484159857034683*x_112 - 7.34711980819702) + 0.0598772666764735*std::sin(0.278399974107742*x_113 + 5.07871961593628) - 0.00254042597643468*std::sin(0.326799839735031*x_113 + 5.14792013168335) - 0.0617946464113178*std::sin(0.38919985294342*x_113 + 5.20240020751953) + 0.0304528683354463*std::sin(0.279999971389771*x_114 + 5.07415962219238) + 2.14840498358223*std::sin(0.114000059664249*x_115 - 7.71016025543213) + 0.0290820509738419*std::sin(0.176960021257401*x_115 - 7.62800025939941) + 0.00625718731863227*std::sin(0.3852798640728*x_115 + 5.18304014205933) - 0.00682410133527704*std::sin(0.462399870157242*x_115 - 4.15016031265259) + 0.00355544865596372*std::sin(0.704079866409302*x_115 - 0.953199863433838) - 0.0106303226660224*std::sin(0.276959955692291*x_117 - 7.5128002166748) + 0.000945340641453437*std::sin(0.486959844827652*x_117 + 2.04119992256165) - 0.00841889122139368*std::sin(0.493199855089188*x_117 + 8.44624042510986) + 0.150690352912585*std::sin(0.541919827461243*x_117 + 2.14631986618042) - 0.0589762066886773*std::sin(0.50111985206604*x_118 - 0.914959847927094) + 0.00156417356819413*std::sin(0.386239856481552*x_119 - 7.41991996765137) - 0.00303320056300516*std::sin(0.361839860677719*x_120 + 5.16088008880615) - 0.0955456911642846*std::sin(0.320879846811295*x_16 + 5.12936019897461) - 0.000924424016781093*std::sin(0.387919843196869*x_16 + 8.37479972839355) - 0.136316793747783*std::sin(0.428879857063293*x_16 + 2.01399970054626) - 0.0556996523671033*std::sin(0.362959831953049*x_2 + 8.34000015258789) - 0.0499748460230822*std::sin(0.341119855642319*x_23 + 8.32808017730713) + 0.181650045363586*std::sin(0.265519946813583*x_24 - 7.50544023513794) + 0.222014804156011*std::sin(0.337759852409363*x_24 - 4.27648019790649) - 0.000749445597888296*std::sin(0.429839849472046*x_24 - 4.17072010040283) + 0.386513057808368*std::sin(0.335119843482971*x_28 - 4.26039981842041) - 0.10393733289631*std::sin(0.337679862976074*x_28 - 4.26599979400635) - 0.00165856240464895*std::sin(0.346559852361679*x_28 + 5.15136003494263) + 0.0207864319021974*std::sin(0.35183984041214*x_28 + 5.15032005310059) - 0.0118820970465578*std::sin(0.649119853973389*x_29 + 5.44807958602905) + 0.212485051333714*std::sin(0.266879975795746*x_3 + 5.08120012283325) + 0.00627738089813526*std::sin(0.277119934558868*x_3 + 5.07439994812012) + 0.266672532812496*std::sin(0.262719959020615*x_31 - 1.11887979507446) - 0.220345274673555*std::sin(0.239359974861145*x_32 - 4.39695978164673) - 0.00770381518383203*std::sin(0.244239971041679*x_32 - 1.18919992446899) + 0.0113781840335682*std::sin(0.3642398416996*x_32 + 2.00423979759216) - 0.0423892050798862*std::sin(0.281919926404953*x_33 - 1.16639983654022) - 0.00311147832735101*std::sin(0.298799932003021*x_33 - 1.17119991779327) + 0.0380219578667662*std::sin(0.351039856672287*x_34 + 2.00447988510132) - 0.0645110106954401*std::sin(0.363679856061935*x_34 + 1.98031985759735) - 0.340357561710417*std::sin(0.312479853630066*x_35 - 7.4268798828125) + 0.024208065907661*std::sin(0.316559851169586*x_35 - 7.42767953872681) - 0.0130777103150137*std::sin(0.338959842920303*x_36 + 5.13944005966187) - 0.00381896717949777*std::sin(0.348479837179184*x_36 + 5.1482400894165) + 0.0194155169986357*std::sin(0.528879821300507*x_38 + 2.14799976348877) + 0.0060580725979207*std::sin(0.138880044221878*x_39 - 7.67199993133545) + 0.543219583561819*std::sin(0.450239837169647*x_4 + 5.25072002410889) + 0.0431234355180533*std::sin(0.142080038785934*x_40 + 1.71799993515015) - 0.00137290905217844*std::sin(0.303359925746918*x_41 + 5.1200795173645) + 0.00240779272568567*std::sin(0.383839845657349*x_43 + 8.36983966827393) + 0.281904989862513*std::sin(0.403679847717285*x_45 + 5.20216035842896) - 0.00476131469950241*std::sin(0.585359811782837*x_45 - 0.991279780864716) - 0.0672970943378957*std::sin(0.392799854278564*x_46 - 4.20968008041382) - 0.00372872068001666*std::sin(0.206560000777245*x_48 - 7.60423994064331) + 0.0260642580901415*std::sin(0.346159845590591*x_48 - 7.44863986968994) + 0.027541833776401*std::sin(0.411759853363037*x_48 - 1.19631993770599) - 0.0083551888154727*std::sin(0.565599858760834*x_49 - 4.01488018035889) + 0.00430673612898114*std::sin(0.331519842147827*x_50 - 7.47583961486816) + 0.00605313838043659*std::sin(0.312879920005798*x_51 - 7.46560001373291) + 0.116327441010711*std::sin(0.328079849481583*x_51 - 7.46679973602295) - 0.023237632488402*std::sin(0.398239850997925*x_51 + 2.0032799243927) + 0.01397508925682*std::sin(0.225839987397194*x_53 + 5.02431964874268) + 0.0200630182463961*std::sin(0.245759963989258*x_53 + 5.05375957489014) + 0.363155991768529*std::sin(0.365519851446152*x_53 + 5.17160034179688) - 0.00984361415024128*std::sin(0.337839841842651*x_54 + 5.14088010787964) - 0.128382983114847*std::sin(0.233839988708496*x_55 - 4.34647989273071) + 0.0103910479345451*std::sin(0.302159935235977*x_55 + 5.13935995101929) - 0.0323074207667498*std::sin(0.237999975681305*x_56 + 1.84207987785339) - 0.0054070553511597*std::sin(0.348079830408096*x_56 - 4.24767971038818) + 1.73710869899912*std::sin(0.219359993934631*x_58 + 5.00799989700317) + 0.00519415787765633*std::sin(0.453039854764938*x_58 - 7.33599948883057) + 0.00326737541742211*std::sin(0.202479988336563*x_59 - 7.59496021270752) - 0.413429182037204*std::sin(0.252719968557358*x_59 - 7.53144025802612) - 0.00656437324772907*std::sin(0.434399873018265*x_59 - 4.15543985366821) + 0.00482109290514266*std::sin(0.284879922866821*x_63 - 4.28927946090698) + 0.421708655031505*std::sin(0.218400001525879*x_64 - 4.37687969207764) - 0.017758522549604*std::sin(0.265199959278107*x_64 + 5.0732798576355) + 0.00462598093600379*std::sin(0.549919843673706*x_64 + 8.54447937011719) - 0.0456728340884766*std::sin(0.209519997239113*x_66 + 5.01255941390991) + 0.00438938834401044*std::sin(0.185360014438629*x_67 + 4.98880004882813) - 0.00532712379048603*std::sin(0.215919986367226*x_67 - 1.38919985294342) + 0.00668800915853099*std::sin(0.14264003932476*x_70 + 4.91504001617432) + 0.0617605393091656*std::sin(0.252799987792969*x_70 + 5.05615997314453) + 0.00733608504503998*std::sin(0.45839986205101*x_70 - 4.14351987838745) - 0.0184994816555194*std::sin(0.265119969844818*x_71 + 5.10031986236572) + 0.00869782773921244*std::sin(0.417279869318008*x_72 - 4.16544008255005) + 0.425979979033896*std::sin(0.22639998793602*x_73 - 4.35999965667725) - 0.0785834834701506*std::sin(0.241039976477623*x_73 + 5.03599977493286) - 0.0262072508451558*std::sin(0.441279858350754*x_73 + 8.44567966461182) + 0.0533016556877366*std::sin(0.286959916353226*x_75 + 5.10399961471558) - 0.000486970373385184*std::sin(0.50631982088089*x_75 + 5.28976011276245) - 0.0188221790333002*std::sin(0.201439991593361*x_77 + 5.00008010864258) - 0.0772719639221343*std::sin(0.177760004997253*x_78 - 7.61360025405884) + 0.0049307671028578*std::sin(0.305519849061966*x_79 + 5.10823965072632) - 0.0330704417260965*std::sin(0.354479849338531*x_79 + 5.14448022842407) + 0.1799753854624*std::sin(0.429439842700958*x_79 - 1.17511987686157) - 0.0187958527162327*std::sin(0.473759859800339*x_79 + 2.05039978027344) + 0.0176058690903302*std::sin(0.389599829912186*x_80 - 4.22240018844604) - 0.00763573063971329*std::sin(0.34639984369278*x_81 + 5.13544034957886) - 0.00674515298526775*std::sin(0.201279997825623*x_83 + 5.00423955917358) - 0.0660006216494604*std::sin(0.329919844865799*x_83 - 7.47191953659058) + 0.0395682469496807*std::sin(0.262319952249527*x_84 - 7.53927993774414) - 0.310687257433809*std::sin(0.274719953536987*x_84 - 7.52063989639282) + 0.00723078148067016*std::sin(0.285919934511185*x_84 - 7.49776029586792) + 0.436868147784863*std::sin(0.181760013103485*x_85 + 4.96687984466553) - 0.259523436930952*std::sin(0.207039996981621*x_85 - 7.60423994064331) - 0.00862926538754037*std::sin(0.218719989061356*x_85 + 1.81463992595673) - 0.235266973550784*std::sin(0.239359974861145*x_86 + 5.04375982284546) + 0.00250770326850802*std::sin(0.274719953536987*x_86 + 5.07567977905273) + 0.0291224298515776*std::sin(0.263039976358414*x_87 + 5.06744003295898) + 0.0932358381053391*std::sin(0.369199842214584*x_87 + 5.17087984085083) + 0.0100036495453739*std::sin(0.851599872112274*x_87 - 0.74703985452652) - 1.10692574466988*std::sin(0.135120034217834*x_89 + 4.91599988937378) - 0.216927393868823*std::sin(0.136560037732124*x_89 - 7.68688011169434) - 0.00734802527526936*std::sin(0.167120009660721*x_89 + 1.74775993824005) + 0.0234429137751466*std::sin(0.231359988451004*x_89 - 7.56800031661987) + 0.00533905637125544*std::sin(0.257439970970154*x_90 + 5.07199954986572) - 0.0257244104479338*std::sin(0.615919828414917*x_90 + 5.41048002243042) + 0.0135296922947394*std::sin(0.346959829330444*x_92 + 5.19504022598267) - 0.00342399171542513*std::sin(0.362319827079773*x_92 - 7.40927982330322) + 0.0355283045540999*std::sin(0.374959826469421*x_92 + 2.00839972496033) + 0.098726696572092*std::sin(0.2882399559021*x_93 - 1.32551980018616) - 0.0406232758523377*std::sin(0.359519839286804*x_94 - 1.19071984291077) - 0.00322554545713809*std::sin(0.384239852428436*x_94 + 2.00543975830078) + 0.00201837452116012*std::sin(0.359839856624603*x_95 - 4.23415994644165) - 0.0143775954750321*std::sin(0.380559861660004*x_95 - 7.42167997360229) + 0.0145490584574994*std::sin(0.38623982667923*x_95 - 4.19471979141235) + 0.0895508942894953*std::sin(0.399759858846664*x_95 + 5.18351984024048) - 0.049493157414101*std::sin(0.402799844741821*x_95 + 2.00415992736816) + 0.0839621957147385*std::sin(0.377199828624725*x_96 - 7.40903997421265) - 0.0185185887183709*std::sin(0.378239840269089*x_96 + 8.36672019958496) + 0.00112503956719814*std::sin(0.381439834833145*x_96 - 7.39928007125854) - 0.0255143282150013*std::sin(0.396879822015762*x_96 + 5.18616008758545) - 0.0352519433828791*std::sin(0.315919935703278*x_97 + 5.12328004837036) - 0.0187279746378702*std::sin(0.417759865522385*x_98 - 7.40039968490601) + 0.0340118636213145*std::sin(0.42223984003067*x_98 - 7.3790397644043) - 0.00246582710475276*std::sin(0.324319928884506*x_99 + 1.9210399389267) - 0.0418070914202819*std::sin(0.333199828863144*x_99 + 1.93759977817535) - 0.0134194792250276*std::sin(0.359599858522415*x_99 + 1.94671976566315) + 3.41622454150471 + 1.24894785149148e-5*std::exp(-2.02751994132996*x_30));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.170817264554737*x_10 + 0.00111968070022957*x_100 - 0.325766006325783*x_101 + 3.28228970800899e-5*x_102 - 0.0937882319364018*x_103 + 0.0802137435797025*x_104 - 0.0397107291831941*x_105 + 0.0208267484958144*x_106 - 0.0494109518328746*x_107 + 0.00127692362975541*x_108 - 0.000702797760005385*x_109 - 0.179964459471008*x_11 + 0.0147559353843779*x_112 + 0.0722755010586019*x_113 + 0.00814941138268263*x_114 - 0.0255786301591375*x_116 + 0.0110363683432841*x_117 + 0.00222730818957796*x_118 - 0.034091162092173*x_119 + 0.0621854253923659*x_12 + 0.0363538178077999*x_120 - 0.0144511607576146*x_13 - 0.00967566455842743*x_14 - 0.000445098169625042*x_15 - 0.0037898894161403*x_16 + 0.0443328398572109*x_17 + 0.0860222426309195*x_18 + 0.0913115624064874*x_19 + 0.00377089961811127*x_2 - 0.0542435702855316*x_20 + 0.125137646017817*x_21 + 0.0740813415965179*x_22 + 0.0225285694494682*x_23 + 0.131422677342738*x_25 - 0.109581234300872*x_26 - 0.0461258589703687*x_27 - 0.000113647250862615*x_28 - 0.0652320295727087*x_29 + 0.22125076011654*x_3 + 0.0555630259150609*x_30 - 0.0126767906509753*x_31 + 0.0293956304363888*x_32 - 0.0455321232204792*x_33 + 0.0959496173573206*x_34 + 1.99219700885167e-5*x_35 - 0.00277019959202949*x_36 - 0.0209494777312271*x_37 + 0.0366890019334173*x_38 + 0.0560304334530329*x_39 + 0.000805724654960529*x_4 + 0.104283077824428*x_40 + 0.00427704235920106*x_41 + 0.0451298121160801*x_42 + 0.00514364358950131*x_43 + 0.0993409585266886*x_44 - 0.00298855640570908*x_45 + 0.0297386236346531*x_46 + 0.0435841874642412*x_47 - 0.0112352083675342*x_48 - 0.0155123700497404*x_49 + 0.000136928241404862*x_5 - 0.0018223154422105*x_50 - 0.000723877968816512*x_51 + 0.0617503032193085*x_52 + 0.000489119869824602*x_53 + 0.039818651922858*x_54 - 0.0138367386408321*x_55 - 0.0091040503868014*x_56 - 0.0211151661795677*x_57 + 0.00245105982816205*x_58 - 0.00404962227977773*x_59 + 0.00475317408461406*x_6 - 0.00326658183287015*x_60 + 0.00226651506130459*x_61 - 0.0965660019252542*x_62 + 0.0314459023935795*x_63 + 0.000711924974942482*x_64 + 0.00242065510530656*x_65 - 0.0146021770028974*x_66 + 0.0433389475618457*x_67 + 0.0268859047080802*x_68 - 0.108554602138861*x_69 - 0.00253675968854359*x_7 + 0.0127363336836862*x_71 + 0.00553677508845958*x_72 - 2.46991779217137e-5*x_73 + 0.000287345226774317*x_74 - 0.0151889096776553*x_75 - 0.0337127204564404*x_76 - 0.0506977256482313*x_77 + 0.106495604995683*x_78 - 0.00683789377812858*x_79 - 0.0815844704679776*x_8 - 0.052783222916966*x_80 - 0.000496631678142512*x_81 + 0.036577621578361*x_82 + 0.090181488668173*x_83 - 0.00121544351886291*x_84 + 0.0109549547977544*x_85 + 0.0166345972512395*x_86 + 0.00435204528812505*x_87 + 0.049199336171629*x_88 + 0.000789542087465464*x_89 + 0.0790851383370604*x_9 + 0.0337541740546636*x_90 - 0.0541321761775517*x_91 + 0.00513511573310738*x_92 + 0.102618095661376*x_93 + 0.0659580552834443*x_94 + 0.00070832244495493*x_96 - 0.000823430165050047*x_97 + 0.0962154623340254*x_98 + 0.0665999859700826*x_99 - 1.35297256151906e-5*std::pow(-6.29120016098022*x_103 - 8.73127937316895, 2) + 1.10064291897254e-5*std::pow(-7.75808048248291*x_110 - 9.38607978820801, 2) - 2.50568026655953e-5*std::pow(-7.40000009536743*x_110 - 9.99830055236816, 2) - 1.41901946915897e-5*std::pow(-7.57424020767212*x_14 - 9.37415981292725, 2) + 0.000943678007661389*std::pow(-7.54568004608154*x_14 - 9.38496017456055, 2) + 7.33453782337436e-6*std::pow(-6.60400009155273*x_14 - 9.96963977813721, 2) + 7.34249546374807e-6*std::pow(-7.48759984970093*x_15 - 9.33039951324463, 2) + 0.000131731224989035*std::pow(-6.43415975570679*x_15 - 9.8625602722168, 2) + 0.00231432271995638*std::pow(-6.26032018661499*x_15 - 8.67928028106689, 2) - 2.37095167426019e-5*std::pow(-7.42991971969604*x_17 - 9.8689603805542, 2) - 0.000401324277971107*std::pow(-3.6814398765564*x_17 - 5.03768014907837, 2) - 6.8479317210175e-5*std::pow(-8.16792011260986*x_18 - 9.38511943817139, 2) - 1.1237157497636e-5*std::pow(-5.65367984771729*x_18 - 5.04967975616455, 2) - 0.000129575846509115*std::pow(-3.69407987594604*x_24 - 5.24943971633911, 2) - 2.13268674980168e-5*std::pow(-3.49719977378845*x_24 - 4.73023986816406, 2) - 8.43084636732188e-6*std::pow(-8.15824031829834*x_42 - 8.98200035095215, 2) + 0.00267542589304073*std::pow(-3.84272003173828*x_7 - 5.66088008880615, 2) + 0.00103560645869603*std::pow(-5.1224799156189*x_70 - 7.08175992965698, 2) - 1.56063098293695e-5*std::pow(-5.91807985305786*x_73 - 8.91327953338623, 2) + 1.47072436766177e-5*std::pow(-6.00263977050781*x_74 - 7.00984001159668, 2) + 2.7494519121077e-5*std::pow(-6.09375953674316*x_76 - 8.72231960296631, 2) - 7.17902883785855e-5*std::pow(-5.88271999359131*x_77 - 8.51807975769043, 2) + 4.53519927173511e-5*std::pow(-3.11719989776611*x_80 - 4.28687953948975, 2) - 5.76455005324393e-5*std::pow(-7.35264015197754*x_81 - 9.76879978179932, 2) + 6.28472748649979e-5*std::pow(-3.48071980476379*x_87 - 4.91408014297485, 2) + 1.16687651803446e-5*std::pow(-6.8120002746582*x_88 - 6.61999988555908, 2) - 6.59136959771626e-5*std::pow(-6.38272047042847*x_88 - 5.97375965118408, 2) + 7.46915315744007e-5*std::pow(-7.00031995773315*x_90 - 9.3840799331665, 2) - 9.93269416397645e-5*std::pow(-5.30272006988525*x_97 - 6.53128004074097, 2) + 0.000530030974180519*std::exp(0.63487982749939*x_1) + 0.000683503954596664*std::exp(1.13743984699249*x_1) - 0.000834938653766937*std::exp(1.20167994499207*x_1) + 0.000230984001370864*std::exp(1.2125598192215*x_1) - 0.018445565919712*std::exp(1.57423985004425*x_100) + 0.000568080928432191*std::exp(1.05679976940155*x_106) + 0.000132135883858637*std::exp(1.3271199464798*x_106) - 0.125636934358367*std::exp(0.543039858341217*x_109) - 0.00385103149260318*std::exp(0.620559811592102*x_109) + 0.00173336856927924*std::exp(0.843999862670898*x_110) - 0.0013241475879007*std::exp(0.924159824848175*x_110) - 0.0104466830625931*std::exp(1.28303980827332*x_110) + 0.00021389178265096*std::exp(1.38351988792419*x_26) - 0.00559638296328039*std::exp(0.582799851894379*x_31) + 0.00294780033488797*std::exp(0.667519807815552*x_31) + 0.0594060698790247*std::exp(0.899439811706543*x_50) + 0.00119694012652502*std::exp(0.815839886665344*x_6) + 0.00193061281130414*std::exp(0.835679888725281*x_66) + 0.000568629397299749*std::exp(0.971119821071625*x_68) + 0.000528835727728501*std::exp(1.1723198890686*x_68) - 0.00114700234617106*std::exp(0.692079842090607*x_70) - 0.0408923909530016*std::exp(1.00575983524323*x_72) + 0.00576135435411536*std::exp(0.620319843292236*x_74) - 0.00892217974913308*std::exp(0.827759861946106*x_74) + 0.0220206745024017*std::exp(0.888719916343689*x_74) + 0.000253056060197673*std::exp(0.861039876937866*x_81) - 0.00526307018386661*std::exp(1.83999991416931*x_81) + 0.534962673440234*std::sin(0.355119854211807*x_1 - 1.1522399187088) + 0.00434453648124942*std::sin(0.397199839353561*x_10 - 4.18671989440918) - 0.0264453106100085*std::sin(0.472399860620499*x_100 - 4.15240001678467) + 0.0218441852974943*std::sin(0.32711985707283*x_101 + 1.96655988693237) - 0.0421208359545625*std::sin(0.362559854984283*x_102 - 7.41928005218506) + 0.0295673513842119*std::sin(0.362959831953049*x_102 - 7.41296005249023) + 0.00713761515447925*std::sin(0.367999851703644*x_102 - 4.21712017059326) - 0.552531362297231*std::sin(0.371519833803177*x_102 + 1.98631989955902) - 0.014135790664903*std::sin(0.378719836473465*x_105 - 7.40032005310059) - 0.0144240878627026*std::sin(0.407439857721329*x_105 + 5.21447992324829) + 0.0508689201039454*std::sin(0.409599840641022*x_105 + 5.19664001464844) + 0.00833251938544028*std::sin(0.579839885234833*x_106 - 7.20016002655029) + 0.00997562092901869*std::sin(0.37679985165596*x_107 + 5.16760015487671) + 0.0448101118199122*std::sin(0.422799855470657*x_108 + 5.2085599899292) - 0.278233977548945*std::sin(0.571119844913483*x_108 + 5.39264011383057) + 0.0172725618426171*std::sin(0.328239858150482*x_111 - 7.45631980895996) + 0.0203703842151944*std::sin(0.346959829330444*x_111 - 7.44280004501343) + 0.666674643469118*std::sin(0.379759848117828*x_111 - 4.20928001403809) - 0.0369357084744564*std::sin(0.413439869880676*x_111 - 4.19479990005493) + 0.00660849850052563*std::sin(0.415359854698181*x_111 + 5.20128011703491) - 0.167965956285169*std::sin(0.0988800674676895*x_112 - 7.72000026702881) + 0.0571805359887683*std::sin(0.188320010900497*x_112 - 7.61392021179199) + 0.219831018509367*std::sin(0.484159857034683*x_112 - 7.34711980819702) + 0.013562212493868*std::sin(0.278399974107742*x_113 + 5.07871961593628) + 0.0140869051739084*std::sin(0.326799839735031*x_113 + 5.14792013168335) + 0.0937475778868885*std::sin(0.38919985294342*x_113 + 5.20240020751953) - 0.0461995142290115*std::sin(0.279999971389771*x_114 + 5.07415962219238) + 5.16178568450215*std::sin(0.114000059664249*x_115 - 7.71016025543213) + 0.0221683813052667*std::sin(0.176960021257401*x_115 - 7.62800025939941) - 0.0346967025335884*std::sin(0.3852798640728*x_115 + 5.18304014205933) + 0.0103527248489884*std::sin(0.462399870157242*x_115 - 4.15016031265259) + 0.000805309808875483*std::sin(0.704079866409302*x_115 - 0.953199863433838) - 0.00240777014177942*std::sin(0.276959955692291*x_117 - 7.5128002166748) - 0.0052420043318427*std::sin(0.486959844827652*x_117 + 2.04119992256165) - 0.00641747003783488*std::sin(0.493199855089188*x_117 + 8.44624042510986) + 0.362050596791956*std::sin(0.541919827461243*x_117 + 2.14631986618042) - 0.141696999280025*std::sin(0.50111985206604*x_118 - 0.914959847927094) - 0.00867349213678266*std::sin(0.386239856481552*x_119 - 7.41991996765137) + 0.0168193874180368*std::sin(0.361839860677719*x_120 + 5.16088008880615) + 0.144950697906087*std::sin(0.320879846811295*x_16 + 5.12936019897461) + 0.00512601964618338*std::sin(0.387919843196869*x_16 + 8.37479972839355) - 0.327516497076497*std::sin(0.428879857063293*x_16 + 2.01399970054626) + 0.0845009689642186*std::sin(0.362959831953049*x_2 + 8.34000015258789) + 0.0758159653305515*std::sin(0.341119855642319*x_23 + 8.32808017730713) + 0.0411437704405046*std::sin(0.265519946813583*x_24 - 7.50544023513794) + 0.533415648631212*std::sin(0.337759852409363*x_24 - 4.27648019790649) + 0.00415574756689903*std::sin(0.429839849472046*x_24 - 4.17072010040283) + 0.928641286868448*std::sin(0.335119843482971*x_28 - 4.26039981842041) - 0.023541826022254*std::sin(0.337679862976074*x_28 - 4.26599979400635) + 0.00919688726852381*std::sin(0.346559852361679*x_28 + 5.15136003494263) - 0.0315347324875193*std::sin(0.35183984041214*x_28 + 5.15032005310059) - 0.00269129728130183*std::sin(0.649119853973389*x_29 + 5.44807958602905) + 0.0481279052620908*std::sin(0.266879975795746*x_3 + 5.08120012283325) - 0.0348086778645837*std::sin(0.277119934558868*x_3 + 5.07439994812012) + 0.640710886839546*std::sin(0.262719959020615*x_31 - 1.11887979507446) - 0.0499082473702263*std::sin(0.239359974861145*x_32 - 4.39695978164673) + 0.042718392497412*std::sin(0.244239971041679*x_32 - 1.18919992446899) + 0.00867325081179836*std::sin(0.3642398416996*x_32 + 2.00423979759216) - 0.0323120285527071*std::sin(0.281919926404953*x_33 - 1.16639983654022) + 0.0172534451130038*std::sin(0.298799932003021*x_33 - 1.17119991779327) + 0.0289830060720751*std::sin(0.351039856672287*x_34 + 2.00447988510132) - 0.0146117564112109*std::sin(0.363679856061935*x_34 + 1.98031985759735) - 0.817747493174927*std::sin(0.312479853630066*x_35 - 7.4268798828125) - 0.0367256336263092*std::sin(0.316559851169586*x_35 - 7.42767953872681) - 0.00996874907907304*std::sin(0.338959842920303*x_36 + 5.13944005966187) + 0.0211765385092443*std::sin(0.348479837179184*x_36 + 5.1482400894165) - 0.0294549414512135*std::sin(0.528879821300507*x_38 + 2.14799976348877) - 0.0335925923507247*std::sin(0.138880044221878*x_39 - 7.67199993133545) + 1.30514641857481*std::sin(0.450239837169647*x_4 + 5.25072002410889) + 0.0328717105481022*std::sin(0.142080038785934*x_40 + 1.71799993515015) + 0.007612912090271*std::sin(0.303359925746918*x_41 + 5.1200795173645) - 0.0133514411046775*std::sin(0.383839845657349*x_43 + 8.36983966827393) + 0.677308585756382*std::sin(0.403679847717285*x_45 + 5.20216035842896) + 0.0072233073018092*std::sin(0.585359811782837*x_45 - 0.991279780864716) - 0.0152428048955854*std::sin(0.392799854278564*x_46 - 4.20968008041382) + 0.0206761130324698*std::sin(0.206560000777245*x_48 - 7.60423994064331) + 0.0198680076690893*std::sin(0.346159845590591*x_48 - 7.44863986968994) + 0.00623823068218148*std::sin(0.411759853363037*x_48 - 1.19631993770599) + 0.0126755109014545*std::sin(0.565599858760834*x_49 - 4.01488018035889) - 0.023881264016654*std::sin(0.331519842147827*x_50 - 7.47583961486816) - 0.0335652316425399*std::sin(0.312879920005798*x_51 - 7.46560001373291) + 0.0263481879087684*std::sin(0.328079849481583*x_51 - 7.46679973602295) + 0.0352534060493364*std::sin(0.398239850997925*x_51 + 2.0032799243927) - 0.021201363623953*std::sin(0.225839987397194*x_53 + 5.02431964874268) + 0.015293441271411*std::sin(0.245759963989258*x_53 + 5.05375957489014) + 0.872523296993286*std::sin(0.365519851446152*x_53 + 5.17160034179688) + 0.0545837825582309*std::sin(0.337839841842651*x_54 + 5.14088010787964) - 0.0290787705291888*std::sin(0.233839988708496*x_55 - 4.34647989273071) + 0.00792078636343403*std::sin(0.302159935235977*x_55 + 5.13935995101929) - 0.0246269846370599*std::sin(0.237999975681305*x_56 + 1.84207987785339) + 0.0299826394110324*std::sin(0.348079830408096*x_56 - 4.24767971038818) + 4.17359989547549*std::sin(0.219359993934631*x_58 + 5.00799989700317) + 0.00395935185228886*std::sin(0.453039854764938*x_58 - 7.33599948883057) - 0.0181179093977699*std::sin(0.202479988336563*x_59 - 7.59496021270752) - 0.99331031611964*std::sin(0.252719968557358*x_59 - 7.53144025802612) - 0.00500382621970645*std::sin(0.434399873018265*x_59 - 4.15543985366821) - 0.0267334215676146*std::sin(0.284879922866821*x_63 - 4.28927946090698) + 1.01320268534415*std::sin(0.218400001525879*x_64 - 4.37687969207764) - 0.0135367928366502*std::sin(0.265199959278107*x_64 + 5.0732798576355) - 0.00701799481486877*std::sin(0.549919843673706*x_64 + 8.54447937011719) + 0.069289458224656*std::sin(0.209519997239113*x_66 + 5.01255941390991) - 0.0243395784593229*std::sin(0.185360014438629*x_67 + 4.98880004882813) - 0.0040607078075089*std::sin(0.215919986367226*x_67 - 1.38919985294342) - 0.0370856508681584*std::sin(0.14264003932476*x_70 + 4.91504001617432) - 0.0936958345984129*std::sin(0.252799987792969*x_70 + 5.05615997314453) + 0.00559207913886778*std::sin(0.45839986205101*x_70 - 4.14351987838745) - 0.0141016038950695*std::sin(0.265119969844818*x_71 + 5.10031986236572) + 0.00663009503778869*std::sin(0.417279869318008*x_72 - 4.16544008255005) + 1.02346502380357*std::sin(0.22639998793602*x_73 - 4.35999965667725) + 0.119217629116358*std::sin(0.241039976477623*x_73 + 5.03599977493286) - 0.00593594738989238*std::sin(0.441279858350754*x_73 + 8.44567966461182) - 0.0808630101194497*std::sin(0.286959916353226*x_75 + 5.10399961471558) + 0.00270029732651659*std::sin(0.50631982088089*x_75 + 5.28976011276245) + 0.104370784139337*std::sin(0.201439991593361*x_77 + 5.00008010864258) + 0.117227945735706*std::sin(0.177760004997253*x_78 - 7.61360025405884) - 0.0273415754904484*std::sin(0.305519849061966*x_79 + 5.10823965072632) - 0.0252086127892809*std::sin(0.354479849338531*x_79 + 5.14448022842407) + 0.432411195906637*std::sin(0.429439842700958*x_79 - 1.17511987686157) - 0.00425726427891793*std::sin(0.473759859800339*x_79 + 2.05039978027344) - 0.0267095562425582*std::sin(0.389599829912186*x_80 - 4.22240018844604) - 0.00582049005132839*std::sin(0.34639984369278*x_81 + 5.13544034957886) + 0.0374025188564336*std::sin(0.201279997825623*x_83 + 5.00423955917358) + 0.100128389399322*std::sin(0.329919844865799*x_83 - 7.47191953659058) - 0.0600282957858861*std::sin(0.262319952249527*x_84 - 7.53927993774414) - 0.746461235211378*std::sin(0.274719953536987*x_84 - 7.52063989639282) + 0.00551180936800967*std::sin(0.285919934511185*x_84 - 7.49776029586792) + 1.04962507929528*std::sin(0.181760013103485*x_85 + 4.96687984466553) - 0.0587821087060316*std::sin(0.207039996981621*x_85 - 7.60423994064331) + 0.0478501024483194*std::sin(0.218719989061356*x_85 + 1.81463992595673) + 0.356919413056552*std::sin(0.239359974861145*x_86 + 5.04375982284546) - 0.0139054546266883*std::sin(0.274719953536987*x_86 + 5.07567977905273) + 0.0221991609211586*std::sin(0.263039976358414*x_87 + 5.06744003295898) + 0.224009634166946*std::sin(0.369199842214584*x_87 + 5.17087984085083) + 0.00226582855863481*std::sin(0.851599872112274*x_87 - 0.74703985452652) - 2.65951415413163*std::sin(0.135120034217834*x_89 + 4.91599988937378) + 0.329096757300848*std::sin(0.136560037732124*x_89 - 7.68688011169434) + 0.0407455034031232*std::sin(0.167120009660721*x_89 + 1.74775993824005) + 0.0178698349693898*std::sin(0.231359988451004*x_89 - 7.56800031661987) - 0.0296055785595376*std::sin(0.257439970970154*x_90 + 5.07199954986572) - 0.00582658394644848*std::sin(0.615919828414917*x_90 + 5.41048002243042) + 0.0103132814808174*std::sin(0.346959829330444*x_92 + 5.19504022598267) + 0.0189863617593512*std::sin(0.362319827079773*x_92 - 7.40927982330322) + 0.00804716785943206*std::sin(0.374959826469421*x_92 + 2.00839972496033) + 0.022361615886091*std::sin(0.2882399559021*x_93 - 1.32551980018616) + 0.0616288616919747*std::sin(0.359519839286804*x_94 - 1.19071984291077) + 0.0178859582646075*std::sin(0.384239852428436*x_94 + 2.00543975830078) - 0.0111920798908374*std::sin(0.359839856624603*x_95 - 4.23415994644165) - 0.0109596128220142*std::sin(0.380559861660004*x_95 - 7.42167997360229) - 0.0220721222651986*std::sin(0.38623982667923*x_95 - 4.19471979141235) + 0.215156140350756*std::sin(0.399759858846664*x_95 + 5.18351984024048) - 0.0112102097356797*std::sin(0.402799844741821*x_95 + 2.00415992736816) + 0.201728660653666*std::sin(0.377199828624725*x_96 - 7.40903997421265) - 0.00419446392972665*std::sin(0.378239840269089*x_96 + 8.36672019958496) - 0.00623845207340278*std::sin(0.381439834833145*x_96 - 7.39928007125854) - 0.0194488125038573*std::sin(0.396879822015762*x_96 + 5.18616008758545) - 0.0846967764900741*std::sin(0.315919935703278*x_97 + 5.12328004837036) - 0.0142757772902983*std::sin(0.417759865522385*x_98 - 7.40039968490601) - 0.0515988037651984*std::sin(0.42223984003067*x_98 - 7.3790397644043) + 0.0136732472908558*std::sin(0.324319928884506*x_99 + 1.9210399389267) + 0.0634248075967519*std::sin(0.333199828863144*x_99 + 1.93759977817535) - 0.0102292693402571*std::sin(0.359599858522415*x_99 + 1.94671976566315) + 7.05614052515408 + 2.82886930146774e-6*std::exp(-2.02751994132996*x_30));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.184650593854817*x_10 - 0.000160169041887094*x_100 - 0.370458905082326*x_101 - 1.66395132777919e-5*x_102 - 0.115488361179473*x_103 + 0.1003338510792*x_104 - 0.0470260649845097*x_105 + 0.00479468633213822*x_106 - 0.0794713959420205*x_107 + 0.000314209742975434*x_108 + 0.000276619451451157*x_109 - 0.240058624576535*x_11 - 0.0137759549678113*x_112 + 0.084622285179354*x_113 + 0.00918446712705063*x_114 - 0.0336733468378576*x_116 - 0.0104976777931227*x_117 + 0.00211785200952473*x_118 - 0.0484600276939616*x_119 + 0.0883681164607063*x_12 + 0.0376780799308291*x_120 - 0.0496541328816065*x_13 + 0.00817299581619151*x_14 - 0.000750668271032421*x_15 + 0.0004337982764181*x_16 + 0.0560099878966643*x_17 + 0.0988881404831078*x_18 + 0.103626749686937*x_19 + 0.00195563410889594*x_2 - 0.049899228047695*x_20 + 0.146979177415927*x_21 + 0.221974642975389*x_22 + 0.0342048767155973*x_23 + 0.206540744822507*x_25 - 0.131733323687875*x_26 - 0.0457874633307217*x_27 + 5.76132854786945e-5*x_28 - 0.0666394084535126*x_29 + 0.273799721326574*x_3 + 0.0897730088266449*x_30 - 0.00162857593725659*x_31 + 0.00636369509522364*x_32 - 0.0546291923430677*x_33 + 0.119538508078659*x_34 + 4.86107246391143e-5*x_35 - 0.000414155445024876*x_36 - 0.0109683832901518*x_37 + 0.0423696704738522*x_38 + 0.0710617389416892*x_39 + 0.00246364470677046*x_4 + 0.124576856168526*x_40 - 0.00123025007237522*x_41 + 0.0687398044762372*x_42 + 0.00928018653173272*x_43 + 0.118878845122135*x_44 + 0.00428618413481706*x_45 + 0.0352252733915373*x_46 + 0.0614854569565386*x_47 - 0.0254099505853861*x_48 - 0.0177644237379682*x_49 - 0.014068977915767*x_5 + 0.00363731944044048*x_50 - 0.000533986472787169*x_51 + 0.0546838312448918*x_52 - 0.000120288371917055*x_53 + 0.0453610538207156*x_54 - 0.0125821236449143*x_55 - 0.0147607843048383*x_56 - 0.0164430790895583*x_57 - 0.00230850010707497*x_58 + 0.00253140605434224*x_59 + 0.0142772168392799*x_6 - 0.00721842036895751*x_60 + 0.0079435163247523*x_61 - 0.134674469411297*x_62 + 0.0343082890156517*x_63 - 0.000412457403902464*x_64 + 0.00562475481581476*x_65 - 0.0150585821756021*x_66 + 0.0510609112877152*x_67 + 0.00174236694533502*x_68 - 0.131835020806729*x_69 + 0.00134062084783002*x_7 + 0.0124299977544056*x_71 - 0.00640183139071212*x_72 + 1.2521207313787e-5*x_73 - 0.0211089970898154*x_75 - 0.0334162247887135*x_76 - 0.0604981755217243*x_77 + 0.127742066044206*x_78 + 0.00650413283007841*x_79 - 0.0918499829262323*x_8 - 0.0617532844859049*x_80 + 0.0196156136610843*x_82 + 0.102557047765722*x_83 + 0.00185494104598228*x_84 - 0.0101369922404654*x_85 + 0.0180858063704083*x_86 - 0.00413961982372724*x_87 + 0.0654183824782368*x_88 + 0.0700281891557871*x_9 + 0.0365583806835146*x_90 - 0.0399112756071871*x_91 + 0.00461736639939008*x_92 + 0.0593418804927503*x_93 + 0.0771122805768918*x_94 - 0.000673748879113714*x_96 + 0.00111509159476424*x_97 + 0.112431035707088*x_98 + 0.0792720153306102*x_99 + 1.63982506311516e-5*std::pow(-6.29120016098022*x_103 - 8.73127937316895, 2) + 2.3833767841696e-5*std::pow(-7.40000009536743*x_110 - 9.99830055236816, 2) + 1.71987500468056e-5*std::pow(-7.57424020767212*x_14 - 9.37415981292725, 2) + 0.0011071389241577*std::pow(-7.54568004608154*x_14 - 9.38496017456055, 2) - 3.71823179412566e-6*std::pow(-6.60400009155273*x_14 - 9.96963977813721, 2) - 3.72226590672502e-6*std::pow(-7.48759984970093*x_15 - 9.33039951324463, 2) - 0.000125301359307182*std::pow(-6.43415975570679*x_15 - 9.8625602722168, 2) + 0.00271520237361049*std::pow(-6.26032018661499*x_15 - 8.67928028106689, 2) + 0.000381735443186977*std::pow(-3.6814398765564*x_17 - 5.03768014907837, 2) + 6.51368081605314e-5*std::pow(-8.16792011260986*x_18 - 9.38511943817139, 2) + 5.69665837023184e-6*std::pow(-5.65367984771729*x_18 - 5.04967975616455, 2) + 0.000123251185907686*std::pow(-3.69407987594604*x_24 - 5.24943971633911, 2) + 1.081162013338e-5*std::pow(-3.49719977378845*x_24 - 4.73023986816406, 2) + 1.02183248719291e-5*std::pow(-8.15824031829834*x_42 - 8.98200035095215, 2) + 0.00313885469496669*std::pow(-3.84272003173828*x_7 - 5.66088008880615, 2) + 0.00121499093040526*std::pow(-5.1224799156189*x_70 - 7.08175992965698, 2) + 1.8915104953945e-5*std::pow(-5.91807985305786*x_73 - 8.91327953338623, 2) - 7.45581280773801e-6*std::pow(-6.00263977050781*x_74 - 7.00984001159668, 2) - 3.33238107226804e-5*std::pow(-6.09375953674316*x_76 - 8.72231960296631, 2) + 6.82861692027843e-5*std::pow(-5.88271999359131*x_77 - 8.51807975769043, 2) - 2.29911175467945e-5*std::pow(-3.11719989776611*x_80 - 4.28687953948975, 2) + 5.48317953868471e-5*std::pow(-7.35264015197754*x_81 - 9.76879978179932, 2) - 7.61719338612467e-5*std::pow(-3.48071980476379*x_87 - 4.91408014297485, 2) - 5.91546116968322e-6*std::pow(-6.8120002746582*x_88 - 6.61999988555908, 2) + 6.26964161578716e-5*std::pow(-6.38272047042847*x_88 - 5.97375965118408, 2) - 7.10458012956812e-5*std::pow(-7.00031995773315*x_90 - 9.3840799331665, 2) + 9.44787449165792e-5*std::pow(-5.30272006988525*x_97 - 6.53128004074097, 2) - 0.000650141791438777*std::exp(1.13743984699249*x_1) + 0.000423270766794196*std::exp(1.20167994499207*x_1) - 0.000279956419959693*std::exp(1.2125598192215*x_1) - 0.0216406484436771*std::exp(1.57423985004425*x_100) - 0.000287987685195579*std::exp(1.05679976940155*x_106) - 0.14739936632062*std::exp(0.543039858341217*x_109) - 0.00210087129951019*std::exp(0.843999862670898*x_110) + 0.000671274425193714*std::exp(0.924159824848175*x_110) - 0.0122562244251069*std::exp(1.28303980827332*x_110) - 0.00020345161986486*std::exp(1.38351988792419*x_26) + 0.00532322076683757*std::exp(0.582799851894379*x_31) - 0.00149438249442037*std::exp(0.667519807815552*x_31) + 0.0696962012045746*std::exp(0.899439811706543*x_50) - 0.00145071117800072*std::exp(0.815839886665344*x_6) - 0.000978720965111178*std::exp(0.835679888725281*x_66) - 0.000288265730579016*std::exp(0.971119821071625*x_68) - 0.000640957625649327*std::exp(1.1723198890686*x_68) - 0.0479756414353011*std::exp(1.00575983524323*x_72) - 0.00698285651614301*std::exp(0.620319843292236*x_74) + 0.00848668378087607*std::exp(0.827759861946106*x_74) + 0.0258350260151065*std::exp(0.888719916343689*x_74) - 0.000306708119357141*std::exp(0.861039876937866*x_81) - 0.0061747225365279*std::exp(1.83999991416931*x_81) + 15.3463066809192*std::exp(0.0182222225129172*x_100 + 0.0109743611417528*x_101 + 0.00481084156986144*x_103 - 0.0049222454457382*x_104 + 0.00660823711859034*x_105 + 0.0233955340960649*x_107 + 0.0150167542975157*x_108 - 0.0247343428014554*x_11 + 0.011045846717482*x_114 - 0.0212662818064846*x_116 + 0.0735402251232026*x_118 + 0.017057308308145*x_119 + 0.111400651549459*x_12 + 0.0118734783846539*x_120 - 0.0188657858767469*x_13 - 0.0192286448992984*x_14 - 0.0188946372510115*x_15 - 0.0520834160923049*x_16 + 0.0134594230624541*x_18 - 0.00113955905747726*x_19 + 0.0451217457711426*x_2 + 0.0054842784897245*x_20 + 0.00393598370305114*x_21 - 0.028629955650153*x_22 + 0.0125757001199818*x_23 + 0.0284830057151436*x_25 + 0.0491586421329953*x_26 - 0.0295215109681604*x_27 - 0.248871410280519*x_31 - 0.00856928114405097*x_33 - 0.0045955422929759*x_35 + 0.0140691655002156*x_36 + 0.0429188818913717*x_37 + 0.0187893462391356*x_38 - 0.00246474438608761*x_39 + 0.025466951907033*x_4 + 0.0439879363629943*x_40 + 0.0353207988529628*x_41 - 0.0325333403230239*x_42 + 0.00501622136493767*x_43 + 0.0928584682761369*x_44 + 0.00560745874080088*x_45 - 0.00956875543954099*x_47 + 0.0170105096994054*x_49 - 0.0165222034208445*x_5 + 0.0341446286481377*x_50 + 0.0183159354803609*x_52 + 0.00692047113432394*x_53 + 0.0249710531948333*x_54 + 0.00648989288680773*x_56 + 6.82719019747471e-5*x_57 - 0.0025522646013523*x_58 - 0.0246433974621685*x_59 - 0.0535842834143978*x_6 + 0.0238215299600037*x_60 + 0.0282551906955405*x_61 - 0.0200842877729087*x_62 - 0.00441584623040287*x_63 + 0.00659643160720491*x_64 + 0.000522998391799638*x_65 - 0.0259792620802516*x_66 + 0.0165273513876154*x_67 + 0.00649186634571128*x_68 + 0.00803334817059189*x_69 - 0.0352859583036442*x_7 + 0.0201415183956308*x_71 + 0.00553325902148761*x_72 + 0.0051005387994068*x_74 + 0.0301201156613469*x_75 + 0.00978411575362754*x_76 + 0.0235010984729626*x_77 + 0.0106276617569252*x_78 + 0.00781690194213038*x_8 - 0.0059411534850857*x_80 - 0.00881549059233165*x_81 + 0.027700650675007*x_82 + 0.0256164075938804*x_83 + 0.00559169387493163*x_84 + 0.00794886055776437*x_86 - 0.0244121664919267*x_88 + 0.0140148145006256*x_89 - 0.0714012575848542*x_9 - 0.00687384363785756*x_91 + 0.030224406233969*x_94 + 0.0101045223544102*x_97 + 0.0127849003383651*x_98 - 0.0171843092073242*x_99 + 0.000195370285963406*std::pow(-7.75808048248291*x_110 - 9.38607978820801, 2) - 0.000420857208655867*std::pow(-7.42991971969604*x_17 - 9.8689603805542, 2) + 0.00940834681349493*std::exp(0.63487982749939*x_1) + 0.00234548598555363*std::exp(1.3271199464798*x_106) - 0.068357967056774*std::exp(0.620559811592102*x_109) - 0.0203599344082754*std::exp(0.692079842090607*x_70) + 0.0771179571583946*std::sin(0.397199839353561*x_10 - 4.18671989440918) + 0.126696668809636*std::sin(0.367999851703644*x_102 - 4.21712017059326) + 0.306597652003511*std::sin(0.328239858150482*x_111 - 7.45631980895996) + 1.01498655695664*std::sin(0.188320010900497*x_112 - 7.61392021179199) + 0.240736871836411*std::sin(0.278399974107742*x_113 + 5.07871961593628) + 0.0142947003916594*std::sin(0.704079866409302*x_115 - 0.953199863433838) - 0.0427392692965967*std::sin(0.276959955692291*x_117 - 7.5128002166748) + 0.730324981700505*std::sin(0.265519946813583*x_24 - 7.50544023513794) - 0.417880604398206*std::sin(0.337679862976074*x_28 - 4.26599979400635) - 0.0477720349076804*std::sin(0.649119853973389*x_29 + 5.44807958602905) + 0.854297288593102*std::sin(0.266879975795746*x_3 + 5.08120012283325) - 0.885899358690807*std::sin(0.239359974861145*x_32 - 4.39695978164673) - 0.259366864518675*std::sin(0.363679856061935*x_34 + 1.98031985759735) - 0.270568328746883*std::sin(0.392799854278564*x_46 - 4.20968008041382) + 0.110732090424133*std::sin(0.411759853363037*x_48 - 1.19631993770599) + 0.467695100528971*std::sin(0.328079849481583*x_51 - 7.46679973602295) - 0.51616447222095*std::sin(0.233839988708496*x_55 - 4.34647989273071) - 0.10536639259076*std::sin(0.441279858350754*x_73 + 8.44567966461182) - 0.0755688266609145*std::sin(0.473759859800339*x_79 + 2.05039978027344) - 1.04341537018655*std::sin(0.207039996981621*x_85 - 7.60423994064331) + 0.040219726653743*std::sin(0.851599872112274*x_87 - 0.74703985452652) - 0.103425130183918*std::sin(0.615919828414917*x_90 + 5.41048002243042) + 0.142841739022899*std::sin(0.374959826469421*x_92 + 2.00839972496033) + 0.396931213108402*std::sin(0.2882399559021*x_93 - 1.32551980018616) - 0.198987504849804*std::sin(0.402799844741821*x_95 + 2.00415992736816) - 0.0744540852703501*std::sin(0.378239840269089*x_96 + 8.36672019958496) + 5.02140153590213e-5*std::exp(-2.02751994132996*x_30)) + 0.62762721386813*std::sin(0.355119854211807*x_1 - 1.1522399187088) + 0.0251545020325326*std::sin(0.472399860620499*x_100 - 4.15240001678467) - 0.026475512920931*std::sin(0.32711985707283*x_101 + 1.96655988693237) + 0.0400648972990328*std::sin(0.362559854984283*x_102 - 7.41928005218506) - 0.0358361176189164*std::sin(0.362959831953049*x_102 - 7.41296005249023) - 0.648239095380766*std::sin(0.371519833803177*x_102 + 1.98631989955902) + 0.0071661156505109*std::sin(0.378719836473465*x_105 - 7.40032005310059) + 0.0174822324284821*std::sin(0.407439857721329*x_105 + 5.21447992324829) - 0.0483859831717446*std::sin(0.409599840641022*x_105 + 5.19664001464844) - 0.0100991509478927*std::sin(0.579839885234833*x_106 - 7.20016002655029) - 0.012090617123214*std::sin(0.37679985165596*x_107 + 5.16760015487671) - 0.0426229082907955*std::sin(0.422799855470657*x_108 + 5.2085599899292) - 0.326428786160913*std::sin(0.571119844913483*x_108 + 5.39264011383057) - 0.0246892416974495*std::sin(0.346959829330444*x_111 - 7.44280004501343) + 0.78215391430258*std::sin(0.379759848117828*x_111 - 4.20928001403809) + 0.03513285843359*std::sin(0.413439869880676*x_111 - 4.19479990005493) - 0.00335016736266301*std::sin(0.415359854698181*x_111 + 5.20128011703491) + 0.203577509773946*std::sin(0.0988800674676895*x_112 - 7.72000026702881) + 0.257909451479219*std::sin(0.484159857034683*x_112 - 7.34711980819702) - 0.0170735614475182*std::sin(0.326799839735031*x_113 + 5.14792013168335) - 0.0891717126441414*std::sin(0.38919985294342*x_113 + 5.20240020751953) + 0.0439444932870581*std::sin(0.279999971389771*x_114 + 5.07415962219238) + 6.05589385688312*std::sin(0.114000059664249*x_115 - 7.71016025543213) - 0.0112382241633354*std::sin(0.176960021257401*x_115 - 7.62800025939941) + 0.042052975825429*std::sin(0.3852798640728*x_115 + 5.18304014205933) - 0.00984740327298604*std::sin(0.462399870157242*x_115 - 4.15016031265259) + 0.00635339572198179*std::sin(0.486959844827652*x_117 + 2.04119992256165) + 0.00325332580009092*std::sin(0.493199855089188*x_117 + 8.44624042510986) + 0.424763854798583*std::sin(0.541919827461243*x_117 + 2.14631986618042) - 0.166241304836631*std::sin(0.50111985206604*x_118 - 0.914959847927094) + 0.0105124155471856*std::sin(0.386239856481552*x_119 - 7.41991996765137) - 0.0203853750022647*std::sin(0.361839860677719*x_120 + 5.16088008880615) - 0.137875583269411*std::sin(0.320879846811295*x_16 + 5.12936019897461) - 0.00621282036968629*std::sin(0.387919843196869*x_16 + 8.37479972839355) - 0.384247867676577*std::sin(0.428879857063293*x_16 + 2.01399970054626) - 0.0803764352367622*std::sin(0.362959831953049*x_2 + 8.34000015258789) - 0.0721153508888646*std::sin(0.341119855642319*x_23 + 8.32808017730713) + 0.625812218320072*std::sin(0.337759852409363*x_24 - 4.27648019790649) - 0.00503683460404375*std::sin(0.429839849472046*x_24 - 4.17072010040283) + 1.08949759020014*std::sin(0.335119843482971*x_28 - 4.26039981842041) - 0.0111467790807505*std::sin(0.346559852361679*x_28 + 5.15136003494263) + 0.0299955067327689*std::sin(0.35183984041214*x_28 + 5.15032005310059) + 0.0421886917737337*std::sin(0.277119934558868*x_3 + 5.07439994812012) + 0.751692797959312*std::sin(0.262719959020615*x_31 - 1.11887979507446) - 0.0517753963868987*std::sin(0.244239971041679*x_32 - 1.18919992446899) - 0.00439689012497562*std::sin(0.3642398416996*x_32 + 2.00423979759216) + 0.016380529324491*std::sin(0.281919926404953*x_33 - 1.16639983654022) - 0.0209114600887543*std::sin(0.298799932003021*x_33 - 1.17119991779327) - 0.0146928868950801*std::sin(0.351039856672287*x_34 + 2.00447988510132) - 0.959395124688763*std::sin(0.312479853630066*x_35 - 7.4268798828125) + 0.0349330374417843*std::sin(0.316559851169586*x_35 - 7.42767953872681) + 0.00505364082455812*std::sin(0.338959842920303*x_36 + 5.13944005966187) - 0.0256663140001107*std::sin(0.348479837179184*x_36 + 5.1482400894165) + 0.0280172313167033*std::sin(0.528879821300507*x_38 + 2.14799976348877) + 0.040714776070463*std::sin(0.138880044221878*x_39 - 7.67199993133545) + 1.53121974868325*std::sin(0.450239837169647*x_4 + 5.25072002410889) - 0.0166642591845028*std::sin(0.142080038785934*x_40 + 1.71799993515015) - 0.00922697503554879*std::sin(0.303359925746918*x_41 + 5.1200795173645) + 0.0161821668634393*std::sin(0.383839845657349*x_43 + 8.36983966827393) + 0.794629834402331*std::sin(0.403679847717285*x_45 + 5.20216035842896) - 0.00687073413069314*std::sin(0.585359811782837*x_45 - 0.991279780864716) - 0.0250597900672715*std::sin(0.206560000777245*x_48 - 7.60423994064331) - 0.0100720535608546*std::sin(0.346159845590591*x_48 - 7.44863986968994) - 0.0120568129993283*std::sin(0.565599858760834*x_49 - 4.01488018035889) + 0.0289444859320807*std::sin(0.331519842147827*x_50 - 7.47583961486816) + 0.0406816144408024*std::sin(0.312879920005798*x_51 - 7.46560001373291) - 0.0335326700147026*std::sin(0.398239850997925*x_51 + 2.0032799243927) + 0.020166514670066*std::sin(0.225839987397194*x_53 + 5.02431964874268) - 0.00775298470692085*std::sin(0.245759963989258*x_53 + 5.05375957489014) + 1.02365901980657*std::sin(0.365519851446152*x_53 + 5.17160034179688) - 0.0661564448713727*std::sin(0.337839841842651*x_54 + 5.14088010787964) - 0.00401542951992684*std::sin(0.302159935235977*x_55 + 5.13935995101929) + 0.0124846090477768*std::sin(0.237999975681305*x_56 + 1.84207987785339) - 0.0363394535579891*std::sin(0.348079830408096*x_56 - 4.24767971038818) + 4.89653765439814*std::sin(0.219359993934631*x_58 + 5.00799989700317) - 0.0020071868597356*std::sin(0.453039854764938*x_58 - 7.33599948883057) + 0.0219592050620418*std::sin(0.202479988336563*x_59 - 7.59496021270752) - 1.16536838393509*std::sin(0.252719968557358*x_59 - 7.53144025802612) + 0.00253668140930419*std::sin(0.434399873018265*x_59 - 4.15543985366821) + 0.0324013479328645*std::sin(0.284879922866821*x_63 - 4.28927946090698) + 1.18870644637098*std::sin(0.218400001525879*x_64 - 4.37687969207764) + 0.00686245469418942*std::sin(0.265199959278107*x_64 + 5.0732798576355) + 0.0066754430469086*std::sin(0.549919843673706*x_64 + 8.54447937011719) - 0.0659074057948692*std::sin(0.209519997239113*x_66 + 5.01255941390991) + 0.0294999705969229*std::sin(0.185360014438629*x_67 + 4.98880004882813) + 0.0020585690932585*std::sin(0.215919986367226*x_67 - 1.38919985294342) + 0.044948420614876*std::sin(0.14264003932476*x_70 + 4.91504001617432) + 0.0891224949709469*std::sin(0.252799987792969*x_70 + 5.05615997314453) - 0.00283489525176912*std::sin(0.45839986205101*x_70 - 4.14351987838745) + 0.00714878472420109*std::sin(0.265119969844818*x_71 + 5.10031986236572) - 0.00336111569143686*std::sin(0.417279869318008*x_72 - 4.16544008255005) + 1.20074639460444*std::sin(0.22639998793602*x_73 - 4.35999965667725) - 0.113398558184686*std::sin(0.241039976477623*x_73 + 5.03599977493286) + 0.0769160469469617*std::sin(0.286959916353226*x_75 + 5.10399961471558) - 0.00327280490368053*std::sin(0.50631982088089*x_75 + 5.28976011276245) - 0.126499112071059*std::sin(0.201439991593361*x_77 + 5.00008010864258) - 0.111505992225421*std::sin(0.177760004997253*x_78 - 7.61360025405884) + 0.0331384405194096*std::sin(0.305519849061966*x_79 + 5.10823965072632) + 0.0127794644756204*std::sin(0.354479849338531*x_79 + 5.14448022842407) + 0.507312094107419*std::sin(0.429439842700958*x_79 - 1.17511987686157) + 0.0254058497061932*std::sin(0.389599829912186*x_80 - 4.22240018844604) + 0.0029506877852986*std::sin(0.34639984369278*x_81 + 5.13544034957886) - 0.0453324698437009*std::sin(0.201279997825623*x_83 + 5.00423955917358) - 0.0952410736180289*std::sin(0.329919844865799*x_83 - 7.47191953659058) + 0.0570982852356466*std::sin(0.262319952249527*x_84 - 7.53927993774414) - 0.875760886836193*std::sin(0.274719953536987*x_84 - 7.52063989639282) - 0.00279420262446265*std::sin(0.285919934511185*x_84 - 7.49776029586792) + 1.2314378120772*std::sin(0.181760013103485*x_85 + 4.96687984466553) - 0.0579951134997775*std::sin(0.218719989061356*x_85 + 1.81463992595673) - 0.339498001501389*std::sin(0.239359974861145*x_86 + 5.04375982284546) + 0.0168536403910901*std::sin(0.274719953536987*x_86 + 5.07567977905273) - 0.0112538278386012*std::sin(0.263039976358414*x_87 + 5.06744003295898) + 0.262811873710151*std::sin(0.369199842214584*x_87 + 5.17087984085083) - 3.12018677502548*std::sin(0.135120034217834*x_89 + 4.91599988937378) - 0.313033383215059*std::sin(0.136560037732124*x_89 - 7.68688011169434) - 0.0493842222599608*std::sin(0.167120009660721*x_89 + 1.74775993824005) - 0.00905908322228751*std::sin(0.231359988451004*x_89 - 7.56800031661987) + 0.0358824495860043*std::sin(0.257439970970154*x_90 + 5.07199954986572) - 0.00522830095463335*std::sin(0.346959829330444*x_92 + 5.19504022598267) - 0.0230117836502162*std::sin(0.362319827079773*x_92 - 7.40927982330322) - 0.0586207267350734*std::sin(0.359519839286804*x_94 - 1.19071984291077) - 0.0216780764623969*std::sin(0.384239852428436*x_94 + 2.00543975830078) + 0.0135649854515722*std::sin(0.359839856624603*x_95 - 4.23415994644165) + 0.00555595755689657*std::sin(0.380559861660004*x_95 - 7.42167997360229) + 0.020994771155084*std::sin(0.38623982667923*x_95 - 4.19471979141235) + 0.252424805728155*std::sin(0.399759858846664*x_95 + 5.18351984024048) + 0.236671460513693*std::sin(0.377199828624725*x_96 - 7.40903997421265) + 0.00756110682209467*std::sin(0.381439834833145*x_96 - 7.39928007125854) + 0.0098595432665669*std::sin(0.396879822015762*x_96 + 5.18616008758545) - 0.099367683936206*std::sin(0.315919935703278*x_97 + 5.12328004837036) + 0.00723708163825703*std::sin(0.417759865522385*x_98 - 7.40039968490601) + 0.049080240853617*std::sin(0.42223984003067*x_98 - 7.3790397644043) - 0.0165722012695829*std::sin(0.324319928884506*x_99 + 1.9210399389267) - 0.0603290116396546*std::sin(0.333199828863144*x_99 + 1.93759977817535) + 0.00518571113920855*std::sin(0.359599858522415*x_99 + 1.94671976566315) + 6.04316970919405);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0051006060178797*x_10 - 0.000103313611218743*x_100 - 0.0199721818356766*x_101 - 2.77596638150674e-5*x_102 - 0.0106466846251032*x_103 + 0.0100760875410651*x_104 - 0.0033094208742295*x_105 - 0.00927884251350844*x_106 - 0.0153649822334103*x_107 - 0.000248617866509038*x_108 + 0.000529109700579841*x_109 - 0.0311898278700377*x_11 - 0.0161838510133571*x_112 + 0.00587203223661138*x_113 + 0.000675010254447761*x_114 - 0.0062226294242543*x_116 - 0.0122186474160901*x_117 + 0.00241546165176769*x_118 - 0.00701433210263189*x_119 + 0.0167887481913433*x_12 + 0.000601095102606106*x_120 - 0.0204640189823355*x_13 + 0.00951286143271103*x_14 - 0.000618781800032998*x_15 + 0.000723704721158775*x_16 + 0.00546723208019585*x_17 + 0.00652052119107506*x_18 + 0.00588117968075749*x_19 + 6.11703877468404e-5*x_2 + 0.00322416795924641*x_20 + 0.0107480883145128*x_21 + 0.080615619851996*x_22 + 0.00576692222352059*x_23 + 0.0409180356983959*x_25 - 0.00955873408884328*x_26 - 8.72957106223008e-5*x_27 + 9.61161188713745e-5*x_28 + 0.000828457479777821*x_29 + 0.0261860792008345*x_3 + 0.0181024917277915*x_30 - 0.00134244804107691*x_31 - 0.0133225718875052*x_32 - 0.00471433468943888*x_33 + 0.0123704404241074*x_34 - 0.000194496744857164*x_35 + 0.0018147196975333*x_36 + 0.00801777867123145*x_37 + 0.00333503896277049*x_38 + 0.00753300225247235*x_39 + 0.00146018308160181*x_4 + 0.0113528918774029*x_40 - 0.00200647068169158*x_41 + 0.0115078681554505*x_42 + 0.00240481179962823*x_43 + 0.0095263577475601*x_44 + 0.00336253958150884*x_45 + 0.00259941211331464*x_46 + 0.00883679681992439*x_47 - 0.00777577881432698*x_48 - 0.000719963963500633*x_49 - 0.00832254938361589*x_5 + 0.00419087266465546*x_50 + 0.000114428027916532*x_51 - 0.00489333265951644*x_52 - 9.91546574833973e-5*x_53 + 0.00335427895877312*x_54 + 0.000946491528169608*x_55 - 0.00282634837315276*x_56 + 0.00294879866170423*x_57 - 0.00293897276768303*x_58 + 0.00294640001860479*x_59 + 0.00354493332627042*x_6 - 0.00130936323199389*x_60 + 0.00373139198049248*x_61 - 0.0213755538424134*x_62 + 0.00096990488632875*x_63 - 0.000339991904110572*x_64 + 0.00174059654650734*x_65 - 0.000923410523764069*x_66 + 0.00423347036450775*x_67 - 0.0142587613907674*x_68 - 0.0106599305984064*x_69 + 0.000817730956427714*x_7 + 0.000422069510201474*x_71 - 0.0051916410421666*x_72 + 2.0889102931478e-5*x_73 - 0.0021114995958408*x_75 + 0.000968145524517154*x_76 - 0.00399978674770195*x_77 + 0.0105213801206129*x_78 + 0.00757040817638817*x_79 - 0.00446048239790375*x_8 - 0.00443004095937416*x_80 - 0.00855293059123246*x_82 + 0.00646895869354694*x_83 + 0.00152904259268797*x_84 - 0.0119618547297213*x_85 + 0.000836536060665338*x_86 - 0.0048182613392761*x_87 + 0.0069343009369457*x_88 - 0.00826102406197984*x_9 + 0.00110583272949321*x_90 + 0.00959142071109533*x_91 - 0.000364091394318173*x_92 - 0.0240028250265379*x_93 + 0.00625928723415413*x_94 - 0.000784202007635403*x_96 + 0.00126681022008513*x_97 + 0.00806335515850481*x_98 + 0.00557870326517386*x_99 + 1.35172078459914e-5*std::pow(-6.29120016098022*x_103 - 8.73127937316895, 2) + 2.77410310731212e-5*std::pow(-7.40000009536743*x_110 - 9.99830055236816, 2) + 1.41770658531275e-5*std::pow(-7.57424020767212*x_14 - 9.37415981292725, 2) + 7.7913996577991e-5*std::pow(-7.54568004608154*x_14 - 9.38496017456055, 2) - 6.2031180160289e-6*std::pow(-6.60400009155273*x_14 - 9.96963977813721, 2) - 6.20984811730535e-6*std::pow(-7.48759984970093*x_15 - 9.33039951324463, 2) - 0.000145843029315901*std::pow(-6.43415975570679*x_15 - 9.8625602722168, 2) + 0.000191080147061931*std::pow(-6.26032018661499*x_15 - 8.67928028106689, 2) + 0.000444316436305778*std::pow(-3.6814398765564*x_17 - 5.03768014907837, 2) + 7.58152144128904e-5*std::pow(-8.16792011260986*x_18 - 9.38511943817139, 2) + 9.50372277042413e-6*std::pow(-5.65367984771729*x_18 - 5.04967975616455, 2) + 0.000143456754331667*std::pow(-3.69407987594604*x_24 - 5.24943971633911, 2) + 1.80370023562775e-5*std::pow(-3.49719977378845*x_24 - 4.73023986816406, 2) + 8.42304610647541e-6*std::pow(-8.15824031829834*x_42 - 8.98200035095215, 2) + 0.000220894332794329*std::pow(-3.84272003173828*x_7 - 5.66088008880615, 2) + 8.55039933366136e-5*std::pow(-5.1224799156189*x_70 - 7.08175992965698, 2) + 1.55918707941629e-5*std::pow(-5.91807985305786*x_73 - 8.91327953338623, 2) - 1.24385162928483e-5*std::pow(-6.00263977050781*x_74 - 7.00984001159668, 2) - 2.74690810557098e-5*std::pow(-6.09375953674316*x_76 - 8.72231960296631, 2) + 7.94808758019711e-5*std::pow(-5.88271999359131*x_77 - 8.51807975769043, 2) - 3.83560314040872e-5*std::pow(-3.11719989776611*x_80 - 4.28687953948975, 2) + 6.38208171584383e-5*std::pow(-7.35264015197754*x_81 - 9.76879978179932, 2) - 6.27891282547908e-5*std::pow(-3.48071980476379*x_87 - 4.91408014297485, 2) - 9.86875100491416e-6*std::pow(-6.8120002746582*x_88 - 6.61999988555908, 2) + 7.29747491190251e-5*std::pow(-6.38272047042847*x_88 - 5.97375965118408, 2) - 8.26929168081566e-5*std::pow(-7.00031995773315*x_90 - 9.3840799331665, 2) + 0.000109967413288935*std::pow(-5.30272006988525*x_97 - 6.53128004074097, 2) - 0.000756724818250743*std::exp(1.13743984699249*x_1) + 0.000706141699747596*std::exp(1.20167994499207*x_1) - 0.000230770293827925*std::exp(1.2125598192215*x_1) - 0.00152294294057898*std::exp(1.57423985004425*x_100) - 0.000480449228919368*std::exp(1.05679976940155*x_106) - 0.0103731098893846*std::exp(0.543039858341217*x_109) - 0.00173176484808751*std::exp(0.843999862670898*x_110) + 0.00111988566371714*std::exp(0.924159824848175*x_110) - 0.00086252177308586*std::exp(1.28303980827332*x_110) - 0.000236805097122499*std::exp(1.38351988792419*x_26) + 0.00619589960273007*std::exp(0.582799851894379*x_31) - 0.00249307506557886*std::exp(0.667519807815552*x_31) + 0.00490481317535064*std::exp(0.899439811706543*x_50) - 0.00119583271158733*std::exp(0.815839886665344*x_6) - 0.00163279805765148*std::exp(0.835679888725281*x_66) - 0.000480913091427887*std::exp(0.971119821071625*x_68) - 0.000528346446292037*std::exp(1.1723198890686*x_68) - 0.00337624654056924*std::exp(1.00575983524323*x_72) - 0.00575602392051083*std::exp(0.620319843292236*x_74) + 0.00987797481442127*std::exp(0.827759861946106*x_74) + 0.00181811883279664*std::exp(0.888719916343689*x_74) - 0.000252821931476508*std::exp(0.861039876937866*x_81) - 0.000434541049983492*std::exp(1.83999991416931*x_81) - 21.3556594522587*std::exp(0.0180014356306941*x_100 + 0.0108413919071186*x_101 + 0.00475255171469554*x_103 - 0.00486260578187553*x_104 + 0.00652816938429668*x_105 + 0.023112065544007*x_107 + 0.0148348060000395*x_108 - 0.0244346527703904*x_11 + 0.0109120113383707*x_114 - 0.021008612027005*x_116 + 0.0726491857885976*x_118 + 0.0168506359377575*x_119 + 0.110050881919778*x_12 + 0.0117296151280269*x_120 - 0.0186372013535658*x_13 - 0.0189956638480748*x_14 - 0.0186657031543924*x_15 - 0.0514523550323055*x_16 + 0.0132963439401147*x_18 - 0.0011257517575592*x_19 + 0.0445750347669163*x_2 + 0.00541782903504733*x_20 + 0.00388829393471134*x_21 - 0.0282830649982744*x_22 + 0.0124233284968554*x_23 + 0.0281378955605656*x_25 + 0.0485630186670229*x_26 - 0.0291638179172412*x_27 - 0.245855996397204*x_31 - 0.00846545270790128*x_33 - 0.0045398610798708*x_35 + 0.0138986985232005*x_36 + 0.0423988615637427*x_37 + 0.0185616878855946*x_38 - 0.00243488067280591*x_39 + 0.025158385325361*x_4 + 0.0434549629939046*x_40 + 0.034892839582306*x_41 - 0.0321391548841659*x_42 + 0.00495544305565514*x_43 + 0.0917333622862301*x_44 + 0.0055395167907068*x_45 - 0.00945281701991333*x_47 + 0.016804404357486*x_49 - 0.0163220145702168*x_5 + 0.0337309202709876*x_50 + 0.0180940131387343*x_52 + 0.006836620262446*x_53 + 0.0246684950970598*x_54 + 0.00641125905301363*x_56 + 6.74446955036507e-5*x_57 - 0.00252134046223912*x_58 - 0.024344809356947*x_59 - 0.0529350373159685*x_6 + 0.0235328998916394*x_60 + 0.0279128408281814*x_61 - 0.0198409394505014*x_62 - 0.00436234227824248*x_63 + 0.00651650691265572*x_64 + 0.000516661558614155*x_65 - 0.0256644881676244*x_66 + 0.0163271001624045*x_67 + 0.00641320860079227*x_68 + 0.00793601328758626*x_69 - 0.0348584211733851*x_7 + 0.0198974766467905*x_71 + 0.00546621610139261*x_72 + 0.0050387388703158*x_74 + 0.0297551697045981*x_75 + 0.0096655679523908*x_76 + 0.0232163508656395*x_77 + 0.0104988932544569*x_78 + 0.00772218959805583*x_8 - 0.00586916837164244*x_80 - 0.00870867899557017*x_81 + 0.0273650198103444*x_82 + 0.0253060301543338*x_83 + 0.00552394293751899*x_84 + 0.00785254935650829*x_86 - 0.0241163800627882*x_88 + 0.0138450060595128*x_89 - 0.0705361347362121*x_9 - 0.00679055772119094*x_91 + 0.0298581966558173*x_94 + 0.00998209239366296*x_97 + 0.0126299939715243*x_98 - 0.0169760980491984*x_99 + 0.000193003110593535*std::pow(-7.75808048248291*x_110 - 9.38607978820801, 2) - 0.000415757954111348*std::pow(-7.42991971969604*x_17 - 9.8689603805542, 2) + 0.00929435196142065*std::exp(0.63487982749939*x_1) + 0.00231706724916287*std::exp(1.3271199464798*x_106) - 0.0675297177907543*std::exp(0.620559811592102*x_109) - 0.0201132462539033*std::exp(0.692079842090607*x_70) + 0.0761835687591561*std::sin(0.397199839353561*x_10 - 4.18671989440918) + 0.125161567233816*std::sin(0.367999851703644*x_102 - 4.21712017059326) + 0.302882806592377*std::sin(0.328239858150482*x_111 - 7.45631980895996) + 1.00268862144137*std::sin(0.188320010900497*x_112 - 7.61392021179199) + 0.237820018893187*std::sin(0.278399974107742*x_113 + 5.07871961593628) + 0.0141215007542633*std::sin(0.704079866409302*x_115 - 0.953199863433838) - 0.0422214252185871*std::sin(0.276959955692291*x_117 - 7.5128002166748) + 0.72147610634488*std::sin(0.265519946813583*x_24 - 7.50544023513794) - 0.412817415441911*std::sin(0.337679862976074*x_28 - 4.26599979400635) - 0.0471932120644603*std::sin(0.649119853973389*x_29 + 5.44807958602905) + 0.843946320992615*std::sin(0.266879975795746*x_3 + 5.08120012283325) - 0.875165489250342*std::sin(0.239359974861145*x_32 - 4.39695978164673) - 0.256224284005873*std::sin(0.363679856061935*x_34 + 1.98031985759735) - 0.267290027338261*std::sin(0.392799854278564*x_46 - 4.20968008041382) + 0.109390421317115*std::sin(0.411759853363037*x_48 - 1.19631993770599) + 0.462028341548084*std::sin(0.328079849481583*x_51 - 7.46679973602295) - 0.509910441218135*std::sin(0.233839988708496*x_55 - 4.34647989273071) - 0.104089736173316*std::sin(0.441279858350754*x_73 + 8.44567966461182) - 0.0746532080737805*std::sin(0.473759859800339*x_79 + 2.05039978027344) - 1.03077298113199*std::sin(0.207039996981621*x_85 - 7.60423994064331) + 0.0397324102440433*std::sin(0.851599872112274*x_87 - 0.74703985452652) - 0.102171994787255*std::sin(0.615919828414917*x_90 + 5.41048002243042) + 0.141111018075559*std::sin(0.374959826469421*x_92 + 2.00839972496033) + 0.392121854374192*std::sin(0.2882399559021*x_93 - 1.32551980018616) - 0.196576501978667*std::sin(0.402799844741821*x_95 + 2.00415992736816) - 0.0735519732835188*std::sin(0.378239840269089*x_96 + 8.36672019958496) + 4.96056046183908e-5*std::exp(-2.02751994132996*x_30)) + 0.0441687520206906*std::sin(0.355119854211807*x_1 - 1.1522399187088) + 0.0292782839519226*std::sin(0.472399860620499*x_100 - 4.15240001678467) - 0.0218239749489865*std::sin(0.32711985707283*x_101 + 1.96655988693237) + 0.0466330614737913*std::sin(0.362559854984283*x_102 - 7.41928005218506) - 0.0295399955241609*std::sin(0.362959831953049*x_102 - 7.41296005249023) - 0.0456192963296293*std::sin(0.371519833803177*x_102 + 1.98631989955902) + 0.0119552151554564*std::sin(0.378719836473465*x_105 - 7.40032005310059) + 0.0144107426251192*std::sin(0.407439857721329*x_105 + 5.21447992324829) - 0.0563182905693425*std::sin(0.409599840641022*x_105 + 5.19664001464844) - 0.00832481009720481*std::sin(0.579839885234833*x_106 - 7.20016002655029) - 0.00996639143509108*std::sin(0.37679985165596*x_107 + 5.16760015487671) - 0.049610427993395*std::sin(0.422799855470657*x_108 + 5.2085599899292) - 0.0229721589341181*std::sin(0.571119844913483*x_108 + 5.39264011383057) - 0.0203515374347529*std::sin(0.346959829330444*x_111 - 7.44280004501343) + 0.0550434422209451*std::sin(0.379759848117828*x_111 - 4.20928001403809) + 0.0408924734002291*std::sin(0.413439869880676*x_111 - 4.19479990005493) - 0.00558907692545663*std::sin(0.415359854698181*x_111 + 5.20128011703491) + 0.167810553349892*std::sin(0.0988800674676895*x_112 - 7.72000026702881) + 0.0181501667780955*std::sin(0.484159857034683*x_112 - 7.34711980819702) - 0.0140738718994199*std::sin(0.326799839735031*x_113 + 5.14792013168335) - 0.103790356092037*std::sin(0.38919985294342*x_113 + 5.20240020751953) + 0.0511486711570695*std::sin(0.279999971389771*x_114 + 5.07415962219238) + 0.426178578809195*std::sin(0.114000059664249*x_115 - 7.71016025543213) - 0.018748704931708*std::sin(0.176960021257401*x_115 - 7.62800025939941) + 0.0346646009724304*std::sin(0.3852798640728*x_115 + 5.18304014205933) - 0.0114617681098475*std::sin(0.462399870157242*x_115 - 4.15016031265259) + 0.00523715440345293*std::sin(0.486959844827652*x_117 + 2.04119992256165) + 0.00542751635722084*std::sin(0.493199855089188*x_117 + 8.44624042510986) + 0.0298924089896031*std::sin(0.541919827461243*x_117 + 2.14631986618042) - 0.0116990959070617*std::sin(0.50111985206604*x_118 - 0.914959847927094) + 0.00866546737886762*std::sin(0.386239856481552*x_119 - 7.41991996765137) - 0.0168038260374325*std::sin(0.361839860677719*x_120 + 5.16088008880615) - 0.16047864798826*std::sin(0.320879846811295*x_16 + 5.12936019897461) - 0.00512127702739966*std::sin(0.387919843196869*x_16 + 8.37479972839355) - 0.0270411295222323*std::sin(0.428879857063293*x_16 + 2.01399970054626) - 0.0935531973903404*std::sin(0.362959831953049*x_2 + 8.34000015258789) - 0.0839378063571283*std::sin(0.341119855642319*x_23 + 8.32808017730713) + 0.0440410231929575*std::sin(0.337759852409363*x_24 - 4.27648019790649) - 0.00415190264865221*std::sin(0.429839849472046*x_24 - 4.17072010040283) + 0.0766725021244869*std::sin(0.335119843482971*x_28 - 4.26039981842041) - 0.00918837826283867*std::sin(0.346559852361679*x_28 + 5.15136003494263) + 0.0349129138898479*std::sin(0.35183984041214*x_28 + 5.15032005310059) + 0.0347764727032945*std::sin(0.277119934558868*x_3 + 5.07439994812012) + 0.0528997660636491*std::sin(0.262719959020615*x_31 - 1.11887979507446) - 0.04267886922894*std::sin(0.244239971041679*x_32 - 1.18919992446899) - 0.00733532223349443*std::sin(0.3642398416996*x_32 + 2.00423979759216) + 0.0273276014489928*std::sin(0.281919926404953*x_33 - 1.16639983654022) - 0.0172374821400687*std::sin(0.298799932003021*x_33 - 1.17119991779327) - 0.0245121112541555*std::sin(0.351039856672287*x_34 + 2.00447988510132) - 0.0675166474874064*std::sin(0.312479853630066*x_35 - 7.4268798828125) + 0.0406598941295253*std::sin(0.316559851169586*x_35 - 7.42767953872681) + 0.0084309779973594*std::sin(0.338959842920303*x_36 + 5.13944005966187) - 0.0211569458708542*std::sin(0.348479837179184*x_36 + 5.1482400894165) + 0.0326103237096978*std::sin(0.528879821300507*x_38 + 2.14799976348877) + 0.0335615123177804*std::sin(0.138880044221878*x_39 - 7.67199993133545) + 0.107758337870583*std::sin(0.450239837169647*x_4 + 5.25072002410889) - 0.0278009473574177*std::sin(0.142080038785934*x_40 + 1.71799993515015) - 0.00760586858627175*std::sin(0.303359925746918*x_41 + 5.1200795173645) + 0.0133390882851912*std::sin(0.383839845657349*x_43 + 8.36983966827393) + 0.0559214248975084*std::sin(0.403679847717285*x_45 + 5.20216035842896) - 0.00799710940715237*std::sin(0.585359811782837*x_45 - 0.991279780864716) - 0.0206569833902112*std::sin(0.206560000777245*x_48 - 7.60423994064331) - 0.0168031850516831*std::sin(0.346159845590591*x_48 - 7.44863986968994) - 0.0140333843259161*std::sin(0.565599858760834*x_49 - 4.01488018035889) + 0.0238591689528185*std::sin(0.331519842147827*x_50 - 7.47583961486816) + 0.0335341769238585*std::sin(0.312879920005798*x_51 - 7.46560001373291) - 0.039029953090975*std::sin(0.398239850997925*x_51 + 2.0032799243927) + 0.0234725752895915*std::sin(0.225839987397194*x_53 + 5.02431964874268) - 0.0129342875259895*std::sin(0.245759963989258*x_53 + 5.05375957489014) + 0.072039166563417*std::sin(0.365519851446152*x_53 + 5.17160034179688) - 0.054533281372064*std::sin(0.337839841842651*x_54 + 5.14088010787964) - 0.00669893233566134*std::sin(0.302159935235977*x_55 + 5.13935995101929) + 0.0208280461238841*std::sin(0.237999975681305*x_56 + 1.84207987785339) - 0.0299548993244406*std::sin(0.348079830408096*x_56 - 4.24767971038818) + 0.344589833962373*std::sin(0.219359993934631*x_58 + 5.00799989700317) - 0.00334858547302864*std::sin(0.453039854764938*x_58 - 7.33599948883057) + 0.0181011466181938*std::sin(0.202479988336563*x_59 - 7.59496021270752) - 0.0820118472007444*std::sin(0.252719968557358*x_59 - 7.53144025802612) + 0.00423194007857183*std::sin(0.434399873018265*x_59 - 4.15543985366821) + 0.0267086876734763*std::sin(0.284879922866821*x_63 - 4.28927946090698) + 0.0836542442632*std::sin(0.218400001525879*x_64 - 4.37687969207764) + 0.0114486182424026*std::sin(0.265199959278107*x_64 + 5.0732798576355) + 0.00776980266910096*std::sin(0.549919843673706*x_64 + 8.54447937011719) - 0.0767121423791703*std::sin(0.209519997239113*x_66 + 5.01255941390991) + 0.0243170593606934*std::sin(0.185360014438629*x_67 + 4.98880004882813) + 0.00343430634147294*std::sin(0.215919986367226*x_67 - 1.38919985294342) + 0.0370513390401605*std::sin(0.14264003932476*x_70 + 4.91504001617432) + 0.103733069765741*std::sin(0.252799987792969*x_70 + 5.05615997314453) - 0.00472944958342464*std::sin(0.45839986205101*x_70 - 4.14351987838745) + 0.0119263020087836*std::sin(0.265119969844818*x_71 + 5.10031986236572) - 0.0056073419985405*std::sin(0.417279869318008*x_72 - 4.16544008255005) + 0.0845015457761285*std::sin(0.22639998793602*x_73 - 4.35999965667725) - 0.131988905285261*std::sin(0.241039976477623*x_73 + 5.03599977493286) + 0.0895255195296673*std::sin(0.286959916353226*x_75 + 5.10399961471558) - 0.00269779899804609*std::sin(0.50631982088089*x_75 + 5.28976011276245) - 0.104274219772538*std::sin(0.201439991593361*x_77 + 5.00008010864258) - 0.129786075609625*std::sin(0.177760004997253*x_78 - 7.61360025405884) + 0.0273162789292863*std::sin(0.305519849061966*x_79 + 5.10823965072632) + 0.0213199527929278*std::sin(0.354479849338531*x_79 + 5.14448022842407) + 0.035701673838566*std::sin(0.429439842700958*x_79 - 1.17511987686157) + 0.0295708370921348*std::sin(0.389599829912186*x_80 - 4.22240018844604) + 0.00492262601529559*std::sin(0.34639984369278*x_81 + 5.13544034957886) - 0.0373679138606024*std::sin(0.201279997825623*x_83 + 5.00423955917358) - 0.110854716728967*std::sin(0.329919844865799*x_83 - 7.47191953659058) + 0.0664588711052619*std::sin(0.262319952249527*x_84 - 7.53927993774414) - 0.0616309563788532*std::sin(0.274719953536987*x_84 - 7.52063989639282) - 0.0046615621617843*std::sin(0.285919934511185*x_84 - 7.49776029586792) + 0.086661429187116*std::sin(0.181760013103485*x_85 + 4.96687984466553) - 0.0478058312963656*std::sin(0.218719989061356*x_85 + 1.81463992595673) - 0.395154667590418*std::sin(0.239359974861145*x_86 + 5.04375982284546) + 0.0138925892311454*std::sin(0.274719953536987*x_86 + 5.07567977905273) - 0.0187747365092203*std::sin(0.263039976358414*x_87 + 5.06744003295898) + 0.0184951707343201*std::sin(0.369199842214584*x_87 + 5.17087984085083) - 0.219580593191574*std::sin(0.135120034217834*x_89 + 4.91599988937378) - 0.364351489381432*std::sin(0.136560037732124*x_89 - 7.68688011169434) - 0.0407078054614199*std::sin(0.167120009660721*x_89 + 1.74775993824005) - 0.0151132488387779*std::sin(0.231359988451004*x_89 - 7.56800031661987) + 0.0295781873315145*std::sin(0.257439970970154*x_90 + 5.07199954986572) - 0.00872236311252713*std::sin(0.346959829330444*x_92 + 5.19504022598267) - 0.0189687954833457*std::sin(0.362319827079773*x_92 - 7.40927982330322) - 0.0682308988107899*std::sin(0.359519839286804*x_94 - 1.19071984291077) - 0.0178694100873694*std::sin(0.384239852428436*x_94 + 2.00543975830078) + 0.0111817249230489*std::sin(0.359839856624603*x_95 - 4.23415994644165) + 0.00926899190952167*std::sin(0.380559861660004*x_95 - 7.42167997360229) + 0.0244366145904697*std::sin(0.38623982667923*x_95 - 4.19471979141235) + 0.0177641893176743*std::sin(0.399759858846664*x_95 + 5.18351984024048) + 0.016655560528324*std::sin(0.377199828624725*x_96 - 7.40903997421265) + 0.00623268022662363*std::sin(0.381439834833145*x_96 - 7.39928007125854) + 0.0164486545898732*std::sin(0.396879822015762*x_96 + 5.18616008758545) - 0.00699291951284127*std::sin(0.315919935703278*x_97 + 5.12328004837036) + 0.0120736075584821*std::sin(0.417759865522385*x_98 - 7.40039968490601) + 0.0571263635544239*std::sin(0.42223984003067*x_98 - 7.3790397644043) - 0.013660596734691*std::sin(0.324319928884506*x_99 + 1.9210399389267) - 0.0702192367410111*std::sin(0.333199828863144*x_99 + 1.93759977817535) + 0.00865131061607483*std::sin(0.359599858522415*x_99 + 1.94671976566315) - 0.0320933286532552);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.287798016824529*x_10 + 0.00128164375341655*x_100 - 0.54918927005278*x_101 + 1.18645577172457e-5*x_102 - 0.160512426744425*x_103 + 0.137289850611108*x_104 - 0.0675003906895481*x_105 + 0.0294742821474389*x_106 - 0.0900935618424516*x_107 + 0.00240797182960963*x_108 + 4.67862599370313e-5*x_109 - 0.319483237698195*x_11 + 0.0152584291996652*x_112 + 0.122536360160526*x_113 + 0.0144384211538877*x_114 - 0.0344411287413568*x_116 + 0.0117184471691585*x_117 + 0.00227954053143232*x_118 - 0.0595287341331136*x_119 + 0.114865577340218*x_12 + 0.0602621305167133*x_120 - 0.0306180489284243*x_13 - 0.0106734635809804*x_14 - 0.00215321302909101*x_15 - 0.00450779376364151*x_16 + 0.0798173601481878*x_17 + 0.144500798332481*x_18 + 0.151573211124572*x_19 + 0.00725469203896917*x_2 - 0.0870288340413346*x_20 + 0.210745628057064*x_21 + 0.169527257673398*x_22 + 0.0476239694425236*x_23 + 0.239826586756067*x_25 - 0.185539444710716*x_26 - 0.0778422337103499*x_27 - 4.10802972076376e-5*x_28 - 0.114383366718772*x_29 + 0.382907517557752*x_3 + 0.103452982115087*x_30 - 0.0214287070737622*x_31 + 0.0414803099799052*x_32 - 0.0776847041696489*x_33 + 0.160642020064386*x_34 + 0.000101813092584366*x_35 - 0.00378652863329801*x_36 - 0.0371960754674443*x_37 + 0.0621652676678226*x_38 + 0.0964108057061119*x_39 + 0.00162241359566356*x_4 + 0.177322721661797*x_40 + 0.00579891849641174*x_41 + 0.081795591653873*x_42 + 0.00970944572614494*x_43 + 0.192954940965353*x_44 + 0.00436359196215851*x_45 + 0.0511866300740068*x_46 + 0.0789172856371948*x_47 - 0.022727679802809*x_48 - 0.024577307410139*x_49 - 0.00574748976967392*x_5 - 0.00134205305874716*x_50 - 0.000977975368495549*x_51 + 0.103360014552184*x_52 + 0.000456895167600572*x_53 + 0.0661545638020253*x_54 - 0.022740192666248*x_55 - 0.0166418706796301*x_56 - 0.0350241887820796*x_57 + 0.00382241982072375*x_58 - 0.00481230330668361*x_59 + 0.00948223747501824*x_6 - 0.00757034905806083*x_60 + 0.00710553790086173*x_61 - 0.162843512542461*x_62 + 0.0549656804927751*x_63 + 0.000185530447372265*x_64 + 0.00384262770993238*x_65 - 0.0239894245067227*x_66 + 0.0737024080538981*x_67 + 0.0367498333207253*x_68 - 0.190656371241689*x_69 - 0.00213163488986881*x_7 + 0.0199719433767833*x_71 - 0.00541957285686921*x_72 - 8.92806083831187e-6*x_73 + 0.000411157975411346*x_74 - 0.0272645373893325*x_75 - 0.0552518274370822*x_76 - 0.0859772213043638*x_77 + 0.183923561662661*x_78 - 0.0072604949830329*x_79 - 0.134743584699639*x_8 - 0.0897501942736257*x_80 - 0.000710622819813153*x_81 + 0.0510669886082956*x_82 + 0.151446824458934*x_83 + 0.00200776868936976*x_84 + 0.0111854747532137*x_85 + 0.0273952994291152*x_86 + 0.00462101401478802*x_87 + 0.0907962263430305*x_88 + 0.00112974393146719*x_89 + 0.123793512969744*x_9 + 0.0548720797884586*x_90 - 0.0910416663495294*x_91 + 0.00829489031866822*x_92 + 0.145425902315789*x_93 + 0.112870226901303*x_94 + 0.000752098778488537*x_96 + 0.00111109996916716*x_97 + 0.163563992763658*x_98 + 0.113298389660393*x_99 + 1.37645222717139e-5*std::pow(-6.29120016098022*x_103 - 8.73127937316895, 2) + 1.57489344540604e-5*std::pow(-7.75808048248291*x_110 - 9.38607978820801, 2) - 2.66053840476869e-5*std::pow(-7.40000009536743*x_110 - 9.99830055236816, 2) + 1.44364532162459e-5*std::pow(-7.57424020767212*x_14 - 9.37415981292725, 2) + 0.00160170911306034*std::pow(-7.54568004608154*x_14 - 9.38496017456055, 2) + 2.65122993629751e-6*std::pow(-6.60400009155273*x_14 - 9.96963977813721, 2) + 2.65410640034871e-6*std::pow(-7.48759984970093*x_15 - 9.33039951324463, 2) + 0.000139872587842894*std::pow(-6.43415975570679*x_15 - 9.8625602722168, 2) + 0.00392811081854397*std::pow(-6.26032018661499*x_15 - 8.67928028106689, 2) - 3.39255919136115e-5*std::pow(-7.42991971969604*x_17 - 9.8689603805542, 2) - 0.000426127255164234*std::pow(-3.6814398765564*x_17 - 5.03768014907837, 2) - 7.27115329922642e-5*std::pow(-8.16792011260986*x_18 - 9.38511943817139, 2) - 4.06191761145164e-6*std::pow(-5.65367984771729*x_18 - 5.04967975616455, 2) - 0.000137584000867465*std::pow(-3.69407987594604*x_24 - 5.24943971633911, 2) - 7.70906509991648e-6*std::pow(-3.49719977378845*x_24 - 4.73023986816406, 2) + 8.57715639570014e-6*std::pow(-8.15824031829834*x_42 - 8.98200035095215, 2) + 0.00454101292963327*std::pow(-3.84272003173828*x_7 - 5.66088008880615, 2) + 0.00175773970461413*std::pow(-5.1224799156189*x_70 - 7.08175992965698, 2) + 1.58771438043386e-5*std::pow(-5.91807985305786*x_73 - 8.91327953338623, 2) + 5.31625654606442e-6*std::pow(-6.00263977050781*x_74 - 7.00984001159668, 2) - 2.79716626601223e-5*std::pow(-6.09375953674316*x_76 - 8.72231960296631, 2) - 7.62271315577322e-5*std::pow(-5.88271999359131*x_77 - 8.51807975769043, 2) + 1.6393474770803e-5*std::pow(-3.11719989776611*x_80 - 4.28687953948975, 2) - 6.12081557553447e-5*std::pow(-7.35264015197754*x_81 - 9.76879978179932, 2) - 6.39379348258572e-5*std::pow(-3.48071980476379*x_87 - 4.91408014297485, 2) + 4.21793169668637e-6*std::pow(-6.8120002746582*x_88 - 6.61999988555908, 2) - 6.99873490995236e-5*std::pow(-6.38272047042847*x_88 - 5.97375965118408, 2) + 7.93076798012792e-5*std::pow(-7.00031995773315*x_90 - 9.3840799331665, 2) - 0.000105465627992379*std::pow(-5.30272006988525*x_97 - 6.53128004074097, 2) + 0.000758413371594048*std::exp(0.63487982749939*x_1) + 0.000725746435123829*std::exp(1.13743984699249*x_1) - 0.000301806931417587*std::exp(1.20167994499207*x_1) - 0.000234992528430079*std::exp(1.2125598192215*x_1) - 0.0313077456391873*std::exp(1.57423985004425*x_100) + 0.00020534534008391*std::exp(1.05679976940155*x_106) + 0.00018907125445023*std::exp(1.3271199464798*x_106) - 0.213244158563635*std::exp(0.543039858341217*x_109) - 0.00551038320531303*std::exp(0.620559811592102*x_109) - 0.00176344967780758*std::exp(0.843999862670898*x_110) - 0.000478642255266653*std::exp(0.924159824848175*x_110) - 0.017731204210295*std::exp(1.28303980827332*x_110) + 0.000227110900701105*std::exp(1.38351988792419*x_26) - 0.00594225528305129*std::exp(0.582799851894379*x_31) + 0.0010655472345069*std::exp(0.667519807815552*x_31) + 0.100830201322733*std::exp(0.899439811706543*x_50) - 0.00121771198456263*std::exp(0.815839886665344*x_6) + 0.00069786244259549*std::exp(0.835679888725281*x_66) + 0.000205543596213446*std::exp(0.971119821071625*x_68) - 0.000538013213233551*std::exp(1.1723198890686*x_68) - 0.00164122845448954*std::exp(0.692079842090607*x_70) - 0.0694068471581364*std::exp(1.00575983524323*x_72) - 0.00586133766330187*std::exp(0.620319843292236*x_74) - 0.00947359573111526*std::exp(0.827759861946106*x_74) + 0.0373757942220564*std::exp(0.888719916343689*x_74) - 0.000257447628699303*std::exp(0.861039876937866*x_81) - 0.00893303373368442*std::exp(1.83999991416931*x_81) + 0.907994657329982*std::sin(0.355119854211807*x_1 - 1.1522399187088) + 0.0062165320920198*std::sin(0.397199839353561*x_10 - 4.18671989440918) - 0.0280797057162334*std::sin(0.472399860620499*x_100 - 4.15240001678467) - 0.0222232721923954*std::sin(0.32711985707283*x_101 + 1.96655988693237) - 0.0447240229304864*std::sin(0.362559854984283*x_102 - 7.41928005218506) - 0.0300804671298459*std::sin(0.362959831953049*x_102 - 7.41296005249023) + 0.0102131064751807*std::sin(0.367999851703644*x_102 - 4.21712017059326) - 0.937814075413603*std::sin(0.371519833803177*x_102 + 1.98631989955902) - 0.00510969229234731*std::sin(0.378719836473465*x_105 - 7.40032005310059) + 0.0146744054005364*std::sin(0.407439857721329*x_105 + 5.21447992324829) + 0.0540127634606336*std::sin(0.409599840641022*x_105 + 5.19664001464844) - 0.00847712303430661*std::sin(0.579839885234833*x_106 - 7.20016002655029) - 0.0101487391804522*std::sin(0.37679985165596*x_107 + 5.16760015487671) + 0.0475795036621141*std::sin(0.422799855470657*x_108 + 5.2085599899292) - 0.472247836428417*std::sin(0.571119844913483*x_108 + 5.39264011383057) + 0.0247150496881422*std::sin(0.328239858150482*x_111 - 7.45631980895996) - 0.0207238945702346*std::sin(0.346959829330444*x_111 - 7.44280004501343) + 1.13155000246005*std::sin(0.379759848117828*x_111 - 4.20928001403809) - 0.0392184398844159*std::sin(0.413439869880676*x_111 - 4.19479990005493) + 0.00238878706204696*std::sin(0.415359854698181*x_111 + 5.20128011703491) + 0.170880859814419*std::sin(0.0988800674676895*x_112 - 7.72000026702881) + 0.0818187713573636*std::sin(0.188320010900497*x_112 - 7.61392021179199) + 0.373120219843176*std::sin(0.484159857034683*x_112 - 7.34711980819702) + 0.0194059664525307*std::sin(0.278399974107742*x_113 + 5.07871961593628) - 0.0143313711985468*std::sin(0.326799839735031*x_113 + 5.14792013168335) + 0.0995414437551448*std::sin(0.38919985294342*x_113 + 5.20240020751953) - 0.0490547750757979*std::sin(0.279999971389771*x_114 + 5.07415962219238) + 8.76112307737291*std::sin(0.114000059664249*x_115 - 7.71016025543213) + 0.00801324876510644*std::sin(0.176960021257401*x_115 - 7.62800025939941) + 0.0352988337207962*std::sin(0.3852798640728*x_115 + 5.18304014205933) + 0.010992552570387*std::sin(0.462399870157242*x_115 - 4.15016031265259) + 0.0011523057275498*std::sin(0.704079866409302*x_115 - 0.953199863433838) - 0.00344524218433408*std::sin(0.276959955692291*x_117 - 7.5128002166748) + 0.00533297477171736*std::sin(0.486959844827652*x_117 + 2.04119992256165) - 0.00231973562470124*std::sin(0.493199855089188*x_117 + 8.44624042510986) + 0.614510177796461*std::sin(0.541919827461243*x_117 + 2.14631986618042) - 0.240502982158675*std::sin(0.50111985206604*x_118 - 0.914959847927094) + 0.00882401307209351*std::sin(0.386239856481552*x_119 - 7.41991996765137) - 0.0171112733027063*std::sin(0.361839860677719*x_120 + 5.16088008880615) + 0.153909061632468*std::sin(0.320879846811295*x_16 + 5.12936019897461) - 0.00521497727240791*std::sin(0.387919843196869*x_16 + 8.37479972839355) - 0.555895288208577*std::sin(0.428879857063293*x_16 + 2.01399970054626) + 0.0897233682085712*std::sin(0.362959831953049*x_2 + 8.34000015258789) + 0.0805016067486966*std::sin(0.341119855642319*x_23 + 8.32808017730713) + 0.0588720040524408*std::sin(0.265519946813583*x_24 - 7.50544023513794) + 0.905368884858204*std::sin(0.337759852409363*x_24 - 4.27648019790649) - 0.00422786696250356*std::sin(0.429839849472046*x_24 - 4.17072010040283) + 1.57618721625967*std::sin(0.335119843482971*x_28 - 4.26039981842041) - 0.0336856457768773*std::sin(0.337679862976074*x_28 - 4.26599979400635) - 0.00935649127251384*std::sin(0.346559852361679*x_28 + 5.15136003494263) - 0.0334836682823671*std::sin(0.35183984041214*x_28 + 5.15032005310059) - 0.00385093691596002*std::sin(0.649119853973389*x_29 + 5.44807958602905) + 0.0688654978211701*std::sin(0.266879975795746*x_3 + 5.08120012283325) + 0.0354127522865679*std::sin(0.277119934558868*x_3 + 5.07439994812012) + 1.0874815964304*std::sin(0.262719959020615*x_31 - 1.11887979507446) - 0.0714129626422771*std::sin(0.239359974861145*x_32 - 4.39695978164673) - 0.0434597331583918*std::sin(0.244239971041679*x_32 - 1.18919992446899) + 0.00313513717578423*std::sin(0.3642398416996*x_32 + 2.00423979759216) - 0.0116798930572595*std::sin(0.281919926404953*x_33 - 1.16639983654022) - 0.0175528636926011*std::sin(0.298799932003021*x_33 - 1.17119991779327) + 0.0104765446975126*std::sin(0.351039856672287*x_34 + 2.00447988510132) - 0.0209077431028836*std::sin(0.363679856061935*x_34 + 1.98031985759735) - 1.3879666595669*std::sin(0.312479853630066*x_35 - 7.4268798828125) - 0.0389953818155829*std::sin(0.316559851169586*x_35 - 7.42767953872681) - 0.00360342350429348*std::sin(0.338959842920303*x_36 + 5.13944005966187) - 0.0215440389730471*std::sin(0.348479837179184*x_36 + 5.1482400894165) - 0.0312753402686803*std::sin(0.528879821300507*x_38 + 2.14799976348877) + 0.0341755626630749*std::sin(0.138880044221878*x_39 - 7.67199993133545) + 2.21523114403174*std::sin(0.450239837169647*x_4 + 5.25072002410889) + 0.0118822024183577*std::sin(0.142080038785934*x_40 + 1.71799993515015) - 0.00774502757849601*std::sin(0.303359925746918*x_41 + 5.1200795173645) + 0.0135831437881101*std::sin(0.383839845657349*x_43 + 8.36983966827393) + 1.14959904263158*std::sin(0.403679847717285*x_45 + 5.20216035842896) + 0.00766972815422177*std::sin(0.585359811782837*x_45 - 0.991279780864716) - 0.0218107009147618*std::sin(0.392799854278564*x_46 - 4.20968008041382) - 0.0210349290460386*std::sin(0.206560000777245*x_48 - 7.60423994064331) + 0.0071817281436616*std::sin(0.346159845590591*x_48 - 7.44863986968994) + 0.00892619072266396*std::sin(0.411759853363037*x_48 - 1.19631993770599) + 0.0134588933805545*std::sin(0.565599858760834*x_49 - 4.01488018035889) + 0.0242957026463898*std::sin(0.331519842147827*x_50 - 7.47583961486816) + 0.0341477271335238*std::sin(0.312879920005798*x_51 - 7.46560001373291) + 0.0377012269107064*std::sin(0.328079849481583*x_51 - 7.46679973602295) + 0.0374321664040356*std::sin(0.398239850997925*x_51 + 2.0032799243927) - 0.0225116679521301*std::sin(0.225839987397194*x_53 + 5.02431964874268) + 0.00552815055347533*std::sin(0.245759963989258*x_53 + 5.05375957489014) + 1.48093788856533*std::sin(0.365519851446152*x_53 + 5.17160034179688) - 0.0555310367753214*std::sin(0.337839841842651*x_54 + 5.14088010787964) - 0.041608376629213*std::sin(0.233839988708496*x_55 - 4.34647989273071) + 0.0028631423589949*std::sin(0.302159935235977*x_55 + 5.13935995101929) - 0.00890196498850064*std::sin(0.237999975681305*x_56 + 1.84207987785339) - 0.0305029621202786*std::sin(0.348079830408096*x_56 - 4.24767971038818) + 7.08387069803309*std::sin(0.219359993934631*x_58 + 5.00799989700317) + 0.00143119476808341*std::sin(0.453039854764938*x_58 - 7.33599948883057) + 0.0184323300054585*std::sin(0.202479988336563*x_59 - 7.59496021270752) - 1.68595026323486*std::sin(0.252719968557358*x_59 - 7.53144025802612) - 0.00180874298956343*std::sin(0.434399873018265*x_59 - 4.15543985366821) + 0.0271973569185619*std::sin(0.284879922866821*x_63 - 4.28927946090698) + 1.71971367491617*std::sin(0.218400001525879*x_64 - 4.37687969207764) - 0.00489317135915639*std::sin(0.265199959278107*x_64 + 5.0732798576355) - 0.00745172677400832*std::sin(0.549919843673706*x_64 + 8.54447937011719) + 0.0735717430162928*std::sin(0.209519997239113*x_66 + 5.01255941390991) + 0.02476197073881*std::sin(0.185360014438629*x_67 + 4.98880004882813) - 0.00146783210627328*std::sin(0.215919986367226*x_67 - 1.38919985294342) + 0.0377292401822726*std::sin(0.14264003932476*x_70 + 4.91504001617432) - 0.0994865025848704*std::sin(0.252799987792969*x_70 + 5.05615997314453) + 0.00202137993915071*std::sin(0.45839986205101*x_70 - 4.14351987838745) - 0.00509733473284042*std::sin(0.265119969844818*x_71 + 5.10031986236572) + 0.00239659360521178*std::sin(0.417279869318008*x_72 - 4.16544008255005) + 1.73713199016597*std::sin(0.22639998793602*x_73 - 4.35999965667725) + 0.126585616298545*std::sin(0.241039976477623*x_73 + 5.03599977493286) - 0.0084936580933474*std::sin(0.441279858350754*x_73 + 8.44567966461182) - 0.0858605732021015*std::sin(0.286959916353226*x_75 + 5.10399961471558) - 0.00274715864520978*std::sin(0.50631982088089*x_75 + 5.28976011276245) - 0.106182048598914*std::sin(0.201439991593361*x_77 + 5.00008010864258) + 0.124472964848877*std::sin(0.177760004997253*x_78 - 7.61360025405884) + 0.0278160648254005*std::sin(0.305519849061966*x_79 + 5.10823965072632) - 0.00911220727044064*std::sin(0.354479849338531*x_79 + 5.14448022842407) + 0.733933553023413*std::sin(0.429439842700958*x_79 - 1.17511987686157) - 0.00609165560660496*std::sin(0.473759859800339*x_79 + 2.05039978027344) - 0.0283602824773922*std::sin(0.389599829912186*x_80 - 4.22240018844604) - 0.00210394408476909*std::sin(0.34639984369278*x_81 + 5.13544034957886) - 0.0380516071397304*std::sin(0.201279997825623*x_83 + 5.00423955917358) + 0.106316607493705*std::sin(0.329919844865799*x_83 - 7.47191953659058) - 0.063738214505099*std::sin(0.262319952249527*x_84 - 7.53927993774414) - 1.26697215922971*std::sin(0.274719953536987*x_84 - 7.52063989639282) + 0.00199236466585012*std::sin(0.285919934511185*x_84 - 7.49776029586792) + 1.78153357517597*std::sin(0.181760013103485*x_85 + 4.96687984466553) - 0.08411043773824*std::sin(0.207039996981621*x_85 - 7.60423994064331) - 0.0486804994858282*std::sin(0.218719989061356*x_85 + 1.81463992595673) + 0.378978043814154*std::sin(0.239359974861145*x_86 + 5.04375982284546) + 0.0141467717344142*std::sin(0.274719953536987*x_86 + 5.07567977905273) + 0.00802437473391941*std::sin(0.263039976358414*x_87 + 5.06744003295898) + 0.380212603817778*std::sin(0.369199842214584*x_87 + 5.17087984085083) + 0.00324214010184061*std::sin(0.851599872112274*x_87 - 0.74703985452652) - 4.51400586047574*std::sin(0.135120034217834*x_89 + 4.91599988937378) + 0.349435869120674*std::sin(0.136560037732124*x_89 - 7.68688011169434) - 0.0414526062845497*std::sin(0.167120009660721*x_89 + 1.74775993824005) + 0.0064594446941915*std::sin(0.231359988451004*x_89 - 7.56800031661987) + 0.0301193577046528*std::sin(0.257439970970154*x_90 + 5.07199954986572) - 0.00833717158234743*std::sin(0.615919828414917*x_90 + 5.41048002243042) + 0.00372796231498964*std::sin(0.346959829330444*x_92 + 5.19504022598267) - 0.0193158536047462*std::sin(0.362319827079773*x_92 - 7.40927982330322) + 0.0115145717993012*std::sin(0.374959826469421*x_92 + 2.00839972496033) + 0.031996900793736*std::sin(0.2882399559021*x_93 - 1.32551980018616) + 0.06543769991804*std::sin(0.359519839286804*x_94 - 1.19071984291077) - 0.0181963535615032*std::sin(0.384239852428436*x_94 + 2.00543975830078) + 0.0113863087327704*std::sin(0.359839856624603*x_95 - 4.23415994644165) - 0.00396159298699836*std::sin(0.380559861660004*x_95 - 7.42167997360229) - 0.0234362419439663*std::sin(0.38623982667923*x_95 - 4.19471979141235) + 0.365185527195576*std::sin(0.399759858846664*x_95 + 5.18351984024048) - 0.0160405209809826*std::sin(0.402799844741821*x_95 + 2.00415992736816) + 0.34239500286243*std::sin(0.377199828624725*x_96 - 7.40903997421265) - 0.00600179552882162*std::sin(0.378239840269089*x_96 + 8.36672019958496) + 0.0063467149998195*std::sin(0.381439834833145*x_96 - 7.39928007125854) - 0.00703020083574147*std::sin(0.396879822015762*x_96 + 5.18616008758545) - 0.143756236395904*std::sin(0.315919935703278*x_97 + 5.12328004837036) - 0.00516029353551583*std::sin(0.417759865522385*x_98 - 7.40039968490601) - 0.054787755999663*std::sin(0.42223984003067*x_98 - 7.3790397644043) - 0.0139105346416137*std::sin(0.324319928884506*x_99 + 1.9210399389267) + 0.0673446403670334*std::sin(0.333199828863144*x_99 + 1.93759977817535) - 0.00369759427988919*std::sin(0.359599858522415*x_99 + 1.94671976566315) + 10.5755531494284 + 4.04778665632161e-6*std::exp(-2.02751994132996*x_30));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0955797169263799*x_10 - 0.00313692897558589*x_100 + 0.219213656696602*x_101 - 1.41991968279126e-6*x_102 + 0.0770979546942632*x_103 - 0.0687957433821917*x_104 + 0.0283955620315099*x_105 + 0.0154014475595993*x_106 + 0.064881892196736*x_107 - 0.00195404223144942*x_108 + 0.000847275327255534*x_109 + 0.173361201111488*x_11 + 0.036645334853004*x_112 - 0.053102531753321*x_113 - 0.00690027935075854*x_114 + 0.0482239829449888*x_116 + 0.0285585402016518*x_117 - 0.0211423094000405*x_118 + 0.0362653762531161*x_119 - 0.0875356411268235*x_12 - 0.0216912988937732*x_120 + 0.073718473343527*x_13 - 0.0190515329179021*x_14 + 0.00264963658593234*x_15 + 0.00865805858836114*x_16 - 0.0325298702099034*x_17 - 0.0649744436157733*x_18 - 0.0657200798988225*x_19 - 0.00718623824964102*x_2 + 0.018648122040317*x_20 - 0.0965436005277905*x_21 - 0.251710438439405*x_22 - 0.0182778182221065*x_23 - 0.183449923417413*x_25 + 0.0758936494365947*x_26 + 0.0231358365301793*x_27 + 4.91638407180179e-6*x_28 + 0.0193911624422349*x_29 - 0.177773863019952*x_3 - 0.076069109609082*x_30 + 0.0401573730403432*x_31 + 0.0223697037808035*x_32 + 0.0373407429514988*x_33 - 0.0895847659355092*x_34 + 0.000944827479083535*x_35 - 0.00559872622415621*x_36 - 0.0268311026078314*x_37 - 0.0299015229390461*x_38 - 0.0496236262928404*x_39 - 0.0106320924150246*x_4 - 0.0912599548635667*x_40 - 0.000848290278781163*x_41 - 0.0490504713810465*x_42 - 0.0100390052266108*x_43 - 0.0543263737094456*x_44 + 0.00191183672176462*x_45 - 0.021120621912368*x_46 - 0.0425592260499091*x_47 + 0.0273960559788866*x_48 + 0.0096150631518743*x_49 + 0.0226675832164039*x_5 - 0.0157847156292014*x_50 + 0.000402626310028718*x_51 - 0.0153187747941506*x_52 - 0.00122207748078509*x_53 - 0.0355124235863298*x_54 + 0.00381381182297536*x_55 + 0.0116039406626085*x_56 - 0.00140930745116915*x_57 + 0.00919374456239864*x_58 - 0.00280752877837257*x_59 - 0.00708673254660173*x_6 - 6.56328796087317e-5*x_60 - 0.0139826445036478*x_61 + 0.12398544239515*x_62 - 0.0125420555033958*x_63 - 0.00135443552522491*x_64 - 0.00902210615827479*x_65 + 0.0139717055449921*x_66 - 0.035980571097345*x_67 + 0.0253626720625132*x_68 + 0.0750422739474773*x_69 + 0.00466501169277799*x_7 - 0.0118848341058627*x_71 - 0.00583580070227471*x_72 + 1.0684873061092e-6*x_73 - 0.000844260153557164*x_74 + 0.00797247703486292*x_75 + 0.013179441884891*x_76 + 0.0341624667400447*x_77 - 0.0804351598091322*x_78 - 0.0176942503442396*x_79 + 0.0576778037253591*x_8 + 0.0395668792822552*x_80 + 0.0014591727921037*x_81 - 0.00444670414864756*x_82 - 0.0688858729172745*x_83 + 0.000255294114072698*x_84 + 0.0266703976266945*x_85 - 0.0128515717763384*x_86 + 0.0112616810579687*x_87 - 0.0330758926690504*x_88 - 0.00231978422431556*x_89 - 0.0131460419411564*x_9 - 0.0235792641187996*x_90 - 0.00606462851033995*x_91 - 0.00157648667305862*x_92 + 0.00177957824745217*x_93 - 0.0529876840344376*x_94 + 0.00183290865172031*x_96 - 0.00118973321804246*x_97 - 0.0723668372755776*x_98 - 0.0468659518537017*x_99 + 1.04390964071224e-5*std::pow(-6.29120016098022*x_103 - 8.73127937316895, 2) - 3.23384164134102e-5*std::pow(-7.75808048248291*x_110 - 9.38607978820801, 2) - 6.48388748900092e-5*std::pow(-7.40000009536743*x_110 - 9.99830055236816, 2) + 1.09486928733444e-5*std::pow(-7.57424020767212*x_14 - 9.37415981292725, 2) - 0.000694271202429297*std::pow(-7.54568004608154*x_14 - 9.38496017456055, 2) - 3.17292364356941e-7*std::pow(-6.60400009155273*x_14 - 9.96963977813721, 2) - 3.17636612159553e-7*std::pow(-7.48759984970093*x_15 - 9.33039951324463, 2) + 0.000340877666243488*std::pow(-6.43415975570679*x_15 - 9.8625602722168, 2) - 0.00170266510880701*std::pow(-6.26032018661499*x_15 - 8.67928028106689, 2) + 6.96618505571932e-5*std::pow(-7.42991971969604*x_17 - 9.8689603805542, 2) - 0.00103849701005233*std::pow(-3.6814398765564*x_17 - 5.03768014907837, 2) - 0.000177202252833335*std::pow(-8.16792011260986*x_18 - 9.38511943817139, 2) + 4.86119828806867e-7*std::pow(-5.65367984771729*x_18 - 5.04967975616455, 2) - 0.000335300246112705*std::pow(-3.69407987594604*x_24 - 5.24943971633911, 2) + 9.22601038501396e-7*std::pow(-3.49719977378845*x_24 - 4.73023986816406, 2) + 6.50496695389719e-6*std::pow(-8.15824031829834*x_42 - 8.98200035095215, 2) - 0.00196833150363971*std::pow(-3.84272003173828*x_7 - 5.66088008880615, 2) - 0.000761903674224896*std::pow(-5.1224799156189*x_70 - 7.08175992965698, 2) + 1.20413212730121e-5*std::pow(-5.91807985305786*x_73 - 8.91327953338623, 2) - 6.36235879029225e-7*std::pow(-6.00263977050781*x_74 - 7.00984001159668, 2) - 2.12138770538068e-5*std::pow(-6.09375953674316*x_76 - 8.72231960296631, 2) - 0.000185769971876266*std::pow(-5.88271999359131*x_77 - 8.51807975769043, 2) - 1.96192880098433e-6*std::pow(-3.11719989776611*x_80 - 4.28687953948975, 2) - 0.000149167850618342*std::pow(-7.35264015197754*x_81 - 9.76879978179932, 2) - 4.84909139993224e-5*std::pow(-3.48071980476379*x_87 - 4.91408014297485, 2) - 5.04791192350025e-7*std::pow(-6.8120002746582*x_88 - 6.61999988555908, 2) - 0.000170563257572744*std::pow(-6.38272047042847*x_88 - 5.97375965118408, 2) + 0.000193277447874281*std::pow(-7.00031995773315*x_90 - 9.3840799331665, 2) - 0.000257025895447979*std::pow(-5.30272006988525*x_97 - 6.53128004074097, 2) - 0.0015573045589623*std::exp(0.63487982749939*x_1) + 0.00176868645175431*std::exp(1.13743984699249*x_1) + 3.61194755451997e-5*std::exp(1.20167994499207*x_1) - 0.00017821974572094*std::exp(1.2125598192215*x_1) + 0.0135705453836988*std::exp(1.57423985004425*x_100) - 2.45752009559357e-5*std::exp(1.05679976940155*x_106) - 0.000388233564375588*std::exp(1.3271199464798*x_106) + 0.0924320634563445*std::exp(0.543039858341217*x_109) + 0.0113148649650346*std::exp(0.620559811592102*x_109) - 0.00133741083288975*std::exp(0.843999862670898*x_110) + 5.72826712521144e-5*std::exp(0.924159824848175*x_110) + 0.00768570545501864*std::exp(1.28303980827332*x_110) + 0.000553482530089487*std::exp(1.38351988792419*x_26) - 0.0144816231997131*std::exp(0.582799851894379*x_31) - 0.000127521946226529*std::exp(0.667519807815552*x_31) - 0.0437055046654308*std::exp(0.899439811706543*x_50) - 0.000923520086787214*std::exp(0.815839886665344*x_6) - 8.35183781593303e-5*std::exp(0.835679888725281*x_66) - 2.4598927738448e-5*std::exp(0.971119821071625*x_68) - 0.000408032454042551*std::exp(1.1723198890686*x_68) + 0.00337005207213472*std::exp(0.692079842090607*x_70) + 0.0300848480166515*std::exp(1.00575983524323*x_72) - 0.00444527370685764*std::exp(0.620319843292236*x_74) - 0.023087706129982*std::exp(0.827759861946106*x_74) - 0.0162007803943359*std::exp(0.888719916343689*x_74) - 0.000195249828706366*std::exp(0.861039876937866*x_81) + 0.00387208140420496*std::exp(1.83999991416931*x_81) - 0.39357617272926*std::sin(0.355119854211807*x_1 - 1.1522399187088) - 0.0127648511094815*std::sin(0.397199839353561*x_10 - 4.18671989440918) - 0.0684318829083551*std::sin(0.472399860620499*x_100 - 4.15240001678467) - 0.0168542631788159*std::sin(0.32711985707283*x_101 + 1.96655988693237) - 0.108995056119847*std::sin(0.362559854984283*x_102 - 7.41928005218506) - 0.0228132070362541*std::sin(0.362959831953049*x_102 - 7.41296005249023) - 0.0209713038702587*std::sin(0.367999851703644*x_102 - 4.21712017059326) + 0.406501592881925*std::sin(0.371519833803177*x_102 + 1.98631989955902) + 0.00061151480163182*std::sin(0.378719836473465*x_105 - 7.40032005310059) + 0.0111291572398556*std::sin(0.407439857721329*x_105 + 5.21447992324829) + 0.131632259328057*std::sin(0.409599840641022*x_105 + 5.19664001464844) - 0.00642910105147779*std::sin(0.579839885234833*x_106 - 7.20016002655029) - 0.00769686478209244*std::sin(0.37679985165596*x_107 + 5.16760015487671) + 0.115954029445584*std::sin(0.422799855470657*x_108 + 5.2085599899292) + 0.204698887312531*std::sin(0.571119844913483*x_108 + 5.39264011383057) - 0.0507491837511077*std::sin(0.328239858150482*x_111 - 7.45631980895996) - 0.0157171261798382*std::sin(0.346959829330444*x_111 - 7.44280004501343) - 0.490477686872734*std::sin(0.379759848117828*x_111 - 4.20928001403809) - 0.0955776286667835*std::sin(0.413439869880676*x_111 - 4.19479990005493) - 0.000285883877699658*std::sin(0.415359854698181*x_111 + 5.20128011703491) + 0.129597070971398*std::sin(0.0988800674676895*x_112 - 7.72000026702881) - 0.168004350154994*std::sin(0.188320010900497*x_112 - 7.61392021179199) - 0.161731379043136*std::sin(0.484159857034683*x_112 - 7.34711980819702) - 0.0398476624483511*std::sin(0.278399974107742*x_113 + 5.07871961593628) - 0.0108689980396436*std::sin(0.326799839735031*x_113 + 5.14792013168335) + 0.242588312442415*std::sin(0.38919985294342*x_113 + 5.20240020751953) - 0.119549352048302*std::sin(0.279999971389771*x_114 + 5.07415962219238) - 3.79756561535504*std::sin(0.114000059664249*x_115 - 7.71016025543213) - 0.000959004955417659*std::sin(0.176960021257401*x_115 - 7.62800025939941) + 0.0267708476179823*std::sin(0.3852798640728*x_115 + 5.18304014205933) + 0.0267894926664341*std::sin(0.462399870157242*x_115 - 4.15016031265259) - 0.00236611197803643*std::sin(0.704079866409302*x_115 - 0.953199863433838) + 0.00707436282289672*std::sin(0.276959955692291*x_117 - 7.5128002166748) + 0.00404456011474617*std::sin(0.486959844827652*x_117 + 2.04119992256165) + 0.000277619979680965*std::sin(0.493199855089188*x_117 + 8.44624042510986) - 0.266363421775523*std::sin(0.541919827461243*x_117 + 2.14631986618042) + 0.104247577322016*std::sin(0.50111985206604*x_118 - 0.914959847927094) + 0.00669218454072967*std::sin(0.386239856481552*x_119 - 7.41991996765137) - 0.0129772925009282*std::sin(0.361839860677719*x_120 + 5.16088008880615) + 0.375085372710262*std::sin(0.320879846811295*x_16 + 5.12936019897461) - 0.00395507010217799*std::sin(0.387919843196869*x_16 + 8.37479972839355) + 0.240956417755495*std::sin(0.428879857063293*x_16 + 2.01399970054626) + 0.218661088881803*std::sin(0.362959831953049*x_2 + 8.34000015258789) + 0.196187117579957*std::sin(0.341119855642319*x_23 + 8.32808017730713) - 0.120886107418458*std::sin(0.265519946813583*x_24 - 7.50544023513794) - 0.392438014622758*std::sin(0.337759852409363*x_24 - 4.27648019790649) - 0.00320643971122488*std::sin(0.429839849472046*x_24 - 4.17072010040283) - 0.683208570746929*std::sin(0.335119843482971*x_28 - 4.26039981842041) + 0.0691691519489709*std::sin(0.337679862976074*x_28 - 4.26599979400635) - 0.00709601920779268*std::sin(0.346559852361679*x_28 + 5.15136003494263) - 0.0816016553163688*std::sin(0.35183984041214*x_28 + 5.15032005310059) + 0.00790740490623995*std::sin(0.649119853973389*x_29 + 5.44807958602905) - 0.141406464770931*std::sin(0.266879975795746*x_3 + 5.08120012283325) + 0.0268572441428436*std::sin(0.277119934558868*x_3 + 5.07439994812012) - 0.471375950487601*std::sin(0.262719959020615*x_31 - 1.11887979507446) + 0.146637356957559*std::sin(0.239359974861145*x_32 - 4.39695978164673) - 0.0329601227934065*std::sin(0.244239971041679*x_32 - 1.18919992446899) - 0.00037520513534828*std::sin(0.3642398416996*x_32 + 2.00423979759216) + 0.00139781949231815*std::sin(0.281919926404953*x_33 - 1.16639983654022) - 0.0133121973063092*std::sin(0.298799932003021*x_33 - 1.17119991779327) - 0.00125380586265073*std::sin(0.351039856672287*x_34 + 2.00447988510132) + 0.0429313681314696*std::sin(0.363679856061935*x_34 + 1.98031985759735) + 0.601623149804098*std::sin(0.312479853630066*x_35 - 7.4268798828125) - 0.0950340231246743*std::sin(0.316559851169586*x_35 - 7.42767953872681) + 0.000431248435981883*std::sin(0.338959842920303*x_36 + 5.13944005966187) - 0.0163391286234912*std::sin(0.348479837179184*x_36 + 5.1482400894165) - 0.0762198309631142*std::sin(0.528879821300507*x_38 + 2.14799976348877) + 0.0259189520976431*std::sin(0.138880044221878*x_39 - 7.67199993133545) - 0.960206305555188*std::sin(0.450239837169647*x_4 + 5.25072002410889) - 0.00142203135513532*std::sin(0.142080038785934*x_40 + 1.71799993515015) - 0.00587387545835072*std::sin(0.303359925746918*x_41 + 5.1200795173645) + 0.010301537875185*std::sin(0.383839845657349*x_43 + 8.36983966827393) - 0.498301160386373*std::sin(0.403679847717285*x_45 + 5.20216035842896) + 0.0186915754848952*std::sin(0.585359811782837*x_45 - 0.991279780864716) + 0.0447854761544242*std::sin(0.392799854278564*x_46 - 4.20968008041382) - 0.0159530165954125*std::sin(0.206560000777245*x_48 - 7.60423994064331) - 0.000859490710961655*std::sin(0.346159845590591*x_48 - 7.44863986968994) - 0.0183287874755617*std::sin(0.411759853363037*x_48 - 1.19631993770599) + 0.0328001092747095*std::sin(0.565599858760834*x_49 - 4.01488018035889) + 0.0184260068891489*std::sin(0.331519842147827*x_50 - 7.47583961486816) + 0.0258978414647573*std::sin(0.312879920005798*x_51 - 7.46560001373291) - 0.0774146326338004*std::sin(0.328079849481583*x_51 - 7.46679973602295) + 0.0912243758625344*std::sin(0.398239850997925*x_51 + 2.0032799243927) - 0.0548622496595946*std::sin(0.225839987397194*x_53 + 5.02431964874268) - 0.000661594807609507*std::sin(0.245759963989258*x_53 + 5.05375957489014) - 0.641922131948704*std::sin(0.365519851446152*x_53 + 5.17160034179688) - 0.0421150719975451*std::sin(0.337839841842651*x_54 + 5.14088010787964) + 0.0854374633183251*std::sin(0.233839988708496*x_55 - 4.34647989273071) - 0.000342653496831237*std::sin(0.302159935235977*x_55 + 5.13935995101929) + 0.00106536422207444*std::sin(0.237999975681305*x_56 + 1.84207987785339) - 0.0231336297759315*std::sin(0.348079830408096*x_56 - 4.24767971038818) - 3.07054969424516*std::sin(0.219359993934631*x_58 + 5.00799989700317) - 0.00017128170046791*std::sin(0.453039854764938*x_58 - 7.33599948883057) + 0.0139791898430282*std::sin(0.202479988336563*x_59 - 7.59496021270752) + 0.730786075291542*std::sin(0.252719968557358*x_59 - 7.53144025802612) + 0.000216465698359638*std::sin(0.434399873018265*x_59 - 4.15543985366821) + 0.0206266389263094*std::sin(0.284879922866821*x_63 - 4.28927946090698) - 0.745421045046635*std::sin(0.218400001525879*x_64 - 4.37687969207764) + 0.000585602134501612*std::sin(0.265199959278107*x_64 + 5.0732798576355) - 0.0181602933883025*std::sin(0.549919843673706*x_64 + 8.54447937011719) + 0.179298634904992*std::sin(0.209519997239113*x_66 + 5.01255941390991) + 0.0187796274124228*std::sin(0.185360014438629*x_67 + 4.98880004882813) + 0.000175666362657658*std::sin(0.215919986367226*x_67 - 1.38919985294342) + 0.0286140824836038*std::sin(0.14264003932476*x_70 + 4.91504001617432) - 0.242454417601455*std::sin(0.252799987792969*x_70 + 5.05615997314453) - 0.000241913540344411*std::sin(0.45839986205101*x_70 - 4.14351987838745) + 0.000610035880765718*std::sin(0.265119969844818*x_71 + 5.10031986236572) - 0.000286818144661686*std::sin(0.417279869318008*x_72 - 4.16544008255005) - 0.752971126752586*std::sin(0.22639998793602*x_73 - 4.35999965667725) + 0.308496540525212*std::sin(0.241039976477623*x_73 + 5.03599977493286) + 0.0174406372124422*std::sin(0.441279858350754*x_73 + 8.44567966461182) - 0.20924723183312*std::sin(0.286959916353226*x_75 + 5.10399961471558) - 0.00208346162524927*std::sin(0.50631982088089*x_75 + 5.28976011276245) - 0.0805291037457712*std::sin(0.201439991593361*x_77 + 5.00008010864258) + 0.303347885546741*std::sin(0.177760004997253*x_78 - 7.61360025405884) + 0.0210958707209072*std::sin(0.305519849061966*x_79 + 5.10823965072632) + 0.00109052547640823*std::sin(0.354479849338531*x_79 + 5.14448022842407) - 0.318128258249834*std::sin(0.429439842700958*x_79 - 1.17511987686157) + 0.01250843326754*std::sin(0.473759859800339*x_79 + 2.05039978027344) - 0.0691156648632111*std::sin(0.389599829912186*x_80 - 4.22240018844604) + 0.000251794604455716*std::sin(0.34639984369278*x_81 + 5.13544034957886) - 0.0288585675213655*std::sin(0.201279997825623*x_83 + 5.00423955917358) + 0.259099782196674*std::sin(0.329919844865799*x_83 - 7.47191953659058) - 0.155333751567025*std::sin(0.262319952249527*x_84 - 7.53927993774414) + 0.549177298961723*std::sin(0.274719953536987*x_84 - 7.52063989639282) - 0.000238441067232228*std::sin(0.285919934511185*x_84 - 7.49776029586792) - 0.77221728172748*std::sin(0.181760013103485*x_85 + 4.96687984466553) + 0.17270999306192*std::sin(0.207039996981621*x_85 - 7.60423994064331) - 0.0369195833497068*std::sin(0.218719989061356*x_85 + 1.81463992595673) + 0.923591628103662*std::sin(0.239359974861145*x_86 + 5.04375982284546) + 0.0107289966967169*std::sin(0.274719953536987*x_86 + 5.07567977905273) - 0.000960336482684343*std::sin(0.263039976358414*x_87 + 5.06744003295898) - 0.16480561887232*std::sin(0.369199842214584*x_87 + 5.17087984085083) - 0.00665731875320022*std::sin(0.851599872112274*x_87 - 0.74703985452652) + 1.95662511436765*std::sin(0.135120034217834*x_89 + 4.91599988937378) + 0.851595622877949*std::sin(0.136560037732124*x_89 - 7.68688011169434) - 0.0314379057106952*std::sin(0.167120009660721*x_89 + 1.74775993824005) - 0.000773049689652768*std::sin(0.231359988451004*x_89 - 7.56800031661987) + 0.022842701881896*std::sin(0.257439970970154*x_90 + 5.07199954986572) + 0.0171193122383266*std::sin(0.615919828414917*x_90 + 5.41048002243042) - 0.000446152919806161*std::sin(0.346959829330444*x_92 + 5.19504022598267) - 0.0146492594501576*std::sin(0.362319827079773*x_92 - 7.40927982330322) - 0.0236436959436266*std::sin(0.374959826469421*x_92 + 2.00839972496033) - 0.0657015307813178*std::sin(0.2882399559021*x_93 - 1.32551980018616) + 0.159475496781812*std::sin(0.359519839286804*x_94 - 1.19071984291077) - 0.0138002238898601*std::sin(0.384239852428436*x_94 + 2.00543975830078) + 0.00863544496759713*std::sin(0.359839856624603*x_95 - 4.23415994644165) + 0.000474113236372091*std::sin(0.380559861660004*x_95 - 7.42167997360229) - 0.0571154904801657*std::sin(0.38623982667923*x_95 - 4.19471979141235) - 0.158292035057116*std::sin(0.399759858846664*x_95 + 5.18351984024048) + 0.0329371519377503*std::sin(0.402799844741821*x_95 + 2.00415992736816) - 0.148413334484242*std::sin(0.377199828624725*x_96 - 7.40903997421265) + 0.0123239171262876*std::sin(0.378239840269089*x_96 + 8.36672019958496) + 0.00481338679568981*std::sin(0.381439834833145*x_96 - 7.39928007125854) + 0.000841356313361361*std::sin(0.396879822015762*x_96 + 5.18616008758545) + 0.0623120729509983*std::sin(0.315919935703278*x_97 + 5.12328004837036) + 0.000617570627972843*std::sin(0.417759865522385*x_98 - 7.40039968490601) - 0.133520961411393*std::sin(0.42223984003067*x_98 - 7.3790397644043) - 0.0105498330658984*std::sin(0.324319928884506*x_99 + 1.9210399389267) + 0.164122822036481*std::sin(0.333199828863144*x_99 + 1.93759977817535) + 0.000442518551648961*std::sin(0.359599858522415*x_99 + 1.94671976566315) - 2.31884510013372 - 8.31161059350428e-6*std::exp(-2.02751994132996*x_30));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.238959353605705*x_10 + 0.00844412901420108*x_100 + 0.47385895929682*x_101 - 1.3798907665291e-5*x_102 + 0.142847982014039*x_103 - 0.123952821649503*x_104 + 0.0616231320222307*x_105 - 0.0180095837783022*x_106 + 0.0976317662866395*x_107 + 0.00708039975000153*x_108 + 0.000404703494113574*x_109 + 0.266442574459078*x_11 - 0.00192833429530172*x_112 - 0.105429484240883*x_113 - 0.00559301870574699*x_114 + 0.0330185295135787*x_116 - 0.00131033305598875*x_117 + 0.0340987241858569*x_118 + 0.0638220359539471*x_119 - 0.0420858797692759*x_12 - 0.0439031224692673*x_120 + 0.0331841818517214*x_13 - 0.00798319027585907*x_14 - 0.00929616885862426*x_15 - 0.0240270728555284*x_16 - 0.0659474226492049*x_17 - 0.11784714263148*x_18 - 0.132740297671217*x_19 + 0.0200320102342818*x_2 + 0.0738442014870915*x_20 - 0.181418459449451*x_21 - 0.207429875130283*x_22 - 0.0288228094444093*x_23 - 0.209936254629111*x_25 + 0.188045193304503*x_26 + 0.047078604293616*x_27 + 4.77778642525328e-5*x_28 + 0.0869878967811952*x_29 - 0.331971980525682*x_3 - 0.0958843157438014*x_30 - 0.117502646906583*x_31 - 0.0251644638117666*x_32 + 0.0628902493153468*x_33 - 0.14616218898354*x_34 - 0.00218683061605099*x_35 + 0.00941201422060767*x_36 + 0.0415977052403611*x_37 - 0.0438311331704713*x_38 - 0.086439207073792*x_39 + 0.0117323231096764*x_4 - 0.13151639969038*x_40 + 0.0156757461680991*x_41 - 0.0924061731084258*x_42 - 0.00700853643517335*x_43 - 0.0902174892547896*x_44 + 0.0051437805032508*x_45 - 0.0435093200649593*x_46 - 0.0742884178629745*x_47 + 0.0241273980302754*x_48 + 0.0317454527118452*x_49 - 0.000127777515647617*x_5 + 0.0163817214232809*x_50 + 0.000861888219853156*x_51 - 0.0676701457754396*x_52 + 0.00316836371495587*x_53 - 0.0446123905028348*x_54 + 0.017764793896844*x_55 + 0.0191716107376965*x_56 + 0.0255649107697874*x_57 - 0.0011317628605392*x_58 - 0.0112227089977113*x_59 - 0.0397194735449458*x_6 + 0.0187778853947053*x_60 + 0.00875291214899113*x_61 + 0.146619237640275*x_62 - 0.0464710530602834*x_63 + 0.00284180350668316*x_64 - 0.00488644247291274*x_65 + 0.00691110275485177*x_66 - 0.0550106709449179*x_67 - 0.0171381549198689*x_68 + 0.163773712128502*x_69 - 0.0161987176498039*x_7 - 0.00714544858318257*x_71 - 0.00135923238053323*x_72 + 1.03836561019795e-5*x_73 + 0.00238820545845212*x_74 + 0.0395630086283912*x_75 + 0.0503323422394542*x_76 + 0.0866347878009093*x_77 - 0.15132906878659*x_78 + 0.000811853860991691*x_79 + 0.121064729134541*x_8 + 0.0738709446644476*x_80 - 0.0041276428980382*x_81 - 0.0263679676505265*x_82 - 0.116620313770257*x_83 + 0.00372818962845207*x_84 - 0.00149301415448269*x_85 - 0.0193540409278703*x_86 - 0.000516712438803343*x_87 - 0.0871535376460906*x_88 + 0.00656210212408943*x_89 - 0.138207645451752*x_9 - 0.0474047116426377*x_90 + 0.0573512066141775*x_91 - 0.00660965986893801*x_92 - 0.116563472576742*x_93 - 0.0807420795856086*x_94 - 8.4098163911683e-5*x_96 + 0.0054935775846197*x_97 - 0.133576860803266*x_98 - 0.1067086697099*x_99 + 9.81285299581136e-6*std::pow(-6.29120016098022*x_103 - 8.73127937316895, 2) + 9.14774696766199e-5*std::pow(-7.75808048248291*x_110 - 9.38607978820801, 2) + 2.9749602214116e-6*std::pow(-7.40000009536743*x_110 - 9.99830055236816, 2) + 1.02918786715211e-5*std::pow(-7.57424020767212*x_14 - 9.37415981292725, 2) - 0.0013779531652155*std::pow(-7.54568004608154*x_14 - 9.38496017456055, 2) - 3.08347584143387e-6*std::pow(-6.60400009155273*x_14 - 9.96963977813721, 2) - 3.08682127265776e-6*std::pow(-7.48759984970093*x_15 - 9.33039951324463, 2) - 1.56402698097751e-5*std::pow(-6.43415975570679*x_15 - 9.8625602722168, 2) - 0.00337936064145126*std::pow(-6.26032018661499*x_15 - 8.67928028106689, 2) - 0.000197056335118509*std::pow(-7.42991971969604*x_17 - 9.8689603805542, 2) + 4.76486876152844e-5*std::pow(-3.6814398765564*x_17 - 5.03768014907837, 2) + 8.13045652346632e-6*std::pow(-8.16792011260986*x_18 - 9.38511943817139, 2) + 4.7241563824136e-6*std::pow(-5.65367984771729*x_18 - 5.04967975616455, 2) + 1.53843646440034e-5*std::pow(-3.69407987594604*x_24 - 5.24943971633911, 2) + 8.96592018300368e-6*std::pow(-3.49719977378845*x_24 - 4.73023986816406, 2) + 6.11473272894119e-6*std::pow(-8.15824031829834*x_42 - 8.98200035095215, 2) - 0.00390664140489096*std::pow(-3.84272003173828*x_7 - 5.66088008880615, 2) - 0.00151218655737695*std::pow(-5.1224799156189*x_70 - 7.08175992965698, 2) + 1.13189600822908e-5*std::pow(-5.91807985305786*x_73 - 8.91327953338623, 2) - 6.18299771069528e-6*std::pow(-6.00263977050781*x_74 - 7.00984001159668, 2) - 1.99412524687665e-5*std::pow(-6.09375953674316*x_76 - 8.72231960296631, 2) + 8.52356364298668e-6*std::pow(-5.88271999359131*x_77 - 8.51807975769043, 2) - 1.90662012075494e-5*std::pow(-3.11719989776611*x_80 - 4.28687953948975, 2) + 6.84417215221319e-6*std::pow(-7.35264015197754*x_81 - 9.76879978179932, 2) - 4.55819346953466e-5*std::pow(-3.48071980476379*x_87 - 4.91408014297485, 2) - 4.90560637894483e-6*std::pow(-6.8120002746582*x_88 - 6.61999988555908, 2) + 7.82584379161524e-6*std::pow(-6.38272047042847*x_88 - 5.97375965118408, 2) - 8.86802431561841e-6*std::pow(-7.00031995773315*x_90 - 9.3840799331665, 2) + 1.1792953164711e-5*std::pow(-5.30272006988525*x_97 - 6.53128004074097, 2) + 0.0044052336622971*std::exp(0.63487982749939*x_1) - 8.11514981875398e-5*std::exp(1.13743984699249*x_1) + 0.000351012324152856*std::exp(1.20167994499207*x_1) - 0.000167528308725768*std::exp(1.2125598192215*x_1) + 0.0269341086015628*std::exp(1.57423985004425*x_100) - 0.000238824021496982*std::exp(1.05679976940155*x_106) + 0.00109821778712351*std::exp(1.3271199464798*x_106) + 0.183454324421645*std::exp(0.543039858341217*x_109) - 0.0320069852370625*std::exp(0.620559811592102*x_109) - 0.00125717929850697*std::exp(0.843999862670898*x_110) + 0.000556678170609842*std::exp(0.924159824848175*x_110) + 0.0152541861474306*std::exp(1.28303980827332*x_110) - 2.53950814701165e-5*std::exp(1.38351988792419*x_26) + 0.000664450964544052*std::exp(0.582799851894379*x_31) - 0.00123926978589307*std::exp(0.667519807815552*x_31) - 0.0867443994225072*std::exp(0.899439811706543*x_50) - 0.000868117938267029*std::exp(0.815839886665344*x_6) - 0.000811639138849008*std::exp(0.835679888725281*x_66) - 0.00023905460051145*std::exp(0.971119821071625*x_68) - 0.00038355450825302*std::exp(1.1723198890686*x_68) - 0.00953305295770431*std::exp(0.692079842090607*x_70) + 0.0597108326033354*std::exp(1.00575983524323*x_72) - 0.00417860087792441*std::exp(0.620319843292236*x_74) + 0.00105931830953039*std::exp(0.827759861946106*x_74) - 0.0321544614629322*std::exp(0.888719916343689*x_74) - 0.000183536753741031*std::exp(0.861039876937866*x_81) + 0.00768510462226708*std::exp(1.83999991416931*x_81) - 0.781149399641008*std::sin(0.355119854211807*x_1 - 1.1522399187088) + 0.0361086413560416*std::sin(0.397199839353561*x_10 - 4.18671989440918) + 0.0031398158878297*std::sin(0.472399860620499*x_100 - 4.15240001678467) - 0.0158431726728374*std::sin(0.32711985707283*x_101 + 1.96655988693237) + 0.00500094976720567*std::sin(0.362559854984283*x_102 - 7.41928005218506) - 0.0214446383364209*std::sin(0.362959831953049*x_102 - 7.41296005249023) + 0.0593226888214367*std::sin(0.367999851703644*x_102 - 4.21712017059326) + 0.806803097430553*std::sin(0.371519833803177*x_102 + 1.98631989955902) + 0.00594275604877062*std::sin(0.378719836473465*x_105 - 7.40032005310059) + 0.010461516945802*std::sin(0.407439857721329*x_105 + 5.21447992324829) - 0.00603959794212664*std::sin(0.409599840641022*x_105 + 5.19664001464844) - 0.00604341803667259*std::sin(0.579839885234833*x_106 - 7.20016002655029) - 0.00723512837603253*std::sin(0.37679985165596*x_107 + 5.16760015487671) - 0.00532024384596708*std::sin(0.422799855470657*x_108 + 5.2085599899292) + 0.406275643727449*std::sin(0.571119844913483*x_108 + 5.39264011383057) + 0.143557026984786*std::sin(0.328239858150482*x_111 - 7.45631980895996) - 0.0147742527422337*std::sin(0.346959829330444*x_111 - 7.44280004501343) - 0.973474455989248*std::sin(0.379759848117828*x_111 - 4.20928001403809) + 0.00438532660881108*std::sin(0.413439869880676*x_111 - 4.19479990005493) - 0.00277824533259383*std::sin(0.415359854698181*x_111 + 5.20128011703491) + 0.121822517633077*std::sin(0.0988800674676895*x_112 - 7.72000026702881) + 0.475243210748891*std::sin(0.188320010900497*x_112 - 7.61392021179199) - 0.32099598094716*std::sin(0.484159857034683*x_112 - 7.34711980819702) + 0.112719289859587*std::sin(0.278399974107742*x_113 + 5.07871961593628) - 0.0102169647462988*std::sin(0.326799839735031*x_113 + 5.14792013168335) - 0.0111305228679524*std::sin(0.38919985294342*x_113 + 5.20240020751953) + 0.00548520571096509*std::sin(0.279999971389771*x_114 + 5.07415962219238) - 7.53720958248291*std::sin(0.114000059664249*x_115 - 7.71016025543213) - 0.00931969673407941*std::sin(0.176960021257401*x_115 - 7.62800025939941) + 0.0251648592946505*std::sin(0.3852798640728*x_115 + 5.18304014205933) - 0.00122916499044186*std::sin(0.462399870157242*x_115 - 4.15016031265259) + 0.00669315200705247*std::sin(0.704079866409302*x_115 - 0.953199863433838) - 0.0200116419536419*std::sin(0.276959955692291*x_117 - 7.5128002166748) + 0.00380192617166052*std::sin(0.486959844827652*x_117 + 2.04119992256165) + 0.00269793602559755*std::sin(0.493199855089188*x_117 + 8.44624042510986) - 0.528664186054285*std::sin(0.541919827461243*x_117 + 2.14631986618042) + 0.206905138272026*std::sin(0.50111985206604*x_118 - 0.914959847927094) + 0.00629071909655096*std::sin(0.386239856481552*x_119 - 7.41991996765137) - 0.0121987822153236*std::sin(0.361839860677719*x_120 + 5.16088008880615) - 0.0172097999130813*std::sin(0.320879846811295*x_16 + 5.12936019897461) - 0.00371780468224447*std::sin(0.387919843196869*x_16 + 8.37479972839355) + 0.478237693517161*std::sin(0.428879857063293*x_16 + 2.01399970054626) - 0.0100326855223415*std::sin(0.362959831953049*x_2 + 8.34000015258789) - 0.00900152681155952*std::sin(0.341119855642319*x_23 + 8.32808017730713) + 0.34195722772346*std::sin(0.265519946813583*x_24 - 7.50544023513794) - 0.778890442968339*std::sin(0.337759852409363*x_24 - 4.27648019790649) - 0.00301408477315277*std::sin(0.429839849472046*x_24 - 4.17072010040283) - 1.35599663253923*std::sin(0.335119843482971*x_28 - 4.26039981842041) - 0.195662611275722*std::sin(0.337679862976074*x_28 - 4.26599979400635) - 0.00667032764387676*std::sin(0.346559852361679*x_28 + 5.15136003494263) + 0.00374407604973639*std::sin(0.35183984041214*x_28 + 5.15032005310059) - 0.0223681142355307*std::sin(0.649119853973389*x_29 + 5.44807958602905) + 0.400004299152901*std::sin(0.266879975795746*x_3 + 5.08120012283325) + 0.0252460728752851*std::sin(0.277119934558868*x_3 + 5.07439994812012) - 0.935562328824956*std::sin(0.262719959020615*x_31 - 1.11887979507446) - 0.414801213611135*std::sin(0.239359974861145*x_32 - 4.39695978164673) - 0.0309828386559316*std::sin(0.244239971041679*x_32 - 1.18919992446899) - 0.00364627737819383*std::sin(0.3642398416996*x_32 + 2.00423979759216) + 0.0135841360191058*std::sin(0.281919926404953*x_33 - 1.16639983654022) - 0.0125135960166936*std::sin(0.298799932003021*x_33 - 1.17119991779327) - 0.0121845985646931*std::sin(0.351039856672287*x_34 + 2.00447988510132) - 0.121442338926459*std::sin(0.363679856061935*x_34 + 1.98031985759735) + 1.19407015678992*std::sin(0.312479853630066*x_35 - 7.4268798828125) + 0.00436038470680156*std::sin(0.316559851169586*x_35 - 7.42767953872681) + 0.00419091123324471*std::sin(0.338959842920303*x_36 + 5.13944005966187) - 0.0153589411390606*std::sin(0.348479837179184*x_36 + 5.1482400894165) + 0.00349714527870255*std::sin(0.528879821300507*x_38 + 2.14799976348877) + 0.0243640691512453*std::sin(0.138880044221878*x_39 - 7.67199993133545) - 1.90576724681937*std::sin(0.450239837169647*x_4 + 5.25072002410889) - 0.0138194290877688*std::sin(0.142080038785934*x_40 + 1.71799993515015) - 0.00552150053420075*std::sin(0.303359925746918*x_41 + 5.1200795173645) + 0.00968354662679451*std::sin(0.383839845657349*x_43 + 8.36983966827393) - 0.989002076972773*std::sin(0.403679847717285*x_45 + 5.20216035842896) - 0.000857613486313651*std::sin(0.585359811782837*x_45 - 0.991279780864716) - 0.126687156986773*std::sin(0.392799854278564*x_46 - 4.20968008041382) - 0.0149959920461808*std::sin(0.206560000777245*x_48 - 7.60423994064331) - 0.00835260832247982*std::sin(0.346159845590591*x_48 - 7.44863986968994) + 0.0518476563314221*std::sin(0.411759853363037*x_48 - 1.19631993770599) - 0.00150494623041724*std::sin(0.565599858760834*x_49 - 4.01488018035889) + 0.0173206271741738*std::sin(0.331519842147827*x_50 - 7.47583961486816) + 0.024344224949307*std::sin(0.312879920005798*x_51 - 7.46560001373291) + 0.218987059191571*std::sin(0.328079849481583*x_51 - 7.46679973602295) - 0.00418558912187352*std::sin(0.398239850997925*x_51 + 2.0032799243927) + 0.00251720916921084*std::sin(0.225839987397194*x_53 + 5.02431964874268) - 0.00642943806799925*std::sin(0.245759963989258*x_53 + 5.05375957489014) - 1.27405346850848*std::sin(0.365519851446152*x_53 + 5.17160034179688) - 0.0395885806876881*std::sin(0.337839841842651*x_54 + 5.14088010787964) - 0.241681684719367*std::sin(0.233839988708496*x_55 - 4.34647989273071) - 0.00332993761637884*std::sin(0.302159935235977*x_55 + 5.13935995101929) + 0.0103533056893831*std::sin(0.237999975681305*x_56 + 1.84207987785339) - 0.0217458388540082*std::sin(0.348079830408096*x_56 - 4.24767971038818) - 6.09426641250829*std::sin(0.219359993934631*x_58 + 5.00799989700317) - 0.00166453102816674*std::sin(0.453039854764938*x_58 - 7.33599948883057) + 0.013140575542207*std::sin(0.202479988336563*x_59 - 7.59496021270752) + 1.4504259747774*std::sin(0.252719968557358*x_59 - 7.53144025802612) + 0.00210363319881276*std::sin(0.434399873018265*x_59 - 4.15543985366821) + 0.0193892428700491*std::sin(0.284879922866821*x_63 - 4.28927946090698) - 1.47947269719121*std::sin(0.218400001525879*x_64 - 4.37687969207764) + 0.0056909344102479*std::sin(0.265199959278107*x_64 + 5.0732798576355) + 0.000833237012995866*std::sin(0.549919843673706*x_64 + 8.54447937011719) - 0.0082266434681448*std::sin(0.209519997239113*x_66 + 5.01255941390991) + 0.0176530339339027*std::sin(0.185360014438629*x_67 + 4.98880004882813) + 0.00170714157116652*std::sin(0.215919986367226*x_67 - 1.38919985294342) + 0.0268975181443912*std::sin(0.14264003932476*x_70 + 4.91504001617432) + 0.0111243794574385*std::sin(0.252799987792969*x_70 + 5.05615997314453) - 0.00235093762460852*std::sin(0.45839986205101*x_70 - 4.14351987838745) + 0.00592838376227939*std::sin(0.265119969844818*x_71 + 5.10031986236572) - 0.00278732462327484*std::sin(0.417279869318008*x_72 - 4.16544008255005) - 1.49445770441598*std::sin(0.22639998793602*x_73 - 4.35999965667725) - 0.0141545475312838*std::sin(0.241039976477623*x_73 + 5.03599977493286) - 0.0493352964890549*std::sin(0.441279858350754*x_73 + 8.44567966461182) + 0.00960075559916821*std::sin(0.286959916353226*x_75 + 5.10399961471558) - 0.00195847435962333*std::sin(0.50631982088089*x_75 + 5.28976011276245) - 0.0756981472460144*std::sin(0.201439991593361*x_77 + 5.00008010864258) - 0.0139183151200844*std::sin(0.177760004997253*x_78 - 7.61360025405884) + 0.0198303253585878*std::sin(0.305519849061966*x_79 + 5.10823965072632) + 0.010597825030514*std::sin(0.354479849338531*x_79 + 5.14448022842407) - 0.63140432566695*std::sin(0.429439842700958*x_79 - 1.17511987686157) - 0.0353832980040085*std::sin(0.473759859800339*x_79 + 2.05039978027344) + 0.00317118941365454*std::sin(0.389599829912186*x_80 - 4.22240018844604) + 0.00244696269768779*std::sin(0.34639984369278*x_81 + 5.13544034957886) - 0.0271273364774793*std::sin(0.201279997825623*x_83 + 5.00423955917358) - 0.0118881079710143*std::sin(0.329919844865799*x_83 - 7.47191953659058) + 0.00712707820329152*std::sin(0.262319952249527*x_84 - 7.53927993774414) + 1.08997837548342*std::sin(0.274719953536987*x_84 - 7.52063989639282) - 0.00231719181741538*std::sin(0.285919934511185*x_84 - 7.49776029586792) - 1.53265646604268*std::sin(0.181760013103485*x_85 + 4.96687984466553) - 0.488554323476997*std::sin(0.207039996981621*x_85 - 7.60423994064331) - 0.0347047704081069*std::sin(0.218719989061356*x_85 + 1.81463992595673) - 0.0423765581851659*std::sin(0.239359974861145*x_86 + 5.04375982284546) + 0.0100853621109961*std::sin(0.274719953536987*x_86 + 5.07567977905273) - 0.00933263663626505*std::sin(0.263039976358414*x_87 + 5.06744003295898) - 0.327097571346464*std::sin(0.369199842214584*x_87 + 5.17087984085083) + 0.0188319262943539*std::sin(0.851599872112274*x_87 - 0.74703985452652) + 3.88340717582566*std::sin(0.135120034217834*x_89 + 4.91599988937378) - 0.0390732119748812*std::sin(0.136560037732124*x_89 - 7.68688011169434) - 0.0295519396702523*std::sin(0.167120009660721*x_89 + 1.74775993824005) - 0.00751256667365218*std::sin(0.231359988451004*x_89 - 7.56800031661987) + 0.0214723637805714*std::sin(0.257439970970154*x_90 + 5.07199954986572) - 0.048426346737149*std::sin(0.615919828414917*x_90 + 5.41048002243042) - 0.00433575435260041*std::sin(0.346959829330444*x_92 + 5.19504022598267) - 0.0137704475440822*std::sin(0.362319827079773*x_92 - 7.40927982330322) + 0.0668822322984691*std::sin(0.374959826469421*x_92 + 2.00839972496033) + 0.185853559213344*std::sin(0.2882399559021*x_93 - 1.32551980018616) - 0.00731711122410064*std::sin(0.359519839286804*x_94 - 1.19071984291077) - 0.0129723457911632*std::sin(0.384239852428436*x_94 + 2.00543975830078) + 0.0081174029547839*std::sin(0.359839856624603*x_95 - 4.23415994644165) + 0.00460747523319777*std::sin(0.380559861660004*x_95 - 7.42167997360229) + 0.00262059316256099*std::sin(0.38623982667923*x_95 - 4.19471979141235) - 0.314169750915989*std::sin(0.399759858846664*x_95 + 5.18351984024048) - 0.0931711460172283*std::sin(0.402799844741821*x_95 + 2.00415992736816) - 0.294563022774337*std::sin(0.377199828624725*x_96 - 7.40903997421265) - 0.0348613469752234*std::sin(0.378239840269089*x_96 + 8.36672019958496) + 0.00452463079140233*std::sin(0.381439834833145*x_96 - 7.39928007125854) + 0.0081763766094577*std::sin(0.396879822015762*x_96 + 5.18616008758545) + 0.123673742845054*std::sin(0.315919935703278*x_97 + 5.12328004837036) + 0.00600160711586234*std::sin(0.417759865522385*x_98 - 7.40039968490601) + 0.00612625604002783*std::sin(0.42223984003067*x_98 - 7.3790397644043) - 0.00991694654102225*std::sin(0.324319928884506*x_99 + 1.9210399389267) - 0.00753034144735876*std::sin(0.333199828863144*x_99 + 1.93759977817535) + 0.00430043523474418*std::sin(0.359599858522415*x_99 + 1.94671976566315) - 5.59289932843472 + 2.35115132513374e-5*std::exp(-2.02751994132996*x_30));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.181956209692752*x_10 - 0.0145253446635861*x_100 + 0.360050581203059*x_101 + 4.94128690561323e-5*x_102 + 0.112235531518039*x_103 - 0.0990628967114054*x_104 + 0.0418752380005366*x_105 - 0.00199389987815718*x_106 + 0.0639746425468062*x_107 - 0.00907434486878371*x_108 - 0.000943705967159704*x_109 + 0.256739657624637*x_11 + 0.0186587832383955*x_112 - 0.0845429806482282*x_113 - 0.0157558888342771*x_114 + 0.0663934221955503*x_116 + 0.0138457042473081*x_117 - 0.0607452148595578*x_118 + 0.0354766112108906*x_119 - 0.1720101234506*x_12 - 0.0463595116727361*x_120 + 0.0716983507459878*x_13 + 0.00424581648676227*x_14 + 0.0140480990220324*x_15 + 0.0394102146950297*x_16 - 0.0519579821490958*x_17 - 0.1105697671045*x_18 - 0.106266165790551*x_19 - 0.0323236007224997*x_2 + 0.045946673033341*x_20 - 0.152033413365745*x_21 - 0.218698867300562*x_22 - 0.036506916289946*x_23 - 0.234264549005465*x_25 + 0.0985332833167641*x_26 + 0.0700199024018906*x_27 - 0.000171089002648405*x_28 + 0.0596475347065857*x_29 - 0.278747227693688*x_3 - 0.0903594627180391*x_30 + 0.19291616374444*x_31 - 0.00235285413236024*x_32 + 0.0615937617714323*x_33 - 0.126384986909463*x_34 + 0.00472792954287444*x_35 - 0.0111167846853039*x_36 - 0.0326317235232335*x_37 - 0.0586788459070794*x_38 - 0.069644819638638*x_39 - 0.0167467527061779*x_4 - 0.160466751071497*x_40 - 0.0260298330670802*x_41 - 0.0458543473879452*x_42 - 0.0136985562210872*x_43 - 0.160471391315373*x_44 + 0.000501546908763864*x_45 - 0.035139894500259*x_46 - 0.0526693047420425*x_47 + 0.0271616552636112*x_48 + 0.00710211882428676*x_49 + 0.0277375475852063*x_5 - 0.031338387758508*x_50 + 0.000346794527655059*x_51 - 0.0583473493289163*x_52 - 0.00552250156707716*x_53 - 0.0638871806626961*x_54 + 0.0115944002181563*x_55 + 0.0102144611493989*x_56 + 0.0167341720824508*x_57 + 0.00672592452024459*x_58 + 0.0159178135202033*x_59 + 0.0277033929540271*x_6 - 0.0114980491975622*x_60 - 0.0262532563864392*x_61 + 0.160223348309597*x_62 - 0.0326296686714167*x_63 - 0.00554809926562283*x_64 - 0.00437420469164034*x_65 + 0.0357165474282872*x_66 - 0.0641760583836964*x_67 - 0.00262502656956756*x_68 + 0.121235969760429*x_69 + 0.0296971835371673*x_7 - 0.0293437164971215*x_71 - 0.0110045978498628*x_72 - 3.71831054846183e-5*x_73 - 0.00398560461297205*x_74 - 0.0016498571926547*x_75 + 0.0247332716634533*x_76 + 0.0418331931051173*x_77 - 0.135648939939153*x_78 - 0.00857849719958729*x_79 + 0.0849436202770704*x_8 + 0.0661944057877914*x_80 + 0.0068884996962468*x_81 - 0.0448126758021321*x_82 - 0.121679707964333*x_83 - 0.0025993030320108*x_84 + 0.0139035305442967*x_85 - 0.0237644431081677*x_86 + 0.00545986959260364*x_87 - 0.0403186692554182*x_88 - 0.0109512958376353*x_89 - 0.0116657352020098*x_9 - 0.034760514916327*x_90 + 0.0278944664845423*x_91 - 0.00441785440051914*x_92 - 0.0725868423418844*x_93 - 0.101777145007065*x_94 + 0.000888627742344616*x_96 - 0.00844787817550501*x_97 - 0.122060369676826*x_98 - 0.0658658049018267*x_99 + 1.56481797285357e-5*std::pow(-6.29120016098022*x_103 - 8.73127937316895, 2) - 0.000152664011312683*std::pow(-7.75808048248291*x_110 - 9.38607978820801, 2) - 3.14350761319151e-5*std::pow(-7.40000009536743*x_110 - 9.99830055236816, 2) + 1.6412063572642e-5*std::pow(-7.57424020767212*x_14 - 9.37415981292725, 2) - 0.00110744277086894*std::pow(-7.54568004608154*x_14 - 9.38496017456055, 2) + 1.10416992189726e-5*std::pow(-6.60400009155273*x_14 - 9.96963977813721, 2) + 1.10536789610661e-5*std::pow(-7.48759984970093*x_15 - 9.33039951324463, 2) + 0.000165263746605892*std::pow(-6.43415975570679*x_15 - 9.8625602722168, 2) - 0.00271594754234549*std::pow(-6.26032018661499*x_15 - 8.67928028106689, 2) + 0.00032886141997713*std::pow(-7.42991971969604*x_17 - 9.8689603805542, 2) - 0.000503482403560202*std::pow(-3.6814398765564*x_17 - 5.03768014907837, 2) - 8.59109032661679e-5*std::pow(-8.16792011260986*x_18 - 9.38511943817139, 2) - 1.69168550429583e-5*std::pow(-5.65367984771729*x_18 - 5.04967975616455, 2) - 0.00016255971099873*std::pow(-3.69407987594604*x_24 - 5.24943971633911, 2) - 3.21062978836268e-5*std::pow(-3.49719977378845*x_24 - 4.73023986816406, 2) + 9.75092939589278e-6*std::pow(-8.15824031829834*x_42 - 8.98200035095215, 2) - 0.00313971613218593*std::pow(-3.84272003173828*x_7 - 5.66088008880615, 2) - 0.00121532437636253*std::pow(-5.1224799156189*x_70 - 7.08175992965698, 2) + 1.8049910844829e-5*std::pow(-5.91807985305786*x_73 - 8.91327953338623, 2) + 2.21408580783128e-5*std::pow(-6.00263977050781*x_74 - 7.00984001159668, 2) - 3.1799549302997e-5*std::pow(-6.09375953674316*x_76 - 8.72231960296631, 2) - 9.00646906483254e-5*std::pow(-5.88271999359131*x_77 - 8.51807975769043, 2) + 6.82746581482136e-5*std::pow(-3.11719989776611*x_80 - 4.28687953948975, 2) - 7.23193107310418e-5*std::pow(-7.35264015197754*x_81 - 9.76879978179932, 2) - 7.26877603069795e-5*std::pow(-3.48071980476379*x_87 - 4.91408014297485, 2) + 1.75666140772467e-5*std::pow(-6.8120002746582*x_88 - 6.61999988555908, 2) - 8.269219655958e-5*std::pow(-6.38272047042847*x_88 - 5.97375965118408, 2) + 9.37044527502507e-5*std::pow(-7.00031995773315*x_90 - 9.3840799331665, 2) - 0.000124610869713377*std::pow(-5.30272006988525*x_97 - 6.53128004074097, 2) - 0.00735176261470012*std::exp(0.63487982749939*x_1) + 0.000857491641529864*std::exp(1.13743984699249*x_1) - 0.00125694920432587*std::exp(1.20167994499207*x_1) - 0.000267150958612897*std::exp(1.2125598192215*x_1) + 0.0216465875717444*std::exp(1.57423985004425*x_100) + 0.000855211179604658*std::exp(1.05679976940155*x_106) - 0.00183278279635301*std::exp(1.3271199464798*x_106) + 0.147439819069339*std::exp(0.543039858341217*x_109) + 0.0534154997245695*std::exp(0.620559811592102*x_109) - 0.00200477553494674*std::exp(0.843999862670898*x_110) - 0.00199342340842972*std::exp(0.924159824848175*x_110) + 0.012259588062138*std::exp(1.28303980827332*x_110) + 0.000268338485215278*std::exp(1.38351988792419*x_26) - 0.00702095661852442*std::exp(0.582799851894379*x_31) + 0.00443773356130097*std::exp(0.667519807815552*x_31) - 0.0697153288506724*std::exp(0.899439811706543*x_50) - 0.00138435432889568*std::exp(0.815839886665344*x_6) + 0.00290641980231935*std::exp(0.835679888725281*x_66) + 0.000856036866023131*std::exp(0.971119821071625*x_68) - 0.000611639640723787*std::exp(1.1723198890686*x_68) + 0.0159094267662209*std::exp(0.692079842090607*x_70) + 0.0479888080222144*std::exp(1.00575983524323*x_72) - 0.00666345430625418*std::exp(0.620319843292236*x_74) - 0.0111933435171173*std::exp(0.827759861946106*x_74) - 0.0258421162614328*std::exp(0.888719916343689*x_74) - 0.000292679010941832*std::exp(0.861039876937866*x_81) + 0.00617641714692831*std::exp(1.83999991416931*x_81) - 0.6277994618676*std::sin(0.355119854211807*x_1 - 1.1522399187088) - 0.0602606308630032*std::sin(0.397199839353561*x_10 - 4.18671989440918) - 0.0331770323393737*std::sin(0.472399860620499*x_100 - 4.15240001678467) - 0.0252644988731217*std::sin(0.32711985707283*x_101 + 1.96655988693237) - 0.0528428029163362*std::sin(0.362559854984283*x_102 - 7.41928005218506) - 0.0341969409961608*std::sin(0.362959831953049*x_102 - 7.41296005249023) - 0.0990018599044097*std::sin(0.367999851703644*x_102 - 4.21712017059326) + 0.64841700017025*std::sin(0.371519833803177*x_102 + 1.98631989955902) - 0.0212805704330545*std::sin(0.378719836473465*x_105 - 7.40032005310059) + 0.0166825792122749*std::sin(0.407439857721329*x_105 + 5.21447992324829) + 0.063817734351696*std::sin(0.409599840641022*x_105 + 5.19664001464844) - 0.00963720659556339*std::sin(0.579839885234833*x_106 - 7.20016002655029) - 0.0115375812962359*std::sin(0.37679985165596*x_107 + 5.16760015487671) + 0.0562166408594775*std::sin(0.422799855470657*x_108 + 5.2085599899292) + 0.326518372310371*std::sin(0.571119844913483*x_108 + 5.39264011383057) - 0.239578025814393*std::sin(0.328239858150482*x_111 - 7.45631980895996) - 0.0235599333205103*std::sin(0.346959829330444*x_111 - 7.44280004501343) - 0.782368571098907*std::sin(0.379759848117828*x_111 - 4.20928001403809) - 0.0463377879203638*std::sin(0.413439869880676*x_111 - 4.19479990005493) + 0.00994869131348552*std::sin(0.415359854698181*x_111 + 5.20128011703491) + 0.194265689266802*std::sin(0.0988800674676895*x_112 - 7.72000026702881) - 0.793119170857302*std::sin(0.188320010900497*x_112 - 7.61392021179199) - 0.257980232965554*std::sin(0.484159857034683*x_112 - 7.34711980819702) - 0.188113849269268*std::sin(0.278399974107742*x_113 + 5.07871961593628) - 0.0162926012137796*std::sin(0.326799839735031*x_113 + 5.14792013168335) + 0.117611264588972*std::sin(0.38919985294342*x_113 + 5.20240020751953) - 0.057959719219905*std::sin(0.279999971389771*x_114 + 5.07415962219238) - 6.05755585556451*std::sin(0.114000059664249*x_115 - 7.71016025543213) + 0.0333731455803765*std::sin(0.176960021257401*x_115 - 7.62800025939941) + 0.0401294344523546*std::sin(0.3852798640728*x_115 + 5.18304014205933) + 0.0129880375458905*std::sin(0.462399870157242*x_115 - 4.15016031265259) - 0.0111700010651183*std::sin(0.704079866409302*x_115 - 0.953199863433838) + 0.0333968303276865*std::sin(0.276959955692291*x_117 - 7.5128002166748) + 0.00606278562148669*std::sin(0.486959844827652*x_117 + 2.04119992256165) - 0.00966110961739393*std::sin(0.493199855089188*x_117 + 8.44624042510986) - 0.424880428335581*std::sin(0.541919827461243*x_117 + 2.14631986618042) + 0.166286928626605*std::sin(0.50111985206604*x_118 - 0.914959847927094) + 0.0100315680961062*std::sin(0.386239856481552*x_119 - 7.41991996765137) - 0.019452929403521*std::sin(0.361839860677719*x_120 + 5.16088008880615) + 0.181848270302599*std::sin(0.320879846811295*x_16 + 5.12936019897461) - 0.00592864031369737*std::sin(0.387919843196869*x_16 + 8.37479972839355) + 0.384353321877807*std::sin(0.428879857063293*x_16 + 2.01399970054626) + 0.106010907619035*std::sin(0.362959831953049*x_2 + 8.34000015258789) + 0.0951151140066618*std::sin(0.341119855642319*x_23 + 8.32808017730713) - 0.57068218290444*std::sin(0.265519946813583*x_24 - 7.50544023513794) - 0.625983968206419*std::sin(0.337759852409363*x_24 - 4.27648019790649) - 0.00480644520685981*std::sin(0.429839849472046*x_24 - 4.17072010040283) - 1.08979659536785*std::sin(0.335119843482971*x_28 - 4.26039981842041) + 0.326535475968684*std::sin(0.337679862976074*x_28 - 4.26599979400635) - 0.0106369152645167*std::sin(0.346559852361679*x_28 + 5.15136003494263) - 0.0395619796258309*std::sin(0.35183984041214*x_28 + 5.15032005310059) + 0.0373294763920347*std::sin(0.649119853973389*x_29 + 5.44807958602905) - 0.667555203121321*std::sin(0.266879975795746*x_3 + 5.08120012283325) + 0.0402589426297126*std::sin(0.277119934558868*x_3 + 5.07439994812012) - 0.751899094910439*std::sin(0.262719959020615*x_31 - 1.11887979507446) + 0.692249330803582*std::sin(0.239359974861145*x_32 - 4.39695978164673) - 0.0494071426521105*std::sin(0.244239971041679*x_32 - 1.18919992446899) + 0.0130570499492671*std::sin(0.3642398416996*x_32 + 2.00423979759216) - 0.048643787655826*std::sin(0.281919926404953*x_33 - 1.16639983654022) - 0.0199549508795347*std::sin(0.298799932003021*x_33 - 1.17119991779327) + 0.0436321474121568*std::sin(0.351039856672287*x_34 + 2.00447988510132) + 0.202671484784697*std::sin(0.363679856061935*x_34 + 1.98031985759735) + 0.959658424123967*std::sin(0.312479853630066*x_35 - 7.4268798828125) - 0.0460742379801324*std::sin(0.316559851169586*x_35 - 7.42767953872681) - 0.0150073435533658*std::sin(0.338959842920303*x_36 + 5.13944005966187) - 0.0244923134471301*std::sin(0.348479837179184*x_36 + 5.1482400894165) - 0.0369527724401704*std::sin(0.528879821300507*x_38 + 2.14799976348877) + 0.0388524451716437*std::sin(0.138880044221878*x_39 - 7.67199993133545) - 1.5316399814785*std::sin(0.450239837169647*x_4 + 5.25072002410889) + 0.0494863547541553*std::sin(0.142080038785934*x_40 + 1.71799993515015) - 0.00880492480293551*std::sin(0.303359925746918*x_41 + 5.1200795173645) + 0.0154419798289465*std::sin(0.383839845657349*x_43 + 8.36983966827393) - 0.794847915129666*std::sin(0.403679847717285*x_45 + 5.20216035842896) + 0.00906201872549233*std::sin(0.585359811782837*x_45 - 0.991279780864716) + 0.211424404673313*std::sin(0.392799854278564*x_46 - 4.20968008041382) - 0.0239135324707803*std::sin(0.206560000777245*x_48 - 7.60423994064331) + 0.0299100734150142*std::sin(0.346159845590591*x_48 - 7.44863986968994) - 0.0865270019021892*std::sin(0.411759853363037*x_48 - 1.19631993770599) + 0.0159020947531047*std::sin(0.565599858760834*x_49 - 4.01488018035889) + 0.0276205388125272*std::sin(0.331519842147827*x_50 - 7.47583961486816) + 0.0388208003850935*std::sin(0.312879920005798*x_51 - 7.46560001373291) - 0.365460949017678*std::sin(0.328079849481583*x_51 - 7.46679973602295) + 0.0442272510926476*std::sin(0.398239850997925*x_51 + 2.0032799243927) - 0.0265982251811594*std::sin(0.225839987397194*x_53 + 5.02431964874268) + 0.0230233427938413*std::sin(0.245759963989258*x_53 + 5.05375957489014) - 1.02393995602859*std::sin(0.365519851446152*x_53 + 5.17160034179688) - 0.0631303888953612*std::sin(0.337839841842651*x_54 + 5.14088010787964) + 0.403335330333212*std::sin(0.233839988708496*x_55 - 4.34647989273071) + 0.0119242606294914*std::sin(0.302159935235977*x_55 + 5.13935995101929) - 0.037074422899025*std::sin(0.237999975681305*x_56 + 1.84207987785339) - 0.034677253891457*std::sin(0.348079830408096*x_56 - 4.24767971038818) - 4.89788147569312*std::sin(0.219359993934631*x_58 + 5.00799989700317) + 0.00596056265682227*std::sin(0.453039854764938*x_58 - 7.33599948883057) + 0.0209547710445299*std::sin(0.202479988336563*x_59 - 7.59496021270752) + 1.16568821132362*std::sin(0.252719968557358*x_59 - 7.53144025802612) - 0.00753295509444773*std::sin(0.434399873018265*x_59 - 4.15543985366821) + 0.0309192808004225*std::sin(0.284879922866821*x_63 - 4.28927946090698) - 1.18903267873124*std::sin(0.218400001525879*x_64 - 4.37687969207764) - 0.0203788157469844*std::sin(0.265199959278107*x_64 + 5.0732798576355) - 0.00880444341774298*std::sin(0.549919843673706*x_64 + 8.54447937011719) + 0.0869272677563894*std::sin(0.209519997239113*x_66 + 5.01255941390991) + 0.0281506151034325*std::sin(0.185360014438629*x_67 + 4.98880004882813) - 0.00611314786376261*std::sin(0.215919986367226*x_67 - 1.38919985294342) + 0.0428924389629239*std::sin(0.14264003932476*x_70 + 4.91504001617432) - 0.117546349913534*std::sin(0.252799987792969*x_70 + 5.05615997314453) + 0.00841853397541853*std::sin(0.45839986205101*x_70 - 4.14351987838745) - 0.0212291043367768*std::sin(0.265119969844818*x_71 + 5.10031986236572) + 0.00998120358274809*std::sin(0.417279869318008*x_72 - 4.16544008255005) - 1.20107593124621*std::sin(0.22639998793602*x_73 - 4.35999965667725) + 0.149564782767949*std::sin(0.241039976477623*x_73 + 5.03599977493286) + 0.0823341997537198*std::sin(0.441279858350754*x_73 + 8.44567966461182) - 0.101446897007772*std::sin(0.286959916353226*x_75 + 5.10399961471558) - 0.0031231038298644*std::sin(0.50631982088089*x_75 + 5.28976011276245) - 0.120712927598979*std::sin(0.201439991593361*x_77 + 5.00008010864258) + 0.147068620373093*std::sin(0.177760004997253*x_78 - 7.61360025405884) + 0.0316226581014694*std::sin(0.305519849061966*x_79 + 5.10823965072632) - 0.0379500285975386*std::sin(0.354479849338531*x_79 + 5.14448022842407) - 0.507451322444538*std::sin(0.429439842700958*x_79 - 1.17511987686157) + 0.0590501270516077*std::sin(0.473759859800339*x_79 + 2.05039978027344) - 0.033508542376292*std::sin(0.389599829912186*x_80 - 4.22240018844604) - 0.00876239266896616*std::sin(0.34639984369278*x_81 + 5.13544034957886) - 0.0432589214306233*std::sin(0.201279997825623*x_83 + 5.00423955917358) + 0.125616328058309*std::sin(0.329919844865799*x_83 - 7.47191953659058) - 0.0753086526354546*std::sin(0.262319952249527*x_84 - 7.53927993774414) + 0.876001233426397*std::sin(0.274719953536987*x_84 - 7.52063989639282) + 0.00829769273258433*std::sin(0.285919934511185*x_84 - 7.49776029586792) - 1.23177577176875*std::sin(0.181760013103485*x_85 + 4.96687984466553) + 0.815333688500736*std::sin(0.207039996981621*x_85 - 7.60423994064331) - 0.0553423642456923*std::sin(0.218719989061356*x_85 + 1.81463992595673) + 0.447774166246546*std::sin(0.239359974861145*x_86 + 5.04375982284546) + 0.0160827395465515*std::sin(0.274719953536987*x_86 + 5.07567977905273) + 0.0334194824142627*std::sin(0.263039976358414*x_87 + 5.06744003295898) - 0.262884000632763*std::sin(0.369199842214584*x_87 + 5.17087984085083) - 0.0314280381716293*std::sin(0.851599872112274*x_87 - 0.74703985452652) + 3.12104308896168*std::sin(0.135120034217834*x_89 + 4.91599988937378) + 0.412869182017513*std::sin(0.136560037732124*x_89 - 7.68688011169434) - 0.0471253430051734*std::sin(0.167120009660721*x_89 + 1.74775993824005) + 0.0269019463224888*std::sin(0.231359988451004*x_89 - 7.56800031661987) + 0.0342411536969224*std::sin(0.257439970970154*x_90 + 5.07199954986572) + 0.0808172807167355*std::sin(0.615919828414917*x_90 + 5.41048002243042) + 0.0155260160645536*std::sin(0.346959829330444*x_92 + 5.19504022598267) - 0.0219592037304698*std::sin(0.362319827079773*x_92 - 7.40927982330322) - 0.111617755763534*std::sin(0.374959826469421*x_92 + 2.00839972496033) - 0.310165442557055*std::sin(0.2882399559021*x_93 - 1.32551980018616) + 0.0773166467033141*std::sin(0.359519839286804*x_94 - 1.19071984291077) - 0.0206865015227971*std::sin(0.384239852428436*x_94 + 2.00543975830078) + 0.012944510675909*std::sin(0.359839856624603*x_95 - 4.23415994644165) - 0.0164990284665821*std::sin(0.380559861660004*x_95 - 7.42167997360229) - 0.027690637670709*std::sin(0.38623982667923*x_95 - 4.19471979141235) - 0.252494081990947*std::sin(0.399759858846664*x_95 + 5.18351984024048) + 0.155490537067459*std::sin(0.402799844741821*x_95 + 2.00415992736816) - 0.236736413378554*std::sin(0.377199828624725*x_96 - 7.40903997421265) + 0.058179058601149*std::sin(0.378239840269089*x_96 + 8.36672019958496) + 0.00721525491713293*std::sin(0.381439834833145*x_96 - 7.39928007125854) - 0.0292790006685095*std::sin(0.396879822015762*x_96 + 5.18616008758545) + 0.0993949547179565*std::sin(0.315919935703278*x_97 + 5.12328004837036) - 0.0214913117571182*std::sin(0.417759865522385*x_98 - 7.40039968490601) - 0.0647334117733183*std::sin(0.42223984003067*x_98 - 7.3790397644043) - 0.0158141737065089*std::sin(0.324319928884506*x_99 + 1.9210399389267) + 0.0795697552502794*std::sin(0.333199828863144*x_99 + 1.93759977817535) - 0.0153995409124516*std::sin(0.359599858522415*x_99 + 1.94671976566315) - 8.56178289815407 - 3.92376607887074e-5*std::exp(-2.02751994132996*x_30));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00445789050478756*x_10 - 0.00907518550928328*x_100 - 0.00810384480107669*x_101 + 1.55372335839262e-5*x_102 - 0.00123096526498072*x_103 + 0.00011169792385461*x_104 - 0.00320576211794712*x_105 + 0.00434867471277391*x_106 - 0.00694222208363109*x_107 - 0.00576358986130375*x_108 - 0.000210848524985059*x_109 + 0.014060108356413*x_11 + 0.00694284058916592*x_112 + 4.8613632021245e-5*x_113 - 0.00429237807305501*x_114 + 0.021300625746784*x_116 + 0.00519144117584331*x_117 - 0.0373765598402334*x_118 - 0.0067458119443875*x_119 - 0.0548687730682784*x_12 - 0.00483142291519658*x_120 + 0.018862145213126*x_13 + 0.00528631417291341*x_14 + 0.00837935337386243*x_15 + 0.0248614414577515*x_16 + 0.00217874359050225*x_17 - 0.00713915598461364*x_18 - 0.00114335791381594*x_19 - 0.0193683891556725*x_2 - 0.00447215284258293*x_20 - 0.00334598473610012*x_21 - 0.0145969541676531*x_22 - 0.00203724945394726*x_23 - 0.0244990749947099*x_25 - 0.0211902423644426*x_26 + 0.0132888216421527*x_27 - 5.37967102207624e-5*x_28 - 0.00662506758806778*x_29 - 0.00352941031072951*x_3 - 0.00359940848474573*x_30 + 0.119024692563436*x_31 + 0.0062272663532145*x_32 + 0.0045504603389518*x_33 - 0.00540598644660846*x_34 + 0.00283111418592829*x_35 - 0.00765901280223487*x_36 - 0.029647762004261*x_37 - 0.00993058756794375*x_38 + 8.54849940363335e-5*x_39 - 0.0104187260319228*x_4 - 0.0229747843893054*x_40 - 0.0162973473549752*x_41 + 0.0126853994010651*x_42 - 0.00322360394842084*x_43 - 0.0257112491598648*x_44 + 0.00217245688746831*x_45 + 0.000166421477873633*x_46 + 0.00427140226792873*x_47 + 0.00270770553731799*x_48 - 0.00686952654363834*x_49 + 0.0102878629550645*x_5 - 0.0183256585874345*x_50 - 8.88260449859746e-5*x_51 - 0.000389088020039332*x_52 - 0.00348330028010512*x_53 - 0.0120402432522337*x_54 - 0.00112062901860944*x_55 - 0.0023399750137411*x_56 - 0.00167367979575798*x_57 + 0.00352444190851101*x_58 + 0.0107030463288297*x_59 + 0.0249657155802339*x_6 - 0.0116436244115367*x_60 - 0.0126860685089961*x_61 + 0.01991485068889*x_62 + 0.00248885004229058*x_63 - 0.003632311710667*x_64 - 0.000266328881844375*x_65 + 0.0127924646275144*x_66 - 0.00830715073575276*x_67 + 0.00335424968483832*x_68 - 0.00671430857615743*x_69 + 0.0186707563593461*x_7 - 0.0103989742950994*x_71 - 0.00978178349683987*x_72 - 1.16917435948517e-5*x_73 - 0.00247435341238871*x_74 - 0.0142459629460747*x_75 - 0.00625885279276584*x_76 - 0.0115513626381528*x_77 - 0.00485285624695987*x_78 - 0.0032165040357158*x_79 - 0.00411973816325172*x_8 + 0.00276509613529093*x_80 + 0.00427653628113823*x_81 - 0.0128689607532558*x_82 - 0.0119895941204745*x_83 - 0.000768546735056605*x_84 + 0.00515503948943149*x_85 - 0.00360120221677547*x_86 + 0.0020471758829666*x_87 + 0.0150824380376005*x_88 - 0.00679881193878002*x_89 + 0.0391715143755188*x_9 + 0.000857210449912212*x_90 - 0.00992846223436575*x_91 + 0.000311595846476655*x_92 + 0.000605889493562217*x_93 - 0.015148864448491*x_94 + 0.000333190610546331*x_96 - 0.00454948014972557*x_97 - 0.00599209702684888*x_98 + 0.00833638480147053*x_99 + 1.71862125761976e-5*std::pow(-6.29120016098022*x_103 - 8.73127937316895, 2) - 9.47772681994174e-5*std::pow(-7.75808048248291*x_110 - 9.38607978820801, 2) - 1.178656900957e-5*std::pow(-7.40000009536743*x_110 - 9.99830055236816, 2) + 1.80251772581019e-5*std::pow(-7.57424020767212*x_14 - 9.37415981292725, 2) + 3.47191861564942e-6*std::pow(-6.60400009155273*x_14 - 9.96963977813721, 2) + 3.47568548963868e-6*std::pow(-7.48759984970093*x_15 - 9.33039951324463, 2) + 6.19655745695105e-5*std::pow(-6.43415975570679*x_15 - 9.8625602722168, 2) + 0.000204164601294111*std::pow(-7.42991971969604*x_17 - 9.8689603805542, 2) - 0.000188780522425442*std::pow(-3.6814398765564*x_17 - 5.03768014907837, 2) - 3.22122582357331e-5*std::pow(-8.16792011260986*x_18 - 9.38511943817139, 2) - 5.31928490145511e-6*std::pow(-5.65367984771729*x_18 - 5.04967975616455, 2) - 6.09516975184611e-5*std::pow(-3.69407987594604*x_24 - 5.24943971633911, 2) - 1.00954075175507e-5*std::pow(-3.49719977378845*x_24 - 4.73023986816406, 2) + 1.07093315849196e-5*std::pow(-8.15824031829834*x_42 - 8.98200035095215, 2) + 1.98240057401023e-5*std::pow(-5.91807985305786*x_73 - 8.91327953338623, 2) + 6.96190466739581e-6*std::pow(-6.00263977050781*x_74 - 7.00984001159668, 2) - 3.49250726684823e-5*std::pow(-6.09375953674316*x_76 - 8.72231960296631, 2) - 3.37697191251366e-5*std::pow(-5.88271999359131*x_77 - 8.51807975769043, 2) + 2.14680776845087e-5*std::pow(-3.11719989776611*x_80 - 4.28687953948975, 2) - 2.71160961430135e-5*std::pow(-7.35264015197754*x_81 - 9.76879978179932, 2) - 7.98321160668533e-5*std::pow(-3.48071980476379*x_87 - 4.91408014297485, 2) + 5.52359317340621e-6*std::pow(-6.8120002746582*x_88 - 6.61999988555908, 2) - 3.1005405465294e-5*std::pow(-6.38272047042847*x_88 - 5.97375965118408, 2) + 3.51344464447948e-5*std::pow(-7.00031995773315*x_90 - 9.3840799331665, 2) - 4.67227949140573e-5*std::pow(-5.30272006988525*x_97 - 6.53128004074097, 2) - 0.00456414036995761*std::exp(0.63487982749939*x_1) + 0.000321516142210324*std::exp(1.13743984699249*x_1) - 0.000395231318557034*std::exp(1.20167994499207*x_1) - 0.000293408769857338*std::exp(1.2125598192215*x_1) + 0.000268910025159803*std::exp(1.05679976940155*x_106) - 0.00113783297810409*std::exp(1.3271199464798*x_106) + 0.0331615493387788*std::exp(0.620559811592102*x_109) - 0.00220182149674089*std::exp(0.843999862670898*x_110) - 0.000626806047089772*std::exp(0.924159824848175*x_110) + 0.000100613405885862*std::exp(1.38351988792419*x_26) - 0.00263250482836969*std::exp(0.582799851894379*x_31) + 0.00139538756283986*std::exp(0.667519807815552*x_31) - 0.00152042015045329*std::exp(0.815839886665344*x_6) + 0.000913885880827638*std::exp(0.835679888725281*x_66) + 0.00026916965150808*std::exp(0.971119821071625*x_68) - 0.000671756655909251*std::exp(1.1723198890686*x_68) + 0.00987693166553026*std::exp(0.692079842090607*x_70) - 0.00731839384425191*std::exp(0.620319843292236*x_74) - 0.00419693959889541*std::exp(0.827759861946106*x_74) - 0.000321445930830209*std::exp(0.861039876937866*x_81) - 4.05488434573581*std::exp(-0.0414827698988171*x_10 - 0.0812325796114639*x_101 - 0.0244365009912956*x_103 + 0.0211439992510248*x_104 - 0.0101600445124323*x_105 + 0.00293574790762709*x_106 - 0.0152336261233433*x_107 - 0.0488290209523365*x_11 + 0.0182940065628587*x_113 + 0.00189742968679791*x_114 - 0.00699886434020096*x_116 - 0.00971023615635837*x_119 + 0.0167881626086201*x_12 + 0.00854487666777199*x_120 - 0.007409287256521*x_13 + 0.0116594080214079*x_17 + 0.0214906177593005*x_18 + 0.0228000406726313*x_19 + 0.000243033806561021*x_2 - 0.012197852503672*x_20 + 0.0317248632611786*x_21 + 0.0351889163851122*x_22 + 0.00647374681873017*x_23 + 0.0393261438685279*x_25 - 0.028613011449611*x_26 - 0.0106418823716201*x_27 - 0.0153692058843761*x_29 + 0.0579773991727572*x_3 + 0.0169712074301601*x_30 + 0.00409545368017025*x_32 - 0.0116308573878142*x_33 + 0.0252191705421262*x_34 - 0.000453764468974103*x_36 - 0.00387878370777219*x_37 + 0.00915294768649167*x_38 + 0.0148362760692672*x_39 + 0.0264266288905327*x_40 + 0.000128079883170252*x_41 + 0.0135715132785309*x_42 + 0.00165796487476053*x_43 + 0.0244761748156931*x_44 + 0.00759243649419139*x_46 + 0.0123080094270127*x_47 - 0.00430691126687501*x_48 - 0.0040394464483446*x_49 - 0.00155967506435132*x_5 - 0.000135920974107304*x_51 + 0.0132454805153211*x_52 + 0.00969898207529323*x_54 - 0.00306620108534597*x_55 - 0.00283592370180176*x_56 - 0.00446552191833895*x_57 + 0.00252619911817638*x_6 - 0.00140743626808*x_60 + 0.000905880430816433*x_61 - 0.0268898367871829*x_62 + 0.00784242742297359*x_63 + 0.000835366439559683*x_65 - 0.00329249290687795*x_66 + 0.0109053162155625*x_67 + 0.00321771605514302*x_68 - 0.0280916242975476*x_69 + 0.0028151788352913*x_71 - 0.00447599114683092*x_75 - 0.00787023804371869*x_76 - 0.0131055581728014*x_77 + 0.0272999346029774*x_78 - 0.0201807661406346*x_8 - 0.0133177500988494*x_80 + 0.00641285331347139*x_82 + 0.0222587785818451*x_83 + 0.00396644540344556*x_86 + 0.0134658784390268*x_88 + 0.0177294817429067*x_9 + 0.00809682773353361*x_90 - 0.0105654958030751*x_91 + 0.00113371824085671*x_92 + 0.0191605408429941*x_93 + 0.0165476415781602*x_94 + 0.0242475725530774*x_98 + 0.017126825402349*x_99 + 0.000239198851840865*std::pow(-7.54568004608154*x_14 - 9.38496017456055, 2) + 0.000586623120289384*std::pow(-6.26032018661499*x_15 - 8.67928028106689, 2) + 0.000678153773432319*std::pow(-3.84272003173828*x_7 - 5.66088008880615, 2) + 0.000262500422673791*std::pow(-5.1224799156189*x_70 - 7.08175992965698, 2) - 0.00467549116725126*std::exp(1.57423985004425*x_100) - 0.0318458311027111*std::exp(0.543039858341217*x_109) - 0.00264797375146026*std::exp(1.28303980827332*x_110) + 0.015057957896736*std::exp(0.899439811706543*x_50) - 0.0103652017802406*std::exp(1.00575983524323*x_72) + 0.00558169207608145*std::exp(0.888719916343689*x_74) - 0.00133405709883885*std::exp(1.83999991416931*x_81) + 0.135599702680089*std::sin(0.355119854211807*x_1 - 1.1522399187088) - 0.140052927369894*std::sin(0.371519833803177*x_102 + 1.98631989955902) - 0.0705253777586234*std::sin(0.571119844913483*x_108 + 5.39264011383057) + 0.168985403892608*std::sin(0.379759848117828*x_111 - 4.20928001403809) + 0.0557216834551011*std::sin(0.484159857034683*x_112 - 7.34711980819702) + 1.30838400297293*std::sin(0.114000059664249*x_115 - 7.71016025543213) + 0.0917708014363416*std::sin(0.541919827461243*x_117 + 2.14631986618042) - 0.0359166572304392*std::sin(0.50111985206604*x_118 - 0.914959847927094) - 0.0830172679914254*std::sin(0.428879857063293*x_16 + 2.01399970054626) + 0.135207570453755*std::sin(0.337759852409363*x_24 - 4.27648019790649) + 0.235387417940824*std::sin(0.335119843482971*x_28 - 4.26039981842041) + 0.162404238786662*std::sin(0.262719959020615*x_31 - 1.11887979507446) - 0.207278605493766*std::sin(0.312479853630066*x_35 - 7.4268798828125) + 0.330822083669169*std::sin(0.450239837169647*x_4 + 5.25072002410889) + 0.171680843189703*std::sin(0.403679847717285*x_45 + 5.20216035842896) + 0.221162906362959*std::sin(0.365519851446152*x_53 + 5.17160034179688) + 1.0579035380033*std::sin(0.219359993934631*x_58 + 5.00799989700317) - 0.251779404848396*std::sin(0.252719968557358*x_59 - 7.53144025802612) + 0.256821624588888*std::sin(0.218400001525879*x_64 - 4.37687969207764) + 0.259422871578607*std::sin(0.22639998793602*x_73 - 4.35999965667725) + 0.109605459430306*std::sin(0.429439842700958*x_79 - 1.17511987686157) - 0.18920931605555*std::sin(0.274719953536987*x_84 - 7.52063989639282) + 0.266053793552956*std::sin(0.181760013103485*x_85 + 4.96687984466553) + 0.0567808583637697*std::sin(0.369199842214584*x_87 + 5.17087984085083) - 0.674120544251444*std::sin(0.135120034217834*x_89 + 4.91599988937378) + 0.0545367183727774*std::sin(0.399759858846664*x_95 + 5.18351984024048) + 0.0511331869769149*std::sin(0.377199828624725*x_96 - 7.40903997421265) - 0.021468521600132*std::sin(0.315919935703278*x_97 + 5.12328004837036)) - 0.0374111614391626*std::sin(0.397199839353561*x_10 - 4.18671989440918) - 0.0124397147810228*std::sin(0.472399860620499*x_100 - 4.15240001678467) - 0.0277477032982164*std::sin(0.32711985707283*x_101 + 1.96655988693237) - 0.0198133874598814*std::sin(0.362559854984283*x_102 - 7.41928005218506) - 0.0375580998947729*std::sin(0.362959831953049*x_102 - 7.41296005249023) - 0.0614625919214389*std::sin(0.367999851703644*x_102 - 4.21712017059326) - 0.00669139841367957*std::sin(0.378719836473465*x_105 - 7.40032005310059) + 0.0183222814177275*std::sin(0.407439857721329*x_105 + 5.21447992324829) + 0.02392843353756*std::sin(0.409599840641022*x_105 + 5.19664001464844) - 0.0105844311648627*std::sin(0.579839885234833*x_106 - 7.20016002655029) - 0.012671590447717*std::sin(0.37679985165596*x_107 + 5.16760015487671) + 0.0210784066243671*std::sin(0.422799855470657*x_108 + 5.2085599899292) - 0.148735452527777*std::sin(0.328239858150482*x_111 - 7.45631980895996) - 0.0258755989100093*std::sin(0.346959829330444*x_111 - 7.44280004501343) - 0.0173743347330303*std::sin(0.413439869880676*x_111 - 4.19479990005493) + 0.00312823650487501*std::sin(0.415359854698181*x_111 + 5.20128011703491) + 0.213359731925396*std::sin(0.0988800674676895*x_112 - 7.72000026702881) - 0.492386304565789*std::sin(0.188320010900497*x_112 - 7.61392021179199) - 0.11678532871576*std::sin(0.278399974107742*x_113 + 5.07871961593628) - 0.0178939731481108*std::sin(0.326799839735031*x_113 + 5.14792013168335) + 0.0440982958197231*std::sin(0.38919985294342*x_113 + 5.20240020751953) - 0.0217319731466192*std::sin(0.279999971389771*x_114 + 5.07415962219238) + 0.010493751288225*std::sin(0.176960021257401*x_115 - 7.62800025939941) + 0.0440736879959959*std::sin(0.3852798640728*x_115 + 5.18304014205933) + 0.00486985939499928*std::sin(0.462399870157242*x_115 - 4.15016031265259) - 0.0069345890864099*std::sin(0.704079866409302*x_115 - 0.953199863433838) + 0.020733506985445*std::sin(0.276959955692291*x_117 - 7.5128002166748) + 0.00665868646081395*std::sin(0.486959844827652*x_117 + 2.04119992256165) - 0.00303781018331168*std::sin(0.493199855089188*x_117 + 8.44624042510986) + 0.0110175537834531*std::sin(0.386239856481552*x_119 - 7.41991996765137) - 0.0213649245956073*std::sin(0.361839860677719*x_120 + 5.16088008880615) + 0.0681839349839024*std::sin(0.320879846811295*x_16 + 5.12936019897461) - 0.00651135623993449*std::sin(0.387919843196869*x_16 + 8.37479972839355) + 0.0397487466922441*std::sin(0.362959831953049*x_2 + 8.34000015258789) + 0.0356633733091053*std::sin(0.341119855642319*x_23 + 8.32808017730713) - 0.354292395704065*std::sin(0.265519946813583*x_24 - 7.50544023513794) - 0.00527886249352711*std::sin(0.429839849472046*x_24 - 4.17072010040283) + 0.20272060269084*std::sin(0.337679862976074*x_28 - 4.26599979400635) - 0.0116823994906972*std::sin(0.346559852361679*x_28 + 5.15136003494263) - 0.0148337481690282*std::sin(0.35183984041214*x_28 + 5.15032005310059) + 0.0231749825340647*std::sin(0.649119853973389*x_29 + 5.44807958602905) - 0.414433355838919*std::sin(0.266879975795746*x_3 + 5.08120012283325) + 0.0442159253108174*std::sin(0.277119934558868*x_3 + 5.07439994812012) + 0.429764028354124*std::sin(0.239359974861145*x_32 - 4.39695978164673) - 0.0542632862819978*std::sin(0.244239971041679*x_32 - 1.18919992446899) + 0.00410561942372332*std::sin(0.3642398416996*x_32 + 2.00423979759216) - 0.0152954059469186*std::sin(0.281919926404953*x_33 - 1.16639983654022) - 0.0219162889047003*std::sin(0.298799932003021*x_33 - 1.17119991779327) + 0.0137195608969977*std::sin(0.351039856672287*x_34 + 2.00447988510132) + 0.125823037824354*std::sin(0.363679856061935*x_34 + 1.98031985759735) - 0.0172755167901385*std::sin(0.316559851169586*x_35 - 7.42767953872681) - 0.00471886386516015*std::sin(0.338959842920303*x_36 + 5.13944005966187) - 0.026899621086128*std::sin(0.348479837179184*x_36 + 5.1482400894165) - 0.0138554269960494*std::sin(0.528879821300507*x_38 + 2.14799976348877) + 0.0426711856208601*std::sin(0.138880044221878*x_39 - 7.67199993133545) + 0.0155603402052795*std::sin(0.142080038785934*x_40 + 1.71799993515015) - 0.00967034581694724*std::sin(0.303359925746918*x_41 + 5.1200795173645) + 0.016959745640809*std::sin(0.383839845657349*x_43 + 8.36983966827393) + 0.00339780023518345*std::sin(0.585359811782837*x_45 - 0.991279780864716) + 0.131257048294001*std::sin(0.392799854278564*x_46 - 4.20968008041382) - 0.0262639527165689*std::sin(0.206560000777245*x_48 - 7.60423994064331) + 0.00940483331646945*std::sin(0.346159845590591*x_48 - 7.44863986968994) - 0.0537179181606763*std::sin(0.411759853363037*x_48 - 1.19631993770599) + 0.00596248395956312*std::sin(0.565599858760834*x_49 - 4.01488018035889) + 0.0303353143775291*std::sin(0.331519842147827*x_50 - 7.47583961486816) + 0.042636430522311*std::sin(0.312879920005798*x_51 - 7.46560001373291) - 0.226886416016663*std::sin(0.328079849481583*x_51 - 7.46679973602295) + 0.0165829898079306*std::sin(0.398239850997925*x_51 + 2.0032799243927) - 0.00997299371295392*std::sin(0.225839987397194*x_53 + 5.02431964874268) + 0.00723939050097155*std::sin(0.245759963989258*x_53 + 5.05375957489014) - 0.0693353669497523*std::sin(0.337839841842651*x_54 + 5.14088010787964) + 0.250399687841266*std::sin(0.233839988708496*x_55 - 4.34647989273071) + 0.00374942856496672*std::sin(0.302159935235977*x_55 + 5.13935995101929) - 0.0116575697702768*std::sin(0.237999975681305*x_56 + 1.84207987785339) - 0.0380856219238429*std::sin(0.348079830408096*x_56 - 4.24767971038818) + 0.00187422135285184*std::sin(0.453039854764938*x_58 - 7.33599948883057) + 0.0230143796853323*std::sin(0.202479988336563*x_59 - 7.59496021270752) - 0.00236863969073935*std::sin(0.434399873018265*x_59 - 4.15543985366821) + 0.0339582840788939*std::sin(0.284879922866821*x_63 - 4.28927946090698) - 0.00640785338865878*std::sin(0.265199959278107*x_64 + 5.0732798576355) - 0.00330122247831055*std::sin(0.549919843673706*x_64 + 8.54447937011719) + 0.0325933436879394*std::sin(0.209519997239113*x_66 + 5.01255941390991) + 0.0309174909613325*std::sin(0.185360014438629*x_67 + 4.98880004882813) - 0.00192219978533247*std::sin(0.215919986367226*x_67 - 1.38919985294342) + 0.0471082634987967*std::sin(0.14264003932476*x_70 + 4.91504001617432) - 0.0440739560885715*std::sin(0.252799987792969*x_70 + 5.05615997314453) + 0.00264709844436899*std::sin(0.45839986205101*x_70 - 4.14351987838745) - 0.00667521556951786*std::sin(0.265119969844818*x_71 + 5.10031986236572) + 0.0031384595648091*std::sin(0.417279869318008*x_72 - 4.16544008255005) + 0.0560792544639649*std::sin(0.241039976477623*x_73 + 5.03599977493286) + 0.0511149318358989*std::sin(0.441279858350754*x_73 + 8.44567966461182) - 0.0380374727699443*std::sin(0.286959916353226*x_75 + 5.10399961471558) - 0.00343006836889193*std::sin(0.50631982088089*x_75 + 5.28976011276245) - 0.132577594991959*std::sin(0.201439991593361*x_77 + 5.00008010864258) + 0.0551433193893177*std::sin(0.177760004997253*x_78 - 7.61360025405884) + 0.0347307951330084*std::sin(0.305519849061966*x_79 + 5.10823965072632) - 0.0119328925864801*std::sin(0.354479849338531*x_79 + 5.14448022842407) + 0.0366596533174871*std::sin(0.473759859800339*x_79 + 2.05039978027344) - 0.012564014334525*std::sin(0.389599829912186*x_80 - 4.22240018844604) - 0.00275522033535743*std::sin(0.34639984369278*x_81 + 5.13544034957886) - 0.047510766902042*std::sin(0.201279997825623*x_83 + 5.00423955917358) + 0.0470997911115236*std::sin(0.329919844865799*x_83 - 7.47191953659058) - 0.0282369486741702*std::sin(0.262319952249527*x_84 - 7.53927993774414) + 0.00260910148826522*std::sin(0.285919934511185*x_84 - 7.49776029586792) + 0.506177579133442*std::sin(0.207039996981621*x_85 - 7.60423994064331) - 0.0607818706645711*std::sin(0.218719989061356*x_85 + 1.81463992595673) + 0.16789274150379*std::sin(0.239359974861145*x_86 + 5.04375982284546) + 0.017663484536199*std::sin(0.274719953536987*x_86 + 5.07567977905273) + 0.0105083213025833*std::sin(0.263039976358414*x_87 + 5.06744003295898) - 0.0195112363232301*std::sin(0.851599872112274*x_87 - 0.74703985452652) + 0.154805131864577*std::sin(0.136560037732124*x_89 - 7.68688011169434) - 0.0517572124466467*std::sin(0.167120009660721*x_89 + 1.74775993824005) + 0.00845896690192046*std::sin(0.231359988451004*x_89 - 7.56800031661987) + 0.0376066581863466*std::sin(0.257439970970154*x_90 + 5.07199954986572) + 0.0501731942176557*std::sin(0.615919828414917*x_90 + 5.41048002243042) + 0.00488195368596637*std::sin(0.346959829330444*x_92 + 5.19504022598267) - 0.0241175363437111*std::sin(0.362319827079773*x_92 - 7.40927982330322) - 0.06929482517101*std::sin(0.374959826469421*x_92 + 2.00839972496033) - 0.192557716010825*std::sin(0.2882399559021*x_93 - 1.32551980018616) + 0.0289898452331706*std::sin(0.359519839286804*x_94 - 1.19071984291077) - 0.0227197424106972*std::sin(0.384239852428436*x_94 + 2.00543975830078) + 0.0142168045121148*std::sin(0.359839856624603*x_95 - 4.23415994644165) - 0.00518790477237668*std::sin(0.380559861660004*x_95 - 7.42167997360229) - 0.0103825933315761*std::sin(0.38623982667923*x_95 - 4.19471979141235) + 0.096532039263203*std::sin(0.402799844741821*x_95 + 2.00415992736816) + 0.0361188743386085*std::sin(0.378239840269089*x_96 + 8.36672019958496) + 0.00792442999431888*std::sin(0.381439834833145*x_96 - 7.39928007125854) - 0.00920640070451658*std::sin(0.396879822015762*x_96 + 5.18616008758545) - 0.00675766328030865*std::sin(0.417759865522385*x_98 - 7.40039968490601) - 0.0242717664143491*std::sin(0.42223984003067*x_98 - 7.3790397644043) - 0.0173685218186338*std::sin(0.324319928884506*x_99 + 1.9210399389267) + 0.0298346473664123*std::sin(0.333199828863144*x_99 + 1.93759977817535) - 0.00484218522041668*std::sin(0.359599858522415*x_99 + 1.94671976566315) - 0.963732334929697 - 2.43596265296098e-5*std::exp(-2.02751994132996*x_30));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00487258530315657*x_10 + 0.0100448011018709*x_100 + 0.0026544759088915*x_101 + 3.26222480737592e-6*x_102 + 0.00415319373037488*x_103 - 0.00414625362218536*x_104 + 0.00360627807373978*x_105 + 0.0053729218215268*x_106 + 0.0182668174044386*x_107 + 0.00780766710919531*x_108 + 3.02885343036201e-5*x_109 - 0.00510541398418292*x_11 + 0.00829425289622169*x_112 + 1.02070034217942e-5*x_113 + 0.00569036109649231*x_114 - 0.0106124038628116*x_116 + 0.00641418579709515*x_117 + 0.0386086232087379*x_118 + 0.0116550337590658*x_119 + 0.0543302104292399*x_12 + 0.00762093275191349*x_120 - 0.000518919393269538*x_13 - 0.0154873279774925*x_14 - 0.00989705201686552*x_15 - 0.0285082528859492*x_16 - 0.00113446049888338*x_17 + 0.00766618475509162*x_18 + 0.000535331160934406*x_19 + 0.023869419925184*x_2 - 0.00108839021588589*x_20 + 0.00195786794980762*x_21 - 0.0511499611112032*x_22 + 0.00459116658641354*x_23 + 0.000499776925929901*x_25 + 0.0260944637665333*x_26 - 0.0187420316485788*x_27 - 1.12952516089443e-5*x_28 - 0.00330777605287467*x_29 - 0.00254147688529917*x_3 - 0.00684193966949892*x_30 - 0.134916624075467*x_31 + 0.00769397977258764*x_32 - 0.00419045455710115*x_33 - 0.00187159781954847*x_34 - 0.0026335952855224*x_35 + 0.00664766277613194*x_36 + 0.0189145870193552*x_37 + 0.010398398030885*x_38 - 0.00287487655441359*x_39 + 0.0117585272372809*x_4 + 0.022604288471032*x_40 + 0.020450025656868*x_41 - 0.0212153115370538*x_42 + 0.0017520870088924*x_43 + 0.0480156834465861*x_44 + 0.000623110552381407*x_45 + 3.63431323103219e-5*x_46 - 0.00793184258614135*x_47 + 0.00334545375973748*x_48 + 0.00869584270885836*x_49 - 0.00496614936417159*x_5 + 0.0163759623747532*x_50 - 1.8650072159185e-5*x_51 + 0.0138728147087425*x_52 + 0.00384304685460467*x_53 + 0.0130520530028908*x_54 - 0.000996107142223644*x_55 + 0.00454046871430708*x_56 - 0.00296835542269417*x_57 + 6.16202963554364e-5*x_58 - 0.0149952244832537*x_59 - 0.031057028121309*x_6 + 0.0132785738734862*x_60 + 0.012924717785625*x_61 - 0.00410023410300932*x_62 - 0.000591012073684947*x_63 + 0.00382742899440696*x_64 - 0.00116839330950016*x_65 - 0.014277299648985*x_66 + 0.00866173842366922*x_67 + 0.011578118880158*x_68 + 0.00511769967320109*x_69 - 0.020260376578635*x_7 + 0.0113229178697674*x_71 + 0.00653726304715943*x_72 - 2.45481898631312e-6*x_73 + 0.00278348989397092*x_74 + 0.0165140922540478*x_75 + 0.0035213393370122*x_76 + 0.012793508787361*x_77 + 0.00524228465245123*x_78 - 0.00397409000764342*x_79 + 0.00375273672748284*x_8 - 0.00318060572338847*x_80 - 0.00481083076497814*x_81 + 0.021208780727055*x_82 + 0.0140713298788815*x_83 + 0.00202797119042297*x_84 + 0.00605967774602102*x_85 + 0.00439141237665514*x_86 + 0.00252934898574615*x_87 - 0.0150280242737874*x_88 + 0.00764823013068841*x_89 - 0.0320297851259808*x_9 + 0.000179981409157579*x_90 - 0.0089200721516811*x_91 + 0.00038498628515804*x_92 + 0.0182937715740449*x_93 + 0.0163920540127395*x_94 + 0.000411667282649037*x_96 + 0.00504550938217222*x_97 + 0.00686643712845535*x_98 - 0.00937790160894796*x_99 - 9.04853418714068e-6*std::pow(-6.29120016098022*x_103 - 8.73127937316895, 2) + 0.000106618386399609*std::pow(-7.75808048248291*x_110 - 9.38607978820801, 2) - 1.45626697822276e-5*std::pow(-7.40000009536743*x_110 - 9.99830055236816, 2) - 9.49024876342426e-6*std::pow(-7.57424020767212*x_14 - 9.37415981292725, 2) + 7.2897012045176e-7*std::pow(-6.60400009155273*x_14 - 9.96963977813721, 2) + 7.29761019919651e-7*std::pow(-7.48759984970093*x_15 - 9.33039951324463, 2) + 7.6560379834802e-5*std::pow(-6.43415975570679*x_15 - 9.8625602722168, 2) - 0.000229672164680849*std::pow(-7.42991971969604*x_17 - 9.8689603805542, 2) - 0.000233244161822324*std::pow(-3.6814398765564*x_17 - 5.03768014907837, 2) - 3.97992392227072e-5*std::pow(-8.16792011260986*x_18 - 9.38511943817139, 2) - 1.11684638512348e-6*std::pow(-5.65367984771729*x_18 - 5.04967975616455, 2) - 7.53077034467689e-5*std::pow(-3.69407987594604*x_24 - 5.24943971633911, 2) - 2.11964946439333e-6*std::pow(-3.49719977378845*x_24 - 4.73023986816406, 2) - 5.63845888312704e-6*std::pow(-8.15824031829834*x_42 - 8.98200035095215, 2) - 1.04373312543464e-5*std::pow(-5.91807985305786*x_73 - 8.91327953338623, 2) + 1.46173371146717e-6*std::pow(-6.00263977050781*x_74 - 7.00984001159668, 2) + 1.83880370749524e-5*std::pow(-6.09375953674316*x_76 - 8.72231960296631, 2) - 4.17235302197483e-5*std::pow(-5.88271999359131*x_77 - 8.51807975769043, 2) + 4.50747523429976e-6*std::pow(-3.11719989776611*x_80 - 4.28687953948975, 2) - 3.35027736734262e-5*std::pow(-7.35264015197754*x_81 - 9.76879978179932, 2) + 4.20315778278664e-5*std::pow(-3.48071980476379*x_87 - 4.91408014297485, 2) + 1.15974330815104e-6*std::pow(-6.8120002746582*x_88 - 6.61999988555908, 2) - 3.83081353775255e-5*std::pow(-6.38272047042847*x_88 - 5.97375965118408, 2) + 4.34096929429996e-5*std::pow(-7.00031995773315*x_90 - 9.3840799331665, 2) - 5.77274551299628e-5*std::pow(-5.30272006988525*x_97 - 6.53128004074097, 2) + 0.0051343670353772*std::exp(0.63487982749939*x_1) + 0.000397243116708779*std::exp(1.13743984699249*x_1) - 8.29834606710499e-5*std::exp(1.20167994499207*x_1) + 0.000154479602360906*std::exp(1.2125598192215*x_1) + 5.64608204085916e-5*std::exp(1.05679976940155*x_106) + 0.0012799895842373*std::exp(1.3271199464798*x_106) - 0.0373046295613038*std::exp(0.620559811592102*x_109) + 0.00115925815527467*std::exp(0.843999862670898*x_110) - 0.000131605296733448*std::exp(0.924159824848175*x_110) + 0.000124310968220811*std::exp(1.38351988792419*x_26) - 0.00325254096289945*std::exp(0.582799851894379*x_31) + 0.000292978019466046*std::exp(0.667519807815552*x_31) + 0.000800500613453835*std::exp(0.815839886665344*x_6) + 0.000191881082011329*std::exp(0.835679888725281*x_66) + 5.65153320119231e-5*std::exp(0.971119821071625*x_68) + 0.000353679616115804*std::exp(1.1723198890686*x_68) - 0.0111109186492095*std::exp(0.692079842090607*x_70) + 0.00385313149136693*std::exp(0.620319843292236*x_74) - 0.00518544840530302*std::exp(0.827759861946106*x_74) + 0.000169241156627072*std::exp(0.861039876937866*x_81) + 2.34073665748427*std::exp(-0.0461080527250518*x_10 - 0.0902899221255749*x_101 - 0.0271611437440335*x_103 + 0.023501531712146*x_104 - 0.0112928782048727*x_105 + 0.00326308054265658*x_106 - 0.0169321585371971*x_107 - 0.0542734026217277*x_11 + 0.0203337680007908*x_113 + 0.00210899099202754*x_114 - 0.00777922995018402*x_116 - 0.010792916716076*x_119 + 0.0186600241161106*x_12 + 0.00949762093726365*x_120 - 0.00823541456638521*x_13 + 0.0129594190818317*x_17 + 0.0238867977995852*x_18 + 0.0253422199151891*x_19 + 0.000270131806391384*x_2 - 0.0135578995265635*x_20 + 0.0352621503219146*x_21 + 0.0391124415264386*x_22 + 0.0071955624075903*x_23 + 0.0437109652847642*x_25 - 0.0318033304853828*x_26 - 0.0118284404508496*x_27 - 0.0170828552911843*x_29 + 0.0644418148652867*x_3 + 0.0188634782321979*x_30 + 0.00455209222235861*x_32 - 0.012927685084264*x_33 + 0.0280310800815542*x_34 - 0.000504358703896715*x_36 - 0.00431126378839354*x_37 + 0.0101734912000279*x_38 + 0.0164905043928782*x_39 + 0.0293731686963556*x_40 + 0.000142360648062723*x_41 + 0.0150847219539959*x_42 + 0.00184282611909004*x_43 + 0.0272052411558405*x_44 + 0.00843898474088554*x_46 + 0.0136803388246579*x_47 - 0.00478712709540775*x_48 - 0.00448984024631409*x_49 - 0.00173357710385462*x_5 - 0.000151076011941013*x_51 + 0.0147223368993613*x_52 + 0.0107804078174564*x_54 - 0.00340807910497738*x_55 - 0.00315212604861828*x_56 - 0.00496342265856066*x_57 + 0.00280786751750098*x_6 - 0.00156436385067993*x_60 + 0.00100688509394518*x_61 - 0.0298880237596386*x_62 + 0.00871684938090813*x_63 + 0.000928508870885571*x_65 - 0.00365960221358112*x_66 + 0.0121212468761604*x_67 + 0.00357648782582887*x_68 - 0.0312238092442474*x_69 + 0.0031290681525045*x_71 - 0.0049750591944158*x_75 - 0.00874776085501555*x_76 - 0.0145668133708688*x_77 + 0.0303438470269663*x_78 - 0.0224308991784768*x_8 - 0.0148026644612833*x_80 + 0.00712787934404528*x_82 + 0.0247406077017107*x_83 + 0.00440869966589001*x_86 + 0.0149673089470694*x_88 + 0.0197062992896503*x_9 + 0.00899961504388536*x_90 - 0.0117435368646487*x_91 + 0.00126012656706092*x_92 + 0.0212969198919013*x_93 + 0.0183926852575683*x_94 + 0.0269511499945353*x_98 + 0.0190364474356565*x_99 + 0.000265869258474105*std::pow(-7.54568004608154*x_14 - 9.38496017456055, 2) + 0.000652030947451476*std::pow(-6.26032018661499*x_15 - 8.67928028106689, 2) + 0.000753767166883468*std::pow(-3.84272003173828*x_7 - 5.66088008880615, 2) + 0.000291768928606106*std::pow(-5.1224799156189*x_70 - 7.08175992965698, 2) - 0.00519680324580452*std::exp(1.57423985004425*x_100) - 0.0353966059435864*std::exp(0.543039858341217*x_109) - 0.00294321988730951*std::exp(1.28303980827332*x_110) + 0.0167369034981945*std::exp(0.899439811706543*x_50) - 0.0115209102804575*std::exp(1.00575983524323*x_72) + 0.00620404455070648*std::exp(0.888719916343689*x_74) - 0.00148280298546904*std::exp(1.83999991416931*x_81) + 0.150718919106055*std::sin(0.355119854211807*x_1 - 1.1522399187088) - 0.155668673408741*std::sin(0.371519833803177*x_102 + 1.98631989955902) - 0.0783888791438088*std::sin(0.571119844913483*x_108 + 5.39264011383057) + 0.18782708896849*std::sin(0.379759848117828*x_111 - 4.20928001403809) + 0.0619345893474126*std::sin(0.484159857034683*x_112 - 7.34711980819702) + 1.45426736789364*std::sin(0.114000059664249*x_115 - 7.71016025543213) + 0.102003143993713*std::sin(0.541919827461243*x_117 + 2.14631986618042) - 0.0399213246687253*std::sin(0.50111985206604*x_118 - 0.914959847927094) - 0.0922736012801195*std::sin(0.428879857063293*x_16 + 2.01399970054626) + 0.150283064571482*std::sin(0.337759852409363*x_24 - 4.27648019790649) + 0.261632853922293*std::sin(0.335119843482971*x_28 - 4.26039981842041) + 0.18051213125382*std::sin(0.262719959020615*x_31 - 1.11887979507446) - 0.230389940068932*std::sin(0.312479853630066*x_35 - 7.4268798828125) + 0.367708379012186*std::sin(0.450239837169647*x_4 + 5.25072002410889) + 0.190823066757119*std::sin(0.403679847717285*x_45 + 5.20216035842896) + 0.245822325082969*std::sin(0.365519851446152*x_53 + 5.17160034179688) + 1.17585860894178*std::sin(0.219359993934631*x_58 + 5.00799989700317) - 0.279852529186172*std::sin(0.252719968557358*x_59 - 7.53144025802612) + 0.285456950834316*std::sin(0.218400001525879*x_64 - 4.37687969207764) + 0.288348233977786*std::sin(0.22639998793602*x_73 - 4.35999965667725) + 0.12182634656974*std::sin(0.429439842700958*x_79 - 1.17511987686157) - 0.210305944902899*std::sin(0.274719953536987*x_84 - 7.52063989639282) + 0.295718496396489*std::sin(0.181760013103485*x_85 + 4.96687984466553) + 0.0631118610834385*std::sin(0.369199842214584*x_87 + 5.17087984085083) - 0.749284237123049*std::sin(0.135120034217834*x_89 + 4.91599988937378) + 0.06061750197291*std::sin(0.399759858846664*x_95 + 5.18351984024048) + 0.0568344806019994*std::sin(0.377199828624725*x_96 - 7.40903997421265) - 0.023862237943181*std::sin(0.315919935703278*x_97 + 5.12328004837036)) + 0.0420851723388594*std::sin(0.397199839353561*x_10 - 4.18671989440918) - 0.0153696515410078*std::sin(0.472399860620499*x_100 - 4.15240001678467) + 0.0146091549138802*std::sin(0.32711985707283*x_101 + 1.96655988693237) - 0.0244800517106639*std::sin(0.362559854984283*x_102 - 7.41928005218506) + 0.0197743248778718*std::sin(0.362959831953049*x_102 - 7.41296005249023) + 0.0691414987907587*std::sin(0.367999851703644*x_102 - 4.21712017059326) - 0.00140493774411193*std::sin(0.378719836473465*x_105 - 7.40032005310059) - 0.00964667398705019*std::sin(0.407439857721329*x_105 + 5.21447992324829) + 0.0295643181430099*std::sin(0.409599840641022*x_105 + 5.19664001464844) + 0.00557269886090789*std::sin(0.579839885234833*x_106 - 7.20016002655029) + 0.0066715874055004*std::sin(0.37679985165596*x_107 + 5.16760015487671) + 0.0260430219308898*std::sin(0.422799855470657*x_108 + 5.2085599899292) + 0.167317904917465*std::sin(0.328239858150482*x_111 - 7.45631980895996) + 0.0136234926870526*std::sin(0.346959829330444*x_111 - 7.44280004501343) - 0.0214665267897362*std::sin(0.413439869880676*x_111 - 4.19479990005493) + 0.000656810021836813*std::sin(0.415359854698181*x_111 + 5.20128011703491) - 0.11233381525607*std::sin(0.0988800674676895*x_112 - 7.72000026702881) + 0.553903211977083*std::sin(0.188320010900497*x_112 - 7.61392021179199) + 0.131376051867453*std::sin(0.278399974107742*x_113 + 5.07871961593628) + 0.00942116985092486*std::sin(0.326799839735031*x_113 + 5.14792013168335) + 0.0544848054985465*std::sin(0.38919985294342*x_113 + 5.20240020751953) - 0.0268505235402682*std::sin(0.279999971389771*x_114 + 5.07415962219238) + 0.00220328642096853*std::sin(0.176960021257401*x_115 - 7.62800025939941) - 0.0232047794601046*std::sin(0.3852798640728*x_115 + 5.18304014205933) + 0.00601686158182861*std::sin(0.462399870157242*x_115 - 4.15016031265259) + 0.00780097076845168*std::sin(0.704079866409302*x_115 - 0.953199863433838) - 0.0233238739751601*std::sin(0.276959955692291*x_117 - 7.5128002166748) - 0.00350579581248589*std::sin(0.486959844827652*x_117 + 2.04119992256165) - 0.000637823952801406*std::sin(0.493199855089188*x_117 + 8.44624042510986) - 0.00580073774988143*std::sin(0.386239856481552*x_119 - 7.41991996765137) + 0.0112486244279778*std::sin(0.361839860677719*x_120 + 5.16088008880615) + 0.0842433560451088*std::sin(0.320879846811295*x_16 + 5.12936019897461) + 0.00342822650892257*std::sin(0.387919843196869*x_16 + 8.37479972839355) + 0.0491108033106644*std::sin(0.362959831953049*x_2 + 8.34000015258789) + 0.044063198408216*std::sin(0.341119855642319*x_23 + 8.32808017730713) + 0.398556365479325*std::sin(0.265519946813583*x_24 - 7.50544023513794) + 0.00277931903437813*std::sin(0.429839849472046*x_24 - 4.17072010040283) - 0.228047758280781*std::sin(0.337679862976074*x_28 - 4.26599979400635) + 0.00615077875423302*std::sin(0.346559852361679*x_28 + 5.15136003494263) - 0.0183275536793521*std::sin(0.35183984041214*x_28 + 5.15032005310059) - 0.0260703783677559*std::sin(0.649119853973389*x_29 + 5.44807958602905) + 0.466211112740132*std::sin(0.266879975795746*x_3 + 5.08120012283325) - 0.023279667350624*std::sin(0.277119934558868*x_3 + 5.07439994812012) - 0.483457142268572*std::sin(0.239359974861145*x_32 - 4.39695978164673) + 0.0285695989650032*std::sin(0.244239971041679*x_32 - 1.18919992446899) + 0.000862023053291203*std::sin(0.3642398416996*x_32 + 2.00423979759216) - 0.00321145025267196*std::sin(0.281919926404953*x_33 - 1.16639983654022) + 0.0115389175206693*std::sin(0.298799932003021*x_33 - 1.17119991779327) + 0.00288058306279134*std::sin(0.351039856672287*x_34 + 2.00447988510132) - 0.141542898625263*std::sin(0.363679856061935*x_34 + 1.98031985759735) - 0.0213444341714582*std::sin(0.316559851169586*x_35 - 7.42767953872681) - 0.000990780931521871*std::sin(0.338959842920303*x_36 + 5.13944005966187) + 0.0141626399615273*std::sin(0.348479837179184*x_36 + 5.1482400894165) - 0.0171188076760423*std::sin(0.528879821300507*x_38 + 2.14799976348877) - 0.0224663625091506*std::sin(0.138880044221878*x_39 - 7.67199993133545) + 0.00326707631411206*std::sin(0.142080038785934*x_40 + 1.71799993515015) + 0.00509143328340465*std::sin(0.303359925746918*x_41 + 5.1200795173645) - 0.00892929943439716*std::sin(0.383839845657349*x_43 + 8.36983966827393) + 0.00419808705746144*std::sin(0.585359811782837*x_45 - 0.991279780864716) - 0.147655814084414*std::sin(0.392799854278564*x_46 - 4.20968008041382) + 0.0138279608140341*std::sin(0.206560000777245*x_48 - 7.60423994064331) + 0.0019746552942322*std::sin(0.346159845590591*x_48 - 7.44863986968994) + 0.0604292343918047*std::sin(0.411759853363037*x_48 - 1.19631993770599) + 0.00736683295320685*std::sin(0.565599858760834*x_49 - 4.01488018035889) - 0.0159715311332116*std::sin(0.331519842147827*x_50 - 7.47583961486816) - 0.0224480639633829*std::sin(0.312879920005798*x_51 - 7.46560001373291) + 0.255232758141848*std::sin(0.328079849481583*x_51 - 7.46679973602295) + 0.0204887957113612*std::sin(0.398239850997925*x_51 + 2.0032799243927) - 0.0123219415305726*std::sin(0.225839987397194*x_53 + 5.02431964874268) + 0.00151999512364821*std::sin(0.245759963989258*x_53 + 5.05375957489014) + 0.0365050435307478*std::sin(0.337839841842651*x_54 + 5.14088010787964) - 0.281683690401678*std::sin(0.233839988708496*x_55 - 4.34647989273071) + 0.000787236596016181*std::sin(0.302159935235977*x_55 + 5.13935995101929) - 0.00244764379018254*std::sin(0.237999975681305*x_56 + 1.84207987785339) + 0.0200520650194735*std::sin(0.348079830408096*x_56 - 4.24767971038818) + 0.000393514801638319*std::sin(0.453039854764938*x_58 - 7.33599948883057) - 0.0121170618863973*std::sin(0.202479988336563*x_59 - 7.59496021270752) - 0.000497323742809597*std::sin(0.434399873018265*x_59 - 4.15543985366821) - 0.0178790232613596*std::sin(0.284879922866821*x_63 - 4.28927946090698) - 0.00134540413347047*std::sin(0.265199959278107*x_64 + 5.0732798576355) - 0.00407876225814909*std::sin(0.549919843673706*x_64 + 8.54447937011719) + 0.040270082060414*std::sin(0.209519997239113*x_66 + 5.01255941390991) - 0.0162780468764646*std::sin(0.185360014438629*x_67 + 4.98880004882813) - 0.000403588437450761*std::sin(0.215919986367226*x_67 - 1.38919985294342) - 0.0248024822732643*std::sin(0.14264003932476*x_70 + 4.91504001617432) - 0.0544547330095074*std::sin(0.252799987792969*x_70 + 5.05615997314453) + 0.000555789430991138*std::sin(0.45839986205101*x_70 - 4.14351987838745) - 0.00140153996577558*std::sin(0.265119969844818*x_71 + 5.10031986236572) + 0.000658956473426417*std::sin(0.417279869318008*x_72 - 4.16544008255005) + 0.0692876496738919*std::sin(0.241039976477623*x_73 + 5.03599977493286) - 0.057501040669402*std::sin(0.441279858350754*x_73 + 8.44567966461182) - 0.046996471564322*std::sin(0.286959916353226*x_75 + 5.10399961471558) + 0.00180592965218724*std::sin(0.50631982088089*x_75 + 5.28976011276245) + 0.0698020518142018*std::sin(0.201439991593361*x_77 + 5.00008010864258) + 0.0681312730032403*std::sin(0.177760004997253*x_78 - 7.61360025405884) - 0.0182857500286509*std::sin(0.305519849061966*x_79 + 5.10823965072632) - 0.00250545105144329*std::sin(0.354479849338531*x_79 + 5.14448022842407) - 0.0412397735969305*std::sin(0.473759859800339*x_79 + 2.05039978027344) - 0.0155232274756381*std::sin(0.389599829912186*x_80 - 4.22240018844604) - 0.000578490892811715*std::sin(0.34639984369278*x_81 + 5.13544034957886) + 0.0250144001573565*std::sin(0.201279997825623*x_83 + 5.00423955917358) + 0.0581932455672308*std::sin(0.329919844865799*x_83 - 7.47191953659058) - 0.0348876215687345*std::sin(0.262319952249527*x_84 - 7.53927993774414) + 0.000547811523461016*std::sin(0.285919934511185*x_84 - 7.49776029586792) - 0.569417516923109*std::sin(0.207039996981621*x_85 - 7.60423994064331) + 0.0320016310881929*std::sin(0.218719989061356*x_85 + 1.81463992595673) + 0.207436663830452*std::sin(0.239359974861145*x_86 + 5.04375982284546) - 0.00929981768706771*std::sin(0.274719953536987*x_86 + 5.07567977905273) + 0.00220634556673129*std::sin(0.263039976358414*x_87 + 5.06744003295898) + 0.0219488973776627*std::sin(0.851599872112274*x_87 - 0.74703985452652) + 0.19126651819606*std::sin(0.136560037732124*x_89 - 7.68688011169434) + 0.0272501520726682*std::sin(0.167120009660721*x_89 + 1.74775993824005) + 0.00177605952328379*std::sin(0.231359988451004*x_89 - 7.56800031661987) - 0.0197998907993583*std::sin(0.257439970970154*x_90 + 5.07199954986572) - 0.0564416458675004*std::sin(0.615919828414917*x_90 + 5.41048002243042) + 0.00102502355627168*std::sin(0.346959829330444*x_92 + 5.19504022598267) + 0.012697873434774*std::sin(0.362319827079773*x_92 - 7.40927982330322) + 0.0779522620342996*std::sin(0.374959826469421*x_92 + 2.00839972496033) + 0.216615158464701*std::sin(0.2882399559021*x_93 - 1.32551980018616) + 0.0358178485041553*std::sin(0.359519839286804*x_94 - 1.19071984291077) + 0.0119619354767523*std::sin(0.384239852428436*x_94 + 2.00543975830078) - 0.00748514200493082*std::sin(0.359839856624603*x_95 - 4.23415994644165) - 0.00108926158285087*std::sin(0.380559861660004*x_95 - 7.42167997360229) - 0.0128280145009237*std::sin(0.38623982667923*x_95 - 4.19471979141235) - 0.10859239201167*std::sin(0.402799844741821*x_95 + 2.00415992736816) - 0.0406314317105031*std::sin(0.378239840269089*x_96 + 8.36672019958496) - 0.00417220928690863*std::sin(0.381439834833145*x_96 - 7.39928007125854) - 0.00193299203508067*std::sin(0.396879822015762*x_96 + 5.18616008758545) - 0.00141885083170292*std::sin(0.417759865522385*x_98 - 7.40039968490601) - 0.0299885165086244*std::sin(0.42223984003067*x_98 - 7.3790397644043) + 0.00914451993184749*std::sin(0.324319928884506*x_99 + 1.9210399389267) + 0.0368616276130487*std::sin(0.333199828863144*x_99 + 1.93759977817535) - 0.001016673699512*std::sin(0.359599858522415*x_99 + 1.94671976566315) + 2.24112498194343 + 2.74030273632645e-5*std::exp(-2.02751994132996*x_30));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
