
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0240567959589726*x_1 + 0.0156299765266712*x_10 + 0.00390700383073021*x_100 - 0.0238364395523987*x_101 - 0.00420343628684085*x_102 - 0.0350314263966563*x_103 + 3.42357633378572e-5*x_104 + 0.000203324261346166*x_105 - 0.00222364261435461*x_106 + 0.0385784259038173*x_107 - 0.00042706693036712*x_108 + 0.00715391990320742*x_109 + 0.0451206663107225*x_11 + 0.00383262393578789*x_110 + 0.00605346146779021*x_111 + 0.0388329605318938*x_112 + 0.000215530516532877*x_113 - 0.00232558023302168*x_114 - 0.00524509883120112*x_115 - 0.0207394935235467*x_116 + 0.00733738847809619*x_117 + 0.00889275524205736*x_118 - 0.0178242967855898*x_119 - 0.00970492205181086*x_12 + 0.00505133821101659*x_120 + 0.027780811821534*x_13 + 0.00261965239288021*x_14 + 0.00192837103318309*x_15 + 0.0098051634813754*x_16 + 0.0027782205868605*x_17 - 0.00723202170802125*x_18 + 0.0193346795052088*x_19 + 0.0258060212453337*x_2 - 0.0275921614511362*x_20 - 0.00802736347370465*x_21 + 0.00813766437135575*x_22 - 0.0348450282234561*x_23 + 0.000244113526470995*x_24 - 0.0655958536632516*x_25 - 0.00522845170381176*x_26 - 0.00423199773889914*x_27 + 0.0291132780090662*x_28 + 0.0283943663323476*x_29 + 0.0543840074798735*x_3 + 0.0506865421555458*x_30 - 0.00472662672339789*x_31 + 0.0900419378487281*x_32 + 0.017321987366304*x_33 + 0.0176715680393313*x_34 - 0.00825445092685535*x_35 - 0.0125507490278064*x_36 - 0.0023151672563237*x_37 + 0.0495367988018892*x_38 + 0.00837641034408849*x_39 - 0.0183389712791356*x_4 - 0.00618026232328216*x_40 + 0.0481225778982219*x_41 - 0.0522180836360307*x_42 + 0.000641492237215401*x_43 + 0.128773373727554*x_44 + 0.0025328280185395*x_45 - 0.042619342578451*x_46 + 0.0194830030471239*x_47 - 0.00563148492443713*x_48 - 0.00169634396552049*x_49 - 0.00140285453241905*x_5 - 0.00274205178743837*x_50 + 0.0046271175873153*x_51 + 0.0361747638885549*x_52 + 0.00826748515278698*x_53 + 0.0529471399225834*x_54 + 0.0309974593170682*x_55 + 0.00572466371889715*x_56 - 0.00629689188543302*x_57 - 0.0293303735090687*x_58 + 0.0435913688056066*x_59 + 0.0180334577671361*x_6 + 0.0105678191416644*x_60 - 0.0484369470325688*x_61 + 0.059539552073687*x_62 - 0.0442358557092382*x_63 + 0.012307389966743*x_64 - 0.00327298765734881*x_65 + 0.00207152482251013*x_66 - 0.0161543247383834*x_67 - 0.00443718837042917*x_68 - 0.0220105109407213*x_69 + 0.0302823234119804*x_7 + 0.00246509317968881*x_70 + 0.00637511055450599*x_71 + 0.00783484591283573*x_72 + 0.0303550559688856*x_73 + 0.0271103937839092*x_74 + 0.00570967148767426*x_75 - 0.00698433518497325*x_76 + 0.0325604794902827*x_77 - 0.0223165980016635*x_78 + 0.0131107908496208*x_79 + 0.10172772167369*x_8 - 0.00344717078195882*x_80 + 0.00214823839161739*x_81 - 0.0121461315838892*x_82 + 0.0460406718147872*x_83 - 0.000447931403094075*x_84 - 0.0235635549195834*x_85 + 0.0097573299158052*x_86 + 0.0235617733435867*x_87 - 0.0154844278527112*x_88 + 0.028524403778342*x_89 - 0.00505742196302598*x_9 + 0.0167260665042977*x_90 - 0.0400816754405112*x_91 - 0.025006933373379*x_92 + 0.0901187971924686*x_93 + 0.0238748226006834*x_94 - 0.00560816076988756*x_95 - 0.000656456539023438*x_96 + 0.0125541417571287*x_97 + 0.00660248738367249*x_98 - 0.000983388132249209*x_99 - 0.000172973246297006*std::pow(-9.94719982147217*x_102 - 9.78800010681152, 2) + 0.000275369583204446*std::pow(-7.96016025543213*x_104 - 9.15664005279541, 2) - 0.000307838634842345*std::pow(-6.34000015258789*x_108 - 9.19999980926514, 2) + 2.9016102651538e-6*std::pow(-7.53336048126221*x_110 - 9.12399959564209, 2) + 3.39937610545595e-7*std::pow(-6.82224035263062*x_112 - 7.22352027893066, 2) - 1.56852622994546e-5*std::pow(-8.39915943145752*x_114 - 7.57599973678589, 2) + 1.90991020272524e-6*std::pow(-7.7480001449585*x_115 - 7.5417594909668, 2) + 6.64866472106696e-5*std::pow(-4.07359981536865*x_13 - 6.10303974151611, 2) + 7.3846220943018e-6*std::pow(-6.60400009155273*x_14 - 9.97567939758301, 2) + 1.13639167417782e-5*std::pow(-8.70680046081543*x_15 - 9.9235200881958, 2) + 7.11753121019481e-5*std::pow(-4.7579197883606*x_15 - 6.15079975128174, 2) + 9.18835854587447e-6*std::pow(-4.46928024291992*x_15 - 5.25055980682373, 2) - 3.4757104975365e-5*std::pow(-4.34728002548218*x_24 - 5.5318398475647, 2) + 9.74385178298368e-6*std::pow(-7.32087993621826*x_27 - 8.55039978027344, 2) + 1.06467791554185e-5*std::pow(-5.54271984100342*x_36 - 6.56727981567383, 2) - 3.9925542215065e-6*std::pow(-9.39496040344238*x_39 - 8.79872035980225, 2) + 6.45062439848038e-5*std::pow(-4.88320016860962*x_4 - 8.13959980010986, 2) - 9.98648778778098e-7*std::pow(-5.77159976959229*x_47 - 3.50111985206604, 2) + 1.6590797565092e-6*std::pow(-6.14759969711304*x_53 - 5.93872022628784, 2) + 5.89835045043858e-6*std::pow(-5.93631982803345*x_57 - 7.71104001998901, 2) - 0.000592077383839171*std::pow(-4.32000017166138*x_57 - 6.7828803062439, 2) - 3.24449890036797e-5*std::pow(-5.4871997833252*x_6 - 8.73799991607666, 2) - 1.671551872624e-5*std::pow(-8.86295986175537*x_67 - 9.87448024749756, 2) + 1.56274220652842e-5*std::pow(-6.9117603302002*x_70 - 9.48536014556885, 2) + 0.000288454839819386*std::pow(-5.01503992080688*x_70 - 7.41752004623413, 2) + 8.49713421814514e-5*std::pow(-4.91472005844116*x_70 - 6.55808019638062, 2) - 9.86534302467678e-6*std::pow(-6.60000038146973*x_72 - 9.96523952484131, 2) - 2.96749796881127e-5*std::pow(-5.69008016586304*x_73 - 7.72512006759644, 2) + 3.88641441915306e-6*std::pow(-5.29624032974243*x_75 - 7.53200006484985, 2) - 2.0597762490221e-6*std::pow(-9.12207984924316*x_81 - 9.71424007415771, 2) + 3.56736555014429e-5*std::pow(-7.73016023635864*x_82 - 8.14496040344238, 2) - 0.000110337116005802*std::pow(-9.88728046417236*x_84 - 8.88064002990723, 2) + 0.000819059463310985*std::pow(-1.53071987628937*x_86 - 2.10567998886108, 2) + 2.58382833157438e-6*std::pow(-9.37191963195801*x_89 - 9.57999992370605, 2) + 5.92018652962844e-6*std::pow(-6.53375959396362*x_90 - 6.33328008651733, 2) - 7.56127213572885e-6*std::pow(-7.40248012542725*x_97 - 5.45391988754272, 2) + 1.69098612259692e-5*std::exp(1.01567983627319*x_1) + 0.00010618216629843*std::exp(1.11351990699768*x_1) + 1.00326099999717e-5*std::exp(1.14375984668732*x_1) - 2.12097862197315e-5*std::exp(1.20751988887787*x_1) + 2.90520989589163e-5*std::exp(1.21103978157043*x_1) + 2.3046034191306e-6*std::exp(1.25095987319946*x_1) - 0.000127698373730611*std::exp(1.2611198425293*x_1) - 8.91841503682545e-6*std::exp(1.30063986778259*x_1) + 3.68417117193999e-6*std::exp(1.32463979721069*x_1) - 1.31326921216087e-5*std::exp(1.35039985179901*x_1) - 2.59703965271491e-6*std::exp(1.37815976142883*x_1) + 3.44433007121244e-5*std::exp(1.6387197971344*x_100) + 5.97668728074003e-5*std::exp(1.64639985561371*x_100) - 0.000166883516705378*std::exp(1.64719986915588*x_100) + 0.000358012879062706*std::exp(1.6736798286438*x_100) - 0.000153905776804746*std::exp(1.71871984004974*x_100) - 0.000203669212036534*std::exp(1.7293598651886*x_100) - 7.26716476250188e-6*std::exp(1.82271993160248*x_100) + 0.00990093565741355*std::exp(0.659519851207733*x_104) + 0.00120736807910551*std::exp(0.859919905662537*x_104) - 0.000813552946235742*std::exp(0.884479880332947*x_104) - 0.000154330245125488*std::exp(1.06447982788086*x_104) - 0.000204688170697702*std::exp(1.13271987438202*x_104) - 2.03490535711557e-5*std::exp(1.14023983478546*x_104) + 0.00059950590298384*std::exp(0.803759872913361*x_106) - 0.00128821215029527*std::exp(0.869199872016907*x_106) + 0.0153994774339484*std::exp(1.24255990982056*x_106) - 0.00240047395146654*std::exp(0.543359875679016*x_108) + 0.000682904144735027*std::exp(0.810959875583649*x_109) - 0.0203681323921785*std::exp(1.05311989784241*x_109) + 0.000205944341206386*std::exp(1.09655976295471*x_109) + 0.00616001276528544*std::exp(0.613439857959747*x_110) + 8.49888630073844e-5*std::exp(1.4670398235321*x_110) - 4.24851853613445e-5*std::exp(1.47447991371155*x_110) - 6.8831788955189e-5*std::exp(1.51207983493805*x_110) + 6.91705239737964e-6*std::exp(1.52231991291046*x_110) + 2.94707067931084e-5*std::exp(1.54567980766296*x_110) - 3.35948446753997e-5*std::exp(1.62999987602234*x_110) - 3.06752842662216e-6*std::exp(1.70063984394073*x_110) + 5.44220219985517e-5*std::exp(1.7707998752594*x_110) + 0.000957219960881218*std::exp(0.520319879055023*x_112) - 0.00237538001875691*std::exp(0.539999842643738*x_112) + 0.000741660374934136*std::exp(0.687439858913422*x_112) - 0.00294006035884294*std::exp(0.755039870738983*x_112) + 0.000418674936727313*std::exp(0.784239888191223*x_112) - 7.93035325248294e-6*std::exp(1.93039989471436*x_19) - 1.79353253916637e-5*std::exp(1.56215977668762*x_23) + 2.19869678851597e-5*std::exp(2.14359974861145*x_23) + 0.00459663142569818*std::exp(0.799119830131531*x_26) + 0.0225302630074071*std::exp(0.807999849319458*x_26) + 0.000791375307888842*std::exp(0.858239889144897*x_26) + 8.13192270594989e-6*std::exp(1.01599979400635*x_26) - 0.000266076009019089*std::exp(1.09751987457275*x_26) + 0.000208418859633846*std::exp(1.21999990940094*x_26) + 9.59363799775992e-6*std::exp(1.22783982753754*x_26) + 1.37971130430177e-5*std::exp(1.26031982898712*x_26) - 7.41816581862691e-6*std::exp(1.3005598783493*x_26) + 3.54514319118897e-6*std::exp(1.30919981002808*x_26) + 0.000105119652858267*std::exp(1.40287983417511*x_26) + 3.93967245683459e-6*std::exp(1.43151986598969*x_26) - 0.00262178263698371*std::exp(0.481919854879379*x_31) + 0.0269459600352538*std::exp(0.533999860286713*x_31) + 0.00110172561943205*std::exp(0.613279819488525*x_31) - 0.00599212189127226*std::exp(0.624479830265045*x_31) - 0.00551953778538772*std::exp(0.631679832935333*x_31) + 0.0033523616313274*std::exp(0.63375985622406*x_31) - 0.00104867911452618*std::exp(0.642559826374054*x_31) + 0.00136501306579817*std::exp(0.643519818782806*x_31) + 0.0123896114794252*std::exp(0.653599858283997*x_31) - 0.00041551187639661*std::exp(0.653999865055084*x_31) - 0.012173892970838*std::exp(0.658079862594604*x_31) + 0.000877817496094129*std::exp(0.669439852237701*x_31) + 0.00183824651660062*std::exp(0.889039874076843*x_45) + 0.00010472542477461*std::exp(1.03455984592438*x_45) + 4.10967512531513e-5*std::exp(1.16495990753174*x_45) + 0.0018204320014732*std::exp(0.592399835586548*x_49) + 9.26540729327153e-5*std::exp(0.920399844646454*x_49) + 0.000679521443443826*std::exp(1.16799986362457*x_50) + 1.4101714118914e-5*std::exp(1.40543985366821*x_50) + 0.000958000796966348*std::exp(1.40831983089447*x_50) - 4.61080771896132e-6*std::exp(2.2727198600769*x_50) + 0.000298270795391647*std::exp(1.14879977703094*x_6) + 3.77912645579434e-6*std::exp(1.83743989467621*x_6) - 3.74596692691246e-5*std::exp(2.31103992462158*x_6) - 1.74924257999376e-6*std::exp(2.35487985610962*x_6) - 6.93472284987703e-6*std::exp(2.37303996086121*x_6) + 2.66210104618493e-5*std::exp(0.849839866161346*x_60) + 0.00212384685272122*std::exp(1.153599858284*x_60) + 0.000155067906931894*std::exp(1.47215986251831*x_60) + 0.000570721941006802*std::exp(0.834719896316528*x_66) - 0.00246007731839623*std::exp(0.882879853248596*x_66) + 0.00142373568202477*std::exp(1.08591985702515*x_66) - 0.000110016452167027*std::exp(1.20335984230042*x_66) + 0.000445725460714575*std::exp(1.46271991729736*x_66) + 0.000756098012509265*std::exp(1.46623992919922*x_66) + 0.000615593752100564*std::exp(0.759039878845215*x_68) + 0.000506314215890209*std::exp(1.16567981243134*x_68) + 0.000334415130480295*std::exp(1.29567980766296*x_68) + 0.000523065554242976*std::exp(1.29711985588074*x_68) + 0.00133471265423064*std::exp(1.39703989028931*x_68) + 0.000808521161296622*std::exp(0.700399875640869*x_70) + 0.00167550515142219*std::exp(0.794639885425568*x_70) + 3.43716429379486e-5*std::exp(1.14799988269806*x_70) + 0.000750057619593131*std::exp(1.35863983631134*x_72) - 0.00252904772454009*std::exp(0.845839858055115*x_74) + 0.00127831788821099*std::exp(0.96727979183197*x_74) - 0.00163457200173905*std::exp(1.12551987171173*x_74) + 7.54199497531878e-5*std::exp(1.40063989162445*x_74) + 0.000235201439242782*std::exp(1.43639981746674*x_74) + 2.88042157797099e-5*std::exp(1.64263987541199*x_74) + 3.12369151391187e-5*std::exp(1.78703987598419*x_74) + 4.85686244706761e-6*std::exp(1.80823993682861*x_74) - 0.000125663835841571*std::exp(0.836559891700745*x_78) - 0.00154661113587886*std::exp(0.914959847927094*x_78) + 0.00127421220760703*std::exp(1.47279977798462*x_81) - 8.62651012462198e-5*std::exp(1.6276798248291*x_81) + 2.98989026880152e-5*std::exp(1.77087986469269*x_81) + 0.000227154140829611*std::exp(1.93223989009857*x_81) + 9.8529076642913e-6*std::exp(2.02951979637146*x_81) - 0.00400842770706454*std::sin(0.38487982749939*x_10 - 7.40855979919434) + 0.000397252624406245*std::sin(0.309519857168198*x_101 - 7.45863962173462) + 0.00177832573740384*std::sin(0.521039843559265*x_104 - 1.01975977420807) - 0.0165514585365636*std::sin(0.301359832286835*x_105 - 1.27151989936829) - 0.0312025421387508*std::sin(0.375199824571609*x_105 - 7.41279983520508) + 0.00285313633834708*std::sin(0.41023987531662*x_105 + 5.21456003189087) - 0.0032384858960923*std::sin(0.537359833717346*x_109 + 2.17647981643677) + 0.00513707552549984*std::sin(0.45991986989975*x_111 - 4.37863969802856) - 0.000361157669252023*std::sin(0.482159852981567*x_111 + 8.4420804977417) - 0.00255527898927862*std::sin(0.476239860057831*x_112 + 2.20975995063782) - 0.0922242223829206*std::sin(0.320559859275818*x_114 - 4.27320003509521) + 0.0950001343069539*std::sin(0.153680041432381*x_115 - 7.64736032485962) - 0.00065552433797598*std::sin(0.341359853744507*x_115 - 7.4410400390625) - 0.0019108177710783*std::sin(0.426559865474701*x_115 + 8.20335960388184) - 0.00272614634484614*std::sin(0.485759854316711*x_115 + 8.46312046051025) - 0.00147098452720334*std::sin(0.39455983042717*x_119 - 1.20143985748291) - 0.010066743428249*std::sin(0.347039848566055*x_120 - 7.45527982711792) + 0.00196612844224844*std::sin(0.556639850139618*x_120 + 2.15871977806091) - 0.00154274120114047*std::sin(0.683679819107056*x_120 - 3.97000002861023) - 0.00147463340557808*std::sin(1.00343978404999*x_15 - 4.19184017181396) + 0.00615785042085138*std::sin(0.397839844226837*x_16 + 5.19200038909912) - 0.00998262193552318*std::sin(0.122640058398247*x_21 - 7.69304037094116) + 0.392057429764006*std::sin(0.22503998875618*x_24 - 4.36663961410522) - 0.0103467128700776*std::sin(0.373199820518494*x_24 - 4.21591997146606) + 0.00390922991237788*std::sin(0.205360010266304*x_27 + 1.81271994113922) - 0.0397313005878444*std::sin(0.129680052399635*x_31 + 1.61399984359741) - 0.00534382734990871*std::sin(0.255439966917038*x_33 + 8.20495986938477) + 0.0027095668687225*std::sin(0.303839921951294*x_34 + 2.04215979576111) + 0.000423103124459622*std::sin(0.359999865293503*x_34 + 8.20528030395508) + 0.0112394118539663*std::sin(0.363679856061935*x_34 - 1.19727993011475) - 0.0112560907543849*std::sin(0.304559946060181*x_35 - 4.34575986862183) - 0.00208637396320367*std::sin(0.309119910001755*x_35 + 5.06063985824585) - 0.00529811342006194*std::sin(0.317599833011627*x_35 - 7.43192005157471) + 0.0505731505418298*std::sin(0.320879846811295*x_35 + 1.97183978557587) + 0.00552999031847212*std::sin(0.328239858150482*x_35 - 7.43264007568359) + 0.00208970813833408*std::sin(0.341359823942184*x_35 - 7.42399978637695) + 0.0149351948142138*std::sin(0.338959842920303*x_36 + 5.15104007720947) + 0.0268191824381178*std::sin(0.395039856433868*x_36 + 5.19752025604248) - 0.000573168802311818*std::sin(0.416319847106934*x_36 - 4.18847990036011) - 0.0130146930704495*std::sin(0.425919860601425*x_36 - 7.38391971588135) + 0.0138060796220537*std::sin(0.457439839839935*x_36 - 4.15664005279541) + 0.00285043794917761*std::sin(0.237759977579117*x_37 + 5.03343963623047) + 0.73955374528006*std::sin(0.247599974274635*x_37 + 1.84727990627289) + 0.02056813131516*std::sin(0.350959837436676*x_37 + 5.16936016082764) + 0.00097163951686857*std::sin(0.35471984744072*x_37 + 5.16247987747192) - 0.010098148871167*std::sin(0.259999960660934*x_40 - 1.3530398607254) + 0.00696869419875771*std::sin(0.302799940109253*x_41 - 7.49200010299683) + 0.00324859340736901*std::sin(0.352559834718704*x_43 - 4.44127988815308) - 0.676937534967274*std::sin(0.225919991731644*x_45 - 7.56376028060913) - 0.0108683213092606*std::sin(0.283919870853424*x_47 - 1.28175985813141) - 0.556538966027398*std::sin(0.200479999184608*x_53 + 5.00799989700317) - 0.0132067609426046*std::sin(0.325919836759567*x_53 - 4.27960014343262) - 0.00573540667178564*std::sin(0.489439845085144*x_53 + 8.49272060394287) + 0.0116311311038986*std::sin(0.362639844417572*x_55 + 5.16312026977539) + 0.00239553519253208*std::sin(0.516959846019745*x_57 - 4.06511974334717) + 0.015154203563316*std::sin(0.375039845705032*x_58 - 4.22424030303955) - 0.00882066300351679*std::sin(0.437199860811234*x_58 + 5.21896028518677) + 0.0132729447625435*std::sin(0.261599957942963*x_59 + 1.86455988883972) - 0.047881998432424*std::sin(0.281519949436188*x_63 + 1.87871992588043) + 0.00651877245598402*std::sin(0.307359933853149*x_64 - 7.48880004882813) - 0.00104756405725349*std::sin(0.521279871463776*x_65 - 0.857679903507233) - 0.0022863616089569*std::sin(0.837119877338409*x_73 - 7.18088006973267) - 0.0206611788349248*std::sin(0.279839843511581*x_75 + 8.11103916168213) + 0.0148830475485471*std::sin(0.463439851999283*x_75 + 8.23503971099854) + 0.0063457514443455*std::sin(0.480639845132828*x_75 - 1.13143992424011) + 0.0004106241722971*std::sin(0.486399859189987*x_75 - 1.11623990535736) + 0.00450287109238028*std::sin(0.545119881629944*x_75 + 5.16215991973877) - 0.0069019520273967*std::sin(0.5065598487854*x_76 + 8.50568008422852) - 0.00784417666333402*std::sin(0.272239863872528*x_79 - 1.29615986347198) - 0.117805700953098*std::sin(0.371999859809875*x_80 + 8.36744022369385) - 0.0501827938438198*std::sin(0.34487983584404*x_83 - 7.46303987503052) + 0.00160689042458398*std::sin(0.226559981703758*x_84 - 7.58008003234863) - 0.0538556829140371*std::sin(0.261679977178574*x_84 + 1.87495994567871) - 0.0179144203829369*std::sin(0.291039943695068*x_87 - 7.48808002471924) - 0.0037390841482536*std::sin(0.934719800949097*x_87 - 3.82536005973816) + 5.4960657952209e-5*std::sin(1.00263977050781*x_87 - 6.9900803565979) - 0.00718523978152343*std::sin(0.23047998547554*x_92 + 4.82000017166138) + 0.0397738167952671*std::sin(0.331599831581116*x_92 - 7.40279960632324) + 0.00409562619958332*std::sin(0.354319840669632*x_92 + 1.98751986026764) - 0.00484802943514894*std::sin(0.354399859905243*x_92 + 8.18423938751221) - 0.0120996362141089*std::sin(0.359759837388992*x_92 + 1.99959981441498) + 0.00667510165320606*std::sin(0.37271985411644*x_92 - 4.39192008972168) - 0.00117073453239687*std::sin(0.416239857673645*x_92 - 7.59040021896362) + 0.00766494365564124*std::sin(0.465199857950211*x_92 - 4.61639976501465) + 0.00327073595563217*std::sin(0.372799843549728*x_94 - 1.18511986732483) - 0.253675486797962*std::sin(0.319919854402542*x_95 + 1.95463979244232) - 0.00540972656525556*std::sin(0.341439843177795*x_95 - 7.4334397315979) + 0.0123339488657935*std::sin(0.348559856414795*x_95 - 1.22079980373383) + 0.00396977739284538*std::sin(0.417919874191284*x_95 + 5.20168018341064) + 0.254760746217383*std::sin(0.375199824571609*x_96 - 4.21479988098145) + 0.026290778742163*std::sin(0.406559854745865*x_96 - 7.38735961914063) + 0.00376361679349851*std::sin(0.343359857797623*x_97 - 4.42447996139526) - 0.0385507853952534*std::sin(0.309119910001755*x_98 - 4.29047966003418) + 0.182802756083145*std::sin(0.387199848890305*x_98 - 1.18119990825653) - 0.000341024510447573*std::sin(0.442879855632782*x_98 + 2.03743982315063) - 0.00903386290895629*std::sin(0.443519860506058*x_98 + 2.00271987915039) + 0.342557992289375*std::sin(0.326079845428467*x_99 + 1.93167984485626) - 1.7453406479993 - 4.59806868994423e-5*std::exp(-1.33871984481812*x_9) - 0.000538147739477146*std::exp(-1.31719982624054*x_9) - 0.000155620612290922*std::exp(-1.29767978191376*x_9) + 0.000126226144144328*std::exp(-1.27743983268738*x_9) - 4.66168584813645e-7*std::exp(-2.84623980522156*x_79) - 6.69630155661239e-6*std::exp(-1.95879983901978*x_30));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0485731692736318*x_1 + 0.0144591001182531*x_10 + 0.00431737385551914*x_100 - 0.0506695632003207*x_101 + 0.00140597324535591*x_102 - 0.0636417729204099*x_103 - 0.000293779940938773*x_104 + 0.00357358828808033*x_105 + 0.00144946418387431*x_106 + 0.101863300837336*x_107 + 0.00154072569324835*x_108 - 0.00300669870753533*x_109 + 0.135602774399039*x_11 + 0.00955547832129983*x_110 + 0.00155721605212015*x_111 + 0.107749577646088*x_112 - 0.0104523233292873*x_113 + 0.000254713500670295*x_114 - 0.0206831599280434*x_115 - 0.0698203914830779*x_116 + 0.0257163882737515*x_117 + 0.0219746390428207*x_118 - 0.0336249887369724*x_119 - 0.0280238695324405*x_12 + 0.00373601242629449*x_120 + 0.0548415270490592*x_13 - 0.0052431068258352*x_14 - 0.000431464276244835*x_15 + 0.0277787319919231*x_16 + 0.0160186780962262*x_17 - 0.0189705522554426*x_18 + 0.0380229051299766*x_19 + 0.0432663663988858*x_2 - 0.0947920993269888*x_20 - 0.0311382875121392*x_21 - 0.00223285870574203*x_22 - 0.112627398078486*x_23 + 0.000204022263620399*x_24 - 0.144779628877213*x_25 + 0.000963379200578629*x_26 - 0.00742849588879368*x_27 + 0.0585751884957789*x_28 + 0.0679216037292283*x_29 + 0.12312735996641*x_3 + 0.12949314110758*x_30 - 0.00302030542018069*x_31 + 0.171645160066775*x_32 + 0.0425314736651516*x_33 + 0.0497436069974537*x_34 - 0.00943118903972366*x_35 - 0.0205713696342493*x_36 - 0.00619177197967659*x_37 + 0.128568535490835*x_38 + 0.0149451235900844*x_39 - 0.0403659278223216*x_4 + 0.00310062221161244*x_40 + 0.117042175081992*x_41 - 0.120192032161019*x_42 - 0.0137132229179797*x_43 + 0.276157035668602*x_44 - 0.0024981865862416*x_45 - 0.10428633792205*x_46 + 0.0210131962566532*x_47 - 0.00234858522276007*x_48 - 0.00745434872272487*x_49 - 0.012462386432246*x_5 + 0.00927055563940235*x_50 + 0.0191154857988272*x_51 + 0.0839965141789887*x_52 - 0.00354623272170029*x_53 + 0.133670236856036*x_54 + 0.0770185035104465*x_55 + 0.0225775028526544*x_56 + 0.000570643410564311*x_57 - 0.0548607529506585*x_58 + 0.089487137906446*x_59 + 0.0490590604692539*x_6 + 0.0212549543433379*x_60 - 0.103353171650869*x_61 + 0.136899649702715*x_62 - 0.113993129692697*x_63 + 0.0225917632812488*x_64 - 0.0271144196288295*x_65 - 0.00253758012599592*x_66 - 0.0623448679217409*x_67 - 0.00971791355835041*x_68 - 0.0602365480036057*x_69 + 0.0739950072814401*x_7 - 0.00176052104329718*x_70 + 0.00858613010051245*x_71 + 0.0209325485085084*x_72 + 0.0803002114349487*x_73 + 0.0627926290447576*x_74 + 0.00676371011754073*x_75 - 0.0202182419042001*x_76 + 0.0877894025947009*x_77 - 0.036812742975665*x_78 + 0.036382769368217*x_79 + 0.178998989038835*x_8 - 1.72079601359839e-5*x_80 + 0.00530133692821206*x_81 - 0.0171499772477435*x_82 + 0.0954507267467619*x_83 - 0.000444377631952329*x_84 - 0.0533511759691021*x_85 + 0.0203719811121604*x_86 + 0.0613109658286072*x_87 - 0.0315663793728837*x_88 + 0.0578443730334926*x_89 - 0.00479018603645662*x_9 + 0.0187615318483314*x_90 + 0.0324930428927957*x_91 - 0.0393171363101679*x_92 + 0.287045666157768*x_93 + 0.042558985612133*x_94 - 0.000823723310488078*x_95 + 0.00277672447755505*x_96 + 0.0208633091870587*x_97 - 0.00204482709351336*x_98 + 0.0038892911924605*x_99 - 0.000421604813349591*std::pow(-9.94719982147217*x_102 - 9.78800010681152, 2) + 0.000671185540044261*std::pow(-7.96016025543213*x_104 - 9.15664005279541, 2) - 0.000750325573248757*std::pow(-6.34000015258789*x_108 - 9.19999980926514, 2) + 1.21214511695043e-5*std::pow(-7.53336048126221*x_110 - 9.12399959564209, 2) - 1.00754508563247e-6*std::pow(-6.82224035263062*x_112 - 7.22352027893066, 2) + 4.9643551530829e-6*std::pow(-8.39915943145752*x_114 - 7.57599973678589, 2) - 6.59603254463381e-6*std::pow(-7.7480001449585*x_115 - 7.5417594909668, 2) - 4.47240683660292e-5*std::pow(-4.07359981536865*x_13 - 6.10303974151611, 2) + 4.40519658533745e-6*std::pow(-6.60400009155273*x_14 - 9.97567939758301, 2) + 6.77899106923405e-6*std::pow(-8.70680046081543*x_15 - 9.9235200881958, 2) + 1.86820728081972e-5*std::pow(-4.7579197883606*x_15 - 6.15079975128174, 2) + 3.83842864009896e-5*std::pow(-4.46928024291992*x_15 - 5.25055980682373, 2) - 2.03580950092286e-5*std::pow(-4.34728002548218*x_24 - 5.5318398475647, 2) + 5.81256319609842e-6*std::pow(-7.32087993621826*x_27 - 8.55039978027344, 2) - 1.4139734631344e-6*std::pow(-5.54271984100342*x_36 - 6.56727981567383, 2) + 5.30241647443425e-7*std::pow(-9.39496040344238*x_39 - 8.79872035980225, 2) - 2.58503083489226e-5*std::pow(-4.88320016860962*x_4 - 8.13959980010986, 2) - 1.70501287524172e-7*std::pow(-5.77159976959229*x_47 - 3.50111985206604, 2) + 6.93079098056383e-6*std::pow(-6.14759969711304*x_53 - 5.93872022628784, 2) + 1.02134945681325e-6*std::pow(-5.93631982803345*x_57 - 7.71104001998901, 2) - 0.00144312880891077*std::pow(-4.32000017166138*x_57 - 6.7828803062439, 2) + 1.30020431870147e-5*std::pow(-5.4871997833252*x_6 - 8.73799991607666, 2) - 4.38748392733569e-6*std::pow(-8.86295986175537*x_67 - 9.87448024749756, 2) + 9.32232759381654e-6*std::pow(-6.9117603302002*x_70 - 9.48536014556885, 2) + 0.000703079531114421*std::pow(-5.01503992080688*x_70 - 7.41752004623413, 2) - 5.7158305860047e-5*std::pow(-4.91472005844116*x_70 - 6.55808019638062, 2) - 5.88503715566202e-6*std::pow(-6.60000038146973*x_72 - 9.96523952484131, 2) - 1.73813686817621e-5*std::pow(-5.69008016586304*x_73 - 7.72512006759644, 2) + 1.62354617958054e-5*std::pow(-5.29624032974243*x_75 - 7.53200006484985, 2) - 8.60469702718768e-6*std::pow(-9.12207984924316*x_81 - 9.71424007415771, 2) + 9.36360951193157e-6*std::pow(-7.73016023635864*x_82 - 8.14496040344238, 2) - 0.000268935573535358*std::pow(-9.88728046417236*x_84 - 8.88064002990723, 2) - 0.000328230856034338*std::pow(-1.53071987628937*x_86 - 2.10567998886108, 2) - 8.92346443329791e-6*std::pow(-9.37191963195801*x_89 - 9.57999992370605, 2) + 1.02513055931078e-6*std::pow(-6.53375959396362*x_90 - 6.33328008651733, 2) + 1.00419460114536e-6*std::pow(-7.40248012542725*x_97 - 5.45391988754272, 2) - 5.83996016213648e-5*std::exp(1.01567983627319*x_1) - 4.25515666455113e-5*std::exp(1.11351990699768*x_1) + 4.19111393689849e-5*std::exp(1.14375984668732*x_1) - 1.07146856303192e-6*std::exp(1.20751988887787*x_1) + 1.70165320512837e-5*std::exp(1.21103978157043*x_1) + 3.93469514552611e-7*std::exp(1.25095987319946*x_1) + 4.04162880777523e-5*std::exp(1.2611198425293*x_1) - 5.32016005222e-6*std::exp(1.30063986778259*x_1) + 9.67020052872521e-7*std::exp(1.32463979721069*x_1) + 8.83406586010826e-6*std::exp(1.35039985179901*x_1) - 4.49699464436807e-7*std::exp(1.37815976142883*x_1) + 5.96414993798271e-6*std::exp(1.6387197971344*x_100) + 3.01928197957423e-6*std::exp(1.64639985561371*x_100) - 9.7747798355769e-5*std::exp(1.64719986915588*x_100) - 0.000240827190885178*std::exp(1.6736798286438*x_100) + 2.02851739241332e-5*std::exp(1.71871984004974*x_100) + 8.16186404151323e-5*std::exp(1.7293598651886*x_100) - 1.24073745944287e-6*std::exp(1.82271993160248*x_100) - 0.00396771264107823*std::exp(0.659519851207733*x_104) + 0.000720239122788029*std::exp(0.859919905662537*x_104) - 0.000213541113147904*std::exp(0.884479880332947*x_104) + 0.000532992241214534*std::exp(1.06447982788086*x_104) - 1.03403654263648e-5*std::exp(1.13271987438202*x_104) + 6.0312799428058e-5*std::exp(1.14023983478546*x_104) - 0.00207044312404794*std::exp(0.803759872913361*x_106) + 0.000516239657540845*std::exp(0.869199872016907*x_106) + 0.0375346705239782*std::exp(1.24255990982056*x_106) + 0.000316388589283597*std::exp(0.543359875679016*x_108) + 0.000399993827753074*std::exp(0.810959875583649*x_109) - 0.0496452650298256*std::exp(1.05311989784241*x_109) + 1.04038242088305e-5*std::exp(1.09655976295471*x_109) + 0.00161687815032899*std::exp(0.613439857959747*x_110) - 5.71700917245737e-5*std::exp(1.4670398235321*x_110) + 0.000146726094718152*std::exp(1.47447991371155*x_110) - 4.03164791831226e-5*std::exp(1.51207983493805*x_110) - 2.05015330279477e-5*std::exp(1.52231991291046*x_110) - 3.88431432124711e-6*std::exp(1.54567980766296*x_110) - 2.00405509123084e-5*std::exp(1.62999987602234*x_110) - 5.31168590034655e-7*std::exp(1.70063984394073*x_110) - 2.18091453280992e-5*std::exp(1.7707998752594*x_110) + 0.000165750762914424*std::exp(0.520319879055023*x_112) + 0.000951912592294181*std::exp(0.539999842643738*x_112) + 3.74669394568965e-5*std::exp(0.687439858913422*x_112) - 0.000771706088281344*std::exp(0.755039870738983*x_112) - 5.5603224371439e-5*std::exp(0.784239888191223*x_112) + 2.7388129593308e-5*std::exp(1.93039989471436*x_19) - 3.10565386042507e-6*std::exp(1.56215977668762*x_23) + 1.28783102473061e-5*std::exp(2.14359974861145*x_23) - 0.003092050310267*std::exp(0.799119830131531*x_26) + 0.0549152399767355*std::exp(0.807999849319458*x_26) - 0.000105100675838209*std::exp(0.858239889144897*x_26) - 2.41023014369395e-5*std::exp(1.01599979400635*x_26) - 0.000155847291514247*std::exp(1.09751987457275*x_26) - 2.74701372782498e-5*std::exp(1.21999990940094*x_26) + 1.63794085109711e-6*std::exp(1.22783982753754*x_26) + 5.76373174714438e-5*std::exp(1.26031982898712*x_26) + 2.56192480103696e-5*std::exp(1.3005598783493*x_26) + 1.79092303970131e-7*std::exp(1.30919981002808*x_26) + 2.75917723473785e-5*std::exp(1.40287983417511*x_26) + 6.82187733268871e-7*std::exp(1.43151986598969*x_26) - 0.00153564285791612*std::exp(0.481919854879379*x_31) + 0.0656780553894555*std::exp(0.533999860286713*x_31) - 0.000145210246625149*std::exp(0.613279819488525*x_31) + 0.00403076527943545*std::exp(0.624479830265045*x_31) - 0.00144876648558295*std::exp(0.631679832935333*x_31) + 0.00199980605947798*std::exp(0.63375985622406*x_31) + 0.00362169988851959*std::exp(0.642559826374054*x_31) + 6.89572527029972e-5*std::exp(0.643519818782806*x_31) - 0.00392128804850895*std::exp(0.653599858283997*x_31) - 7.09411671177225e-5*std::exp(0.653999865055084*x_31) + 0.00487858023755157*std::exp(0.658079862594604*x_31) + 0.000152001552018707*std::exp(0.669439852237701*x_31) + 0.00109658113503005*std::exp(0.889039874076843*x_45) + 1.78799795684269e-5*std::exp(1.03455984592438*x_45) + 0.000171681314173299*std::exp(1.16495990753174*x_45) - 0.000729522068862273*std::exp(0.592399835586548*x_49) - 0.000274618497486521*std::exp(0.920399844646454*x_49) - 8.95626593855763e-5*std::exp(1.16799986362457*x_50) - 4.17962364820472e-5*std::exp(1.40543985366821*x_50) - 0.00038391037007096*std::exp(1.40831983089447*x_50) - 7.98400501767626e-7*std::exp(2.2727198600769*x_50) - 0.00103010281358246*std::exp(1.14879977703094*x_6) + 6.45217758357436e-7*std::exp(1.83743989467621*x_6) + 2.51982748363391e-5*std::exp(2.31103992462158*x_6) - 7.30744537667544e-6*std::exp(2.35487985610962*x_6) - 1.20080613645899e-6*std::exp(2.37303996086121*x_6) - 7.89023262896918e-5*std::exp(0.849839866161346*x_60) - 0.0014286638870374*std::exp(1.153599858284*x_60) - 0.000535539817155561*std::exp(1.47215986251831*x_60) - 7.57962260353144e-5*std::exp(0.834719896316528*x_66) - 0.00144092805811808*std::exp(0.882879853248596*x_66) - 0.000187651994171125*std::exp(1.08591985702515*x_66) - 1.87833271736145e-5*std::exp(1.20335984230042*x_66) - 0.000299829466724553*std::exp(1.46271991729736*x_66) - 0.000239303557248553*std::exp(1.46623992919922*x_66) - 0.00212600383899446*std::exp(0.759039878845215*x_68) - 6.72423889728289e-5*std::exp(1.16567981243134*x_68) - 4.40767671330532e-5*std::exp(1.29567980766296*x_68) + 0.000312027692688133*std::exp(1.29711985588074*x_68) + 0.000350334944069413*std::exp(1.39703989028931*x_68) - 0.00279229457245056*std::exp(0.700399875640869*x_70) - 0.000220835852383235*std::exp(0.794639885425568*x_70) + 1.73637463792581e-6*std::exp(1.14799988269806*x_70) - 0.000237391784584038*std::exp(1.35863983631134*x_72) + 0.00170123337660393*std::exp(0.845839858055115*x_74) - 0.00040458513695617*std::exp(0.96727979183197*x_74) + 0.000655040313204783*std::exp(1.12551987171173*x_74) + 3.81003864672669e-6*std::exp(1.40063989162445*x_74) + 0.000137763293283651*std::exp(1.43639981746674*x_74) - 3.82541951367319e-6*std::exp(1.64263987541199*x_74) - 4.11710508601825e-6*std::exp(1.78703987598419*x_74) + 8.29221762596111e-7*std::exp(1.80823993682861*x_74) - 0.000524959560633988*std::exp(0.836559891700745*x_78) + 0.000203847292386599*std::exp(0.914959847927094*x_78) - 0.00051062930398432*std::exp(1.47279977798462*x_81) - 5.14602811885076e-5*std::exp(1.6276798248291*x_81) - 0.000103258328531668*std::exp(1.77087986469269*x_81) - 7.18938458307331e-5*std::exp(1.93223989009857*x_81) + 4.97745743751211e-7*std::exp(2.02951979637146*x_81) + 0.0138434359745724*std::sin(0.38487982749939*x_10 - 7.40855979919434) - 0.00117742172992484*std::sin(0.309519857168198*x_101 - 7.45863962173462) + 0.00742894000903004*std::sin(0.521039843559265*x_104 - 1.01975977420807) - 0.0098735490721842*std::sin(0.301359832286835*x_105 - 1.27151989936829) + 0.00987554418271859*std::sin(0.375199824571609*x_105 - 7.41279983520508) - 0.00985354186556068*std::sin(0.41023987531662*x_105 + 5.21456003189087) - 0.00193187502744893*std::sin(0.537359833717346*x_109 + 2.17647981643677) + 0.00306445303152538*std::sin(0.45991986989975*x_111 - 4.37863969802856) + 0.00107043946743441*std::sin(0.482159852981567*x_111 + 8.4420804977417) + 0.00882486692298459*std::sin(0.476239860057831*x_112 + 2.20975995063782) - 0.2247872251718*std::sin(0.320559859275818*x_114 - 4.27320003509521) - 0.0639044481828575*std::sin(0.153680041432381*x_115 - 7.64736032485962) + 0.00194291630214182*std::sin(0.341359853744507*x_115 - 7.4410400390625) + 0.000253771171708326*std::sin(0.426559865474701*x_115 + 8.20335960388184) - 0.000137718507695737*std::sin(0.485759854316711*x_115 + 8.46312046051025) - 0.00614502482698053*std::sin(0.39455983042717*x_119 - 1.20143985748291) + 0.003186104807092*std::sin(0.347039848566055*x_120 - 7.45527982711792) + 0.000340451831980617*std::sin(0.556639850139618*x_120 + 2.15871977806091) - 0.00644478769646738*std::sin(0.683679819107056*x_120 - 3.97000002861023) + 0.000590946331409334*std::sin(1.00343978404999*x_15 - 4.19184017181396) + 0.0036733825103772*std::sin(0.397839844226837*x_16 + 5.19200038909912) + 0.0344758089011365*std::sin(0.122640058398247*x_21 - 7.69304037094116) + 0.955600377726362*std::sin(0.22503998875618*x_24 - 4.36663961410522) - 0.00617219183631664*std::sin(0.373199820518494*x_24 - 4.21591997146606) + 0.0163307733165682*std::sin(0.205360010266304*x_27 + 1.81271994113922) - 0.165977156119182*std::sin(0.129680052399635*x_31 + 1.61399984359741) - 0.022323791398893*std::sin(0.255439966917038*x_33 + 8.20495986938477) + 0.00046260972783173*std::sin(0.303839921951294*x_34 + 2.04215979576111) - 0.00125404033134444*std::sin(0.359999865293503*x_34 + 8.20528030395508) - 0.00149267960486045*std::sin(0.363679856061935*x_34 - 1.19727993011475) - 0.00671466893258169*std::sin(0.304559946060181*x_35 - 4.34575986862183) + 0.00720546470820008*std::sin(0.309119910001755*x_35 + 5.06063985824585) - 0.0002676482409659*std::sin(0.317599833011627*x_35 - 7.43192005157471) + 0.0132744241319108*std::sin(0.320879846811295*x_35 + 1.97183978557587) + 0.00323905194012458*std::sin(0.328239858150482*x_35 - 7.43264007568359) + 0.0087297372295413*std::sin(0.341359823942184*x_35 - 7.42399978637695) + 0.00890938877531616*std::sin(0.338959842920303*x_36 + 5.15104007720947) - 0.0180406592782874*std::sin(0.395039856433868*x_36 + 5.19752025604248) + 0.00169882176049967*std::sin(0.416319847106934*x_36 - 4.18847990036011) + 0.00171536974104754*std::sin(0.425919860601425*x_36 - 7.38391971588135) + 0.00808656189432223*std::sin(0.457439839839935*x_36 - 4.15664005279541) + 0.000493577530791841*std::sin(0.237759977579117*x_37 + 5.03343963623047) + 1.80258754122826*std::sin(0.247599974274635*x_37 + 1.84727990627289) + 0.00539871642864018*std::sin(0.350959837436676*x_37 + 5.16936016082764) - 0.00287985380216092*std::sin(0.35471984744072*x_37 + 5.16247987747192) + 0.0348747907099154*std::sin(0.259999960660934*x_40 - 1.3530398607254) - 0.024066960668108*std::sin(0.302799940109253*x_41 - 7.49200010299683) + 0.0135709701712507*std::sin(0.352559834718704*x_43 - 4.44127988815308) - 1.64996685434902*std::sin(0.225919991731644*x_45 - 7.56376028060913) - 0.0064833503066932*std::sin(0.283919870853424*x_47 - 1.28175985813141) - 1.35650750573799*std::sin(0.200479999184608*x_53 + 5.00799989700317) + 0.0041799142717067*std::sin(0.325919836759567*x_53 - 4.27960014343262) - 0.0034213793967287*std::sin(0.489439845085144*x_53 + 8.49272060394287) + 0.00693839418838272*std::sin(0.362639844417572*x_55 + 5.16312026977539) + 0.000121016809120259*std::sin(0.516959846019745*x_57 - 4.06511974334717) + 0.00887619139021625*std::sin(0.375039845705032*x_58 - 4.22424030303955) - 0.00526184739683396*std::sin(0.437199860811234*x_58 + 5.21896028518677) + 0.00791779595471057*std::sin(0.261599957942963*x_59 + 1.86455988883972) + 0.0322091406505782*std::sin(0.281519949436188*x_63 + 1.87871992588043) - 0.000859190836021994*std::sin(0.307359933853149*x_64 - 7.48880004882813) - 0.000613584146922917*std::sin(0.521279871463776*x_65 - 0.857679903507233) + 0.000723629023126428*std::sin(0.837119877338409*x_73 - 7.18088006973267) + 0.00272319606739507*std::sin(0.279839843511581*x_75 + 8.11103916168213) + 0.00390649748766199*std::sin(0.463439851999283*x_75 + 8.23503971099854) + 0.00378547232844879*std::sin(0.480639845132828*x_75 - 1.13143992424011) - 0.00121705381812805*std::sin(0.486399859189987*x_75 - 1.11623990535736) - 0.000598015619521927*std::sin(0.545119881629944*x_75 + 5.16215991973877) + 0.00276589640159032*std::sin(0.5065598487854*x_76 + 8.50568008422852) + 0.0270905116289656*std::sin(0.272239863872528*x_79 - 1.29615986347198) - 0.287139494835903*std::sin(0.371999859809875*x_80 + 8.36744022369385) + 0.0158827571039935*std::sin(0.34487983584404*x_83 - 7.46303987503052) - 0.00476268144569518*std::sin(0.226559981703758*x_84 - 7.58008003234863) + 0.0170452193844661*std::sin(0.261679977178574*x_84 + 1.87495994567871) - 0.00470217124487353*std::sin(0.291039943695068*x_87 - 7.48808002471924) + 0.00118341289452576*std::sin(0.934719800949097*x_87 - 3.82536005973816) - 0.000162898541099934*std::sin(1.00263977050781*x_87 - 6.9900803565979) + 0.000947032929372852*std::sin(0.23047998547554*x_92 + 4.82000017166138) - 0.0267549496952823*std::sin(0.331599831581116*x_92 - 7.40279960632324) + 0.000206901412080287*std::sin(0.354319840669632*x_92 + 1.98751986026764) + 0.0167430698500674*std::sin(0.354399859905243*x_92 + 8.18423938751221) - 0.00721787458499015*std::sin(0.359759837388992*x_92 + 1.99959981441498) + 0.00390977193723542*std::sin(0.37271985411644*x_92 - 4.39192008972168) - 0.00489073313439939*std::sin(0.416239857673645*x_92 - 7.59040021896362) + 0.00201189192174261*std::sin(0.465199857950211*x_92 - 4.61639976501465) + 0.000566355698891387*std::sin(0.372799843549728*x_94 - 1.18511986732483) - 0.618308371684138*std::sin(0.319919854402542*x_95 + 1.95463979244232) - 0.00093674008273298*std::sin(0.341439843177795*x_95 - 7.4334397315979) + 0.00735765063309677*std::sin(0.348559856414795*x_95 - 1.22079980373383) - 0.0137099539239053*std::sin(0.417919874191284*x_95 + 5.20168018341064) + 0.620953581881416*std::sin(0.375199824571609*x_96 - 4.21479988098145) - 0.0176852140270348*std::sin(0.406559854745865*x_96 - 7.38735961914063) + 0.00220444333078596*std::sin(0.343359857797623*x_97 - 4.42447996139526) - 0.0101187976321862*std::sin(0.309119910001755*x_98 - 4.29047966003418) + 0.44556325043406*std::sin(0.387199848890305*x_98 - 1.18119990825653) + 0.00101076656104689*std::sin(0.442879855632782*x_98 + 2.03743982315063) - 0.00538902892128341*std::sin(0.443519860506058*x_98 + 2.00271987915039) + 0.834950499527465*std::sin(0.326079845428467*x_99 + 1.93167984485626) - 4.58122472495857 - 0.000192083912055747*std::exp(-1.33871984481812*x_9) + 0.000215657960274932*std::exp(-1.31719982624054*x_9) + 2.06676040597783e-5*std::exp(-1.29767978191376*x_9) - 0.000435932408535022*std::exp(-1.27743983268738*x_9) - 7.95898874590311e-8*std::exp(-2.84623980522156*x_79) - 1.75764305813072e-6*std::exp(-1.95879983901978*x_30));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0248868336537415*x_1 - 0.00865380962142225*x_10 - 0.00661222789474634*x_100 + 0.0291279607027297*x_101 - 0.00453411612765681*x_102 + 0.0377030550427971*x_103 + 0.000257023406900198*x_104 - 0.00708437932588806*x_105 - 0.0010316293234628*x_106 - 0.043133994611851*x_107 - 0.00358324943615965*x_108 - 0.00220303644643065*x_109 - 0.0717791831767487*x_11 - 0.00522026813348814*x_110 - 0.00993143287308183*x_111 - 0.0535518396143628*x_112 + 0.00744624754586684*x_113 - 0.00261622479638775*x_114 + 0.00988977560143958*x_115 + 0.0374659645377002*x_116 - 0.00805321010464393*x_117 - 0.010739033042686*x_118 + 0.0235241634164567*x_119 + 0.0327097538411058*x_12 - 0.00876148500580234*x_120 - 0.0293841709867763*x_13 - 0.00573733672616467*x_14 - 0.00189628383544517*x_15 - 0.0140136288984678*x_16 - 0.00834247531664026*x_17 + 0.0080697555719881*x_18 - 0.0141512948825626*x_19 - 0.0190092597758551*x_2 + 0.0470231208485987*x_20 + 0.0120517653804949*x_21 + 0.00860991840382044*x_22 + 0.0528657663565875*x_23 + 0.000143744820895431*x_24 + 0.0683710588764178*x_25 - 0.000535247234605988*x_26 + 0.000328376683906507*x_27 - 0.0329532255007775*x_28 - 0.0356621329704554*x_29 - 0.0583709941382172*x_3 - 0.0637867327656889*x_30 + 0.00181111400188147*x_31 - 0.0878569105557939*x_32 - 0.019256911427126*x_33 - 0.0339524246364802*x_34 + 0.00251341526858335*x_35 + 0.0100591726717515*x_36 - 0.00858690199042141*x_37 - 0.0693372846444782*x_38 - 0.0137034076816576*x_39 + 0.018001535433066*x_4 - 0.00381314776327068*x_40 - 0.0578548643852317*x_41 + 0.0442521236524674*x_42 + 0.00793533580338879*x_43 - 0.146362814653322*x_44 + 0.00111212594018274*x_45 + 0.0555669479642627*x_46 - 0.00691046170317064*x_47 - 0.00370104996319434*x_48 + 0.0013119825312297*x_49 + 0.00870577889557195*x_5 - 0.00537631573926879*x_50 - 0.0047782713361643*x_51 - 0.03860606689992*x_52 - 0.0025695913393504*x_53 - 0.07261260133373*x_54 - 0.037332283504024*x_55 - 0.0183587482643974*x_56 - 0.00515605209111704*x_57 + 0.0326182986180348*x_58 - 0.0466121228859098*x_59 - 0.0254735633630585*x_6 - 0.0113037690512739*x_60 + 0.0565871271241991*x_61 - 0.085387018088982*x_62 + 0.0552505512077152*x_63 - 0.011006218720663*x_64 + 0.0208799336089341*x_65 + 0.00374388979829979*x_66 + 0.0252855180067736*x_67 + 0.00329488255931454*x_68 + 0.030917594960561*x_69 - 0.0376284149236524*x_7 + 0.00149799065011188*x_70 + 0.00489190995532839*x_71 - 0.00740692783092101*x_72 - 0.0332315140179411*x_73 - 0.0337885941408919*x_74 - 0.0037150266704524*x_75 + 0.0133648022310274*x_76 - 0.0445031270503873*x_77 + 0.0244832888151951*x_78 - 0.0180372623939298*x_79 - 0.105950970685054*x_8 + 0.00299957667695267*x_80 - 0.0012604783590435*x_81 + 0.0122910291481611*x_82 - 0.046708623946618*x_83 - 3.25734385552719e-5*x_84 + 0.02754830046357*x_85 - 0.00884548279733163*x_86 - 0.0307563428817208*x_87 + 0.016933278757177*x_88 - 0.0263794587033405*x_89 + 0.00783119878537724*x_9 - 0.00661150629489816*x_90 + 0.00915346215913446*x_91 + 0.0183609402730812*x_92 - 0.134438479592947*x_93 - 0.0335425140361368*x_94 + 0.000141072354677363*x_95 + 0.00844689465112254*x_96 - 0.00968855176683326*x_97 - 0.00467637580308336*x_98 - 0.00307873732438826*x_99 + 0.000210138580256593*std::pow(-9.94719982147217*x_102 - 9.78800010681152, 2) - 0.000334535973043328*std::pow(-7.96016025543213*x_104 - 9.15664005279541, 2) + 0.000373981381853835*std::pow(-6.34000015258789*x_108 - 9.19999980926514, 2) + 1.76069142953569e-5*std::pow(-7.53336048126221*x_110 - 9.12399959564209, 2) + 3.28668327400348e-8*std::pow(-6.82224035263062*x_112 - 7.22352027893066, 2) - 4.40286122329687e-6*std::pow(-8.39915943145752*x_114 - 7.57599973678589, 2) - 1.15389802441462e-5*std::pow(-7.7480001449585*x_115 - 7.5417594909668, 2) - 7.7881932487461e-5*std::pow(-4.07359981536865*x_13 - 6.10303974151611, 2) - 7.14829338103463e-6*std::pow(-6.60400009155273*x_14 - 9.97567939758301, 2) - 1.10002393880878e-5*std::pow(-8.70680046081543*x_15 - 9.9235200881958, 2) + 4.19454027925506e-5*std::pow(-4.7579197883606*x_15 - 6.15079975128174, 2) + 5.57547798114255e-5*std::pow(-4.46928024291992*x_15 - 5.25055980682373, 2) + 3.14923518466244e-5*std::pow(-4.34728002548218*x_24 - 5.5318398475647, 2) - 9.43202107252452e-6*std::pow(-7.32087993621826*x_27 - 8.55039978027344, 2) - 2.98513154692986e-6*std::pow(-5.54271984100342*x_36 - 6.56727981567383, 2) + 1.11942770536209e-6*std::pow(-9.39496040344238*x_39 - 8.79872035980225, 2) + 2.58316524576492e-5*std::pow(-4.88320016860962*x_4 - 8.13959980010986, 2) + 1.00672634891133e-5*std::pow(-6.14759969711304*x_53 - 5.93872022628784, 2) + 4.45924148908986e-6*std::pow(-5.93631982803345*x_57 - 7.71104001998901, 2) + 0.000719292165150021*std::pow(-4.32000017166138*x_57 - 6.7828803062439, 2) - 1.29926597513993e-5*std::pow(-5.4871997833252*x_6 - 8.73799991607666, 2) - 9.85087588873905e-6*std::pow(-8.86295986175537*x_67 - 9.87448024749756, 2) - 1.5127300528771e-5*std::pow(-6.9117603302002*x_70 - 9.48536014556885, 2) - 0.000350432750760243*std::pow(-5.01503992080688*x_70 - 7.41752004623413, 2) - 9.95347579217793e-5*std::pow(-4.91472005844116*x_70 - 6.55808019638062, 2) + 9.54962425218061e-6*std::pow(-6.60000038146973*x_72 - 9.96523952484131, 2) + 2.68875932573168e-5*std::pow(-5.69008016586304*x_73 - 7.72512006759644, 2) + 2.35826866261242e-5*std::pow(-5.29624032974243*x_75 - 7.53200006484985, 2) - 1.24986819627968e-5*std::pow(-9.12207984924316*x_81 - 9.71424007415771, 2) + 2.10233830369077e-5*std::pow(-7.73016023635864*x_82 - 8.14496040344238, 2) + 0.000134044341558198*std::pow(-9.88728046417236*x_84 - 8.88064002990723, 2) + 0.000327993975333338*std::pow(-1.53071987628937*x_86 - 2.10567998886108, 2) - 1.5610547569074e-5*std::pow(-9.37191963195801*x_89 - 9.57999992370605, 2) + 4.47574989276996e-6*std::pow(-6.53375959396362*x_90 - 6.33328008651733, 2) + 2.12002068022596e-6*std::pow(-7.40248012542725*x_97 - 5.45391988754272, 2) - 0.000102163208688709*std::exp(1.01567983627319*x_1) + 4.25208576346115e-5*std::exp(1.11351990699768*x_1) + 6.08776811102439e-5*std::exp(1.14375984668732*x_1) - 1.97461802706538e-5*std::exp(1.20751988887787*x_1) - 2.6323220042222e-5*std::exp(1.21103978157043*x_1) - 3.58449994168174e-5*std::exp(1.2611198425293*x_1) + 8.63300062791997e-6*std::exp(1.30063986778259*x_1) + 2.17117479642911e-6*std::exp(1.32463979721069*x_1) + 1.5383531642871e-5*std::exp(1.35039985179901*x_1) - 1.96340096532188e-6*std::exp(1.37815976142883*x_1) + 2.60396524159196e-5*std::exp(1.6387197971344*x_100) + 5.56425902855283e-5*std::exp(1.64639985561371*x_100) + 0.000151208060314942*std::exp(1.64719986915588*x_100) - 0.00041937345386742*std::exp(1.6736798286438*x_100) - 8.15597371146024e-5*std::exp(1.7293598651886*x_100) + 0.00396484918526807*std::exp(0.659519851207733*x_104) - 0.00116872889880202*std::exp(0.859919905662537*x_104) - 0.00047944722706724*std::exp(0.884479880332947*x_104) + 0.000932407003761861*std::exp(1.06447982788086*x_104) - 0.000190563425580739*std::exp(1.13271987438202*x_104) - 1.96744614127209e-6*std::exp(1.14023983478546*x_104) - 0.00362199581996512*std::exp(0.803759872913361*x_106) - 0.000515867092897047*std::exp(0.869199872016907*x_106) - 0.0187082360650555*std::exp(1.24255990982056*x_106) - 0.000618758599680746*std::exp(0.810959875583649*x_109) + 0.0247444649100327*std::exp(1.05311989784241*x_109) + 0.000191732912583492*std::exp(1.09655976295471*x_109) + 0.00363025056043385*std::exp(0.613439857959747*x_110) - 9.95552816786491e-5*std::exp(1.4670398235321*x_110) + 0.000256679981003259*std::exp(1.47447991371155*x_110) + 6.23663828603044e-5*std::exp(1.51207983493805*x_110) + 6.68774496101958e-7*std::exp(1.52231991291046*x_110) + 3.25197149919628e-5*std::exp(1.62999987602234*x_110) - 2.31909754157435e-6*std::exp(1.70063984394073*x_110) + 2.179340590099e-5*std::exp(1.7707998752594*x_110) + 0.000723672660621431*std::exp(0.520319879055023*x_112) - 0.000951225607149404*std::exp(0.539999842643738*x_112) + 0.000690481238770144*std::exp(0.687439858913422*x_112) - 0.00173265156616998*std::exp(0.755039870738983*x_112) - 0.000117387591429235*std::exp(0.784239888191223*x_112) + 4.79122994258729e-5*std::exp(1.93039989471436*x_19) - 1.35593752488692e-5*std::exp(1.56215977668762*x_23) - 1.99217204416377e-5*std::exp(2.14359974861145*x_23) - 0.00538445768263251*std::exp(0.799119830131531*x_26) - 0.027371154687441*std::exp(0.807999849319458*x_26) - 0.000221884887678733*std::exp(0.858239889144897*x_26) + 7.86234106318454e-7*std::exp(1.01599979400635*x_26) + 0.000241083349718391*std::exp(1.09751987457275*x_26) + 8.37206118923374e-5*std::exp(1.26031982898712*x_26) + 4.48178499213195e-5*std::exp(1.3005598783493*x_26) + 3.30050646495316e-6*std::exp(1.30919981002808*x_26) + 6.19496571260195e-5*std::exp(1.40287983417511*x_26) + 2.97845152141394e-6*std::exp(1.43151986598969*x_26) + 0.00237551721663189*std::exp(0.481919854879379*x_31) - 0.0327356160948524*std::exp(0.533999860286713*x_31) + 0.0070191241726175*std::exp(0.624479830265045*x_31) - 0.00325280253503031*std::exp(0.631679832935333*x_31) - 0.00324507661381118*std::exp(0.63375985622406*x_31) + 0.00633573639624518*std::exp(0.642559826374054*x_31) + 0.00127081875271206*std::exp(0.643519818782806*x_31) + 0.00347777033708716*std::exp(0.653599858283997*x_31) - 0.00487505941833147*std::exp(0.658079862594604*x_31) + 0.000663643205218649*std::exp(0.669439852237701*x_31) - 0.00177941744879073*std::exp(0.889039874076843*x_45) + 0.000249374282212047*std::exp(1.16495990753174*x_45) + 0.000728995580581571*std::exp(0.592399835586548*x_49) + 8.95824946487966e-6*std::exp(0.920399844646454*x_49) + 1.36342277205002e-6*std::exp(1.40543985366821*x_50) + 0.000383633306059727*std::exp(1.40831983089447*x_50) - 3.48583985495119e-6*std::exp(2.2727198600769*x_50) - 0.00180204326387649*std::exp(1.14879977703094*x_6) + 4.38799601937575e-5*std::exp(2.31103992462158*x_6) - 1.06143697372489e-5*std::exp(2.35487985610962*x_6) - 5.2427545815308e-6*std::exp(2.37303996086121*x_6) + 2.57384964498644e-6*std::exp(0.849839866161346*x_60) - 0.00248785739899358*std::exp(1.153599858284*x_60) - 0.000936863687117356*std::exp(1.47215986251831*x_60) - 0.000160018353509041*std::exp(0.834719896316528*x_66) + 0.00222900096356545*std::exp(0.882879853248596*x_66) - 0.000522119278015634*std::exp(1.46271991729736*x_66) + 0.000212237102366125*std::exp(1.46623992919922*x_66) - 0.00371919273156013*std::exp(0.759039878845215*x_68) - 0.000141959790510326*std::exp(1.16567981243134*x_68) - 0.000506325982764565*std::exp(1.29711985588074*x_68) + 0.000786579759760355*std::exp(1.39703989028931*x_68) - 0.00488478971098413*std::exp(0.700399875640869*x_70) + 3.19997877687175e-5*std::exp(1.14799988269806*x_70) + 0.000210541560956859*std::exp(1.35863983631134*x_72) + 0.00296250649421511*std::exp(0.845839858055115*x_74) + 0.000358824491015788*std::exp(0.96727979183197*x_74) - 0.000654567577611153*std::exp(1.12551987171173*x_74) + 7.02155084639487e-5*std::exp(1.40063989162445*x_74) - 0.000213108844500025*std::exp(1.43639981746674*x_74) - 8.07609249270719e-6*std::exp(1.64263987541199*x_74) - 0.000762525696251996*std::exp(0.836559891700745*x_78) + 0.000510260788272726*std::exp(1.47279977798462*x_81) + 8.35043749535213e-5*std::exp(1.6276798248291*x_81) - 0.000180638255634414*std::exp(1.77087986469269*x_81) + 6.37622845749151e-5*std::exp(1.93223989009857*x_81) + 9.17299631941625e-6*std::exp(2.02951979637146*x_81) + 0.052703426425641*std::exp(0.0117332112953095*x_10 + 0.0193966852014209*x_101 - 0.000868816786026897*x_102 - 0.00247036220711717*x_103 + 0.000273830362324282*x_104 + 0.000482875380157574*x_105 + 0.00236288237586471*x_106 + 0.00222464894730637*x_107 - 0.000228830585496257*x_108 + 0.00033481487515377*x_109 + 0.000923916205111872*x_11 - 0.000720695642369921*x_110 - 0.000216180770362724*x_111 - 0.0037502305452908*x_112 - 0.000988016207122947*x_113 + 0.000174134320184552*x_114 + 0.00236383929765387*x_115 + 0.00549190318979322*x_116 + 0.0021035035214579*x_117 + 0.00135865161611943*x_118 - 0.000320766384600053*x_119 + 0.0095909448437621*x_12 - 0.00021546481653863*x_120 - 0.000760285676961645*x_13 - 0.000652179869812517*x_14 + 0.00123381808335535*x_15 - 0.000850315253400068*x_16 - 0.00068202523052252*x_17 + 0.000379797058785944*x_18 + 0.00755624044103678*x_19 + 0.00348063198486592*x_2 - 0.001542637729422*x_20 - 0.00311597010091058*x_21 + 0.0196686611883681*x_22 + 0.00176410972896837*x_23 - 0.000403702310539445*x_24 + 0.00336596526707777*x_25 + 0.00012434727907654*x_27 - 0.000918689187984157*x_28 - 0.00133129324142697*x_29 + 0.00237074115427206*x_3 + 0.00324477734307357*x_30 + 0.0473790753431671*x_32 - 0.0738655944443571*x_33 - 0.000660329555804188*x_35 - 0.00270291520661683*x_36 - 0.0143602266204341*x_37 - 0.00746999252319207*x_38 + 0.0104110667415366*x_39 - 0.00713815809931571*x_4 - 0.0012810446662835*x_40 + 0.0123521092008844*x_41 - 0.0195269954335433*x_42 - 0.00112204495578675*x_43 + 0.0119996619165585*x_44 + 0.000629179659278858*x_46 - 0.000148062165645987*x_48 + 0.000216224253996587*x_49 + 2.37052294365876e-5*x_5 - 0.00604549635137334*x_50 + 0.00115515030842517*x_51 + 0.00022342021446156*x_52 + 0.00132331383192544*x_53 - 0.0033123254285762*x_54 - 0.000113400397799526*x_55 + 0.00580864899420635*x_56 - 0.0071593624482606*x_57 + 0.00132711368340186*x_58 + 0.000739503631129794*x_59 - 0.00104629547423149*x_60 - 0.0275336572799717*x_61 - 0.00360158235851534*x_62 - 0.0143479413783285*x_63 - 0.000725674359853188*x_64 + 0.00751291539174275*x_65 - 0.000801073861466866*x_67 + 0.0007696645189435*x_68 + 0.00041873521658644*x_69 + 0.0101069439549043*x_7 - 0.000164219781738319*x_70 + 0.000165605226722294*x_71 - 0.00123359515906644*x_72 + 0.000701891599387204*x_73 - 0.00143796889291449*x_75 - 0.00416651814771028*x_76 - 0.00454273895049176*x_77 - 0.00098904574881484*x_78 - 0.0117839081147056*x_8 - 0.00124661227755721*x_80 - 0.000105637328994036*x_81 - 0.000596987442290579*x_82 + 0.00827250477614296*x_83 - 0.000140296706441141*x_84 - 0.00123684618279906*x_85 - 0.00368895318633571*x_86 + 3.24109872372947e-5*x_87 - 0.00260772155439448*x_88 - 0.000807571752464259*x_89 + 0.0438129926863185*x_9 - 8.32881631760307e-5*x_90 - 0.0191600573558882*x_91 - 0.00082327687758386*x_92 - 0.00189241293624497*x_93 - 0.00408851945942889*x_94 + 0.0129810556650004*x_95 - 0.00096096285112086*x_96 - 0.00296721366164416*x_97 - 0.00103953072945569*x_98 - 0.000368292045903951*x_99 - 6.40524345590543e-5*std::pow(-5.77159976959229*x_47 - 3.50111985206604, 2) + 0.000147815190711044*std::exp(1.25095987319946*x_1) - 0.000466109412309658*std::exp(1.82271993160248*x_100) + 0.000615327313359001*std::exp(1.22783982753754*x_26) - 0.0266505580710448*std::exp(0.653999865055084*x_31) + 0.00671699456264534*std::exp(1.03455984592438*x_45) + 0.000242389772204332*std::exp(1.83743989467621*x_6) - 0.00705635630123135*std::exp(1.20335984230042*x_66) + 0.000311514789447565*std::exp(1.80823993682861*x_74) + 0.173789182173319*std::sin(0.303839921951294*x_34 + 2.04215979576111) - 2.98996337919698e-5*std::exp(-2.84623980522156*x_79)) + 0.0242174569547341*std::sin(0.38487982749939*x_10 - 7.40855979919434) + 3.84083289311369e-5*std::sin(0.309519857168198*x_101 - 7.45863962173462) + 0.0107908457671648*std::sin(0.521039843559265*x_104 - 1.01975977420807) + 0.0160217652294871*std::sin(0.301359832286835*x_105 - 1.27151989936829) - 0.0087585696833243*std::sin(0.375199824571609*x_105 - 7.41279983520508) - 0.0172376082367988*std::sin(0.41023987531662*x_105 + 5.21456003189087) + 0.00313484522294967*std::sin(0.537359833717346*x_109 + 2.17647981643677) - 0.00497267463492016*std::sin(0.45991986989975*x_111 - 4.37863969802856) - 3.49184919227846e-5*std::sin(0.482159852981567*x_111 + 8.4420804977417) + 0.015438062864681*std::sin(0.476239860057831*x_112 + 2.20975995063782) + 0.112039679960326*std::sin(0.320559859275818*x_114 - 4.27320003509521) - 0.111282405667864*std::sin(0.153680041432381*x_115 - 7.64736032485962) - 6.33793028629553e-5*std::sin(0.341359853744507*x_115 - 7.4410400390625) + 0.000535752862496171*std::sin(0.426559865474701*x_115 + 8.20335960388184) - 0.00253802544786787*std::sin(0.485759854316711*x_115 + 8.46312046051025) - 0.00892590531929777*std::sin(0.39455983042717*x_119 - 1.20143985748291) - 0.00282574007618968*std::sin(0.347039848566055*x_120 - 7.45527982711792) + 0.00148642261870044*std::sin(0.556639850139618*x_120 + 2.15871977806091) - 0.00936132341224556*std::sin(0.683679819107056*x_120 - 3.97000002861023) - 0.000590519851757394*std::sin(1.00343978404999*x_15 - 4.19184017181396) - 0.00596078185757657*std::sin(0.397839844226837*x_16 + 5.19200038909912) + 0.0603113576410135*std::sin(0.122640058398247*x_21 - 7.69304037094116) - 0.47629557421958*std::sin(0.22503998875618*x_24 - 4.36663961410522) + 0.0100155889062641*std::sin(0.373199820518494*x_24 - 4.21591997146606) + 0.0237211305924418*std::sin(0.205360010266304*x_27 + 1.81271994113922) - 0.241088754301109*std::sin(0.129680052399635*x_31 + 1.61399984359741) - 0.032426239763816*std::sin(0.255439966917038*x_33 + 8.20495986938477) + 4.09076818569193e-5*std::sin(0.359999865293503*x_34 + 8.20528030395508) - 0.0031512932131345*std::sin(0.363679856061935*x_34 - 1.19727993011475) + 0.0108958641360918*std::sin(0.304559946060181*x_35 - 4.34575986862183) + 0.0126051098679698*std::sin(0.309119910001755*x_35 + 5.06063985824585) - 0.00493251094580046*std::sin(0.317599833011627*x_35 - 7.43192005157471) + 0.0298040304611082*std::sin(0.320879846811295*x_35 + 1.97183978557587) - 0.00501055542287498*std::sin(0.328239858150482*x_35 - 7.43264007568359) + 0.0126803080812811*std::sin(0.341359823942184*x_35 - 7.42399978637695) - 0.0144572265000923*std::sin(0.338959842920303*x_36 + 5.15104007720947) - 0.0314157781094907*std::sin(0.395039856433868*x_36 + 5.19752025604248) - 5.54167664094406e-5*std::sin(0.416319847106934*x_36 - 4.18847990036011) - 0.012509267310623*std::sin(0.457439839839935*x_36 - 4.15664005279541) + 0.00215497388157123*std::sin(0.237759977579117*x_37 + 5.03343963623047) - 0.89845555531606*std::sin(0.247599974274635*x_37 + 1.84727990627289) + 0.0121213174516005*std::sin(0.350959837436676*x_37 + 5.16936016082764) + 9.39428662608789e-5*std::sin(0.35471984744072*x_37 + 5.16247987747192) + 0.0610093292137917*std::sin(0.259999960660934*x_40 - 1.3530398607254) - 0.0421023064708606*std::sin(0.302799940109253*x_41 - 7.49200010299683) + 0.0197124012107725*std::sin(0.352559834718704*x_43 - 4.44127988815308) + 0.822385516637455*std::sin(0.225919991731644*x_45 - 7.56376028060913) + 0.010520504405756*std::sin(0.283919870853424*x_47 - 1.28175985813141) + 0.67611790078599*std::sin(0.200479999184608*x_53 + 5.00799989700317) - 0.0037071446131677*std::sin(0.325919836759567*x_53 - 4.27960014343262) + 0.00555185749872058*std::sin(0.489439845085144*x_53 + 8.49272060394287) - 0.0112589021377411*std::sin(0.362639844417572*x_55 + 5.16312026977539) + 0.00223022850237067*std::sin(0.516959846019745*x_57 - 4.06511974334717) - 0.0137307612618937*std::sin(0.375039845705032*x_58 - 4.22424030303955) + 0.00853837693509455*std::sin(0.437199860811234*x_58 + 5.21896028518677) - 0.0128481731334823*std::sin(0.261599957942963*x_59 + 1.86455988883972) + 0.0560885941121771*std::sin(0.281519949436188*x_63 + 1.87871992588043) + 0.000949165815055283*std::sin(0.521279871463776*x_65 - 0.857679903507233) - 0.00064178288372398*std::sin(0.837119877338409*x_73 - 7.18088006973267) + 0.00877095450330179*std::sin(0.463439851999283*x_75 + 8.23503971099854) - 0.00614266951890579*std::sin(0.480639845132828*x_75 - 1.13143992424011) + 3.97011556568962e-5*std::sin(0.486399859189987*x_75 - 1.11623990535736) - 0.00126250975561769*std::sin(0.545119881629944*x_75 + 5.16215991973877) - 0.0027639002837164*std::sin(0.5065598487854*x_76 + 8.50568008422852) + 0.0473916519324575*std::sin(0.272239863872528*x_79 - 1.29615986347198) + 0.143117639718168*std::sin(0.371999859809875*x_80 + 8.36744022369385) - 0.0140863361334632*std::sin(0.34487983584404*x_83 - 7.46303987503052) + 0.00015536203461453*std::sin(0.226559981703758*x_84 - 7.58008003234863) - 0.0151173179912095*std::sin(0.261679977178574*x_84 + 1.87495994567871) - 0.0105574188095032*std::sin(0.291039943695068*x_87 - 7.48808002471924) - 0.00104956285031728*std::sin(0.934719800949097*x_87 - 3.82536005973816) + 5.31386553343803e-6*std::sin(1.00263977050781*x_87 - 6.9900803565979) - 0.0465907342959013*std::sin(0.331599831581116*x_92 - 7.40279960632324) + 0.0038130027535567*std::sin(0.354319840669632*x_92 + 1.98751986026764) + 0.0292900241044844*std::sin(0.354399859905243*x_92 + 8.18423938751221) + 0.0117124137644066*std::sin(0.359759837388992*x_92 + 1.99959981441498) - 0.00604810584839399*std::sin(0.37271985411644*x_92 - 4.39192008972168) - 0.00710399422764443*std::sin(0.416239857673645*x_92 - 7.59040021896362) + 0.00451714421086854*std::sin(0.465199857950211*x_92 - 4.61639976501465) + 0.00247272548414421*std::sin(0.372799843549728*x_94 - 1.18511986732483) + 0.308180645173834*std::sin(0.319919854402542*x_95 + 1.95463979244232) - 0.00408983449646086*std::sin(0.341439843177795*x_95 - 7.4334397315979) - 0.0119392277510589*std::sin(0.348559856414795*x_95 - 1.22079980373383) - 0.0239839458652764*std::sin(0.417919874191284*x_95 + 5.20168018341064) - 0.309499085328537*std::sin(0.375199824571609*x_96 - 4.21479988098145) - 0.0307968102008808*std::sin(0.406559854745865*x_96 - 7.38735961914063) - 0.00341009829100344*std::sin(0.343359857797623*x_97 - 4.42447996139526) - 0.0227189480961731*std::sin(0.309119910001755*x_98 - 4.29047966003418) - 0.222080075691852*std::sin(0.387199848890305*x_98 - 1.18119990825653) - 3.29719195447168e-5*std::sin(0.442879855632782*x_98 + 2.03743982315063) + 0.00874475384286704*std::sin(0.443519860506058*x_98 + 2.00271987915039) - 0.416160601111897*std::sin(0.326079845428467*x_99 + 1.93167984485626) + 1.19084966182709*std::sin(0.00486279633441369*x_1 + 0.000435217657718631*x_10 + 0.000990830266914831*x_101 + 3.7325921011513e-5*x_102 + 0.000384865981748127*x_103 - 0.000986844607340331*x_104 + 0.000255718320324566*x_105 - 0.000856060477762675*x_106 + 0.00120976580993989*x_107 + 0.00032288424988607*x_109 - 0.000175010930212109*x_11 - 0.00108864698672717*x_111 - 0.000280714775087362*x_112 + 1.08703745823873e-5*x_113 - 0.00068606280924402*x_114 + 8.8768886122149e-6*x_115 + 0.00237136827254935*x_116 + 0.000284173678336382*x_117 + 0.00165947669840664*x_118 + 0.000508695921128974*x_119 + 0.0138522699038841*x_12 + 0.00209949332475898*x_120 + 0.000690513608711787*x_13 - 0.000140574171560974*x_14 - 0.000286542091008861*x_15 + 0.00118678911792542*x_16 + 7.70496083976873e-5*x_17 + 0.00215313573359347*x_18 + 0.00415467882802929*x_19 - 0.0011772137462716*x_2 + 0.000882654350028443*x_20 - 2.45530440838011e-5*x_21 + 0.000636515627935441*x_22 + 0.00194628618774959*x_23 - 0.000109242383376377*x_24 - 0.00279762116980101*x_25 - 1.50349662002852e-5*x_27 + 0.000272720099695975*x_28 + 0.000302856923274179*x_29 + 0.00225482261935352*x_3 + 0.000140302525479789*x_30 - 0.00988148462401153*x_32 + 1.41017445510302e-5*x_33 - 0.00877398356391113*x_34 + 1.25860735440964e-5*x_35 - 0.000970842725828301*x_37 - 0.00213342975303699*x_38 - 0.000316550017861632*x_39 - 0.000652723825987561*x_4 - 0.000158998619632894*x_40 - 0.00265934178088977*x_41 - 0.00754075808740648*x_42 - 0.00087693981747463*x_43 + 0.00713893980585088*x_44 - 0.000472296193476235*x_45 - 0.000163027611151389*x_46 + 0.00256960011804868*x_47 - 0.00113266639419095*x_48 + 0.00379509732025957*x_49 - 0.000867669711151693*x_5 - 0.00283042531172684*x_51 + 0.00156979131141535*x_52 + 0.000225921309264289*x_53 - 0.000436917517715182*x_54 - 3.17852789031555e-5*x_55 - 1.06980824528249e-6*x_56 - 0.000782401182161044*x_57 + 5.52389379798145e-5*x_58 + 0.00018211639958376*x_59 - 0.00255268982523491*x_6 + 0.00162838680576689*x_60 - 0.00813065083354636*x_61 + 0.00325107020732056*x_62 - 0.000348495776778201*x_63 + 0.00721342847228614*x_65 - 0.00512287467717392*x_67 + 0.00385551100019487*x_69 + 0.00223565971624573*x_7 - 0.000323101078486799*x_71 - 6.77261046916908e-5*x_72 - 0.00107213145009291*x_73 + 0.00032047747249945*x_76 - 0.000354884324004768*x_77 - 1.55021660616793e-5*x_79 + 0.00191899393963792*x_8 + 0.000178887191969039*x_80 + 8.37150654561616e-5*x_81 + 0.000386276959055995*x_82 + 0.000142728494596602*x_83 - 0.000479893624398461*x_84 + 0.000164157871407196*x_85 - 0.000241080020570397*x_86 - 0.000140482613415301*x_87 - 0.000130059882960039*x_88 + 0.00481337586887422*x_89 - 0.00759340513015878*x_9 + 0.00101119875743678*x_90 - 0.0126947118928627*x_91 + 0.00407387530914887*x_93 + 0.00180019583875384*x_94 - 4.33561825944357e-5*x_95 + 6.25866739107806e-6*x_96 - 0.00208727471155859*x_97 + 0.00865508937154706*x_98 + 0.000144738566530906*x_99 - 0.000316732490901374*std::exp(1.71871984004974*x_100) - 0.00494008808360994*std::exp(0.543359875679016*x_108) + 6.06496426904581e-5*std::exp(1.54567980766296*x_110) + 0.000428918432648565*std::exp(1.21999990940094*x_26) + 0.0022673112535293*std::exp(0.613279819488525*x_31) + 0.00139843041548667*std::exp(1.16799986362457*x_50) + 0.00292999625040042*std::exp(1.08591985702515*x_66) + 0.000688214175394521*std::exp(1.29567980766296*x_68) + 0.00344812866122167*std::exp(0.794639885425568*x_70) + 6.42844352271433e-5*std::exp(1.78703987598419*x_74) - 0.00318286946528447*std::exp(0.914959847927094*x_78) - 0.0267837649768659*std::sin(0.425919860601425*x_36 - 7.38391971588135) + 0.0134153966177792*std::sin(0.307359933853149*x_64 - 7.48880004882813) - 0.0425199545670507*std::sin(0.279839843511581*x_75 + 8.11103916168213) - 0.0147869621334147*std::sin(0.23047998547554*x_92 + 4.82000017166138) - 1.17070465012823) + 3.44487213604815 - 0.000279009908119831*std::exp(-1.33871984481812*x_9) - 0.000215502322229736*std::exp(-1.31719982624054*x_9) + 4.36327261344335e-5*std::exp(-1.29767978191376*x_9) - 0.00076261228485918*std::exp(-1.27743983268738*x_9) - 3.94629904270981e-6*std::exp(-1.95879983901978*x_30));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0421690374051019*x_1 - 0.0166279091543949*x_10 - 0.00649851299468725*x_100 + 0.0468511021333447*x_101 - 0.000676537010717538*x_102 + 0.0591926222545644*x_103 + 0.000505396374932158*x_104 - 0.00186598230255851*x_105 - 0.00224245967083761*x_106 - 0.0856482696286644*x_107 + 0.00348162741640724*x_108 + 0.0029746711913702*x_109 - 0.126621067523759*x_11 - 0.00862425003811106*x_110 - 0.00576129957816475*x_111 - 0.0980320259797798*x_112 + 0.00862528618441084*x_113 - 0.00301465491913769*x_114 + 0.0187261513617194*x_115 + 0.061112061653985*x_116 - 0.0193403115192012*x_117 - 0.0182876673286541*x_118 + 0.0361291147142619*x_119 + 0.0257995777405332*x_12 - 0.00676138489885611*x_120 - 0.0508087032486294*x_13 + 0.00273828775003372*x_14 - 0.00082725942301135*x_15 - 0.0291506409104373*x_16 - 0.0158406791763586*x_17 + 0.017063377152413*x_18 - 0.0294185429926823*x_19 - 0.0397500972923812*x_2 + 0.0910039452970682*x_20 + 0.0257306639251876*x_21 + 0.000142067106342272*x_22 + 0.0978554922324544*x_23 - 0.000426277086233604*x_24 + 0.123915868350155*x_25 - 0.000504667744710053*x_26 + 0.00597785123395769*x_27 - 0.055047867144409*x_28 - 0.0636018067456917*x_29 - 0.10836762120479*x_3 - 0.116146028970765*x_30 - 0.00327912871336119*x_31 - 0.151033935836956*x_32 - 0.0392470782655687*x_33 - 0.0424611022870377*x_34 + 0.00961234136413341*x_35 + 0.0257022493207603*x_36 - 0.000498037222829759*x_37 - 0.120742274264179*x_38 - 0.0132668585852402*x_39 + 0.0337657024521931*x_4 - 0.00532156993827165*x_40 - 0.108080425450509*x_41 + 0.0982694734301937*x_42 + 0.0112578325729022*x_43 - 0.24994570157389*x_44 + 0.00133841582054659*x_45 + 0.0970471815303929*x_46 - 0.0192855434515245*x_47 - 0.00642451637996905*x_48 + 0.00497586849655148*x_49 + 0.0102791352332986*x_5 - 0.0065495458740262*x_50 - 0.0148691836429221*x_51 - 0.0719644635225278*x_52 - 0.00127040659859112*x_53 - 0.122254466920412*x_54 - 0.0693475059255214*x_55 - 0.0196963017689283*x_56 - 0.00105122142900371*x_57 + 0.0555042355257323*x_58 - 0.0795199740684625*x_59 - 0.0444898362815187*x_6 - 0.0198498156771603*x_60 + 0.100018615336144*x_61 - 0.127020159487219*x_62 + 0.104402754702468*x_63 - 0.0166050274407952*x_64 + 0.0324717847283543*x_65 + 0.00233785369460462*x_66 + 0.0564158494784652*x_67 + 0.00739545209294021*x_68 + 0.058787932996886*x_69 - 0.0662784072309529*x_7 + 0.00116084490728829*x_70 - 0.00239836423335201*x_71 - 0.0173131509954759*x_72 - 0.0666301862188852*x_73 - 0.0620295833308033*x_74 - 0.00727543718794836*x_75 + 0.0168135455943465*x_76 - 0.077199415209761*x_77 + 0.0332044561562262*x_78 - 0.0345130187925694*x_79 - 0.178048858202273*x_8 + 0.0043557930293721*x_80 - 0.0053952288830728*x_81 + 0.0182146958828412*x_82 - 0.0880076852982756*x_83 + 0.00157243391208581*x_84 + 0.0480531476859933*x_85 - 0.0168345005824063*x_86 - 0.0553827070996507*x_87 + 0.028127816371362*x_88 - 0.0539928784712848*x_89 + 0.00142097978273612*x_9 - 0.0196770266324473*x_90 - 0.0195978397227317*x_91 + 0.03484186576369*x_92 - 0.252186031962677*x_93 - 0.0411300842264312*x_94 - 0.00259365564147098*x_95 + 0.00455050066541192*x_96 - 0.0218592472311783*x_97 + 0.00562197755957804*x_98 - 0.00693554809755785*x_99 + 0.000377763475756092*std::pow(-9.94719982147217*x_102 - 9.78800010681152, 2) - 0.000601391100044461*std::pow(-7.96016025543213*x_104 - 9.15664005279541, 2) + 0.000672301614033287*std::pow(-6.34000015258789*x_108 - 9.19999980926514, 2) + 2.50885951149083e-5*std::pow(-7.53336048126221*x_110 - 9.12399959564209, 2) + 2.31386554045552e-7*std::pow(-6.82224035263062*x_112 - 7.22352027893066, 2) - 1.08490110780023e-5*std::pow(-8.39915943145752*x_114 - 7.57599973678589, 2) + 6.21105582012295e-7*std::pow(-7.7480001449585*x_115 - 7.5417594909668, 2) + 1.70999599563435e-5*std::pow(-4.07359981536865*x_13 - 6.10303974151611, 2) - 4.84770404255587e-6*std::pow(-6.60400009155273*x_14 - 9.97567939758301, 2) - 7.45994912466744e-6*std::pow(-8.70680046081543*x_15 - 9.9235200881958, 2) - 4.49569873870174e-5*std::pow(-4.7579197883606*x_15 - 6.15079975128174, 2) + 7.94465783694191e-5*std::pow(-4.46928024291992*x_15 - 5.25055980682373, 2) + 4.29713275295252e-5*std::pow(-4.34728002548218*x_24 - 5.5318398475647, 2) - 6.39644237379235e-6*std::pow(-7.32087993621826*x_27 - 8.55039978027344, 2) + 7.35643497181439e-6*std::pow(-5.54271984100342*x_36 - 6.56727981567383, 2) - 2.75867143229018e-6*std::pow(-9.39496040344238*x_39 - 8.79872035980225, 2) + 6.35562086277506e-6*std::pow(-4.88320016860962*x_4 - 8.13959980010986, 2) - 2.40682930904947e-8*std::pow(-5.77159976959229*x_47 - 3.50111985206604, 2) + 1.43451313135583e-5*std::pow(-6.14759969711304*x_53 - 5.93872022628784, 2) + 1.28331624534438e-6*std::pow(-5.93631982803345*x_57 - 7.71104001998901, 2) + 0.00129306245459261*std::pow(-4.32000017166138*x_57 - 6.7828803062439, 2) - 3.19671455453014e-6*std::pow(-5.4871997833252*x_6 - 8.73799991607666, 2) + 1.05581463902349e-5*std::pow(-8.86295986175537*x_67 - 9.87448024749756, 2) - 1.02587669555984e-5*std::pow(-6.9117603302002*x_70 - 9.48536014556885, 2) - 0.000629968536878435*std::pow(-5.01503992080688*x_70 - 7.41752004623413, 2) + 2.18541107079077e-5*std::pow(-4.91472005844116*x_70 - 6.55808019638062, 2) + 6.47619643242525e-6*std::pow(-6.60000038146973*x_72 - 9.96523952484131, 2) + 3.66881324700002e-5*std::pow(-5.69008016586304*x_73 - 7.72512006759644, 2) + 3.3603643804901e-5*std::pow(-5.29624032974243*x_75 - 7.53200006484985, 2) - 1.78097289493429e-5*std::pow(-9.12207984924316*x_81 - 9.71424007415771, 2) - 2.25328141607583e-5*std::pow(-7.73016023635864*x_82 - 8.14496040344238, 2) + 0.000240969822441126*std::pow(-9.88728046417236*x_84 - 8.88064002990723, 2) + 8.06996515577463e-5*std::pow(-1.53071987628937*x_86 - 2.10567998886108, 2) + 8.40264739888e-7*std::pow(-9.37191963195801*x_89 - 9.57999992370605, 2) + 1.2880671660288e-6*std::pow(-6.53375959396362*x_90 - 6.33328008651733, 2) - 5.22449145968924e-6*std::pow(-7.40248012542725*x_97 - 5.45391988754272, 2) + 5.49911152027792e-6*std::exp(1.01567983627319*x_1) + 1.0461833610091e-5*std::exp(1.11351990699768*x_1) + 8.674634676402e-5*std::exp(1.14375984668732*x_1) - 1.08138224168128e-5*std::exp(1.20751988887787*x_1) - 3.59180449772388e-5*std::exp(1.21103978157043*x_1) + 5.55429213230096e-8*std::exp(1.25095987319946*x_1) - 8.83250177648894e-5*std::exp(1.2611198425293*x_1) + 5.85457672377987e-6*std::exp(1.30063986778259*x_1) - 2.32706021255347e-6*std::exp(1.32463979721069*x_1) - 3.37764827705821e-6*std::exp(1.35039985179901*x_1) - 5.6504326152488e-7*std::exp(1.37815976142883*x_1) + 7.49389981462768e-6*std::exp(1.6387197971344*x_100) + 3.04721764873898e-5*std::exp(1.64639985561371*x_100) + 0.000206323462805909*std::exp(1.64719986915588*x_100) + 9.20787278749269e-5*std::exp(1.6736798286438*x_100) - 4.31216055329834e-5*std::exp(1.71871984004974*x_100) - 2.00669611678102e-5*std::exp(1.7293598651886*x_100) - 1.7514491096141e-7*std::exp(1.82271993160248*x_100) + 0.000975511661166865*std::exp(0.659519851207733*x_104) - 0.000792588035405227*std::exp(0.859919905662537*x_104) + 0.000513870448368431*std::exp(0.884479880332947*x_104) - 5.01884206828104e-5*std::exp(1.06447982788086*x_104) - 0.000104360388445973*std::exp(1.13271987438202*x_104) - 1.3851063365307e-5*std::exp(1.14023983478546*x_104) + 0.00019496019355322*std::exp(0.803759872913361*x_106) - 0.000126923961345908*std::exp(0.869199872016907*x_106) - 0.0336315600522817*std::exp(1.24255990982056*x_106) - 0.00067256923668735*std::exp(0.543359875679016*x_108) - 0.000844296373230116*std::exp(0.810959875583649*x_109) + 0.0444828125264986*std::exp(1.05311989784241*x_109) + 0.000105000847744592*std::exp(1.09655976295471*x_109) - 0.0038908943004863*std::exp(0.613439857959747*x_110) + 2.18586169574244e-5*std::exp(1.4670398235321*x_110) - 1.38162442103851e-5*std::exp(1.47447991371155*x_110) + 8.50989560187188e-5*std::exp(1.51207983493805*x_110) + 4.70825489363593e-6*std::exp(1.52231991291046*x_110) + 8.25715720029714e-6*std::exp(1.54567980766296*x_110) + 2.20536490916222e-5*std::exp(1.62999987602234*x_110) - 6.67408472252981e-7*std::exp(1.70063984394073*x_110) + 5.36205050924808e-6*std::exp(1.7707998752594*x_110) + 0.000208264316691362*std::exp(0.520319879055023*x_112) - 0.000234039588598383*std::exp(0.539999842643738*x_112) + 0.000378135993688771*std::exp(0.687439858913422*x_112) + 0.00185705201095921*std::exp(0.755039870738983*x_112) + 0.00028928513510074*std::exp(0.784239888191223*x_112) - 2.57896243782467e-6*std::exp(1.93039989471436*x_19) - 3.90222565343639e-6*std::exp(1.56215977668762*x_23) - 2.71831960413275e-5*std::exp(2.14359974861145*x_23) + 0.00118222555371833*std::exp(0.799119830131531*x_26) - 0.0492047796152412*std::exp(0.807999849319458*x_26) + 0.00054680395881237*std::exp(0.858239889144897*x_26) + 5.53518502902506e-6*std::exp(1.01599979400635*x_26) + 0.000328958333538195*std::exp(1.09751987457275*x_26) + 5.8395182022094e-5*std::exp(1.21999990940094*x_26) + 2.31214913632313e-7*std::exp(1.22783982753754*x_26) + 0.00011929589133589*std::exp(1.26031982898712*x_26) - 2.4123983377164e-6*std::exp(1.3005598783493*x_26) + 1.80749341433843e-6*std::exp(1.30919981002808*x_26) - 6.63975017195242e-5*std::exp(1.40287983417511*x_26) + 8.57162643636356e-7*std::exp(1.43151986598969*x_26) + 0.0032413942555026*std::exp(0.481919854879379*x_31) - 0.0588484042383288*std::exp(0.533999860286713*x_31) + 0.000308683524121398*std::exp(0.613279819488525*x_31) - 0.0015411371860821*std::exp(0.624479830265045*x_31) + 0.00348634636465542*std::exp(0.631679832935333*x_31) - 0.00220068905690313*std::exp(0.63375985622406*x_31) - 0.000341031976708918*std::exp(0.642559826374054*x_31) + 0.000695952742627764*std::exp(0.643519818782806*x_31) + 0.00856951127920264*std::exp(0.653599858283997*x_31) - 1.00141930138155e-5*std::exp(0.653999865055084*x_31) - 0.0011994598253911*std::exp(0.658079862594604*x_31) + 0.000190988559030323*std::exp(0.669439852237701*x_31) - 0.00120673406925119*std::exp(0.889039874076843*x_45) + 2.52397266292753e-6*std::exp(1.03455984592438*x_45) + 0.000355340538014592*std::exp(1.16495990753174*x_45) + 0.000179362103466326*std::exp(0.592399835586548*x_49) + 6.30671805328547e-5*std::exp(0.920399844646454*x_49) + 0.000190389576296167*std::exp(1.16799986362457*x_50) + 9.59866438689746e-6*std::exp(1.40543985366821*x_50) + 9.43891548419532e-5*std::exp(1.40831983089447*x_50) - 1.00318292370409e-6*std::exp(2.2727198600769*x_50) + 9.69980974522549e-5*std::exp(1.14879977703094*x_6) + 9.10801926533088e-8*std::exp(1.83743989467621*x_6) - 9.63439835445794e-6*std::exp(2.31103992462158*x_6) - 1.51247186344287e-5*std::exp(2.35487985610962*x_6) - 1.50880192097543e-6*std::exp(2.37303996086121*x_6) + 1.81202187839457e-5*std::exp(0.849839866161346*x_60) + 0.000546240450655644*std::exp(1.153599858284*x_60) + 5.0428309377547e-5*std::exp(1.47215986251831*x_60) + 0.0003943426255693*std::exp(0.834719896316528*x_66) + 0.00304147276568883*std::exp(0.882879853248596*x_66) + 0.000398904899725712*std::exp(1.08591985702515*x_66) - 2.65149096639588e-6*std::exp(1.20335984230042*x_66) + 0.000114637868647388*std::exp(1.46271991729736*x_66) + 0.000522969623150885*std::exp(1.46623992919922*x_66) + 0.00020019198553732*std::exp(0.759039878845215*x_68) + 0.000349839848289321*std::exp(1.16567981243134*x_68) + 9.36970504955584e-5*std::exp(1.29567980766296*x_68) - 0.000343371261175572*std::exp(1.29711985588074*x_68) - 0.000843054398912811*std::exp(1.39703989028931*x_68) + 0.000262932260239167*std::exp(0.700399875640869*x_70) + 0.000469446135863829*std::exp(0.794639885425568*x_70) + 1.75244030776365e-5*std::exp(1.14799988269806*x_70) + 0.000518791670088225*std::exp(1.35863983631134*x_72) - 0.000650455642322974*std::exp(0.845839858055115*x_74) + 0.000884172968589236*std::exp(0.96727979183197*x_74) - 0.000161049834468862*std::exp(1.12551987171173*x_74) + 3.84529072979145e-5*std::exp(1.40063989162445*x_74) - 0.000290787109233661*std::exp(1.43639981746674*x_74) + 1.99023889952394e-5*std::exp(1.64263987541199*x_74) + 8.75201672517606e-6*std::exp(1.78703987598419*x_74) + 1.1705455547572e-7*std::exp(1.80823993682861*x_74) - 0.00108654464587385*std::exp(0.836559891700745*x_78) - 0.000433332371915431*std::exp(0.914959847927094*x_78) + 0.00012554458591912*std::exp(1.47279977798462*x_81) + 5.66295302186794e-5*std::exp(1.6276798248291*x_81) + 9.72316673792865e-6*std::exp(1.77087986469269*x_81) + 0.000157115497543209*std::exp(1.93223989009857*x_81) + 5.0235109711657e-6*std::exp(2.02951979637146*x_81) - 0.00130354653344332*std::sin(0.38487982749939*x_10 - 7.40855979919434) + 0.000270399370341471*std::sin(0.309519857168198*x_101 - 7.45863962173462) + 0.0153761843704329*std::sin(0.521039843559265*x_104 - 1.01975977420807) + 0.0108653593147046*std::sin(0.301359832286835*x_105 - 1.27151989936829) - 0.021581833880898*std::sin(0.375199824571609*x_105 - 7.41279983520508) + 0.000927844096262163*std::sin(0.41023987531662*x_105 + 5.21456003189087) + 0.00212593426850655*std::sin(0.537359833717346*x_109 + 2.17647981643677) - 0.00337228113691781*std::sin(0.45991986989975*x_111 - 4.37863969802856) - 0.000245830487603961*std::sin(0.482159852981567*x_111 + 8.4420804977417) - 0.000830980452156894*std::sin(0.476239860057831*x_112 + 2.20975995063782) + 0.201412319778367*std::sin(0.320559859275818*x_114 - 4.27320003509521) + 0.0244334548461855*std::sin(0.153680041432381*x_115 - 7.64736032485962) - 0.000446198105039953*std::sin(0.341359853744507*x_115 - 7.4410400390625) - 0.00132028724093247*std::sin(0.426559865474701*x_115 + 8.20335960388184) - 0.00138992737361889*std::sin(0.485759854316711*x_115 + 8.46312046051025) - 0.0127187774548844*std::sin(0.39455983042717*x_119 - 1.20143985748291) - 0.00696285525147245*std::sin(0.347039848566055*x_120 - 7.45527982711792) + 0.000427774611151401*std::sin(0.556639850139618*x_120 + 2.15871977806091) - 0.0133392171330939*std::sin(0.683679819107056*x_120 - 3.97000002861023) - 0.000145291529292032*std::sin(1.00343978404999*x_15 - 4.19184017181396) - 0.00404237833668562*std::sin(0.397839844226837*x_16 + 5.19200038909912) - 0.0032463632051521*std::sin(0.122640058398247*x_21 - 7.69304037094116) - 0.856230547406998*std::sin(0.22503998875618*x_24 - 4.36663961410522) + 0.00679219615667856*std::sin(0.373199820518494*x_24 - 4.21591997146606) + 0.0338009165671113*std::sin(0.205360010266304*x_27 + 1.81271994113922) - 0.343534252621039*std::sin(0.129680052399635*x_31 + 1.61399984359741) - 0.0462050752838534*std::sin(0.255439966917038*x_33 + 8.20495986938477) + 6.53028881930852e-5*std::sin(0.303839921951294*x_34 + 2.04215979576111) + 0.000287995123038871*std::sin(0.359999865293503*x_34 + 8.20528030395508) + 0.00776591692362317*std::sin(0.363679856061935*x_34 - 1.19727993011475) + 0.00738916574966134*std::sin(0.304559946060181*x_35 - 4.34575986862183) - 0.00067849185415202*std::sin(0.309119910001755*x_35 + 5.06063985824585) - 0.00270124635275122*std::sin(0.317599833011627*x_35 - 7.43192005157471) - 0.0319438921149254*std::sin(0.320879846811295*x_35 + 1.97183978557587) - 0.00683690501204274*std::sin(0.328239858150482*x_35 - 7.43264007568359) + 0.0180685331936588*std::sin(0.341359823942184*x_35 - 7.42399978637695) - 0.00980434792094383*std::sin(0.338959842920303*x_36 + 5.15104007720947) + 0.00689773007052893*std::sin(0.395039856433868*x_36 + 5.19752025604248) - 0.000390140866850506*std::sin(0.416319847106934*x_36 - 4.18847990036011) - 0.00364648080382819*std::sin(0.425919860601425*x_36 - 7.38391971588135) - 0.0170689005818656*std::sin(0.457439839839935*x_36 - 4.15664005279541) + 0.000620175650338603*std::sin(0.237759977579117*x_37 + 5.03343963623047) - 1.61514222173829*std::sin(0.247599974274635*x_37 + 1.84727990627289) - 0.0129916004974547*std::sin(0.350959837436676*x_37 + 5.16936016082764) + 0.000661369358988739*std::sin(0.35471984744072*x_37 + 5.16247987747192) - 0.0032839327330277*std::sin(0.259999960660934*x_40 - 1.3530398607254) + 0.00226622951173782*std::sin(0.302799940109253*x_41 - 7.49200010299683) + 0.0280887635631939*std::sin(0.352559834718704*x_43 - 4.44127988815308) + 1.47839207249373*std::sin(0.225919991731644*x_45 - 7.56376028060913) + 0.00713461088108397*std::sin(0.283919870853424*x_47 - 1.28175985813141) + 1.21544862399828*std::sin(0.200479999184608*x_53 + 5.00799989700317) - 0.00913470830359198*std::sin(0.325919836759567*x_53 - 4.27960014343262) + 0.00376506119791441*std::sin(0.489439845085144*x_53 + 8.49272060394287) - 0.00763536448471404*std::sin(0.362639844417572*x_55 + 5.16312026977539) + 0.00122136507633293*std::sin(0.516959846019745*x_57 - 4.06511974334717) - 0.0187356295994704*std::sin(0.375039845705032*x_58 - 4.22424030303955) + 0.00579040648988203*std::sin(0.437199860811234*x_58 + 5.21896028518677) - 0.00871314837243359*std::sin(0.261599957942963*x_59 + 1.86455988883972) - 0.0123149578174662*std::sin(0.281519949436188*x_63 + 1.87871992588043) + 0.00182644173754985*std::sin(0.307359933853149*x_64 - 7.48880004882813) + 0.00129513715956216*std::sin(0.521279871463776*x_65 - 0.857679903507233) - 0.00158140565011496*std::sin(0.837119877338409*x_73 - 7.18088006973267) - 0.00578888734434155*std::sin(0.279839843511581*x_75 + 8.11103916168213) - 0.00940068910357613*std::sin(0.463439851999283*x_75 + 8.23503971099854) - 0.00416572771591733*std::sin(0.480639845132828*x_75 - 1.13143992424011) + 0.000279501029859976*std::sin(0.486399859189987*x_75 - 1.11623990535736) + 0.00311127693117406*std::sin(0.545119881629944*x_75 + 5.16215991973877) - 0.000680030142656096*std::sin(0.5065598487854*x_76 + 8.50568008422852) - 0.00255093768541338*std::sin(0.272239863872528*x_79 - 1.29615986347198) + 0.257280776123674*std::sin(0.371999859809875*x_80 + 8.36744022369385) - 0.0347098872777944*std::sin(0.34487983584404*x_83 - 7.46303987503052) + 0.00109376787545376*std::sin(0.226559981703758*x_84 - 7.58008003234863) - 0.0372503111132598*std::sin(0.261679977178574*x_84 + 1.87495994567871) + 0.011315417487005*std::sin(0.291039943695068*x_87 - 7.48808002471924) - 0.00258620892475586*std::sin(0.934719800949097*x_87 - 3.82536005973816) + 3.74102684055085e-5*std::sin(1.00263977050781*x_87 - 6.9900803565979) - 0.0020131737869192*std::sin(0.23047998547554*x_92 + 4.82000017166138) + 0.0102295829770893*std::sin(0.331599831581116*x_92 - 7.40279960632324) + 0.00208815751130663*std::sin(0.354319840669632*x_92 + 1.98751986026764) - 0.00157658623930818*std::sin(0.354399859905243*x_92 + 8.18423938751221) + 0.00794291903357537*std::sin(0.359759837388992*x_92 + 1.99959981441498) - 0.008252643010288*std::sin(0.37271985411644*x_92 - 4.39192008972168) - 0.0101226842981236*std::sin(0.416239857673645*x_92 - 7.59040021896362) - 0.00484146489944834*std::sin(0.465199857950211*x_92 - 4.61639976501465) + 0.000711620752507614*std::sin(0.372799843549728*x_94 - 1.18511986732483) + 0.554012459489669*std::sin(0.319919854402542*x_95 + 1.95463979244232) - 0.00117700534113691*std::sin(0.341439843177795*x_95 - 7.4334397315979) - 0.00809673575896609*std::sin(0.348559856414795*x_95 - 1.22079980373383) + 0.00129097739491849*std::sin(0.417919874191284*x_95 + 5.20168018341064) - 0.556382602729473*std::sin(0.375199824571609*x_96 - 4.21479988098145) + 0.00676182786428622*std::sin(0.406559854745865*x_96 - 7.38735961914063) - 0.00465308057284042*std::sin(0.343359857797623*x_97 - 4.42447996139526) + 0.0243501169379008*std::sin(0.309119910001755*x_98 - 4.29047966003418) - 0.399230551510771*std::sin(0.387199848890305*x_98 - 1.18119990825653) - 0.00023212637810476*std::sin(0.442879855632782*x_98 + 2.03743982315063) + 0.00593036355610334*std::sin(0.443519860506058*x_98 + 2.00271987915039) - 0.748126664588724*std::sin(0.326079845428467*x_99 + 1.93167984485626) + 4.73198238219677 - 0.00039756918790206*std::exp(-1.33871984481812*x_9) - 5.30222004722818e-5*std::exp(-1.31719982624054*x_9) - 0.000107526689328337*std::exp(-1.29767978191376*x_9) + 4.10489260762429e-5*std::exp(-1.27743983268738*x_9) - 1.12350631846805e-8*std::exp(-2.84623980522156*x_79) + 4.229634345531e-6*std::exp(-1.95879983901978*x_30));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0351764623693809*x_1 + 0.00973356283559472*x_10 - 0.000725899036913084*x_100 - 0.0455691776003017*x_101 - 0.000325214069479207*x_102 - 0.0552250205475331*x_103 + 0.000364423370659271*x_104 + 0.00730331464787179*x_105 - 0.000102706625257841*x_106 + 0.0748362662622001*x_107 - 0.00400980096259305*x_108 - 0.00405714775752328*x_109 + 0.104035753210219*x_11 + 0.00719980807092548*x_110 + 0.0115864982906791*x_111 + 0.0824561292049826*x_112 - 0.0100788269961379*x_113 + 0.00239595049525932*x_114 - 0.0150926439308527*x_115 - 0.0491380418371569*x_116 + 0.0259372846693556*x_117 + 0.0180087811075209*x_118 - 0.0284644960330829*x_119 - 0.0496271111456646*x_12 + 0.00190412456903492*x_120 + 0.0393769097124293*x_13 - 0.00142741840398612*x_14 - 0.00195286291133242*x_15 + 0.0240448672875673*x_16 + 0.0110911197932183*x_17 - 0.0126057871877241*x_18 + 0.0259469769287676*x_19 + 0.0275197205526889*x_2 - 0.0705840106354352*x_20 - 0.0181526592120071*x_21 + 0.00907596910797149*x_22 - 0.0872030165549327*x_23 + 0.00724912777735116*x_24 - 0.109152146678178*x_25 + 0.00182436679425998*x_26 - 0.00576689526661565*x_27 + 0.0429374333803185*x_28 + 0.0490346542206522*x_29 + 0.0942753462515752*x_3 + 0.0984454731339125*x_30 + 0.00279237594604071*x_31 + 0.127513738878771*x_32 + 0.0299880283074295*x_33 + 0.0348738072490179*x_34 - 0.0065376529162049*x_35 - 0.0193062151723193*x_36 + 0.00521802330270382*x_37 + 0.108855927367514*x_38 + 0.0143143198685722*x_39 - 0.0261905527742579*x_4 + 0.00607169584884346*x_40 + 0.0888753538870471*x_41 - 0.0961616393821775*x_42 - 0.00747112976058189*x_43 + 0.20732081804095*x_44 - 0.00444411030567028*x_45 - 0.0851704285953544*x_46 + 0.0131337475549615*x_47 - 0.00130013466179614*x_48 - 0.00613380998581764*x_49 - 0.00511564050822844*x_5 + 0.00459223849377053*x_50 + 0.0195757539693271*x_51 + 0.0626381970640548*x_52 - 0.00530040174830118*x_53 + 0.110559065543733*x_54 + 0.0589637672725616*x_55 + 0.016812166887113*x_56 + 0.00216682386319715*x_57 - 0.0382964006711185*x_58 + 0.0684568624772791*x_59 + 0.0363486410250656*x_6 + 0.0139083331554919*x_60 - 0.0804277909126866*x_61 + 0.107263968551869*x_62 - 0.0884998980463953*x_63 + 0.0126068254737289*x_64 - 0.0250349432547385*x_65 - 0.00589264083799946*x_66 - 0.0425141869973389*x_67 - 0.00382652864044023*x_68 - 0.058268497814652*x_69 + 0.0560845764131238*x_7 - 0.000123879101711162*x_70 + 0.00575984215312969*x_71 + 0.0172026957950349*x_72 + 0.0558653677432935*x_73 + 0.0517767463324708*x_74 + 0.00458814702151936*x_75 - 0.0153426740626987*x_76 + 0.066195586194928*x_77 - 0.0304719714097424*x_78 + 0.0256183027677922*x_79 + 0.144378253379143*x_8 - 0.00130585345872497*x_80 + 0.00184732612108208*x_81 - 0.0116542629508725*x_82 + 0.0737498423413393*x_83 + 0.00195243106390439*x_84 - 0.0412390630107188*x_85 + 0.0153676459389567*x_86 + 0.0448183104857784*x_87 - 0.0270151016888044*x_88 + 0.0389584923866444*x_89 - 0.00631968758399817*x_9 + 0.0105964709738425*x_90 + 0.0182673538775726*x_91 - 0.0304930791732755*x_92 + 0.18235344913799*x_93 + 0.0305046841254809*x_94 + 0.00212188454785932*x_95 + 0.000417257314874425*x_96 + 0.0136152660915157*x_97 - 0.000213185641661437*x_98 - 0.000936349896897271*x_99 - 0.00032282483295399*std::pow(-9.94719982147217*x_102 - 9.78800010681152, 2) + 0.000513929995543616*std::pow(-7.96016025543213*x_104 - 9.15664005279541, 2) - 0.000574527899529191*std::pow(-6.34000015258789*x_108 - 9.19999980926514, 2) - 2.24447881062153e-5*std::pow(-7.53336048126221*x_110 - 9.12399959564209, 2) - 8.41038127680999e-7*std::pow(-6.82224035263062*x_112 - 7.22352027893066, 2) + 3.28832458622247e-6*std::pow(-8.39915943145752*x_114 - 7.57599973678589, 2) - 1.03354735341322e-5*std::pow(-7.7480001449585*x_115 - 7.5417594909668, 2) + 6.48430012049075e-5*std::pow(-4.07359981536865*x_13 - 6.10303974151611, 2) - 6.30791029275799e-6*std::pow(-6.60400009155273*x_14 - 9.97567939758301, 2) - 9.70700551309457e-6*std::pow(-8.70680046081543*x_15 - 9.9235200881958, 2) - 3.92081854193173e-5*std::pow(-4.7579197883606*x_15 - 6.15079975128174, 2) - 7.10745902310744e-5*std::pow(-4.46928024291992*x_15 - 5.25055980682373, 2) - 4.02479841706196e-6*std::pow(-4.34728002548218*x_24 - 5.5318398475647, 2) - 8.32315346243893e-6*std::pow(-7.32087993621826*x_27 - 8.55039978027344, 2) - 1.05851917359527e-5*std::pow(-5.54271984100342*x_36 - 6.56727981567383, 2) + 3.96945886957046e-6*std::pow(-9.39496040344238*x_39 - 8.79872035980225, 2) - 1.50035007634965e-5*std::pow(-4.88320016860962*x_4 - 8.13959980010986, 2) - 1.71161601176681e-6*std::pow(-5.77159976959229*x_47 - 3.50111985206604, 2) - 1.28334580399572e-5*std::pow(-6.14759969711304*x_53 - 5.93872022628784, 2) - 7.41887310543155e-8*std::pow(-5.93631982803345*x_57 - 7.71104001998901, 2) - 0.00110501066856039*std::pow(-4.32000017166138*x_57 - 6.7828803062439, 2) + 7.54637671049366e-6*std::pow(-5.4871997833252*x_6 - 8.73799991607666, 2) + 9.20804051634849e-6*std::pow(-8.86295986175537*x_67 - 9.87448024749756, 2) - 1.33488721881847e-5*std::pow(-6.9117603302002*x_70 - 9.48536014556885, 2) + 0.000538351377874759*std::pow(-5.01503992080688*x_70 - 7.41752004623413, 2) + 8.28707278018715e-5*std::pow(-4.91472005844116*x_70 - 6.55808019638062, 2) + 8.42693072336975e-6*std::pow(-6.60000038146973*x_72 - 9.96523952484131, 2) - 3.43629917853385e-6*std::pow(-5.69008016586304*x_73 - 7.72512006759644, 2) - 3.00625308568816e-5*std::pow(-5.29624032974243*x_75 - 7.53200006484985, 2) + 1.59329604015809e-5*std::pow(-9.12207984924316*x_81 - 9.71424007415771, 2) - 1.96514670351145e-5*std::pow(-7.73016023635864*x_82 - 8.14496040344238, 2) - 0.000205925261887245*std::pow(-9.88728046417236*x_84 - 8.88064002990723, 2) - 0.000190504957722083*std::pow(-1.53071987628937*x_86 - 2.10567998886108, 2) - 1.39823795378561e-5*std::pow(-9.37191963195801*x_89 - 9.57999992370605, 2) - 7.44633825895048e-8*std::pow(-6.53375959396362*x_90 - 6.33328008651733, 2) + 7.5175331577788e-6*std::pow(-7.40248012542725*x_97 - 5.45391988754272, 2) - 9.15076650815689e-5*std::exp(1.01567983627319*x_1) - 2.46968993188242e-5*std::exp(1.11351990699768*x_1) - 7.76051175121299e-5*std::exp(1.14375984668732*x_1) + 5.55628418770106e-6*std::exp(1.20751988887787*x_1) + 3.36417092232078e-6*std::exp(1.21103978157043*x_1) + 3.94993334671966e-6*std::exp(1.25095987319946*x_1) + 2.67712260045275e-5*std::exp(1.2611198425293*x_1) + 7.61806918315945e-6*std::exp(1.30063986778259*x_1) - 2.02949115585224e-6*std::exp(1.32463979721069*x_1) - 1.2808032992954e-5*std::exp(1.35039985179901*x_1) + 3.26652473350974e-8*std::exp(1.37815976142883*x_1) - 4.33223626609827e-7*std::exp(1.6387197971344*x_100) - 1.56570050677438e-5*std::exp(1.64639985561371*x_100) - 1.93247543011883e-5*std::exp(1.64719986915588*x_100) + 0.000349162283290923*std::exp(1.6736798286438*x_100) + 5.37629594692686e-5*std::exp(1.71871984004974*x_100) + 4.73714014260501e-5*std::exp(1.7293598651886*x_100) - 1.24554256030484e-5*std::exp(1.82271993160248*x_100) - 0.00230285762305939*std::exp(0.659519851207733*x_104) - 0.00103132827057106*std::exp(0.859919905662537*x_104) + 0.000448160096843043*std::exp(0.884479880332947*x_104) + 0.000835157674813512*std::exp(1.06447982788086*x_104) + 5.36217401945833e-5*std::exp(1.13271987438202*x_104) + 5.03455027765152e-5*std::exp(1.14023983478546*x_104) - 0.00324422445882754*std::exp(0.803759872913361*x_106) + 0.000299625133732073*std::exp(0.869199872016907*x_106) + 0.028740477713282*std::exp(1.24255990982056*x_106) + 0.000838542817814168*std::exp(0.543359875679016*x_108) + 7.90788393533551e-5*std::exp(0.810959875583649*x_109) - 0.0380136181626579*std::exp(1.05311989784241*x_109) - 5.39508166059224e-5*std::exp(1.09655976295471*x_109) - 0.00339335249195293*std::exp(0.613439857959747*x_110) + 8.28878154876662e-5*std::exp(1.4670398235321*x_110) + 0.000229908457616657*std::exp(1.47447991371155*x_110) - 7.97057394241386e-6*std::exp(1.51207983493805*x_110) - 1.71134485178811e-5*std::exp(1.52231991291046*x_110) - 1.02948209465762e-5*std::exp(1.54567980766296*x_110) + 2.86965620996474e-5*std::exp(1.62999987602234*x_110) + 3.85829976289756e-8*std::exp(1.70063984394073*x_110) - 1.26580125917523e-5*std::exp(1.7707998752594*x_110) - 1.20397956741208e-5*std::exp(0.520319879055023*x_112) + 0.000552489398288472*std::exp(0.539999842643738*x_112) - 0.000194291247030926*std::exp(0.687439858913422*x_112) + 0.00161958449199892*std::exp(0.755039870738983*x_112) - 0.000416253067298858*std::exp(0.784239888191223*x_112) + 4.29150836727311e-5*std::exp(1.93039989471436*x_19) + 2.25588330675542e-7*std::exp(1.56215977668762*x_23) + 2.54604385500186e-6*std::exp(2.14359974861145*x_23) + 0.00448299605378854*std::exp(0.799119830131531*x_26) + 0.0420488633212497*std::exp(0.807999849319458*x_26) - 0.00078679751376629*std::exp(0.858239889144897*x_26) - 2.01191537355393e-5*std::exp(1.01599979400635*x_26) - 3.0811032756532e-5*std::exp(1.09751987457275*x_26) - 7.28056797851143e-5*std::exp(1.21999990940094*x_26) + 1.64428423255591e-5*std::exp(1.22783982753754*x_26) - 0.000106724628888648*std::exp(1.26031982898712*x_26) + 4.01433828568601e-5*std::exp(1.3005598783493*x_26) - 9.28713889535314e-7*std::exp(1.30919981002808*x_26) - 5.79070286980646e-5*std::exp(1.40287983417511*x_26) - 4.95527186453397e-8*std::exp(1.43151986598969*x_26) - 0.000303596821849566*std::exp(0.481919854879379*x_31) + 0.050290002837949*std::exp(0.533999860286713*x_31) - 0.000384859042028845*std::exp(0.613279819488525*x_31) - 0.00584398797828636*std::exp(0.624479830265045*x_31) + 0.00304053546837186*std::exp(0.631679832935333*x_31) - 0.00286357191597039*std::exp(0.63375985622406*x_31) + 0.00567492399303222*std::exp(0.642559826374054*x_31) - 0.000357589672754172*std::exp(0.643519818782806*x_31) - 0.00259741043941322*std::exp(0.653599858283997*x_31) - 0.000712159065161926*std::exp(0.653999865055084*x_31) + 0.00283152453467484*std::exp(0.658079862594604*x_31) - 1.10410811767988e-5*std::exp(0.669439852237701*x_31) - 0.00157022173573905*std::exp(0.889039874076843*x_45) + 0.000179492247617452*std::exp(1.03455984592438*x_45) - 0.000317895164904901*std::exp(1.16495990753174*x_45) - 0.000423414095082501*std::exp(0.592399835586548*x_49) - 0.000229235029028651*std::exp(0.920399844646454*x_49) - 0.000237373051102021*std::exp(1.16799986362457*x_50) - 3.48889880723374e-5*std::exp(1.40543985366821*x_50) - 0.000222821308462804*std::exp(1.40831983089447*x_50) + 5.79941759445216e-8*std::exp(2.2727198600769*x_50) - 0.001614091545967*std::exp(1.14879977703094*x_6) + 6.47716543562354e-6*std::exp(1.83743989467621*x_6) - 3.65336121079585e-5*std::exp(2.31103992462158*x_6) + 1.35308933545727e-5*std::exp(2.35487985610962*x_6) + 8.72240964263981e-8*std::exp(2.37303996086121*x_6) - 6.58629233754852e-5*std::exp(0.849839866161346*x_60) + 0.00207134228913171*std::exp(1.153599858284*x_60) - 0.000839149529543837*std::exp(1.47215986251831*x_60) - 0.000567420539609628*std::exp(0.834719896316528*x_66) - 0.000284871691815213*std::exp(0.882879853248596*x_66) - 0.000497344838879943*std::exp(1.08591985702515*x_66) - 0.000188560708317557*std::exp(1.20335984230042*x_66) + 0.000434706483161855*std::exp(1.46271991729736*x_66) - 0.000158511578363252*std::exp(1.46623992919922*x_66) - 0.00333128380775911*std::exp(0.759039878845215*x_68) - 0.000503385387787333*std::exp(1.16567981243134*x_68) - 0.000116819183003973*std::exp(1.29567980766296*x_68) - 0.000446800195224938*std::exp(1.29711985588074*x_68) - 0.000735250182726658*std::exp(1.39703989028931*x_68) - 0.00437530992422748*std::exp(0.700399875640869*x_70) - 0.000585293920843156*std::exp(0.794639885425568*x_70) - 9.00426879285388e-6*std::exp(1.14799988269806*x_70) - 0.000157245244899561*std::exp(1.35863983631134*x_72) - 0.00246652600980163*std::exp(0.845839858055115*x_74) - 0.000267991957071599*std::exp(0.96727979183197*x_74) + 0.000380184936544425*std::exp(1.12551987171173*x_74) - 1.97576095255971e-5*std::exp(1.40063989162445*x_74) + 2.72358236114888e-5*std::exp(1.43639981746674*x_74) - 2.86375947487191e-5*std::exp(1.64263987541199*x_74) - 1.09117996571369e-5*std::exp(1.78703987598419*x_74) + 8.32433154479134e-6*std::exp(1.80823993682861*x_74) + 0.000972045833291395*std::exp(0.836559891700745*x_78) + 0.000540268166272043*std::exp(0.914959847927094*x_78) - 0.000296368888478337*std::exp(1.47279977798462*x_81) + 7.3687253471877e-5*std::exp(1.6276798248291*x_81) - 0.000161797825358824*std::exp(1.77087986469269*x_81) - 4.76215527602765e-5*std::exp(1.93223989009857*x_81) - 2.58114600924409e-6*std::exp(2.02951979637146*x_81) + 0.0216915949350566*std::sin(0.38487982749939*x_10 - 7.40855979919434) - 0.000982840948110327*std::sin(0.309519857168198*x_101 - 7.45863962173462) - 0.0137558599234355*std::sin(0.521039843559265*x_104 - 1.01975977420807) + 0.0141381799000262*std::sin(0.301359832286835*x_105 - 1.27151989936829) + 0.00654143262054756*std::sin(0.375199824571609*x_105 - 7.41279983520508) - 0.0154397390370396*std::sin(0.41023987531662*x_105 + 5.21456003189087) + 0.00276629978569589*std::sin(0.537359833717346*x_109 + 2.17647981643677) - 0.00438806633138068*std::sin(0.45991986989975*x_111 - 4.37863969802856) + 0.000893538580381985*std::sin(0.482159852981567*x_111 + 8.4420804977417) + 0.0138278848546539*std::sin(0.476239860057831*x_112 + 2.20975995063782) - 0.172120659248986*std::sin(0.320559859275818*x_114 - 4.27320003509521) + 0.0926515936923892*std::sin(0.153680041432381*x_115 - 7.64736032485962) + 0.00162182984394043*std::sin(0.341359853744507*x_115 - 7.4410400390625) + 0.0018997644436943*std::sin(0.426559865474701*x_115 + 8.20335960388184) + 0.000714162965732117*std::sin(0.485759854316711*x_115 + 8.46312046051025) + 0.0113784874616338*std::sin(0.39455983042717*x_119 - 1.20143985748291) + 0.00211043457777915*std::sin(0.347039848566055*x_120 - 7.45527982711792) - 2.4729723241413e-5*std::sin(0.556639850139618*x_120 + 2.15871977806091) + 0.0119335459272959*std::sin(0.683679819107056*x_120 - 3.97000002861023) + 0.000342984834641438*std::sin(1.00343978404999*x_15 - 4.19184017181396) - 0.00526000756097257*std::sin(0.397839844226837*x_16 + 5.19200038909912) + 0.0540209297110551*std::sin(0.122640058398247*x_21 - 7.69304037094116) + 0.731707804423202*std::sin(0.22503998875618*x_24 - 4.36663961410522) + 0.00883811463551205*std::sin(0.373199820518494*x_24 - 4.21591997146606) - 0.0302390152445748*std::sin(0.205360010266304*x_27 + 1.81271994113922) + 0.307333012151185*std::sin(0.129680052399635*x_31 + 1.61399984359741) + 0.0413360381252104*std::sin(0.255439966917038*x_33 + 8.20495986938477) + 0.00464401312654968*std::sin(0.303839921951294*x_34 + 2.04215979576111) - 0.00104679755511717*std::sin(0.359999865293503*x_34 + 8.20528030395508) - 0.0111743962880103*std::sin(0.363679856061935*x_34 - 1.19727993011475) + 0.00961490104965425*std::sin(0.304559946060181*x_35 - 4.34575986862183) + 0.0112904066632164*std::sin(0.309119910001755*x_35 + 5.06063985824585) + 0.00138793590447182*std::sin(0.317599833011627*x_35 - 7.43192005157471) - 0.0278591186343226*std::sin(0.320879846811295*x_35 + 1.97183978557587) + 0.000640361051242036*std::sin(0.328239858150482*x_35 - 7.43264007568359) - 0.0161644921552744*std::sin(0.341359823942184*x_35 - 7.42399978637695) - 0.0127575748480914*std::sin(0.338959842920303*x_36 + 5.15104007720947) + 0.0261561734890796*std::sin(0.395039856433868*x_36 + 5.19752025604248) + 0.00141807438008345*std::sin(0.416319847106934*x_36 - 4.18847990036011) + 0.00454634277269029*std::sin(0.425919860601425*x_36 - 7.38391971588135) + 0.00159871449155669*std::sin(0.457439839839935*x_36 - 4.15664005279541) - 3.5852460137025e-5*std::sin(0.237759977579117*x_37 + 5.03343963623047) + 1.38024994842607*std::sin(0.247599974274635*x_37 + 1.84727990627289) - 0.0113303206198598*std::sin(0.350959837436676*x_37 + 5.16936016082764) - 0.00240392899960802*std::sin(0.35471984744072*x_37 + 5.16247987747192) + 0.0546461033889184*std::sin(0.259999960660934*x_40 - 1.3530398607254) - 0.0377110684868582*std::sin(0.302799940109253*x_41 - 7.49200010299683) - 0.0251288022886081*std::sin(0.352559834718704*x_43 - 4.44127988815308) - 1.26338755457513*std::sin(0.225919991731644*x_45 - 7.56376028060913) + 0.0092836701697418*std::sin(0.283919870853424*x_47 - 1.28175985813141) - 1.0386843201849*std::sin(0.200479999184608*x_53 + 5.00799989700317) + 0.00276872110155529*std::sin(0.325919836759567*x_53 - 4.27960014343262) + 0.00489915804981082*std::sin(0.489439845085144*x_53 + 8.49272060394287) - 0.00993525879453095*std::sin(0.362639844417572*x_55 + 5.16312026977539) - 0.000627553440353154*std::sin(0.516959846019745*x_57 - 4.06511974334717) + 0.00175482436056452*std::sin(0.375039845705032*x_58 - 4.22424030303955) + 0.00753456984505228*std::sin(0.437199860811234*x_58 + 5.21896028518677) - 0.0113376884847582*std::sin(0.261599957942963*x_59 + 1.86455988883972) - 0.0466982862319578*std::sin(0.281519949436188*x_63 + 1.87871992588043) - 0.00227716273304723*std::sin(0.307359933853149*x_64 - 7.48880004882813) - 0.000121305677282191*std::sin(0.521279871463776*x_65 - 0.857679903507233) + 0.000479322497016169*std::sin(0.837119877338409*x_73 - 7.18088006973267) + 0.00721744266752639*std::sin(0.279839843511581*x_75 + 8.11103916168213) - 0.00819859120606484*std::sin(0.463439851999283*x_75 + 8.23503971099854) - 0.00542051175265394*std::sin(0.480639845132828*x_75 - 1.13143992424011) - 0.00101592343517103*std::sin(0.486399859189987*x_75 - 1.11623990535736) - 0.00447682375856051*std::sin(0.545119881629944*x_75 + 5.16215991973877) + 0.00160532432390665*std::sin(0.5065598487854*x_76 + 8.50568008422852) + 0.0424487393099754*std::sin(0.272239863872528*x_79 - 1.29615986347198) - 0.219864091964318*std::sin(0.371999859809875*x_80 + 8.36744022369385) + 0.0105205326918699*std::sin(0.34487983584404*x_83 - 7.46303987503052) - 0.00397560044006773*std::sin(0.226559981703758*x_84 - 7.58008003234863) + 0.0112905326575372*std::sin(0.261679977178574*x_84 + 1.87495994567871) + 0.00986847679779354*std::sin(0.291039943695068*x_87 - 7.48808002471924) + 0.000783877381195248*std::sin(0.934719800949097*x_87 - 3.82536005973816) - 0.000135977918965933*std::sin(1.00263977050781*x_87 - 6.9900803565979) + 0.00250997566934152*std::sin(0.23047998547554*x_92 + 4.82000017166138) + 0.0387905505628414*std::sin(0.331599831581116*x_92 - 7.40279960632324) - 0.00107292279402178*std::sin(0.354319840669632*x_92 + 1.98751986026764) + 0.0262350972564986*std::sin(0.354399859905243*x_92 + 8.18423938751221) + 0.0103354537089309*std::sin(0.359759837388992*x_92 + 1.99959981441498) + 0.000772962494620692*std::sin(0.37271985411644*x_92 - 4.39192008972168) + 0.00905596758594456*std::sin(0.416239857673645*x_92 - 7.59040021896362) - 0.00422237041473789*std::sin(0.465199857950211*x_92 - 4.61639976501465) - 4.11389170923257e-5*std::sin(0.372799843549728*x_94 - 1.18511986732483) - 0.473441693459687*std::sin(0.319919854402542*x_95 + 1.95463979244232) + 6.80428795473297e-5*std::sin(0.341439843177795*x_95 - 7.4334397315979) - 0.0105356025003532*std::sin(0.348559856414795*x_95 - 1.22079980373383) - 0.0214824388715265*std::sin(0.417919874191284*x_95 + 5.20168018341064) + 0.475467143627772*std::sin(0.375199824571609*x_96 - 4.21479988098145) + 0.0256408326961395*std::sin(0.406559854745865*x_96 - 7.38735961914063) + 0.00043581877499973*std::sin(0.343359857797623*x_97 - 4.42447996139526) + 0.021236385162209*std::sin(0.309119910001755*x_98 - 4.29047966003418) + 0.34116992343857*std::sin(0.387199848890305*x_98 - 1.18119990825653) + 0.000843727221885872*std::sin(0.442879855632782*x_98 + 2.03743982315063) + 0.00771668422555315*std::sin(0.443519860506058*x_98 + 2.00271987915039) + 0.63932561251691*std::sin(0.326079845428467*x_99 + 1.93167984485626) - 3.75379632459368 + 0.000355673808722727*std::exp(-1.33871984481812*x_9) + 0.000125167728290324*std::exp(-1.31719982624054*x_9) + 0.000154720408408905*std::exp(-1.29767978191376*x_9) - 0.000683072413696582*std::exp(-1.27743983268738*x_9) - 7.98981214322404e-7*std::exp(-2.84623980522156*x_79) + 3.68877670222588e-6*std::exp(-1.95879983901978*x_30));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.066265268380505*x_1 + 0.0185669828735559*x_10 + 0.0068001398885068*x_100 - 0.0836796785806319*x_101 - 0.0035184500153488*x_102 - 0.0887214221724772*x_103 + 0.000626873569344476*x_104 + 0.00125874059510484*x_105 - 0.00469516448712978*x_106 + 0.133934733140106*x_107 - 0.00275576629983029*x_108 + 0.00394210735926024*x_109 + 0.177780419646459*x_11 + 0.0135532689941326*x_110 + 0.00543861821649498*x_111 + 0.143245226118809*x_112 - 0.0153783162189616*x_113 - 0.000260407453526687*x_114 - 0.0274523489415136*x_115 - 0.097862947431587*x_116 + 0.0385482920370487*x_117 + 0.0317898702367696*x_118 - 0.0388211116197411*x_119 - 0.0436567788771196*x_12 + 0.0100870997963049*x_120 + 0.0750402229778241*x_13 - 0.00485637840622881*x_14 + 0.00109109081098921*x_15 + 0.0347921786976274*x_16 + 0.0151154173902025*x_17 - 0.0307004851401888*x_18 + 0.0525783007423622*x_19 + 0.0678397438938992*x_2 - 0.122363282269693*x_20 - 0.0342969808689129*x_21 - 0.0104315500970885*x_22 - 0.155630080623351*x_23 - 0.00287086597653352*x_24 - 0.200145518096817*x_25 - 0.00111927920388174*x_26 - 0.0125886953040154*x_27 + 0.0856988329702984*x_28 + 0.0917172556740753*x_29 + 0.175264197819213*x_3 + 0.175008900155371*x_30 + 7.40560678684867e-5*x_31 + 0.258965951793524*x_32 + 0.0453705188495396*x_33 + 0.0740415357340293*x_34 - 0.0137445549704592*x_35 - 0.0272963089087995*x_36 + 0.00081326686581084*x_37 + 0.179207597970013*x_38 + 0.0298634125312131*x_39 - 0.0487923474573234*x_4 - 0.00316148027912908*x_40 + 0.165801246949623*x_41 - 0.162595767374215*x_42 - 0.0125349451980868*x_43 + 0.390272004480854*x_44 + 0.00274903633802779*x_45 - 0.146286977476163*x_46 + 0.0352796939028006*x_47 - 0.0140556405784813*x_48 - 0.0152946179183144*x_49 - 0.0101333942785443*x_5 + 0.00899849262678412*x_50 + 0.0261985611097099*x_51 + 0.116702145218035*x_52 - 0.00126019464370348*x_53 + 0.188882681376023*x_54 + 0.105546034370804*x_55 + 0.0295948114872986*x_56 + 0.00418801140115267*x_57 - 0.0820407086261792*x_58 + 0.131160716028986*x_59 + 0.0647046197543788*x_6 + 0.030196582978931*x_60 - 0.139422291577766*x_61 + 0.196511805287128*x_62 - 0.156370968169082*x_63 + 0.0365744891713986*x_64 - 0.0324912397236601*x_65 - 0.00304934739230358*x_66 - 0.078612568564174*x_67 - 0.0113674369153657*x_68 - 0.0874145424254483*x_69 + 0.104229783936964*x_7 - 0.000369511830050863*x_70 + 0.0162668337983554*x_71 + 0.0281608412042721*x_72 + 0.11325640064166*x_73 + 0.0878581196494286*x_74 + 0.0111431113022097*x_75 - 0.0246704574364507*x_76 + 0.119316260727914*x_77 - 0.0656346488080357*x_78 + 0.0448752191013253*x_79 + 0.295940120294136*x_8 + 0.00191776552145025*x_80 + 0.00650600429828537*x_81 - 0.0275789090453566*x_82 + 0.136536907119855*x_83 + 3.59586430044127e-5*x_84 - 0.0758572486678089*x_85 + 0.0322539264557675*x_86 + 0.0856306223908112*x_87 - 0.0415650250713166*x_88 + 0.0815652338807593*x_89 - 0.00795423904058122*x_9 + 0.0341174043961462*x_90 + 0.0127557456184967*x_91 - 0.0633479951530813*x_92 + 0.381990101270893*x_93 + 0.0630860362797016*x_94 - 0.000621038333001625*x_95 - 0.00142162937412379*x_96 + 0.0354266401600528*x_97 - 0.0057777965682055*x_98 - 0.00500134731372134*x_99 - 0.000590256821551868*std::pow(-9.94719982147217*x_102 - 9.78800010681152, 2) + 0.000939675807756013*std::pow(-7.96016025543213*x_104 - 9.15664005279541, 2) - 0.00105047374691061*std::pow(-6.34000015258789*x_108 - 9.19999980926514, 2) + 5.72348519541683e-6*std::pow(-7.53336048126221*x_110 - 9.12399959564209, 2) - 8.17400660295516e-7*std::pow(-6.82224035263062*x_112 - 7.22352027893066, 2) - 2.38174239819507e-5*std::pow(-8.39915943145752*x_114 - 7.57599973678589, 2) + 3.68570438355436e-7*std::pow(-7.7480001449585*x_115 - 7.5417594909668, 2) - 2.1726008398749e-5*std::pow(-4.07359981536865*x_13 - 6.10303974151611, 2) - 1.6050265430948e-6*std::pow(-6.60400009155273*x_14 - 9.97567939758301, 2) - 2.46991488137862e-6*std::pow(-8.70680046081543*x_15 - 9.9235200881958, 2) + 9.0878725893653e-5*std::pow(-4.7579197883606*x_15 - 6.15079975128174, 2) + 1.81242238970046e-5*std::pow(-4.46928024291992*x_15 - 5.25055980682373, 2) + 3.94980652766781e-6*std::pow(-4.34728002548218*x_24 - 5.5318398475647, 2) - 2.11779838479995e-6*std::pow(-7.32087993621826*x_27 - 8.55039978027344, 2) - 5.615218958616e-6*std::pow(-5.54271984100342*x_36 - 6.56727981567383, 2) + 2.10571345856233e-6*std::pow(-9.39496040344238*x_39 - 8.79872035980225, 2) - 1.35959740575818e-5*std::pow(-4.88320016860962*x_4 - 8.13959980010986, 2) + 8.93119665281144e-7*std::pow(-5.77159976959229*x_47 - 3.50111985206604, 2) + 3.27256852459918e-6*std::pow(-6.14759969711304*x_53 - 5.93872022628784, 2) + 1.36316884749216e-6*std::pow(-5.93631982803345*x_57 - 7.71104001998901, 2) - 0.00202041484552807*std::pow(-4.32000017166138*x_57 - 6.7828803062439, 2) + 6.83842681797557e-6*std::pow(-5.4871997833252*x_6 - 8.73799991607666, 2) - 2.13428645358986e-5*std::pow(-8.86295986175537*x_67 - 9.87448024749756, 2) - 3.3965755992146e-6*std::pow(-6.9117603302002*x_70 - 9.48536014556885, 2) + 0.000984328158012901*std::pow(-5.01503992080688*x_70 - 7.41752004623413, 2) - 2.77662985176208e-5*std::pow(-4.91472005844116*x_70 - 6.55808019638062, 2) + 2.14420415955469e-6*std::pow(-6.60000038146973*x_72 - 9.96523952484131, 2) + 3.37227247676678e-6*std::pow(-5.69008016586304*x_73 - 7.72512006759644, 2) + 7.66603139588012e-6*std::pow(-5.29624032974243*x_75 - 7.53200006484985, 2) - 4.06295049639423e-6*std::pow(-9.12207984924316*x_81 - 9.71424007415771, 2) + 4.55491695673435e-5*std::pow(-7.73016023635864*x_82 - 8.14496040344238, 2) - 0.000376516234660686*std::pow(-9.88728046417236*x_84 - 8.88064002990723, 2) - 0.000172633074364342*std::pow(-1.53071987628937*x_86 - 2.10567998886108, 2) + 4.98621735956329e-7*std::pow(-9.37191963195801*x_89 - 9.57999992370605, 2) + 1.36821538773305e-6*std::pow(-6.53375959396362*x_90 - 6.33328008651733, 2) + 3.98789136395218e-6*std::pow(-7.40248012542725*x_97 - 5.45391988754272, 2) + 3.26322931606521e-6*std::exp(1.01567983627319*x_1) - 2.23800036894318e-5*std::exp(1.11351990699768*x_1) + 1.97895270415255e-5*std::exp(1.14375984668732*x_1) + 7.08768085347976e-6*std::exp(1.20751988887787*x_1) - 3.30148814729279e-6*std::exp(1.21103978157043*x_1) - 2.06107159798275e-6*std::exp(1.25095987319946*x_1) - 0.000193904714558284*std::exp(1.2611198425293*x_1) + 1.93839206308011e-6*std::exp(1.30063986778259*x_1) + 4.70405780027297e-6*std::exp(1.32463979721069*x_1) + 4.29140272975695e-6*std::exp(1.35039985179901*x_1) - 6.00202307412842e-7*std::exp(1.37815976142883*x_1) + 7.96019750438553e-6*std::exp(1.6387197971344*x_100) - 1.99723144628062e-5*std::exp(1.64639985561371*x_100) + 1.89646866190454e-5*std::exp(1.64719986915588*x_100) - 0.000116988766071038*std::exp(1.6736798286438*x_100) + 0.000102947835638105*std::exp(1.71871984004974*x_100) + 4.29273377601892e-5*std::exp(1.7293598651886*x_100) + 6.49922965726751e-6*std::exp(1.82271993160248*x_100) - 0.00208681913607764*std::exp(0.659519851207733*x_104) - 0.000262418007245765*std::exp(0.859919905662537*x_104) - 0.00103876826131835*std::exp(0.884479880332947*x_104) - 2.97823248528852e-5*std::exp(1.06447982788086*x_104) + 6.84007096232894e-5*std::exp(1.13271987438202*x_104) + 4.893053698517e-5*std::exp(1.14023983478546*x_104) + 0.000115691383366683*std::exp(0.803759872913361*x_106) + 0.000271516335383009*std::exp(0.869199872016907*x_106) + 0.0525494363915366*std::exp(1.24255990982056*x_106) + 0.001605681105282*std::exp(0.543359875679016*x_108) - 7.76054061624989e-5*std::exp(0.810959875583649*x_109) - 0.0695045583298567*std::exp(1.05311989784241*x_109) - 6.88204845126197e-5*std::exp(1.09655976295471*x_109) + 0.00786528495717627*std::exp(0.613439857959747*x_110) - 2.77720238418377e-5*std::exp(1.4670398235321*x_110) - 8.19870136821053e-6*std::exp(1.47447991371155*x_110) + 7.82206255437428e-6*std::exp(1.51207983493805*x_110) - 1.66324731995445e-5*std::exp(1.52231991291046*x_110) - 1.97130058537357e-5*std::exp(1.54567980766296*x_110) + 7.3017436405812e-6*std::exp(1.62999987602234*x_110) - 7.08937053690501e-7*std::exp(1.70063984394073*x_110) - 1.14705236818278e-5*std::exp(1.7707998752594*x_110) + 0.000221223279599115*std::exp(0.520319879055023*x_112) + 0.000500658589260371*std::exp(0.539999842643738*x_112) - 0.000247840878014839*std::exp(0.687439858913422*x_112) - 0.00375395529111799*std::exp(0.755039870738983*x_112) - 0.000220813394162692*std::exp(0.784239888191223*x_112) - 1.53038282659071e-6*std::exp(1.93039989471436*x_19) - 4.14503631972785e-6*std::exp(1.56215977668762*x_23) - 2.49860479858663e-6*std::exp(2.14359974861145*x_23) - 0.00150205277526231*std::exp(0.799119830131531*x_26) + 0.076882649289273*std::exp(0.807999849319458*x_26) - 0.00041737933767288*std::exp(0.858239889144897*x_26) - 1.9553702747534e-5*std::exp(1.01599979400635*x_26) + 3.02369474679863e-5*std::exp(1.09751987457275*x_26) - 0.00013941172937704*std::exp(1.21999990940094*x_26) - 8.5798600463634e-6*std::exp(1.22783982753754*x_26) + 2.72150857713548e-5*std::exp(1.26031982898712*x_26) - 1.43154197703292e-6*std::exp(1.3005598783493*x_26) - 1.18468160210208e-6*std::exp(1.30919981002808*x_26) + 0.000134219855677752*std::exp(1.40287983417511*x_26) + 9.10498419448862e-7*std::exp(1.43151986598969*x_26) + 0.000297940066671954*std::exp(0.481919854879379*x_31) + 0.0919508482644917*std::exp(0.533999860286713*x_31) - 0.000736946139009916*std::exp(0.613279819488525*x_31) + 0.00195806069335404*std::exp(0.624479830265045*x_31) - 0.00704750771924162*std::exp(0.631679832935333*x_31) - 0.000728626235929516*std::exp(0.63375985622406*x_31) - 0.000202371881350019*std::exp(0.642559826374054*x_31) - 0.000456146840471545*std::exp(0.643519818782806*x_31) + 0.0188131141158776*std::exp(0.653599858283997*x_31) + 0.000371603947107154*std::exp(0.653999865055084*x_31) + 0.00256589010282917*std::exp(0.658079862594604*x_31) + 0.00020287256149219*std::exp(0.669439852237701*x_31) - 0.000399537635672947*std::exp(0.889039874076843*x_45) - 9.36588902011853e-5*std::exp(1.03455984592438*x_45) + 8.1064176744175e-5*std::exp(1.16495990753174*x_45) - 0.000383692255767552*std::exp(0.592399835586548*x_49) - 0.000222792353787261*std::exp(0.920399844646454*x_49) - 0.000454533048236208*std::exp(1.16799986362457*x_50) - 3.39084292955952e-5*std::exp(1.40543985366821*x_50) - 0.000201917724209234*std::exp(1.40831983089447*x_50) - 1.06560461218392e-6*std::exp(2.2727198600769*x_50) + 5.75596683285214e-5*std::exp(1.14879977703094*x_6) - 3.37977898434314e-6*std::exp(1.83743989467621*x_6) + 1.22407900427976e-5*std::exp(2.31103992462158*x_6) - 3.45041652561716e-6*std::exp(2.35487985610962*x_6) - 1.60268506159065e-6*std::exp(2.37303996086121*x_6) - 6.40118388027878e-5*std::exp(0.849839866161346*x_60) - 0.000694014760793549*std::exp(1.153599858284*x_60) + 2.99246772707932e-5*std::exp(1.47215986251831*x_60) - 0.000301004521316526*std::exp(0.834719896316528*x_66) + 0.000279563831845489*std::exp(0.882879853248596*x_66) - 0.000952339217072657*std::exp(1.08591985702515*x_66) + 9.83908046781553e-5*std::exp(1.20335984230042*x_66) - 0.000145650826283012*std::exp(1.46271991729736*x_66) + 0.00114810365246296*std::exp(1.46623992919922*x_66) + 0.000118795982521495*std::exp(0.759039878845215*x_68) - 0.000267035235969609*std::exp(1.16567981243134*x_68) - 0.000223690849052777*std::exp(1.29567980766296*x_68) - 0.0001136868058538*std::exp(1.29711985588074*x_68) + 0.00170420026085557*std::exp(1.39703989028931*x_68) + 0.000156026706603029*std::exp(0.700399875640869*x_70) - 0.00112074824298661*std::exp(0.794639885425568*x_70) - 1.14859826039786e-5*std::exp(1.14799988269806*x_70) + 0.00113893156491004*std::exp(1.35863983631134*x_72) + 0.000826423265563277*std::exp(0.845839858055115*x_74) + 0.00194107299871496*std::exp(0.96727979183197*x_74) + 0.000344518563755302*std::exp(1.12551987171173*x_74) - 2.52031080510741e-5*std::exp(1.40063989162445*x_74) - 2.67283532588935e-5*std::exp(1.43639981746674*x_74) - 1.51916345942028e-5*std::exp(1.64263987541199*x_74) - 2.08944256177151e-5*std::exp(1.78703987598419*x_74) - 4.34362856614021e-6*std::exp(1.80823993682861*x_74) - 0.000247874469109793*std::exp(0.836559891700745*x_78) + 0.00103453081695898*std::exp(0.914959847927094*x_78) - 0.000268565568979035*std::exp(1.47279977798462*x_81) + 1.87494736324803e-5*std::exp(1.6276798248291*x_81) + 5.76982711247059e-6*std::exp(1.77087986469269*x_81) + 0.000344924195598738*std::exp(1.93223989009857*x_81) - 3.29254921665993e-6*std::exp(2.02951979637146*x_81) - 0.000773537915552666*std::sin(0.38487982749939*x_10 - 7.40855979919434) - 0.000955218097146206*std::sin(0.309519857168198*x_101 - 7.45863962173462) + 0.00350778364444478*std::sin(0.521039843559265*x_104 - 1.01975977420807) + 0.00359741228987418*std::sin(0.301359832286835*x_105 - 1.27151989936829) - 0.0473797735253144*std::sin(0.375199824571609*x_105 - 7.41279983520508) + 0.000550592226488925*std::sin(0.41023987531662*x_105 + 5.21456003189087) + 0.000703875669775588*std::sin(0.537359833717346*x_109 + 2.17647981643677) - 0.00111652870885189*std::sin(0.45991986989975*x_111 - 4.37863969802856) + 0.000868425582104859*std::sin(0.482159852981567*x_111 + 8.4420804977417) - 0.000493112344158907*std::sin(0.476239860057831*x_112 + 2.20975995063782) - 0.314707491124756*std::sin(0.320559859275818*x_114 - 4.27320003509521) - 0.0310434320638137*std::sin(0.153680041432381*x_115 - 7.64736032485962) + 0.00157624814106728*std::sin(0.341359853744507*x_115 - 7.4410400390625) + 0.00100778460959797*std::sin(0.426559865474701*x_115 + 8.20335960388184) + 0.000910997171398855*std::sin(0.485759854316711*x_115 + 8.46312046051025) - 0.00290154686356174*std::sin(0.39455983042717*x_119 - 1.20143985748291) - 0.0152859347692553*std::sin(0.347039848566055*x_120 - 7.45527982711792) + 0.000454392302587254*std::sin(0.556639850139618*x_120 + 2.15871977806091) - 0.00304308836066896*std::sin(0.683679819107056*x_120 - 3.97000002861023) + 0.000310808323166456*std::sin(1.00343978404999*x_15 - 4.19184017181396) - 0.00133839121997866*std::sin(0.397839844226837*x_16 + 5.19200038909912) - 0.00192642530390298*std::sin(0.122640058398247*x_21 - 7.69304037094116) + 1.33786338241547*std::sin(0.22503998875618*x_24 - 4.36663961410522) + 0.00224882852205389*std::sin(0.373199820518494*x_24 - 4.21591997146606) + 0.00771103541977218*std::sin(0.205360010266304*x_27 + 1.81271994113922) - 0.0783707975671675*std::sin(0.129680052399635*x_31 + 1.61399984359741) - 0.0105408080097362*std::sin(0.255439966917038*x_33 + 8.20495986938477) - 0.00242324179058355*std::sin(0.303839921951294*x_34 + 2.04215979576111) - 0.00101737719680772*std::sin(0.359999865293503*x_34 + 8.20528030395508) - 0.00592777943496323*std::sin(0.363679856061935*x_34 - 1.19727993011475) + 0.00244647921065754*std::sin(0.304559946060181*x_35 - 4.34575986862183) - 0.000402624042268634*std::sin(0.309119910001755*x_35 + 5.06063985824585) + 0.00177047220834329*std::sin(0.317599833011627*x_35 - 7.43192005157471) + 0.0645732818015082*std::sin(0.320879846811295*x_35 + 1.97183978557587) - 0.000628429550542898*std::sin(0.328239858150482*x_35 - 7.43264007568359) + 0.0041219917561407*std::sin(0.341359823942184*x_35 - 7.42399978637695) - 0.00324612198119143*std::sin(0.338959842920303*x_36 + 5.15104007720947) - 0.00876377148409769*std::sin(0.395039856433868*x_36 + 5.19752025604248) + 0.0013782192465215*std::sin(0.416319847106934*x_36 - 4.18847990036011) + 0.00870555031080351*std::sin(0.425919860601425*x_36 - 7.38391971588135) - 0.00156892651017223*std::sin(0.457439839839935*x_36 - 4.15664005279541) + 0.000658765233886608*std::sin(0.237759977579117*x_37 + 5.03343963623047) + 2.52366566738445*std::sin(0.247599974274635*x_37 + 1.84727990627289) + 0.0262619932773561*std::sin(0.350959837436676*x_37 + 5.16936016082764) - 0.00233636631552147*std::sin(0.35471984744072*x_37 + 5.16247987747192) - 0.00194871944802104*std::sin(0.259999960660934*x_40 - 1.3530398607254) + 0.00134480389284072*std::sin(0.302799940109253*x_41 - 7.49200010299683) + 0.00640791649254099*std::sin(0.352559834718704*x_43 - 4.44127988815308) - 2.30999305576342*std::sin(0.225919991731644*x_45 - 7.56376028060913) + 0.00236219862810669*std::sin(0.283919870853424*x_47 - 1.28175985813141) - 1.89914294950005*std::sin(0.200479999184608*x_53 + 5.00799989700317) - 0.0200539218785789*std::sin(0.325919836759567*x_53 - 4.27960014343262) + 0.00124657427639556*std::sin(0.489439845085144*x_53 + 8.49272060394287) - 0.00252799316059488*std::sin(0.362639844417572*x_55 + 5.16312026977539) - 0.000800516739869409*std::sin(0.516959846019745*x_57 - 4.06511974334717) - 0.00172212766852754*std::sin(0.375039845705032*x_58 - 4.22424030303955) + 0.00191714593753728*std::sin(0.437199860811234*x_58 + 5.21896028518677) - 0.0028848366750347*std::sin(0.261599957942963*x_59 + 1.86455988883972) + 0.0156465206734743*std::sin(0.281519949436188*x_63 + 1.87871992588043) - 0.00436041797321381*std::sin(0.307359933853149*x_64 - 7.48880004882813) + 0.000119045454286906*std::sin(0.521279871463776*x_65 - 0.857679903507233) - 0.00347174581954393*std::sin(0.837119877338409*x_73 - 7.18088006973267) + 0.0138202976324001*std::sin(0.279839843511581*x_75 + 8.11103916168213) + 0.0190031115942181*std::sin(0.463439851999283*x_75 + 8.23503971099854) - 0.00137923097133377*std::sin(0.480639845132828*x_75 - 1.13143992424011) - 0.000987370797336149*std::sin(0.486399859189987*x_75 - 1.11623990535736) - 0.00237485973523453*std::sin(0.545119881629944*x_75 + 5.16215991973877) + 0.00145472368121861*std::sin(0.5065598487854*x_76 + 8.50568008422852) - 0.00151375265036919*std::sin(0.272239863872528*x_79 - 1.29615986347198) - 0.402002159836142*std::sin(0.371999859809875*x_80 + 8.36744022369385) - 0.076200503042824*std::sin(0.34487983584404*x_83 - 7.46303987503052) - 0.00386386576045347*std::sin(0.226559981703758*x_84 - 7.58008003234863) - 0.0817776336354745*std::sin(0.261679977178574*x_84 + 1.87495994567871) - 0.0228736573320911*std::sin(0.291039943695068*x_87 - 7.48808002471924) - 0.00567764508893445*std::sin(0.934719800949097*x_87 - 3.82536005973816) - 0.000132156244871839*std::sin(1.00263977050781*x_87 - 6.9900803565979) + 0.00480621909980078*std::sin(0.23047998547554*x_92 + 4.82000017166138) - 0.0129969898317509*std::sin(0.331599831581116*x_92 - 7.40279960632324) - 0.00136863668011852*std::sin(0.354319840669632*x_92 + 1.98751986026764) - 0.000935562484311182*std::sin(0.354399859905243*x_92 + 8.18423938751221) + 0.00262982140960484*std::sin(0.359759837388992*x_92 + 1.99959981441498) - 0.000758560303033483*std::sin(0.37271985411644*x_92 - 4.39192008972168) - 0.00230929764910435*std::sin(0.416239857673645*x_92 - 7.59040021896362) + 0.0097868248540107*std::sin(0.465199857950211*x_92 - 4.61639976501465) + 0.000755900382751714*std::sin(0.372799843549728*x_94 - 1.18511986732483) - 0.865646507471366*std::sin(0.319919854402542*x_95 + 1.95463979244232) - 0.00125024289234269*std::sin(0.341439843177795*x_95 - 7.4334397315979) - 0.00268074859592991*std::sin(0.348559856414795*x_95 - 1.22079980373383) + 0.000766079259520564*std::sin(0.417919874191284*x_95 + 5.20168018341064) + 0.869349865008908*std::sin(0.375199824571609*x_96 - 4.21479988098145) - 0.00859110368360134*std::sin(0.406559854745865*x_96 - 7.38735961914063) - 0.000427698399769974*std::sin(0.343359857797623*x_97 - 4.42447996139526) - 0.0492227733951078*std::sin(0.309119910001755*x_98 - 4.29047966003418) + 0.623799206446566*std::sin(0.387199848890305*x_98 - 1.18119990825653) + 0.000820014177217418*std::sin(0.442879855632782*x_98 + 2.03743982315063) + 0.00196348432870286*std::sin(0.443519860506058*x_98 + 2.00271987915039) + 1.16895066754272*std::sin(0.326079845428467*x_99 + 1.93167984485626) - 6.61572895728742 - 9.06978390256369e-5*std::exp(-1.33871984481812*x_9) + 0.000113425340759279*std::exp(-1.31719982624054*x_9) + 8.20758841459283e-5*std::exp(-1.29767978191376*x_9) + 2.43588547842761e-5*std::exp(-1.27743983268738*x_9) + 4.16907664917758e-7*std::exp(-2.84623980522156*x_79) - 8.55003421401172e-6*std::exp(-1.95879983901978*x_30));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0496200705956834*x_1 + 0.0147266680235226*x_10 + 0.00684465676412944*x_100 - 0.0634315710394242*x_101 - 0.00171482796538558*x_102 - 0.0631870191989077*x_103 - 0.000141404879075791*x_104 + 0.00337434806813156*x_105 - 0.0028423657691109*x_106 + 0.089942175986997*x_107 + 0.000455610334388572*x_108 + 0.00572964645428932*x_109 + 0.129778719265877*x_11 + 0.00906826383901841*x_110 + 0.0114599271291264*x_111 + 0.0988107234248841*x_112 - 0.0135835011381937*x_113 + 0.00207056015436991*x_114 - 0.0201591116582594*x_115 - 0.0677061976396828*x_116 + 0.0230920794585487*x_117 + 0.0245785882312612*x_118 - 0.0330701166127224*x_119 - 0.0484706774241926*x_12 + 0.0144006335502145*x_120 + 0.0536108148640802*x_13 - 0.00295126020533873*x_14 + 0.00219701694779775*x_15 + 0.0243872532053314*x_16 + 0.0112177516823146*x_17 - 0.0204886957390739*x_18 + 0.0368297002348379*x_19 + 0.0505170890972984*x_2 - 0.0815635061357055*x_20 - 0.0197643239065002*x_21 - 0.00894107375840422*x_22 - 0.101029044277298*x_23 + 0.00171842412224233*x_24 - 0.136429117430733*x_25 + 0.000422713689770161*x_26 - 0.0013367756110519*x_27 + 0.0631264474358253*x_28 + 0.0606981646737494*x_29 + 0.120240334813023*x_3 + 0.123686288071836*x_30 + 0.000203721743291529*x_31 + 0.182253401687522*x_32 + 0.0282746529882119*x_33 + 0.0552179688419926*x_34 - 0.00621157334143287*x_35 - 0.0189518398776288*x_36 + 0.00737413714156947*x_37 + 0.129040139043915*x_38 + 0.0241124487790811*x_39 - 0.0365225435980982*x_4 + 0.00115767448108954*x_40 + 0.114402843418907*x_41 - 0.114671961158753*x_42 - 0.0133714943357498*x_43 + 0.281082049687333*x_44 - 0.00186554102742838*x_45 - 0.0959766649049198*x_46 + 0.0230579318664378*x_47 - 0.00452065660394396*x_48 - 0.0060390877286685*x_49 - 0.0109064853332437*x_5 + 0.00112280743421881*x_50 + 0.0168847185801142*x_51 + 0.0830359411152245*x_52 - 0.00122843749188499*x_53 + 0.137153920384222*x_54 + 0.0743722103632921*x_55 + 0.023327298773196*x_56 + 0.00875181718962044*x_57 - 0.0613709192572521*x_58 + 0.0956392546926838*x_59 + 0.0441160358479373*x_6 + 0.0222385242251288*x_60 - 0.102528673936559*x_61 + 0.14105116321262*x_62 - 0.108860824387352*x_63 + 0.0200874191514056*x_64 - 0.0243394513423018*x_65 - 0.00178350889727094*x_66 - 0.0483510685261538*x_67 - 0.00653923373309338*x_68 - 0.0662371230171806*x_69 + 0.072395015231485*x_7 - 0.00277688933372883*x_70 + 0.00807973526335589*x_71 + 0.0181275334562485*x_72 + 0.0754929461713203*x_73 + 0.0641533461393676*x_74 + 0.00443813944314278*x_75 - 0.0165836478047255*x_76 + 0.0889644046171957*x_77 - 0.046506057158039*x_78 + 0.0350585181356729*x_79 + 0.217125165892513*x_8 - 0.0044180384627358*x_80 + 0.00432873405871339*x_81 - 0.0200298072724166*x_82 + 0.0917866776405433*x_83 + 0.00135802350900162*x_84 - 0.054065767059926*x_85 + 0.0213004478736685*x_86 + 0.057823517699868*x_87 - 0.0309356649438703*x_88 + 0.0570462757112755*x_89 - 0.00881946872926298*x_9 + 0.0268327126414175*x_90 - 0.0199204727318083*x_91 - 0.0412418712748893*x_92 + 0.259576100782775*x_93 + 0.0523767402248885*x_94 - 0.00229278466493597*x_95 - 0.00516549950757538*x_96 + 0.0257116988858739*x_97 + 0.0093143635150499*x_98 + 0.000931403342025467*x_99 - 0.000408730244291553*std::pow(-9.94719982147217*x_102 - 9.78800010681152, 2) + 0.000650689510794967*std::pow(-7.96016025543213*x_104 - 9.15664005279541, 2) - 0.000727412840512015*std::pow(-6.34000015258789*x_108 - 9.19999980926514, 2) - 1.31870878189995e-5*std::pow(-7.53336048126221*x_110 - 9.12399959564209, 2) + 2.34436299056249e-7*std::pow(-6.82224035263062*x_112 - 7.22352027893066, 2) - 1.48637226132509e-5*std::pow(-8.39915943145752*x_114 - 7.57599973678589, 2) + 3.62484006502212e-6*std::pow(-7.7480001449585*x_115 - 7.5417594909668, 2) + 9.43152446371137e-5*std::pow(-4.07359981536865*x_13 - 6.10303974151611, 2) + 2.80833438981166e-6*std::pow(-6.60400009155273*x_14 - 9.97567939758301, 2) + 4.32163999475582e-6*std::pow(-8.70680046081543*x_15 - 9.9235200881958, 2) + 7.86618866959715e-5*std::pow(-4.7579197883606*x_15 - 6.15079975128174, 2) - 4.17587752952339e-5*std::pow(-4.46928024291992*x_15 - 5.25055980682373, 2) - 4.4405688955501e-5*std::pow(-4.34728002548218*x_24 - 5.5318398475647, 2) + 3.70553749426062e-6*std::pow(-7.32087993621826*x_27 - 8.55039978027344, 2) + 1.21230618489875e-6*std::pow(-5.54271984100342*x_36 - 6.56727981567383, 2) - 4.54616190081543e-7*std::pow(-9.39496040344238*x_39 - 8.79872035980225, 2) - 4.50260020486068e-5*std::pow(-4.88320016860962*x_4 - 8.13959980010986, 2) - 2.88468488937516e-7*std::pow(-5.77159976959229*x_47 - 3.50111985206604, 2) - 7.54009961660084e-6*std::pow(-6.14759969711304*x_53 - 5.93872022628784, 2) + 9.94674618100449e-7*std::pow(-5.93631982803345*x_57 - 7.71104001998901, 2) - 0.00139905990618086*std::pow(-4.32000017166138*x_57 - 6.7828803062439, 2) + 2.26469261129335e-5*std::pow(-5.4871997833252*x_6 - 8.73799991607666, 2) - 1.84737404203373e-5*std::pow(-8.86295986175537*x_67 - 9.87448024749756, 2) + 5.94302948066953e-6*std::pow(-6.9117603302002*x_70 - 9.48536014556885, 2) + 0.000681609553329514*std::pow(-5.01503992080688*x_70 - 7.41752004623413, 2) + 0.000120536878624576*std::pow(-4.91472005844116*x_70 - 6.55808019638062, 2) - 3.75173999829545e-6*std::pow(-6.60000038146973*x_72 - 9.96523952484131, 2) - 3.79127639866761e-5*std::pow(-5.69008016586304*x_73 - 7.72512006759644, 2) - 1.76627746537425e-5*std::pow(-5.29624032974243*x_75 - 7.53200006484985, 2) + 9.3611642506042e-6*std::pow(-9.12207984924316*x_81 - 9.71424007415771, 2) + 3.94259886499157e-5*std::pow(-7.73016023635864*x_82 - 8.14496040344238, 2) - 0.000260723073336095*std::pow(-9.88728046417236*x_84 - 8.88064002990723, 2) - 0.000571711679285792*std::pow(-1.53071987628937*x_86 - 2.10567998886108, 2) + 4.90387686503052e-6*std::pow(-9.37191963195801*x_89 - 9.57999992370605, 2) + 9.98356968600219e-7*std::pow(-6.53375959396362*x_90 - 6.33328008651733, 2) - 8.60971834020009e-7*std::pow(-7.40248012542725*x_97 - 5.45391988754272, 2) + 3.20934158990275e-5*std::exp(1.01567983627319*x_1) - 7.41162117330054e-5*std::exp(1.11351990699768*x_1) - 4.55956855102964e-5*std::exp(1.14375984668732*x_1) - 1.76664334676234e-5*std::exp(1.20751988887787*x_1) + 3.71169713584732e-5*std::exp(1.21103978157043*x_1) + 6.65704980614167e-7*std::exp(1.25095987319946*x_1) - 0.000121009975418839*std::exp(1.2611198425293*x_1) - 3.39162807936462e-6*std::exp(1.30063986778259*x_1) + 4.07169068511574e-6*std::exp(1.32463979721069*x_1) - 1.86295011428196e-5*std::exp(1.35039985179901*x_1) - 4.37954551270151e-7*std::exp(1.37815976142883*x_1) + 5.80838274528158e-6*std::exp(1.6387197971344*x_100) + 4.97820897901166e-5*std::exp(1.64639985561371*x_100) - 0.000213210436826416*std::exp(1.64719986915588*x_100) + 0.000507862460939643*std::exp(1.6736798286438*x_100) - 0.000125711063764927*std::exp(1.71871984004974*x_100) + 0.000142163142540983*std::exp(1.7293598651886*x_100) - 2.0991845005447e-6*std::exp(1.82271993160248*x_100) - 0.00691095189635978*std::exp(0.659519851207733*x_104) + 0.000459155966874623*std::exp(0.859919905662537*x_104) - 0.000899126505919714*std::exp(0.884479880332947*x_104) - 0.000292905108825177*std::exp(1.06447982788086*x_104) - 0.000170492522262031*std::exp(1.13271987438202*x_104) - 1.40336245844125e-5*std::exp(1.14023983478546*x_104) + 0.00113780899921487*std::exp(0.803759872913361*x_106) + 0.000899184936762078*std::exp(0.869199872016907*x_106) + 0.0363884722538675*std::exp(1.24255990982056*x_106) - 0.00196071999533645*std::exp(0.543359875679016*x_108) + 0.000872478563994887*std::exp(0.810959875583649*x_109) - 0.0481292448782693*std::exp(1.05311989784241*x_109) + 0.000171538834209062*std::exp(1.09655976295471*x_109) + 0.00680795365525849*std::exp(0.613439857959747*x_110) + 0.000120561732953279*std::exp(1.4670398235321*x_110) - 8.06331113619624e-5*std::exp(1.47447991371155*x_110) - 8.79395166185791e-5*std::exp(1.51207983493805*x_110) + 4.77031112214144e-6*std::exp(1.52231991291046*x_110) + 2.4071831335909e-5*std::exp(1.54567980766296*x_110) - 1.277594931975e-5*std::exp(1.62999987602234*x_110) - 5.17295927378441e-7*std::exp(1.70063984394073*x_110) - 3.79871144655915e-5*std::exp(1.7707998752594*x_110) + 0.00016142180886469*std::exp(0.520319879055023*x_112) + 0.00165803895846058*std::exp(0.539999842643738*x_112) + 0.000617756988854386*std::exp(0.687439858913422*x_112) - 0.00324931058251433*std::exp(0.755039870738983*x_112) + 4.76728415089083e-5*std::exp(0.784239888191223*x_112) - 1.50511066742094e-5*std::exp(1.93039989471436*x_19) - 3.02454272331917e-6*std::exp(1.56215977668762*x_23) + 2.80905575327692e-5*std::exp(2.14359974861145*x_23) + 0.00652059376746247*std::exp(0.799119830131531*x_26) + 0.0532382903143203*std::exp(0.807999849319458*x_26) + 9.01107430073377e-5*std::exp(0.858239889144897*x_26) + 5.60814044769743e-6*std::exp(1.01599979400635*x_26) - 0.000339938798222612*std::exp(1.09751987457275*x_26) + 0.000170237642128815*std::exp(1.21999990940094*x_26) + 2.77120677002527e-6*std::exp(1.22783982753754*x_26) - 6.27044036657674e-5*std::exp(1.26031982898712*x_26) - 1.40790203801036e-5*std::exp(1.3005598783493*x_26) + 2.95288390328392e-6*std::exp(1.30919981002808*x_26) + 0.000116176662644105*std::exp(1.40287983417511*x_26) + 6.64370865951416e-7*std::exp(1.43151986598969*x_26) - 0.00334959037495639*std::exp(0.481919854879379*x_31) + 0.063672441048881*std::exp(0.533999860286713*x_31) + 0.000899895393605551*std::exp(0.613279819488525*x_31) - 0.00850017959666425*std::exp(0.624479830265045*x_31) - 0.00610011032008413*std::exp(0.631679832935333*x_31) + 0.00127488615343044*std::exp(0.63375985622406*x_31) - 0.00199029989172389*std::exp(0.642559826374054*x_31) + 0.00113697103118022*std::exp(0.643519818782806*x_31) + 0.0117406865629865*std::exp(0.653599858283997*x_31) - 0.000120024262450288*std::exp(0.653999865055084*x_31) + 0.00849749878435957*std::exp(0.658079862594604*x_31) + 0.000148031689542014*std::exp(0.669439852237701*x_31) + 0.000699075842148304*std::exp(0.889039874076843*x_45) + 3.02508606429529e-5*std::exp(1.03455984592438*x_45) - 0.000186774383299943*std::exp(1.16495990753174*x_45) - 0.00127067970423129*std::exp(0.592399835586548*x_49) + 6.38984251138639e-5*std::exp(0.920399844646454*x_49) + 0.000555036758722675*std::exp(1.16799986362457*x_50) + 9.72517769681747e-6*std::exp(1.40543985366821*x_50) - 0.000668694116757679*std::exp(1.40831983089447*x_50) - 7.77548476566263e-7*std::exp(2.2727198600769*x_50) + 0.000566091498866764*std::exp(1.14879977703094*x_6) + 1.09163393714921e-6*std::exp(1.83743989467621*x_6) - 5.31387582223561e-5*std::exp(2.31103992462158*x_6) + 7.94986693979331e-6*std::exp(2.35487985610962*x_6) - 1.16944438284792e-6*std::exp(2.37303996086121*x_6) + 1.83590487672047e-5*std::exp(0.849839866161346*x_60) + 0.00301280247823988*std::exp(1.153599858284*x_60) + 0.000294305125468096*std::exp(1.47215986251831*x_60) + 6.49858261207419e-5*std::exp(0.834719896316528*x_66) - 0.00314299560577941*std::exp(0.882879853248596*x_66) + 0.0011629149394079*std::exp(1.08591985702515*x_66) - 3.1779220472006e-5*std::exp(1.20335984230042*x_66) + 0.000632287950016212*std::exp(1.46271991729736*x_66) + 0.000716496218667559*std::exp(1.46623992919922*x_66) + 0.00116834230908207*std::exp(0.759039878845215*x_68) + 5.76519759136241e-5*std::exp(1.16567981243134*x_68) + 0.00027315207177115*std::exp(1.29567980766296*x_68) + 0.000198919181692443*std::exp(1.29711985588074*x_68) + 0.00147510439333777*std::exp(1.39703989028931*x_68) + 0.00153450140991148*std::exp(0.700399875640869*x_70) + 0.00136856159204546*std::exp(0.794639885425568*x_70) + 2.86294419399322e-5*std::exp(1.14799988269806*x_70) + 0.000710772200601022*std::exp(1.35863983631134*x_72) - 0.0035876039001205*std::exp(0.845839858055115*x_74) + 0.00121136402689202*std::exp(0.96727979183197*x_74) + 0.00114094756960637*std::exp(1.12551987171173*x_74) + 6.28201298515051e-5*std::exp(1.40063989162445*x_74) + 0.000300493437537556*std::exp(1.43639981746674*x_74) + 3.27982091402063e-6*std::exp(1.64263987541199*x_74) + 2.55144797836611e-5*std::exp(1.78703987598419*x_74) + 1.40294746346881e-6*std::exp(1.80823993682861*x_74) + 0.000571110482622759*std::exp(0.836559891700745*x_78) - 0.00126328026899649*std::exp(0.914959847927094*x_78) - 0.000889412837051708*std::exp(1.47279977798462*x_81) - 3.28061811933856e-5*std::exp(1.6276798248291*x_81) + 5.67454638490699e-5*std::exp(1.77087986469269*x_81) + 0.000215256594074304*std::exp(1.93223989009857*x_81) + 8.2068596029462e-6*std::exp(2.02951979637146*x_81) - 0.00760764005008173*std::sin(0.38487982749939*x_10 - 7.40855979919434) + 0.000273963316111768*std::sin(0.309519857168198*x_101 - 7.45863962173462) - 0.00808204256497158*std::sin(0.521039843559265*x_104 - 1.01975977420807) - 0.00629443587176118*std::sin(0.301359832286835*x_105 - 1.27151989936829) - 0.0295682611055087*std::sin(0.375199824571609*x_105 - 7.41279983520508) + 0.00541499956147351*std::sin(0.41023987531662*x_105 + 5.21456003189087) - 0.00123157978793983*std::sin(0.537359833717346*x_109 + 2.17647981643677) + 0.00195360381033622*std::sin(0.45991986989975*x_111 - 4.37863969802856) - 0.00024907060804285*std::sin(0.482159852981567*x_111 + 8.4420804977417) - 0.00484969274703585*std::sin(0.476239860057831*x_112 + 2.20975995063782) - 0.217922885481638*std::sin(0.320559859275818*x_114 - 4.27320003509521) + 0.134763313892615*std::sin(0.153680041432381*x_115 - 7.64736032485962) - 0.000452079131490435*std::sin(0.341359853744507*x_115 - 7.4410400390625) - 0.000217577181631848*std::sin(0.426559865474701*x_115 + 8.20335960388184) - 0.00227071044117477*std::sin(0.485759854316711*x_115 + 8.46312046051025) + 0.00668525417544033*std::sin(0.39455983042717*x_119 - 1.20143985748291) - 0.00953948229105882*std::sin(0.347039848566055*x_120 - 7.45527982711792) + 0.000331560166501209*std::sin(0.556639850139618*x_120 + 2.15871977806091) + 0.0070113701849445*std::sin(0.683679819107056*x_120 - 3.97000002861023) + 0.00102930883336107*std::sin(1.00343978404999*x_15 - 4.19184017181396) + 0.00234179933425939*std::sin(0.397839844226837*x_16 + 5.19200038909912) - 0.0189461305009106*std::sin(0.122640058398247*x_21 - 7.69304037094116) + 0.926419157148779*std::sin(0.22503998875618*x_24 - 4.36663961410522) - 0.00393480251304495*std::sin(0.373199820518494*x_24 - 4.21591997146606) - 0.0177664653238517*std::sin(0.205360010266304*x_27 + 1.81271994113922) + 0.180568753945734*std::sin(0.129680052399635*x_31 + 1.61399984359741) + 0.0242863493416413*std::sin(0.255439966917038*x_33 + 8.20495986938477) + 0.000782682237144371*std::sin(0.303839921951294*x_34 + 2.04215979576111) + 0.000291790986170225*std::sin(0.359999865293503*x_34 + 8.20528030395508) + 0.00127978690139855*std::sin(0.363679856061935*x_34 - 1.19727993011475) - 0.00428063431773604*std::sin(0.304559946060181*x_35 - 4.34575986862183) - 0.00395975262169307*std::sin(0.309119910001755*x_35 + 5.06063985824585) - 0.00441299913491689*std::sin(0.317599833011627*x_35 - 7.43192005157471) + 0.0558926869485527*std::sin(0.320879846811295*x_35 + 1.97183978557587) + 0.00706511748268602*std::sin(0.328239858150482*x_35 - 7.43264007568359) - 0.00949719714850434*std::sin(0.341359823942184*x_35 - 7.42399978637695) + 0.00567977896223801*std::sin(0.338959842920303*x_36 + 5.15104007720947) + 0.0380445978062876*std::sin(0.395039856433868*x_36 + 5.19752025604248) - 0.000395283041887659*std::sin(0.416319847106934*x_36 - 4.18847990036011) - 0.010630471087098*std::sin(0.425919860601425*x_36 - 7.38391971588135) + 0.0176386519483232*std::sin(0.457439839839935*x_36 - 4.15664005279541) + 0.000480686643213349*std::sin(0.237759977579117*x_37 + 5.03343963623047) + 1.74754182768832*std::sin(0.247599974274635*x_37 + 1.84727990627289) + 0.0227315900314358*std::sin(0.350959837436676*x_37 + 5.16936016082764) + 0.000670086407873119*std::sin(0.35471984744072*x_37 + 5.16247987747192) - 0.0191653903720362*std::sin(0.259999960660934*x_40 - 1.3530398607254) + 0.0132259631350731*std::sin(0.302799940109253*x_41 - 7.49200010299683) - 0.0147640388048211*std::sin(0.352559834718704*x_43 - 4.44127988815308) - 1.59958172700424*std::sin(0.225919991731644*x_45 - 7.56376028060913) - 0.00413316756125828*std::sin(0.283919870853424*x_47 - 1.28175985813141) - 1.31508376244242*std::sin(0.200479999184608*x_53 + 5.00799989700317) - 0.0125150365688955*std::sin(0.325919836759567*x_53 - 4.27960014343262) - 0.00218114611556893*std::sin(0.489439845085144*x_53 + 8.49272060394287) + 0.00442326026360795*std::sin(0.362639844417572*x_55 + 5.16312026977539) + 0.00199533190291412*std::sin(0.516959846019745*x_57 - 4.06511974334717) + 0.0193610155471208*std::sin(0.375039845705032*x_58 - 4.22424030303955) - 0.00335445347607293*std::sin(0.437199860811234*x_58 + 5.21896028518677) + 0.00504763368452989*std::sin(0.261599957942963*x_59 + 1.86455988883972) - 0.0679234490732937*std::sin(0.281519949436188*x_63 + 1.87871992588043) + 0.00532456829689308*std::sin(0.307359933853149*x_64 - 7.48880004882813) - 0.00133836819034071*std::sin(0.521279871463776*x_65 - 0.857679903507233) - 0.00216660991064862*std::sin(0.837119877338409*x_73 - 7.18088006973267) - 0.016876161661371*std::sin(0.279839843511581*x_75 + 8.11103916168213) + 0.0164485207775089*std::sin(0.463439851999283*x_75 + 8.23503971099854) + 0.00241325714204166*std::sin(0.480639845132828*x_75 - 1.13143992424011) + 0.000283184938265181*std::sin(0.486399859189987*x_75 - 1.11623990535736) + 0.00051272393231865*std::sin(0.545119881629944*x_75 + 5.16215991973877) + 0.00481763139391838*std::sin(0.5065598487854*x_76 + 8.50568008422852) - 0.0148875511559614*std::sin(0.272239863872528*x_79 - 1.29615986347198) - 0.278371100504291*std::sin(0.371999859809875*x_80 + 8.36744022369385) - 0.0475543929972042*std::sin(0.34487983584404*x_83 - 7.46303987503052) + 0.00110818406802287*std::sin(0.226559981703758*x_84 - 7.58008003234863) - 0.0510349088653289*std::sin(0.261679977178574*x_84 + 1.87495994567871) - 0.0197987485375286*std::sin(0.291039943695068*x_87 - 7.48808002471924) - 0.00354324387735471*std::sin(0.934719800949097*x_87 - 3.82536005973816) + 3.79033470975229e-5*std::sin(1.00263977050781*x_87 - 6.9900803565979) - 0.00586894238211287*std::sin(0.23047998547554*x_92 + 4.82000017166138) + 0.0564215134703824*std::sin(0.331599831581116*x_92 - 7.40279960632324) + 0.00341140202987441*std::sin(0.354319840669632*x_92 + 1.98751986026764) - 0.0092011296174339*std::sin(0.354399859905243*x_92 + 8.18423938751221) - 0.00460143038470613*std::sin(0.359759837388992*x_92 + 1.99959981441498) + 0.00852811210740102*std::sin(0.37271985411644*x_92 - 4.39192008972168) + 0.00532069357379205*std::sin(0.416239857673645*x_92 - 7.59040021896362) + 0.00847118068843078*std::sin(0.465199857950211*x_92 - 4.61639976501465) + 0.000551564045729757*std::sin(0.372799843549728*x_94 - 1.18511986732483) - 0.599427055393733*std::sin(0.319919854402542*x_95 + 1.95463979244232) - 0.000912275008163226*std::sin(0.341439843177795*x_95 - 7.4334397315979) + 0.00469053829968008*std::sin(0.348559856414795*x_95 - 1.22079980373383) + 0.00753428518381243*std::sin(0.417919874191284*x_95 + 5.20168018341064) + 0.60199148866371*std::sin(0.375199824571609*x_96 - 4.21479988098145) + 0.0372950258855797*std::sin(0.406559854745865*x_96 - 7.38735961914063) + 0.00480839807568121*std::sin(0.343359857797623*x_97 - 4.42447996139526) - 0.042605749426972*std::sin(0.309119910001755*x_98 - 4.29047966003418) + 0.431957061282987*std::sin(0.387199848890305*x_98 - 1.18119990825653) - 0.000235185874221101*std::sin(0.442879855632782*x_98 + 2.03743982315063) - 0.00343553232055602*std::sin(0.443519860506058*x_98 + 2.00271987915039) + 0.809453570825903*std::sin(0.326079845428467*x_99 + 1.93167984485626) - 4.42810340795213 + 0.000208970640682761*std::exp(-1.33871984481812*x_9) + 0.00037563249266008*std::exp(-1.31719982624054*x_9) - 1.77198970715946e-5*std::exp(-1.29767978191376*x_9) + 0.000239566019331559*std::exp(-1.27743983268738*x_9) - 1.34656898510275e-7*std::exp(-2.84623980522156*x_79) - 7.40065197850933e-6*std::exp(-1.95879983901978*x_30));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00509034519270446*x_1 + 0.00347945339043568*x_10 - 0.00204727801998655*x_100 - 0.00782306464699044*x_101 - 0.000209801900683762*x_102 - 0.00733529601518034*x_103 - 0.000304813303073633*x_104 - 0.00200340750901805*x_105 + 0.00115652969350433*x_106 + 0.00963171744804291*x_107 - 0.00874168561122638*x_108 - 0.00555101515355892*x_109 + 0.0135625921576536*x_11 + 0.000837401168359852*x_110 - 0.000404593272753349*x_111 + 0.0103042070982295*x_112 + 0.00233301599484311*x_113 + 0.00308294878442765*x_114 - 0.00156410323872027*x_115 - 0.00100781104592837*x_116 + 0.00418486220594215*x_117 + 0.000439295167529205*x_118 - 0.00227204795287112*x_119 - 0.00188879749671509*x_12 - 0.00339503430133829*x_120 + 0.00681852990638865*x_13 - 0.00293910866792973*x_14 - 0.00239871029129702*x_15 + 0.00895525809933571*x_16 + 0.00187712751965215*x_17 - 0.000789896491188244*x_18 - 4.09231467606397e-5*x_19 + 0.00312417225690272*x_2 - 0.0141465956745931*x_20 - 0.00317572664454886*x_21 + 0.0116941948054901*x_22 - 0.0099691925274013*x_23 + 0.00205240342429686*x_24 - 0.014395280327978*x_25 - 0.00111817615135566*x_26 - 0.00486944989124112*x_27 + 0.00436914809247059*x_28 + 0.00943521756363516*x_29 + 0.0110173115584711*x_3 + 0.0120101485812119*x_30 - 0.00133195586024879*x_31 + 0.00294875680209291*x_32 + 0.00865614335859836*x_33 - 0.0101949983341265*x_34 - 0.0024010576196982*x_35 - 0.00891391965890753*x_36 + 0.00173936683407217*x_37 + 0.0138554770159187*x_38 - 0.000543407524826564*x_39 + 0.00194149815116741*x_4 - 0.00159806328544443*x_40 + 0.0145524079412712*x_41 - 0.0183201933990201*x_42 + 0.000434731793649304*x_43 + 0.0241960560253453*x_44 + 4.54563533299756e-5*x_45 - 0.0136284798580617*x_46 + 0.00368880110878506*x_47 + 0.00487605007543114*x_48 + 0.000185116011816745*x_49 + 0.00128729575053153*x_5 + 0.00117941499055338*x_50 + 0.000582341147487931*x_51 + 0.00895372301423502*x_52 - 0.00247681022610188*x_53 + 0.0140586142317327*x_54 + 0.00690488257032149*x_55 - 0.0017298430505113*x_56 - 0.00342309667083975*x_57 - 0.00201810231196118*x_58 + 0.00406588242419207*x_59 + 0.00409656076968138*x_6 + 0.00327499955884602*x_60 - 0.0125591028250495*x_61 + 0.0100627128637744*x_62 - 0.0117180516547649*x_63 - 0.000680624687966069*x_64 - 0.000827451180831853*x_65 - 0.00012788071496774*x_66 - 0.0116175301022182*x_67 + 0.00237596279673683*x_68 - 0.00742053208294014*x_69 + 0.005590662716315*x_7 + 0.00116460021368615*x_70 - 0.000617465397825378*x_71 + 0.00351071651043938*x_72 + 0.00138435070067703*x_73 + 0.01264604625072*x_74 + 0.00203591847253158*x_75 - 0.00227388515921524*x_76 + 0.00724381705427061*x_77 + 0.00130136263650685*x_78 + 0.00189473249116942*x_79 + 0.0189262201672726*x_8 + 0.00198060368050261*x_80 + 0.000311485904347503*x_81 - 0.00253574855023384*x_82 + 0.0106379862668826*x_83 - 0.00239116643021909*x_84 - 0.00323596795310209*x_85 + 0.000933997360704003*x_86 + 0.00596837683096221*x_87 - 0.0031797311467654*x_88 + 0.0113398213581194*x_89 - 0.00397162215178171*x_9 - 0.000754796452201198*x_90 + 0.0110756328575834*x_91 - 0.00449512401373514*x_92 + 0.0190637742836314*x_93 - 0.00200303969861099*x_94 + 0.00724152865731288*x_95 - 0.00331490152643139*x_96 + 0.00287163392948814*x_97 - 0.00574714952587511*x_98 + 0.00141315825046781*x_99 - 3.89615827925607e-5*std::pow(-9.94719982147217*x_102 - 9.78800010681152, 2) + 6.20259782611171e-5*std::pow(-7.96016025543213*x_104 - 9.15664005279541, 2) - 6.93395118315847e-5*std::pow(-6.34000015258789*x_108 - 9.19999980926514, 2) - 3.17273486267851e-5*std::pow(-7.53336048126221*x_110 - 9.12399959564209, 2) - 1.22805029718245e-6*std::pow(-6.82224035263062*x_112 - 7.22352027893066, 2) + 2.68046808823997e-6*std::pow(-8.39915943145752*x_114 - 7.57599973678589, 2) - 8.40643804621175e-6*std::pow(-7.7480001449585*x_115 - 7.5417594909668, 2) - 4.48050323841284e-5*std::pow(-4.07359981536865*x_13 - 6.10303974151611, 2) + 3.40786069747575e-6*std::pow(-6.60400009155273*x_14 - 9.97567939758301, 2) + 5.24422844380557e-6*std::pow(-8.70680046081543*x_15 - 9.9235200881958, 2) + 4.81993456153133e-6*std::pow(-4.7579197883606*x_15 - 6.15079975128174, 2) - 0.000100469128605529*std::pow(-4.46928024291992*x_15 - 5.25055980682373, 2) + 3.0031436042699e-5*std::pow(-4.34728002548218*x_24 - 5.5318398475647, 2) + 4.49659970533653e-6*std::pow(-7.32087993621826*x_27 - 8.55039978027344, 2) - 5.88174888370546e-6*std::pow(-5.54271984100342*x_36 - 6.56727981567383, 2) + 2.20566248183405e-6*std::pow(-9.39496040344238*x_39 - 8.79872035980225, 2) + 1.91451367774646e-5*std::pow(-4.88320016860962*x_4 - 8.13959980010986, 2) + 3.72656245212142e-7*std::pow(-5.77159976959229*x_47 - 3.50111985206604, 2) - 1.81410310221725e-5*std::pow(-6.14759969711304*x_53 - 5.93872022628784, 2) - 1.13987182028813e-6*std::pow(-5.93631982803345*x_57 - 7.71104001998901, 2) - 0.000133363236823589*std::pow(-4.32000017166138*x_57 - 6.7828803062439, 2) - 9.62951357647047e-6*std::pow(-5.4871997833252*x_6 - 8.73799991607666, 2) - 1.1319614068868e-6*std::pow(-8.86295986175537*x_67 - 9.87448024749756, 2) + 7.21175393663561e-6*std::pow(-6.9117603302002*x_70 - 9.48536014556885, 2) + 6.4973383827464e-5*std::pow(-5.01503992080688*x_70 - 7.41752004623413, 2) - 5.72617795886063e-5*std::pow(-4.91472005844116*x_70 - 6.55808019638062, 2) - 4.55266557063963e-6*std::pow(-6.60000038146973*x_72 - 9.96523952484131, 2) + 2.56402900990631e-5*std::pow(-5.69008016586304*x_73 - 7.72512006759644, 2) - 4.24955848362695e-5*std::pow(-5.29624032974243*x_75 - 7.53200006484985, 2) + 2.25224041735433e-5*std::pow(-9.12207984924316*x_81 - 9.71424007415771, 2) + 2.41579109398609e-6*std::pow(-7.73016023635864*x_82 - 8.14496040344238, 2) - 2.4853026536664e-5*std::pow(-9.88728046417236*x_84 - 8.88064002990723, 2) + 0.000243092830791073*std::pow(-1.53071987628937*x_86 - 2.10567998886108, 2) - 1.13726775009806e-5*std::pow(-9.37191963195801*x_89 - 9.57999992370605, 2) - 1.14409170032802e-6*std::pow(-6.53375959396362*x_90 - 6.33328008651733, 2) + 4.1771791538554e-6*std::pow(-7.40248012542725*x_97 - 5.45391988754272, 2) - 7.44284734242021e-5*std::exp(1.01567983627319*x_1) + 3.15143460777198e-5*std::exp(1.11351990699768*x_1) - 0.000109700506276918*std::exp(1.14375984668732*x_1) + 4.67976178911459e-6*std::exp(1.20751988887787*x_1) - 2.51020978993863e-5*std::exp(1.21103978157043*x_1) - 8.59986889411803e-7*std::exp(1.25095987319946*x_1) + 2.18224859215103e-5*std::exp(1.2611198425293*x_1) - 4.11567656403516e-6*std::exp(1.30063986778259*x_1) + 2.4948909162205e-7*std::exp(1.32463979721069*x_1) + 8.85005817687009e-6*std::exp(1.35039985179901*x_1) + 5.01884779681153e-7*std::exp(1.37815976142883*x_1) - 6.6562589336382e-6*std::exp(1.6387197971344*x_100) - 1.31870601957668e-5*std::exp(1.64639985561371*x_100) + 0.000144193587528952*std::exp(1.64719986915588*x_100) - 0.000241263160548806*std::exp(1.6736798286438*x_100) - 8.8259083861218e-5*std::exp(1.71871984004974*x_100) - 6.04480230272974e-5*std::exp(1.7293598651886*x_100) + 2.71181860057498e-6*std::exp(1.82271993160248*x_100) + 0.00293854913379725*std::exp(0.659519851207733*x_104) + 0.000557177086603438*std::exp(0.859919905662537*x_104) - 5.5093147432647e-5*std::exp(0.884479880332947*x_104) + 0.000679282011506551*std::exp(1.06447982788086*x_104) + 4.51627314858903e-5*std::exp(1.13271987438202*x_104) + 7.35124932052424e-5*std::exp(1.14023983478546*x_104) - 0.00263871527812184*std::exp(0.803759872913361*x_106) - 0.000382335046846082*std::exp(0.869199872016907*x_106) + 0.00346867523070437*std::exp(1.24255990982056*x_106) - 0.00137658011406509*std::exp(0.543359875679016*x_108) - 0.000590054671136737*std::exp(0.810959875583649*x_109) - 0.00458784634916941*std::exp(1.05311989784241*x_109) - 4.5439894993634e-5*std::exp(1.09655976295471*x_109) + 0.000417151081604612*std::exp(0.613439857959747*x_110) - 5.72735867890932e-5*std::exp(1.4670398235321*x_110) + 0.000186997837967644*std::exp(1.47447991371155*x_110) + 5.9473234873199e-5*std::exp(1.51207983493805*x_110) - 2.49883743037292e-5*std::exp(1.52231991291046*x_110) + 1.69003245771741e-5*std::exp(1.54567980766296*x_110) - 1.55033730020441e-5*std::exp(1.62999987602234*x_110) + 5.92807979251113e-7*std::exp(1.70063984394073*x_110) + 1.61521891603844e-5*std::exp(1.7707998752594*x_110) - 0.000184985288411386*std::exp(0.520319879055023*x_112) - 0.000705001137072418*std::exp(0.539999842643738*x_112) - 0.000163641153529793*std::exp(0.687439858913422*x_112) - 0.000199098509273518*std::exp(0.755039870738983*x_112) - 0.000231294441801027*std::exp(0.784239888191223*x_112) + 3.49053181696428e-5*std::exp(1.93039989471436*x_19) + 3.46604905446665e-6*std::exp(1.56215977668762*x_23) - 1.89975609385205e-5*std::exp(2.14359974861145*x_23) - 0.00309764785151113*std::exp(0.799119830131531*x_26) + 0.00507485825868121*std::exp(0.807999849319458*x_26) - 0.000437190512343665*std::exp(0.858239889144897*x_26) - 2.93771850654549e-5*std::exp(1.01599979400635*x_26) + 0.000229899603347775*std::exp(1.09751987457275*x_26) + 0.000119520254486742*std::exp(1.21999990940094*x_26) - 3.57996644079825e-6*std::exp(1.22783982753754*x_26) - 0.000150863064146137*std::exp(1.26031982898712*x_26) + 3.26509336835999e-5*std::exp(1.3005598783493*x_26) - 7.82206169887362e-7*std::exp(1.30919981002808*x_26) + 7.11861785982769e-6*std::exp(1.40287983417511*x_26) - 7.6135211911275e-7*std::exp(1.43151986598969*x_26) + 0.002265318059034*std::exp(0.481919854879379*x_31) + 0.00606947765226016*std::exp(0.533999860286713*x_31) + 0.000631797557286404*std::exp(0.613279819488525*x_31) + 0.00403806217716772*std::exp(0.624479830265045*x_31) - 0.000373778634048873*std::exp(0.631679832935333*x_31) + 0.00154705024864329*std::exp(0.63375985622406*x_31) + 0.00461574371090405*std::exp(0.642559826374054*x_31) - 0.000301178706884926*std::exp(0.643519818782806*x_31) - 0.00211727145917385*std::exp(0.653599858283997*x_31) + 0.000155052606070846*std::exp(0.653999865055084*x_31) - 0.00361315171436451*std::exp(0.658079862594604*x_31) - 0.000169640552144402*std::exp(0.669439852237701*x_31) + 0.000848315320160907*std::exp(0.889039874076843*x_45) - 3.90793884737977e-5*std::exp(1.03455984592438*x_45) - 0.000449368052662265*std::exp(1.16495990753174*x_45) + 0.000540295287855988*std::exp(0.592399835586548*x_49) - 0.000334719837612449*std::exp(0.920399844646454*x_49) + 0.000389679590380099*std::exp(1.16799986362457*x_50) - 5.09435075063325e-5*std::exp(1.40543985366821*x_50) + 0.000284329937039298*std::exp(1.40831983089447*x_50) + 8.91050783057524e-7*std::exp(2.2727198600769*x_50) - 0.00131283395359446*std::exp(1.14879977703094*x_6) - 1.41022059519398e-6*std::exp(1.83743989467621*x_6) + 2.52438912941985e-5*std::exp(2.31103992462158*x_6) + 1.91269068195613e-5*std::exp(2.35487985610962*x_6) + 1.34015352673649e-6*std::exp(2.37303996086121*x_6) - 9.61704112601751e-5*std::exp(0.849839866161346*x_60) - 0.00143125019845838*std::exp(1.153599858284*x_60) - 0.00068252881769972*std::exp(1.47215986251831*x_60) - 0.000315291891605976*std::exp(0.834719896316528*x_66) + 0.00212559862796039*std::exp(0.882879853248596*x_66) + 0.000816458027533618*std::exp(1.08591985702515*x_66) + 4.10537907293986e-5*std::exp(1.20335984230042*x_66) - 0.000300372248257125*std::exp(1.46271991729736*x_66) - 0.000129210245606363*std::exp(1.46623992919922*x_66) - 0.00270952567889543*std::exp(0.759039878845215*x_68) - 0.000279710232610661*std::exp(1.16567981243134*x_68) + 0.000191774302812331*std::exp(1.29567980766296*x_68) + 0.000241384666912538*std::exp(1.29711985588074*x_68) + 9.03856612897581e-5*std::exp(1.39703989028931*x_68) - 0.00355869246721282*std::exp(0.700399875640869*x_70) + 0.000960838200744605*std::exp(0.794639885425568*x_70) - 7.58381530033822e-6*std::exp(1.14799988269806*x_70) - 0.000128177997618219*std::exp(1.35863983631134*x_72) + 0.00170431312079819*std::exp(0.845839858055115*x_74) - 0.000218452853421203*std::exp(0.96727979183197*x_74) - 0.000485132951676436*std::exp(1.12551987171173*x_74) - 1.6640780597004e-5*std::exp(1.40063989162445*x_74) - 0.000203222822636602*std::exp(1.43639981746674*x_74) - 1.59127151540564e-5*std::exp(1.64263987541199*x_74) + 1.79131775951909e-5*std::exp(1.78703987598419*x_74) - 1.81238906159845e-6*std::exp(1.80823993682861*x_74) + 0.00137405783864405*std::exp(0.836559891700745*x_78) - 0.000886922406527994*std::exp(0.914959847927094*x_78) + 0.000378179932533332*std::exp(1.47279977798462*x_81) - 3.9809680759101e-5*std::exp(1.6276798248291*x_81) - 0.0001315995237566*std::exp(1.77087986469269*x_81) - 3.88185682828214e-5*std::exp(1.93223989009857*x_81) - 2.17396160061855e-6*std::exp(2.02951979637146*x_81) + 0.0176430279989473*std::sin(0.38487982749939*x_10 - 7.40855979919434) - 0.00143510511436381*std::sin(0.309519857168198*x_101 - 7.45863962173462) - 0.0194449135089497*std::sin(0.521039843559265*x_104 - 1.01975977420807) - 0.00763817894976353*std::sin(0.301359832286835*x_105 - 1.27151989936829) + 0.00533222950806458*std::sin(0.375199824571609*x_105 - 7.41279983520508) - 0.0125580322213507*std::sin(0.41023987531662*x_105 + 5.21456003189087) - 0.00149449879271932*std::sin(0.537359833717346*x_109 + 2.17647981643677) + 0.00237066129583313*std::sin(0.45991986989975*x_111 - 4.37863969802856) + 0.0013047093622351*std::sin(0.482159852981567*x_111 + 8.4420804977417) + 0.0112470180448832*std::sin(0.476239860057831*x_112 + 2.20975995063782) - 0.0207731643637071*std::sin(0.320559859275818*x_114 - 4.27320003509521) - 0.0640201344584653*std::sin(0.153680041432381*x_115 - 7.64736032485962) + 0.00236813118963121*std::sin(0.341359853744507*x_115 - 7.4410400390625) + 0.00105561974452006*std::sin(0.426559865474701*x_115 + 8.20335960388184) + 0.00060150137129986*std::sin(0.485759854316711*x_115 + 8.46312046051025) + 0.0160843237562483*std::sin(0.39455983042717*x_119 - 1.20143985748291) + 0.00172031452179535*std::sin(0.347039848566055*x_120 - 7.45527982711792) - 0.000379959520075541*std::sin(0.556639850139618*x_120 + 2.15871977806091) + 0.0168689394703719*std::sin(0.683679819107056*x_120 - 3.97000002861023) - 0.00043766396091922*std::sin(1.00343978404999*x_15 - 4.19184017181396) + 0.00284172922624526*std::sin(0.397839844226837*x_16 + 5.19200038909912) + 0.0439383447033203*std::sin(0.122640058398247*x_21 - 7.69304037094116) + 0.0883094833229899*std::sin(0.22503998875618*x_24 - 4.36663961410522) - 0.00477480847194766*std::sin(0.373199820518494*x_24 - 4.21591997146606) - 0.04274505841869*std::sin(0.205360010266304*x_27 + 1.81271994113922) + 0.434437677686985*std::sin(0.129680052399635*x_31 + 1.61399984359741) + 0.0584315114155816*std::sin(0.255439966917038*x_33 + 8.20495986938477) - 0.00101110323960424*std::sin(0.303839921951294*x_34 + 2.04215979576111) - 0.00152849199856857*std::sin(0.359999865293503*x_34 + 8.20528030395508) - 0.00620914524106833*std::sin(0.363679856061935*x_34 - 1.19727993011475) - 0.00519446882985217*std::sin(0.304559946060181*x_35 - 4.34575986862183) + 0.0091831403580517*std::sin(0.309119910001755*x_35 + 5.06063985824585) + 0.00116898437734065*std::sin(0.317599833011627*x_35 - 7.43192005157471) + 0.0034247728458562*std::sin(0.320879846811295*x_35 + 1.97183978557587) - 0.00477811804762362*std::sin(0.328239858150482*x_35 - 7.43264007568359) - 0.0228496912315829*std::sin(0.341359823942184*x_35 - 7.42399978637695) + 0.00689230440861375*std::sin(0.338959842920303*x_36 + 5.15104007720947) - 0.0180733182987588*std::sin(0.395039856433868*x_36 + 5.19752025604248) + 0.00207061559585895*std::sin(0.416319847106934*x_36 - 4.18847990036011) - 0.00746342932007076*std::sin(0.425919860601425*x_36 - 7.38391971588135) - 0.0119289681192949*std::sin(0.457439839839935*x_36 - 4.15664005279541) - 0.000550854670479245*std::sin(0.237759977579117*x_37 + 5.03343963623047) + 0.16658174077858*std::sin(0.247599974274635*x_37 + 1.84727990627289) + 0.00139285721501376*std::sin(0.350959837436676*x_37 + 5.16936016082764) - 0.00351012115290672*std::sin(0.35471984744072*x_37 + 5.16247987747192) + 0.0444468345924119*std::sin(0.259999960660934*x_40 - 1.3530398607254) - 0.0306725918115216*std::sin(0.302799940109253*x_41 - 7.49200010299683) - 0.0355213988660222*std::sin(0.352559834718704*x_43 - 4.44127988815308) - 0.152477671424011*std::sin(0.225919991731644*x_45 - 7.56376028060913) - 0.00501552070835782*std::sin(0.283919870853424*x_47 - 1.28175985813141) - 0.125358339895699*std::sin(0.200479999184608*x_53 + 5.00799989700317) + 0.00225691484017432*std::sin(0.325919836759567*x_53 - 4.27960014343262) - 0.00264677958211299*std::sin(0.489439845085144*x_53 + 8.49272060394287) + 0.00536754271917978*std::sin(0.362639844417572*x_55 + 5.16312026977539) - 0.000528554787980924*std::sin(0.516959846019745*x_57 - 4.06511974334717) - 0.0130937975246307*std::sin(0.375039845705032*x_58 - 4.22424030303955) - 0.0040705658856339*std::sin(0.437199860811234*x_58 + 5.21896028518677) + 0.00612520806324554*std::sin(0.261599957942963*x_59 + 1.86455988883972) + 0.0322674488846425*std::sin(0.281519949436188*x_63 + 1.87871992588043) + 0.00373826698912544*std::sin(0.307359933853149*x_64 - 7.48880004882813) + 0.000905134446851559*std::sin(0.521279871463776*x_65 - 0.857679903507233) + 0.0003907183197822*std::sin(0.837119877338409*x_73 - 7.18088006973267) - 0.0118483968134392*std::sin(0.279839843511581*x_75 + 8.11103916168213) + 0.00100786794102717*std::sin(0.463439851999283*x_75 + 8.23503971099854) + 0.00292844192525733*std::sin(0.480639845132828*x_75 - 1.13143992424011) - 0.00148341084121409*std::sin(0.486399859189987*x_75 - 1.11623990535736) - 0.00248758395703158*std::sin(0.545119881629944*x_75 + 5.16215991973877) - 0.00204846550400823*std::sin(0.5065598487854*x_76 + 8.50568008422852) + 0.0345260133433319*std::sin(0.272239863872528*x_79 - 1.29615986347198) - 0.0265352976219145*std::sin(0.371999859809875*x_80 + 8.36744022369385) + 0.00857578119568722*std::sin(0.34487983584404*x_83 - 7.46303987503052) - 0.00580501304425481*std::sin(0.226559981703758*x_84 - 7.58008003234863) + 0.00920344439674858*std::sin(0.261679977178574*x_84 + 1.87495994567871) - 0.00121315005728167*std::sin(0.291039943695068*x_87 - 7.48808002471924) + 0.00063897533540043*std::sin(0.934719800949097*x_87 - 3.82536005973816) - 0.000198549528612693*std::sin(1.00263977050781*x_87 - 6.9900803565979) - 0.0041204605415492*std::sin(0.23047998547554*x_92 + 4.82000017166138) - 0.0268033842029314*std::sin(0.331599831581116*x_92 - 7.40279960632324) - 0.000903665637774133*std::sin(0.354319840669632*x_92 + 1.98751986026764) + 0.0213385210648322*std::sin(0.354399859905243*x_92 + 8.18423938751221) - 0.00558374879327044*std::sin(0.359759837388992*x_92 + 1.99959981441498) - 0.00576753698326876*std::sin(0.37271985411644*x_92 - 4.39192008972168) + 0.0128012721435568*std::sin(0.416239857673645*x_92 - 7.59040021896362) + 0.00051906378415451*std::sin(0.465199857950211*x_92 - 4.61639976501465) - 0.000632078371530308*std::sin(0.372799843549728*x_94 - 1.18511986732483) - 0.0571394634309583*std::sin(0.319919854402542*x_95 + 1.95463979244232) + 0.00104544396251335*std::sin(0.341439843177795*x_95 - 7.4334397315979) + 0.00569187956372833*std::sin(0.348559856414795*x_95 - 1.22079980373383) - 0.01747290928264*std::sin(0.417919874191284*x_95 + 5.20168018341064) + 0.0573839140938579*std::sin(0.375199824571609*x_96 - 4.21479988098145) - 0.0177172295846726*std::sin(0.406559854745865*x_96 - 7.38735961914063) - 0.00325190539037383*std::sin(0.343359857797623*x_97 - 4.42447996139526) - 0.00261062800307233*std::sin(0.309119910001755*x_98 - 4.29047966003418) + 0.0411756434495791*std::sin(0.387199848890305*x_98 - 1.18119990825653) + 0.0012319768051834*std::sin(0.442879855632782*x_98 + 2.03743982315063) - 0.0041689535308207*std::sin(0.443519860506058*x_98 + 2.00271987915039) + 0.0771599184472661*std::sin(0.326079845428467*x_99 + 1.93167984485626) - 0.869643712014051 + 0.000502770927190779*std::exp(-1.33871984481812*x_9) - 0.000159719609177687*std::exp(-1.31719982624054*x_9) + 8.59716679816592e-5*std::exp(-1.29767978191376*x_9) - 0.000555582277662788*std::exp(-1.27743983268738*x_9) + 1.73955687068548e-7*std::exp(-2.84623980522156*x_79) - 4.53468124746989e-7*std::exp(-1.95879983901978*x_30));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0146030078386295*x_1 + 0.00124510462001722*x_10 - 0.00210119328263786*x_100 - 0.0229309122168769*x_101 + 0.00041364538367713*x_102 - 0.0141039418372546*x_103 - 0.000887384919390629*x_104 + 1.62213101815173e-5*x_105 - 0.00184278126884703*x_106 + 0.0308913483249187*x_107 - 0.00261823548499163*x_108 - 0.0038760556454011*x_109 + 0.0389600793441805*x_11 + 0.00257518381530619*x_110 - 0.00167630147645007*x_111 + 0.0308261137184502*x_112 - 0.00426703858465201*x_113 + 0.00129519280001356*x_114 - 0.00639867625871694*x_115 - 0.0179634197137786*x_116 + 0.009567939402009*x_117 + 0.00817937121558579*x_118 - 0.00445774073410421*x_119 - 0.0125779742939692*x_12 + 0.000416852941694315*x_120 + 0.0163455576786402*x_13 - 0.00556575834387541*x_14 - 0.000253202927718695*x_15 + 0.00942764732211489*x_16 + 0.00418540670722964*x_17 - 0.00476446676193364*x_18 + 0.0108240219151744*x_19 + 0.0145306732719463*x_2 - 0.0295002024770794*x_20 - 0.00668503815734611*x_21 + 0.000857960016560795*x_22 - 0.0347126174263908*x_23 + 0.00193365184056142*x_24 - 0.045251166048931*x_25 + 0.000897514831267607*x_26 - 0.000830756900164372*x_27 + 0.016140006477804*x_28 + 0.0190504443135655*x_29 + 0.0365076310690434*x_3 + 0.0388124511934199*x_30 + 0.00385989205651494*x_31 + 0.0463265678284091*x_32 + 0.00867636078742043*x_33 + 0.00545065332269873*x_34 - 0.00170445073976379*x_35 - 0.00676080537304911*x_36 - 0.00364573317437941*x_37 + 0.0360895671412574*x_38 + 0.00614320128095608*x_39 - 0.00922508260652583*x_4 + 0.00211643462870099*x_40 + 0.034200433405035*x_41 - 0.0448849585287065*x_42 - 0.00592521921430491*x_43 + 0.0783390103277988*x_44 - 0.00273676816042242*x_45 - 0.0296725596981603*x_46 + 0.00612769679720108*x_47 - 0.000729559091206623*x_48 - 0.00187731916758181*x_49 - 0.00218228638709156*x_5 + 0.00163487552621799*x_50 + 0.00660229090853878*x_51 + 0.0265059633961717*x_52 - 0.00403978419710755*x_53 + 0.0420892756551977*x_54 + 0.0235548450580467*x_55 + 0.00323270702166967*x_56 + 0.00120358529247654*x_57 - 0.0123383859414524*x_58 + 0.0257784654107783*x_59 + 0.0120084887258117*x_6 + 0.00738061675704975*x_60 - 0.0283412575990207*x_61 + 0.036252792915298*x_62 - 0.0351147649190848*x_63 + 0.00221719667625255*x_64 - 0.00257992286242957*x_65 - 0.000628163499607207*x_66 - 0.0218794130043309*x_67 - 0.00242907130011794*x_68 - 0.0235283391912565*x_69 + 0.0217519056628691*x_7 - 0.000796977127318673*x_70 + 0.00515250546023593*x_71 + 0.00708733770799335*x_72 + 0.0232791593309965*x_73 + 0.0211031570751225*x_74 - 0.000749237385788576*x_75 - 0.00535096900785018*x_76 + 0.0266005840650086*x_77 - 0.00912859825566844*x_78 + 0.0105093845270561*x_79 + 0.0596690216645714*x_8 - 0.000586633720481942*x_80 + 0.00275605460184936*x_81 - 0.00454805330171593*x_82 + 0.0271252725293682*x_83 - 0.000553475299281805*x_84 - 0.0148137948681036*x_85 + 0.00627089510741335*x_86 + 0.0181150525079026*x_87 - 0.0101263448442402*x_88 + 0.021290135951609*x_89 - 0.00222609729498417*x_9 + 0.00711993683097359*x_90 + 0.0132883547621225*x_91 - 0.0116843184977655*x_92 + 0.0819954149583772*x_93 + 0.01031424468173*x_94 + 0.00219172022460374*x_95 + 0.00130553122324286*x_96 + 0.00629118237631256*x_97 - 0.00134062890672437*x_98 + 0.000114049133560413*x_99 - 0.000124854676101152*std::pow(-9.94719982147217*x_102 - 9.78800010681152, 2) + 0.000198765883482731*std::pow(-7.96016025543213*x_104 - 9.15664005279541, 2) - 0.000222202530550108*std::pow(-6.34000015258789*x_108 - 9.19999980926514, 2) - 7.86253501787409e-6*std::pow(-7.53336048126221*x_110 - 9.12399959564209, 2) - 8.88755325163911e-7*std::pow(-6.82224035263062*x_112 - 7.22352027893066, 2) - 2.95902937225372e-6*std::pow(-8.39915943145752*x_114 - 7.57599973678589, 2) - 9.74051599975638e-6*std::pow(-7.7480001449585*x_115 - 7.5417594909668, 2) - 3.90035181758217e-5*std::pow(-4.07359981536865*x_13 - 6.10303974151611, 2) - 1.23715341970396e-6*std::pow(-6.60400009155273*x_14 - 9.97567939758301, 2) - 1.90380879059069e-6*std::pow(-8.70680046081543*x_15 - 9.9235200881958, 2) + 1.67072729602975e-5*std::pow(-4.7579197883606*x_15 - 6.15079975128174, 2) - 2.48978271449186e-5*std::pow(-4.46928024291992*x_15 - 5.25055980682373, 2) - 2.62745996462565e-5*std::pow(-4.34728002548218*x_24 - 5.5318398475647, 2) - 1.63239762312394e-6*std::pow(-7.32087993621826*x_27 - 8.55039978027344, 2) - 1.2794824727501e-5*std::pow(-5.54271984100342*x_36 - 6.56727981567383, 2) + 4.79807373981469e-6*std::pow(-9.39496040344238*x_39 - 8.79872035980225, 2) - 2.14441418490728e-5*std::pow(-4.88320016860962*x_4 - 8.13959980010986, 2) - 4.79936599000149e-7*std::pow(-5.77159976959229*x_47 - 3.50111985206604, 2) - 4.49563224932561e-6*std::pow(-6.14759969711304*x_53 - 5.93872022628784, 2) - 2.52528137697307e-6*std::pow(-5.93631982803345*x_57 - 7.71104001998901, 2) - 0.000427370310545746*std::pow(-4.32000017166138*x_57 - 6.7828803062439, 2) + 1.07858542600995e-5*std::pow(-5.4871997833252*x_6 - 8.73799991607666, 2) - 3.92370227519679e-6*std::pow(-8.86295986175537*x_67 - 9.87448024749756, 2) - 2.61807827162094e-6*std::pow(-6.9117603302002*x_70 - 9.48536014556885, 2) + 0.000208211017405659*std::pow(-5.01503992080688*x_70 - 7.41752004623413, 2) - 4.98473216538787e-5*std::pow(-4.91472005844116*x_70 - 6.55808019638062, 2) + 1.6527511771996e-6*std::pow(-6.60000038146973*x_72 - 9.96523952484131, 2) - 2.24327719862913e-5*std::pow(-5.69008016586304*x_73 - 7.72512006759644, 2) - 1.05310729809339e-5*std::pow(-5.29624032974243*x_75 - 7.53200006484985, 2) + 5.58140529119724e-6*std::pow(-9.12207984924316*x_81 - 9.71424007415771, 2) + 8.37382348391432e-6*std::pow(-7.73016023635864*x_82 - 8.14496040344238, 2) - 7.96429804941348e-5*std::pow(-9.88728046417236*x_84 - 8.88064002990723, 2) - 0.000272284142263869*std::pow(-1.53071987628937*x_86 - 2.10567998886108, 2) - 1.31774892706538e-5*std::pow(-9.37191963195801*x_89 - 9.57999992370605, 2) - 2.53463013381409e-6*std::pow(-6.53375959396362*x_90 - 6.33328008651733, 2) + 9.08679989331337e-6*std::pow(-7.40248012542725*x_97 - 5.45391988754272, 2) - 8.62400617527399e-5*std::exp(1.01567983627319*x_1) - 3.52986826590272e-5*std::exp(1.11351990699768*x_1) - 2.71855074379779e-5*std::exp(1.14375984668732*x_1) + 9.22918533875509e-7*std::exp(1.20751988887787*x_1) + 2.19619059058568e-5*std::exp(1.21103978157043*x_1) + 1.107560085714e-6*std::exp(1.25095987319946*x_1) - 2.40903359755131e-5*std::exp(1.2611198425293*x_1) + 1.49411134655917e-6*std::exp(1.30063986778259*x_1) + 8.64800611114929e-7*std::exp(1.32463979721069*x_1) + 7.70412131385734e-6*std::exp(1.35039985179901*x_1) + 1.11187965607807e-6*std::exp(1.37815976142883*x_1) - 1.47463306191553e-5*std::exp(1.6387197971344*x_100) - 2.60068413958904e-6*std::exp(1.64639985561371*x_100) - 0.000126155431877914*std::exp(1.64719986915588*x_100) - 0.000210023552420307*std::exp(1.6736798286438*x_100) - 0.000127004684146705*std::exp(1.71871984004974*x_100) + 6.77068017513033e-5*std::exp(1.7293598651886*x_100) - 3.4924974771975e-6*std::exp(1.82271993160248*x_100) - 0.00329141886987151*std::exp(0.659519851207733*x_104) - 0.000202271629994359*std::exp(0.859919905662537*x_104) - 0.00019096862014382*std::exp(0.884479880332947*x_104) + 0.00078708214645178*std::exp(1.06447982788086*x_104) + 8.90676145647518e-6*std::exp(1.13271987438202*x_104) + 5.32019087102003e-5*std::exp(1.14023983478546*x_104) - 0.00305747193330353*std::exp(0.803759872913361*x_106) + 0.000428246978527204*std::exp(0.869199872016907*x_106) + 0.0111155731207197*std::exp(1.24255990982056*x_106) - 0.00198089663908573*std::exp(0.543359875679016*x_108) + 0.00051624072293707*std::exp(0.810959875583649*x_109) - 0.0147020225789383*std::exp(1.05311989784241*x_109) - 8.96142221694498e-6*std::exp(1.09655976295471*x_109) + 0.00144596506385708*std::exp(0.613439857959747*x_110) - 4.98576000162477e-5*std::exp(1.4670398235321*x_110) + 0.000216673866223817*std::exp(1.47447991371155*x_110) - 5.20333238057385e-5*std::exp(1.51207983493805*x_110) - 1.80843983186862e-5*std::exp(1.52231991291046*x_110) + 2.43195407316476e-5*std::exp(1.54567980766296*x_110) + 5.62817926819365e-6*std::exp(1.62999987602234*x_110) + 1.31331165792437e-6*std::exp(1.70063984394073*x_110) - 1.80917921639528e-5*std::exp(1.7707998752594*x_110) - 0.000409817924721732*std::exp(0.520319879055023*x_112) + 0.000789659774326282*std::exp(0.539999842643738*x_112) - 3.22724660577196e-5*std::exp(0.687439858913422*x_112) - 0.000690132427724118*std::exp(0.755039870738983*x_112) - 0.000503144881191346*std::exp(0.784239888191223*x_112) + 4.04446934883684e-5*std::exp(1.93039989471436*x_19) + 7.67871349491497e-6*std::exp(1.56215977668762*x_23) + 1.66210269533993e-5*std::exp(2.14359974861145*x_23) - 0.00269655344165108*std::exp(0.799119830131531*x_26) + 0.0162626807930371*std::exp(0.807999849319458*x_26) - 0.000951039578289429*std::exp(0.858239889144897*x_26) - 2.12606354358219e-5*std::exp(1.01599979400635*x_26) - 0.000201139899810568*std::exp(1.09751987457275*x_26) + 0.000171989459964161*std::exp(1.21999990940094*x_26) + 4.6105678898613e-6*std::exp(1.22783982753754*x_26) - 3.73862354117858e-5*std::exp(1.26031982898712*x_26) + 3.78325445573716e-5*std::exp(1.3005598783493*x_26) - 1.54262674903674e-7*std::exp(1.30919981002808*x_26) + 2.46751673006955e-5*std::exp(1.40287983417511*x_26) - 1.68670572734083e-6*std::exp(1.43151986598969*x_26) - 0.00198193403032498*std::exp(0.481919854879379*x_31) + 0.0194499969472703*std::exp(0.533999860286713*x_31) + 0.000909155700437522*std::exp(0.613279819488525*x_31) + 0.0035151995912417*std::exp(0.624479830265045*x_31) - 0.00129562374469201*std::exp(0.631679832935333*x_31) - 0.000561624630660692*std::exp(0.63375985622406*x_31) + 0.00534824918945263*std::exp(0.642559826374054*x_31) - 5.93969144410977e-5*std::exp(0.643519818782806*x_31) + 0.00233730387025187*std::exp(0.653599858283997*x_31) - 0.000199689181061193*std::exp(0.653999865055084*x_31) + 0.00404702973844795*std::exp(0.658079862594604*x_31) - 0.000375823070177664*std::exp(0.669439852237701*x_31) - 0.000307963350761873*std::exp(0.889039874076843*x_45) + 5.03295705790281e-5*std::exp(1.03455984592438*x_45) - 0.000111360457236195*std::exp(1.16495990753174*x_45) - 0.000605175555956711*std::exp(0.592399835586548*x_49) - 0.000242240923518027*std::exp(0.920399844646454*x_49) + 0.000560748323339315*std::exp(1.16799986362457*x_50) - 3.68684521168713e-5*std::exp(1.40543985366821*x_50) - 0.000318473123105892*std::exp(1.40831983089447*x_50) + 1.97404121090006e-6*std::exp(2.2727198600769*x_50) - 0.00152117699074377*std::exp(1.14879977703094*x_6) + 1.81619517985556e-6*std::exp(1.83743989467621*x_6) + 2.19752228830108e-5*std::exp(2.31103992462158*x_6) + 4.73994774733415e-6*std::exp(2.35487985610962*x_6) + 2.96898711163592e-6*std::exp(2.37303996086121*x_6) - 6.95997267593883e-5*std::exp(0.849839866161346*x_60) - 0.00124592685596395*std::exp(1.153599858284*x_60) - 0.000790844211609321*std::exp(1.47215986251831*x_60) - 0.000685868195134378*std::exp(0.834719896316528*x_66) - 0.00185969305226977*std::exp(0.882879853248596*x_66) + 0.00117488182937636*std::exp(1.08591985702515*x_66) - 5.28723641475939e-5*std::exp(1.20335984230042*x_66) - 0.000261478986198864*std::exp(1.46271991729736*x_66) + 0.000142638113702145*std::exp(1.46623992919922*x_66) - 0.00313951974450403*std::exp(0.759039878845215*x_68) - 0.000608465861345529*std::exp(1.16567981243134*x_68) + 0.00027596292291492*std::exp(1.29567980766296*x_68) - 8.76297163074028e-5*std::exp(1.29711985588074*x_68) + 0.000313302576121534*std::exp(1.39703989028931*x_68) - 0.00412344690159462*std::exp(0.700399875640869*x_70) + 0.00138264467364678*std::exp(0.794639885425568*x_70) - 1.49564102054328e-6*std::exp(1.14799988269806*x_70) + 0.00014149859179186*std::exp(1.35863983631134*x_72) + 0.00148363262444357*std::exp(0.845839858055115*x_74) + 0.000241155047717959*std::exp(0.96727979183197*x_74) + 0.000543389162079758*std::exp(1.12551987171173*x_74) - 3.28180910123562e-6*std::exp(1.40063989162445*x_74) + 0.000177800298865729*std::exp(1.43639981746674*x_74) - 3.46156228972724e-5*std::exp(1.64263987541199*x_74) + 2.5777034646297e-5*std::exp(1.78703987598419*x_74) + 2.33413998413863e-6*std::exp(1.80823993682861*x_74) + 0.000340513101173622*std::exp(0.836559891700745*x_78) - 0.00127627996094825*std::exp(0.914959847927094*x_78) - 0.000423592905706653*std::exp(1.47279977798462*x_81) + 1.44520821302718e-5*std::exp(1.6276798248291*x_81) - 0.000152483996154487*std::exp(1.77087986469269*x_81) + 4.28526958562402e-5*std::exp(1.93223989009857*x_81) - 4.28737517753897e-7*std::exp(2.02951979637146*x_81) + 0.0204429266668229*std::sin(0.38487982749939*x_10 - 7.40855979919434) - 0.00103860348023784*std::sin(0.309519857168198*x_101 - 7.45863962173462) - 0.00481875479675535*std::sin(0.521039843559265*x_104 - 1.01975977420807) + 0.00277288306268217*std::sin(0.301359832286835*x_105 - 1.27151989936829) - 0.00588636880371192*std::sin(0.375199824571609*x_105 - 7.41279983520508) - 0.014550956434235*std::sin(0.41023987531662*x_105 + 5.21456003189087) + 0.000542546910302312*std::sin(0.537359833717346*x_109 + 2.17647981643677) - 0.000860619605511518*std::sin(0.45991986989975*x_111 - 4.37863969802856) + 0.0009442344471868*std::sin(0.482159852981567*x_111 + 8.4420804977417) + 0.0130318880141038*std::sin(0.476239860057831*x_112 + 2.20975995063782) - 0.0665688229873934*std::sin(0.320559859275818*x_114 - 4.27320003509521) - 0.0557305808097984*std::sin(0.153680041432381*x_115 - 7.64736032485962) + 0.0017138460943337*std::sin(0.341359853744507*x_115 - 7.4410400390625) + 0.00229633564388328*std::sin(0.426559865474701*x_115 + 8.20335960388184) + 0.000118625004592212*std::sin(0.485759854316711*x_115 + 8.46312046051025) + 0.00398594790443857*std::sin(0.39455983042717*x_119 - 1.20143985748291) - 0.0018990941253285*std::sin(0.347039848566055*x_120 - 7.45527982711792) - 0.000841765436229356*std::sin(0.556639850139618*x_120 + 2.15871977806091) + 0.00418038799460933*std::sin(0.683679819107056*x_120 - 3.97000002861023) + 0.000490219953467561*std::sin(1.00343978404999*x_15 - 4.19184017181396) - 0.00103163108536863*std::sin(0.397839844226837*x_16 + 5.19200038909912) + 0.0509112357972312*std::sin(0.122640058398247*x_21 - 7.69304037094116) + 0.282992916269749*std::sin(0.22503998875618*x_24 - 4.36663961410522) + 0.0017333955680398*std::sin(0.373199820518494*x_24 - 4.21591997146606) - 0.0105928964506758*std::sin(0.205360010266304*x_27 + 1.81271994113922) + 0.107660475953358*std::sin(0.129680052399635*x_31 + 1.61399984359741) + 0.0144802457355187*std::sin(0.255439966917038*x_33 + 8.20495986938477) + 0.00130217984077375*std::sin(0.303839921951294*x_34 + 2.04215979576111) - 0.00110618873373101*std::sin(0.359999865293503*x_34 + 8.20528030395508) - 0.0135070242946204*std::sin(0.363679856061935*x_34 - 1.19727993011475) + 0.00188574459078017*std::sin(0.304559946060181*x_35 - 4.34575986862183) + 0.0106404787728044*std::sin(0.309119910001755*x_35 + 5.06063985824585) + 0.000230541082276483*std::sin(0.317599833011627*x_35 - 7.43192005157471) + 0.0118712430702702*std::sin(0.320879846811295*x_35 + 1.97183978557587) + 0.00418039079401214*std::sin(0.328239858150482*x_35 - 7.43264007568359) - 0.0056625121616453*std::sin(0.341359823942184*x_35 - 7.42399978637695) - 0.00250210872031041*std::sin(0.338959842920303*x_36 + 5.15104007720947) - 0.0157331210637124*std::sin(0.395039856433868*x_36 + 5.19752025604248) + 0.00149853034636226*std::sin(0.416319847106934*x_36 - 4.18847990036011) - 0.0107398631617041*std::sin(0.425919860601425*x_36 - 7.38391971588135) + 0.0104366924406077*std::sin(0.457439839839935*x_36 - 4.15664005279541) - 0.00122036795367768*std::sin(0.237759977579117*x_37 + 5.03343963623047) + 0.533820953835762*std::sin(0.247599974274635*x_37 + 1.84727990627289) + 0.00482804183104123*std::sin(0.350959837436676*x_37 + 5.16936016082764) - 0.0025403184818845*std::sin(0.35471984744072*x_37 + 5.16247987747192) + 0.0515004215942577*std::sin(0.259999960660934*x_40 - 1.3530398607254) - 0.0355402454228231*std::sin(0.302799940109253*x_41 - 7.49200010299683) - 0.00880276022283783*std::sin(0.352559834718704*x_43 - 4.44127988815308) - 0.488623636767083*std::sin(0.225919991731644*x_45 - 7.56376028060913) + 0.00182078117234575*std::sin(0.283919870853424*x_47 - 1.28175985813141) - 0.40171814906976*std::sin(0.200479999184608*x_53 + 5.00799989700317) - 0.00249145935818104*std::sin(0.325919836759567*x_53 - 4.27960014343262) + 0.000960858644732501*std::sin(0.489439845085144*x_53 + 8.49272060394287) - 0.00194857549058829*std::sin(0.362639844417572*x_55 + 5.16312026977539) - 0.000104238854877382*std::sin(0.516959846019745*x_57 - 4.06511974334717) + 0.011455805420682*std::sin(0.375039845705032*x_58 - 4.22424030303955) + 0.00147773484675369*std::sin(0.437199860811234*x_58 + 5.21896028518677) - 0.00222363024036032*std::sin(0.261599957942963*x_59 + 1.86455988883972) + 0.0280893453724045*std::sin(0.281519949436188*x_63 + 1.87871992588043) + 0.00537936037220247*std::sin(0.307359933853149*x_64 - 7.48880004882813) - 0.000791905028558974*std::sin(0.521279871463776*x_65 - 0.857679903507233) - 0.00043132279380065*std::sin(0.837119877338409*x_73 - 7.18088006973267) - 0.0170498245517922*std::sin(0.279839843511581*x_75 + 8.11103916168213) + 0.00349355879913111*std::sin(0.463439851999283*x_75 + 8.23503971099854) - 0.00106311033925774*std::sin(0.480639845132828*x_75 - 1.13143992424011) - 0.00107356293757652*std::sin(0.486399859189987*x_75 - 1.11623990535736) - 0.00541134981354576*std::sin(0.545119881629944*x_75 + 5.16215991973877) + 0.00229445134560706*std::sin(0.5065598487854*x_76 + 8.50568008422852) + 0.0400051940583891*std::sin(0.272239863872528*x_79 - 1.29615986347198) - 0.0850339168064908*std::sin(0.371999859809875*x_80 + 8.36744022369385) - 0.00946699890194247*std::sin(0.34487983584404*x_83 - 7.46303987503052) - 0.00420116038208241*std::sin(0.226559981703758*x_84 - 7.58008003234863) - 0.0101598905114236*std::sin(0.261679977178574*x_84 + 1.87495994567871) - 0.00420512537879062*std::sin(0.291039943695068*x_87 - 7.48808002471924) - 0.000705379330532165*std::sin(0.934719800949097*x_87 - 3.82536005973816) - 0.000143692771597529*std::sin(1.00263977050781*x_87 - 6.9900803565979) - 0.00592933629858773*std::sin(0.23047998547554*x_92 + 4.82000017166138) - 0.0233327871291282*std::sin(0.331599831581116*x_92 - 7.40279960632324) - 0.000178216286022963*std::sin(0.354319840669632*x_92 + 1.98751986026764) + 0.0247248840353734*std::sin(0.354399859905243*x_92 + 8.18423938751221) + 0.00202706463896227*std::sin(0.359759837388992*x_92 + 1.99959981441498) + 0.00504603659195331*std::sin(0.37271985411644*x_92 - 4.39192008972168) + 0.00317235618034214*std::sin(0.416239857673645*x_92 - 7.59040021896362) + 0.00179922366475431*std::sin(0.465199857950211*x_92 - 4.61639976501465) - 0.00140031160697479*std::sin(0.372799843549728*x_94 - 1.18511986732483) - 0.183106760247639*std::sin(0.319919854402542*x_95 + 1.95463979244232) + 0.00231608512660358*std::sin(0.341439843177795*x_95 - 7.4334397315979) - 0.00206631928119172*std::sin(0.348559856414795*x_95 - 1.22079980373383) - 0.0202458105911508*std::sin(0.417919874191284*x_95 + 5.20168018341064) + 0.183890116727316*std::sin(0.375199824571609*x_96 - 4.21479988098145) - 0.0154231399769231*std::sin(0.406559854745865*x_96 - 7.38735961914063) + 0.00284510244858397*std::sin(0.343359857797623*x_97 - 4.42447996139526) - 0.00904918398544991*std::sin(0.309119910001755*x_98 - 4.29047966003418) + 0.131949763271305*std::sin(0.387199848890305*x_98 - 1.18119990825653) + 0.000891596988003903*std::sin(0.442879855632782*x_98 + 2.03743982315063) + 0.00151345244864676*std::sin(0.443519860506058*x_98 + 2.00271987915039) + 0.247263482005259*std::sin(0.326079845428467*x_99 + 1.93167984485626) - 1.56901027185285 + 0.000124594527815956*std::exp(-1.33871984481812*x_9) + 0.00017889921576932*std::exp(-1.31719982624054*x_9) + 0.000187017916797436*std::exp(-1.29767978191376*x_9) - 0.000643751614537167*std::exp(-1.27743983268738*x_9) - 2.24034084765939e-7*std::exp(-2.84623980522156*x_79) - 1.57185033162259e-6*std::exp(-1.95879983901978*x_30));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0214866302041503*x_1 - 0.00993598407265092*x_10 - 0.00335744291192114*x_100 + 0.0152219620741198*x_101 - 0.000215593584788201*x_102 + 0.033490822219184*x_103 - 0.000120314920076197*x_104 - 0.00235592143295247*x_105 - 0.00475688388211284*x_106 - 0.0456282119683948*x_107 + 0.000782864580939325*x_108 + 0.001832898465445*x_109 - 0.0699103449386561*x_11 - 0.00384493906386627*x_110 - 0.00668965997139344*x_111 - 0.0516962292800973*x_112 + 0.0037909656590385*x_113 - 0.00198657114792418*x_114 + 0.0104033871919205*x_115 + 0.031215139581325*x_116 - 0.0120352067182101*x_117 - 0.00984314949769688*x_118 + 0.0232247125946037*x_119 + 0.011618648147667*x_12 - 0.00377585980545824*x_120 - 0.0242844248083836*x_13 + 0.00240930712494426*x_14 + 0.00189557820271243*x_15 - 0.0154833069982136*x_16 - 0.00919481193050012*x_17 + 0.00856017932751667*x_18 - 0.0175580617191374*x_19 - 0.0170263071096296*x_2 + 0.0444033580884989*x_20 + 0.0155622959695384*x_21 - 0.00546868778598993*x_22 + 0.0481934819521549*x_23 - 0.00347885174403219*x_24 + 0.0624083490649205*x_25 - 0.00123452777219571*x_26 + 0.00352334269333953*x_27 - 0.0270883058551455*x_28 - 0.030732077238819*x_29 - 0.0560837597606521*x_3 - 0.0608492202679352*x_30 - 0.00945092439928171*x_31 - 0.068290971621124*x_32 - 0.0237972685217579*x_33 - 0.023410409322337*x_34 + 0.00458060079717709*x_35 + 0.0128441996143517*x_36 - 0.00251740535415497*x_37 - 0.0669879005028731*x_38 - 0.00322002042086766*x_39 + 0.0192604978129818*x_4 - 0.004898484376751*x_40 - 0.0547484194490356*x_41 + 0.0550495651169385*x_42 + 0.00621602746851696*x_43 - 0.128360676299065*x_44 + 0.0020620059439903*x_45 + 0.0473756756337437*x_46 - 0.00856115011334239*x_47 - 0.00478910033919218*x_48 + 0.000565519038043764*x_49 + 0.00739085520801486*x_5 - 0.00254085942006186*x_50 - 0.00920050705774207*x_51 - 0.0395499958442617*x_52 + 0.00327029804381595*x_53 - 0.0627648124129369*x_54 - 0.0356923110951009*x_55 - 0.0123277124118592*x_56 - 0.00107216091368419*x_57 + 0.0280204941784914*x_58 - 0.0407431797115215*x_59 - 0.0232935883067172*x_6 - 0.00954669649111221*x_60 + 0.0538301093034636*x_61 - 0.0651898671250902*x_62 + 0.0545609736709861*x_63 - 0.00988172040631483*x_64 + 0.0188521198988738*x_65 + 0.00138805673430432*x_66 + 0.0275781648648592*x_67 + 0.00252717595674405*x_68 + 0.0276356130659299*x_69 - 0.0332758391203502*x_7 + 0.00069325141712917*x_70 - 0.000768865856926788*x_71 - 0.0100895896362273*x_72 - 0.0341552738017009*x_73 - 0.0312254368132426*x_74 - 0.00443716413223889*x_75 + 0.00829417392110253*x_76 - 0.0431496260200113*x_77 + 0.013539701078292*x_78 - 0.0192213376900025*x_79 - 0.0678706437666856*x_8 + 0.00149945840599263*x_80 - 0.000866829088053083*x_81 + 0.00549388646252327*x_82 - 0.0430849784748938*x_83 + 6.48937991822636e-5*x_84 + 0.0241559486406767*x_85 - 0.00750644930146014*x_86 - 0.0269170924261544*x_87 + 0.0143687358701158*x_88 - 0.0245266202957606*x_89 + 0.00403330422618755*x_9 - 0.00666674644905378*x_90 - 0.0155898717494376*x_91 + 0.0151169305228179*x_92 - 0.127441744395443*x_93 - 0.0192239635369764*x_94 - 0.000756502148224716*x_95 + 8.48631757945707e-5*x_96 - 0.00951672555908523*x_97 - 0.00450112876995163*x_98 - 0.00607991232744868*x_99 + 0.000192134626254687*std::pow(-9.94719982147217*x_102 - 9.78800010681152, 2) - 0.000305874076387794*std::pow(-7.96016025543213*x_104 - 9.15664005279541, 2) + 0.000341939937640001*std::pow(-6.34000015258789*x_108 - 9.19999980926514, 2) + 7.42555981028205e-6*std::pow(-7.53336048126221*x_110 - 9.12399959564209, 2) - 1.38736891661433e-6*std::pow(-6.82224035263062*x_112 - 7.22352027893066, 2) - 1.37979366419439e-5*std::pow(-8.39915943145752*x_114 - 7.57599973678589, 2) + 2.81801952362344e-6*std::pow(-7.7480001449585*x_115 - 7.5417594909668, 2) - 3.30448873944255e-5*std::pow(-4.07359981536865*x_13 - 6.10303974151611, 2) - 3.96405562745955e-6*std::pow(-6.60400009155273*x_14 - 9.97567939758301, 2) - 6.10013586815599e-6*std::pow(-8.70680046081543*x_15 - 9.9235200881958, 2) - 4.67086213896096e-6*std::pow(-4.7579197883606*x_15 - 6.15079975128174, 2) + 2.35140834591343e-5*std::pow(-4.46928024291992*x_15 - 5.25055980682373, 2) - 1.91298519337969e-5*std::pow(-4.34728002548218*x_24 - 5.5318398475647, 2) - 5.23048708521897e-6*std::pow(-7.32087993621826*x_27 - 8.55039978027344, 2) + 7.41978956148863e-6*std::pow(-5.54271984100342*x_36 - 6.56727981567383, 2) - 2.78242947505253e-6*std::pow(-9.39496040344238*x_39 - 8.79872035980225, 2) + 1.44322294474664e-5*std::pow(-4.88320016860962*x_4 - 8.13959980010986, 2) + 6.21282249608116e-7*std::pow(-5.77159976959229*x_47 - 3.50111985206604, 2) + 4.24577901103279e-6*std::pow(-6.14759969711304*x_53 - 5.93872022628784, 2) - 1.04908926551859e-6*std::pow(-5.93631982803345*x_57 - 7.71104001998901, 2) + 0.000657665675433188*std::pow(-4.32000017166138*x_57 - 6.7828803062439, 2) - 7.25904186627175e-6*std::pow(-5.4871997833252*x_6 - 8.73799991607666, 2) + 1.09695175540158e-6*std::pow(-8.86295986175537*x_67 - 9.87448024749756, 2) - 8.38878003362911e-6*std::pow(-6.9117603302002*x_70 - 9.48536014556885, 2) - 0.000320408872623514*std::pow(-5.01503992080688*x_70 - 7.41752004623413, 2) - 4.22320654137101e-5*std::pow(-4.91472005844116*x_70 - 6.55808019638062, 2) + 5.29570342725659e-6*std::pow(-6.60000038146973*x_72 - 9.96523952484131, 2) - 1.63327172379397e-5*std::pow(-5.69008016586304*x_73 - 7.72512006759644, 2) + 9.94578874480029e-6*std::pow(-5.29624032974243*x_75 - 7.53200006484985, 2) - 5.2712081689928e-6*std::pow(-9.12207984924316*x_81 - 9.71424007415771, 2) - 2.34107476200958e-6*std::pow(-7.73016023635864*x_82 - 8.14496040344238, 2) + 0.000122559881366819*std::pow(-9.88728046417236*x_84 - 8.88064002990723, 2) + 0.000183251316080464*std::pow(-1.53071987628937*x_86 - 2.10567998886108, 2) + 3.81236702839661e-6*std::pow(-9.37191963195801*x_89 - 9.57999992370605, 2) - 1.05297306260247e-6*std::pow(-6.53375959396362*x_90 - 6.33328008651733, 2) - 5.26948547023285e-6*std::pow(-7.40248012542725*x_97 - 5.45391988754272, 2) + 2.49500311630093e-5*std::exp(1.01567983627319*x_1) + 2.37565434380118e-5*std::exp(1.11351990699768*x_1) + 2.56746216067289e-5*std::exp(1.14375984668732*x_1) + 1.74252035097214e-5*std::exp(1.20751988887787*x_1) + 1.59898919039429e-5*std::exp(1.21103978157043*x_1) - 1.43374650539693e-6*std::exp(1.25095987319946*x_1) - 0.000112333095639434*std::exp(1.2611198425293*x_1) + 4.78739370319672e-6*std::exp(1.30063986778259*x_1) - 2.41772816054781e-7*std::exp(1.32463979721069*x_1) + 6.52715019557454e-6*std::exp(1.35039985179901*x_1) + 4.61913283159827e-7*std::exp(1.37815976142883*x_1) - 6.12613600187687e-6*std::exp(1.6387197971344*x_100) - 4.91023299819836e-5*std::exp(1.64639985561371*x_100) - 9.18504854483116e-5*std::exp(1.64719986915588*x_100) - 0.000177937913411322*std::exp(1.6736798286438*x_100) + 2.42019580290538e-5*std::exp(1.71871984004974*x_100) - 4.55676941938892e-5*std::exp(1.7293598651886*x_100) + 4.52106943688881e-6*std::exp(1.82271993160248*x_100) + 0.00221517431996283*std::exp(0.659519851207733*x_104) - 0.000648113629550022*std::exp(0.859919905662537*x_104) + 5.3389209578312e-5*std::exp(0.884479880332947*x_104) - 0.000227709995594899*std::exp(1.06447982788086*x_104) + 0.000168164496968004*std::exp(1.13271987438202*x_104) + 8.3049487704023e-5*std::exp(1.14023983478546*x_104) + 0.000884554329688033*std::exp(0.803759872913361*x_106) - 0.000288216646662224*std::exp(0.869199872016907*x_106) - 0.0171053784595611*std::exp(1.24255990982056*x_106) + 0.000377478812227654*std::exp(0.543359875679016*x_108) + 0.000375861429857769*std::exp(0.810959875583649*x_109) + 0.0226244438862967*std::exp(1.05311989784241*x_109) - 0.000169196521832845*std::exp(1.09655976295471*x_109) - 0.000404249304304778*std::exp(0.613439857959747*x_110) - 4.22407735339764e-5*std::exp(1.4670398235321*x_110) - 6.26857124707727e-5*std::exp(1.47447991371155*x_110) - 3.78841083566769e-5*std::exp(1.51207983493805*x_110) - 2.82301904614641e-5*std::exp(1.52231991291046*x_110) - 4.63432123017857e-6*std::exp(1.54567980766296*x_110) + 1.80336693453694e-5*std::exp(1.62999987602234*x_110) + 5.45595106815524e-7*std::exp(1.70063984394073*x_110) + 1.21760477739673e-5*std::exp(1.7707998752594*x_110) - 0.000170252546731254*std::exp(0.520319879055023*x_112) - 0.000531452884835503*std::exp(0.539999842643738*x_112) - 0.000609321698693067*std::exp(0.687439858913422*x_112) + 0.000192940729177408*std::exp(0.755039870738983*x_112) + 0.00029177649689533*std::exp(0.784239888191223*x_112) - 1.17010162377475e-5*std::exp(1.93039989471436*x_19) + 3.19000328991613e-6*std::exp(1.56215977668762*x_23) + 1.21013369903612e-5*std::exp(2.14359974861145*x_23) - 0.00228459659538221*std::exp(0.799119830131531*x_26) - 0.0250260878778621*std::exp(0.807999849319458*x_26) + 0.000551513106731918*std::exp(0.858239889144897*x_26) - 3.31883747033397e-5*std::exp(1.01599979400635*x_26) - 0.000146444724302512*std::exp(1.09751987457275*x_26) - 3.2774237576026e-5*std::exp(1.21999990940094*x_26) - 5.96842165517592e-6*std::exp(1.22783982753754*x_26) + 3.53084248910045e-5*std::exp(1.26031982898712*x_26) - 1.0945297887062e-5*std::exp(1.3005598783493*x_26) - 2.9125631412589e-6*std::exp(1.30919981002808*x_26) - 6.89845105130155e-6*std::exp(1.40287983417511*x_26) - 7.00715923689664e-7*std::exp(1.43151986598969*x_26) - 0.00144299456711501*std::exp(0.481919854879379*x_31) - 0.0299309406008229*std::exp(0.533999860286713*x_31) - 0.00017324831955369*std::exp(0.613279819488525*x_31) + 0.00297817684389097*std::exp(0.624479830265045*x_31) + 0.000362218293182958*std::exp(0.631679832935333*x_31) - 0.00179954340523356*std::exp(0.63375985622406*x_31) - 0.00154729694335061*std::exp(0.642559826374054*x_31) - 0.00112144602583661*std::exp(0.643519818782806*x_31) + 0.0108988342654208*std::exp(0.653599858283997*x_31) + 0.000258499443240131*std::exp(0.653999865055084*x_31) - 0.00272371177998556*std::exp(0.658079862594604*x_31) - 0.000156129907840298*std::exp(0.669439852237701*x_31) - 0.000986768362109063*std::exp(0.889039874076843*x_45) - 6.5152082371487e-5*std::exp(1.03455984592438*x_45) + 0.000105171389866993*std::exp(1.16495990753174*x_45) + 0.00040729223584869*std::exp(0.592399835586548*x_49) - 0.000378144038190576*std::exp(0.920399844646454*x_49) - 0.000106855959506533*std::exp(1.16799986362457*x_50) - 5.75525603305922e-5*std::exp(1.40543985366821*x_50) + 0.000214337193713079*std::exp(1.40831983089447*x_50) + 8.20085026140299e-7*std::exp(2.2727198600769*x_50) + 0.000440090284632755*std::exp(1.14879977703094*x_6) - 2.35108101657346e-6*std::exp(1.83743989467621*x_6) + 1.86180324134618e-5*std::exp(2.31103992462158*x_6) - 4.47651621460862e-6*std::exp(2.35487985610962*x_6) + 1.2334199811087e-6*std::exp(2.37303996086121*x_6) - 0.000108646884892664*std::exp(0.849839866161346*x_60) - 0.00105558458781653*std::exp(1.153599858284*x_60) + 0.000228798395127671*std::exp(1.47215986251831*x_60) + 0.000397738756348642*std::exp(0.834719896316528*x_66) - 0.0013539940935808*std::exp(0.882879853248596*x_66) - 0.000223884976484957*std::exp(1.08591985702515*x_66) + 6.84437515458296e-5*std::exp(1.20335984230042*x_66) - 0.00022153241705017*std::exp(1.46271991729736*x_66) + 0.000665120689251421*std::exp(1.46623992919922*x_66) + 0.00090829150478629*std::exp(0.759039878845215*x_68) + 0.000352852715272444*std::exp(1.16567981243134*x_68) - 5.2587375991952e-5*std::exp(1.29567980766296*x_68) - 0.00028078091571227*std::exp(1.29711985588074*x_68) - 8.75901856827598e-5*std::exp(1.39703989028931*x_68) + 0.0011929505452903*std::exp(0.700399875640869*x_70) - 0.000263476174800299*std::exp(0.794639885425568*x_70) - 2.82385153227072e-5*std::exp(1.14799988269806*x_70) + 0.00065980710525403*std::exp(1.35863983631134*x_72) + 0.00125697566020661*std::exp(0.845839858055115*x_74) + 0.00112450457589174*std::exp(0.96727979183197*x_74) - 0.000365709065048956*std::exp(1.12551987171173*x_74) - 6.19623394374268e-5*std::exp(1.40063989162445*x_74) + 0.000129451768509471*std::exp(1.43639981746674*x_74) + 2.00737909981337e-5*std::exp(1.64263987541199*x_74) - 4.91206064417688e-6*std::exp(1.78703987598419*x_74) - 3.02156523021377e-6*std::exp(1.80823993682861*x_74) - 0.000321588443574655*std::exp(0.836559891700745*x_78) + 0.000243207360860109*std::exp(0.914959847927094*x_78) + 0.000285084385773253*std::exp(1.47279977798462*x_81) + 4.63069952235351e-5*std::exp(1.6276798248291*x_81) + 4.41150015270457e-5*std::exp(1.77087986469269*x_81) + 0.000199821869936544*std::exp(1.93223989009857*x_81) - 8.09479734656859e-6*std::exp(2.02951979637146*x_81) - 0.0059143238888525*std::sin(0.38487982749939*x_10 - 7.40855979919434) - 0.00162128557137331*std::sin(0.309519857168198*x_101 - 7.45863962173462) + 0.00455094341367592*std::sin(0.521039843559265*x_104 - 1.01975977420807) + 0.00888480162108172*std::sin(0.301359832286835*x_105 - 1.27151989936829) - 0.0274481032754575*std::sin(0.375199824571609*x_105 - 7.41279983520508) + 0.00420972352184362*std::sin(0.41023987531662*x_105 + 5.21456003189087) + 0.00173841505725241*std::sin(0.537359833717346*x_109 + 2.17647981643677) - 0.00275757552458312*std::sin(0.45991986989975*x_111 - 4.37863969802856) + 0.00147397319029496*std::sin(0.482159852981567*x_111 + 8.4420804977417) - 0.00377024326579182*std::sin(0.476239860057831*x_112 + 2.20975995063782) + 0.102440503826506*std::sin(0.320559859275818*x_114 - 4.27320003509521) - 0.0472165295187996*std::sin(0.153680041432381*x_115 - 7.64736032485962) + 0.00267535589584336*std::sin(0.341359853744507*x_115 - 7.4410400390625) - 0.00133165772904552*std::sin(0.426559865474701*x_115 + 8.20335960388184) + 0.00223970455732526*std::sin(0.485759854316711*x_115 + 8.46312046051025) - 0.00376442133456849*std::sin(0.39455983042717*x_119 - 1.20143985748291) - 0.00885546478993308*std::sin(0.347039848566055*x_120 - 7.45527982711792) - 0.000349698489556559*std::sin(0.556639850139618*x_120 + 2.15871977806091) - 0.00394805505013189*std::sin(0.683679819107056*x_120 - 3.97000002861023) - 0.000329925389319138*std::sin(1.00343978404999*x_15 - 4.19184017181396) - 0.00330552617346061*std::sin(0.397839844226837*x_16 + 5.19200038909912) - 0.0147290817500821*std::sin(0.122640058398247*x_21 - 7.69304037094116) - 0.435488200347109*std::sin(0.22503998875618*x_24 - 4.36663961410522) + 0.00555410214017422*std::sin(0.373199820518494*x_24 - 4.21591997146606) + 0.0100041762586496*std::sin(0.205360010266304*x_27 + 1.81271994113922) - 0.101677042019872*std::sin(0.129680052399635*x_31 + 1.61399984359741) - 0.0136754787778037*std::sin(0.255439966917038*x_33 + 8.20495986938477) - 0.00168568353102407*std::sin(0.303839921951294*x_34 + 2.04215979576111) - 0.00172678781396256*std::sin(0.359999865293503*x_34 + 8.20528030395508) + 0.00783279802595405*std::sin(0.363679856061935*x_34 - 1.19727993011475) + 0.0060422550170231*std::sin(0.304559946060181*x_35 - 4.34575986862183) - 0.00307838690714265*std::sin(0.309119910001755*x_35 + 5.06063985824585) + 0.00435274092844365*std::sin(0.317599833011627*x_35 - 7.43192005157471) - 0.00331885041509133*std::sin(0.320879846811295*x_35 + 1.97183978557587) + 0.00304363369914387*std::sin(0.328239858150482*x_35 - 7.43264007568359) + 0.00534780737219732*std::sin(0.341359823942184*x_35 - 7.42399978637695) - 0.0080171933369715*std::sin(0.338959842920303*x_36 + 5.15104007720947) - 0.0133295466211437*std::sin(0.395039856433868*x_36 + 5.19752025604248) + 0.00233924271875713*std::sin(0.416319847106934*x_36 - 4.18847990036011) + 0.00204658370849612*std::sin(0.425919860601425*x_36 - 7.38391971588135) + 0.00759868404296881*std::sin(0.457439839839935*x_36 - 4.15664005279541) - 0.000506983075969434*std::sin(0.237759977579117*x_37 + 5.03343963623047) - 0.821478959819334*std::sin(0.247599974274635*x_37 + 1.84727990627289) - 0.00134977849751541*std::sin(0.350959837436676*x_37 + 5.16936016082764) - 0.00396549961533843*std::sin(0.35471984744072*x_37 + 5.16247987747192) - 0.0148995385389323*std::sin(0.259999960660934*x_40 - 1.3530398607254) + 0.0102821149801909*std::sin(0.302799940109253*x_41 - 7.49200010299683) + 0.00831353022678529*std::sin(0.352559834718704*x_43 - 4.44127988815308) + 0.751926341576428*std::sin(0.225919991731644*x_45 - 7.56376028060913) + 0.0058341008783993*std::sin(0.283919870853424*x_47 - 1.28175985813141) + 0.618190434202972*std::sin(0.200479999184608*x_53 + 5.00799989700317) - 0.0116176604032752*std::sin(0.325919836759567*x_53 - 4.27960014343262) + 0.00307875891314794*std::sin(0.489439845085144*x_53 + 8.49272060394287) - 0.00624357619352061*std::sin(0.362639844417572*x_55 + 5.16312026977539) - 0.00196808623208742*std::sin(0.516959846019745*x_57 - 4.06511974334717) + 0.00834067367078829*std::sin(0.375039845705032*x_58 - 4.22424030303955) + 0.00473492053763936*std::sin(0.437199860811234*x_58 + 5.21896028518677) - 0.00712489965052096*std::sin(0.261599957942963*x_59 + 1.86455988883972) + 0.0237980904858381*std::sin(0.281519949436188*x_63 + 1.87871992588043) - 0.00102508860067565*std::sin(0.307359933853149*x_64 - 7.48880004882813) - 0.000576565433761832*std::sin(0.521279871463776*x_65 - 0.857679903507233) - 0.00201125566271578*std::sin(0.837119877338409*x_73 - 7.18088006973267) + 0.00324900723920197*std::sin(0.279839843511581*x_75 + 8.11103916168213) - 0.000976696290524055*std::sin(0.463439851999283*x_75 + 8.23503971099854) - 0.00340639120082091*std::sin(0.480639845132828*x_75 - 1.13143992424011) - 0.00167585814391395*std::sin(0.486399859189987*x_75 - 1.11623990535736) + 0.00313807165906776*std::sin(0.545119881629944*x_75 + 5.16215991973877) - 0.00154420020670032*std::sin(0.5065598487854*x_76 + 8.50568008422852) - 0.0115738650709782*std::sin(0.272239863872528*x_79 - 1.29615986347198) + 0.130855810409142*std::sin(0.371999859809875*x_80 + 8.36744022369385) - 0.0441445604640502*std::sin(0.34487983584404*x_83 - 7.46303987503052) - 0.0065581146607901*std::sin(0.226559981703758*x_84 - 7.58008003234863) - 0.0473755099831735*std::sin(0.261679977178574*x_84 + 1.87495994567871) + 0.00117562937817874*std::sin(0.291039943695068*x_87 - 7.48808002471924) - 0.00328917968928668*std::sin(0.934719800949097*x_87 - 3.82536005973816) - 0.000224307949794628*std::sin(1.00263977050781*x_87 - 6.9900803565979) + 0.0011298917768482*std::sin(0.23047998547554*x_92 + 4.82000017166138) - 0.0197681993661307*std::sin(0.331599831581116*x_92 - 7.40279960632324) - 0.0033648203375616*std::sin(0.354319840669632*x_92 + 1.98751986026764) - 0.00715313294826993*std::sin(0.354399859905243*x_92 + 8.18423938751221) + 0.00649506913316009*std::sin(0.359759837388992*x_92 + 1.99959981441498) + 0.00367388786722544*std::sin(0.37271985411644*x_92 - 4.39192008972168) - 0.00299604650447939*std::sin(0.416239857673645*x_92 - 7.59040021896362) - 0.000503010019360685*std::sin(0.465199857950211*x_92 - 4.61639976501465) - 0.000581737896083175*std::sin(0.372799843549728*x_94 - 1.18511986732483) + 0.281776782764501*std::sin(0.319919854402542*x_95 + 1.95463979244232) + 0.00096218190436249*std::sin(0.341439843177795*x_95 - 7.4334397315979) - 0.00662084786274626*std::sin(0.348559856414795*x_95 - 1.22079980373383) + 0.00585729642237353*std::sin(0.417919874191284*x_95 + 5.20168018341064) - 0.28298226348134*std::sin(0.375199824571609*x_96 - 4.21479988098145) - 0.0130669218481379*std::sin(0.406559854745865*x_96 - 7.38735961914063) + 0.00207144501954947*std::sin(0.343359857797623*x_97 - 4.42447996139526) + 0.00252988569508457*std::sin(0.309119910001755*x_98 - 4.29047966003418) - 0.203053015251005*std::sin(0.387199848890305*x_98 - 1.18119990825653) + 0.00139180482218258*std::sin(0.442879855632782*x_98 + 2.03743982315063) + 0.0048493659722383*std::sin(0.443519860506058*x_98 + 2.00271987915039) - 0.380505385821704*std::sin(0.326079845428467*x_99 + 1.93167984485626) + 2.18210268124643 - 0.000117669952022852*std::exp(-1.33871984481812*x_9) - 0.000120401858378225*std::exp(-1.31719982624054*x_9) - 0.000108452723379821*std::exp(-1.29767978191376*x_9) + 0.000186243174198905*std::exp(-1.27743983268738*x_9) + 2.9001414033072e-7*std::exp(-2.84623980522156*x_79) + 4.39443122736796e-7*std::exp(-1.95879983901978*x_30));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00476612257431793*x_1 + 0.000713017996432009*x_10 + 0.00200044903957662*x_100 + 0.00605802204321088*x_101 + 0.00226967142229283*x_102 - 0.000122380023717447*x_103 + 0.000961580011302858*x_104 + 0.000347165937372258*x_105 + 0.00337614431130048*x_106 - 0.0055816306696442*x_107 - 0.000289789608712565*x_108 - 0.0010286327766458*x_109 - 0.00153635053920862*x_11 - 0.000126830321344924*x_110 + 0.000750539528020014*x_111 - 0.0028165971501166*x_112 + 0.00196593604457418*x_113 + 0.00159635864576385*x_114 + 0.00060436484735899*x_115 - 0.00092686304951043*x_116 - 0.00277266701579173*x_117 - 0.00377652439175684*x_118 - 0.00117105568872794*x_119 - 0.0028456723722208*x_12 - 0.00126929993261292*x_120 - 0.0014338265364713*x_13 + 0.0026044836515513*x_14 - 0.000948944572960512*x_15 - 0.000486597459482703*x_16 + 0.000258882977831812*x_17 - 0.000629504552716684*x_18 - 0.00591208452377785*x_19 - 0.00353558716519916*x_2 + 0.000645956802423815*x_20 - 0.00231830139856831*x_21 - 0.00306280952735187*x_22 + 0.00311010950773963*x_23 - 0.00192693537582947*x_24 + 0.00828681920278971*x_25 - 0.00035302037986595*x_26 - 0.00220635413357289*x_27 - 0.00180041268491757*x_28 + 0.000160444888917385*x_29 - 0.00747683345728281*x_3 - 0.00507409502356748*x_30 - 0.00276674532675249*x_31 - 0.0087215563295679*x_32 + 0.00162021499846801*x_33 + 0.00580376194611068*x_34 + 0.000356397249358091*x_35 + 0.000783314068751263*x_36 + 0.00428663285660103*x_37 - 0.00240120804790904*x_38 - 0.00113698912899862*x_39 + 0.00342775160682506*x_4 - 0.000849305624964806*x_40 - 0.000738370152157723*x_41 + 0.0153623198938377*x_42 + 0.000735076985888567*x_43 - 0.0120088222624664*x_44 + 0.00194917234538404*x_45 + 0.0020158193131626*x_46 - 0.00402330365374928*x_47 + 0.00364001298396559*x_48 - 0.000912579339283034*x_49 - 0.00132381354183443*x_5 + 0.00303352246024557*x_50 - 0.00278222536615715*x_51 - 0.00425676222954953*x_52 - 0.000288237574990538*x_53 - 0.00556250925780556*x_54 - 0.00397645479078837*x_55 + 0.00298508756478954*x_56 + 0.000521488312074665*x_57 + 0.00155651451723969*x_58 - 0.00584619042311628*x_59 + 0.0013485464840344*x_6 - 0.000569233126382436*x_60 + 0.00673435008417014*x_61 - 0.000496281798838492*x_62 + 0.00479313366854339*x_63 + 0.00236855764538339*x_64 - 0.00623872507383004*x_65 - 0.000564473493624388*x_66 + 0.00366422436628676*x_67 + 0.00188007944175423*x_68 + 0.00643733319484644*x_69 - 0.00384458820922417*x_7 + 0.000174563980097682*x_70 - 0.00536769177248254*x_71 - 0.000994244717940662*x_72 - 0.00516584774467577*x_73 - 0.00157714236427181*x_74 + 0.00196596505618218*x_75 - 0.00191755030666082*x_76 - 0.00220907050276116*x_77 + 0.00247085035559447*x_78 - 0.00233727174298016*x_79 - 0.0172370136797202*x_8 + 0.00292578117879562*x_80 - 0.00148657982681754*x_81 - 0.000127904867004498*x_82 - 0.0041694959010186*x_83 - 0.0011827821085244*x_84 + 0.00292164870969411*x_85 - 0.00174495513576435*x_86 - 0.00132645723587249*x_87 + 0.00249161292043186*x_88 - 0.00449691917137304*x_89 + 0.000427499875835151*x_9 - 0.0062188872116609*x_90 + 0.0134417986510521*x_91 + 0.0030364622265662*x_92 - 0.00480217003118772*x_93 - 0.00141144921585389*x_94 + 0.00272468299191625*x_95 - 0.00434631471249128*x_96 - 0.000117723217861439*x_97 - 0.00599144215850772*x_98 + 0.00169555195380363*x_99 + 1.62420817559861e-5*std::pow(-9.94719982147217*x_102 - 9.78800010681152, 2) - 2.5857034999729e-5*std::pow(-7.96016025543213*x_104 - 9.15664005279541, 2) + 2.8905859037734e-5*std::pow(-6.34000015258789*x_108 - 9.19999980926514, 2) - 4.64652662635437e-6*std::pow(-7.53336048126221*x_110 - 9.12399959564209, 2) - 5.20733567469941e-7*std::pow(-6.82224035263062*x_112 - 7.22352027893066, 2) + 5.63251881786977e-6*std::pow(-8.39915943145752*x_114 - 7.57599973678589, 2) + 5.54943396636852e-6*std::pow(-7.7480001449585*x_115 - 7.5417594909668, 2) - 1.23097505718751e-5*std::pow(-4.07359981536865*x_13 - 6.10303974151611, 2) + 6.64383811626719e-6*std::pow(-6.60400009155273*x_14 - 9.97567939758301, 2) + 1.02239521853625e-5*std::pow(-8.70680046081543*x_15 - 9.9235200881958, 2) - 3.04380297077002e-5*std::pow(-4.7579197883606*x_15 - 6.15079975128174, 2) - 1.47138825460536e-5*std::pow(-4.46928024291992*x_15 - 5.25055980682373, 2) + 4.25527155367076e-5*std::pow(-4.34728002548218*x_24 - 5.5318398475647, 2) + 8.76640308039564e-6*std::pow(-7.32087993621826*x_27 - 8.55039978027344, 2) + 1.40336668164108e-6*std::pow(-5.54271984100342*x_36 - 6.56727981567383, 2) - 5.2626409239043e-7*std::pow(-9.39496040344238*x_39 - 8.79872035980225, 2) - 2.37963795173102e-6*std::pow(-4.88320016860962*x_4 - 8.13959980010986, 2) + 6.77370561517654e-7*std::pow(-5.77159976959229*x_47 - 3.50111985206604, 2) - 2.65678625294529e-6*std::pow(-6.14759969711304*x_53 - 5.93872022628784, 2) + 1.51032700779263e-6*std::pow(-5.93631982803345*x_57 - 7.71104001998901, 2) + 5.55957032665844e-5*std::pow(-4.32000017166138*x_57 - 6.7828803062439, 2) + 1.19689695767808e-6*std::pow(-5.4871997833252*x_6 - 8.73799991607666, 2) + 7.14836985667373e-6*std::pow(-8.86295986175537*x_67 - 9.87448024749756, 2) + 1.40597665053768e-5*std::pow(-6.9117603302002*x_70 - 9.48536014556885, 2) - 2.70857325716817e-5*std::pow(-5.01503992080688*x_70 - 7.41752004623413, 2) - 1.57321217401269e-5*std::pow(-4.91472005844116*x_70 - 6.55808019638062, 2) - 8.87570700035874e-6*std::pow(-6.60000038146973*x_72 - 9.96523952484131, 2) + 3.63307292169714e-5*std::pow(-5.69008016586304*x_73 - 7.72512006759644, 2) - 6.22355396812228e-6*std::pow(-5.29624032974243*x_75 - 7.53200006484985, 2) + 3.29844614225138e-6*std::pow(-9.12207984924316*x_81 - 9.71424007415771, 2) - 1.52557924070622e-5*std::pow(-7.73016023635864*x_82 - 8.14496040344238, 2) + 1.03605875316047e-5*std::pow(-9.88728046417236*x_84 - 8.88064002990723, 2) - 3.02151367560389e-5*std::pow(-1.53071987628937*x_86 - 2.10567998886108, 2) + 7.50757008682618e-6*std::pow(-9.37191963195801*x_89 - 9.57999992370605, 2) + 1.51591833716885e-6*std::pow(-6.53375959396362*x_90 - 6.33328008651733, 2) - 9.96661735084693e-7*std::pow(-7.40248012542725*x_97 - 5.45391988754272, 2) + 4.91332828737556e-5*std::exp(1.01567983627319*x_1) - 3.9170644128696e-6*std::exp(1.11351990699768*x_1) - 1.60658342219599e-5*std::exp(1.14375984668732*x_1) + 1.18263504691341e-5*std::exp(1.20751988887787*x_1) - 3.55681436534851e-5*std::exp(1.21103978157043*x_1) - 1.56318271775394e-6*std::exp(1.25095987319946*x_1) + 4.58560066970663e-5*std::exp(1.2611198425293*x_1) - 8.0237695310194e-6*std::exp(1.30063986778259*x_1) - 1.5755310130448e-6*std::exp(1.32463979721069*x_1) + 2.43146813888804e-6*std::exp(1.35039985179901*x_1) - 6.64995944334244e-7*std::exp(1.37815976142883*x_1) + 8.81952466882949e-6*std::exp(1.6387197971344*x_100) - 3.33253705125474e-5*std::exp(1.64639985561371*x_100) + 0.000204313530116004*std::exp(1.64719986915588*x_100) - 6.62847267484648e-5*std::exp(1.6736798286438*x_100) + 0.000203796931783222*std::exp(1.71871984004974*x_100) + 7.51336547630122e-6*std::exp(1.7293598651886*x_100) + 4.92922394782301e-6*std::exp(1.82271993160248*x_100) - 0.000365245917179406*std::exp(0.659519851207733*x_104) + 0.00108625166757215*std::exp(0.859919905662537*x_104) + 0.000347914860012714*std::exp(0.884479880332947*x_104) - 0.000448421869842521*std::exp(1.06447982788086*x_104) + 0.000114131939779052*std::exp(1.13271987438202*x_104) + 3.11717060190479e-5*std::exp(1.14023983478546*x_104) + 0.00174192400056808*std::exp(0.803759872913361*x_106) + 4.75221983695998e-5*std::exp(0.869199872016907*x_106) - 0.00144600148772246*std::exp(1.24255990982056*x_106) + 0.00317862809500039*std::exp(0.543359875679016*x_108) - 0.0008360715263928*std::exp(0.810959875583649*x_109) + 0.00191255514140303*std::exp(1.05311989784241*x_109) - 0.000114832367050255*std::exp(1.09655976295471*x_109) - 0.00263432145237392*std::exp(0.613439857959747*x_110) - 1.57353656545984e-5*std::exp(1.4670398235321*x_110) - 0.000123444929701559*std::exp(1.47447991371155*x_110) + 8.4269951060908e-5*std::exp(1.51207983493805*x_110) - 1.05958895383272e-5*std::exp(1.52231991291046*x_110) - 3.90241337694429e-5*std::exp(1.54567980766296*x_110) - 3.02247977911725e-5*std::exp(1.62999987602234*x_110) - 7.85468932174858e-7*std::exp(1.70063984394073*x_110) - 2.00763059446156e-6*std::exp(1.7707998752594*x_110) + 0.000245104995280436*std::exp(0.520319879055023*x_112) + 8.76278650443372e-5*std::exp(0.539999842643738*x_112) - 0.000413541910897747*std::exp(0.687439858913422*x_112) + 0.00125731299100891*std::exp(0.755039870738983*x_112) + 5.51861223065073e-5*std::exp(0.784239888191223*x_112) - 2.30424297654589e-5*std::exp(1.93039989471436*x_19) - 4.59250540641654e-6*std::exp(1.56215977668762*x_23) - 2.6918386631886e-5*std::exp(2.14359974861145*x_23) - 0.000851048875150785*std::exp(0.799119830131531*x_26) - 0.00211557788030315*std::exp(0.807999849319458*x_26) + 0.000104312273557345*std::exp(0.858239889144897*x_26) - 1.24568891163961e-5*std::exp(1.01599979400635*x_26) + 0.000325753733832455*std::exp(1.09751987457275*x_26) - 0.0002759813504143*std::exp(1.21999990940094*x_26) - 6.50724067924155e-6*std::exp(1.22783982753754*x_26) - 2.20941640202686e-5*std::exp(1.26031982898712*x_26) - 2.15542182576446e-5*std::exp(1.3005598783493*x_26) - 1.97673401362533e-6*std::exp(1.30919981002808*x_26) - 4.49542829117499e-5*std::exp(1.40287983417511*x_26) + 1.00878945112046e-6*std::exp(1.43151986598969*x_26) + 0.00320981769999891*std::exp(0.481919854879379*x_31) - 0.00253020912340766*std::exp(0.533999860286713*x_31) - 0.00145886857250374*std::exp(0.613279819488525*x_31) + 0.00110941864227434*std::exp(0.624479830265045*x_31) + 0.00236042315970128*std::exp(0.631679832935333*x_31) + 0.00301607146598751*std::exp(0.63375985622406*x_31) - 0.00304704142093639*std::exp(0.642559826374054*x_31) - 0.000761116719604575*std::exp(0.643519818782806*x_31) - 0.00444906297846125*std::exp(0.653599858283997*x_31) + 0.000281836336270698*std::exp(0.653999865055084*x_31) + 0.000449095404478087*std::exp(0.658079862594604*x_31) + 0.000224773262186428*std::exp(0.669439852237701*x_31) + 0.00165384390942774*std::exp(0.889039874076843*x_45) - 7.10339023010163e-5*std::exp(1.03455984592438*x_45) - 6.58107504125157e-5*std::exp(1.16495990753174*x_45) - 6.71558102231438e-5*std::exp(0.592399835586548*x_49) - 0.000141932179441503*std::exp(0.920399844646454*x_49) - 0.000899799787440382*std::exp(1.16799986362457*x_50) - 2.16017165290935e-5*std::exp(1.40543985366821*x_50) - 3.53406881787557e-5*std::exp(1.40831983089447*x_50) - 1.18063982196382e-6*std::exp(2.2727198600769*x_50) + 0.000866655448387214*std::exp(1.14879977703094*x_6) - 2.56333263886806e-6*std::exp(1.83743989467621*x_6) + 6.93551569455379e-6*std::exp(2.31103992462158*x_6) + 2.8011695166315e-6*std::exp(2.35487985610962*x_6) - 1.77569971464601e-6*std::exp(2.37303996086121*x_6) - 4.0779405742143e-5*std::exp(0.849839866161346*x_60) - 0.00039322218981836*std::exp(1.153599858284*x_60) + 0.000450565219555151*std::exp(1.47215986251831*x_60) + 7.52276481740348e-5*std::exp(0.834719896316528*x_66) + 0.00301184377704122*std::exp(0.882879853248596*x_66) - 0.00188526363136482*std::exp(1.08591985702515*x_66) + 7.46227378075211e-5*std::exp(1.20335984230042*x_66) - 8.25243785800355e-5*std::exp(1.46271991729736*x_66) - 0.000271511958315192*std::exp(1.46623992919922*x_66) + 0.00178866884553868*std::exp(0.759039878845215*x_68) + 6.67379768706791e-5*std::exp(1.16567981243134*x_68) - 0.000442821438861469*std::exp(1.29567980766296*x_68) + 0.000470594543933054*std::exp(1.29711985588074*x_68) - 0.000570788131740469*std::exp(1.39703989028931*x_68) + 0.00234923861269757*std::exp(0.700399875640869*x_70) - 0.00221864842331436*std::exp(0.794639885425568*x_70) - 1.91652613266775e-5*std::exp(1.14799988269806*x_70) - 0.000269342875891327*std::exp(1.35863983631134*x_72) + 0.000468243594459082*std::exp(0.845839858055115*x_74) - 0.000459039155552937*std::exp(0.96727979183197*x_74) + 6.02994273095718e-5*std::exp(1.12551987171173*x_74) - 4.20533591854832e-5*std::exp(1.40063989162445*x_74) - 0.000287954360554944*std::exp(1.43639981746674*x_74) + 3.79672350914431e-6*std::exp(1.64263987541199*x_74) - 4.1362888358645e-5*std::exp(1.78703987598419*x_74) - 3.29434703460967e-6*std::exp(1.80823993682861*x_74) + 0.000201233213922593*std::exp(0.836559891700745*x_78) + 0.00204797123732236*std::exp(0.914959847927094*x_78) - 4.70057399171306e-5*std::exp(1.47279977798462*x_81) - 7.76114688665693e-5*std::exp(1.6276798248291*x_81) + 8.68742341379533e-5*std::exp(1.77087986469269*x_81) - 8.15701993599631e-5*std::exp(1.93223989009857*x_81) - 5.49387617445779e-6*std::exp(2.02951979637146*x_81) - 0.011646885197836*std::sin(0.38487982749939*x_10 - 7.40855979919434) - 0.00060853159484721*std::sin(0.309519857168198*x_101 - 7.45863962173462) - 0.00284774216179588*std::sin(0.521039843559265*x_104 - 1.01975977420807) - 0.0148911088070289*std::sin(0.301359832286835*x_105 - 1.27151989936829) + 0.0112047157648106*std::sin(0.375199824571609*x_105 - 7.41279983520508) + 0.00829007127356621*std::sin(0.41023987531662*x_105 + 5.21456003189087) - 0.00291361910747662*std::sin(0.537359833717346*x_109 + 2.17647981643677) + 0.00462175284620114*std::sin(0.45991986989975*x_111 - 4.37863969802856) + 0.000553239523060983*std::sin(0.482159852981567*x_111 + 8.4420804977417) - 0.00742461713457351*std::sin(0.476239860057831*x_112 + 2.20975995063782) + 0.00865979792767274*std::sin(0.320559859275818*x_114 - 4.27320003509521) - 0.0175889145666767*std::sin(0.153680041432381*x_115 - 7.64736032485962) + 0.00100416522470031*std::sin(0.341359853744507*x_115 - 7.4410400390625) - 0.000251867532469123*std::sin(0.426559865474701*x_115 + 8.20335960388184) + 0.00152007011151795*std::sin(0.485759854316711*x_115 + 8.46312046051025) + 0.00235557781645887*std::sin(0.39455983042717*x_119 - 1.20143985748291) + 0.00361492978005543*std::sin(0.347039848566055*x_120 - 7.45527982711792) + 0.000503445312730827*std::sin(0.556639850139618*x_120 + 2.15871977806091) + 0.00247048618305505*std::sin(0.683679819107056*x_120 - 3.97000002861023) + 5.43992860230805e-5*std::sin(1.00343978404999*x_15 - 4.19184017181396) + 0.00554012931438877*std::sin(0.397839844226837*x_16 + 5.19200038909912) - 0.0290055004488487*std::sin(0.122640058398247*x_21 - 7.69304037094116) - 0.0368139522359128*std::sin(0.22503998875618*x_24 - 4.36663961410522) - 0.0093087885157099*std::sin(0.373199820518494*x_24 - 4.21591997146606) - 0.00626008981790049*std::sin(0.205360010266304*x_27 + 1.81271994113922) + 0.0636241704470683*std::sin(0.129680052399635*x_31 + 1.61399984359741) + 0.00855739875412781*std::sin(0.255439966917038*x_33 + 8.20495986938477) - 0.00183786419243598*std::sin(0.303839921951294*x_34 + 2.04215979576111) - 0.000648130693905628*std::sin(0.359999865293503*x_34 + 8.20528030395508) + 0.00148148241706232*std::sin(0.363679856061935*x_34 - 1.19727993011475) - 0.0101269426978329*std::sin(0.304559946060181*x_35 - 4.34575986862183) - 0.00606216696545651*std::sin(0.309119910001755*x_35 + 5.06063985824585) + 0.00295417150751782*std::sin(0.317599833011627*x_35 - 7.43192005157471) - 0.0216275420949236*std::sin(0.320879846811295*x_35 + 1.97183978557587) - 0.00677030221905644*std::sin(0.328239858150482*x_35 - 7.43264007568359) - 0.00334637791390778*std::sin(0.341359823942184*x_35 - 7.42399978637695) + 0.0134369796197312*std::sin(0.338959842920303*x_36 + 5.15104007720947) - 0.00496546991321085*std::sin(0.395039856433868*x_36 + 5.19752025604248) + 0.000878008863777295*std::sin(0.416319847106934*x_36 - 4.18847990036011) + 0.0172336254747792*std::sin(0.425919860601425*x_36 - 7.38391971588135) - 0.0169026211835187*std::sin(0.457439839839935*x_36 - 4.15664005279541) + 0.000729880914139286*std::sin(0.237759977579117*x_37 + 5.03343963623047) - 0.0694436431698765*std::sin(0.247599974274635*x_37 + 1.84727990627289) - 0.00879593462275219*std::sin(0.350959837436676*x_37 + 5.16936016082764) - 0.00148840639051876*std::sin(0.35471984744072*x_37 + 5.16247987747192) - 0.0293411754453892*std::sin(0.259999960660934*x_40 - 1.3530398607254) + 0.0202482337822165*std::sin(0.302799940109253*x_41 - 7.49200010299683) - 0.00520217203075662*std::sin(0.352559834718704*x_43 - 4.44127988815308) + 0.0635640194192532*std::sin(0.225919991731644*x_45 - 7.56376028060913) - 0.00977807211421447*std::sin(0.283919870853424*x_47 - 1.28175985813141) + 0.0522586676270608*std::sin(0.200479999184608*x_53 + 5.00799989700317) + 0.00474249828355849*std::sin(0.325919836759567*x_53 - 4.27960014343262) - 0.00516006275902807*std::sin(0.489439845085144*x_53 + 8.49272060394287) + 0.0104643610975043*std::sin(0.362639844417572*x_55 + 5.16312026977539) - 0.00133572486089808*std::sin(0.516959846019745*x_57 - 4.06511974334717) - 0.0185531134964262*std::sin(0.375039845705032*x_58 - 4.22424030303955) - 0.0079358234348556*std::sin(0.437199860811234*x_58 + 5.21896028518677) + 0.0119414771944173*std::sin(0.261599957942963*x_59 + 1.86455988883972) + 0.00886517041111178*std::sin(0.281519949436188*x_63 + 1.87871992588043) - 0.00863194256319524*std::sin(0.307359933853149*x_64 - 7.48880004882813) + 0.00128252037580178*std::sin(0.521279871463776*x_65 - 0.857679903507233) + 0.000821023872030023*std::sin(0.837119877338409*x_73 - 7.18088006973267) + 0.0273588486475333*std::sin(0.279839843511581*x_75 + 8.11103916168213) - 0.00636471593935439*std::sin(0.463439851999283*x_75 + 8.23503971099854) + 0.00570918115834693*std::sin(0.480639845132828*x_75 - 1.13143992424011) - 0.000629014805941812*std::sin(0.486399859189987*x_75 - 1.11623990535736) + 0.000593529664748913*std::sin(0.545119881629944*x_75 + 5.16215991973877) + 0.000254613289673*std::sin(0.5065598487854*x_76 + 8.50568008422852) - 0.0227920351185031*std::sin(0.272239863872528*x_79 - 1.29615986347198) + 0.0110618830782422*std::sin(0.371999859809875*x_80 + 8.36744022369385) + 0.018020452910655*std::sin(0.34487983584404*x_83 - 7.46303987503052) - 0.00246151575279921*std::sin(0.226559981703758*x_84 - 7.58008003234863) + 0.0193393735897607*std::sin(0.261679977178574*x_84 + 1.87495994567871) + 0.0076610785918442*std::sin(0.291039943695068*x_87 - 7.48808002471924) + 0.00134269108316851*std::sin(0.934719800949097*x_87 - 3.82536005973816) - 8.41915063179227e-5*std::sin(1.00263977050781*x_87 - 6.9900803565979) + 0.00951445652010159*std::sin(0.23047998547554*x_92 + 4.82000017166138) - 0.00736397133231627*std::sin(0.331599831581116*x_92 - 7.40279960632324) - 0.00228367746497037*std::sin(0.354319840669632*x_92 + 1.98751986026764) - 0.0140864314871877*std::sin(0.354399859905243*x_92 + 8.18423938751221) - 0.0108858683959323*std::sin(0.359759837388992*x_92 + 1.99959981441498) - 0.00817224858137084*std::sin(0.37271985411644*x_92 - 4.39192008972168) + 0.00187476906961047*std::sin(0.416239857673645*x_92 - 7.59040021896362) - 0.00327790319154597*std::sin(0.465199857950211*x_92 - 4.61639976501465) + 0.000837502093281417*std::sin(0.372799843549728*x_94 - 1.18511986732483) + 0.0238199726504952*std::sin(0.319919854402542*x_95 + 1.95463979244232) - 0.00138521035752821*std::sin(0.341439843177795*x_95 - 7.4334397315979) + 0.0110966761131731*std::sin(0.348559856414795*x_95 - 1.22079980373383) + 0.011534582867479*std::sin(0.417919874191284*x_95 + 5.20168018341064) - 0.0239218778444721*std::sin(0.375199824571609*x_96 - 4.21479988098145) - 0.00486763797294396*std::sin(0.406559854745865*x_96 - 7.38735961914063) - 0.00460775185149712*std::sin(0.343359857797623*x_97 - 4.42447996139526) + 0.0164861932664961*std::sin(0.309119910001755*x_98 - 4.29047966003418) - 0.0171650666972157*std::sin(0.387199848890305*x_98 - 1.18119990825653) + 0.000522398535528437*std::sin(0.442879855632782*x_98 + 2.03743982315063) - 0.00812763631844737*std::sin(0.443519860506058*x_98 + 2.00271987915039) - 0.0321659854112756*std::sin(0.326079845428467*x_99 + 1.93167984485626) + 0.247038959758647 + 7.36316963522315e-5*std::exp(-1.33871984481812*x_9) + 1.98522918928554e-5*std::exp(-1.31719982624054*x_9) - 2.05125680806966e-5*std::exp(-1.29767978191376*x_9) + 0.000366762610492758*std::exp(-1.27743983268738*x_9) + 3.16196126974159e-7*std::exp(-2.84623980522156*x_79) + 2.86366465692404e-6*std::exp(-1.95879983901978*x_30));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0221074340985892*x_1 + 0.0106897815874179*x_10 + 0.00139640766166299*x_100 - 0.0216761055532244*x_101 - 0.00177740975305752*x_102 - 0.0320209107637781*x_103 + 0.000316831758522884*x_104 + 0.00118068246903754*x_105 - 0.000177160232375154*x_106 + 0.0450702848599975*x_107 + 0.000160402291333092*x_108 + 0.00105926426945198*x_109 + 0.0519672768837924*x_11 + 0.00385908435157271*x_110 + 0.00126585637083551*x_111 + 0.0442297457479426*x_112 - 0.00111541736152486*x_113 - 0.00171261838866674*x_114 - 0.00677902959725016*x_115 - 0.0247316259682456*x_116 + 0.0113473367246967*x_117 + 0.00869942588047154*x_118 - 0.014874243433083*x_119 - 0.0116539421547943*x_12 - 0.000520186608907157*x_120 + 0.0260898647302607*x_13 - 0.000198892937541547*x_14 + 6.83985606258576e-5*x_15 + 0.0112242329639909*x_16 + 0.00470751079079562*x_17 - 0.00737146342446036*x_18 + 0.0188013477669107*x_19 + 0.0216475527546505*x_2 - 0.0353553655631351*x_20 - 0.0130481770074454*x_21 + 0.00713316436471004*x_22 - 0.0450485161207541*x_23 + 0.000660962182231248*x_24 - 0.0679849857273059*x_25 - 0.00280892413395224*x_26 - 0.00560310265333338*x_27 + 0.025645818549585*x_28 + 0.0306374856009245*x_29 + 0.0559066642554018*x_3 + 0.0553877024494985*x_30 - 0.00141780017905261*x_31 + 0.0842973593953735*x_32 + 0.0215908346814967*x_33 + 0.0170572248967158*x_34 - 0.00773008800084554*x_35 - 0.0107943044164458*x_36 - 0.0062056033779432*x_37 + 0.052241932834866*x_38 + 0.00610823008011199*x_39 - 0.0185498940953889*x_4 - 0.00303505291127662*x_40 + 0.0509046211665077*x_41 - 0.0566015490982124*x_42 - 0.00223131293048512*x_43 + 0.123726659183344*x_44 + 0.000737757377101477*x_45 - 0.0462945046297195*x_46 + 0.0148562960159687*x_47 - 0.00481307812137403*x_48 - 0.00358445110936292*x_49 - 0.00247794807059474*x_5 + 0.00235502788405684*x_50 + 0.00814133620537317*x_51 + 0.0377759422406347*x_52 + 0.00243528308559999*x_53 + 0.0555415044021352*x_54 + 0.0329308456276446*x_55 + 0.00711899884625699*x_56 - 0.00571285870247979*x_57 - 0.0234924256177686*x_58 + 0.0407486678433774*x_59 + 0.020759994838305*x_6 + 0.00930281171309471*x_60 - 0.0455306848006852*x_61 + 0.0579713450817894*x_62 - 0.0481530323273031*x_63 + 0.012044582514526*x_64 - 0.00613915442040742*x_65 + 0.000155219067624834*x_66 - 0.0228994732025576*x_67 - 0.00487154590981712*x_68 - 0.0235873513026158*x_69 + 0.0312409143024661*x_7 + 0.00167682043527126*x_70 + 0.00643796598764465*x_71 + 0.00993203830833323*x_72 + 0.0341360181862565*x_73 + 0.0270279084432566*x_74 + 0.00494638005930015*x_75 - 0.00910233303557381*x_76 + 0.0352291939715755*x_77 - 0.0174573256321367*x_78 + 0.0138069205763121*x_79 + 0.080448232765571*x_8 - 0.000238202477343007*x_80 + 0.00220954439269261*x_81 - 0.00889326609204906*x_82 + 0.0454353060709683*x_83 - 0.000588025022310421*x_84 - 0.0232283332179605*x_85 + 0.0096779054949168*x_86 + 0.0256166861953105*x_87 - 0.0150983619641979*x_88 + 0.0269675771091656*x_89 - 0.00242165148305551*x_9 + 0.0099297269200183*x_90 - 0.00103997261399493*x_91 - 0.0219225340343958*x_92 + 0.109283722241514*x_93 + 0.0175881893257724*x_94 - 0.00247119892364063*x_95 + 0.00324054824892584*x_96 + 0.0101821863219389*x_97 - 0.000149313534811678*x_98 - 0.000616636802377108*x_99 - 0.000182404516036092*std::pow(-9.94719982147217*x_102 - 9.78800010681152, 2) + 0.000290383956078512*std::pow(-7.96016025543213*x_104 - 9.15664005279541, 2) - 0.000324623364639952*std::pow(-6.34000015258789*x_108 - 9.19999980926514, 2) + 1.15665069720297e-5*std::pow(-7.53336048126221*x_110 - 9.12399959564209, 2) + 2.36685104303162e-7*std::pow(-6.82224035263062*x_112 - 7.22352027893066, 2) - 6.05386030549081e-6*std::pow(-8.39915943145752*x_114 - 7.57599973678589, 2) - 4.93320967081455e-6*std::pow(-7.7480001449585*x_115 - 7.5417594909668, 2) - 7.87868705452136e-6*std::pow(-4.07359981536865*x_13 - 6.10303974151611, 2) + 4.86159075839912e-6*std::pow(-6.60400009155273*x_14 - 9.97567939758301, 2) + 7.48131886852761e-6*std::pow(-8.70680046081543*x_15 - 9.9235200881958, 2) + 2.11960809345639e-5*std::pow(-4.7579197883606*x_15 - 6.15079975128174, 2) + 3.66269772542083e-5*std::pow(-4.46928024291992*x_15 - 5.25055980682373, 2) - 9.23855165944141e-6*std::pow(-4.34728002548218*x_24 - 5.5318398475647, 2) + 6.41476559997794e-6*std::pow(-7.32087993621826*x_27 - 8.55039978027344, 2) + 4.0974621482181e-6*std::pow(-5.54271984100342*x_36 - 6.56727981567383, 2) - 1.53655293854813e-6*std::pow(-9.39496040344238*x_39 - 8.79872035980225, 2) + 3.62192685375056e-5*std::pow(-4.88320016860962*x_4 - 8.13959980010986, 2) - 8.16985486922286e-7*std::pow(-5.77159976959229*x_47 - 3.50111985206604, 2) + 6.61348555361546e-6*std::pow(-6.14759969711304*x_53 - 5.93872022628784, 2) + 7.11619904427607e-6*std::pow(-5.93631982803345*x_57 - 7.71104001998901, 2) - 0.000624360072826875*std::pow(-4.32000017166138*x_57 - 6.7828803062439, 2) - 1.82173646584899e-5*std::pow(-5.4871997833252*x_6 - 8.73799991607666, 2) - 4.97789861851414e-6*std::pow(-8.86295986175537*x_67 - 9.87448024749756, 2) + 1.02881541831114e-5*std::pow(-6.9117603302002*x_70 - 9.48536014556885, 2) + 0.000304182679009097*std::pow(-5.01503992080688*x_70 - 7.41752004623413, 2) - 1.00691287910646e-5*std::pow(-4.91472005844116*x_70 - 6.55808019638062, 2) - 6.49474812180494e-6*std::pow(-6.60000038146973*x_72 - 9.96523952484131, 2) - 7.88770621246553e-6*std::pow(-5.69008016586304*x_73 - 7.72512006759644, 2) + 1.54921699909784e-5*std::pow(-5.29624032974243*x_75 - 7.53200006484985, 2) - 8.21075684465586e-6*std::pow(-9.12207984924316*x_81 - 9.71424007415771, 2) + 1.06236511918244e-5*std::pow(-7.73016023635864*x_82 - 8.14496040344238, 2) - 0.00011635318569034*std::pow(-9.88728046417236*x_84 - 8.88064002990723, 2) + 0.000459889350507437*std::pow(-1.53071987628937*x_86 - 2.10567998886108, 2) - 6.67390901145998e-6*std::pow(-9.37191963195801*x_89 - 9.57999992370605, 2) + 7.14254367862212e-6*std::pow(-6.53375959396362*x_90 - 6.33328008651733, 2) - 2.9099905160292e-6*std::pow(-7.40248012542725*x_97 - 5.45391988754272, 2) - 4.36773890275321e-5*std::exp(1.01567983627319*x_1) + 5.96196609426353e-5*std::exp(1.11351990699768*x_1) + 3.99923638628901e-5*std::exp(1.14375984668732*x_1) - 2.18936515940084e-5*std::exp(1.20751988887787*x_1) + 7.72214248676312e-6*std::exp(1.21103978157043*x_1) + 1.88537510539483e-6*std::exp(1.25095987319946*x_1) - 4.92862727472754e-5*std::exp(1.2611198425293*x_1) - 5.87134772354221e-6*std::exp(1.30063986778259*x_1) + 1.09714995313789e-6*std::exp(1.32463979721069*x_1) + 1.55622784048176e-6*std::exp(1.35039985179901*x_1) - 3.13325755224034e-6*std::exp(1.37815976142883*x_1) + 4.15549034715474e-5*std::exp(1.6387197971344*x_100) + 6.1693931119934e-5*std::exp(1.64639985561371*x_100) - 4.43581820547094e-5*std::exp(1.64719986915588*x_100) - 4.2424630417679e-5*std::exp(1.6736798286438*x_100) - 1.94000739403748e-5*std::exp(1.71871984004974*x_100) - 0.000114357144795334*std::exp(1.7293598651886*x_100) - 5.94520142437017e-6*std::exp(1.82271993160248*x_100) + 0.00555922380836348*std::exp(0.659519851207733*x_104) + 0.000794858480286311*std::exp(0.859919905662537*x_104) - 0.000242276901691221*std::exp(0.884479880332947*x_104) + 0.00039862788138724*std::exp(1.06447982788086*x_104) - 0.00021128791437329*std::exp(1.13271987438202*x_104) - 1.41682406345962e-5*std::exp(1.14023983478546*x_104) - 0.00154849600472852*std::exp(0.803759872913361*x_106) - 0.000723311402471571*std::exp(0.869199872016907*x_106) + 0.0162391253484656*std::exp(1.24255990982056*x_106) - 0.000302583652915608*std::exp(0.543359875679016*x_108) + 0.000181518144967853*std::exp(0.810959875583649*x_109) - 0.0214786934458932*std::exp(1.05311989784241*x_109) + 0.000212584587483282*std::exp(1.09655976295471*x_109) + 0.00183445811862289*std::exp(0.613439857959747*x_110) - 1.00712050140395e-5*std::exp(1.4670398235321*x_110) + 0.000109737267747914*std::exp(1.47447991371155*x_110) - 1.82957135965437e-5*std::exp(1.51207983493805*x_110) + 4.81606982386155e-6*std::exp(1.52231991291046*x_110) + 3.71483061085318e-6*std::exp(1.54567980766296*x_110) - 2.21168238967575e-5*std::exp(1.62999987602234*x_110) - 3.70088943362041e-6*std::exp(1.70063984394073*x_110) + 3.05571322612417e-5*std::exp(1.7707998752594*x_110) + 0.00115485979139785*std::exp(0.520319879055023*x_112) - 0.00133373951827437*std::exp(0.539999842643738*x_112) + 0.000765573668761627*std::exp(0.687439858913422*x_112) - 0.000875552989908592*std::exp(0.755039870738983*x_112) + 0.000161128983761694*std::exp(0.784239888191223*x_112) + 2.04837354668828e-5*std::exp(1.93039989471436*x_19) - 2.16384812132428e-5*std::exp(1.56215977668762*x_23) + 5.84420764576045e-6*std::exp(2.14359974861145*x_23) - 0.000544702162425218*std::exp(0.799119830131531*x_26) + 0.023758713026496*std::exp(0.807999849319458*x_26) + 0.000304564443553682*std::exp(0.858239889144897*x_26) + 5.66193593805017e-6*std::exp(1.01599979400635*x_26) - 7.07238694477902e-5*std::exp(1.09751987457275*x_26) + 2.62715368546225e-5*std::exp(1.21999990940094*x_26) + 7.84846802751423e-6*std::exp(1.22783982753754*x_26) + 5.49985661832109e-5*std::exp(1.26031982898712*x_26) + 1.91607790271702e-5*std::exp(1.3005598783493*x_26) + 3.65944894845551e-6*std::exp(1.30919981002808*x_26) + 3.13047404218703e-5*std::exp(1.40287983417511*x_26) + 4.75310743362197e-6*std::exp(1.43151986598969*x_26) - 0.000696878360518463*std::exp(0.481919854879379*x_31) + 0.0284151734709244*std::exp(0.533999860286713*x_31) + 0.00013887430948159*std::exp(0.613279819488525*x_31) + 0.000710068188944632*std::exp(0.624479830265045*x_31) - 0.00164372401279937*std::exp(0.631679832935333*x_31) + 0.00220699314298682*std::exp(0.63375985622406*x_31) + 0.00270868962424513*std::exp(0.642559826374054*x_31) + 0.00140902506862857*std::exp(0.643519818782806*x_31) + 0.00478187585924866*std::exp(0.653599858283997*x_31) - 0.000339926488545086*std::exp(0.653999865055084*x_31) - 0.00683545454547789*std::exp(0.658079862594604*x_31) + 0.00105906288194344*std::exp(0.669439852237701*x_31) + 0.00121019087539508*std::exp(0.889039874076843*x_45) + 8.56749179199064e-5*std::exp(1.03455984592438*x_45) + 0.000163821401380432*std::exp(1.16495990753174*x_45) + 0.00102214470169987*std::exp(0.592399835586548*x_49) + 6.45113639558608e-5*std::exp(0.920399844646454*x_49) + 8.56547851586157e-5*std::exp(1.16799986362457*x_50) + 9.81846542879333e-6*std::exp(1.40543985366821*x_50) + 0.00053790278244448*std::exp(1.40831983089447*x_50) - 5.5628138339209e-6*std::exp(2.2727198600769*x_50) - 0.000770419661745375*std::exp(1.14879977703094*x_6) + 3.09166899638705e-6*std::exp(1.83743989467621*x_6) + 4.43898171616543e-6*std::exp(2.31103992462158*x_6) - 6.97289596064915e-6*std::exp(2.35487985610962*x_6) - 8.3665540952971e-6*std::exp(2.37303996086121*x_6) + 1.85351559884936e-5*std::exp(0.849839866161346*x_60) - 0.000251676470484367*std::exp(1.153599858284*x_60) - 0.000400533227697217*std::exp(1.47215986251831*x_60) + 0.000219644975846314*std::exp(0.834719896316528*x_66) - 0.000653896560381896*std::exp(0.882879853248596*x_66) + 0.000179464202554732*std::exp(1.08591985702515*x_66) - 9.00034593274288e-5*std::exp(1.20335984230042*x_66) - 5.28185968842018e-5*std::exp(1.46271991729736*x_66) + 0.000291822454582063*std::exp(1.46623992919922*x_66) - 0.00159005017451723*std::exp(0.759039878845215*x_68) + 0.000194857365258584*std::exp(1.16567981243134*x_68) + 4.21535720931933e-5*std::exp(1.29567980766296*x_68) + 0.000344354881275072*std::exp(1.29711985588074*x_68) + 0.000397478797183735*std::exp(1.39703989028931*x_68) - 0.00208837274458002*std::exp(0.700399875640869*x_70) + 0.000211200154405554*std::exp(0.794639885425568*x_70) + 3.54798849644715e-5*std::exp(1.14799988269806*x_70) + 0.000289491113594171*std::exp(1.35863983631134*x_72) + 0.000299692891784188*std::exp(0.845839858055115*x_74) + 0.000493377654354461*std::exp(0.96727979183197*x_74) - 0.000917787156989351*std::exp(1.12551987171173*x_74) + 7.78517089247126e-5*std::exp(1.40063989162445*x_74) + 6.25173082844362e-5*std::exp(1.43639981746674*x_74) + 1.1085435524076e-5*std::exp(1.64263987541199*x_74) + 3.93746405072838e-6*std::exp(1.78703987598419*x_74) + 3.97335501284761e-6*std::exp(1.80823993682861*x_74) - 0.000500925865492305*std::exp(0.836559891700745*x_78) - 0.000194952853726356*std::exp(0.914959847927094*x_78) + 0.000715450648962897*std::exp(1.47279977798462*x_81) - 5.67917509705199e-5*std::exp(1.6276798248291*x_81) - 7.7227482044337e-5*std::exp(1.77087986469269*x_81) + 8.76720714096103e-5*std::exp(1.93223989009857*x_81) + 1.01705941472078e-5*std::exp(2.02951979637146*x_81) + 0.0103535832737245*std::sin(0.38487982749939*x_10 - 7.40855979919434) + 0.000276591280062804*std::sin(0.309519857168198*x_101 - 7.45863962173462) + 0.00708882832654681*std::sin(0.521039843559265*x_104 - 1.01975977420807) - 0.0108964841845427*std::sin(0.301359832286835*x_105 - 1.27151989936829) - 0.0120428863526723*std::sin(0.375199824571609*x_105 - 7.41279983520508) - 0.00736951913048188*std::sin(0.41023987531662*x_105 + 5.21456003189087) - 0.00213202421228798*std::sin(0.537359833717346*x_109 + 2.17647981643677) + 0.0033819413615274*std::sin(0.45991986989975*x_111 - 4.37863969802856) - 0.000251459791341143*std::sin(0.482159852981567*x_111 + 8.4420804977417) + 0.00660016738145672*std::sin(0.476239860057831*x_112 + 2.20975995063782) - 0.0972526966492665*std::sin(0.320559859275818*x_114 - 4.27320003509521) - 0.011257543578192*std::sin(0.153680041432381*x_115 - 7.64736032485962) - 0.000456415652443071*std::sin(0.341359853744507*x_115 - 7.4410400390625) - 0.000735387047560868*std::sin(0.426559865474701*x_115 + 8.20335960388184) - 0.00281404525486521*std::sin(0.485759854316711*x_115 + 8.46312046051025) - 0.00586369334089165*std::sin(0.39455983042717*x_119 - 1.20143985748291) - 0.00388534519106869*std::sin(0.347039848566055*x_120 - 7.45527982711792) + 0.00237208037386317*std::sin(0.556639850139618*x_120 + 2.15871977806091) - 0.00614973246866525*std::sin(0.683679819107056*x_120 - 3.97000002861023) - 0.000827984083580979*std::sin(1.00343978404999*x_15 - 4.19184017181396) + 0.00405395811936206*std::sin(0.397839844226837*x_16 + 5.19200038909912) + 0.0257846505045834*std::sin(0.122640058398247*x_21 - 7.69304037094116) + 0.413434142362486*std::sin(0.22503998875618*x_24 - 4.36663961410522) - 0.00681165305774996*std::sin(0.373199820518494*x_24 - 4.21591997146606) + 0.0155831179603264*std::sin(0.205360010266304*x_27 + 1.81271994113922) - 0.158378391052718*std::sin(0.129680052399635*x_31 + 1.61399984359741) - 0.0213017637283433*std::sin(0.255439966917038*x_33 + 8.20495986938477) + 0.00221667202186969*std::sin(0.303839921951294*x_34 + 2.04215979576111) + 0.000294589960148842*std::sin(0.359999865293503*x_34 + 8.20528030395508) + 0.00432553958033616*std::sin(0.363679856061935*x_34 - 1.19727993011475) - 0.007410332727716*std::sin(0.304559946060181*x_35 - 4.34575986862183) + 0.00538900739810994*std::sin(0.309119910001755*x_35 + 5.06063985824585) - 0.00546894005072367*std::sin(0.317599833011627*x_35 - 7.43192005157471) + 0.015060736094351*std::sin(0.320879846811295*x_35 + 1.97183978557587) + 0.00146988943036614*std::sin(0.328239858150482*x_35 - 7.43264007568359) + 0.00833007245729025*std::sin(0.341359823942184*x_35 - 7.42399978637695) + 0.0098324334212985*std::sin(0.338959842920303*x_36 + 5.15104007720947) - 0.00317808092831813*std::sin(0.395039856433868*x_36 + 5.19752025604248) - 0.000399074752395765*std::sin(0.416319847106934*x_36 - 4.18847990036011) - 0.00164052326767643*std::sin(0.425919860601425*x_36 - 7.38391971588135) + 0.00366970091131317*std::sin(0.457439839839935*x_36 - 4.15664005279541) + 0.00343897568992322*std::sin(0.237759977579117*x_37 + 5.03343963623047) + 0.77987750058677*std::sin(0.247599974274635*x_37 + 1.84727990627289) + 0.00612521059836612*std::sin(0.350959837436676*x_37 + 5.16936016082764) + 0.000676514140421265*std::sin(0.35471984744072*x_37 + 5.16247987747192) + 0.0260830512332378*std::sin(0.259999960660934*x_40 - 1.3530398607254) - 0.0179998146327544*std::sin(0.302799940109253*x_41 - 7.49200010299683) + 0.0129496641044009*std::sin(0.352559834718704*x_43 - 4.44127988815308) - 0.713847176345145*std::sin(0.225919991731644*x_45 - 7.56376028060913) - 0.00715504866216302*std::sin(0.283919870853424*x_47 - 1.28175985813141) - 0.586883942613569*std::sin(0.200479999184608*x_53 + 5.00799989700317) - 0.00509726164013978*std::sin(0.325919836759567*x_53 - 4.27960014343262) - 0.0037758465788966*std::sin(0.489439845085144*x_53 + 8.49272060394287) + 0.00765723672279377*std::sin(0.362639844417572*x_55 + 5.16312026977539) + 0.00247277423464513*std::sin(0.516959846019745*x_57 - 4.06511974334717) + 0.00402803664392119*std::sin(0.375039845705032*x_58 - 4.22424030303955) - 0.00580699366781946*std::sin(0.437199860811234*x_58 + 5.21896028518677) + 0.00873810802642358*std::sin(0.261599957942963*x_59 + 1.86455988883972) + 0.00567403075686469*std::sin(0.281519949436188*x_63 + 1.87871992588043) + 0.000821701889767325*std::sin(0.307359933853149*x_64 - 7.48880004882813) - 0.000278445936920522*std::sin(0.521279871463776*x_65 - 0.857679903507233) - 0.000882440696509333*std::sin(0.837119877338409*x_73 - 7.18088006973267) - 0.00260437525747562*std::sin(0.279839843511581*x_75 + 8.11103916168213) + 0.00443218682258976*std::sin(0.463439851999283*x_75 + 8.23503971099854) + 0.00417766084478895*std::sin(0.480639845132828*x_75 - 1.13143992424011) + 0.000285901359645237*std::sin(0.486399859189987*x_75 - 1.11623990535736) + 0.00173295074407021*std::sin(0.545119881629944*x_75 + 5.16215991973877) - 0.00387534040847506*std::sin(0.5065598487854*x_76 + 8.50568008422852) + 0.0202611453250109*std::sin(0.272239863872528*x_79 - 1.29615986347198) - 0.124228991064582*std::sin(0.371999859809875*x_80 + 8.36744022369385) - 0.0193684758258899*std::sin(0.34487983584404*x_83 - 7.46303987503052) + 0.00111881420574791*std::sin(0.226559981703758*x_84 - 7.58008003234863) - 0.0207860585812279*std::sin(0.261679977178574*x_84 + 1.87495994567871) - 0.00533493276135756*std::sin(0.291039943695068*x_87 - 7.48808002471924) - 0.00144313130834857*std::sin(0.934719800949097*x_87 - 3.82536005973816) + 3.8266930920385e-5*std::sin(1.00263977050781*x_87 - 6.9900803565979) - 0.000905711182093705*std::sin(0.23047998547554*x_92 + 4.82000017166138) - 0.00471320887186333*std::sin(0.331599831581116*x_92 - 7.40279960632324) + 0.00422768113473731*std::sin(0.354319840669632*x_92 + 1.98751986026764) + 0.0125222356840359*std::sin(0.354399859905243*x_92 + 8.18423938751221) - 0.00796567229132727*std::sin(0.359759837388992*x_92 + 1.99959981441498) + 0.00177426375122082*std::sin(0.37271985411644*x_92 - 4.39192008972168) - 0.00466682562230545*std::sin(0.416239857673645*x_92 - 7.59040021896362) + 0.00228262808108427*std::sin(0.465199857950211*x_92 - 4.61639976501465) + 0.00394605377844553*std::sin(0.372799843549728*x_94 - 1.18511986732483) - 0.267507001170291*std::sin(0.319919854402542*x_95 + 1.95463979244232) - 0.00652668764545925*std::sin(0.341439843177795*x_95 - 7.4334397315979) + 0.00811992963956515*std::sin(0.348559856414795*x_95 - 1.22079980373383) - 0.0102537513006747*std::sin(0.417919874191284*x_95 + 5.20168018341064) + 0.268651433754006*std::sin(0.375199824571609*x_96 - 4.21479988098145) - 0.00311546493648313*std::sin(0.406559854745865*x_96 - 7.38735961914063) + 0.00100038159673315*std::sin(0.343359857797623*x_97 - 4.42447996139526) - 0.0114804634247108*std::sin(0.309119910001755*x_98 - 4.29047966003418) + 0.192769974358671*std::sin(0.387199848890305*x_98 - 1.18119990825653) - 0.000237441869688004*std::sin(0.442879855632782*x_98 + 2.03743982315063) - 0.00594735165455734*std::sin(0.443519860506058*x_98 + 2.00271987915039) + 0.361235775679146*std::sin(0.326079845428467*x_99 + 1.93167984485626) - 1.96590536442933 - 0.000183289927661227*std::exp(-1.33871984481812*x_9) - 0.000302161717764346*std::exp(-1.31719982624054*x_9) - 5.98913116386053e-5*std::exp(-1.29767978191376*x_9) - 0.000326036289095635*std::exp(-1.27743983268738*x_9) - 3.81368281166722e-7*std::exp(-2.84623980522156*x_79) - 1.99416547064663e-6*std::exp(-1.95879983901978*x_30));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
