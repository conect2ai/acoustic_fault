
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (6.01206711319061*x_1 + 5.28292581581832*x_10 - 0.665683220972545*x_100 + 0.211186934980063*x_101 + 0.0289659103980542*x_102 - 0.0365373621219621*x_103 + 12.0924638906113*x_104 + 0.353322516015551*x_105 - 2.06206526613569*x_106 - 0.147546551508404*x_107 + 0.900707306375494*x_108 + 0.289836326902832*x_109 + 0.778547914072365*x_11 + 1.26953477532765*x_110 + 0.546336807128131*x_111 - 0.859483905690057*x_112 - 0.521211778479348*x_113 - 0.447195934585643*x_114 + 0.642727896568565*x_115 - 4.28789460605246*x_116 - 1.20405029567122*x_117 + 0.326856617887615*x_118 - 1.00923414640997*x_119 - 3.16710230366102*x_12 + 0.570534375367335*x_120 + 0.468323075091511*x_13 - 5.81587164422045*x_14 + 0.276897930195525*x_15 + 0.206929835021668*x_16 - 0.751834088873219*x_17 - 10.2716692579249*x_18 + 9.69069464102096*x_19 - 0.342121747493352*x_2 + 2.4388903108777*x_20 - 5.74023412982631*x_21 + 0.0718337662843632*x_22 - 8.27131780933233*x_23 + 4.99470964570503*x_24 - 0.44536446871632*x_25 - 1.91257219868793*x_26 + 2.12025785068794*x_27 + 25.547160168034*x_28 - 32.3704280482988*x_29 - 0.427468069300597*x_3 - 0.606880393501722*x_30 + 0.44581203346553*x_31 - 0.911719122199401*x_32 - 0.592679961694336*x_33 + 93.0021972053469*x_34 - 0.0445205549066906*x_35 - 7.09777305026218*x_36 - 44.1711764751283*x_37 + 0.733101793226718*x_38 + 27.1600441425549*x_39 - 3.84132744881639*x_4 - 1.30123935786293*x_40 - 60.2783564551279*x_41 - 76.9241817523542*x_42 - 32.3232526814475*x_43 + 0.0897376611871789*x_44 - 26.7022474251123*x_45 + 7.96956578183292*x_46 - 35.4393439917188*x_47 - 3.5258912257529*x_48 - 17.5063524466987*x_49 - 0.847815462793704*x_5 + 39.2397597254573*x_50 + 0.0269547464344884*x_51 - 0.191660107171425*x_52 - 5.84139520517342*x_53 + 10.1363791235257*x_54 + 14.0653661282779*x_55 - 28.2355749691159*x_56 - 6.39342835713852*x_57 - 23.8690306841194*x_58 - 50.8697932733089*x_59 + 0.00328130578701994*x_6 - 0.505441227432866*x_60 + 0.566635425666453*x_61 - 1.28011400814317*x_62 + 0.060903774901202*x_63 - 0.408245405230448*x_64 - 0.0781220382991624*x_65 - 1.34239052966307*x_66 - 0.627074071095901*x_67 + 0.156105219181162*x_68 - 0.121208984709471*x_69 + 0.0149859310840512*x_7 + 0.624872028397954*x_70 + 0.240569055985909*x_71 - 0.221475907277697*x_72 - 0.363068147811649*x_73 - 0.425332952118283*x_74 - 0.640703787086833*x_75 + 0.290516226360105*x_76 - 0.475967011724838*x_77 - 0.315454515699045*x_78 + 0.285585272399119*x_79 + 0.0420311304946583*x_8 - 0.457823354656113*x_80 + 0.044364850542777*x_81 - 0.45861108704089*x_82 - 2.16754083679779*x_83 - 1.24583604373083*x_84 - 27.0770451587749*x_85 - 2.24404759894816*x_86 + 32.3797585551896*x_87 - 0.53379062344844*x_88 - 1.45734741355801*x_89 - 1.08909566363029*x_9 + 0.574620227515079*x_90 - 0.153427058750388*x_91 - 1.76138831892539*x_92 - 0.788402823826152*x_93 - 0.0437229920460496*x_94 - 0.109970032350345*x_95 + 0.694297578929919*x_96 + 0.197383104311778*x_97 + 0.0053455615261928*x_98 + 0.380828380673755*x_99 + 0.00579834949512608*std::exp(1.00599980354309*x_13) - 0.00104649248334803*std::exp(0.959599852561951*x_23) - 0.0234351832860363*std::exp(0.991999804973602*x_23) - 0.00119579137957265*std::exp(0.838239848613739*x_24) + 0.00315282695969523*std::exp(0.643119871616364*x_3) + 0.000812324859687629*std::exp(0.919679820537567*x_4) - 8.68879699766656e-5*std::exp(1.44239985942841*x_6) - 0.00638434736378638*std::exp(1.61327981948853*x_6) - 0.00058432214513821*std::exp(1.63687980175018*x_6) + 0.000518259279920012*std::exp(1.6503199338913*x_6) - 0.0267604989472211*std::exp(0.971999824047089*x_8) + 3.24330999560062*std::sin(0.227359995245934*x_109 - 7.42807960510254) + 0.0299664490008254*std::sin(0.209120005369186*x_118 - 7.39463996887207) + 5.10943527053524*std::sin(0.285039931535721*x_49 - 1.14103984832764) + 1.9332871413889*std::sin(0.339839845895767*x_91 + 5.18584012985229) - 0.304732048105438*std::sin(0.344159841537476*x_91 + 1.99103975296021) + 0.892305399339533*std::sin(0.295999944210052*x_94 - 1.20031988620758) - 0.0378146491996184*std::sin(0.258559972047806*x_95 + 1.98215985298157) - 926.916046889908 + 3.30830973033654e-7*std::exp(-8.0653600692749*x_113));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-23.0939507739424*x_1 - 3.1280650331609*x_10 + 1.90451228996358*x_100 - 0.33546812190771*x_101 - 0.313261015596428*x_102 + 0.259368958694439*x_103 - 23.0863224385576*x_104 - 1.92083872673958*x_105 + 2.63287638926164*x_106 - 0.0734221662369999*x_107 - 1.99724543926671*x_108 - 0.840328340789492*x_109 - 10.7857369161881*x_11 - 3.56926350605092*x_110 - 1.56685486694866*x_111 + 2.21553770799403*x_112 + 1.84704255188098*x_113 + 0.7525447777646*x_114 - 2.47672930061984*x_115 + 16.8749589285892*x_116 + 4.18440317985678*x_117 - 0.790059009353824*x_118 + 2.71143779942049*x_119 + 9.97763016476926*x_12 - 1.73934656416098*x_120 - 0.266356345241453*x_13 + 15.5201907482944*x_14 - 2.83802058690325*x_15 - 0.419091548205211*x_16 - 1.06910223757921*x_17 + 29.1789832465264*x_18 - 20.766207366386*x_19 + 1.1097615971173*x_2 - 5.65198308036106*x_20 + 11.6495306061219*x_21 + 24.830310627608*x_22 + 40.3036774584782*x_23 + 12.069205775357*x_24 + 1.81063070018582*x_25 - 3.91513483979456*x_26 - 9.53275025953274*x_27 - 71.5287993101656*x_28 + 114.625922695667*x_29 + 1.65803854397564*x_3 - 1.16373669323647*x_30 - 1.62864463919465*x_31 + 2.87225341904158*x_32 - 1.0397235283395*x_33 - 241.273947788528*x_34 + 1.1845437978372*x_35 + 19.1719619014666*x_36 + 155.722958406276*x_37 - 0.669438046062632*x_38 - 79.2809083560239*x_39 + 22.3262135838704*x_4 + 2.87787061445648*x_40 + 289.850144514103*x_41 + 223.116161639644*x_42 + 97.4789082856798*x_43 - 0.63061234407994*x_44 - 22.4530941162942*x_45 - 63.445062243529*x_46 + 93.863377035928*x_47 + 13.6073109220305*x_48 + 11.2473611710925*x_49 + 2.31589963795761*x_5 - 84.7673548696965*x_50 - 0.577492950992891*x_51 + 4.19663930103591*x_52 + 3.40753541971793*x_53 - 24.9320296649926*x_54 - 21.2957480552248*x_55 + 48.8133410201554*x_56 + 16.2603161515137*x_57 + 31.3527811133624*x_58 + 95.9574421969565*x_59 + 0.0074776052434237*x_6 + 5.4298196997258*x_60 - 1.56101437507249*x_61 + 1.31344615046356*x_62 - 0.112323516020546*x_63 + 1.2227222028765*x_64 + 0.272071998703919*x_65 + 4.14577707845026*x_66 + 1.85770677396986*x_67 - 0.57761388303044*x_68 + 0.00166576916198564*x_69 + 0.422527654813399*x_7 - 1.36370949487096*x_70 - 0.461248904431436*x_71 - 0.209223384475652*x_72 + 1.45938639082316*x_73 + 3.39622934661323*x_74 + 1.65742252338673*x_75 - 1.20361175844807*x_76 + 1.20807126817927*x_77 + 0.113032030789985*x_78 - 0.94907746371225*x_79 - 0.172317631195375*x_8 + 0.723592351754375*x_80 - 0.0569360758924683*x_81 + 1.73815412254093*x_82 + 5.67542569841563*x_83 + 0.843487564947845*x_84 + 90.6352477599759*x_85 + 5.459855593287*x_86 - 117.7817961418*x_87 + 1.26796333073312*x_88 + 3.84334988553214*x_89 + 1.70417262800731*x_9 - 1.06791946655533*x_90 + 0.104915230089311*x_91 + 3.67156925418939*x_92 + 1.6721772943605*x_93 + 0.0249511303321944*x_94 + 0.625664197853193*x_95 - 1.00925622457686*x_96 + 0.0324298782634447*x_97 + 0.644235532892217*x_98 - 0.565196359686863*x_99 - 0.0177323859840612*std::exp(1.00599980354309*x_13) - 0.0023847998902271*std::exp(0.959599852561951*x_23) - 0.00671621227124757*std::exp(0.991999804973602*x_23) - 0.00477488171518978*std::exp(0.838239848613739*x_24) + 0.0125894667399143*std::exp(0.643119871616364*x_3) + 0.00324367208659988*std::exp(0.919679820537567*x_4) - 0.000346949966523265*std::exp(1.44239985942841*x_6) + 0.0195244718874128*std::exp(1.61327981948853*x_6) + 0.000372825975388286*std::exp(1.63687980175018*x_6) + 0.000148526226272815*std::exp(1.6503199338913*x_6) + 0.0818383743265319*std::exp(0.971999824047089*x_8) - 2.06938967255873*std::sin(0.227359995245934*x_109 - 7.42807960510254) + 0.119658204472376*std::sin(0.209120005369186*x_118 - 7.39463996887207) - 15.6255635252522*std::sin(0.285039931535721*x_49 - 1.14103984832764) - 5.91233657749441*std::sin(0.339839845895767*x_91 + 5.18584012985229) - 0.0873321576344414*std::sin(0.344159841537476*x_91 + 1.99103975296021) - 2.72882891416782*std::sin(0.295999944210052*x_94 - 1.20031988620758) - 0.086173931198926*std::sin(0.258559972047806*x_95 + 1.98215985298157) + 4868.07922117316 + 1.32103207210056e-6*std::exp(-8.0653600692749*x_113));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-9.73152354727199*x_1 + 30.2900648996399*x_10 - 0.382728677653565*x_100 + 0.590303628524968*x_101 - 0.633249536588769*x_102 - 0.194392498728613*x_103 + 40.8672789451596*x_104 - 1.48197832656854*x_105 - 7.6978496328202*x_106 - 1.39497815900166*x_107 + 1.49181016549813*x_108 + 0.0662119244440852*x_109 - 21.2023369050684*x_11 + 0.291853076499653*x_110 - 0.283267192833574*x_111 - 0.726281355779484*x_112 + 0.238487258247691*x_113 - 1.53215330487235*x_114 - 1.73225493860638*x_115 + 9.59376825807855*x_116 + 0.784769151862117*x_117 + 0.431190568774657*x_118 - 1.50425730699064*x_119 - 2.85858712359716*x_12 + 0.550491985703349*x_120 + 2.348367035207*x_13 - 5.26412981433292*x_14 - 3.32237731226025*x_15 + 0.420954136120733*x_16 - 7.76451099745308*x_17 + 4.88545503067062*x_18 + 24.8496729183815*x_19 - 0.254374743568484*x_2 + 6.01200846645177*x_20 - 17.7381212015903*x_21 + 55.1781035808374*x_22 + 35.6732552996514*x_23 + 71.2053785042627*x_24 + 1.99141229786434*x_25 - 19.13824632537*x_26 + 4.37037442288069*x_27 + 77.7632945956267*x_28 + 22.7108090587877*x_29 + 0.78764660090453*x_3 - 3.25241990741929*x_30 - 0.4389328226048*x_31 - 0.316879849090658*x_32 - 8.77855908516131*x_33 + 141.363040492965*x_34 + 2.77746149439459*x_35 - 6.17232470342137*x_36 + 1.38353411341361*x_37 + 1.35127268934432*x_38 + 18.3510124764873*x_39 + 24.7762470063679*x_4 - 3.01884270286416*x_40 + 481.75123922152*x_41 - 83.5653461445467*x_42 - 5.9026829723793*x_43 - 0.591158753920144*x_44 - 228.501236320623*x_45 - 141.965930693084*x_46 - 31.1991634949817*x_47 + 6.75290679453876*x_48 - 104.645194814118*x_49 - 1.37427366274493*x_5 + 68.1097749510057*x_50 - 2.88300437645202*x_51 + 17.7279369386366*x_52 - 33.5574840961255*x_53 + 15.0327598068161*x_54 + 42.7679391128755*x_55 - 85.4117381395379*x_56 - 5.06627808175272*x_57 - 106.827851243826*x_58 - 212.579082719209*x_59 + 0.0116027349806323*x_6 + 7.85226628561561*x_60 - 0.162496130687553*x_61 - 5.02641474264106*x_62 + 0.276883517552298*x_63 + 0.0073317855153566*x_64 - 0.296189600597346*x_65 - 0.4878254601875*x_66 - 0.404082490140121*x_67 - 0.527127027120867*x_68 - 0.374920292961698*x_69 + 0.230535075874381*x_7 + 1.51547548870268*x_70 + 0.33694768911228*x_71 - 1.85369715524269*x_72 + 1.2376473224869*x_73 + 4.4875405959577*x_74 - 1.02065535463796*x_75 - 1.53706794341062*x_76 - 0.460947340494968*x_77 - 2.99650598649165*x_78 + 0.225778900609322*x_79 + 1.02841403146415*x_8 - 1.09791347923711*x_80 + 0.247578671812801*x_81 + 0.990508564687792*x_82 - 3.03262580846487*x_83 - 8.67727507188626*x_84 + 22.7992956656424*x_85 - 1.31427482122024*x_86 - 16.3732656415109*x_87 - 0.731104660498852*x_88 + 0.529947138131903*x_89 - 4.07538635502713*x_9 + 2.28170265397247*x_90 - 0.896872303377422*x_91 - 3.79748476755655*x_92 - 1.43173821434171*x_93 - 0.0455818953464924*x_94 + 0.140671366635577*x_95 + 2.41564621312237*x_96 + 1.80854064352222*x_97 + 1.06380906159369*x_98 + 1.76304496285847*x_99 + 0.000850121745398816*std::exp(1.00599980354309*x_13) - 0.00370040945026899*std::exp(0.959599852561951*x_23) - 0.0134778570525708*std::exp(0.991999804973602*x_23) - 0.00232647024787643*std::exp(0.838239848613739*x_24) + 0.00613397808659151*std::exp(0.643119871616364*x_3) + 0.00158041749585873*std::exp(0.919679820537567*x_4) - 0.00016904476859612*std::exp(1.44239985942841*x_6) - 0.000936037492858369*std::exp(1.61327981948853*x_6) - 0.00338985704161883*std::exp(1.63687980175018*x_6) + 0.000298057173510232*std::exp(1.6503199338913*x_6) - 0.00392347548071696*std::exp(0.971999824047089*x_8) + 18.8155751381611*std::sin(0.227359995245934*x_109 - 7.42807960510254) + 0.0583011829871543*std::sin(0.209120005369186*x_118 - 7.39463996887207) + 0.749116974380524*std::sin(0.285039931535721*x_49 - 1.14103984832764) + 0.283447805341178*std::sin(0.339839845895767*x_91 + 5.18584012985229) - 0.175255082649575*std::sin(0.344159841537476*x_91 + 1.99103975296021) + 0.130824853547193*std::sin(0.295999944210052*x_94 - 1.20031988620758) - 0.133713034239099*std::sin(0.258559972047806*x_95 + 1.98215985298157) - 3105.81395291605 + 6.43647737378631e-7*std::exp(-8.0653600692749*x_113));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-32.3645709819171*x_1 + 10.0668725483805*x_10 + 2.06885152060204*x_100 - 0.107804129856788*x_101 - 0.625677083964082*x_102 + 0.305451875384336*x_103 - 9.88781497119168*x_104 - 3.00776503021839*x_105 - 0.828881360841699*x_106 - 0.632021804422216*x_107 - 1.57136709263839*x_108 - 0.950743744605563*x_109 - 22.496821950648*x_11 - 4.10942274724791*x_110 - 1.86444222755216*x_111 + 2.24195707175516*x_112 + 2.37532786209526*x_113 + 0.233521363293234*x_114 - 3.66499798865033*x_115 + 24.8283790911729*x_116 + 5.29763462715396*x_117 - 0.719195383677612*x_118 + 2.55358234159492*x_119 + 11.1023388115338*x_12 - 1.84453343877526*x_120 + 0.936478125619089*x_13 + 15.9008414611903*x_14 - 5.38093816033406*x_15 - 0.295222867402647*x_16 - 5.03436330301491*x_17 + 37.223656606215*x_18 - 13.4080951208443*x_19 + 1.28098467792193*x_2 - 3.91153079085336*x_20 + 6.35281362385016*x_21 + 56.7958677750777*x_22 + 66.0591140695811*x_23 + 47.3732872645499*x_24 + 3.12733513350515*x_25 - 14.5083645218489*x_26 - 11.7085879746189*x_27 - 58.729625986065*x_28 + 151.98460530518*x_29 + 2.37896842904105*x_3 - 3.34938139504399*x_30 - 2.20295929450565*x_31 + 3.2478826741239*x_32 - 5.16929562635173*x_33 - 222.158823729052*x_34 + 2.63158889816107*x_35 + 20.2897723864881*x_36 + 194.489857092137*x_37 + 0.0741398256342382*x_38 - 85.7955622335999*x_39 + 38.504702924428*x_4 + 2.22878529354546*x_40 + 582.748788160926*x_41 + 234.538880911171*x_42 + 109.217953047283*x_43 - 1.13988712158835*x_44 - 137.70244703428*x_45 - 137.824992911936*x_46 + 98.0229302826424*x_47 + 19.221240294024*x_48 - 34.508643937729*x_49 + 2.20885462611453*x_5 - 66.4837198004252*x_50 - 1.28339906745557*x_51 + 12.096991698878*x_52 - 11.5605047261714*x_53 - 22.7739645982732*x_54 - 2.05883824853194*x_55 + 18.9931835307057*x_56 + 16.6500320212942*x_57 - 14.7638404116284*x_58 + 21.2723217701153*x_59 + 0.0123572750285025*x_6 + 10.4774785061595*x_60 - 1.86301023332188*x_61 - 0.888455776069462*x_62 - 0.042655287011168*x_63 + 1.45861630690085*x_64 + 0.261508707293811*x_65 + 4.824160184948*x_66 + 2.09725683870639*x_67 - 0.909804607467224*x_68 - 0.194119513007284*x_69 + 0.721511680440322*x_7 - 1.0187963197673*x_70 - 0.25323398736122*x_71 - 1.17679851941518*x_72 + 2.25965721668184*x_73 + 6.32547517753524*x_74 + 1.49417739627183*x_75 - 2.05666045853271*x_76 + 1.21024412104821*x_77 - 1.15286365932179*x_78 - 1.08127974867881*x_79 + 0.130637574795712*x_8 + 0.208260789969279*x_80 + 0.0517775829474734*x_81 + 2.50640117716405*x_82 + 5.325837122126*x_83 - 2.88067541838964*x_84 + 117.935364590341*x_85 + 5.65103948850311*x_86 - 151.764102330824*x_87 + 1.13010103883271*x_88 + 4.55533952724696*x_89 + 0.17521427344902*x_9 - 0.354267508059758*x_90 - 0.331915370966511*x_91 + 2.58894235545888*x_92 + 1.29231818455321*x_93 - 0.0665527846649281*x_94 + 0.869360307726195*x_95 + 0.00696836634301003*x_96 + 0.833894734953702*x_97 + 1.31927287221325*x_98 + 0.118429516936209*x_99 - 0.0208304697687453*std::exp(1.00599980354309*x_13) - 0.0039410516030378*std::exp(0.959599852561951*x_23) - 0.0402223798522905*std::exp(0.991999804973602*x_23) + 0.00130718602244614*std::exp(0.838239848613739*x_24) - 0.00344653039259896*std::exp(0.643119871616364*x_3) - 0.000887997455416246*std::exp(0.919679820537567*x_4) + 9.49820694583099e-5*std::exp(1.44239985942841*x_6) + 0.0229356569255281*std::exp(1.61327981948853*x_6) - 0.00116453779873459*std::exp(1.63687980175018*x_6) + 0.000889501113112184*std::exp(1.6503199338913*x_6) + 0.0961366272911266*std::exp(0.971999824047089*x_8) + 6.4638266995636*std::sin(0.227359995245934*x_109 - 7.42807960510254) - 0.0327579910219986*std::sin(0.209120005369186*x_118 - 7.39463996887207) - 18.3555573922732*std::sin(0.285039931535721*x_49 - 1.14103984832764) - 6.94530044918063*std::sin(0.339839845895767*x_91 + 5.18584012985229) - 0.523019088114693*std::sin(0.344159841537476*x_91 + 1.99103975296021) - 3.20559163621546*std::sin(0.295999944210052*x_94 - 1.20031988620758) - 0.142408556409005*std::sin(0.258559972047806*x_95 + 1.98215985298157) + 3104.9262696644 - 3.61649725135501e-7*std::exp(-8.0653600692749*x_113));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-8.78512379538187*x_1 + 2.63337350062691*x_10 + 0.542469257508444*x_100 - 0.0452596101340114*x_101 - 0.23035027488455*x_102 - 0.0567964476374313*x_103 - 0.350160714391601*x_104 - 0.684668495029013*x_105 + 0.228440761760935*x_106 - 0.24961593761742*x_107 - 0.511491683439648*x_108 - 0.248306196527919*x_109 - 6.75995860754932*x_11 - 1.23302496501373*x_110 - 0.624133141302867*x_111 + 0.725186457733281*x_112 + 0.553638687743197*x_113 + 0.0791376502539448*x_114 - 1.16953527252805*x_115 + 7.22785139096478*x_116 + 1.41678549190846*x_117 - 0.233359272152474*x_118 + 0.560405311467133*x_119 + 2.27278982925181*x_12 - 0.369550249068456*x_120 + 0.146110242949339*x_13 + 4.5869996473979*x_14 - 0.853139391789582*x_15 - 0.137094472974544*x_16 - 1.29816995379779*x_17 + 12.8300800021511*x_18 - 2.4952772292677*x_19 + 0.231661782953791*x_2 - 0.47175065161332*x_20 + 0.959924200895667*x_21 + 13.9509542457424*x_22 + 18.5193071718926*x_23 + 14.6323542141808*x_24 + 1.16884223217188*x_25 - 2.54561986319547*x_26 - 0.378051592847453*x_27 - 0.75529142784703*x_28 + 38.727744469541*x_29 + 0.608015096686261*x_3 - 0.0243877373595447*x_30 - 0.566601415875677*x_31 + 0.773272491107065*x_32 - 1.96476257972787*x_33 - 53.80569470902*x_34 + 0.771571594590375*x_35 + 5.7175118116849*x_36 + 40.8951823436897*x_37 - 0.607856276504436*x_38 - 22.0350467096703*x_39 + 10.4866317223161*x_4 + 0.627871790232784*x_40 + 209.10864848249*x_41 + 54.6954098817106*x_42 + 30.4666374138371*x_43 - 0.261004005184331*x_44 - 32.427818871563*x_45 - 50.8621553640742*x_46 + 30.3117403623902*x_47 + 5.33343175416501*x_48 - 10.2078898714253*x_49 + 0.473135747149786*x_5 - 22.3697125932151*x_50 - 1.14950790837815*x_51 + 5.92125468771329*x_52 - 3.1101734207685*x_53 - 5.99703207712265*x_54 - 3.07440908216218*x_55 + 6.6560232066851*x_56 + 5.46815059739713*x_57 - 5.02015901907065*x_58 - 13.1915556464012*x_59 + 0.00833228776245027*x_6 + 2.58747730636458*x_60 - 0.679308633770647*x_61 + 0.0809629428119789*x_62 - 0.00206454016959882*x_63 + 0.418272675761601*x_64 + 0.00634909387012987*x_65 + 1.16368351256112*x_66 + 0.522819706618085*x_67 - 0.34604819967875*x_68 + 0.0674898096897051*x_69 - 0.0142343142078462*x_7 - 0.252620834606913*x_70 - 0.153923280132909*x_71 - 0.247823701102565*x_72 + 0.735562151383133*x_73 + 1.65540704600805*x_74 + 0.346279740559453*x_75 - 0.785507051706721*x_76 + 0.358628315798379*x_77 - 0.570246025013111*x_78 - 0.194620599984384*x_79 + 0.334525332484404*x_8 + 0.16970276945726*x_80 + 0.0198242872210548*x_81 + 0.763422300255286*x_82 + 1.42174051995378*x_83 - 1.21734639397595*x_84 + 34.5452523386992*x_85 + 2.15660275799609*x_86 - 35.0888428223974*x_87 + 0.342652825770006*x_88 + 1.8064281137778*x_89 - 0.0200486449415325*x_9 + 0.0856917872376332*x_90 - 0.12339447270588*x_91 + 0.817000268557669*x_92 + 0.486672979377831*x_93 + 0.0727133990215829*x_94 + 0.0982584543930699*x_95 - 0.040137498053645*x_96 + 0.285452453577213*x_97 + 0.20535899631217*x_98 + 0.0914608835105184*x_99 - 0.00563664393444879*std::exp(1.00599980354309*x_13) - 0.0026573800427226*std::exp(0.959599852561951*x_23) + 0.0344762194664486*std::exp(0.991999804973602*x_23) + 0.00552280419144772*std::exp(0.838239848613739*x_24) - 0.0145614412725881*std::exp(0.643119871616364*x_3) - 0.00375175069542928*std::exp(0.919679820537567*x_4) + 0.000401295119676316*std::exp(1.44239985942841*x_6) + 0.00620629937428739*std::exp(1.61327981948853*x_6) - 0.000324783174155171*std::exp(1.63687980175018*x_6) - 0.000762427178698121*std::exp(1.6503199338913*x_6) + 0.0260141966606994*std::exp(0.971999824047089*x_8) + 1.80272564355952*std::sin(0.227359995245934*x_109 - 7.42807960510254) - 0.138401089831998*std::sin(0.209120005369186*x_118 - 7.39463996887207) - 4.96694229113468*std::sin(0.285039931535721*x_49 - 1.14103984832764) - 1.87937123283401*std::sin(0.339839845895767*x_91 + 5.18584012985229) + 0.448300695612797*std::sin(0.344159841537476*x_91 + 1.99103975296021) - 0.86742060324077*std::sin(0.295999944210052*x_94 - 1.20031988620758) - 0.0960235221032191*std::sin(0.258559972047806*x_95 + 1.98215985298157) + 90.7324597910225 - 1.52795438714734e-6*std::exp(-8.0653600692749*x_113));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (89.3616460568006*x_1 + 7.00493215485901*x_10 - 7.16871458215995*x_100 + 1.26911499147907*x_101 + 1.21805130360232*x_102 - 0.837025613701944*x_103 + 79.8853130157865*x_104 + 7.46791266315731*x_105 - 8.00297343523016*x_106 + 0.363493418921401*x_107 + 7.32491782869895*x_108 + 3.25515363106724*x_109 + 44.9010439023832*x_11 + 13.8288430807644*x_110 + 6.15529542116509*x_111 - 8.25301746523348*x_112 - 7.05725456946344*x_113 - 2.54182520818617*x_114 + 9.83319304201427*x_115 - 66.4838813723716*x_116 - 15.7260511249283*x_117 + 2.89083893266776*x_118 - 9.79836580211399*x_119 - 36.469302984164*x_12 + 6.3442730954657*x_120 + 0.514246730869027*x_13 - 57.7382474756609*x_14 + 12.2070190961829*x_15 + 1.46354102678569*x_16 + 5.75272318992946*x_17 - 117.561249644064*x_18 + 73.8716075946378*x_19 - 4.16892123444283*x_2 + 20.0659456828856*x_20 - 40.1287790812826*x_21 - 107.292821154052*x_22 - 162.270574985316*x_23 - 62.452938241581*x_24 - 7.6126511867449*x_25 + 19.2181459243886*x_26 + 33.5049726187207*x_27 + 243.360995738588*x_28 - 441.84039217625*x_29 - 6.6169410066533*x_3 + 3.66565277520478*x_30 + 6.28837145156591*x_31 - 10.6187937539038*x_32 + 6.27023929358814*x_33 + 871.961266355624*x_34 - 5.15389370788035*x_35 - 72.1140373324621*x_36 - 587.489014662861*x_37 + 2.99044598755452*x_38 + 293.134709180044*x_39 - 90.5809391373942*x_4 - 10.2476597681228*x_40 - 1353.50611370959*x_41 - 812.858898548582*x_42 - 361.515074016723*x_43 + 2.54421411363675*x_44 + 129.467015172422*x_45 + 285.809438456342*x_46 - 349.199866640989*x_47 - 53.0774633662764*x_48 - 21.3320815533435*x_49 - 8.27343375827919*x_5 + 313.982945100215*x_50 + 1.5094795492051*x_51 - 21.2901448392481*x_52 - 7.30466944496768*x_53 + 92.5899356288534*x_54 + 71.6241145710747*x_55 - 171.766063088305*x_56 - 61.4831118966875*x_57 - 89.5450631596386*x_58 - 304.775036368139*x_59 + 0.0183613571532115*x_6 - 22.0215189171313*x_60 + 6.10374268075499*x_61 - 4.34480331206564*x_62 + 0.344284683664246*x_63 - 4.70927417009328*x_64 - 0.845237050884999*x_65 - 15.6994536763064*x_66 - 6.98283306779995*x_67 + 2.35194223156325*x_68 - 0.152352526258371*x_69 - 1.38621737654925*x_7 + 4.90435256641701*x_70 + 1.62805871329991*x_71 + 1.16479429295455*x_72 - 5.90117936711056*x_73 - 13.803635329777*x_74 - 5.9641430604837*x_75 + 5.07673109080955*x_76 - 4.58740624902718*x_77 + 0.419085192928983*x_78 + 3.48106944703536*x_79 + 0.176580864088013*x_8 - 2.62563846542035*x_80 + 0.110527524897817*x_81 - 6.82652619003572*x_82 - 20.3457459236522*x_83 - 1.06324543037238*x_84 - 349.38124839911*x_85 - 20.9813424733806*x_86 + 444.983357069931*x_87 - 4.7194167384323*x_88 - 15.1999828088019*x_89 - 5.73969038885195*x_9 + 3.61336395307343*x_90 - 0.218412200324802*x_91 - 13.3308664971599*x_92 - 6.09669310865881*x_93 + 0.0212852280164774*x_94 - 2.25850377024633*x_95 + 3.42166648876927*x_96 - 0.589786912480894*x_97 - 2.59267420068208*x_98 + 1.6395677942061*x_99 + 0.0671079054310329*std::exp(1.00599980354309*x_13) - 0.00585590721867936*std::exp(0.959599852561951*x_23) - 0.00910144278704415*std::exp(0.991999804973602*x_23) + 0.000201242542482127*std::exp(0.838239848613739*x_24) - 0.000530596661101549*std::exp(0.643119871616364*x_3) - 0.000136708060350291*std::exp(0.919679820537567*x_4) + 1.46225807343283e-5*std::exp(1.44239985942841*x_6) - 0.0738900232709281*std::exp(1.61327981948853*x_6) - 0.000708330532324743*std::exp(1.63687980175018*x_6) + 0.000201274601844366*std::exp(1.6503199338913*x_6) - 0.309715900041364*std::exp(0.971999824047089*x_8) + 3.93162490039557*std::sin(0.227359995245934*x_109 - 7.42807960510254) - 0.00504312415117282*std::sin(0.209120005369186*x_118 - 7.39463996887207) + 59.1346725873078*std::sin(0.285039931535721*x_49 - 1.14103984832764) + 22.375134642093*std::sin(0.339839845895767*x_91 + 5.18584012985229) - 0.118347753775111*std::sin(0.344159841537476*x_91 + 1.99103975296021) + 10.3272054236833*std::sin(0.295999944210052*x_94 - 1.20031988620758) - 0.211601211421439*std::sin(0.258559972047806*x_95 + 1.98215985298157) - 18678.7996375154 - 5.56763222100848e-8*std::exp(-8.0653600692749*x_113));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (33.5037320535591*x_1 - 0.21096967355715*x_10 - 2.55397476157182*x_100 + 0.380164032208008*x_101 + 0.508366098658589*x_102 - 0.327652639526689*x_103 + 25.6190230949791*x_104 + 2.86086096588391*x_105 - 2.22108211052225*x_106 + 0.259628347795512*x_107 + 2.4823831413626*x_108 + 1.14984731527427*x_109 + 18.2245529535186*x_11 + 4.94059256945688*x_110 + 2.18650809644909*x_111 - 2.92672520707075*x_112 - 2.59933254393637*x_113 - 0.815123303880041*x_114 + 3.69033316330753*x_115 - 25.0698119202899*x_116 - 5.81896306272749*x_117 + 1.01272161244712*x_118 - 3.45749752895999*x_119 - 13.3013940518168*x_12 + 2.27990161820547*x_120 - 0.0695212979265931*x_13 - 20.5107212411048*x_14 + 4.67734275920404*x_15 + 0.50836272514448*x_16 + 2.79673763265078*x_17 - 42.401126810267*x_18 + 24.5793764511302*x_19 - 1.50754225523853*x_2 + 6.70041450728738*x_20 - 13.3431607022355*x_21 - 43.8597664079352*x_22 - 62.3481158697088*x_23 - 28.6295103646577*x_24 - 2.93535732737654*x_25 + 8.76116610212355*x_26 + 12.8113720743469*x_27 + 86.2658136972291*x_28 - 163.799366032808*x_29 - 2.44876148645013*x_3 + 1.9779524376997*x_30 + 2.33993115567013*x_31 - 3.84669410809206*x_32 + 2.94348976944683*x_33 + 306.785062843723*x_34 - 2.07049388268888*x_35 - 25.7043105709831*x_36 - 216.251154067764*x_37 + 0.802445636982937*x_38 + 105.473299856372*x_39 - 35.0616036138806*x_4 - 3.56705262938126*x_40 - 514.661016935508*x_41 - 293.56598960372*x_42 - 130.560088908052*x_43 + 1.0127066508975*x_44 + 68.7003421005964*x_45 + 113.090379581963*x_46 - 125.133213053667*x_47 - 19.8115254499749*x_48 + 1.1153410188071*x_49 - 2.95581378234333*x_5 + 106.228494343976*x_50 + 0.848479559399825*x_51 - 8.78617625227719*x_52 + 0.513752267795122*x_53 + 32.1111753096677*x_54 + 21.2467629101588*x_55 - 54.6329388787321*x_56 - 21.7019230863525*x_57 - 23.6100112302561*x_58 - 95.3785203454073*x_59 - 0.00442442228746605*x_6 - 8.84031827963039*x_60 + 2.1941091721877*x_61 - 1.05793249643352*x_62 + 0.121734147331682*x_63 - 1.69977176896761*x_64 - 0.33169918764782*x_65 - 5.67488227835295*x_66 - 2.52341133640781*x_67 + 0.893333495644668*x_68 + 0.0153795010594485*x_69 - 0.596918133338333*x_7 + 1.68262861779656*x_70 + 0.523546902781446*x_71 + 0.604069623989845*x_72 - 2.22163312089518*x_73 - 5.48014804504503*x_74 - 2.09090141520762*x_75 + 1.92924409706619*x_76 - 1.60407132789447*x_77 + 0.353710910422352*x_78 + 1.27053892955763*x_79 + 0.0498440365951023*x_8 - 0.789693109177424*x_80 + 0.0272675381591735*x_81 - 2.56081267478643*x_82 - 7.23163565813592*x_83 + 0.287719846726009*x_84 - 128.809986058111*x_85 - 7.38091833451829*x_86 + 164.967711223983*x_87 - 1.6262437842961*x_88 - 5.42559922591417*x_89 - 1.71761937463021*x_9 + 1.14608267662553*x_90 + 0.0218774344053986*x_91 - 4.48530993451111*x_92 - 2.08633052199701*x_93 + 0.00957330177069648*x_94 - 0.868380497030362*x_95 + 0.983556441829969*x_96 - 0.339073539383881*x_97 - 1.05125251063789*x_98 + 0.476677796099232*x_99 + 0.0243466719818667*std::exp(1.00599980354309*x_13) + 0.0014110616222683*std::exp(0.959599852561951*x_23) + 0.0104975238733785*std::exp(0.991999804973602*x_23) - 0.00027418587442831*std::exp(0.838239848613739*x_24) + 0.000722919258018172*std::exp(0.643119871616364*x_3) + 0.000186259916050662*std::exp(0.919679820537567*x_4) - 1.99227511021754e-5*std::exp(1.44239985942841*x_6) - 0.0268072166424357*std::exp(1.61327981948853*x_6) + 4.93689514038265e-5*std::exp(1.63687980175018*x_6) - 0.000232148351355201*std::exp(1.6503199338913*x_6) - 0.112364577279575*std::exp(0.971999824047089*x_8) - 0.274024893447224*std::sin(0.227359995245934*x_109 - 7.42807960510254) + 0.00687107898849297*std::sin(0.209120005369186*x_118 - 7.39463996887207) + 21.4539921487773*std::sin(0.285039931535721*x_49 - 1.14103984832764) + 8.11767347203219*std::sin(0.339839845895767*x_91 + 5.18584012985229) + 0.136501255864998*std::sin(0.344159841537476*x_91 + 1.99103975296021) + 3.74669841540757*std::sin(0.295999944210052*x_94 - 1.20031988620758) + 0.0509882307748738*std::sin(0.258559972047806*x_95 + 1.98215985298157) - 6243.07565201647 + 7.58570275541029e-8*std::exp(-8.0653600692749*x_113));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (73.2509509589988*x_1 - 0.137390920618903*x_10 - 5.70104090972403*x_100 + 0.958688985035194*x_101 + 1.0468048389639*x_102 - 0.598024568152001*x_103 + 56.3993603507916*x_104 + 6.27725019537926*x_105 - 4.61773674582209*x_106 + 0.495964444144124*x_107 + 5.61620166995602*x_108 + 2.65401968568553*x_109 + 39.8981463417355*x_11 + 11.1379342356537*x_110 + 5.0880386821271*x_111 - 6.43459872607989*x_112 - 5.71351037080178*x_113 - 1.68273072275644*x_114 + 8.23577862283604*x_115 - 55.0457270470523*x_116 - 12.6453067252262*x_117 + 2.21083851300021*x_118 - 7.50869144899094*x_119 - 28.286403389267*x_12 + 4.95207366567046*x_120 - 0.0337183656360094*x_13 - 45.0862889683974*x_14 + 10.9013340702712*x_15 + 1.03909945558012*x_16 + 6.19579875604323*x_17 - 96.5712920963877*x_18 + 54.6849441208891*x_19 - 3.30907479254584*x_2 + 15.1167754994373*x_20 - 28.259968899063*x_21 - 98.0059547268344*x_22 - 137.116151513342*x_23 - 64.7715669485539*x_24 - 6.47315985818335*x_25 + 19.7195795010173*x_26 + 25.0782639503439*x_27 + 175.118930576641*x_28 - 358.143353365451*x_29 - 5.54516187833618*x_3 + 3.07786089012176*x_30 + 5.11822825655798*x_31 - 8.41002240632788*x_32 + 6.87638192001637*x_33 + 665.534281983854*x_34 - 4.7582752117233*x_35 - 56.5232463990459*x_36 - 470.443141345802*x_37 + 2.29968141090117*x_38 + 229.866198182087*x_39 - 77.7934889609116*x_4 - 7.42213103612784*x_40 - 1226.18384558432*x_41 - 625.778597400389*x_42 - 286.966484738004*x_43 + 2.12967209824192*x_44 + 148.969344544602*x_45 + 261.227391419126*x_46 - 270.598244648306*x_47 - 43.9613898333215*x_48 + 4.29441545438195*x_49 - 6.2415483602828*x_5 + 240.28062310321*x_50 + 1.17082545061968*x_51 - 20.8429176237418*x_52 + 0.377319580808468*x_53 + 71.7255048822956*x_54 + 49.1982013707268*x_55 - 121.03834287357*x_56 - 48.3550164257143*x_57 - 48.1089259535494*x_58 - 199.41802888212*x_59 + 0.0392423726013162*x_6 - 19.0693571999285*x_60 + 4.94918480540361*x_61 - 2.54817993565546*x_62 + 0.187471204941737*x_63 - 3.7985488707224*x_64 - 0.539445182032052*x_65 - 12.524764667719*x_66 - 5.50091351887366*x_67 + 1.9790389280508*x_68 - 0.107193367320436*x_69 - 1.06791536149692*x_7 + 3.59045233230034*x_70 + 1.24963609341152*x_71 + 1.30637116769152*x_72 - 5.00514782541552*x_73 - 11.8891020577867*x_74 - 4.54687634776054*x_75 + 4.41490098548136*x_76 - 3.62441410267664*x_77 + 0.99407298441222*x_78 + 2.72457672776799*x_79 - 0.130577286026323*x_8 - 1.96149639919598*x_80 + 0.0156563257116563*x_81 - 5.65672044028877*x_82 - 15.4174568657136*x_83 + 0.962552961087778*x_84 - 284.022428599161*x_85 - 16.6249485616364*x_86 + 358.131572720069*x_87 - 3.66755972783098*x_88 - 12.4040114572131*x_89 - 3.83271453772428*x_9 + 2.45315966010729*x_90 - 0.0375280736662511*x_91 - 9.94409586686839*x_92 - 4.56101273330181*x_93 + 0.084224046907536*x_94 - 1.80340327309915*x_95 + 2.32348281398124*x_96 - 0.888723890642281*x_97 - 2.3080136449615*x_98 + 0.893681630206984*x_99 + 0.0535411814319607*std::exp(1.00599980354309*x_13) - 0.01251539802187*std::exp(0.959599852561951*x_23) - 0.0150419344507092*std::exp(0.991999804973602*x_23) - 0.000819434335055849*std::exp(0.838239848613739*x_24) + 0.00216052290340755*std::exp(0.643119871616364*x_3) + 0.000556658036358614*std::exp(0.919679820537567*x_4) - 5.9541310565081e-5*std::exp(1.44239985942841*x_6) - 0.0589522071438562*std::exp(1.61327981948853*x_6) + 0.000107047674399815*std::exp(1.63687980175018*x_6) + 0.000332646091215919*std::exp(1.6503199338913*x_6) - 0.247102857554088*std::exp(0.971999824047089*x_8) - 0.594173599743681*std::sin(0.227359995245934*x_109 - 7.42807960510254) + 0.0205349675791709*std::sin(0.209120005369186*x_118 - 7.39463996887207) + 47.1798398948765*std::sin(0.285039931535721*x_49 - 1.14103984832764) + 17.8517141273025*std::sin(0.339839845895767*x_91 + 5.18584012985229) - 0.195593072035565*std::sin(0.344159841537476*x_91 + 1.99103975296021) + 8.23942836128011*std::sin(0.295999944210052*x_94 - 1.20031988620758) - 0.452239641776023*std::sin(0.258559972047806*x_95 + 1.98215985298157) - 10881.762606941 + 2.26706985043324e-7*std::exp(-8.0653600692749*x_113));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (91.4789566489607*x_1 + 25.5087935517928*x_10 - 7.97840282185933*x_100 + 1.67471485048325*x_101 + 1.02371375439435*x_102 - 1.01665118498359*x_103 + 110.003689248674*x_104 + 7.18441296109526*x_105 - 13.7790939853751*x_106 - 0.3302563492579*x_107 + 8.84215141679561*x_108 + 3.51082306953141*x_109 + 36.5362855078597*x_11 + 15.0991137613837*x_110 + 6.45348455143352*x_111 - 9.47548146080614*x_112 - 7.4778324790963*x_113 - 3.73360777853455*x_114 + 9.68123904767618*x_115 - 66.6745258906203*x_116 - 16.7337531243107*x_117 + 3.43345989841212*x_118 - 11.5586671289447*x_119 - 41.4744679503703*x_12 + 7.20947972227288*x_120 + 1.99682818428785*x_13 - 66.1097002016189*x_14 + 10.540389546728*x_15 + 1.91306231752748*x_16 + 1.49436764230712*x_17 - 123.862081315704*x_18 + 94.3854184568615*x_19 - 4.62031803537376*x_2 + 25.009298665439*x_20 - 54.3671573938884*x_21 - 81.6015538469327*x_22 - 154.742703889747*x_23 - 24.8405469530451*x_24 - 7.16943489513422*x_25 + 8.31945719120742*x_26 + 38.9823268041727*x_27 + 310.833072633822*x_28 - 465.393898608657*x_29 - 6.6034419313081*x_3 + 2.2997570752157*x_30 + 6.55877746399129*x_31 - 11.7399813627606*x_32 + 1.57459702979556*x_33 + 1035.95935315683*x_34 - 3.86765852256964*x_35 - 82.0827556526423*x_36 - 633.782549240535*x_37 + 4.06131354637745*x_38 + 330.633242129533*x_39 - 83.1241211943376*x_4 - 13.1313415840459*x_40 - 1140.74041694635*x_41 - 939.687487296473*x_42 - 398.677917124663*x_43 + 2.40925611084941*x_44 + 1.54425578791629*x_45 + 224.54087849885*x_46 - 402.178329645846*x_47 - 53.5378913480312*x_48 - 86.4267465299161*x_49 - 9.89490357590877*x_5 + 380.999752632468*x_50 + 0.882142350466127*x_51 - 12.9941457093614*x_52 - 27.6373206765922*x_53 + 108.974997943327*x_54 + 104.272215528013*x_55 - 237.79739142001*x_56 - 70.0063958312422*x_57 - 164.231237170286*x_58 - 456.119942216172*x_59 - 0.00413427031564019*x_6 - 19.2342024103299*x_60 + 6.55639445973888*x_61 - 7.76532307552283*x_62 + 0.569594977266193*x_63 - 5.09028942648764*x_64 - 1.15657667040864*x_65 - 17.2470816669727*x_66 - 7.82119547754069*x_67 + 2.27686679719206*x_68 - 0.358229127505241*x_69 - 1.3969085696173*x_7 + 6.26039855915622*x_70 + 1.99815291677136*x_71 + 0.118524230195598*x_72 - 5.66958266686002*x_73 - 12.3222188951805*x_74 - 7.10981547241024*x_75 + 4.61349206181938*x_76 - 5.2249926771611*x_77 - 1.33684480055787*x_78 + 3.90623592826358*x_79 + 0.790446552090794*x_8 - 3.47651603721002*x_80 + 0.294189637291802*x_81 - 6.8542933632934*x_82 - 24.2304146513596*x_83 - 6.34217298061486*x_84 - 366.997811178959*x_85 - 23.6860432868295*x_86 + 473.267856462687*x_87 - 5.54567525954706*x_88 - 16.238829431544*x_89 - 8.61423611581699*x_9 + 5.2190219433059*x_90 - 0.728830625610063*x_91 - 16.7749770022657*x_92 - 7.56494411689571*x_93 - 0.101271524463398*x_94 - 2.36375719550406*x_95 + 5.12317816888354*x_96 + 0.488222031844695*x_97 - 2.1093422737005*x_98 + 2.89894132967309*x_99 + 0.0734501624943645*std::exp(1.00599980354309*x_13) + 0.00131852472468762*std::exp(0.959599852561951*x_23) - 0.0214130269447674*std::exp(0.991999804973602*x_23) + 0.000237047390501527*std::exp(0.838239848613739*x_24) - 0.000624999825442556*std::exp(0.643119871616364*x_3) - 0.000161031005506403*std::exp(0.919679820537567*x_4) + 1.72242139396459e-5*std::exp(1.44239985942841*x_6) - 0.0808732470653497*std::exp(1.61327981948853*x_6) - 0.00281092445333183*std::exp(1.63687980175018*x_6) + 0.000473540137913723*std::exp(1.6503199338913*x_6) - 0.338986637103515*std::exp(0.971999824047089*x_8) + 15.6021801539165*std::sin(0.227359995245934*x_109 - 7.42807960510254) - 0.00594039115818128*std::sin(0.209120005369186*x_118 - 7.39463996887207) + 64.7233926121058*std::sin(0.285039931535721*x_49 - 1.14103984832764) + 24.4897715811441*std::sin(0.339839845895767*x_91 + 5.18584012985229) - 0.278437573001784*std::sin(0.344159841537476*x_91 + 1.99103975296021) + 11.3032125143851*std::sin(0.295999944210052*x_94 - 1.20031988620758) + 0.0476444415210424*std::sin(0.258559972047806*x_95 + 1.98215985298157) - 19096.7894033683 - 6.5582191170115e-8*std::exp(-8.0653600692749*x_113));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (98.0456791073566*x_1 + 13.6045707250016*x_10 - 8.02501751399838*x_100 + 1.47744367267078*x_101 + 1.28608679496663*x_102 - 0.988833954778557*x_103 + 96.3676980878896*x_104 + 8.00903054065989*x_105 - 10.6678168025985*x_106 + 0.186874709149723*x_107 + 8.40801514645577*x_108 + 3.58138822359417*x_109 + 46.270282213349*x_11 + 15.3988284333374*x_110 + 6.71090737625302*x_111 - 9.3845609982334*x_112 - 7.80386687730204*x_113 - 3.1944742851787*x_114 + 10.6306282060715*x_115 - 72.5481742518379*x_116 - 17.4525920352855*x_117 + 3.3278355572159*x_118 - 11.225513046862*x_119 - 41.4913998270112*x_12 + 7.17207622695195*x_120 + 0.996490571432006*x_13 - 65.5327451931523*x_14 + 12.5226026233415*x_15 + 1.7700707319877*x_16 + 4.88039567013374*x_17 - 129.622087305867*x_18 + 86.5828961792572*x_19 - 4.67115060930212*x_2 + 23.1745165278132*x_20 - 48.5262278833158*x_21 - 107.91886517365*x_22 - 174.4599200644*x_23 - 55.6108212020114*x_24 - 8.21218312000542*x_25 + 17.1268383650548*x_26 + 38.9321700241567*x_27 + 289.109398586515*x_28 - 489.120875320696*x_29 - 7.14605197113104*x_3 + 3.78911876441899*x_30 + 6.93852690903879*x_31 - 11.8931155973242*x_32 + 5.2822200781391*x_33 + 1002.41263560232*x_34 - 5.12902090178561*x_35 - 81.7626786793939*x_36 - 654.302941855599*x_37 + 3.54238928844067*x_38 + 331.161055380012*x_39 - 95.9830315723933*x_4 - 12.2427755019279*x_40 - 1391.34879264087*x_41 - 930.022180795805*x_42 - 404.483636622002*x_43 + 2.76305419199932*x_44 + 99.8111898868167*x_45 + 289.755495283881*x_46 - 399.142818554538*x_47 - 57.755574607238*x_48 - 44.7550384905641*x_49 - 9.58320395529975*x_5 + 361.668222636604*x_50 + 1.65402359838268*x_51 - 20.4020818095219*x_52 - 14.3229724664489*x_53 + 105.653116635221*x_54 + 87.6160016705999*x_55 - 208.378313746782*x_56 - 69.5817431978811*x_57 - 121.857553282954*x_58 - 380.183126633404*x_59 - 0.00157143501384652*x_6 - 23.1640029898779*x_60 + 6.77377538076848*x_61 - 5.81992583726989*x_62 + 0.475382778376851*x_63 - 5.23232656053866*x_64 - 1.07372566334668*x_65 - 17.5509661157937*x_66 - 7.8827865379098*x_67 + 2.54683744504859*x_68 - 0.216220827829955*x_69 - 1.55414818995307*x_7 + 5.81819422997751*x_70 + 1.85265124652747*x_71 + 0.931507845109832*x_72 - 6.32521572237227*x_73 - 14.6023493967475*x_74 - 6.85579649024088*x_75 + 5.35512197721315*x_76 - 5.1718228261716*x_77 - 0.136477256384758*x_78 + 3.93148293631862*x_79 + 0.419213738504531*x_8 - 3.06377207239531*x_80 + 0.189628317977827*x_81 - 7.43887183680887*x_82 - 23.5053321249608*x_83 - 2.88925079378573*x_84 - 385.855700486728*x_85 - 23.6729170418766*x_86 + 493.743598728633*x_87 - 5.37380641062574*x_88 - 16.8069869584638*x_89 - 7.15004474642456*x_9 + 4.45674908786172*x_90 - 0.362987098860389*x_91 - 15.6111722221658*x_92 - 7.13632160814655*x_93 - 0.0386916031288838*x_94 - 2.50037223447628*x_95 + 4.21859815621212*x_96 - 0.256427334258754*x_97 - 2.64107547411244*x_98 + 2.22586121822922*x_99 + 0.0750445888129523*std::exp(1.00599980354309*x_13) + 0.000501170886470111*std::exp(0.959599852561951*x_23) - 0.00817954221446804*std::exp(0.991999804973602*x_23) - 0.00262192717640786*std::exp(0.838239848613739*x_24) + 0.00691298066648597*std::exp(0.643119871616364*x_3) + 0.00178112726188732*std::exp(0.919679820537567*x_4) - 0.000190513105945074*std::exp(1.44239985942841*x_6) - 0.0826288106912374*std::exp(1.61327981948853*x_6) - 0.00144182230438664*std::exp(1.63687980175018*x_6) + 0.000180887156136364*std::exp(1.6503199338913*x_6) - 0.346345221448225*std::exp(0.971999824047089*x_8) + 8.00290855071226*std::sin(0.227359995245934*x_109 - 7.42807960510254) + 0.0657053131155566*std::sin(0.209120005369186*x_118 - 7.39463996887207) + 66.1283817517411*std::sin(0.285039931535721*x_49 - 1.14103984832764) + 25.0213856037567*std::sin(0.339839845895767*x_91 + 5.18584012985229) - 0.106360109121268*std::sin(0.344159841537476*x_91 + 1.99103975296021) + 11.5485780643784*std::sin(0.295999944210052*x_94 - 1.20031988620758) + 0.0181096391636731*std::sin(0.258559972047806*x_95 + 1.98215985298157) - 18601.6210886441 + 7.25389673995134e-7*std::exp(-8.0653600692749*x_113));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (39.0829337624542*x_1 + 18.4907299878445*x_10 - 3.70446173541893*x_100 + 0.898853930573442*x_101 + 0.309103578115455*x_102 - 0.509068261574377*x_103 + 59.3425194283467*x_104 + 2.92119472868113*x_105 - 7.96141311692543*x_106 - 0.476336167718166*x_107 + 4.34798763536761*x_108 + 1.61204289380458*x_109 + 11.5678829916228*x_11 + 6.89544965380216*x_110 + 2.86289767856193*x_111 - 4.4420688374791*x_112 - 3.33319433802506*x_113 - 2.02982349891813*x_114 + 3.9706678666226*x_115 - 27.859463364573*x_116 - 7.38537980252829*x_117 + 1.64795423059519*x_118 - 5.58315844195163*x_119 - 19.4154126858557*x_12 + 3.3979377499347*x_120 + 1.44817789644418*x_13 - 31.0837932097816*x_14 + 4.07553577127144*x_15 + 0.951506391695945*x_16 - 1.11153922135572*x_17 - 54.7100113191166*x_18 + 48.5605997048898*x_19 - 2.15633882172106*x_2 + 12.7881622379692*x_20 - 28.6543523898079*x_21 - 24.3495275550015*x_22 - 61.5883624377672*x_23 + 5.27264300353991*x_24 - 2.74195965622325*x_25 - 0.516327464518508*x_26 + 18.6460482880999*x_27 + 158.878434281374*x_28 - 205.083469124919*x_29 - 2.8151442962866*x_3 + 0.301972576893933*x_30 + 2.8631637887376*x_31 - 5.39481013299797*x_32 - 1.34593830180486*x_33 + 501.319416980809*x_34 - 1.11850277435798*x_35 - 38.4908071861177*x_36 - 286.888704022026*x_37 + 2.11550352366323*x_38 + 153.799778635814*x_39 - 31.8910538293129*x_4 - 6.59351118975433*x_40 - 402.591500985533*x_41 - 443.70999586085*x_42 - 181.845727218994*x_43 + 0.946073975440239*x_44 - 51.7364183781481*x_45 + 68.1284132229853*x_46 - 188.308214511912*x_47 - 22.6722828735103*x_48 - 63.1235892301366*x_49 - 4.78675282899304*x_5 + 187.991492194794*x_50 - 0.345106670649614*x_51 - 1.63241007525543*x_52 - 20.2587070856607*x_53 + 52.8167468501063*x_54 + 57.0657877701761*x_55 - 127.016382094031*x_56 - 32.7666697001013*x_57 - 98.9639107237553*x_58 - 256.581618264762*x_59 + 0.00380829481727874*x_6 - 6.87713284567243*x_60 + 2.9177973110752*x_61 - 4.64870569831564*x_62 + 0.315584998206385*x_63 - 2.30073603739518*x_64 - 0.583862464650187*x_65 - 7.9239605866222*x_66 - 3.62789904518965*x_67 + 0.898540051566771*x_68 - 0.242327335357605*x_69 - 0.583834334274421*x_7 + 3.16994274207828*x_70 + 0.985939440464391*x_71 - 0.370149429983612*x_72 - 2.27411501395894*x_73 - 4.52460624828904*x_74 - 3.45524203025464*x_75 + 1.72009991796435*x_76 - 2.47131694634165*x_77 - 1.3071191879144*x_78 + 1.82301395864251*x_79 + 0.60828991190419*x_8 - 1.83299679031056*x_80 + 0.188772141163692*x_81 - 2.86454184762471*x_82 - 11.6352271888177*x_83 - 4.89111969727349*x_84 - 160.490147976647*x_85 - 10.9749955097815*x_86 + 210.487472157726*x_87 - 2.67940727044489*x_88 - 7.19533978827122*x_89 - 4.84187139225929*x_9 + 2.89386721696918*x_90 - 0.547490775437861*x_91 - 8.4515297645432*x_92 - 3.73487161768888*x_93 - 0.0472936040811507*x_94 - 1.04380539765608*x_95 + 2.88223151162249*x_96 + 0.633607238178313*x_97 - 0.72354471602683*x_98 + 1.71404103534165*x_99 + 0.0334063224344528*std::exp(1.00599980354309*x_13) - 0.00121456278668711*std::exp(0.959599852561951*x_23) - 0.0110469416116269*std::exp(0.991999804973602*x_23) + 0.000790756299376881*std::exp(0.838239848613739*x_24) - 0.00208491031279658*std::exp(0.643119871616364*x_3) - 0.000537176476525527*std::exp(0.919679820537567*x_4) + 5.7457522083553e-5*std::exp(1.44239985942841*x_6) - 0.0367824614137991*std::exp(1.61327981948853*x_6) - 0.00205492173844094*std::exp(1.63687980175018*x_6) + 0.000244298494920307*std::exp(1.6503199338913*x_6) - 0.154176607858692*std::exp(0.971999824047089*x_8) + 11.4059483624158*std::sin(0.227359995245934*x_109 - 7.42807960510254) - 0.0198162979949122*std::sin(0.209120005369186*x_118 - 7.39463996887207) + 29.4372462799872*std::sin(0.285039931535721*x_49 - 1.14103984832764) + 11.1383443957468*std::sin(0.339839845895767*x_91 + 5.18584012985229) - 0.143645436928078*std::sin(0.344159841537476*x_91 + 1.99103975296021) + 5.14088395420039*std::sin(0.295999944210052*x_94 - 1.20031988620758) - 0.0438878123257475*std::sin(0.258559972047806*x_95 + 1.98215985298157) - 9832.60811087442 - 2.18772839831676e-7*std::exp(-8.0653600692749*x_113));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-122.261889296451*x_1 - 8.18153926412328*x_10 + 9.71962744594462*x_100 - 1.63989774793438*x_101 - 1.69479202588639*x_102 + 1.24967239487746*x_103 - 108.206587867568*x_104 - 10.2920077526309*x_105 + 10.5829978933519*x_106 - 0.559507943070421*x_107 - 9.81692677253092*x_108 - 4.37536932294719*x_109 - 61.7552386941451*x_11 - 18.6355210013961*x_110 - 8.21462749810166*x_111 + 11.1683374696712*x_112 + 9.65844223668101*x_113 + 3.44811557016135*x_114 - 13.3269093680375*x_115 + 90.7027462132464*x_116 + 21.5417114289549*x_117 - 3.9146726051673*x_118 + 13.3979012625241*x_119 + 50.3387857367439*x_12 - 8.71018275163675*x_120 - 0.521688341831506*x_13 + 78.3533987284021*x_14 - 16.6735114425811*x_15 - 1.99206687043767*x_16 - 8.11512732434752*x_17 + 157.362809176195*x_18 - 99.8959426169723*x_19 + 5.71774435560251*x_2 - 27.195957922717*x_20 + 54.8249114423309*x_21 + 147.91569199667*x_22 + 221.918351764452*x_23 + 85.9807017242249*x_24 + 10.2808118338802*x_25 - 27.1994155818978*x_26 - 48.0663882380318*x_27 - 341.920036513978*x_28 + 604.366883225453*x_29 + 8.97545921506119*x_3 - 6.11198840667043*x_30 - 8.60383940192602*x_31 + 14.530616075615*x_32 - 8.41901236825946*x_33 - 1190.06308371297*x_34 + 7.00137413090649*x_35 + 97.8714920909954*x_36 + 807.468765837036*x_37 - 3.49070704038946*x_38 - 400.255307530975*x_39 + 123.89550750643*x_4 + 14.0261032605446*x_40 + 1789.02486158938*x_41 + 1117.4104281884*x_42 + 492.374160486291*x_43 - 3.54620867557334*x_44 - 187.627448976149*x_45 - 382.449654927814*x_46 + 475.014399915341*x_47 + 72.3119583669813*x_48 + 26.4248526023298*x_49 + 11.3975145083701*x_5 - 420.137666314272*x_50 - 2.22167868594821*x_51 + 27.7947369872287*x_52 + 8.32249114293442*x_53 - 125.088984923615*x_54 - 93.9531784819005*x_55 + 229.612114396675*x_56 + 82.8465183859184*x_57 + 120.680371742919*x_58 + 420.640719075647*x_59 - 0.00211374460144333*x_6 + 30.5525441565487*x_60 - 8.18541008442078*x_61 + 5.48486620221649*x_62 - 0.4992632934194*x_63 + 6.37444016147426*x_64 + 1.25741517840443*x_65 + 21.3997249527671*x_66 + 9.53463625566621*x_67 - 3.17251219804729*x_68 + 0.0696052629297775*x_69 + 2.10475409443823*x_7 - 6.67982317972255*x_70 - 2.13177813974886*x_71 - 1.69211944894863*x_72 + 7.97336409385015*x_73 + 19.0571175068608*x_74 + 8.14023479341783*x_75 - 6.79034241119913*x_76 + 6.17077416370098*x_77 - 0.465342595718323*x_78 - 4.80800492004736*x_79 - 0.446085970492544*x_8 + 3.38647178632455*x_80 - 0.166808525246794*x_81 + 9.2869014500728*x_82 + 27.8595435735391*x_83 + 1.47887524283781*x_84 + 475.269649787702*x_85 + 28.0717541625545*x_86 - 611.482649523878*x_87 + 6.34360263796035*x_88 + 20.2526092561759*x_89 + 7.66698974191446*x_9 - 4.94002107093145*x_90 + 0.241277305724161*x_91 + 17.9272644426996*x_92 + 8.20605589131165*x_93 - 0.0328301220584614*x_94 + 3.19235090842337*x_95 - 4.48110397640649*x_96 + 0.776016276223136*x_97 + 3.63736710837091*x_98 - 2.27020876081254*x_99 - 0.0913768261004525*std::exp(1.00599980354309*x_13) + 0.000674127308060754*std::exp(0.959599852561951*x_23) - 0.0254218132761064*std::exp(0.991999804973602*x_23) - 0.00375530262418011*std::exp(0.838239848613739*x_24) + 0.00990124160249475*std::exp(0.643119871616364*x_3) + 0.0025510517381066*std::exp(0.919679820537567*x_4) - 0.00027286584201641*std::exp(1.44239985942841*x_6) + 0.100611630829767*std::exp(1.61327981948853*x_6) + 0.000846529577678477*std::exp(1.63687980175018*x_6) + 0.000562192771523414*std::exp(1.6503199338913*x_6) + 0.421721640048948*std::exp(0.971999824047089*x_8) - 4.69870578019384*std::sin(0.227359995245934*x_109 - 7.42807960510254) + 0.0941076231962602*std::sin(0.209120005369186*x_118 - 7.39463996887207) - 80.5201512222859*std::sin(0.285039931535721*x_49 - 1.14103984832764) - 30.4668842520492*std::sin(0.339839845895767*x_91 + 5.18584012985229) - 0.3305645674552*std::sin(0.344159841537476*x_91 + 1.99103975296021) - 14.0619387245422*std::sin(0.295999944210052*x_94 - 1.20031988620758) + 0.0243593605074397*std::sin(0.258559972047806*x_95 + 1.98215985298157) + 20763.0690788723 + 1.03895248152511e-6*std::exp(-8.0653600692749*x_113));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
