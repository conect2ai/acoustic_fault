
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00179228046430289*x_1 + 0.00811909515082572*x_10 - 0.00240395828819214*x_100 + 3.0000729948046e-5*x_101 + 1.92640448257603e-6*x_102 + 0.000105634971549855*x_103 + 0.00176837096754152*x_104 - 0.000719196228108264*x_105 + 0.000132887890411087*x_106 - 9.68425374933893e-5*x_107 - 0.00158479297492183*x_108 + 0.000540760162448393*x_109 - 0.000227942758421428*x_11 - 0.00211383062789295*x_110 + 0.00129991037401328*x_111 + 0.000509485620443617*x_112 - 7.84317494843313e-5*x_113 - 0.000138966781527476*x_114 - 0.000139573269086082*x_115 - 0.00396255919005095*x_116 + 0.000366057764385203*x_117 + 0.00128392420096044*x_118 + 0.000826197448610377*x_119 + 0.00215713834898817*x_12 + 5.3502483371687e-5*x_120 + 0.000560585040427386*x_13 - 0.000441031069522009*x_14 - 0.000655123226180766*x_15 + 0.000376897288382434*x_16 - 0.00451613890115131*x_17 + 0.00039192085211735*x_18 - 0.000701751916451904*x_19 + 0.00203301404556689*x_2 - 0.00519089919805472*x_20 - 0.000840743393036051*x_21 - 0.000111725787848255*x_22 - 6.10044773921229e-5*x_23 + 0.00132453326705365*x_24 - 0.00026562458046891*x_25 - 0.00107092971741691*x_26 - 0.00100404379883368*x_27 + 0.000838734021185949*x_28 - 0.0015968702454224*x_29 - 0.00153367957719619*x_3 - 0.00184547205089402*x_30 + 0.00132838963672646*x_31 - 0.00612605359597004*x_32 + 0.000281144322252069*x_33 - 0.000807846559375878*x_34 + 0.00230973808909681*x_35 - 8.33257058896477e-6*x_36 + 5.74624655799287e-5*x_37 - 8.37101978108794e-5*x_38 - 0.000330157507097261*x_39 - 0.00132500476622756*x_4 - 0.000463208511591952*x_40 - 1.31040877179359e-5*x_41 - 0.00134866110899613*x_42 - 0.00279454963218514*x_43 - 0.00102709379805598*x_44 - 0.000684097217115266*x_45 - 0.000269135397226369*x_46 - 0.000494569573497864*x_47 + 0.000116514773005848*x_48 - 0.000421444615849603*x_49 - 0.00141462956113898*x_5 - 0.00207606329451344*x_50 - 0.00151879964912842*x_51 - 3.40782793106891e-5*x_52 - 6.33150645476487e-5*x_53 - 0.000176687259443351*x_54 + 0.000468572322226555*x_55 + 0.00239103362384302*x_56 + 0.000878637772111976*x_57 - 0.000512887008730382*x_58 - 3.93290843185237e-5*x_59 - 0.00122316720181638*x_6 + 0.000128401081471469*x_60 - 0.000154134835618395*x_61 - 0.00462317469279826*x_62 + 0.000221559452650624*x_63 + 0.000447082942500031*x_64 - 0.000668115057313453*x_65 - 0.00138490950495759*x_66 + 4.35730878252564e-5*x_67 + 0.0002467179032707*x_68 - 2.32050647747364e-5*x_69 + 0.00144320215554719*x_7 + 0.000298873439462155*x_70 - 0.00027306688785916*x_71 + 9.62802679374374e-5*x_72 + 0.000633706307848999*x_73 - 0.000112331696505955*x_74 + 0.000625846256531927*x_75 - 0.000173163988815428*x_76 + 0.000372907092324537*x_77 + 0.00136475886433719*x_78 - 0.000597789390440395*x_79 - 0.00262754384429402*x_8 + 6.10630012606897e-5*x_80 + 0.000175201452624477*x_81 + 0.000278538486251104*x_82 - 0.000607205979914415*x_83 - 0.000154658465026189*x_84 - 7.14861623534277e-6*x_85 + 0.00129418050347848*x_86 - 0.00204931644385659*x_87 + 0.00105315499494118*x_88 + 0.000373129789427952*x_89 - 0.00245816811145183*x_9 + 0.000298832556902978*x_90 - 0.00864656118327152*x_91 - 0.0016184522395461*x_92 - 9.11896457218667e-5*x_93 - 4.5646920601824e-5*x_94 + 9.9530153440371e-5*x_95 + 4.70215034400056e-5*x_96 + 0.00169829627451883*x_97 + 2.33143826245434e-5*x_98 - 0.00110375580593523*x_99 - 2.42398629786902e-6*std::pow(-5.55215978622437*x_100 - 7.38375997543335, 2) - 1.53087998966781e-7*std::pow(-9.58480072021484*x_106 - 7.96384000778198, 2) + 1.87405954672498e-6*std::pow(-7.98799991607666*x_106 - 8.19944000244141, 2) - 1.72178899782538e-6*std::pow(-6.71752023696899*x_106 - 9.56103992462158, 2) - 1.68428935452314e-6*std::pow(-5.86383962631226*x_106 - 8.48952007293701, 2) + 2.90216226247933e-8*std::pow(-8.6636791229248*x_108 - 6.04663944244385, 2) + 2.70928837264141e-6*std::pow(-8.47000026702881*x_116 - 8.86903953552246, 2) - 4.45549853112259e-6*std::pow(-6.09335994720459*x_13 - 9.55160045623779, 2) + 1.25761151491736e-5*std::pow(-4.07000017166138*x_13 - 6.52231979370117, 2) + 4.5722533753254e-5*std::pow(-5.10199975967407*x_14 - 7.75728034973145, 2) + 1.63272931244869e-6*std::pow(-3.51191973686218*x_14 - 6.0479998588562, 2) + 1.3885542677399e-6*std::pow(-5.6691198348999*x_15 - 7.42512035369873, 2) + 1.5879629263186e-6*std::pow(-5.32231998443604*x_15 - 8.46951961517334, 2) + 4.49175812690612e-7*std::pow(-5.82096004486084*x_17 - 9.23791980743408, 2) - 1.21253696901929e-7*std::pow(-6.85031986236572*x_18 - 7.45431995391846, 2) + 5.68842526103066e-5*std::pow(-5.03071975708008*x_18 - 7.24015998840332, 2) + 6.78949172960757e-6*std::pow(-3.47519993782043*x_18 - 4.50079965591431, 2) + 4.30693055714827e-5*std::pow(-1.34583985805511*x_2 - 2.49487972259521, 2) + 1.82607707371628e-6*std::pow(-5.71983957290649*x_22 - 9.39935970306396, 2) - 6.73716172651075e-6*std::pow(-5.3167200088501*x_22 - 8.58440017700195, 2) - 3.77411611153614e-5*std::pow(-4.98327970504761*x_22 - 7.76327991485596, 2) + 9.85959826441943e-7*std::pow(-5.90136003494263*x_23 - 8.54720020294189, 2) + 2.93890064700008e-7*std::pow(-5.04120016098022*x_23 - 8.87744045257568, 2) + 1.36231874955268e-6*std::pow(-4.40399980545044*x_23 - 9.9993200302124, 2) + 5.3264662554573e-6*std::pow(-5.77959966659546*x_24 - 8.97016048431396, 2) - 4.21894155502458e-6*std::pow(-4.79911994934082*x_36 - 3.79999995231628, 2) + 4.74260071350245e-7*std::pow(-5.51895999908447*x_38 - 6.90023994445801, 2) + 2.20938779075787e-7*std::pow(-3.78287982940674*x_38 - 6.56720018386841, 2) + 4.96949996317718e-7*std::pow(-5.15136003494263*x_40 - 5.74847984313965, 2) - 6.22145842823535e-7*std::pow(-5.46367979049683*x_47 - 7.07823991775513, 2) + 4.49479894708911e-7*std::pow(-7.80000019073486*x_49 - 9.99882030487061, 2) + 2.96481103830206e-7*std::pow(-4.93391990661621*x_49 - 8.67199993133545, 2) - 4.41312877707673e-7*std::pow(-5.88295984268188*x_5 - 9.54328060150146, 2) + 2.23108830003226e-5*std::pow(-3.3374400138855*x_5 - 5.49232006072998, 2) + 3.49829744471758e-7*std::pow(-9.99993991851807*x_50 - 7.19999980926514, 2) + 9.52718141383186e-6*std::pow(-4.51688003540039*x_53 - 6.4747200012207, 2) + 1.55339851436221e-5*std::pow(-7.36400032043457*x_54 - 9.79903984069824, 2) + 1.80650736205412e-6*std::pow(-8.16296005249023*x_55 - 7.95711994171143, 2) + 2.67011324156715e-6*std::pow(-6.19600009918213*x_57 - 9.98884010314941, 2) + 1.63162675760962e-5*std::pow(-3.92007994651794*x_58 - 5.68487977981567, 2) - 4.21513550936979e-6*std::pow(-6.60400009155273*x_64 - 9.96195983886719, 2) + 6.11071063420602e-5*std::pow(-3.24863982200623*x_68 - 5.47495985031128, 2) - 8.4528137001416e-8*std::pow(-7.40719985961914*x_69 - 9.41207981109619, 2) + 8.90977824064194e-7*std::pow(-6.92199993133545*x_69 - 9.16287994384766, 2) + 4.55675272505994e-7*std::pow(-6.40399980545044*x_69 - 9.99507999420166, 2) - 1.37488830364487e-5*std::pow(-6.09127998352051*x_7 - 9.73591995239258, 2) + 3.76697509761773e-5*std::pow(-5.7707200050354*x_7 - 9.56975936889648, 2) - 1.85092341715498e-5*std::pow(-2.79311990737915*x_7 - 4.79031991958618, 2) - 2.50461449702506e-6*std::pow(-8.72799968719482*x_70 - 9.33439922332764, 2) + 1.78524178480138e-5*std::pow(-4.89879989624023*x_70 - 7.14247989654541, 2) - 4.29616016989402e-6*std::pow(-5.99983978271484*x_71 - 9.40424060821533, 2) + 9.56358861140087e-7*std::pow(-5.7838397026062*x_72 - 7.57272005081177, 2) + 2.2674307159859e-5*std::pow(-4.69727993011475*x_72 - 5.92263984680176, 2) + 2.30646780415111e-6*std::pow(-5.50311994552612*x_73 - 8.97648048400879, 2) + 1.98434483622807e-6*std::pow(-4.92944002151489*x_74 - 6.36568021774292, 2) + 8.81682978782474e-7*std::pow(-7.0*x_77 - 9.99993991851807, 2) - 8.17900963705085e-6*std::pow(-4.67551946640015*x_78 - 6.30359983444214, 2) + 5.07554805801572e-6*std::pow(-4.72591972351074*x_79 - 6.36720037460327, 2) - 1.07758591075786e-5*std::pow(-5.28800010681152*x_82 - 7.51375961303711, 2) + 2.88077142964837e-6*std::pow(-4.89039993286133*x_84 - 8.17303943634033, 2) + 1.09877122715419e-5*std::pow(-5.09136009216309*x_85 - 8.60568046569824, 2) + 2.6475600024061e-5*std::pow(-6.66607999801636*x_86 - 8.43383884429932, 2) + 4.97643655752657e-6*std::pow(-5.27888011932373*x_86 - 8.12639999389648, 2) + 2.38037294056364e-6*std::pow(-7.70527982711792*x_87 - 8.48975944519043, 2) + 2.05979243086401e-6*std::pow(-8.80000019073486*x_88 - 9.99983978271484, 2) + 2.26948654421525e-6*std::pow(-4.33304023742676*x_90 - 5.97864007949829, 2) + 0.00284779237087211*std::exp(0.649039804935455*x_22) + 0.000541307981995833*std::exp(0.715519845485687*x_22) - 0.00123713590167739*std::exp(0.543359875679016*x_67) - 1.88014340491475e-5*std::exp(0.656719863414764*x_69) + 0.00783998206657456*std::exp(0.0371898441839521*x_1 + 0.0216220714337976*x_10 + 0.000737810914658509*x_100 - 0.0206674921616768*x_101 + 0.00302159992452487*x_102 + 0.014550867635715*x_105 + 0.000739690772198382*x_106 - 0.00235769339128678*x_107 + 0.000785871687232707*x_108 - 0.0189138596990719*x_109 + 0.00757743161147072*x_11 - 0.00020621377602745*x_111 + 0.000340885100896812*x_112 + 0.0182735246892831*x_113 - 0.000127055779068511*x_114 - 0.0031940464845665*x_116 + 0.000206800499161214*x_118 + 0.000114851557423903*x_12 + 0.000572634685915945*x_120 + 0.00841381877856652*x_14 + 0.00797191172542705*x_15 + 5.24415699658927e-6*x_19 + 0.00109948903487347*x_2 - 0.0453207757926601*x_20 + 3.25618520596008e-5*x_22 - 0.00711206850786418*x_25 - 0.00297992310078181*x_27 - 0.0316987621170772*x_29 - 0.0161907223236054*x_3 + 0.00740894644010472*x_30 + 0.00293772935356091*x_31 + 0.000432334539060068*x_32 - 0.0179975382701358*x_33 + 0.000312644516607283*x_35 - 0.000918299783789682*x_36 - 0.00147297324115919*x_38 - 0.00556289734334286*x_39 - 0.00762956820662279*x_4 - 0.0109389038861457*x_40 - 0.00181241508768842*x_42 + 0.00845458661908889*x_43 + 0.00142928521235685*x_44 - 0.00018109046357596*x_45 - 0.00157007325001916*x_46 - 0.00329786546213073*x_47 - 0.00131774468123523*x_48 - 0.0032831766353876*x_5 - 0.00447189874542078*x_51 - 0.0102619518587382*x_52 - 0.0146956421524306*x_54 - 0.00021828971426986*x_55 + 0.000438967139673222*x_56 - 0.00554671108597106*x_57 - 0.00401654369437648*x_58 + 0.0181766111804147*x_6 + 0.00208092647908656*x_60 + 0.000389682253101456*x_61 - 0.0415436815399049*x_63 - 0.00285466931953967*x_68 - 0.00074426330553899*x_69 - 0.000588980864394363*x_71 - 0.0192655250685682*x_72 - 0.000877190716035312*x_73 + 0.00253016343062212*x_74 - 0.000432592127001727*x_76 + 0.00375171049695346*x_77 + 0.000442644119503417*x_78 - 0.00219280002136193*x_8 + 0.00522864703698844*x_81 + 0.000339037261031386*x_82 + 0.00136491728675739*x_83 - 0.000338797059107067*x_84 - 0.000191462902885612*x_86 - 0.00129812312125413*x_87 + 0.0013858812688621*x_88 - 0.000497166687082332*x_89 - 0.00255080123144546*x_9 + 0.000309034935081961*x_90 - 0.0269558945024091*x_91 - 0.000213819760198112*x_94 + 0.000484282908359347*x_95 - 0.00166016878730096*x_98 + 0.00084409947961013*std::pow(-5.46256017684937*x_17 - 8.0926399230957, 2) + 0.0125517544073261*std::pow(-0.788719892501831*x_49 - 1.1847198009491, 2) + 0.00016926579508272*std::pow(-6.08367967605591*x_66 - 9.94783973693848, 2) + 0.000297567856413369*std::pow(-3.43055987358093*x_67 - 6.46231985092163, 2) + 0.000984596334817872*std::pow(-5.54423999786377*x_7 - 8.90136051177979, 2) + 0.000122567559732561*std::pow(-7.34127998352051*x_70 - 7.9312801361084, 2) - 0.000307496896176464*std::pow(-5.33200025558472*x_85 - 8.39999961853027, 2) + 0.0767009271952581*std::sin(0.418079853057861*x_103 - 1.19207990169525) + 0.133639895216213*std::sin(0.451519846916199*x_104 - 1.14063990116119) - 0.165713652313535*std::sin(0.330799847841263*x_110 - 4.43279981613159) - 0.363779105905159*std::sin(0.20720000565052*x_115 - 1.37271988391876) + 0.474992701669528*std::sin(0.189600005745888*x_117 + 8.18416023254395) + 0.151402480131468*std::sin(0.398399829864502*x_119 + 8.18903923034668) + 0.506856996419373*std::sin(0.165200024843216*x_13 + 4.96023941040039) - 0.0164459703332598*std::sin(1.44519984722137*x_16 - 3.38727998733521) + 0.160815027013182*std::sin(0.412719875574112*x_18 - 7.16936016082764) - 0.254330353314057*std::sin(0.363679856061935*x_21 + 5.15895986557007) - 1.89143276809457*std::sin(0.179360017180443*x_23 - 7.61696004867554) + 0.174117284891622*std::sin(0.547119855880737*x_24 + 8.55247974395752) + 0.527501127392163*std::sin(0.339359849691391*x_26 + 8.35319995880127) - 0.0666082821291836*std::sin(0.457199841737747*x_28 - 7.13647985458374) + 0.177283299681033*std::sin(0.384159833192825*x_34 - 1.19863986968994) - 0.0869759725611026*std::sin(0.292879939079285*x_37 + 5.11407995223999) - 0.175094176354968*std::sin(0.363999843597412*x_41 - 1.21383988857269) - 0.369370523623438*std::sin(0.285839945077896*x_50 + 5.09280014038086) - 0.423887206071583*std::sin(0.166960015892982*x_53 - 7.6497597694397) + 0.161122336373102*std::sin(0.320719838142395*x_59 - 4.28952026367188) + 0.199541801448106*std::sin(0.305039942264557*x_62 - 4.27687978744507) + 1.18666978283581*std::sin(0.130960047245026*x_64 + 4.91191959381104) + 0.242095230360249*std::sin(0.220399990677834*x_65 + 5.01191997528076) + 0.186058097460613*std::sin(0.23735998570919*x_75 - 7.56728029251099) - 0.467096039112*std::sin(0.242639973759651*x_79 + 1.85583996772766) - 0.88729105666097*std::sin(0.182960003614426*x_80 - 7.60896015167236) + 0.137688461482092*std::sin(0.367679834365845*x_92 - 1.3977597951889) + 0.14129126581464*std::sin(0.422959864139557*x_93 - 7.60512018203735) - 0.101502222328163*std::sin(0.343759834766388*x_96 - 4.42055988311768) - 0.18273801334292*std::sin(0.411359876394272*x_97 + 8.21576023101807) - 0.121297343376693*std::sin(0.468479871749878*x_99 + 8.24679946899414)) - 0.00523793127763981*std::sin(0.217519998550415*x_1 + 1.81207990646362) - 0.000554761404818636*std::sin(0.322799921035767*x_1 + 1.95039975643158) + 0.0050305021383667*std::sin(0.269199937582016*x_10 + 5.06816005706787) - 0.00348669906588222*std::sin(0.367199838161469*x_101 + 8.17160034179688) - 0.000535705552727817*std::sin(0.183680012822151*x_102 + 1.7850399017334) + 0.00917379982205168*std::sin(0.315999835729599*x_102 - 4.44975996017456) - 0.000157789013834201*std::sin(0.324799835681915*x_102 + 5.12800025939941) - 0.00281942101317859*std::sin(0.394879847764969*x_102 + 2.00839972496033) + 0.00274133539166937*std::sin(0.467919856309891*x_102 + 5.0220799446106) + 0.00992868300099437*std::sin(0.178960010409355*x_103 - 7.6241602897644) - 0.00619197952702568*std::sin(0.323359847068787*x_103 + 5.13160037994385) - 0.00895704508136836*std::sin(0.366719841957092*x_103 - 7.41215991973877) - 0.000470362415149682*std::sin(0.310239911079407*x_105 + 1.91767990589142) - 0.00236898026077433*std::sin(0.308159917593002*x_107 + 1.90919995307922) + 0.000344900399464226*std::sin(0.410559862852097*x_107 + 5.20783996582031) + 9.7821945148771e-6*std::sin(1.69463980197906*x_107 - 6.01591968536377) - 0.00367078631931563*std::sin(0.444559872150421*x_108 - 4.1657600402832) + 0.00610919893832726*std::sin(0.394479840993881*x_110 + 5.18344020843506) - 0.00136362943891723*std::sin(0.303359925746918*x_111 - 7.49376010894775) + 0.0149943076819926*std::sin(0.141760036349297*x_112 + 8.10503959655762) - 0.0168453545578026*std::sin(0.270639955997467*x_112 - 7.53815984725952) + 0.00206625863992337*std::sin(0.362479835748672*x_112 - 7.42967987060547) + 0.0033752267891459*std::sin(0.398479819297791*x_112 - 4.41079998016357) + 0.00116841875646447*std::sin(0.271599948406219*x_113 + 5.0623197555542) - 0.00183542073521587*std::sin(0.395199835300446*x_114 - 1.21023988723755) + 0.000848012229494462*std::sin(0.269599944353104*x_115 + 1.86295986175537) - 0.0025578085689746*std::sin(0.457519859075546*x_115 - 1.14735984802246) - 0.00260187637657417*std::sin(0.350239843130112*x_117 - 7.43336009979248) + 0.000141447471755682*std::sin(1.79807984828949*x_117 + 8.98896026611328) - 0.000758883569585569*std::sin(0.238799974322319*x_118 - 1.3614399433136) + 0.000925930277153785*std::sin(0.279359966516495*x_118 - 7.5207200050354) + 0.0003221479085916*std::sin(0.279519945383072*x_118 + 1.8647198677063) + 0.0244502223842726*std::sin(0.373199850320816*x_119 + 1.97575974464417) - 0.00741103966436131*std::sin(0.3572798371315*x_12 - 1.03671979904175) + 0.00168179598697318*std::sin(0.416479855775833*x_12 - 4.17271995544434) + 0.00418975258409628*std::sin(0.328719854354858*x_120 - 7.45576000213623) - 0.0121475510382324*std::sin(0.330799847841263*x_120 + 5.12911987304688) - 0.105604866358175*std::sin(0.126080051064491*x_13 + 8.07575988769531) + 0.00105176755027739*std::sin(0.277359962463379*x_13 - 1.07599985599518) - 0.00397819455874524*std::sin(0.182000011205673*x_14 + 8.18039894104004) + 0.00781170202133311*std::sin(0.205119997262955*x_14 - 4.38215970993042) - 0.0227549172092103*std::sin(0.287039935588837*x_15 + 5.13007974624634) - 0.000346712485837848*std::sin(1.16935980319977*x_15 + 5.98727989196777) - 0.000934232962971006*std::sin(0.292079925537109*x_16 + 8.31447982788086) - 0.000486767494468276*std::sin(0.345759838819504*x_16 + 5.15791988372803) + 0.00291690244758382*std::sin(0.358719855546951*x_16 + 8.34712028503418) - 0.00971905692857179*std::sin(0.402959853410721*x_16 + 1.97447979450226) - 3.03896418688083e-5*std::sin(1.47319984436035*x_2 - 3.38879990577698) + 0.00619092279470573*std::sin(0.243679970502853*x_21 + 8.26344013214111) + 0.0252020412533957*std::sin(0.390239834785461*x_23 + 1.97439980506897) + 0.00222567799280225*std::sin(0.186960011720657*x_24 + 4.96975994110107) + 0.0165202155599916*std::sin(0.209600001573563*x_24 - 4.37680006027222) - 0.00173567880423314*std::sin(0.271279960870743*x_24 + 1.85807991027832) + 0.00119034580588021*std::sin(0.333439826965332*x_24 + 5.13248014450073) - 1.61354903167901e-5*std::sin(1.16631984710693*x_25 - 8.98752021789551) - 0.000945699003445948*std::sin(0.338239848613739*x_26 - 7.44767951965332) - 0.00219301541020011*std::sin(0.353679865598679*x_26 + 1.9618399143219) + 0.00609639325036565*std::sin(0.32687982916832*x_27 + 8.30775928497314) + 0.00243463523436892*std::sin(0.378799855709076*x_27 - 7.41504001617432) - 0.0452981622350319*std::sin(0.136960044503212*x_28 + 8.09280014038086) - 0.00651751880983901*std::sin(0.19055999815464*x_28 - 4.42063999176025) + 0.000361096855711502*std::sin(0.300159931182861*x_3 - 1.0843198299408) - 0.00546217818884121*std::sin(0.359999865293503*x_3 - 1.0461597442627) + 0.012185804138876*std::sin(0.281439960002899*x_30 - 7.52135992050171) + 0.00336643451412986*std::sin(0.312719851732254*x_30 - 4.26567983627319) + 0.00202211550934103*std::sin(0.283119946718216*x_33 - 1.17807984352112) + 0.00580521439505814*std::sin(0.285759925842285*x_33 + 8.2041597366333) - 0.0269556829278376*std::sin(0.292399942874908*x_33 + 8.20679950714111) - 0.00549569704121866*std::sin(0.303599923849106*x_33 - 1.19399988651276) + 0.00260011717531202*std::sin(0.318159908056259*x_34 + 8.25111961364746) - 0.000455132836529403*std::sin(0.328159838914871*x_34 - 7.41232013702393) + 0.0240266748891414*std::sin(0.341119825839996*x_34 - 1.19039988517761) - 0.00110068067372482*std::sin(0.350879848003387*x_34 + 2.00583982467651) - 0.00209969462488369*std::sin(0.355279833078384*x_34 + 1.97823989391327) + 0.000581467945068912*std::sin(0.291759938001633*x_35 + 8.24959945678711) - 0.000389498501627969*std::sin(0.321279853582382*x_35 + 1.77135992050171) + 0.000134740628773972*std::sin(0.322319835424423*x_35 - 4.42935991287231) + 0.000748189889537754*std::sin(0.346479833126068*x_35 + 8.19127941131592) + 0.0170788937219297*std::sin(0.285039931535721*x_36 - 7.51999998092651) - 0.000990829269670417*std::sin(0.317039847373962*x_36 - 4.27767992019653) - 0.00492101806162478*std::sin(0.322799831628799*x_36 - 7.46775960922241) - 0.00626040784970857*std::sin(0.331679850816727*x_36 + 5.1483998298645) + 0.00374453055214111*std::sin(0.352559864521027*x_36 + 5.15791988372803) + 0.000770289082484057*std::sin(0.353839844465256*x_36 + 5.14800024032593) + 0.00560399123606461*std::sin(0.26335996389389*x_37 + 1.8458399772644) + 0.00482132590321415*std::sin(0.267279952764511*x_37 + 5.08191967010498) - 0.00543103222025408*std::sin(0.317519843578339*x_37 + 5.12696027755737) - 0.0104601847363536*std::sin(0.225279986858368*x_38 + 5.02023983001709) - 0.000902475249851546*std::sin(0.474399864673615*x_39 - 7.7836799621582) - 0.00117975703761823*std::sin(0.256319969892502*x_41 - 4.32304000854492) - 0.00682985486258088*std::sin(0.295359939336777*x_41 - 4.28927993774414) - 0.00020798358419068*std::sin(0.333999842405319*x_41 + 5.13104009628296) - 0.000864437142763216*std::sin(0.360479861497879*x_41 + 4.78455972671509) - 0.000967748629007951*std::sin(0.465279847383499*x_41 - 4.34639978408813) - 0.00955729568533932*std::sin(0.198400005698204*x_42 + 5.00551986694336) - 0.000111277419451565*std::sin(0.403279840946198*x_42 + 8.20879936218262) + 0.000585156910962206*std::sin(0.409599870443344*x_42 + 2.00727987289429) + 0.000915212492916898*std::sin(0.189600005745888*x_43 - 7.60376024246216) + 0.000947236250178453*std::sin(0.236559987068176*x_43 - 7.55200004577637) - 0.00398885208026972*std::sin(0.26199996471405*x_43 + 5.06319952011108) + 0.000713025199005733*std::sin(0.337439835071564*x_43 + 5.13944005966187) + 0.000897092703955579*std::sin(0.356799840927124*x_43 + 5.16048002243042) - 0.00755040149655803*std::sin(0.373679846525192*x_43 - 1.21103978157043) + 0.00947717966222338*std::sin(0.294879943132401*x_47 - 7.48031997680664) + 0.0212299209688734*std::sin(0.32711985707283*x_47 + 8.3133602142334) + 8.60819690289872e-5*std::sin(1.76415991783142*x_49 - 7.41623973846436) + 0.0103454279784498*std::sin(0.399759829044342*x_50 - 1.19031989574432) + 0.000176647812560043*std::sin(0.254639983177185*x_51 + 1.83439981937408) + 0.0076975807598229*std::sin(0.335119843482971*x_51 + 5.13655996322632) - 0.000482792746289984*std::sin(0.477919846773148*x_51 + 8.44704055786133) + 0.00121836259086827*std::sin(0.26639997959137*x_52 + 8.27744007110596) + 0.00148559658748879*std::sin(0.409919857978821*x_52 + 5.20424032211304) + 0.00807422639814549*std::sin(0.597679853439331*x_52 + 2.00543975830078) + 0.000655507725587621*std::sin(0.383759826421738*x_54 - 7.42215967178345) - 4.48373062706591e-5*std::sin(0.454879850149155*x_54 - 1.15599977970123) + 0.00166278285357217*std::sin(0.460639864206314*x_54 - 1.13079988956451) - 0.00183621161632833*std::sin(0.331519842147827*x_55 - 4.2804799079895) + 0.000481372708758477*std::sin(0.330559849739075*x_57 + 1.92791974544525) - 0.000372734374353796*std::sin(0.350719839334488*x_58 - 7.43415975570679) - 1.13291485052457e-5*std::sin(1.39943981170654*x_6 - 5.19679975509644) + 0.00857312430860729*std::sin(0.186400011181831*x_64 - 4.42831993103027) + 0.00299157311992137*std::sin(0.306479841470718*x_67 - 7.49200010299683) - 0.0187654909034776*std::sin(0.14544004201889*x_68 + 4.9206395149231) - 0.000390039382412864*std::sin(0.167200013995171*x_71 - 4.45599985122681) - 0.000280585847249156*std::sin(0.207039996981621*x_73 - 7.59656000137329) + 0.00228835360288256*std::sin(0.250639975070953*x_73 - 7.52424001693726) + 0.0031753796590948*std::sin(0.269359946250916*x_75 + 5.09375953674316) + 0.0255118388640841*std::sin(0.171120017766953*x_76 - 7.64520025253296) + 0.0019891293909785*std::sin(0.22223998606205*x_76 - 7.56864023208618) + 0.000784692768496189*std::sin(0.243519976735115*x_79 - 7.54839992523193) + 0.133193351589994*std::sin(0.134880036115646*x_80 + 4.91583967208862) - 0.00331013091282046*std::sin(0.281279861927032*x_84 - 1.29047977924347) - 0.000322711801334128*std::sin(0.295519828796387*x_85 - 1.26815986633301) + 0.00102438204230913*std::sin(0.157360032200813*x_86 - 7.64720010757446) + 0.0188637096854696*std::sin(0.173280015587807*x_86 - 7.63872003555298) + 0.00101481260128093*std::sin(0.364959836006165*x_86 + 1.95703983306885) + 0.0174089211791848*std::sin(0.184800013899803*x_88 - 7.60400009155273) + 0.00142611070009581*std::sin(0.214479997754097*x_88 + 5.01127958297729) + 0.00640200882675335*std::sin(0.314479917287827*x_9 + 8.34624004364014) - 0.00314942406518534*std::sin(0.356559842824936*x_9 - 4.25672006607056) - 0.00110249728299664*std::sin(0.336159855127335*x_92 + 5.19160032272339) + 0.00138791868172457*std::sin(0.361919850111008*x_92 - 7.40287971496582) + 0.00460553450407253*std::sin(0.367439836263657*x_92 + 1.98079979419708) - 0.000485477551826658*std::sin(0.392559856176376*x_92 + 1.97831988334656) - 0.000470762559151647*std::sin(0.345039844512939*x_93 - 1.42127990722656) - 0.0275023595830144*std::sin(0.361599832773209*x_93 - 7.40575981140137) + 0.000937689753625757*std::sin(0.409999877214432*x_93 + 1.99575984477997) - 0.00325889799910503*std::sin(0.36983984708786*x_94 + 5.17535972595215) + 0.00130106499013487*std::sin(0.379439830780029*x_94 + 4.98119974136353) - 0.00537472749965316*std::sin(0.398239850997925*x_94 + 5.19799995422363) + 0.000285684079542357*std::sin(0.328559845685959*x_95 + 1.94279980659485) - 0.00416732695147045*std::sin(0.344959855079651*x_95 - 7.42527961730957) + 0.000253971805024213*std::sin(0.373599827289581*x_95 - 7.42496013641357) - 0.00962898781152256*std::sin(0.386799842119217*x_95 + 8.18487930297852) - 0.00260370490592841*std::sin(0.346959829330444*x_96 + 1.94447982311249) - 0.000222915050936237*std::sin(0.42103984951973*x_96 - 1.15919995307922) + 0.000324853335423134*std::sin(0.449839860200882*x_96 + 8.23176002502441) - 0.00417173930318514*std::sin(0.312559932470322*x_97 + 1.90231990814209) + 0.00462637767626302*std::sin(0.371679842472076*x_97 - 7.43088006973267) + 0.00131657055348895*std::sin(0.411279857158661*x_98 + 5.21224021911621) - 0.0115696492934808*std::sin(0.463359862565994*x_98 + 2.01143980026245) + 0.00361227345827462*std::sin(0.33247983455658*x_99 - 7.45544004440308) - 0.0023405579631756*std::sin(0.396479845046997*x_99 + 2.0019998550415) + 0.000590991719215789*std::sin(0.39743983745575*x_99 - 7.39287996292114) + 0.211714114997039);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000726777616444277*x_1 - 0.00364978210426969*x_10 + 0.00157016818851529*x_100 - 0.000398373468132507*x_101 + 1.51909413270277e-5*x_102 + 0.000326954701494823*x_103 - 0.00114234803977994*x_104 + 0.000751255431930188*x_105 + 0.000670254404628367*x_106 + 0.000140754036665683*x_107 + 0.000821214687406866*x_108 - 1.90500177973529e-5*x_109 - 0.000277569156387815*x_11 + 0.00114354857288171*x_110 + 9.99271537116151e-5*x_111 + 0.000303610036887133*x_112 + 0.000105189527000313*x_113 + 3.93137103470829e-5*x_114 + 9.13959496541046e-5*x_115 + 0.00110790053128711*x_116 + 0.000469484165486891*x_117 - 0.00152265535290329*x_118 - 0.000632655846987608*x_119 + 0.000409756607998883*x_12 - 0.000562896906512971*x_120 - 0.000440591668190474*x_13 + 1.99411906571393e-5*x_14 - 0.000156890092184947*x_15 + 0.000187874098610145*x_16 + 0.0029141380219246*x_17 - 1.60744278694472e-5*x_18 + 0.000327555483825566*x_19 + 0.000271111439805897*x_2 + 0.00332382324397693*x_20 + 0.000578149957442581*x_21 + 0.00138967024754119*x_22 + 0.000483891601430283*x_23 - 0.000257377638545678*x_24 - 0.000148332927233687*x_25 + 0.000859000602102079*x_26 + 0.00030823915342589*x_27 + 0.000400876559820335*x_28 + 0.000992658361366682*x_29 + 0.000903567644182068*x_3 + 0.000714152551374647*x_30 + 0.00117055917495106*x_31 + 0.00329187912345676*x_32 - 3.97609283370493e-5*x_33 + 7.97518979244765e-5*x_34 - 0.00115393300537745*x_35 - 5.23182984156215e-5*x_36 - 5.75789895214823e-5*x_37 + 5.121122583587e-5*x_38 - 0.000907895583026347*x_39 + 0.0024198478389162*x_4 + 0.000136548990378082*x_40 + 5.11234727533997e-6*x_41 + 0.000854247182531279*x_42 + 0.00205038454468726*x_43 - 0.000488651012859621*x_44 - 0.000513034183415982*x_45 + 0.000124580868933027*x_46 + 0.00015223614991574*x_47 - 0.000602191376218582*x_48 + 0.000161560989265703*x_49 + 0.000567264336920915*x_5 + 0.00149662974430905*x_50 + 0.00085358012351223*x_51 + 4.29192477989921e-5*x_52 + 2.07032608575768e-5*x_53 - 9.19368240856963e-6*x_54 + 4.0611137775973e-5*x_55 - 0.001079344372933*x_56 - 0.000485681768006147*x_57 + 0.00108839779446192*x_58 + 0.000162716896646147*x_59 + 0.000990003073235994*x_6 + 0.00129555125037349*x_60 + 0.000288662342221629*x_61 + 0.00198585208320211*x_62 + 0.00177368168035252*x_63 + 0.000383467129726598*x_64 + 4.61274066861934e-5*x_65 + 0.000265907678482502*x_66 + 0.000593792611777731*x_67 - 0.000371000676769199*x_68 - 2.85441510072982e-5*x_69 + 0.000526999821805339*x_7 + 0.000217523041249497*x_70 + 0.00019674238723891*x_71 + 0.000146408611472371*x_72 - 0.000246256000976784*x_73 - 0.000529349757552032*x_74 + 0.000259413626146152*x_75 - 0.000103095054615659*x_76 + 0.000563870276642016*x_77 - 0.000742405095718349*x_78 + 0.000165079368690748*x_79 + 0.00137614107912793*x_8 + 6.80127200665071e-5*x_80 + 0.000218149261245137*x_81 - 0.000214793007675049*x_82 + 0.00027054773481429*x_83 - 3.6699755672951e-5*x_84 + 1.60062154695599e-5*x_85 - 2.27374377090817e-5*x_86 + 0.00101333489917959*x_87 + 0.000543559685731864*x_88 + 0.000206149384535569*x_89 + 0.000773240267003945*x_9 - 0.000110714047481321*x_90 + 0.00559599703516819*x_91 + 0.000936713820007948*x_92 + 0.000341560366481845*x_93 - 9.86189601707192e-6*x_94 - 2.2320616961498e-5*x_95 + 2.24541190671035e-5*x_96 - 0.000446020008814241*x_97 - 4.73805611996196e-5*x_98 + 0.00041265403896098*x_99 + 1.31951280217432e-6*std::pow(-5.55215978622437*x_100 - 7.38375997543335, 2) - 7.8160554834325e-7*std::pow(-9.58480072021484*x_106 - 7.96384000778198, 2) - 6.28476851521581e-7*std::pow(-7.98799991607666*x_106 - 8.19944000244141, 2) + 9.16853930986743e-7*std::pow(-5.86383962631226*x_106 - 8.48952007293701, 2) + 9.44497711783379e-7*std::pow(-8.6636791229248*x_108 - 6.04663944244385, 2) - 9.08575732973538e-7*std::pow(-8.47000026702881*x_116 - 8.86903953552246, 2) + 2.42537977919e-6*std::pow(-6.09335994720459*x_13 - 9.55160045623779, 2) - 2.35060770059829e-5*std::pow(-5.10199975967407*x_14 - 7.75728034973145, 2) + 5.31365568185703e-5*std::pow(-3.51191973686218*x_14 - 6.0479998588562, 2) - 2.36717582597511e-7*std::pow(-5.6691198348999*x_15 - 7.42512035369873, 2) + 6.88421632902648e-6*std::pow(-5.32231998443604*x_15 - 8.46951961517334, 2) + 1.46182566274667e-5*std::pow(-5.82096004486084*x_17 - 9.23791980743408, 2) - 3.9461556216126e-6*std::pow(-6.85031986236572*x_18 - 7.45431995391846, 2) - 2.92443465513433e-5*std::pow(-5.03071975708008*x_18 - 7.24015998840332, 2) - 3.69590424886055e-6*std::pow(-3.47519993782043*x_18 - 4.50079965591431, 2) - 7.34235754114914e-6*std::pow(-1.34583985805511*x_2 - 2.49487972259521, 2) + 9.32321267605542e-6*std::pow(-5.71983957290649*x_22 - 9.39935970306396, 2) + 1.23031317953179e-6*std::pow(-4.98327970504761*x_22 - 7.76327991485596, 2) + 5.03391301729532e-6*std::pow(-5.90136003494263*x_23 - 8.54720020294189, 2) - 5.01017117454449e-8*std::pow(-5.04120016098022*x_23 - 8.87744045257568, 2) + 5.905992404213e-6*std::pow(-4.40399980545044*x_23 - 9.9993200302124, 2) - 8.08507814356321e-8*std::pow(-5.51895999908447*x_38 - 6.90023994445801, 2) + 9.5782484932116e-7*std::pow(-3.78287982940674*x_38 - 6.56720018386841, 2) + 2.53722615092363e-6*std::pow(-5.15136003494263*x_40 - 5.74847984313965, 2) - 3.17642562389937e-6*std::pow(-5.46367979049683*x_47 - 7.07823991775513, 2) - 7.66263131183631e-8*std::pow(-7.80000019073486*x_49 - 9.99882030487061, 2) + 9.64886518493327e-6*std::pow(-4.93391990661621*x_49 - 8.67199993133545, 2) + 7.52340185811732e-8*std::pow(-5.88295984268188*x_5 - 9.54328060150146, 2) - 1.21450751485766e-5*std::pow(-3.3374400138855*x_5 - 5.49232006072998, 2) + 1.51659941133187e-6*std::pow(-9.99993991851807*x_50 - 7.19999980926514, 2) - 7.98606334824542e-6*std::pow(-7.36400032043457*x_54 - 9.79903984069824, 2) - 9.28730271018656e-7*std::pow(-8.16296005249023*x_55 - 7.95711994171143, 2) - 1.4534936144649e-6*std::pow(-6.19600009918213*x_57 - 9.98884010314941, 2) + 1.41357039497225e-6*std::pow(-6.60400009155273*x_64 - 9.96195983886719, 2) - 3.14153269598063e-5*std::pow(-3.24863982200623*x_68 - 5.47495985031128, 2) - 2.75093619027851e-6*std::pow(-7.40719985961914*x_69 - 9.41207981109619, 2) + 3.86261164134544e-6*std::pow(-6.92199993133545*x_69 - 9.16287994384766, 2) - 7.76824870753168e-8*std::pow(-6.40399980545044*x_69 - 9.99507999420166, 2) - 1.93661198222465e-5*std::pow(-5.7707200050354*x_7 - 9.56975936889648, 2) + 6.20718014885915e-6*std::pow(-2.79311990737915*x_7 - 4.79031991958618, 2) - 9.17797580823114e-6*std::pow(-4.89879989624023*x_70 - 7.14247989654541, 2) - 1.63037889814182e-7*std::pow(-5.7838397026062*x_72 - 7.57272005081177, 2) - 7.39153171526886e-7*std::pow(-4.69727993011475*x_72 - 5.92263984680176, 2) - 1.25554084115732e-6*std::pow(-5.50311994552612*x_73 - 8.97648048400879, 2) - 1.08019109581325e-6*std::pow(-4.92944002151489*x_74 - 6.36568021774292, 2) - 1.70211478542539e-6*std::pow(-4.72591972351074*x_79 - 6.36720037460327, 2) + 3.51279109837335e-7*std::pow(-5.28800010681152*x_82 - 7.51375961303711, 2) - 1.56816677755183e-6*std::pow(-4.89039993286133*x_84 - 8.17303943634033, 2) - 5.6488122939177e-6*std::pow(-5.09136009216309*x_85 - 8.60568046569824, 2) - 1.36111768499901e-5*std::pow(-6.66607999801636*x_86 - 8.43383884429932, 2) - 1.66887716291449e-6*std::pow(-5.27888011932373*x_86 - 8.12639999389648, 2) - 1.29577158574878e-6*std::pow(-7.70527982711792*x_87 - 8.48975944519043, 2) - 6.90763462665668e-7*std::pow(-8.80000019073486*x_88 - 9.99983978271484, 2) + 9.83879161613238e-6*std::pow(-4.33304023742676*x_90 - 5.97864007949829, 2) + 0.00160239194519818*std::pow(-0.154447799443024*x_1 - 0.0897955187935672*x_10 - 0.00306409652082446*x_100 + 0.0858311927468181*x_101 - 0.0125485725842716*x_102 - 0.0604291181002757*x_105 - 0.00307190348712589*x_106 + 0.00979139773332887*x_107 - 0.00326369081132217*x_108 + 0.0785484336811575*x_109 - 0.0314687427038661*x_11 + 0.000856396809966191*x_111 - 0.00141568094332443*x_112 - 0.0758891503381294*x_113 + 0.000527657104089679*x_114 + 0.0132647356202932*x_116 - 0.000858833445528412*x_118 - 0.000476973504352038*x_12 - 0.00237812685331521*x_120 - 0.0349422220979011*x_14 - 0.0331070013968368*x_15 - 2.17787550829926e-5*x_19 - 0.00456612996569686*x_2 + 0.188215203473412*x_20 - 0.000135227950176913*x_22 + 0.029536110049142*x_25 + 0.0123754905545903*x_27 + 0.131643575322186*x_29 + 0.0672393630343024*x_3 - 0.0307690311420874*x_30 - 0.0122002617642708*x_31 - 0.00179546646796264*x_32 + 0.07474299078708*x_33 - 0.00129839902955978*x_35 + 0.003813658915423*x_36 + 0.00611719357064862*x_38 + 0.023102469829048*x_39 + 0.0316852637076073*x_4 + 0.0454287903218206*x_40 + 0.00752688074158703*x_42 - 0.0351115291599468*x_43 - 0.00593575909415147*x_44 + 0.000752060790066259*x_45 + 0.0065204456687252*x_46 + 0.0136958913020946*x_47 + 0.00547253613749619*x_48 + 0.0136348892458436*x_5 + 0.0185716002773761*x_51 + 0.0426174381030691*x_52 + 0.0610303603483356*x_54 + 0.000906547654334474*x_55 - 0.00182301136877533*x_56 + 0.0230352490087636*x_57 + 0.0166805306280602*x_58 - 0.0754866727663762*x_6 - 0.00864199682870209*x_60 - 0.00161833338628211*x_61 + 0.172529095923688*x_63 + 0.0118553170688107*x_68 + 0.00309089301848407*x_69 + 0.0024460118189743*x_71 + 0.0800088846093835*x_72 + 0.00364293475157838*x_73 - 0.0105076582778323*x_74 + 0.00179653621943983*x_76 - 0.0155806899199592*x_77 - 0.00183828170549846*x_78 + 0.00910660276614193*x_8 - 0.0217143428978285*x_81 - 0.0014080069450273*x_82 - 0.00566844190899807*x_83 + 0.00140700939692116*x_84 + 0.000795137077729851*x_86 + 0.00539104865543711*x_87 - 0.00575550441153559*x_88 + 0.00206471154857322*x_89 + 0.0105933661637472*x_9 - 0.00128340859505463*x_90 + 0.111946653159464*x_91 + 0.00088798413020197*x_94 - 0.00201120577795387*x_95 + 0.00689460850210473*x_98 - 0.00350550829124049*std::pow(-5.46256017684937*x_17 - 8.0926399230957, 2) - 0.0521268881303172*std::pow(-0.788719892501831*x_49 - 1.1847198009491, 2) - 0.00070295345799757*std::pow(-6.08367967605591*x_66 - 9.94783973693848, 2) - 0.00123578631791779*std::pow(-3.43055987358093*x_67 - 6.46231985092163, 2) - 0.00408898559779142*std::pow(-5.54423999786377*x_7 - 8.90136051177979, 2) - 0.00050901772511228*std::pow(-7.34127998352051*x_70 - 7.9312801361084, 2) + 0.00127702118662031*std::pow(-5.33200025558472*x_85 - 8.39999961853027, 2) - 0.318535602406719*std::sin(0.418079853057861*x_103 - 1.19207990169525) - 0.555000651033836*std::sin(0.451519846916199*x_104 - 1.14063990116119) + 0.688201564139277*std::sin(0.330799847841263*x_110 - 4.43279981613159) + 1.51075874672922*std::sin(0.20720000565052*x_115 - 1.37271988391876) - 1.97262395511761*std::sin(0.189600005745888*x_117 + 8.18416023254395) - 0.628767890794546*std::sin(0.398399829864502*x_119 + 8.18903923034668) - 2.10495498023766*std::sin(0.165200024843216*x_13 + 4.96023941040039) + 0.0682993968760237*std::sin(1.44519984722137*x_16 - 3.38727998733521) - 0.667857787107216*std::sin(0.412719875574112*x_18 - 7.16936016082764) + 1.05622285499849*std::sin(0.363679856061935*x_21 + 5.15895986557007) + 7.85503771894508*std::sin(0.179360017180443*x_23 - 7.61696004867554) - 0.723101483391247*std::sin(0.547119855880737*x_24 + 8.55247974395752) - 2.19068915498683*std::sin(0.339359849691391*x_26 + 8.35319995880127) + 0.276621288022811*std::sin(0.457199841737747*x_28 - 7.13647985458374) - 0.736249804605229*std::sin(0.384159833192825*x_34 - 1.19863986968994) + 0.361207417273228*std::sin(0.292879939079285*x_37 + 5.11407995223999) + 0.727158470994155*std::sin(0.363999843597412*x_41 - 1.21383988857269) + 1.53397966043038*std::sin(0.285839945077896*x_50 + 5.09280014038086) + 1.76038506281395*std::sin(0.166960015892982*x_53 - 7.6497597694397) - 0.669134029463951*std::sin(0.320719838142395*x_59 - 4.28952026367188) - 0.828688390790717*std::sin(0.305039942264557*x_62 - 4.27687978744507) - 4.92818780627235*std::sin(0.130960047245026*x_64 + 4.91191959381104) - 1.00541092347268*std::sin(0.220399990677834*x_65 + 5.01191997528076) - 0.772691156736478*std::sin(0.23735998570919*x_75 - 7.56728029251099) + 1.9398294602302*std::sin(0.242639973759651*x_79 + 1.85583996772766) + 3.68488102528531*std::sin(0.182960003614426*x_80 - 7.60896015167236) - 0.571814170003464*std::sin(0.367679834365845*x_92 - 1.3977597951889) - 0.586776459122866*std::sin(0.422959864139557*x_93 - 7.60512018203735) + 0.421534298439628*std::sin(0.343759834766388*x_96 - 4.42055988311768) + 0.758902992327748*std::sin(0.411359876394272*x_97 + 8.21576023101807) + 0.503742572035272*std::sin(0.468479871749878*x_99 + 8.24679946899414) + 4.17825295387789, 2) + 0.00260538840666413*std::pow(-0.0429012462252443*x_1 + 0.229407457606574*x_10 + 0.006059030431055*x_100 - 0.000288184002044121*x_104 + 0.00185854145637506*x_105 + 0.00627833787650436*x_107 + 0.00200130943215801*x_109 - 0.00363353469433528*x_11 + 0.00176219074335089*x_111 + 0.00500361950356357*x_113 + 0.000916036198579005*x_115 - 0.0894486642134081*x_116 + 0.00406725856460738*x_117 + 0.000419558493015391*x_118 + 0.00389569452100428*x_119 + 0.173219470410524*x_12 - 0.0176789991860841*x_120 + 0.000670019160890582*x_16 - 0.115284009495418*x_17 - 0.00215984935806215*x_18 - 0.0107385654886223*x_19 + 0.101545349463702*x_2 - 0.00394805549134902*x_20 - 0.0606222316824139*x_21 - 0.0122990661260053*x_23 + 0.0214479712006119*x_25 + 0.0426749739902641*x_26 + 0.000641932375143336*x_27 - 0.0121767447738999*x_28 + 0.139317909541066*x_29 - 0.00419936769189552*x_3 - 0.0146758138945829*x_31 - 0.00371869303080705*x_32 + 0.00800269896470184*x_35 - 0.0188306113241166*x_38 - 0.00984302296987328*x_39 - 0.192102648011289*x_4 + 0.00227648639754731*x_40 - 0.000215373592025821*x_43 - 0.0218427030498121*x_44 + 0.000857882373314338*x_45 + 0.00158762943343154*x_46 - 0.0375848659090044*x_48 - 0.0224071514311552*x_49 - 0.0246524477100756*x_5 + 0.000618117763037113*x_50 - 0.000734995455505881*x_54 + 0.00122466440771033*x_55 + 0.000992339961732372*x_56 + 0.0427895157972954*x_57 - 0.039023194281628*x_59 - 0.0242564773630051*x_6 + 0.0807278977379999*x_60 + 0.0477305512520775*x_61 - 0.0331302206006684*x_62 + 0.00923667125210169*x_63 - 0.000793185699076503*x_64 + 0.000358931896671303*x_65 + 0.00230211464147398*x_66 - 0.000777082527568129*x_68 - 0.0157851817436998*x_69 + 0.0272786027590943*x_72 + 0.0189377152665965*x_73 - 0.00444037830123938*x_74 + 0.0869323786968416*x_75 - 0.00277494102115711*x_76 + 0.00260568671963235*x_79 - 0.0723751877529203*x_8 - 0.00961137953388976*x_80 + 0.0358255845077808*x_81 + 0.0290140031588341*x_82 - 0.00348110202093313*x_83 - 0.00113010124891457*x_85 + 0.00150631703199147*x_87 - 0.00470348815977853*x_89 + 0.0221442280824754*x_90 + 0.212665484020387*x_91 - 0.00113080837933987*x_92 + 0.00965263992359509*x_93 + 0.00451487309690339*x_95 + 0.0092357451283745*x_96 - 0.00485367540101051*x_97 + 0.00469192566338788*x_98 - 0.000275519620698238*std::pow(-6.71752023696899*x_106 - 9.56103992462158, 2) + 0.00201242224229213*std::pow(-4.07000017166138*x_13 - 6.52231979370117, 2) - 0.00107807649242464*std::pow(-5.3167200088501*x_22 - 8.58440017700195, 2) + 0.000852337867310725*std::pow(-5.77959966659546*x_24 - 8.97016048431396, 2) - 0.000675112443195139*std::pow(-4.79911994934082*x_36 - 3.79999995231628, 2) + 0.00152453373367906*std::pow(-4.51688003540039*x_53 - 6.4747200012207, 2) + 0.00261091914250511*std::pow(-3.92007994651794*x_58 - 5.68487977981567, 2) - 0.00220008784119954*std::pow(-6.09127998352051*x_7 - 9.73591995239258, 2) - 0.0004007868775368*std::pow(-8.72799968719482*x_70 - 9.33439922332764, 2) - 0.000687468918643956*std::pow(-5.99983978271484*x_71 - 9.40424060821533, 2) + 0.000141086370163271*std::pow(-7.0*x_77 - 9.99993991851807, 2) - 0.00130880011182184*std::pow(-4.67551946640015*x_78 - 6.30359983444214, 2) - 0.5579394486398*std::sin(0.367199838161469*x_101 + 8.17160034179688) - 0.451162023407463*std::sin(0.394879847764969*x_102 + 2.00839972496033) - 0.990836770830839*std::sin(0.323359847068787*x_103 + 5.13160037994385) - 0.587396978166016*std::sin(0.444559872150421*x_108 - 4.1657600402832) + 0.977590271737064*std::sin(0.394479840993881*x_110 + 5.18344020843506) + 0.540101723202159*std::sin(0.398479819297791*x_112 - 4.41079998016357) - 0.293702901706915*std::sin(0.395199835300446*x_114 - 1.21023988723755) + 1.25002377216005*std::sin(0.205119997262955*x_14 - 4.38215970993042) - 3.64122791260701*std::sin(0.287039935588837*x_15 + 5.13007974624634) + 0.538694788740067*std::sin(0.312719851732254*x_30 - 4.26567983627319) + 0.92894685133804*std::sin(0.285759925842285*x_33 + 8.2041597366333) + 0.416069157613233*std::sin(0.318159908056259*x_34 + 8.25111961364746) + 0.771505617583735*std::sin(0.267279952764511*x_37 + 5.08191967010498) - 0.154858542790242*std::sin(0.465279847383499*x_41 - 4.34639978408813) - 1.52935260095828*std::sin(0.198400005698204*x_42 + 5.00551986694336) + 1.51653248401675*std::sin(0.294879943132401*x_47 - 7.48031997680664) + 1.2317621578016*std::sin(0.335119843482971*x_51 + 5.13655996322632) + 0.237724255882961*std::sin(0.409919857978821*x_52 + 5.20424032211304) + 0.478709698071476*std::sin(0.306479841470718*x_67 - 7.49200010299683) - 0.529685120949004*std::sin(0.281279861927032*x_84 - 1.29047977924347) + 3.01855926833454*std::sin(0.173280015587807*x_86 - 7.63872003555298) + 2.78576490273343*std::sin(0.184800013899803*x_88 - 7.60400009155273) + 1.02444553071348*std::sin(0.314479917287827*x_9 + 8.34624004364014) - 0.521486861480529*std::sin(0.36983984708786*x_94 + 5.17535972595215) + 0.578033785986051*std::sin(0.33247983455658*x_99 - 7.45544004440308) - 0.94665224099945, 2) - 0.00146405768166788*std::exp(0.649039804935455*x_22) - 0.000181530803982594*std::exp(0.715519845485687*x_22) + 4.03290349243157e-5*std::exp(0.543359875679016*x_67) - 9.59925354619872e-5*std::exp(0.656719863414764*x_69) + 0.00285130216446813*std::sin(0.217519998550415*x_1 + 1.81207990646362) - 0.00283238787455202*std::sin(0.322799921035767*x_1 + 1.95039975643158) - 0.00273838675522861*std::sin(0.269199937582016*x_10 + 5.06816005706787) - 0.00273509638323254*std::sin(0.183680012822151*x_102 + 1.7850399017334) - 0.00471627504762403*std::sin(0.315999835729599*x_102 - 4.44975996017456) - 0.00513518366762996*std::sin(0.324799835681915*x_102 + 5.12800025939941) - 8.93639984095509e-5*std::sin(0.467919856309891*x_102 + 5.0220799446106) - 0.00332964202931835*std::sin(0.178960010409355*x_103 - 7.6241602897644) + 0.000291988118213526*std::sin(0.366719841957092*x_103 - 7.41215991973877) + 8.01863178456744e-5*std::sin(0.310239911079407*x_105 + 1.91767990589142) + 0.00128956990595947*std::sin(0.308159917593002*x_107 + 1.90919995307922) + 0.00149522946822437*std::sin(0.410559862852097*x_107 + 5.20783996582031) + 4.99439378619087e-5*std::sin(1.69463980197906*x_107 - 6.01591968536377) - 0.00591167457032416*std::sin(0.303359925746918*x_111 - 7.49376010894775) - 0.00048879509304767*std::sin(0.141760036349297*x_112 + 8.10503959655762) + 0.00866024187473233*std::sin(0.270639955997467*x_112 - 7.53815984725952) - 0.0011247814108434*std::sin(0.362479835748672*x_112 - 7.42967987060547) + 0.00506538745274188*std::sin(0.271599948406219*x_113 + 5.0623197555542) + 0.003676345046061*std::sin(0.269599944353104*x_115 + 1.86295986175537) + 8.33812606747791e-5*std::sin(0.457519859075546*x_115 - 1.14735984802246) + 0.00141634843051001*std::sin(0.350239843130112*x_117 - 7.43336009979248) - 4.61100516172605e-6*std::sin(1.79807984828949*x_117 + 8.98896026611328) - 0.00387455328006032*std::sin(0.238799974322319*x_118 - 1.3614399433136) - 0.000157850493822215*std::sin(0.279359966516495*x_118 - 7.5207200050354) + 0.00139659173141368*std::sin(0.279519945383072*x_118 + 1.8647198677063) - 0.0125699247832524*std::sin(0.373199850320816*x_119 + 1.97575974464417) + 0.00381003533148407*std::sin(0.3572798371315*x_12 - 1.03671979904175) - 0.000915496650046005*std::sin(0.416479855775833*x_12 - 4.17271995544434) - 0.00228071923406422*std::sin(0.328719854354858*x_120 - 7.45576000213623) + 0.00624508850886851*std::sin(0.330799847841263*x_120 + 5.12911987304688) + 0.00344258245012693*std::sin(0.126080051064491*x_13 + 8.07575988769531) - 0.00017930294677025*std::sin(0.277359962463379*x_13 - 1.07599985599518) - 0.0172464680928347*std::sin(0.182000011205673*x_14 + 8.18039894104004) + 0.000188735210318191*std::sin(1.16935980319977*x_15 + 5.98727989196777) + 0.000159265916871483*std::sin(0.292079925537109*x_16 + 8.31447982788086) - 0.0158416636671117*std::sin(0.345759838819504*x_16 + 5.15791988372803) - 0.00158783493358197*std::sin(0.358719855546951*x_16 + 8.34712028503418) + 0.00499659318578952*std::sin(0.402959853410721*x_16 + 1.97447979450226) - 0.000989019379725677*std::sin(1.47319984436035*x_2 - 3.38879990577698) - 0.000201816098993575*std::sin(0.243679970502853*x_21 + 8.26344013214111) - 0.0129564368765569*std::sin(0.390239834785461*x_23 + 1.97439980506897) - 0.000379428536814894*std::sin(0.186960011720657*x_24 + 4.96975994110107) - 0.000538537721985746*std::sin(0.209600001573563*x_24 - 4.37680006027222) + 0.000944828114194234*std::sin(0.271279960870743*x_24 + 1.85807991027832) + 0.0060774253540604*std::sin(0.333439826965332*x_24 + 5.13248014450073) - 0.000525123418484932*std::sin(1.16631984710693*x_25 - 8.98752021789551) - 0.00409984163607636*std::sin(0.338239848613739*x_26 - 7.44767951965332) + 0.000735440569510963*std::sin(0.353679865598679*x_26 + 1.9618399143219) - 0.00331861155651684*std::sin(0.32687982916832*x_27 + 8.30775928497314) - 0.00081646919350756*std::sin(0.378799855709076*x_27 - 7.41504001617432) + 0.0232879064723833*std::sin(0.136960044503212*x_28 + 8.09280014038086) + 0.00354785401037742*std::sin(0.19055999815464*x_28 - 4.42063999176025) + 0.0117517603464501*std::sin(0.300159931182861*x_3 - 1.0843198299408) + 0.00183177346556137*std::sin(0.359999865293503*x_3 - 1.0461597442627) - 0.00626475453031646*std::sin(0.281439960002899*x_30 - 7.52135992050171) + 0.00876637632898376*std::sin(0.283119946718216*x_33 - 1.17807984352112) + 0.0138579887560478*std::sin(0.292399942874908*x_33 + 8.20679950714111) + 0.00299161864451735*std::sin(0.303599923849106*x_33 - 1.19399988651276) - 0.00197311464466974*std::sin(0.328159838914871*x_34 - 7.41232013702393) - 0.0123521778821297*std::sin(0.341119825839996*x_34 - 1.19039988517761) + 0.000187641545130265*std::sin(0.350879848003387*x_34 + 2.00583982467651) + 0.00114298250803905*std::sin(0.355279833078384*x_34 + 1.97823989391327) - 9.91273366209105e-5*std::sin(0.291759938001633*x_35 + 8.24959945678711) - 0.00198862217808375*std::sin(0.321279853582382*x_35 + 1.77135992050171) + 0.00438508270907465*std::sin(0.322319835424423*x_35 - 4.42935991287231) + 0.00324359024345062*std::sin(0.346479833126068*x_35 + 8.19127941131592) - 0.00878030498421594*std::sin(0.285039931535721*x_36 - 7.51999998092651) - 0.00429549262422384*std::sin(0.317039847373962*x_36 - 4.27767992019653) + 0.00165029224554552*std::sin(0.322799831628799*x_36 - 7.46775960922241) + 0.000204081222175376*std::sin(0.331679850816727*x_36 + 5.1483998298645) - 0.00203835970773712*std::sin(0.352559864521027*x_36 + 5.15791988372803) - 0.000131317135918404*std::sin(0.353839844465256*x_36 + 5.14800024032593) - 0.00187933130201293*std::sin(0.26335996389389*x_37 + 1.8458399772644) + 0.00295641792610237*std::sin(0.317519843578339*x_37 + 5.12696027755737) + 0.00569407000561883*std::sin(0.225279986858368*x_38 + 5.02023983001709) + 2.94195292693757e-5*std::sin(0.474399864673615*x_39 - 7.7836799621582) - 0.00511454173649001*std::sin(0.256319969892502*x_41 - 4.32304000854492) + 0.000222644460408569*std::sin(0.295359939336777*x_41 - 4.28927993774414) - 0.00676874694073044*std::sin(0.333999842405319*x_41 + 5.13104009628296) + 0.000289894061675653*std::sin(0.360479861497879*x_41 + 4.78455972671509) - 0.00362148145208717*std::sin(0.403279840946198*x_42 + 8.20879936218262) + 0.00253680151766999*std::sin(0.409599870443344*x_42 + 2.00727987289429) + 0.00467270568042456*std::sin(0.189600005745888*x_43 - 7.60376024246216) - 0.000161482687785722*std::sin(0.236559987068176*x_43 - 7.55200004577637) + 0.00133768492093764*std::sin(0.26199996471405*x_43 + 5.06319952011108) - 0.000388139932634139*std::sin(0.337439835071564*x_43 + 5.13944005966187) + 0.00388912117459751*std::sin(0.356799840927124*x_43 + 5.16048002243042) + 0.000246133351424393*std::sin(0.373679846525192*x_43 - 1.21103978157043) - 0.0109143592045521*std::sin(0.32711985707283*x_47 + 8.3133602142334) - 4.68592831032e-5*std::sin(1.76415991783142*x_49 - 7.41623973846436) - 0.000337247610132563*std::sin(0.399759829044342*x_50 - 1.19031989574432) + 0.00574893612640268*std::sin(0.254639983177185*x_51 + 1.83439981937408) + 0.000262811390512636*std::sin(0.477919846773148*x_51 + 8.44704055786133) + 0.00528190646249857*std::sin(0.26639997959137*x_52 + 8.27744007110596) - 0.0041509814067345*std::sin(0.597679853439331*x_52 + 2.00543975830078) - 0.000111749470496143*std::sin(0.383759826421738*x_54 - 7.42215967178345) - 0.00145921314334056*std::sin(0.454879850149155*x_54 - 1.15599977970123) - 0.00090514672647006*std::sin(0.460639864206314*x_54 - 1.13079988956451) - 0.00796043647063041*std::sin(0.331519842147827*x_55 - 4.2804799079895) - 8.20633277309309e-5*std::sin(0.330559849739075*x_57 + 1.92791974544525) + 6.35429108519031e-5*std::sin(0.350719839334488*x_58 - 7.43415975570679) + 1.93136754490341e-6*std::sin(1.39943981170654*x_6 - 5.19679975509644) - 0.00466683631412609*std::sin(0.186400011181831*x_64 - 4.42831993103027) + 0.0102151177620074*std::sin(0.14544004201889*x_68 + 4.9206395149231) - 0.0126936839113756*std::sin(0.167200013995171*x_71 - 4.45599985122681) - 0.00913156008235137*std::sin(0.207039996981621*x_73 - 7.59656000137329) + 0.00992058503284604*std::sin(0.250639975070953*x_73 - 7.52424001693726) - 0.00106488217731453*std::sin(0.269359946250916*x_75 + 5.09375953674316) - 0.00083165304566633*std::sin(0.171120017766953*x_76 - 7.64520025253296) + 0.00862337325825785*std::sin(0.22223998606205*x_76 - 7.56864023208618) + 0.00400632463511744*std::sin(0.243519976735115*x_79 - 7.54839992523193) - 0.0684750586232884*std::sin(0.134880036115646*x_80 + 4.91583967208862) + 5.50151760448244e-5*std::sin(0.295519828796387*x_85 - 1.26815986633301) + 0.0333381254198516*std::sin(0.157360032200813*x_86 - 7.64720010757446) + 0.00439946636338432*std::sin(0.364959836006165*x_86 + 1.95703983306885) - 0.000243120118014977*std::sin(0.214479997754097*x_88 + 5.01127958297729) + 0.00171440959758779*std::sin(0.356559842824936*x_9 - 4.25672006607056) - 0.00477960138270256*std::sin(0.336159855127335*x_92 + 5.19160032272339) - 0.000236609229335*std::sin(0.361919850111008*x_92 - 7.40287971496582) - 0.00154449298569608*std::sin(0.367439836263657*x_92 + 1.98079979419708) - 0.0157996829726105*std::sin(0.392559856176376*x_92 + 1.97831988334656) + 8.02545334876819e-5*std::sin(0.345039844512939*x_93 - 1.42127990722656) + 0.0141390366879779*std::sin(0.361599832773209*x_93 - 7.40575981140137) + 0.00406511953552755*std::sin(0.409999877214432*x_93 + 1.99575984477997) - 0.00070824324067055*std::sin(0.379439830780029*x_94 + 4.98119974136353) + 0.00276316179621235*std::sin(0.398239850997925*x_94 + 5.19799995422363) - 4.87027740053218e-5*std::sin(0.328559845685959*x_95 + 1.94279980659485) + 0.00139753751490882*std::sin(0.344959855079651*x_95 - 7.42527961730957) + 0.00826541616242838*std::sin(0.373599827289581*x_95 - 7.42496013641357) + 0.00495028841159119*std::sin(0.386799842119217*x_95 + 8.18487930297852) + 0.00141734380242865*std::sin(0.346959829330444*x_96 + 1.94447982311249) - 0.00113811429894507*std::sin(0.42103984951973*x_96 - 1.15919995307922) + 0.00140832043317487*std::sin(0.449839860200882*x_96 + 8.23176002502441) + 0.00227091358673349*std::sin(0.312559932470322*x_97 + 1.90231990814209) - 0.00155148286563714*std::sin(0.371679842472076*x_97 - 7.43088006973267) + 0.00570766253570932*std::sin(0.411279857158661*x_98 + 5.21224021911621) + 0.00594798767479549*std::sin(0.463359862565994*x_98 + 2.01143980026245) + 0.00127409804228528*std::sin(0.396479845046997*x_99 + 2.0019998550415) - 0.000100750928039431*std::sin(0.39743983745575*x_99 - 7.39287996292114) + 0.0449510883160687);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000192108059338415*x_1 - 0.00326398484948834*x_10 - 0.000174132958332013*x_100 + 0.000612110896731781*x_101 + 3.78591499548823e-7*x_102 + 0.00107693184663301*x_103 - 0.00132662220375516*x_104 - 0.00154832396954781*x_105 + 2.07076982619664e-6*x_106 + 0.000198315634467047*x_107 - 1.55719651570066e-5*x_108 + 0.00145075514712754*x_109 - 0.000143249581738897*x_11 + 6.77011784636037e-5*x_110 + 0.00221109368168098*x_111 + 0.00182394523573419*x_112 - 0.000306941228911872*x_113 + 3.92739904744939e-5*x_114 + 1.23292474098052e-5*x_115 + 0.00126042414741783*x_116 + 0.00173903364839356*x_117 - 4.45458292311275e-7*x_118 - 0.000315772696075926*x_119 - 0.00260098704815404*x_12 + 0.000530157267399597*x_120 - 0.000269545032324094*x_13 - 3.5201735246701e-6*x_14 + 0.000377953545735474*x_15 + 0.000513066678870571*x_16 + 0.00441789475346002*x_17 - 0.000128870339883448*x_18 + 0.000339932443303522*x_19 - 0.0012440939232834*x_2 - 0.00250039472780862*x_20 + 0.00110027279730623*x_21 + 2.88596614325327e-5*x_22 - 1.05638712375743e-5*x_23 - 2.58390429748195e-5*x_24 - 0.000170605294138715*x_25 - 0.000511052097701898*x_26 + 0.000319592847299773*x_27 + 0.000279965151593863*x_28 + 0.00225150394190385*x_29 - 0.000327316809321297*x_3 + 0.000746256861547799*x_30 - 0.00125504171017847*x_31 + 0.00189904157525056*x_32 + 0.000426292224908173*x_33 - 0.000454331433233963*x_34 + 0.000489929447565005*x_35 - 0.000151658514655113*x_36 - 1.20186815360092e-5*x_37 + 0.000281559506632855*x_38 - 0.000764323041214346*x_39 + 0.00456883394731358*x_4 - 0.000204087758783227*x_40 - 1.00240308425063e-5*x_41 + 0.00010159160257709*x_42 - 0.000147790882930424*x_43 - 0.00119358048587474*x_44 - 0.000580729822184983*x_45 + 2.73404414748852e-6*x_46 - 0.00170310178367545*x_47 - 0.000128289862382623*x_48 + 0.000700460549289079*x_49 + 0.000361906471417485*x_5 - 7.63161522728167e-5*x_50 - 0.000653259341278553*x_51 + 5.26900276516757e-5*x_52 + 5.99141903239107e-5*x_53 + 0.000195581509126797*x_54 - 1.12496874247298e-5*x_55 + 0.000376343734062741*x_56 - 0.000319023167061338*x_57 + 0.000531830424985682*x_58 + 0.00221232622049532*x_59 + 0.000909737507020428*x_6 - 0.000928163292789453*x_60 - 0.000154896949100626*x_61 - 0.000667090717647598*x_62 + 0.0016737391276229*x_63 - 4.54335243116665e-5*x_64 + 8.11615961231439e-7*x_65 - 0.000398671324803174*x_66 + 0.000450271192076414*x_67 + 0.000362124576445846*x_68 + 0.000291101745932094*x_69 + 0.000132528500233495*x_7 + 0.0003843064222081*x_70 + 8.499841527715e-5*x_71 + 0.000601409182153194*x_72 - 0.000214365228413678*x_73 - 0.000525982081376988*x_74 - 0.000221334977827881*x_75 - 0.00066719674516568*x_76 + 0.000128935401039396*x_77 - 4.56663242896028e-5*x_78 - 1.78257710509169e-5*x_79 - 0.00120531680327147*x_8 + 3.42731160948857e-5*x_80 + 0.000666064898931125*x_81 - 0.000224399225649255*x_82 - 0.00066252987822551*x_83 - 0.000161277398351478*x_84 - 0.000101192341619667*x_85 - 0.000104723974855259*x_86 + 9.87763618711377e-8*x_87 + 0.000178545539291591*x_88 + 0.000953694769832728*x_89 - 0.000400448853342212*x_9 - 0.000922236901861243*x_90 - 0.00146059496918076*x_91 + 4.10881647874614e-5*x_92 - 0.000988505392032551*x_93 + 5.18776800772628e-5*x_94 - 0.000105857149489864*x_95 - 9.882607578948e-5*x_96 + 0.000532040713703118*x_97 - 6.54406271229837e-5*x_98 + 0.000102902935861004*x_99 + 6.96016377776339e-8*std::pow(-5.55215978622437*x_100 - 7.38375997543335, 2) - 3.22400586743682e-6*std::pow(-9.58480072021484*x_106 - 7.96384000778198, 2) + 5.80915724349317e-6*std::pow(-7.98799991607666*x_106 - 8.19944000244141, 2) + 3.1643568245449e-6*std::pow(-6.71752023696899*x_106 - 9.56103992462158, 2) + 4.83621948149227e-8*std::pow(-5.86383962631226*x_106 - 8.48952007293701, 2) + 8.39817614234612e-6*std::pow(-8.47000026702881*x_116 - 8.86903953552246, 2) + 1.27933889376602e-7*std::pow(-6.09335994720459*x_13 - 9.55160045623779, 2) - 2.31127715700423e-5*std::pow(-4.07000017166138*x_13 - 6.52231979370117, 2) - 1.70964817954292e-6*std::pow(-5.6691198348999*x_15 - 7.42512035369873, 2) + 8.17345635232913e-6*std::pow(-5.32231998443604*x_15 - 8.46951961517334, 2) - 1.50022890338831e-5*std::pow(-5.46256017684937*x_17 - 8.0926399230957, 2) - 1.94951491464215e-7*std::pow(-3.47519993782043*x_18 - 4.50079965591431, 2) - 5.30287951830022e-5*std::pow(-1.34583985805511*x_2 - 2.49487972259521, 2) + 3.84568564471905e-5*std::pow(-5.71983957290649*x_22 - 9.39935970306396, 2) + 1.23817632208549e-5*std::pow(-5.3167200088501*x_22 - 8.58440017700195, 2) + 2.07641375350107e-5*std::pow(-5.90136003494263*x_23 - 8.54720020294189, 2) - 3.61850181713052e-7*std::pow(-5.04120016098022*x_23 - 8.87744045257568, 2) + 7.01203576788946e-6*std::pow(-4.40399980545044*x_23 - 9.9993200302124, 2) - 9.78914365665715e-6*std::pow(-5.77959966659546*x_24 - 8.97016048431396, 2) + 7.75370066765406e-6*std::pow(-4.79911994934082*x_36 - 3.79999995231628, 2) - 5.83929549209176e-7*std::pow(-5.51895999908447*x_38 - 6.90023994445801, 2) + 1.13720127679512e-6*std::pow(-3.78287982940674*x_38 - 6.56720018386841, 2) + 1.04656780071878e-5*std::pow(-5.15136003494263*x_40 - 5.74847984313965, 2) - 1.31022801343151e-5*std::pow(-5.46367979049683*x_47 - 7.07823991775513, 2) - 5.53419122020353e-7*std::pow(-7.80000019073486*x_49 - 9.99882030487061, 2) - 0.000223083951654604*std::pow(-0.788719892501831*x_49 - 1.1847198009491, 2) + 5.43363536817197e-7*std::pow(-5.88295984268188*x_5 - 9.54328060150146, 2) - 6.40628207532687e-7*std::pow(-3.3374400138855*x_5 - 5.49232006072998, 2) + 1.80062021587315e-6*std::pow(-9.99993991851807*x_50 - 7.19999980926514, 2) - 1.75093472914581e-5*std::pow(-4.51688003540039*x_53 - 6.4747200012207, 2) - 7.66688552770287e-8*std::pow(-6.19600009918213*x_57 - 9.98884010314941, 2) - 2.99865388388066e-5*std::pow(-3.92007994651794*x_58 - 5.68487977981567, 2) - 1.30659588802032e-5*std::pow(-6.60400009155273*x_64 - 9.96195983886719, 2) - 3.00838283013025e-6*std::pow(-6.08367967605591*x_66 - 9.94783973693848, 2) - 5.28871193140446e-6*std::pow(-3.43055987358093*x_67 - 6.46231985092163, 2) + 4.58598134451709e-6*std::pow(-6.92199993133545*x_69 - 9.16287994384766, 2) - 5.61047139605581e-7*std::pow(-6.40399980545044*x_69 - 9.99507999420166, 2) + 2.52681204963003e-5*std::pow(-6.09127998352051*x_7 - 9.73591995239258, 2) - 1.74993577812204e-5*std::pow(-5.54423999786377*x_7 - 8.90136051177979, 2) - 5.73744051767577e-5*std::pow(-2.79311990737915*x_7 - 4.79031991958618, 2) + 4.60305762583292e-6*std::pow(-8.72799968719482*x_70 - 9.33439922332764, 2) - 2.1784090639825e-6*std::pow(-7.34127998352051*x_70 - 7.9312801361084, 2) + 7.89561541519435e-6*std::pow(-5.99983978271484*x_71 - 9.40424060821533, 2) - 1.17751046820746e-6*std::pow(-5.7838397026062*x_72 - 7.57272005081177, 2) - 6.62272459177799e-8*std::pow(-5.50311994552612*x_73 - 8.97648048400879, 2) - 5.69779006748029e-8*std::pow(-4.92944002151489*x_74 - 6.36568021774292, 2) - 1.62038412053922e-6*std::pow(-7.0*x_77 - 9.99993991851807, 2) + 1.50316356973522e-5*std::pow(-4.67551946640015*x_78 - 6.30359983444214, 2) + 1.57330415767449e-5*std::pow(-4.72591972351074*x_79 - 6.36720037460327, 2) - 8.27176332402587e-8*std::pow(-4.89039993286133*x_84 - 8.17303943634033, 2) + 5.46518203706507e-6*std::pow(-5.33200025558472*x_85 - 8.39999961853027, 2) + 1.54258185261293e-5*std::pow(-5.27888011932373*x_86 - 8.12639999389648, 2) - 6.83493365166473e-8*std::pow(-7.70527982711792*x_87 - 8.48975944519043, 2) + 6.38488683070755e-6*std::pow(-8.80000019073486*x_88 - 9.99983978271484, 2) + 1.16813490440519e-5*std::pow(-4.33304023742676*x_90 - 5.97864007949829, 2) - 0.00086477940203622*std::pow(-0.076759304702341*x_1 + 0.369323603086497*x_10 - 0.138083433203526*x_100 - 0.00425537370785232*x_101 - 0.00288692933848458*x_103 + 0.111708245179204*x_104 - 0.0253937746253508*x_105 + 0.00975184208914149*x_106 - 0.0114311088856953*x_107 - 0.0877468758852984*x_108 + 0.0076905725969749*x_109 - 0.0107918812297385*x_11 - 0.112432914013395*x_110 + 0.0488994165703404*x_111 - 0.00766052938084959*x_113 - 0.00652370375100703*x_114 - 0.00892370744372498*x_115 - 0.185816374288534*x_116 - 0.00595492587554442*x_117 + 0.0725483107138432*x_118 + 0.0347522434059409*x_13 - 0.0358915664231898*x_15 - 0.184012114027896*x_17 - 0.0112077985814258*x_19 + 0.0617604299727814*x_2 - 0.333669345440225*x_20 - 0.0282967135122621*x_21 + 0.0741386767353185*x_24 - 0.00454556547205481*x_25 - 0.0703333799180623*x_26 - 0.0160882851405663*x_27 - 0.0194127868318779*x_29 - 0.10923035756922*x_3 + 0.00666903433643301*x_31 - 0.27722539322734*x_32 + 0.118832753502696*x_35 + 0.00626343503353784*x_37 + 0.00727225001107237*x_38 + 0.0105788838249642*x_39 - 0.0454340986445122*x_4 - 0.000931426146467602*x_40 + 0.000169577136729273*x_41 - 0.0925629279946566*x_42 - 0.15747025866797*x_43 - 0.0156519377297685*x_44 - 0.00634049485030304*x_45 - 0.00443559104394659*x_46 + 0.0634770322825558*x_48 - 0.0254524528238685*x_49 - 0.0592349612416305*x_5 - 0.117121490412294*x_50 - 0.0883985414114671*x_51 + 0.000232745576622751*x_53 + 0.130152851473344*x_56 + 0.0376263153612775*x_57 - 0.0296170969291142*x_58 - 0.00127784366644741*x_59 - 0.0620248536765097*x_6 - 0.0088453360439143*x_60 - 0.00278126278583497*x_61 - 0.21547797427079*x_62 + 0.0169260881080453*x_63 - 0.00169722107299173*x_64 - 0.000606871509409584*x_65 - 0.0728304159633985*x_66 - 0.0026121610823266*x_67 + 0.00201461865747913*x_69 - 0.00404788386534442*x_71 + 0.0150340463600522*x_72 + 0.0267396622557739*x_73 - 0.00225234562719133*x_74 + 0.00304911529487286*x_75 + 0.0187049020405805*x_76 + 0.00405207067671475*x_77 + 0.0641758677477526*x_78 - 0.00372609101121694*x_79 - 0.0840114583522211*x_8 + 0.000105007246211952*x_81 - 2.13054620377757e-5*x_82 + 0.000123611491806778*x_83 + 0.00489106208305398*x_84 - 0.0920853859712713*x_87 + 0.024537508957936*x_88 + 0.0169704852859731*x_89 - 0.153869900528888*x_9 + 0.0212891625523552*x_90 - 0.459319744279342*x_91 - 0.125634898814151*x_92 - 0.00240402654779533*x_96 + 0.0840840976436032*x_97 - 0.0573685247853477*x_99 + 0.00256062612542668*std::pow(-5.10199975967407*x_14 - 7.75728034973145, 2) + 0.00318572247429214*std::pow(-5.03071975708008*x_18 - 7.24015998840332, 2) + 0.000869958966084591*std::pow(-7.36400032043457*x_54 - 9.79903984069824, 2) + 0.000101170901245651*std::pow(-8.16296005249023*x_55 - 7.95711994171143, 2) + 0.003422217451752*std::pow(-3.24863982200623*x_68 - 5.47495985031128, 2) + 0.0021096413643317*std::pow(-5.7707200050354*x_7 - 9.56975936889648, 2) + 0.000999799525335895*std::pow(-4.89879989624023*x_70 - 7.14247989654541, 2) + 0.000615351355045569*std::pow(-5.09136009216309*x_85 - 8.60568046569824, 2) + 0.00148272870164666*std::pow(-6.66607999801636*x_86 - 8.43383884429932, 2) + 0.159486602033006*std::exp(0.649039804935455*x_22) + 0.513765742304436*std::sin(0.315999835729599*x_102 - 4.44975996017456) - 0.943400363714858*std::sin(0.270639955997467*x_112 - 7.53815984725952) + 1.36930027866632*std::sin(0.373199850320816*x_119 + 1.97575974464417) - 0.41504484164302*std::sin(0.3572798371315*x_12 - 1.03671979904175) - 0.680306492118632*std::sin(0.330799847841263*x_120 + 5.12911987304688) - 0.544302098831935*std::sin(0.402959853410721*x_16 + 1.97447979450226) + 1.41140483586899*std::sin(0.390239834785461*x_23 + 1.97439980506897) - 2.53685979606465*std::sin(0.136960044503212*x_28 + 8.09280014038086) + 0.68244880315973*std::sin(0.281439960002899*x_30 - 7.52135992050171) - 1.50961506871492*std::sin(0.292399942874908*x_33 + 8.20679950714111) + 1.34558009755726*std::sin(0.341119825839996*x_34 - 1.19039988517761) + 0.95647939577816*std::sin(0.285039931535721*x_36 - 7.51999998092651) + 1.18895183208809*std::sin(0.32711985707283*x_47 + 8.3133602142334) + 0.452185680900278*std::sin(0.597679853439331*x_52 + 2.00543975830078) + 7.45930611927662*std::sin(0.134880036115646*x_80 + 4.91583967208862) - 1.54023092506621*std::sin(0.361599832773209*x_93 - 7.40575981140137) - 0.301004045990378*std::sin(0.398239850997925*x_94 + 5.19799995422363) - 0.5392579047491*std::sin(0.386799842119217*x_95 + 8.18487930297852) - 0.647941918590696*std::sin(0.463359862565994*x_98 + 2.01143980026245) + 2.66444612749699, 2) + 0.00167793130696782*std::exp(0.715519845485687*x_22) - 0.000395954837085768*std::exp(0.656719863414764*x_69) + 0.000150400435766046*std::sin(0.217519998550415*x_1 + 1.81207990646362) - 0.0116831759264871*std::sin(0.322799921035767*x_1 + 1.95039975643158) - 0.000144444375771439*std::sin(0.269199937582016*x_10 + 5.06816005706787) + 0.00640796287941995*std::sin(0.367199838161469*x_101 + 8.17160034179688) - 0.0112818630909647*std::sin(0.183680012822151*x_102 + 1.7850399017334) + 0.00518161873236791*std::sin(0.394879847764969*x_102 + 2.00839972496033) + 0.0307766532148715*std::sin(0.178960010409355*x_103 - 7.6241602897644) + 0.0113798105915026*std::sin(0.323359847068787*x_103 + 5.13160037994385) - 0.00136321548199694*std::sin(0.418079853057861*x_103 - 1.19207990169525) - 0.00237519911209695*std::sin(0.451519846916199*x_104 - 1.14063990116119) + 0.000579130586012279*std::sin(0.310239911079407*x_105 + 1.91767990589142) + 6.80222104216239e-5*std::sin(0.308159917593002*x_107 + 1.90919995307922) + 0.00177524822160497*std::sin(0.410559862852097*x_107 + 5.20783996582031) + 0.000206011266233975*std::sin(1.69463980197906*x_107 - 6.01591968536377) + 0.00674628410080623*std::sin(0.444559872150421*x_108 - 4.1657600402832) + 0.00294525013807179*std::sin(0.330799847841263*x_110 - 4.43279981613159) - 0.0112276738772371*std::sin(0.394479840993881*x_110 + 5.18344020843506) - 0.00701878206034695*std::sin(0.303359925746918*x_111 - 7.49376010894775) - 5.93299498174901e-5*std::sin(0.362479835748672*x_112 - 7.42967987060547) - 0.00620309569762029*std::sin(0.398479819297791*x_112 - 4.41079998016357) + 0.00601400671824561*std::sin(0.271599948406219*x_113 + 5.0623197555542) + 0.0033731927296126*std::sin(0.395199835300446*x_114 - 1.21023988723755) + 0.00646549301724185*std::sin(0.20720000565052*x_115 - 1.37271988391876) + 0.00436483171561377*std::sin(0.269599944353104*x_115 + 1.86295986175537) - 0.00844210661369273*std::sin(0.189600005745888*x_117 + 8.18416023254395) + 7.47095217756398e-5*std::sin(0.350239843130112*x_117 - 7.43336009979248) - 0.0159819521945426*std::sin(0.238799974322319*x_118 - 1.3614399433136) - 0.00114004547715391*std::sin(0.279359966516495*x_118 - 7.5207200050354) + 0.00165813812541066*std::sin(0.279519945383072*x_118 + 1.8647198677063) - 0.00269089582714602*std::sin(0.398399829864502*x_119 + 8.18903923034668) - 4.8290600984045e-5*std::sin(0.416479855775833*x_12 - 4.17271995544434) - 0.000120303337519911*std::sin(0.328719854354858*x_120 - 7.45576000213623) - 0.0090084348383219*std::sin(0.165200024843216*x_13 + 4.96023941040039) - 0.00129498178026621*std::sin(0.277359962463379*x_13 - 1.07599985599518) - 0.0204762964223345*std::sin(0.182000011205673*x_14 + 8.18039894104004) - 0.0143565864538202*std::sin(0.205119997262955*x_14 - 4.38215970993042) + 0.0418196873448841*std::sin(0.287039935588837*x_15 + 5.13007974624634) + 9.9554015109259e-6*std::sin(1.16935980319977*x_15 + 5.98727989196777) + 0.00115026810368174*std::sin(0.292079925537109*x_16 + 8.31447982788086) - 8.37550887840839e-5*std::sin(0.358719855546951*x_16 + 8.34712028503418) + 0.000292296354093463*std::sin(1.44519984722137*x_16 - 3.38727998733521) - 0.00285818623814079*std::sin(0.412719875574112*x_18 - 7.16936016082764) + 0.0045202462063706*std::sin(0.363679856061935*x_21 + 5.15895986557007) + 0.0336166787926685*std::sin(0.179360017180443*x_23 - 7.61696004867554) - 0.00274035118183501*std::sin(0.186960011720657*x_24 + 4.96975994110107) + 4.98377765322994e-5*std::sin(0.271279960870743*x_24 + 1.85807991027832) + 0.0250684696928421*std::sin(0.333439826965332*x_24 + 5.13248014450073) - 0.00309460898488597*std::sin(0.547119855880737*x_24 + 8.55247974395752) - 0.00486763853172965*std::sin(0.338239848613739*x_26 - 7.44767951965332) - 0.00937534564349168*std::sin(0.339359849691391*x_26 + 8.35319995880127) - 0.00679784768713419*std::sin(0.353679865598679*x_26 + 1.9618399143219) - 0.000175050063251178*std::sin(0.32687982916832*x_27 + 8.30775928497314) + 0.00754681404425697*std::sin(0.378799855709076*x_27 - 7.41504001617432) + 0.000187142140122709*std::sin(0.19055999815464*x_28 - 4.42063999176025) + 0.00118383759816318*std::sin(0.457199841737747*x_28 - 7.13647985458374) - 0.0169315068170637*std::sin(0.359999865293503*x_3 - 1.0461597442627) - 0.0061869369839304*std::sin(0.312719851732254*x_30 - 4.26567983627319) + 0.0104080974316466*std::sin(0.283119946718216*x_33 - 1.17807984352112) - 0.0106690017256177*std::sin(0.285759925842285*x_33 + 8.2041597366333) + 0.000157801846955483*std::sin(0.303599923849106*x_33 - 1.19399988651276) - 0.00477857538798689*std::sin(0.318159908056259*x_34 + 8.25111961364746) - 0.00234262923411504*std::sin(0.328159838914871*x_34 - 7.41232013702393) + 0.00135520573722668*std::sin(0.350879848003387*x_34 + 2.00583982467651) + 6.02900209680542e-5*std::sin(0.355279833078384*x_34 + 1.97823989391327) - 0.00315087897450642*std::sin(0.384159833192825*x_34 - 1.19863986968994) - 0.000715928528575043*std::sin(0.291759938001633*x_35 + 8.24959945678711) - 0.00820276875445286*std::sin(0.321279853582382*x_35 + 1.77135992050171) + 0.00385103285727707*std::sin(0.346479833126068*x_35 + 8.19127941131592) - 0.00509993001350238*std::sin(0.317039847373962*x_36 - 4.27767992019653) - 0.015254033826196*std::sin(0.322799831628799*x_36 - 7.46775960922241) - 0.00010751936154364*std::sin(0.352559864521027*x_36 + 5.15791988372803) - 0.000948413294450606*std::sin(0.353839844465256*x_36 + 5.14800024032593) + 0.017371094925104*std::sin(0.26335996389389*x_37 + 1.8458399772644) - 0.00886078116683265*std::sin(0.267279952764511*x_37 + 5.08191967010498) + 0.00154583518990845*std::sin(0.292879939079285*x_37 + 5.11407995223999) + 0.000155945080087746*std::sin(0.317519843578339*x_37 + 5.12696027755737) + 0.000300350703197811*std::sin(0.225279986858368*x_38 + 5.02023983001709) - 0.00607236635913187*std::sin(0.256319969892502*x_41 - 4.32304000854492) - 0.00267955802055655*std::sin(0.360479861497879*x_41 + 4.78455972671509) + 0.00311197140299173*std::sin(0.363999843597412*x_41 - 1.21383988857269) + 0.00177855822200802*std::sin(0.465279847383499*x_41 - 4.34639978408813) + 0.017564692226686*std::sin(0.198400005698204*x_42 + 5.00551986694336) + 0.00301188043608881*std::sin(0.409599870443344*x_42 + 2.00727987289429) + 0.0192742113492242*std::sin(0.189600005745888*x_43 - 7.60376024246216) - 0.00116627831431504*std::sin(0.236559987068176*x_43 - 7.55200004577637) - 0.0123645318505571*std::sin(0.26199996471405*x_43 + 5.06319952011108) - 2.0473598250597e-5*std::sin(0.337439835071564*x_43 + 5.13944005966187) + 0.00461745544448732*std::sin(0.356799840927124*x_43 + 5.16048002243042) - 0.0174174525330752*std::sin(0.294879943132401*x_47 - 7.48031997680664) - 2.47173263017546e-6*std::sin(1.76415991783142*x_49 - 7.41623973846436) + 0.00656487000626396*std::sin(0.285839945077896*x_50 + 5.09280014038086) - 0.0141468508862556*std::sin(0.335119843482971*x_51 + 5.13655996322632) + 1.38627705439118e-5*std::sin(0.477919846773148*x_51 + 8.44704055786133) + 0.00627107427555553*std::sin(0.26639997959137*x_52 + 8.27744007110596) - 0.00273027514177293*std::sin(0.409919857978821*x_52 + 5.20424032211304) + 0.00753380204213402*std::sin(0.166960015892982*x_53 - 7.6497597694397) - 0.000807089514442451*std::sin(0.383759826421738*x_54 - 7.42215967178345) - 4.77446633996789e-5*std::sin(0.460639864206314*x_54 - 1.13079988956451) - 0.00945122537242922*std::sin(0.331519842147827*x_55 - 4.2804799079895) - 0.000592686936571879*std::sin(0.330559849739075*x_57 + 1.92791974544525) + 0.000458926712028514*std::sin(0.350719839334488*x_58 - 7.43415975570679) - 0.00286364808707176*std::sin(0.320719838142395*x_59 - 4.28952026367188) + 1.39489385238724e-5*std::sin(1.39943981170654*x_6 - 5.19679975509644) - 0.00354648220023648*std::sin(0.305039942264557*x_62 - 4.27687978744507) - 0.0210908352628067*std::sin(0.130960047245026*x_64 + 4.91191959381104) - 0.000246166198742496*std::sin(0.186400011181831*x_64 - 4.42831993103027) - 0.00430278978642008*std::sin(0.220399990677834*x_65 + 5.01191997528076) - 0.00549800517374912*std::sin(0.306479841470718*x_67 - 7.49200010299683) + 0.000538826849694473*std::sin(0.14544004201889*x_68 + 4.9206395149231) + 0.0117784603039927*std::sin(0.250639975070953*x_73 - 7.52424001693726) - 0.00330683458836836*std::sin(0.23735998570919*x_75 - 7.56728029251099) + 0.00984295284517897*std::sin(0.269359946250916*x_75 + 5.09375953674316) + 0.010238313493873*std::sin(0.22223998606205*x_76 - 7.56864023208618) + 0.00830175821050951*std::sin(0.242639973759651*x_79 + 1.85583996772766) + 0.016525489305768*std::sin(0.243519976735115*x_79 - 7.54839992523193) + 0.0157699385093279*std::sin(0.182960003614426*x_80 - 7.60896015167236) + 0.00608346049216811*std::sin(0.281279861927032*x_84 - 1.29047977924347) + 0.000397336752683009*std::sin(0.295519828796387*x_85 - 1.26815986633301) - 0.0346683063690381*std::sin(0.173280015587807*x_86 - 7.63872003555298) + 0.00522337541065433*std::sin(0.364959836006165*x_86 + 1.95703983306885) - 0.031994651267312*std::sin(0.184800013899803*x_88 - 7.60400009155273) - 0.0017558892863539*std::sin(0.214479997754097*x_88 + 5.01127958297729) - 0.0117658089041803*std::sin(0.314479917287827*x_9 + 8.34624004364014) + 9.04316469057194e-5*std::sin(0.356559842824936*x_9 - 4.25672006607056) - 0.00567470012793392*std::sin(0.336159855127335*x_92 + 5.19160032272339) - 0.00170886561850133*std::sin(0.361919850111008*x_92 - 7.40287971496582) + 0.0142761067391083*std::sin(0.367439836263657*x_92 + 1.98079979419708) - 0.00244715480305604*std::sin(0.367679834365845*x_92 - 1.3977597951889) + 0.000579623260645464*std::sin(0.345039844512939*x_93 - 1.42127990722656) + 0.00482641385781866*std::sin(0.409999877214432*x_93 + 1.99575984477997) - 0.00251118790962113*std::sin(0.422959864139557*x_93 - 7.60512018203735) + 0.00598930306616442*std::sin(0.36983984708786*x_94 + 5.17535972595215) - 3.73584018392091e-5*std::sin(0.379439830780029*x_94 + 4.98119974136353) - 0.000351746617227258*std::sin(0.328559845685959*x_95 + 1.94279980659485) - 0.0129177632527445*std::sin(0.344959855079651*x_95 - 7.42527961730957) + 0.00180401210252125*std::sin(0.343759834766388*x_96 - 4.42055988311768) + 7.47620256358683e-5*std::sin(0.346959829330444*x_96 + 1.94447982311249) - 0.00469455108832112*std::sin(0.42103984951973*x_96 - 1.15919995307922) + 0.00167206331708577*std::sin(0.449839860200882*x_96 + 8.23176002502441) + 0.000119786109409229*std::sin(0.312559932470322*x_97 + 1.90231990814209) + 0.014340715819924*std::sin(0.371679842472076*x_97 - 7.43088006973267) + 0.00324782630468426*std::sin(0.411359876394272*x_97 + 8.21576023101807) + 0.00677656371906045*std::sin(0.411279857158661*x_98 + 5.21224021911621) - 0.00663874736349833*std::sin(0.33247983455658*x_99 - 7.45544004440308) + 6.72061008322199e-5*std::sin(0.396479845046997*x_99 + 2.0019998550415) - 0.000727654611963262*std::sin(0.39743983745575*x_99 - 7.39287996292114) + 0.00215583334469037*std::sin(0.468479871749878*x_99 + 8.24679946899414) - 0.00101251155138016*std::sin(-0.0174877546070151*x_1 + 0.00213892076482271*x_10 + 0.0367717452151751*x_100 - 0.0384218862573473*x_101 + 0.0114783861616095*x_103 - 0.0144159570847247*x_104 + 0.0700614511238347*x_105 + 0.0963762024559103*x_106 + 0.00720562725499628*x_107 + 0.0125825743253861*x_109 - 0.049313549347551*x_11 + 0.0113492664510387*x_110 + 0.0470613754524998*x_111 - 0.00877574878988607*x_112 + 0.00530181468307393*x_113 - 0.0033777001166505*x_114 + 0.00272396480565752*x_115 - 0.0861082259926709*x_116 + 0.0347779859962165*x_117 - 0.110770241530933*x_118 - 0.0601272852980228*x_119 + 0.103553294291035*x_12 + 0.00918567735040957*x_120 - 0.0143144036142703*x_13 - 0.0763027739034418*x_15 + 0.00751011157859337*x_19 + 0.062191909186721*x_20 + 0.00974950568145769*x_21 + 0.162296342185567*x_22 + 0.0604889876941853*x_23 + 0.0512903614587277*x_24 + 0.0288835157518917*x_26 + 0.0161096059555705*x_27 + 0.0516620383902272*x_28 + 0.0245008236735544*x_29 + 0.0016900115406578*x_30 + 0.0969296554465984*x_31 + 0.0517746543864768*x_32 - 0.00481600211485831*x_33 - 0.000172690025601294*x_34 - 0.00149771071525929*x_36 + 0.000190302401838465*x_37 + 0.0138333761153394*x_38 - 0.0670524231711007*x_39 + 0.0948347739668283*x_4 + 0.0108541099526607*x_40 + 0.0781293041005925*x_43 - 0.0539230210486168*x_44 - 0.0208612506347805*x_45 + 0.00440746843379889*x_46 - 0.000692369426778028*x_47 - 0.0078879111478758*x_48 + 0.00219259252065665*x_5 + 0.0561759934056402*x_50 + 0.00823512192868401*x_52 - 0.00120558860636133*x_53 + 0.00757325506206868*x_55 + 0.00300169025584556*x_56 - 0.00206601116903323*x_57 + 0.0598320529421047*x_58 + 0.00112049751833692*x_59 - 0.00898065817875014*x_6 + 0.13867692181634*x_60 + 0.000410991025322381*x_61 - 0.0375659147261278*x_62 + 0.102500949067188*x_63 + 0.0626583816393014*x_64 - 0.00137547545618257*x_65 - 0.0023992628770729*x_66 + 0.0253671815669113*x_67 - 0.069017584634309*x_68 + 0.0069450926530799*x_7 + 0.00295382495895438*x_70 - 0.00657260375137681*x_72 - 0.00184589238945263*x_74 - 0.00498944661519528*x_75 + 0.00412763473413872*x_76 + 0.0538563948977165*x_77 - 0.00504775265271891*x_78 - 0.00198892575437545*x_79 + 0.0561876340499483*x_8 + 0.00533380556281238*x_80 + 0.00873225799331155*x_81 + 0.0020573153160278*x_82 + 0.0077019724272318*x_83 + 0.00261661919195609*x_84 - 0.000633246178779231*x_85 - 0.0040536757819282*x_87 + 0.115678410319714*x_88 + 0.0121934039320356*x_89 - 0.0659890743099536*x_9 + 0.00203218593718229*x_90 + 0.144585495167072*x_91 + 0.0439187856979962*x_93 - 0.00155894584002176*x_94 + 0.001022220107171*x_96 - 0.00127303381151259*x_97 - 0.00499238198451752*x_98 - 0.0274541735767705*x_99 + 0.000122004783067568*std::pow(-8.6636791229248*x_108 - 6.04663944244385, 2) + 0.00686387484768625*std::pow(-3.51191973686218*x_14 - 6.0479998588562, 2) + 0.00188830232875054*std::pow(-5.82096004486084*x_17 - 9.23791980743408, 2) - 0.000509741690804782*std::pow(-6.85031986236572*x_18 - 7.45431995391846, 2) + 0.00124638491872385*std::pow(-4.93391990661621*x_49 - 8.67199993133545, 2) - 0.000355350117782632*std::pow(-7.40719985961914*x_69 - 9.41207981109619, 2) - 0.663333496275321*std::sin(0.324799835681915*x_102 + 5.12800025939941) - 2.04633501492125*std::sin(0.345759838819504*x_16 + 5.15791988372803) - 0.127755836110195*std::sin(1.47319984436035*x_2 - 3.38879990577698) - 0.0678324234740417*std::sin(1.16631984710693*x_25 - 8.98752021789551) + 1.51802482297546*std::sin(0.300159931182861*x_3 - 1.0843198299408) + 0.566439767909884*std::sin(0.322319835424423*x_35 - 4.42935991287231) - 0.874347806077566*std::sin(0.333999842405319*x_41 + 5.13104009628296) - 0.467802148626539*std::sin(0.403279840946198*x_42 + 8.20879936218262) + 0.742614509511831*std::sin(0.254639983177185*x_51 + 1.83439981937408) - 0.188492762641483*std::sin(0.454879850149155*x_54 - 1.15599977970123) - 1.63969709255457*std::sin(0.167200013995171*x_71 - 4.45599985122681) - 1.17956242033888*std::sin(0.207039996981621*x_73 - 7.59656000137329) + 4.30642733061615*std::sin(0.157360032200813*x_86 - 7.64720010757446) - 2.04091219021586*std::sin(0.392559856176376*x_92 + 1.97831988334656) + 1.06767892952982*std::sin(0.373599827289581*x_95 - 7.42496013641357) + 7.56675723593871) - 0.0369148515164852*std::sin(0.00565257529932951*x_1 - 0.00632007527651537*x_10 - 0.00149995371132423*x_100 + 0.014633906546206*x_101 + 0.000464114679871145*x_104 + 0.000761176251756576*x_105 + 0.00335109885238026*x_106 - 0.000875108257082962*x_107 - 0.000338200296903897*x_108 - 0.00594368816548022*x_109 + 0.00137440981045056*x_11 + 0.00535570486994675*x_110 - 0.000750110060884074*x_111 + 0.00036037361401652*x_113 - 0.000323074224514907*x_114 + 0.00169911637197202*x_116 - 0.00069906219713194*x_118 - 0.0436333332143649*x_119 - 0.0595777193554951*x_12 + 0.000961727269559767*x_120 + 0.0283959588389934*x_14 + 0.00198803286839961*x_15 - 0.0187717429536346*x_16 + 0.0291473969888307*x_17 - 0.0208450824425474*x_18 + 0.0168065714315153*x_19 - 0.0197460223183854*x_2 - 0.0651108738555138*x_20 - 0.00267245559179771*x_23 + 0.0156851610987358*x_25 + 0.00560629821448838*x_26 + 0.037561280049823*x_27 - 0.0444473655204033*x_28 + 0.141059644991261*x_29 - 0.0223434512410034*x_3 + 0.0954827754518324*x_30 - 0.115105596612825*x_31 + 0.0744888374530831*x_32 - 0.00806318389777975*x_33 + 0.0334985056215041*x_34 + 0.00277121830968642*x_35 + 0.00280206404030525*x_37 + 0.00526232993929478*x_38 + 0.00795294385240737*x_4 + 0.0188925495622177*x_40 - 0.0152052574634705*x_42 + 0.0190048685657009*x_44 + 0.0241139129636538*x_45 + 0.00955529472261712*x_46 - 0.00217117209888848*x_47 + 0.023624026937889*x_48 - 0.000517829692029736*x_49 + 0.0107204852909507*x_5 - 0.00584790994197749*x_51 - 0.00132335434965377*x_52 + 0.000345185484420569*x_53 + 0.00729007170044612*x_54 - 0.0230256468938851*x_55 - 0.000742128672490744*x_56 - 0.000150134402653099*x_57 - 0.00184849052318385*x_58 + 0.00130884923800992*x_59 + 0.00711821509710338*x_6 + 0.00193626830673206*x_60 + 0.000594075903531457*x_61 - 4.14224603361589e-5*x_62 - 0.000622439710152743*x_63 - 0.0281540929650945*x_64 + 0.0317937764705125*x_65 + 0.00738336434224315*x_66 - 0.0110343353614715*x_68 - 0.000493744825269432*x_69 - 0.0710038222500969*x_7 - 0.00192061154816453*x_70 - 0.000848578447588673*x_71 - 0.00211508717616447*x_73 - 0.000492596990077977*x_74 + 0.00194426308975457*x_75 - 0.0281398217048806*x_77 + 0.000469011082421948*x_78 + 0.0161364201953476*x_79 + 0.00381283937982271*x_8 - 0.00683037384516152*x_80 + 0.000686867965656265*x_81 + 0.000501797542757729*x_83 + 0.0104953686592726*x_84 - 0.00222159116173449*x_85 - 0.0667669364821637*x_86 + 0.0179775362015273*x_87 - 0.0185107175381811*x_88 - 0.00652350588110197*x_89 - 0.0220215282854385*x_9 + 0.000304130383616324*x_90 + 0.0828000505500561*x_91 - 0.0117084580782517*x_92 - 0.00334694014542962*x_93 + 0.00302024475577465*x_94 + 0.00145472828114978*x_95 + 8.31411311374609e-5*x_96 - 0.00715884220832077*x_97 + 0.00061625922267739*x_98 + 0.00508830688814368*x_99 + 0.00193646309351224*std::pow(-4.98327970504761*x_22 - 7.76327991485596, 2) - 0.00116339714222931*std::pow(-4.69727993011475*x_72 - 5.92263984680176, 2) + 0.000552899085402552*std::pow(-5.28800010681152*x_82 - 7.51375961303711, 2) + 0.0634762668783439*std::exp(0.543359875679016*x_67) - 0.140655312555977*std::sin(0.467919856309891*x_102 + 5.0220799446106) + 0.459577466998899*std::sin(0.366719841957092*x_103 - 7.41215991973877) - 0.769343670964258*std::sin(0.141760036349297*x_112 + 8.10503959655762) + 0.131238725776051*std::sin(0.457519859075546*x_115 - 1.14735984802246) - 0.00725753529119716*std::sin(1.79807984828949*x_117 + 8.98896026611328) + 5.41848528647051*std::sin(0.126080051064491*x_13 + 8.07575988769531) - 0.317650362427555*std::sin(0.243679970502853*x_21 + 8.26344013214111) - 0.84763655339076*std::sin(0.209600001573563*x_24 - 4.37680006027222) + 0.321215574535163*std::sin(0.331679850816727*x_36 + 5.1483998298645) + 0.0463051470198261*std::sin(0.474399864673615*x_39 - 7.7836799621582) + 0.350433359350193*std::sin(0.295359939336777*x_41 - 4.28927993774414) + 0.387403922062513*std::sin(0.373679846525192*x_43 - 1.21103978157043) - 0.530814073409704*std::sin(0.399759829044342*x_50 - 1.19031989574432) - 1.30898819612156*std::sin(0.171120017766953*x_76 - 7.64520025253296) - 14.7263854820233) + 0.189797118148708);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000396282653120136*x_1 + 0.00057345521511607*x_10 + 0.000141057938959759*x_100 - 0.000489339006062046*x_101 - 1.37107092858394e-5*x_102 + 3.74771950611431e-6*x_103 - 2.75606161715209e-5*x_104 + 0.000224164604363772*x_105 + 0.000165275661106934*x_106 + 5.45028692061791e-5*x_107 + 3.05674455472774e-7*x_108 + 0.000221220822540897*x_109 - 0.000192822667202649*x_11 - 0.00012242935261826*x_110 + 0.000138724755195048*x_111 - 0.000416012052763113*x_112 - 1.18334373847771e-5*x_113 + 1.54748737527455e-5*x_114 + 9.26345329740843e-6*x_115 - 0.000371351757426508*x_116 - 2.7772997059764e-5*x_117 - 0.000291392298204294*x_118 + 0.00118411610751185*x_119 + 0.00242684285802356*x_12 + 0.000415043953282583*x_120 - 3.78465529294958e-5*x_13 - 0.000830733698200649*x_14 - 0.000289379094835705*x_15 + 0.000484271452907846*x_16 - 0.00137331180042276*x_17 + 0.000563993650162033*x_18 - 0.000444702073533489*x_19 + 8.72514858948762e-6*x_2 + 0.00235277387939254*x_20 - 0.000179159987301214*x_21 + 0.000428126439370621*x_22 + 0.000235348609369642*x_23 + 0.000127663260156726*x_24 - 0.000261087097195391*x_25 - 4.19916891934479e-5*x_26 - 0.000973670410987475*x_27 + 0.00138602857828956*x_28 - 0.00408365805838273*x_29 + 0.000610186177807181*x_3 - 0.00317695475904172*x_30 + 0.00345988551809527*x_31 - 0.00211828138126398*x_32 + 0.00023600084461012*x_33 - 0.000964043700304785*x_34 - 7.00693675603506e-5*x_35 + 1.58282438275545e-7*x_36 - 7.90317793857205e-5*x_37 - 0.000127524801957232*x_38 + 0.000186474614866037*x_39 - 0.00122265137140722*x_4 - 0.000501876648482892*x_40 + 4.57743372115979e-7*x_41 + 0.000436771421736536*x_42 + 0.000210169984045155*x_43 - 0.000708482606361504*x_44 - 0.000423796379807741*x_45 - 0.00028547570344517*x_46 + 6.73846577998911e-5*x_47 - 0.000717100243274699*x_48 - 2.38625173161933e-6*x_49 - 0.000319751022034058*x_5 + 0.00015952260591604*x_50 + 2.03476970117822e-5*x_51 + 7.55145823289109e-5*x_52 - 1.49626050430632e-5*x_53 - 0.000169210198515534*x_54 + 0.000682509953207423*x_55 + 1.42368718580428e-5*x_56 + 0.000225689640094704*x_57 - 1.36497533057936e-6*x_58 - 8.37679882614776e-5*x_59 - 0.000598229197925112*x_6 + 0.000393329735882812*x_60 + 0.000142836613192807*x_61 - 0.000135703195679749*x_62 - 0.00033458072923309*x_63 + 0.00107077462115742*x_64 - 0.000938094273226441*x_65 + 4.22004672919739e-5*x_66 - 0.000224375558580839*x_67 + 5.65271124072175e-6*x_68 + 1.60081697983045e-6*x_69 + 0.00154531615356281*x_7 - 0.00016317712577159*x_70 + 1.14757203049907e-5*x_71 + 2.29319160764498e-5*x_72 + 7.82741842925161e-5*x_73 + 0.000406580337446631*x_74 - 0.000154711925411736*x_75 + 3.64529296194564e-5*x_76 + 0.000946349782624007*x_77 - 2.52321895106106e-5*x_78 - 0.000468075371033748*x_79 - 6.29570139809741e-6*x_8 + 0.000175274763719579*x_80 + 0.000181047509304287*x_81 + 0.000158120453576145*x_82 + 0.000133106347153549*x_83 - 0.000280689319098182*x_84 + 5.67726336255467e-5*x_85 + 0.001916724990169*x_86 - 0.000666998423371624*x_87 + 0.000892496035872062*x_88 + 0.000188010628227341*x_89 + 0.000557714873690523*x_9 + 1.35777746694648e-5*x_90 - 0.00184635160736696*x_91 + 0.000327416130108725*x_92 + 0.000231795169255556*x_93 - 9.39137488762699e-5*x_94 - 7.94875100866195e-5*x_95 + 8.76972821049799e-6*x_96 - 5.39295830994122e-5*x_97 - 2.59074758747263e-5*x_98 - 0.000305448487032093*x_99 + 3.9677036160644e-8*std::pow(-5.55215978622437*x_100 - 7.38375997543335, 2) + 6.41646343867766e-8*std::pow(-9.58480072021484*x_106 - 7.96384000778198, 2) + 2.73108298628536e-8*std::pow(-7.98799991607666*x_106 - 8.19944000244141, 2) - 2.42061030816554e-7*std::pow(-6.71752023696899*x_106 - 9.56103992462158, 2) + 2.75693017254892e-8*std::pow(-5.86383962631226*x_106 - 8.48952007293701, 2) + 3.43290058633391e-7*std::pow(-8.6636791229248*x_108 - 6.04663944244385, 2) + 3.94826908909718e-8*std::pow(-8.47000026702881*x_116 - 8.86903953552246, 2) + 7.29298579321423e-8*std::pow(-6.09335994720459*x_13 - 9.55160045623779, 2) + 1.76803743113788e-6*std::pow(-4.07000017166138*x_13 - 6.52231979370117, 2) + 1.9313177235105e-5*std::pow(-3.51191973686218*x_14 - 6.0479998588562, 2) - 5.46376020942239e-6*std::pow(-5.32231998443604*x_15 - 8.46951961517334, 2) + 5.31319675225634e-6*std::pow(-5.82096004486084*x_17 - 9.23791980743408, 2) - 9.46131542089949e-7*std::pow(-5.46256017684937*x_17 - 8.0926399230957, 2) - 1.43428192341727e-6*std::pow(-6.85031986236572*x_18 - 7.45431995391846, 2) - 1.11133841435018e-7*std::pow(-3.47519993782043*x_18 - 4.50079965591431, 2) - 7.65373958689636e-7*std::pow(-5.71983957290649*x_22 - 9.39935970306396, 2) - 9.47156889930608e-7*std::pow(-5.3167200088501*x_22 - 8.58440017700195, 2) - 5.55341286491241e-5*std::pow(-4.98327970504761*x_22 - 7.76327991485596, 2) - 4.132508897541e-7*std::pow(-5.90136003494263*x_23 - 8.54720020294189, 2) - 4.68737830902143e-6*std::pow(-4.40399980545044*x_23 - 9.9993200302124, 2) + 7.48831543257628e-7*std::pow(-5.77959966659546*x_24 - 8.97016048431396, 2) - 5.93128044756861e-7*std::pow(-4.79911994934082*x_36 - 3.79999995231628, 2) - 7.60191872130929e-7*std::pow(-3.78287982940674*x_38 - 6.56720018386841, 2) - 2.08289448143845e-7*std::pow(-5.15136003494263*x_40 - 5.74847984313965, 2) + 2.60763487728959e-7*std::pow(-5.46367979049683*x_47 - 7.07823991775513, 2) + 3.50700637360688e-6*std::pow(-4.93391990661621*x_49 - 8.67199993133545, 2) - 1.40689705896074e-5*std::pow(-0.788719892501831*x_49 - 1.1847198009491, 2) - 3.65195839744607e-7*std::pow(-3.3374400138855*x_5 - 5.49232006072998, 2) - 1.20367157585246e-6*std::pow(-9.99993991851807*x_50 - 7.19999980926514, 2) + 1.33939719484857e-6*std::pow(-4.51688003540039*x_53 - 6.4747200012207, 2) - 4.37057667082566e-8*std::pow(-6.19600009918213*x_57 - 9.98884010314941, 2) + 2.29385398183913e-6*std::pow(-3.92007994651794*x_58 - 5.68487977981567, 2) - 6.14275298490102e-8*std::pow(-6.60400009155273*x_64 - 9.96195983886719, 2) - 1.89726106452126e-7*std::pow(-6.08367967605591*x_66 - 9.94783973693848, 2) - 3.33536913202242e-7*std::pow(-3.43055987358093*x_67 - 6.46231985092163, 2) - 9.99863773385209e-7*std::pow(-7.40719985961914*x_69 - 9.41207981109619, 2) - 3.0656189145961e-6*std::pow(-6.92199993133545*x_69 - 9.16287994384766, 2) - 1.93291326903723e-6*std::pow(-6.09127998352051*x_7 - 9.73591995239258, 2) - 1.10361121064499e-6*std::pow(-5.54423999786377*x_7 - 8.90136051177979, 2) - 2.69736650702644e-7*std::pow(-2.79311990737915*x_7 - 4.79031991958618, 2) - 3.52116065158791e-7*std::pow(-8.72799968719482*x_70 - 9.33439922332764, 2) - 1.37383136823555e-7*std::pow(-7.34127998352051*x_70 - 7.9312801361084, 2) - 6.03983972827683e-7*std::pow(-5.99983978271484*x_71 - 9.40424060821533, 2) + 3.33640474652183e-5*std::pow(-4.69727993011475*x_72 - 5.92263984680176, 2) - 3.77534338989938e-8*std::pow(-5.50311994552612*x_73 - 8.97648048400879, 2) - 3.24807619133095e-8*std::pow(-4.92944002151489*x_74 - 6.36568021774292, 2) + 1.23953103990702e-7*std::pow(-7.0*x_77 - 9.99993991851807, 2) - 1.14986186246025e-6*std::pow(-4.67551946640015*x_78 - 6.30359983444214, 2) + 7.3966395419743e-8*std::pow(-4.72591972351074*x_79 - 6.36720037460327, 2) - 1.58561085112332e-5*std::pow(-5.28800010681152*x_82 - 7.51375961303711, 2) - 4.71539266889389e-8*std::pow(-4.89039993286133*x_84 - 8.17303943634033, 2) + 3.44666143736619e-7*std::pow(-5.33200025558472*x_85 - 8.39999961853027, 2) + 7.25220350566791e-8*std::pow(-5.27888011932373*x_86 - 8.12639999389648, 2) - 3.89631506257241e-8*std::pow(-7.70527982711792*x_87 - 8.48975944519043, 2) + 3.00175310493355e-8*std::pow(-8.80000019073486*x_88 - 9.99983978271484, 2) - 7.80870262812102e-6*std::pow(-4.33304023742676*x_90 - 5.97864007949829, 2) + 7.8885274619624e-6*std::exp(0.715519845485687*x_22) - 0.00182038025036381*std::exp(0.543359875679016*x_67) + 7.8803508429973e-6*std::exp(0.656719863414764*x_69) - 7.44721226666778e-5*std::exp(0.00489138519457143*x_1 - 0.00232152721864236*x_10 - 0.00696591269573498*x_100 - 0.0587722051119431*x_101 + 0.00182589276058729*x_102 - 0.000274929914105116*x_103 + 0.0176382913163753*x_104 + 0.00087240473911618*x_106 + 0.0104499915579022*x_107 + 0.00770162864877614*x_108 + 0.00110690641478936*x_109 - 0.00903401295247934*x_11 - 0.00253061265913597*x_110 - 0.0188169374201956*x_111 - 0.00104945632437421*x_112 - 0.00237803316320388*x_113 - 0.00177858971818867*x_114 + 0.000397975796238681*x_115 - 0.000517869418491155*x_116 - 0.00655649983461028*x_117 - 0.00460613833365921*x_119 - 0.00452800091876271*x_12 + 0.000602548434685755*x_120 - 0.00675130986941244*x_14 - 0.00187208592625192*x_17 - 0.000169106532397599*x_18 + 0.000157773464717693*x_19 - 0.100734290307698*x_20 + 0.000452507117114811*x_21 - 0.0109853914977333*x_22 + 0.011075368904772*x_25 - 0.00247017923735602*x_26 - 0.00451084008818464*x_27 - 0.00241774469732599*x_28 - 0.0170263393025468*x_29 - 0.0314593186163303*x_3 - 0.00075145357338192*x_30 + 0.082483399227576*x_31 + 0.0158591807229872*x_32 - 0.0525073410677242*x_33 - 0.000501464900473028*x_37 + 0.0291446049922535*x_39 + 0.00178474434596427*x_4 - 0.00202448990544436*x_40 - 0.000597992032449248*x_41 - 0.000692825184726107*x_42 + 0.00234675972200647*x_44 + 0.00159203434483878*x_45 + 0.000134171371285392*x_46 - 0.00169702841438524*x_47 + 0.0023321229500342*x_48 - 0.000939322050086631*x_50 - 0.000932443089965941*x_51 + 0.0209537486697105*x_52 + 0.013888036023121*x_53 - 0.000358592539038324*x_55 - 0.000641524371211966*x_56 + 0.000502594116426361*x_59 + 0.00345305183487276*x_60 - 0.000264155148872961*x_61 - 0.0706527761939957*x_62 - 0.0542609558541302*x_63 + 0.0334942876530779*x_64 + 0.0210207032545654*x_65 - 0.00233588318593033*x_66 - 0.00262600653577078*x_67 - 0.00337424744087736*x_68 + 0.0161910080453772*x_7 - 0.000311636515460102*x_70 + 0.000502430758915035*x_71 - 3.54040156799474e-5*x_73 - 0.012902264306417*x_74 - 4.15430789429489e-5*x_75 + 0.00253485855663097*x_76 + 0.000849468982581056*x_77 - 0.0218164432516948*x_78 - 0.00170501637016441*x_79 - 0.00382386669928566*x_8 + 0.000889772658419606*x_80 - 0.00197594131643599*x_81 - 0.00187866511647461*x_82 - 0.00510692020325859*x_83 + 0.00106260739160469*x_84 - 0.0384681956368159*x_86 + 0.0241591377473624*x_87 - 0.000343247179339909*x_89 + 0.00338829859959819*x_9 - 0.000771935156648223*x_90 + 0.092161605672436*x_91 + 0.000345870621399969*x_94 - 0.01336275707026*x_96 - 0.00602877067905744*x_97 + 3.61895181223313e-5*x_98 - 0.000829050230957473*std::pow(-5.6691198348999*x_15 - 7.42512035369873, 2) - 0.0257149602005358*std::pow(-1.34583985805511*x_2 - 2.49487972259521, 2) - 0.000175470006233337*std::pow(-5.04120016098022*x_23 - 8.87744045257568, 2) - 0.000283161724983785*std::pow(-5.51895999908447*x_38 - 6.90023994445801, 2) - 0.000268366472363876*std::pow(-7.80000019073486*x_49 - 9.99882030487061, 2) + 0.000263490273076303*std::pow(-5.88295984268188*x_5 - 9.54328060150146, 2) - 0.000272065484720016*std::pow(-6.40399980545044*x_69 - 9.99507999420166, 2) - 0.000571003635311235*std::pow(-5.7838397026062*x_72 - 7.57272005081177, 2) + 0.280834590316928*std::sin(0.310239911079407*x_105 + 1.91767990589142) - 0.552835944521149*std::sin(0.279359966516495*x_118 - 7.5207200050354) - 0.6279683486122*std::sin(0.277359962463379*x_13 - 1.07599985599518) + 0.557793146233934*std::sin(0.292079925537109*x_16 + 8.31447982788086) - 1.32886333421669*std::sin(0.186960011720657*x_24 + 4.96975994110107) + 0.65717241879733*std::sin(0.350879848003387*x_34 + 2.00583982467651) - 0.347171259599662*std::sin(0.291759938001633*x_35 + 8.24959945678711) - 0.459908810605484*std::sin(0.353839844465256*x_36 + 5.14800024032593) - 0.56555688908*std::sin(0.236559987068176*x_43 - 7.55200004577637) - 0.391377452015163*std::sin(0.383759826421738*x_54 - 7.42215967178345) - 0.287408396376478*std::sin(0.330559849739075*x_57 + 1.92791974544525) + 0.222544790882949*std::sin(0.350719839334488*x_58 - 7.43415975570679) + 0.00676418156858438*std::sin(1.39943981170654*x_6 - 5.19679975509644) + 0.192678312720346*std::sin(0.295519828796387*x_85 - 1.26815986633301) - 0.851473674997067*std::sin(0.214479997754097*x_88 + 5.01127958297729) - 0.828670747962065*std::sin(0.361919850111008*x_92 - 7.40287971496582) + 0.281073500300465*std::sin(0.345039844512939*x_93 - 1.42127990722656) - 0.170570540617739*std::sin(0.328559845685959*x_95 + 1.94279980659485) - 0.352857524328016*std::sin(0.39743983745575*x_99 - 7.39287996292114)) + 8.57371136514208e-5*std::sin(0.217519998550415*x_1 + 1.81207990646362) + 0.000232520269076131*std::sin(0.322799921035767*x_1 + 1.95039975643158) - 8.23418083780593e-5*std::sin(0.269199937582016*x_10 + 5.06816005706787) - 0.000490184320552942*std::sin(0.367199838161469*x_101 + 8.17160034179688) + 0.000224533282567795*std::sin(0.183680012822151*x_102 + 1.7850399017334) - 0.00186644973339886*std::sin(0.324799835681915*x_102 + 5.12800025939941) - 0.000396373747083891*std::sin(0.394879847764969*x_102 + 2.00839972496033) + 0.00403373048979672*std::sin(0.467919856309891*x_102 + 5.0220799446106) + 0.000144691545514779*std::sin(0.178960010409355*x_103 - 7.6241602897644) - 0.000870511397737972*std::sin(0.323359847068787*x_103 + 5.13160037994385) - 0.0131798195700517*std::sin(0.366719841957092*x_103 - 7.41215991973877) - 8.59722915129583e-5*std::sin(0.418079853057861*x_103 - 1.19207990169525) - 0.000149793861031705*std::sin(0.451519846916199*x_104 - 1.14063990116119) + 3.87766694693064e-5*std::sin(0.308159917593002*x_107 + 1.90919995307922) - 0.00118671100412607*std::sin(0.410559862852097*x_107 + 5.20783996582031) - 4.10006622846786e-6*std::sin(1.69463980197906*x_107 - 6.01591968536377) - 0.000516064582526134*std::sin(0.444559872150421*x_108 - 4.1657600402832) + 0.000185744591953994*std::sin(0.330799847841263*x_110 - 4.43279981613159) + 0.000858873528836935*std::sin(0.394479840993881*x_110 + 5.18344020843506) + 0.00469188804427925*std::sin(0.303359925746918*x_111 - 7.49376010894775) + 0.022063333167495*std::sin(0.141760036349297*x_112 + 8.10503959655762) - 3.38215685647874e-5*std::sin(0.362479835748672*x_112 - 7.42967987060547) + 0.000474512775289068*std::sin(0.398479819297791*x_112 - 4.41079998016357) - 0.0040202197442439*std::sin(0.271599948406219*x_113 + 5.0623197555542) - 0.000258036168026141*std::sin(0.395199835300446*x_114 - 1.21023988723755) + 0.000407751568107969*std::sin(0.20720000565052*x_115 - 1.37271988391876) - 0.00291778567359688*std::sin(0.269599944353104*x_115 + 1.86295986175537) - 0.0037636804467961*std::sin(0.457519859075546*x_115 - 1.14735984802246) - 0.000532408309882659*std::sin(0.189600005745888*x_117 + 8.18416023254395) + 4.25888311207099e-5*std::sin(0.350239843130112*x_117 - 7.43336009979248) + 0.000208132496760313*std::sin(1.79807984828949*x_117 + 8.98896026611328) + 0.000318075140528528*std::sin(0.238799974322319*x_118 - 1.3614399433136) - 0.00110842570398793*std::sin(0.279519945383072*x_118 + 1.8647198677063) - 0.000169703530760605*std::sin(0.398399829864502*x_119 + 8.18903923034668) - 2.75284890218329e-5*std::sin(0.416479855775833*x_12 - 4.17271995544434) - 6.85799935954598e-5*std::sin(0.328719854354858*x_120 - 7.45576000213623) - 0.155391992747182*std::sin(0.126080051064491*x_13 + 8.07575988769531) - 0.000568124259314596*std::sin(0.165200024843216*x_13 + 4.96023941040039) + 0.013687914733503*std::sin(0.182000011205673*x_14 + 8.18039894104004) + 0.00109822321207992*std::sin(0.205119997262955*x_14 - 4.38215970993042) - 0.0031990439727304*std::sin(0.287039935588837*x_15 + 5.13007974624634) + 5.67516567648452e-6*std::sin(1.16935980319977*x_15 + 5.98727989196777) - 0.00575786005755884*std::sin(0.345759838819504*x_16 + 5.15791988372803) - 4.7745337501123e-5*std::sin(0.358719855546951*x_16 + 8.34712028503418) + 1.84339069605391e-5*std::sin(1.44519984722137*x_16 - 3.38727998733521) - 0.000180253836395557*std::sin(0.412719875574112*x_18 - 7.16936016082764) - 0.000359472041721004*std::sin(1.47319984436035*x_2 - 3.38879990577698) + 0.00910961647118076*std::sin(0.243679970502853*x_21 + 8.26344013214111) + 0.000285072998140517*std::sin(0.363679856061935*x_21 + 5.15895986557007) + 0.00212006314997769*std::sin(0.179360017180443*x_23 - 7.61696004867554) + 0.0243086261552886*std::sin(0.209600001573563*x_24 - 4.37680006027222) + 2.84104702816859e-5*std::sin(0.271279960870743*x_24 + 1.85807991027832) - 0.000498916335334097*std::sin(0.333439826965332*x_24 + 5.13248014450073) - 0.000195164028930706*std::sin(0.547119855880737*x_24 + 8.55247974395752) - 0.000190862981320598*std::sin(1.16631984710693*x_25 - 8.98752021789551) + 0.00325390001207224*std::sin(0.338239848613739*x_26 - 7.44767951965332) - 0.000591263787230683*std::sin(0.339359849691391*x_26 + 8.35319995880127) - 3.19590009075527e-5*std::sin(0.353679865598679*x_26 + 1.9618399143219) - 9.97888542756662e-5*std::sin(0.32687982916832*x_27 + 8.30775928497314) + 3.54801472451377e-5*std::sin(0.378799855709076*x_27 - 7.41504001617432) + 0.000106682050852761*std::sin(0.19055999815464*x_28 - 4.42063999176025) + 7.46596795865274e-5*std::sin(0.457199841737747*x_28 - 7.13647985458374) + 0.00427133115098927*std::sin(0.300159931182861*x_3 - 1.0843198299408) - 7.9600789343501e-5*std::sin(0.359999865293503*x_3 - 1.0461597442627) + 0.000473276696329165*std::sin(0.312719851732254*x_30 - 4.26567983627319) - 0.00695756435851241*std::sin(0.283119946718216*x_33 - 1.17807984352112) + 0.000816137274865654*std::sin(0.285759925842285*x_33 + 8.2041597366333) + 8.9956354301207e-5*std::sin(0.303599923849106*x_33 - 1.19399988651276) + 0.000365542493589382*std::sin(0.318159908056259*x_34 + 8.25111961364746) + 0.00156599164943726*std::sin(0.328159838914871*x_34 - 7.41232013702393) + 3.43688657114354e-5*std::sin(0.355279833078384*x_34 + 1.97823989391327) - 0.000198712741526013*std::sin(0.384159833192825*x_34 - 1.19863986968994) + 0.000163252698577496*std::sin(0.321279853582382*x_35 + 1.77135992050171) + 0.00159381571975238*std::sin(0.322319835424423*x_35 - 4.42935991287231) - 0.00257432341762891*std::sin(0.346479833126068*x_35 + 8.19127941131592) + 0.00340918131540188*std::sin(0.317039847373962*x_36 - 4.27767992019653) - 7.17144165818692e-5*std::sin(0.322799831628799*x_36 - 7.46775960922241) - 0.00921186006596377*std::sin(0.331679850816727*x_36 + 5.1483998298645) - 6.12923737450792e-5*std::sin(0.352559864521027*x_36 + 5.15791988372803) + 8.1667442994832e-5*std::sin(0.26335996389389*x_37 + 1.8458399772644) + 0.000677815411475251*std::sin(0.267279952764511*x_37 + 5.08191967010498) + 9.74893517077125e-5*std::sin(0.292879939079285*x_37 + 5.11407995223999) + 8.88978877405714e-5*std::sin(0.317519843578339*x_37 + 5.12696027755737) + 0.000171217604817395*std::sin(0.225279986858368*x_38 + 5.02023983001709) - 0.00132794474644573*std::sin(0.474399864673615*x_39 - 7.7836799621582) + 0.00405923176926311*std::sin(0.256319969892502*x_41 - 4.32304000854492) - 0.0100497713208679*std::sin(0.295359939336777*x_41 - 4.28927993774414) - 0.00246018969148214*std::sin(0.333999842405319*x_41 + 5.13104009628296) - 1.25975163245984e-5*std::sin(0.360479861497879*x_41 + 4.78455972671509) + 0.000196259003929502*std::sin(0.363999843597412*x_41 - 1.21383988857269) - 0.00013605280960956*std::sin(0.465279847383499*x_41 - 4.34639978408813) - 0.00134363086785531*std::sin(0.198400005698204*x_42 + 5.00551986694336) - 0.00131627484589595*std::sin(0.403279840946198*x_42 + 8.20879936218262) - 0.00201337008150173*std::sin(0.409599870443344*x_42 + 2.00727987289429) - 0.000383598161779918*std::sin(0.189600005745888*x_43 - 7.60376024246216) - 5.8129882106848e-5*std::sin(0.26199996471405*x_43 + 5.06319952011108) - 1.16711578069859e-5*std::sin(0.337439835071564*x_43 + 5.13944005966187) - 0.00308665859813166*std::sin(0.356799840927124*x_43 + 5.16048002243042) - 0.0111100177013825*std::sin(0.373679846525192*x_43 - 1.21103978157043) + 0.00133236760205162*std::sin(0.294879943132401*x_47 - 7.48031997680664) - 1.40903329401869e-6*std::sin(1.76415991783142*x_49 - 7.41623973846436) + 0.000414018858630062*std::sin(0.285839945077896*x_50 + 5.09280014038086) + 0.0152227517995368*std::sin(0.399759829044342*x_50 - 1.19031989574432) + 0.0020895260997361*std::sin(0.254639983177185*x_51 + 1.83439981937408) + 0.00108217925417675*std::sin(0.335119843482971*x_51 + 5.13655996322632) + 7.90259634284425e-6*std::sin(0.477919846773148*x_51 + 8.44704055786133) - 0.00419206326187192*std::sin(0.26639997959137*x_52 + 8.27744007110596) + 0.000208855464751647*std::sin(0.409919857978821*x_52 + 5.20424032211304) + 0.000475125344394175*std::sin(0.166960015892982*x_53 - 7.6497597694397) - 0.000530370120844594*std::sin(0.454879850149155*x_54 - 1.15599977970123) - 2.7217272418776e-5*std::sin(0.460639864206314*x_54 - 1.13079988956451) + 0.00631791825809981*std::sin(0.331519842147827*x_55 - 4.2804799079895) - 0.00018059829233425*std::sin(0.320719838142395*x_59 - 4.28952026367188) - 0.000223661780247397*std::sin(0.305039942264557*x_62 - 4.27687978744507) - 0.00133011065485381*std::sin(0.130960047245026*x_64 + 4.91191959381104) - 0.000140329243404282*std::sin(0.186400011181831*x_64 - 4.42831993103027) - 0.000271358932408249*std::sin(0.220399990677834*x_65 + 5.01191997528076) + 0.000420576083414317*std::sin(0.306479841470718*x_67 - 7.49200010299683) + 0.000307163065155968*std::sin(0.14544004201889*x_68 + 4.9206395149231) - 0.00461368560224662*std::sin(0.167200013995171*x_71 - 4.45599985122681) - 0.00331898506155798*std::sin(0.207039996981621*x_73 - 7.59656000137329) - 0.00787361918423627*std::sin(0.250639975070953*x_73 - 7.52424001693726) - 0.000208548208974182*std::sin(0.23735998570919*x_75 - 7.56728029251099) + 4.62750790235326e-5*std::sin(0.269359946250916*x_75 + 5.09375953674316) + 0.0375393257569152*std::sin(0.171120017766953*x_76 - 7.64520025253296) - 0.00684406785428969*std::sin(0.22223998606205*x_76 - 7.56864023208618) + 0.000523557123851401*std::sin(0.242639973759651*x_79 + 1.85583996772766) - 0.000328892695288486*std::sin(0.243519976735115*x_79 - 7.54839992523193) + 0.000994543979708419*std::sin(0.182960003614426*x_80 - 7.60896015167236) - 0.000465361145823933*std::sin(0.281279861927032*x_84 - 1.29047977924347) + 0.0121171781438185*std::sin(0.157360032200813*x_86 - 7.64720010757446) + 0.00265199104957463*std::sin(0.173280015587807*x_86 - 7.63872003555298) - 0.00349170161280372*std::sin(0.364959836006165*x_86 + 1.95703983306885) + 0.00244746679840557*std::sin(0.184800013899803*x_88 - 7.60400009155273) + 0.00090003877238026*std::sin(0.314479917287827*x_9 + 8.34624004364014) + 5.15513691762267e-5*std::sin(0.356559842824936*x_9 - 4.25672006607056) + 0.00379340139873312*std::sin(0.336159855127335*x_92 + 5.19160032272339) + 6.71168477480002e-5*std::sin(0.367439836263657*x_92 + 1.98079979419708) - 0.000154331805121138*std::sin(0.367679834365845*x_92 - 1.3977597951889) - 0.0057426016245346*std::sin(0.392559856176376*x_92 + 1.97831988334656) - 0.00322634230291569*std::sin(0.409999877214432*x_93 + 1.99575984477997) - 0.000158370104991405*std::sin(0.422959864139557*x_93 - 7.60512018203735) - 0.000458158467724959*std::sin(0.36983984708786*x_94 + 5.17535972595215) - 2.12964911172606e-5*std::sin(0.379439830780029*x_94 + 4.98119974136353) - 6.07308116507762e-5*std::sin(0.344959855079651*x_95 - 7.42527961730957) + 0.0030041737143776*std::sin(0.373599827289581*x_95 - 7.42496013641357) + 0.000113771488381035*std::sin(0.343759834766388*x_96 - 4.42055988311768) + 4.26187614158492e-5*std::sin(0.346959829330444*x_96 + 1.94447982311249) + 9.34316395744191e-5*std::sin(0.42103984951973*x_96 - 1.15919995307922) - 0.00111773436178254*std::sin(0.449839860200882*x_96 + 8.23176002502441) + 6.82851430846662e-5*std::sin(0.312559932470322*x_97 + 1.90231990814209) + 6.74205970768256e-5*std::sin(0.371679842472076*x_97 - 7.43088006973267) + 0.000204826803639835*std::sin(0.411359876394272*x_97 + 8.21576023101807) - 0.00452997087263664*std::sin(0.411279857158661*x_98 + 5.21224021911621) + 0.000507838438975733*std::sin(0.33247983455658*x_99 - 7.45544004440308) + 3.83114388982489e-5*std::sin(0.396479845046997*x_99 + 2.0019998550415) + 0.000135959380751438*std::sin(0.468479871749878*x_99 + 8.24679946899414) + 0.372708380222321*std::sin(0.00655987324797149*x_1 - 0.0315625061108411*x_10 + 0.011800651699132*x_100 + 0.000363665515920317*x_101 + 0.000246717848862061*x_103 - 0.00954662020416336*x_104 + 0.00217015961095301*x_105 - 0.000833395355612837*x_106 + 0.000976906000708403*x_107 + 0.00749887438330963*x_108 - 0.000657238645348746*x_109 + 0.000922277413126287*x_11 + 0.00960855062051458*x_110 - 0.0041789588356108*x_111 + 0.000654671143069932*x_113 + 0.000557517683098777*x_114 + 0.000762622719940169*x_115 + 0.0158799231892109*x_116 + 0.000508909754929628*x_117 - 0.00620000043620443*x_118 - 0.00296993716539843*x_13 + 0.00306730405284786*x_15 + 0.015725730565111*x_17 + 0.000957821834995148*x_19 - 0.00527806490604271*x_2 + 0.0285154825373859*x_20 + 0.00241824564063489*x_21 - 0.00633591359434486*x_24 + 0.000388465391299015*x_25 + 0.00601071178475436*x_26 + 0.00137490968304875*x_27 + 0.00165902259668495*x_29 + 0.00933485918434634*x_3 - 0.000569937678604793*x_31 + 0.0236917654184397*x_32 - 0.0101554828265836*x_35 - 0.000535275040286538*x_37 - 0.000621488671441015*x_38 - 0.000904074590903171*x_39 + 0.00388281172425398*x_4 + 7.95999583941991e-5*x_40 - 1.44921130670955e-5*x_41 + 0.00791045564392066*x_42 + 0.013457455629554*x_43 + 0.00133761930218855*x_44 + 0.000541860595385714*x_45 + 0.000379066943622794*x_46 - 0.00542476625531837*x_48 + 0.00217517426743262*x_49 + 0.00506223758931143*x_5 + 0.0100092377686001*x_50 + 0.00755456591501795*x_51 - 1.98905069241035e-5*x_53 - 0.0111229018011305*x_56 - 0.0032155562184327*x_57 + 0.00253108600424763*x_58 + 0.000109204903758886*x_59 + 0.00530066263522933*x_6 + 0.000755925076559764*x_60 + 0.000237687553517157*x_61 + 0.0184148124377543*x_62 - 0.00144650857643045*x_63 + 0.000145045022955665*x_64 + 5.18634215743566e-5*x_65 + 0.00622410923561118*x_66 + 0.000223236071116*x_67 - 0.000172169915911947*x_69 + 0.000345933371623655*x_71 - 0.00128481412004064*x_72 - 0.00228517957232219*x_73 + 0.000192486134186509*x_74 - 0.000260578309435979*x_75 - 0.00159852654968342*x_76 - 0.000346291177781606*x_77 - 0.00548448894419179*x_78 + 0.000318432857603042*x_79 + 0.00717964447834554*x_8 - 8.97395081860263e-6*x_81 + 1.82077118857767e-6*x_82 - 1.0563875238182e-5*x_83 - 0.00041799163550546*x_84 + 0.00786964475908871*x_87 - 0.00209698288968628*x_88 - 0.00145030277259863*x_89 + 0.0131497679409895*x_9 - 0.00181937822965523*x_90 + 0.0392536033832946*x_91 + 0.010736796209117*x_92 + 0.000205448831245274*x_96 - 0.007185852254017*x_97 + 0.00490273136884621*x_99 - 0.000218831878211777*std::pow(-5.10199975967407*x_14 - 7.75728034973145, 2) - 0.000272252800043057*std::pow(-5.03071975708008*x_18 - 7.24015998840332, 2) - 7.43469546862271e-5*std::pow(-7.36400032043457*x_54 - 9.79903984069824, 2) - 8.646095624864e-6*std::pow(-8.16296005249023*x_55 - 7.95711994171143, 2) - 0.00029246373188949*std::pow(-3.24863982200623*x_68 - 5.47495985031128, 2) - 0.000180290584996291*std::pow(-5.7707200050354*x_7 - 9.56975936889648, 2) - 8.54431679002104e-5*std::pow(-4.89879989624023*x_70 - 7.14247989654541, 2) - 5.25881117308157e-5*std::pow(-5.09136009216309*x_85 - 8.60568046569824, 2) - 0.000126714440440141*std::pow(-6.66607999801636*x_86 - 8.43383884429932, 2) - 0.013629772939492*std::exp(0.649039804935455*x_22) - 0.0439065747369165*std::sin(0.315999835729599*x_102 - 4.44975996017456) + 0.0806232785987042*std::sin(0.270639955997467*x_112 - 7.53815984725952) - 0.117020813324135*std::sin(0.373199850320816*x_119 + 1.97575974464417) + 0.0354698568982683*std::sin(0.3572798371315*x_12 - 1.03671979904175) + 0.0581391972657386*std::sin(0.330799847841263*x_120 + 5.12911987304688) + 0.0465162209427028*std::sin(0.402959853410721*x_16 + 1.97447979450226) - 0.120619081436159*std::sin(0.390239834785461*x_23 + 1.97439980506897) + 0.216800800562115*std::sin(0.136960044503212*x_28 + 8.09280014038086) - 0.0583222798111294*std::sin(0.281439960002899*x_30 - 7.52135992050171) + 0.129012157449827*std::sin(0.292399942874908*x_33 + 8.20679950714111) - 0.114993679518042*std::sin(0.341119825839996*x_34 - 1.19039988517761) - 0.0817410166094135*std::sin(0.285039931535721*x_36 - 7.51999998092651) - 0.101608180880298*std::sin(0.32711985707283*x_47 + 8.3133602142334) - 0.0386439241829537*std::sin(0.597679853439331*x_52 + 2.00543975830078) - 0.637474542663234*std::sin(0.134880036115646*x_80 + 4.91583967208862) + 0.131628597734446*std::sin(0.361599832773209*x_93 - 7.40575981140137) + 0.0257238962296547*std::sin(0.398239850997925*x_94 + 5.19799995422363) + 0.046085142600476*std::sin(0.386799842119217*x_95 + 8.18487930297852) + 0.0553733110856696*std::sin(0.463359862565994*x_98 + 2.01143980026245) + 1.4309327349112) - 0.123849223901958);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000545731426954359*x_1 - 0.000598887012733822*x_10 + 0.000682288832330235*x_100 + 0.000409543141998201*x_101 - 5.50932686893607e-5*x_102 + 6.86389635432035e-5*x_103 - 0.000291641859517078*x_104 + 4.64164130224965e-6*x_105 - 3.03580475184224e-5*x_106 + 0.000148008060240053*x_107 + 0.000407478726136881*x_108 + 0.000235585685719996*x_109 - 0.000101715987714475*x_11 + 0.000519355458042123*x_110 - 0.00029952136533167*x_111 - 3.67453392775049e-5*x_112 - 0.000238451201112381*x_113 + 5.54892798693797e-6*x_114 + 4.83551459091779e-5*x_115 + 0.000287719397482997*x_116 + 2.53649169588231e-5*x_117 - 0.000377223119673494*x_118 + 5.77799892546857e-6*x_119 + 0.00116954611299511*x_12 - 0.000144297882300008*x_120 - 0.00016359415502189*x_13 - 8.20721020128977e-5*x_14 + 6.7582733369914e-6*x_15 + 8.00194376462844e-7*x_16 - 2.02688350920287e-5*x_17 - 1.22903366999686e-5*x_18 - 1.39447541809435e-5*x_19 + 0.000375674318248784*x_2 + 0.00251434866894546*x_20 - 0.000266728375895492*x_21 - 8.19317361301987e-5*x_22 - 6.20728357329674e-5*x_23 - 0.000334821281468646*x_24 + 0.000313895249647607*x_25 + 0.000630072391522676*x_26 + 0.000124933419847146*x_27 - 7.15336166107388e-5*x_28 + 0.0014941449828656*x_29 + 0.000706520080924983*x_3 - 0.000234416733544694*x_30 - 0.000123336744520916*x_31 + 0.00130086977707052*x_32 + 0.000225284046346346*x_33 + 1.02766909118169e-5*x_34 - 0.000525295528943872*x_35 + 1.69176553964005e-5*x_36 - 3.01552619667135e-5*x_37 - 0.000130515618680973*x_38 - 9.98841281568013e-6*x_39 - 0.000592670801937782*x_4 + 0.000226192289369051*x_40 - 1.19911853574265e-5*x_41 + 0.000467501486488765*x_42 + 0.000621086383092432*x_43 - 0.000180336215122216*x_44 + 4.11945224580533e-5*x_45 + 5.71758326915291e-5*x_46 + 0.000107210672930266*x_47 - 0.000686347387488392*x_48 - 3.84724829354058e-5*x_49 + 0.000172754383307025*x_5 + 0.000575068322556783*x_50 + 0.000504887723024123*x_51 + 0.000202148591201729*x_52 - 8.49424967358772e-6*x_53 + 0.0002457213198246*x_54 + 2.13429171095923e-5*x_55 - 0.00060225314640543*x_56 + 0.000195982431789112*x_57 + 0.000138769569679191*x_58 - 0.000346165026549894*x_59 - 0.00014081086893439*x_6 + 0.000458402627169264*x_60 + 0.000148307829797034*x_61 + 0.000473730584813305*x_62 + 0.000326428117325411*x_63 + 6.83130680829518e-5*x_64 + 3.98086623420349e-5*x_65 + 0.000425325739770414*x_66 + 5.72351487692028e-6*x_67 + 1.74101645013469e-5*x_68 - 0.000104230805169821*x_69 + 1.04556848458804e-5*x_7 + 0.000127693272232508*x_70 - 0.000101911437261899*x_71 + 0.000198921197675009*x_72 + 1.39906720292322e-5*x_73 - 8.32637614524699e-5*x_74 + 0.000551617533687093*x_75 - 0.000400526597328036*x_76 - 0.000235286979319605*x_77 - 0.000223034021770314*x_78 - 0.00011631200468516*x_79 + 2.83475896284816e-5*x_8 - 5.23133417375459e-5*x_80 + 9.00374721952137e-5*x_81 + 0.000174110279166438*x_82 - 0.000173033961158601*x_83 - 1.24447290015388e-5*x_84 - 6.77753007711425e-6*x_85 - 9.53896026741679e-5*x_86 + 0.000505600210501372*x_87 + 3.19168738432714e-5*x_88 - 0.000154298587306069*x_89 + 0.000762741157010059*x_9 + 4.97575054073875e-5*x_90 + 0.00413742610168956*x_91 + 0.000836796158468284*x_92 + 7.50841363762786e-5*x_93 + 2.77554501928767e-6*x_94 + 8.05497938471805e-5*x_95 + 5.27957001814531e-5*x_96 - 0.00043962375674917*x_97 + 6.92345419918235e-5*x_98 + 0.000263459034895987*x_99 - 1.51434329606401e-6*std::pow(-5.55215978622437*x_100 - 7.38375997543335, 2) + 3.37342413150809e-8*std::pow(-9.58480072021484*x_106 - 7.96384000778198, 2) - 1.27553299766782e-7*std::pow(-7.98799991607666*x_106 - 8.19944000244141, 2) - 1.82234297632945e-6*std::pow(-6.71752023696899*x_106 - 9.56103992462158, 2) - 1.05223049111143e-6*std::pow(-5.86383962631226*x_106 - 8.48952007293701, 2) + 3.42019350924667e-8*std::pow(-8.6636791229248*x_108 - 6.04663944244385, 2) - 1.84401116044635e-7*std::pow(-8.47000026702881*x_116 - 8.86903953552246, 2) - 2.78349524383042e-6*std::pow(-6.09335994720459*x_13 - 9.55160045623779, 2) + 1.3310571237563e-5*std::pow(-4.07000017166138*x_13 - 6.52231979370117, 2) - 1.20989938149824e-5*std::pow(-5.10199975967407*x_14 - 7.75728034973145, 2) + 1.92416884093281e-6*std::pow(-3.51191973686218*x_14 - 6.0479998588562, 2) - 1.18951835619456e-6*std::pow(-5.6691198348999*x_15 - 7.42512035369873, 2) + 5.29352965179344e-7*std::pow(-5.82096004486084*x_17 - 9.23791980743408, 2) - 1.43209842646229e-5*std::pow(-5.46256017684937*x_17 - 8.0926399230957, 2) - 1.42897284716897e-7*std::pow(-6.85031986236572*x_18 - 7.45431995391846, 2) - 1.50525826984165e-5*std::pow(-5.03071975708008*x_18 - 7.24015998840332, 2) + 4.24161691567813e-6*std::pow(-3.47519993782043*x_18 - 4.50079965591431, 2) - 3.68957344744034e-5*std::pow(-1.34583985805511*x_2 - 2.49487972259521, 2) - 4.02391598821857e-7*std::pow(-5.71983957290649*x_22 - 9.39935970306396, 2) - 7.13061784470038e-6*std::pow(-5.3167200088501*x_22 - 8.58440017700195, 2) - 2.17264625161017e-7*std::pow(-5.90136003494263*x_23 - 8.54720020294189, 2) - 2.51763747939701e-7*std::pow(-5.04120016098022*x_23 - 8.87744045257568, 2) + 5.63753652831324e-6*std::pow(-5.77959966659546*x_24 - 8.97016048431396, 2) - 4.46533141985102e-6*std::pow(-4.79911994934082*x_36 - 3.79999995231628, 2) - 4.06279447327245e-7*std::pow(-5.51895999908447*x_38 - 6.90023994445801, 2) - 1.0950715412348e-7*std::pow(-5.15136003494263*x_40 - 5.74847984313965, 2) + 1.37095122652545e-7*std::pow(-5.46367979049683*x_47 - 7.07823991775513, 2) - 3.85051270892638e-7*std::pow(-7.80000019073486*x_49 - 9.99882030487061, 2) + 3.49402498972637e-7*std::pow(-4.93391990661621*x_49 - 8.67199993133545, 2) - 0.000212952953653938*std::pow(-0.788719892501831*x_49 - 1.1847198009491, 2) + 3.78054917300971e-7*std::pow(-5.88295984268188*x_5 - 9.54328060150146, 2) + 1.39383362564835e-5*std::pow(-3.3374400138855*x_5 - 5.49232006072998, 2) + 1.00835771140604e-5*std::pow(-4.51688003540039*x_53 - 6.4747200012207, 2) - 4.11056813231258e-6*std::pow(-7.36400032043457*x_54 - 9.79903984069824, 2) - 4.78033905954686e-7*std::pow(-8.16296005249023*x_55 - 7.95711994171143, 2) + 1.66810682496582e-6*std::pow(-6.19600009918213*x_57 - 9.98884010314941, 2) + 1.72691518268293e-5*std::pow(-3.92007994651794*x_58 - 5.68487977981567, 2) + 2.86892934711619e-7*std::pow(-6.60400009155273*x_64 - 9.96195983886719, 2) - 2.87176197411961e-6*std::pow(-6.08367967605591*x_66 - 9.94783973693848, 2) - 5.04853360568557e-6*std::pow(-3.43055987358093*x_67 - 6.46231985092163, 2) - 1.61700247338423e-5*std::pow(-3.24863982200623*x_68 - 5.47495985031128, 2) - 9.96162720667365e-8*std::pow(-7.40719985961914*x_69 - 9.41207981109619, 2) - 3.90358600814417e-7*std::pow(-6.40399980545044*x_69 - 9.99507999420166, 2) - 1.45518297918572e-5*std::pow(-6.09127998352051*x_7 - 9.73591995239258, 2) - 9.96808458893119e-6*std::pow(-5.7707200050354*x_7 - 9.56975936889648, 2) - 1.67046526606613e-5*std::pow(-5.54423999786377*x_7 - 8.90136051177979, 2) + 1.2597859544341e-6*std::pow(-2.79311990737915*x_7 - 4.79031991958618, 2) - 2.65088616713848e-6*std::pow(-8.72799968719482*x_70 - 9.33439922332764, 2) - 2.0794801284488e-6*std::pow(-7.34127998352051*x_70 - 7.9312801361084, 2) - 4.72406656838498e-6*std::pow(-4.89879989624023*x_70 - 7.14247989654541, 2) - 4.54705966914693e-6*std::pow(-5.99983978271484*x_71 - 9.40424060821533, 2) - 8.19274008128678e-7*std::pow(-5.7838397026062*x_72 - 7.57272005081177, 2) + 1.44092566029531e-6*std::pow(-5.50311994552612*x_73 - 8.97648048400879, 2) + 1.23968493652911e-6*std::pow(-4.92944002151489*x_74 - 6.36568021774292, 2) + 9.33174033382003e-7*std::pow(-7.0*x_77 - 9.99993991851807, 2) - 8.65667093019844e-6*std::pow(-4.67551946640015*x_78 - 6.30359983444214, 2) - 3.45454819755414e-7*std::pow(-4.72591972351074*x_79 - 6.36720037460327, 2) + 1.79971186545727e-6*std::pow(-4.89039993286133*x_84 - 8.17303943634033, 2) + 5.21698960600885e-6*std::pow(-5.33200025558472*x_85 - 8.39999961853027, 2) - 2.90754365301838e-6*std::pow(-5.09136009216309*x_85 - 8.60568046569824, 2) - 7.00591359760908e-6*std::pow(-6.66607999801636*x_86 - 8.43383884429932, 2) - 3.38709036808271e-7*std::pow(-5.27888011932373*x_86 - 8.12639999389648, 2) + 1.48709660935117e-6*std::pow(-7.70527982711792*x_87 - 8.48975944519043, 2) - 1.40194756271479e-7*std::pow(-8.80000019073486*x_88 - 9.99983978271484, 2) - 0.000753576397744659*std::exp(0.649039804935455*x_22) - 3.68428097251913e-5*std::exp(0.715519845485687*x_22) + 4.14305574286818e-6*std::exp(0.656719863414764*x_69) - 0.000183814559597129*std::exp(-0.0167596006380037*x_1 + 0.0333715385835524*x_10 - 0.00153133483700679*x_100 + 0.00341431634300359*x_101 - 0.00170218613751844*x_102 - 0.000888622641748586*x_103 + 0.00673385127210071*x_104 + 0.0113996261172403*x_105 - 0.00143584115490185*x_106 - 0.00142332523545453*x_108 - 0.00195983402485386*x_109 - 6.63977171230934e-5*x_11 - 2.2365223529718e-6*x_110 - 0.0634376236682185*x_112 + 0.00249147312627363*x_114 - 0.000414107502325894*x_116 - 0.0200529029221254*x_117 + 0.01557264152154*x_119 + 0.0438180949084903*x_12 + 0.0687008613200191*x_120 + 0.000158182769787647*x_13 - 0.00690399699416271*x_16 - 0.0619553670447749*x_17 - 0.00574214477070997*x_18 + 0.00655689945213076*x_19 - 0.103478124611302*x_2 + 0.0469513086027713*x_20 - 0.0238619863000965*x_21 - 0.00502769444930122*x_22 - 0.0026280489736206*x_24 + 0.0262713675977404*x_25 + 0.00988641956932677*x_27 - 0.00366795419715764*x_28 - 0.0382982828351377*x_29 - 0.00947915062956955*x_3 - 0.0700000194095418*x_30 - 0.0134740586665628*x_31 - 0.0171340845845188*x_32 + 9.43857613995223e-5*x_37 + 0.0619681054675037*x_39 - 0.172728464180949*x_4 - 0.000446815900209587*x_40 - 0.00333200561898464*x_44 + 0.0519388694127606*x_45 - 0.0042811793756478*x_46 + 0.00191460917185958*x_47 - 8.39381686052218e-5*x_48 - 0.000230293896113407*x_49 - 8.10636519208331e-5*x_5 - 0.0266861793402794*x_51 - 0.000342300874115812*x_53 + 0.00403068979462464*x_54 - 0.00117735820796466*x_56 + 0.0308562728127337*x_57 - 0.0367605563285078*x_58 - 0.00102486389221085*x_59 - 0.0505675615529946*x_6 - 0.0019704897132548*x_60 + 0.0214481871541608*x_61 - 0.000490360350214779*x_62 - 0.112635979875985*x_63 + 0.0140733690902839*x_64 - 0.00367081354673158*x_65 + 0.0417332001311151*x_66 - 0.0474630579550411*x_67 - 0.0187372233109979*x_68 - 0.0839950735321044*x_7 - 0.0353847970031218*x_70 - 0.00240125634073419*x_71 + 0.000170071088987223*x_72 + 0.0645072264883872*x_74 - 0.0240665683726911*x_75 - 0.0013900753263242*x_77 + 0.00104036001198735*x_78 - 0.000942462804777251*x_79 + 0.00238882800079024*x_8 - 0.00435600310096103*x_80 + 0.0283933631273347*x_81 + 0.0196251209037135*x_82 + 0.0231706876668399*x_83 + 0.00189330277390219*x_84 - 0.000545242502992614*x_85 - 0.0229832457176871*x_87 + 0.00752306496640993*x_88 - 0.0021401787275613*x_89 + 0.017571490724315*x_9 - 0.0155053667329817*x_91 - 0.000529632939466488*x_94 - 0.00668665838024394*x_95 - 0.0398704149716455*x_97 - 0.0132839133014987*x_99 - 0.000874608036367935*std::pow(-5.32231998443604*x_15 - 8.46951961517334, 2) - 0.000750329183827832*std::pow(-4.40399980545044*x_23 - 9.9993200302124, 2) - 0.000121687243777776*std::pow(-3.78287982940674*x_38 - 6.56720018386841, 2) - 0.00019267698307344*std::pow(-9.99993991851807*x_50 - 7.19999980926514, 2) - 0.000490727051769856*std::pow(-6.92199993133545*x_69 - 9.16287994384766, 2) - 0.00124997324377163*std::pow(-4.33304023742676*x_90 - 5.97864007949829, 2) - 0.189962030043893*std::sin(0.410559862852097*x_107 + 5.20783996582031) + 0.751051076910105*std::sin(0.303359925746918*x_111 - 7.49376010894775) - 0.643534189186621*std::sin(0.271599948406219*x_113 + 5.0623197555542) - 0.467062737146886*std::sin(0.269599944353104*x_115 + 1.86295986175537) - 0.177430559041154*std::sin(0.279519945383072*x_118 + 1.8647198677063) + 2.191084485442*std::sin(0.182000011205673*x_14 + 8.18039894104004) + 0.520866032002704*std::sin(0.338239848613739*x_26 - 7.44767951965332) - 1.11372781166496*std::sin(0.283119946718216*x_33 - 1.17807984352112) + 0.250675144769522*std::sin(0.328159838914871*x_34 - 7.41232013702393) - 0.412083228942882*std::sin(0.346479833126068*x_35 + 8.19127941131592) + 0.545722590596835*std::sin(0.317039847373962*x_36 - 4.27767992019653) + 0.649779014963922*std::sin(0.256319969892502*x_41 - 4.32304000854492) - 0.322288970593448*std::sin(0.409599870443344*x_42 + 2.00727987289429) - 0.49409496609946*std::sin(0.356799840927124*x_43 + 5.16048002243042) - 0.671041933991383*std::sin(0.26639997959137*x_52 + 8.27744007110596) + 1.01133685774141*std::sin(0.331519842147827*x_55 - 4.2804799079895) - 1.26036472134303*std::sin(0.250639975070953*x_73 - 7.52424001693726) - 1.09555992894535*std::sin(0.22223998606205*x_76 - 7.56864023208618) - 0.558931976167354*std::sin(0.364959836006165*x_86 + 1.95703983306885) + 0.607226382808644*std::sin(0.336159855127335*x_92 + 5.19160032272339) - 0.516454748753002*std::sin(0.409999877214432*x_93 + 1.99575984477997) - 0.178920636680529*std::sin(0.449839860200882*x_96 + 8.23176002502441) - 0.725132285799841*std::sin(0.411279857158661*x_98 + 5.21224021911621)) - 0.00327230649880779*std::sin(0.217519998550415*x_1 + 1.81207990646362) + 0.000122246389192833*std::sin(0.322799921035767*x_1 + 1.95039975643158) + 0.00314271875041881*std::sin(0.269199937582016*x_10 + 5.06816005706787) - 0.0036903253309842*std::sin(0.367199838161469*x_101 + 8.17160034179688) + 0.000118047270272769*std::sin(0.183680012822151*x_102 + 1.7850399017334) - 0.00242755022951874*std::sin(0.315999835729599*x_102 - 4.44975996017456) - 0.000185954096338199*std::sin(0.324799835681915*x_102 + 5.12800025939941) - 0.00298407765827921*std::sin(0.394879847764969*x_102 + 2.00839972496033) - 0.000675771632405363*std::sin(0.178960010409355*x_103 - 7.6241602897644) - 0.00655359652948333*std::sin(0.323359847068787*x_103 + 5.13160037994385) - 0.00130130724870559*std::sin(0.418079853057861*x_103 - 1.19207990169525) - 0.00226733327379991*std::sin(0.451519846916199*x_104 - 1.14063990116119) + 0.000402940482690125*std::sin(0.310239911079407*x_105 + 1.91767990589142) - 0.00147997923072642*std::sin(0.308159917593002*x_107 + 1.90919995307922) - 2.1555896777221e-6*std::sin(1.69463980197906*x_107 - 6.01591968536377) - 0.00388516344050277*std::sin(0.444559872150421*x_108 - 4.1657600402832) + 0.00281149635148626*std::sin(0.330799847841263*x_110 - 4.43279981613159) + 0.00646598148223798*std::sin(0.394479840993881*x_110 + 5.18344020843506) + 0.00445757975063082*std::sin(0.270639955997467*x_112 - 7.53815984725952) + 0.00129085916123085*std::sin(0.362479835748672*x_112 - 7.42967987060547) + 0.00357234297610654*std::sin(0.398479819297791*x_112 - 4.41079998016357) - 0.00194261090624607*std::sin(0.395199835300446*x_114 - 1.21023988723755) + 0.00617187307575715*std::sin(0.20720000565052*x_115 - 1.37271988391876) - 0.0080587219524906*std::sin(0.189600005745888*x_117 + 8.18416023254395) - 0.00162547702993052*std::sin(0.350239843130112*x_117 - 7.43336009979248) + 0.000167226442563958*std::sin(0.238799974322319*x_118 - 1.3614399433136) - 0.000793207069265981*std::sin(0.279359966516495*x_118 - 7.5207200050354) - 0.00646996273213327*std::sin(0.373199850320816*x_119 + 1.97575974464417) - 0.00256869313151229*std::sin(0.398399829864502*x_119 + 8.18903923034668) + 0.00196109261016873*std::sin(0.3572798371315*x_12 - 1.03671979904175) + 0.00105067280308438*std::sin(0.416479855775833*x_12 - 4.17271995544434) + 0.00261747508369616*std::sin(0.328719854354858*x_120 - 7.45576000213623) + 0.00321445757297511*std::sin(0.330799847841263*x_120 + 5.12911987304688) - 0.00859933129385236*std::sin(0.165200024843216*x_13 + 4.96023941040039) - 0.000901006778468301*std::sin(0.277359962463379*x_13 - 1.07599985599518) + 0.00826791222950925*std::sin(0.205119997262955*x_14 - 4.38215970993042) - 0.0240838242116402*std::sin(0.287039935588837*x_15 + 5.13007974624634) - 0.000216602597569057*std::sin(1.16935980319977*x_15 + 5.98727989196777) + 0.000800319644852512*std::sin(0.292079925537109*x_16 + 8.31447982788086) - 0.00057365470105396*std::sin(0.345759838819504*x_16 + 5.15791988372803) + 0.00182228409073702*std::sin(0.358719855546951*x_16 + 8.34712028503418) + 0.00257183493593863*std::sin(0.402959853410721*x_16 + 1.97447979450226) + 0.000279022186422685*std::sin(1.44519984722137*x_16 - 3.38727998733521) - 0.00272838631820317*std::sin(0.412719875574112*x_18 - 7.16936016082764) - 3.58141435480019e-5*std::sin(1.47319984436035*x_2 - 3.38879990577698) + 0.00431496651260687*std::sin(0.363679856061935*x_21 + 5.15895986557007) + 0.0320900315232815*std::sin(0.179360017180443*x_23 - 7.61696004867554) - 0.00666890734654584*std::sin(0.390239834785461*x_23 + 1.97439980506897) - 0.00190664843926175*std::sin(0.186960011720657*x_24 + 4.96975994110107) - 0.00108433515635857*std::sin(0.271279960870743*x_24 + 1.85807991027832) - 0.000262302812336523*std::sin(0.333439826965332*x_24 + 5.13248014450073) - 0.00295407230707392*std::sin(0.547119855880737*x_24 + 8.55247974395752) - 1.90156491122078e-5*std::sin(1.16631984710693*x_25 - 8.98752021789551) - 0.00894957943635175*std::sin(0.339359849691391*x_26 + 8.35319995880127) + 0.000149262253965871*std::sin(0.353679865598679*x_26 + 1.9618399143219) + 0.0038086156910116*std::sin(0.32687982916832*x_27 + 8.30775928497314) - 0.000165707518960604*std::sin(0.378799855709076*x_27 - 7.41504001617432) + 0.0119866975804401*std::sin(0.136960044503212*x_28 + 8.09280014038086) - 0.00407170656258556*std::sin(0.19055999815464*x_28 - 4.42063999176025) + 0.00113007552226686*std::sin(0.457199841737747*x_28 - 7.13647985458374) + 0.000425552057540289*std::sin(0.300159931182861*x_3 - 1.0843198299408) + 0.000371769858176811*std::sin(0.359999865293503*x_3 - 1.0461597442627) - 0.00322458002223806*std::sin(0.281439960002899*x_30 - 7.52135992050171) + 0.00356303722456459*std::sin(0.312719851732254*x_30 - 4.26567983627319) + 0.00614424397663256*std::sin(0.285759925842285*x_33 + 8.2041597366333) + 0.00713295205341334*std::sin(0.292399942874908*x_33 + 8.20679950714111) - 0.00343334117807706*std::sin(0.303599923849106*x_33 - 1.19399988651276) + 0.00275196628509527*std::sin(0.318159908056259*x_34 + 8.25111961364746) - 0.00635788454872377*std::sin(0.341119825839996*x_34 - 1.19039988517761) + 0.000942908675679869*std::sin(0.350879848003387*x_34 + 2.00583982467651) - 0.00131174771151534*std::sin(0.355279833078384*x_34 + 1.97823989391327) - 0.00300778688583619*std::sin(0.384159833192825*x_34 - 1.19863986968994) - 0.00049812010251785*std::sin(0.291759938001633*x_35 + 8.24959945678711) + 8.58293042855143e-5*std::sin(0.321279853582382*x_35 + 1.77135992050171) + 0.000158791612006856*std::sin(0.322319835424423*x_35 - 4.42935991287231) - 0.00451937835780291*std::sin(0.285039931535721*x_36 - 7.51999998092651) + 0.000334937111827158*std::sin(0.322799831628799*x_36 - 7.46775960922241) + 0.00233933035988149*std::sin(0.352559864521027*x_36 + 5.15791988372803) - 0.000659875544282781*std::sin(0.353839844465256*x_36 + 5.14800024032593) - 0.000381422017925384*std::sin(0.26335996389389*x_37 + 1.8458399772644) + 0.00510289553912495*std::sin(0.267279952764511*x_37 + 5.08191967010498) + 0.00147563357700816*std::sin(0.292879939079285*x_37 + 5.11407995223999) - 0.00339294295544478*std::sin(0.317519843578339*x_37 + 5.12696027755737) - 0.00653481855281677*std::sin(0.225279986858368*x_38 + 5.02023983001709) - 0.0002451083159186*std::sin(0.333999842405319*x_41 + 5.13104009628296) + 5.88358092426177e-5*std::sin(0.360479861497879*x_41 + 4.78455972671509) + 0.00297064623895369*std::sin(0.363999843597412*x_41 - 1.21383988857269) - 0.00102426599261145*std::sin(0.465279847383499*x_41 - 4.34639978408813) - 0.0101154500852771*std::sin(0.198400005698204*x_42 + 5.00551986694336) - 0.000131140257956776*std::sin(0.403279840946198*x_42 + 8.20879936218262) - 0.000201674849099928*std::sin(0.189600005745888*x_43 - 7.60376024246216) - 0.000811459035788456*std::sin(0.236559987068176*x_43 - 7.55200004577637) + 0.000271491504103559*std::sin(0.26199996471405*x_43 + 5.06319952011108) + 0.000445450096392162*std::sin(0.337439835071564*x_43 + 5.13944005966187) + 0.0100306552165671*std::sin(0.294879943132401*x_47 - 7.48031997680664) - 0.00561781383072815*std::sin(0.32711985707283*x_47 + 8.3133602142334) + 5.37782135260568e-5*std::sin(1.76415991783142*x_49 - 7.41623973846436) + 0.00626673701904188*std::sin(0.285839945077896*x_50 + 5.09280014038086) + 0.000208179159984093*std::sin(0.254639983177185*x_51 + 1.83439981937408) + 0.00814712618683756*std::sin(0.335119843482971*x_51 + 5.13655996322632) - 0.000301616374389288*std::sin(0.477919846773148*x_51 + 8.44704055786133) + 0.00157235672332003*std::sin(0.409919857978821*x_52 + 5.20424032211304) - 0.00213658358872068*std::sin(0.597679853439331*x_52 + 2.00543975830078) + 0.00719166656864892*std::sin(0.166960015892982*x_53 - 7.6497597694397) - 0.000561546991953702*std::sin(0.383759826421738*x_54 - 7.42215967178345) - 5.28406925627941e-5*std::sin(0.454879850149155*x_54 - 1.15599977970123) + 0.00103879467855525*std::sin(0.460639864206314*x_54 - 1.13079988956451) - 0.000412372556508941*std::sin(0.330559849739075*x_57 + 1.92791974544525) + 0.000319306483426245*std::sin(0.350719839334488*x_58 - 7.43415975570679) - 0.00273360012607072*std::sin(0.320719838142395*x_59 - 4.28952026367188) + 9.705223929763e-6*std::sin(1.39943981170654*x_6 - 5.19679975509644) - 0.00338542442887504*std::sin(0.305039942264557*x_62 - 4.27687978744507) - 0.0201330289827265*std::sin(0.130960047245026*x_64 + 4.91191959381104) + 0.00535591035909574*std::sin(0.186400011181831*x_64 - 4.42831993103027) - 0.00410738552537757*std::sin(0.220399990677834*x_65 + 5.01191997528076) + 0.00316628359813551*std::sin(0.306479841470718*x_67 - 7.49200010299683) - 0.0117234141843185*std::sin(0.14544004201889*x_68 + 4.9206395149231) - 0.000459660778215553*std::sin(0.167200013995171*x_71 - 4.45599985122681) - 0.000330669964927529*std::sin(0.207039996981621*x_73 - 7.59656000137329) - 0.00315666002693167*std::sin(0.23735998570919*x_75 - 7.56728029251099) - 0.000216124484538218*std::sin(0.269359946250916*x_75 + 5.09375953674316) + 0.00792474724576335*std::sin(0.242639973759651*x_79 + 1.85583996772766) - 0.000172913718836925*std::sin(0.243519976735115*x_79 - 7.54839992523193) - 0.0352453244560057*std::sin(0.134880036115646*x_80 + 4.91583967208862) + 0.0150537721767717*std::sin(0.182960003614426*x_80 - 7.60896015167236) - 0.00350344544385404*std::sin(0.281279861927032*x_84 - 1.29047977924347) + 0.00027645416557782*std::sin(0.295519828796387*x_85 - 1.26815986633301) + 0.00120723257186227*std::sin(0.157360032200813*x_86 - 7.64720010757446) + 0.0199653667762138*std::sin(0.173280015587807*x_86 - 7.63872003555298) + 0.0184256173528982*std::sin(0.184800013899803*x_88 - 7.60400009155273) - 0.00122169143485517*std::sin(0.214479997754097*x_88 + 5.01127958297729) + 0.00677589172341564*std::sin(0.314479917287827*x_9 + 8.34624004364014) - 0.00196754792870276*std::sin(0.356559842824936*x_9 - 4.25672006607056) - 0.00118897387532712*std::sin(0.361919850111008*x_92 - 7.40287971496582) - 0.000313464491675746*std::sin(0.367439836263657*x_92 + 1.98079979419708) - 0.00233602121306357*std::sin(0.367679834365845*x_92 - 1.3977597951889) - 0.000572134505747445*std::sin(0.392559856176376*x_92 + 1.97831988334656) + 0.000403283269894427*std::sin(0.345039844512939*x_93 - 1.42127990722656) + 0.00727761239759885*std::sin(0.361599832773209*x_93 - 7.40575981140137) - 0.00239714635933041*std::sin(0.422959864139557*x_93 - 7.60512018203735) - 0.00344922048331351*std::sin(0.36983984708786*x_94 + 5.17535972595215) + 0.000812817732215076*std::sin(0.379439830780029*x_94 + 4.98119974136353) + 0.00142224827535704*std::sin(0.398239850997925*x_94 + 5.19799995422363) - 0.000244734011902395*std::sin(0.328559845685959*x_95 + 1.94279980659485) + 0.000283638961630662*std::sin(0.344959855079651*x_95 - 7.42527961730957) + 0.00029930535942308*std::sin(0.373599827289581*x_95 - 7.42496013641357) + 0.00254800104921703*std::sin(0.386799842119217*x_95 + 8.18487930297852) + 0.00172208580137648*std::sin(0.343759834766388*x_96 - 4.42055988311768) - 0.00162661937185368*std::sin(0.346959829330444*x_96 + 1.94447982311249) + 4.91212255160401e-5*std::sin(0.42103984951973*x_96 - 1.15919995307922) - 0.00260622159962659*std::sin(0.312559932470322*x_97 + 1.90231990814209) - 0.000314883131438367*std::sin(0.371679842472076*x_97 - 7.43088006973267) + 0.00310033150931587*std::sin(0.411359876394272*x_97 + 8.21576023101807) + 0.00306153451597326*std::sin(0.463359862565994*x_98 + 2.01143980026245) + 0.00382323337736628*std::sin(0.33247983455658*x_99 - 7.45544004440308) - 0.0014622228944529*std::sin(0.396479845046997*x_99 + 2.0019998550415) - 0.000506278735155521*std::sin(0.39743983745575*x_99 - 7.39287996292114) + 0.00205792964905097*std::sin(0.468479871749878*x_99 + 8.24679946899414) - 0.0198849011212587*std::sin(0.00508691478580763*x_1 - 0.00568761717784402*x_10 - 0.00134985140544122*x_100 + 0.0131694726106262*x_101 + 0.000417670124204616*x_104 + 0.0006850043607779*x_105 + 0.0030157500604898*x_106 - 0.00078753504312728*x_107 - 0.000304356156226532*x_108 - 0.005348895611315*x_109 + 0.00123687084493494*x_11 + 0.00481975256385981*x_110 - 0.000675045577923902*x_111 + 0.00032431056084702*x_113 - 0.000290743769444903*x_114 + 0.00152908360131311*x_116 - 0.000629106139853005*x_118 - 0.0392668891838649*x_119 - 0.0536157000031674*x_12 + 0.000865485979110845*x_120 + 0.0255543385494386*x_14 + 0.00178908785065333*x_15 - 0.0168932303825392*x_16 + 0.0262305793127383*x_17 - 0.0187590881099719*x_18 + 0.0151247161137063*x_19 - 0.0177700123524576*x_2 - 0.058595144583347*x_20 - 0.00240501950782374*x_23 + 0.0141155267618281*x_25 + 0.00504526870863811*x_26 + 0.0338024742247962*x_27 - 0.0399994602252809*x_28 + 0.126943624063166*x_29 - 0.0201075132068235*x_3 + 0.0859276907454006*x_30 - 0.103586830839465*x_31 + 0.0670346432470622*x_32 - 0.00725629066722333*x_33 + 0.0301462668827609*x_34 + 0.00249389891292855*x_35 + 0.00252165787143064*x_37 + 0.00473572178316175*x_38 + 0.00715708248562521*x_4 + 0.0170019477177152*x_40 - 0.0136836477033954*x_42 + 0.0171030268133999*x_44 + 0.021700802537392*x_45 + 0.0085990840339617*x_46 - 0.00195390010172511*x_47 + 0.0212599400391747*x_48 - 0.00046600980569489*x_49 + 0.00964767247665665*x_5 - 0.00526270203838688*x_51 - 0.00119092457006545*x_52 + 0.000310642327003312*x_53 + 0.00656054480636391*x_54 - 0.0207214406593015*x_55 - 0.000667862897379315*x_56 - 0.000135110259000891*x_57 - 0.00166350968821673*x_58 + 0.0011778710036849*x_59 + 0.00640588611536221*x_6 + 0.00174250343555341*x_60 + 0.000534625960298956*x_61 - 3.72772612111033e-5*x_62 - 0.000560151364144655*x_63 - 0.0253366765060396*x_64 + 0.0286121321804765*x_65 + 0.00664450153295907*x_66 - 0.00993011516511553*x_68 - 0.000444335142669749*x_69 - 0.0638983780181961*x_7 - 0.00172841346904479*x_70 - 0.000763660105946494*x_71 - 0.00190342766968171*x_73 - 0.000443302172828945*x_74 + 0.00174969817030933*x_75 - 0.0253238333892742*x_77 + 0.000422076537425843*x_78 + 0.0145216277775999*x_79 + 0.00343128361676675*x_8 - 0.00614684950940278*x_80 + 0.00061813220087646*x_81 + 0.000451582014314609*x_83 + 0.0094450835571688*x_84 - 0.00199927366380899*x_85 - 0.0600854828832593*x_86 + 0.0161785009262572*x_87 - 0.0166583261176638*x_88 - 0.00587069021899042*x_89 - 0.0198178054973572*x_9 + 0.000273695663181123*x_90 + 0.0745141425110534*x_91 - 0.0105367775506383*x_92 - 0.0030120075207169*x_93 + 0.00271800496080617*x_94 + 0.00130915174249711*x_95 + 7.4821090723389e-5*x_96 - 0.00644244761906848*x_97 + 0.000554589366036358*x_98 + 0.00457911344358299*x_99 + 0.00174267872976883*std::pow(-4.98327970504761*x_22 - 7.76327991485596, 2) - 0.00104697448705807*std::pow(-4.69727993011475*x_72 - 5.92263984680176, 2) + 0.000497569759562048*std::pow(-5.28800010681152*x_82 - 7.51375961303711, 2) + 0.0571241148383499*std::exp(0.543359875679016*x_67) - 0.126579753697092*std::sin(0.467919856309891*x_102 + 5.0220799446106) + 0.413586956086728*std::sin(0.366719841957092*x_103 - 7.41215991973877) - 0.692354455792888*std::sin(0.141760036349297*x_112 + 8.10503959655762) + 0.11810549692278*std::sin(0.457519859075546*x_115 - 1.14735984802246) - 0.00653126435762663*std::sin(1.79807984828949*x_117 + 8.98896026611328) + 4.87625046298763*std::sin(0.126080051064491*x_13 + 8.07575988769531) - 0.285862680244445*std::sin(0.243679970502853*x_21 + 8.26344013214111) - 0.762812468317925*std::sin(0.209600001573563*x_24 - 4.37680006027222) + 0.289071116970071*std::sin(0.331679850816727*x_36 + 5.1483998298645) + 0.0416713311297401*std::sin(0.474399864673615*x_39 - 7.7836799621582) + 0.315365040308297*std::sin(0.295359939336777*x_41 - 4.28927993774414) + 0.348635911042781*std::sin(0.373679846525192*x_43 - 1.21103978157043) - 0.477694823253906*std::sin(0.399759829044342*x_50 - 1.19031989574432) - 1.17799605607877*std::sin(0.171120017766953*x_76 - 7.64520025253296) - 4.99620478004859) + 0.0693801377387129);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00304733569026509*x_1 - 0.00534223019010602*x_10 + 0.0016421644111939*x_100 - 0.000329442377433148*x_101 + 0.000136077959070917*x_102 + 0.000130089557879062*x_103 - 0.00161279405659246*x_104 + 0.000813916024697025*x_105 - 0.000135137752917093*x_106 - 0.000109899733470302*x_107 + 0.000952284932886802*x_108 - 0.000796585570249844*x_109 + 0.000641246379945034*x_11 + 0.00122343129216074*x_110 - 0.000116381972354284*x_111 + 0.000349434808755919*x_112 + 0.00102204260108507*x_113 + 7.00483770791603e-5*x_114 + 9.99409471715263e-5*x_115 + 0.00283058145606736*x_116 + 0.000397425590167245*x_117 - 0.000817684650529194*x_118 + 0.000698840826795776*x_119 - 0.000806632441540226*x_12 + 0.000408834376419262*x_120 - 0.000439232285252495*x_13 + 0.000133834956354744*x_14 + 0.00080943923566165*x_15 + 0.000275855216644436*x_16 + 0.00274243231350431*x_17 + 0.000356109178242895*x_18 - 0.000126530834996992*x_19 - 0.00156390898488606*x_2 + 0.0032892435156048*x_20 + 0.000942035376363313*x_21 - 1.32893825904207e-5*x_22 + 0.000131401603738384*x_23 - 0.000860845511471353*x_24 - 0.000880867510013239*x_25 + 0.000320386496398593*x_26 - 0.0005240408126482*x_27 + 0.000886049348054666*x_28 - 0.00453701050654714*x_29 + 0.001153600835771*x_3 - 0.00122004822635536*x_30 + 0.000444022786174441*x_31 + 0.00205910387154214*x_32 - 0.000166792005444583*x_33 - 0.000657381432531745*x_34 - 0.00132445663352914*x_35 - 4.89129336143063e-5*x_36 - 0.000111022833559813*x_37 - 4.78018560154137e-5*x_38 - 0.000887170928815814*x_39 + 0.0023989546711078*x_4 - 0.000931384459317432*x_40 - 8.85560861557927e-6*x_41 + 0.00122277709256991*x_42 + 0.00224480178984253*x_43 - 5.02515493205958e-7*x_44 - 0.000364285083604129*x_45 - 0.000217536147581329*x_46 - 0.000529499557359155*x_47 - 0.00105736029056437*x_48 + 0.00065853446758252*x_49 + 0.000595996468046873*x_5 + 0.00134720356831976*x_50 + 0.000834237945912395*x_51 - 0.000766631284951957*x_52 - 0.000200182455714067*x_53 - 0.000886237208672936*x_54 + 0.000357228742534295*x_55 - 0.00143687560011551*x_56 - 0.00118047910655147*x_57 + 8.71038386639078e-5*x_58 + 0.000558462651330983*x_59 + 0.00185060353196171*x_6 - 0.000864155748308696*x_60 - 0.000764095324382661*x_61 + 0.00308191161672868*x_62 - 0.00215316448841128*x_63 + 9.00358456154503e-5*x_64 - 0.000755482303740869*x_65 + 0.000805907653524476*x_66 + 6.69574234575894e-5*x_67 + 8.6959497438021e-5*x_68 + 0.00013195049176317*x_69 + 0.000935770616452279*x_7 + 0.000201720343239915*x_70 - 0.000159153731324738*x_71 - 0.00174323928720795*x_72 - 0.000514939404538071*x_73 + 0.00037679415453015*x_74 - 0.000951898434072546*x_75 - 0.000613467871728891*x_76 + 0.000368782804938594*x_77 - 0.000309617995226749*x_78 - 0.000417791965817081*x_79 + 0.00110481040513269*x_8 + 0.000185356502252821*x_80 - 0.000130333549756184*x_81 - 0.000160275428615997*x_82 - 0.000300706730777239*x_83 - 0.000278150780038101*x_84 + 1.27167636262175e-5*x_85 + 0.00144601145888643*x_86 + 0.000364270637847195*x_87 + 0.000276591809974845*x_88 - 0.000117398535411784*x_89 + 0.0018743672086376*x_9 - 0.000618551835888805*x_90 - 0.000755864080549711*x_91 + 0.00197039498004917*x_92 - 0.000213580870664578*x_93 - 5.31402125889549e-5*x_94 + 3.19001029549093e-5*x_95 + 9.41235599261377e-5*x_96 - 0.000719108132656475*x_97 - 0.000137471533363615*x_98 + 0.000581388001222137*x_99 - 1.99347127664908e-6*std::pow(-5.55215978622437*x_100 - 7.38375997543335, 2) - 2.98438520560484e-8*std::pow(-9.58480072021484*x_106 - 7.96384000778198, 2) + 1.44958865183237e-6*std::pow(-7.98799991607666*x_106 - 8.19944000244141, 2) + 2.83585122250954e-6*std::pow(-6.71752023696899*x_106 - 9.56103992462158, 2) - 1.38514910449759e-6*std::pow(-5.86383962631226*x_106 - 8.48952007293701, 2) + 2.47332831725758e-9*std::pow(-8.6636791229248*x_108 - 6.04663944244385, 2) + 2.09563974975376e-6*std::pow(-8.47000026702881*x_116 - 8.86903953552246, 2) - 3.6641743201079e-6*std::pow(-6.09335994720459*x_13 - 9.55160045623779, 2) - 2.07133345405554e-5*std::pow(-4.07000017166138*x_13 - 6.52231979370117, 2) - 2.93554558802282e-5*std::pow(-5.10199975967407*x_14 - 7.75728034973145, 2) + 1.39147135055292e-7*std::pow(-3.51191973686218*x_14 - 6.0479998588562, 2) + 9.57003019122606e-6*std::pow(-5.6691198348999*x_15 - 7.42512035369873, 2) + 2.09487616564032e-7*std::pow(-5.32231998443604*x_15 - 8.46951961517334, 2) + 3.82803977337153e-8*std::pow(-5.82096004486084*x_17 - 9.23791980743408, 2) + 4.35034659049016e-5*std::pow(-5.46256017684937*x_17 - 8.0926399230957, 2) - 1.03336814070314e-8*std::pow(-6.85031986236572*x_18 - 7.45431995391846, 2) - 3.65216673422604e-5*std::pow(-5.03071975708008*x_18 - 7.24015998840332, 2) + 5.58363583074616e-6*std::pow(-3.47519993782043*x_18 - 4.50079965591431, 2) + 0.000296837195499108*std::pow(-1.34583985805511*x_2 - 2.49487972259521, 2) + 3.55985932266029e-7*std::pow(-5.71983957290649*x_22 - 9.39935970306396, 2) + 1.10963586958102e-5*std::pow(-5.3167200088501*x_22 - 8.58440017700195, 2) - 3.10255968430814e-5*std::pow(-4.98327970504761*x_22 - 7.76327991485596, 2) + 1.92208660326963e-7*std::pow(-5.90136003494263*x_23 - 8.54720020294189, 2) + 2.02551449188825e-6*std::pow(-5.04120016098022*x_23 - 8.87744045257568, 2) + 1.79720132702283e-7*std::pow(-4.40399980545044*x_23 - 9.9993200302124, 2) - 8.77289020970169e-6*std::pow(-5.77959966659546*x_24 - 8.97016048431396, 2) + 6.94875538269999e-6*std::pow(-4.79911994934082*x_36 - 3.79999995231628, 2) + 3.2686394091765e-6*std::pow(-5.51895999908447*x_38 - 6.90023994445801, 2) + 2.91467372871573e-8*std::pow(-3.78287982940674*x_38 - 6.56720018386841, 2) + 9.68782809198387e-8*std::pow(-5.15136003494263*x_40 - 5.74847984313965, 2) - 1.21284676890578e-7*std::pow(-5.46367979049683*x_47 - 7.07823991775513, 2) + 3.09785239414145e-6*std::pow(-7.80000019073486*x_49 - 9.99882030487061, 2) + 2.52671988439605e-8*std::pow(-4.93391990661621*x_49 - 8.67199993133545, 2) + 0.000646896287814342*std::pow(-0.788719892501831*x_49 - 1.1847198009491, 2) - 3.0415646414119e-6*std::pow(-5.88295984268188*x_5 - 9.54328060150146, 2) + 1.83483316126504e-5*std::pow(-3.3374400138855*x_5 - 5.49232006072998, 2) + 4.61503213695867e-8*std::pow(-9.99993991851807*x_50 - 7.19999980926514, 2) - 1.56916260317661e-5*std::pow(-4.51688003540039*x_53 - 6.4747200012207, 2) - 9.97335838798011e-6*std::pow(-7.36400032043457*x_54 - 9.79903984069824, 2) - 1.15984051650053e-6*std::pow(-8.16296005249023*x_55 - 7.95711994171143, 2) + 2.19588454651904e-6*std::pow(-6.19600009918213*x_57 - 9.98884010314941, 2) - 2.68735062257366e-5*std::pow(-3.92007994651794*x_58 - 5.68487977981567, 2) - 3.26041539661643e-6*std::pow(-6.60400009155273*x_64 - 9.96195983886719, 2) + 8.72367407292831e-6*std::pow(-6.08367967605591*x_66 - 9.94783973693848, 2) + 1.5336146282015e-5*std::pow(-3.43055987358093*x_67 - 6.46231985092163, 2) - 3.92328862147781e-5*std::pow(-3.24863982200623*x_68 - 5.47495985031128, 2) - 7.20379551321244e-9*std::pow(-7.40719985961914*x_69 - 9.41207981109619, 2) + 1.17539784891154e-7*std::pow(-6.92199993133545*x_69 - 9.16287994384766, 2) + 3.14055144735213e-6*std::pow(-6.40399980545044*x_69 - 9.99507999420166, 2) + 2.26449273495752e-5*std::pow(-6.09127998352051*x_7 - 9.73591995239258, 2) - 2.41852894410442e-5*std::pow(-5.7707200050354*x_7 - 9.56975936889648, 2) + 5.07444372571158e-5*std::pow(-5.54423999786377*x_7 - 8.90136051177979, 2) - 1.43169281125964e-5*std::pow(-2.79311990737915*x_7 - 4.79031991958618, 2) + 4.12519425566916e-6*std::pow(-8.72799968719482*x_70 - 9.33439922332764, 2) + 6.31692565233572e-6*std::pow(-7.34127998352051*x_70 - 7.9312801361084, 2) - 1.14618727676148e-5*std::pow(-4.89879989624023*x_70 - 7.14247989654541, 2) + 7.07593734498142e-6*std::pow(-5.99983978271484*x_71 - 9.40424060821533, 2) + 6.59130391040041e-6*std::pow(-5.7838397026062*x_72 - 7.57272005081177, 2) + 1.8639699782624e-5*std::pow(-4.69727993011475*x_72 - 5.92263984680176, 2) + 1.89682479729082e-6*std::pow(-5.50311994552612*x_73 - 8.97648048400879, 2) + 1.63191286908889e-6*std::pow(-4.92944002151489*x_74 - 6.36568021774292, 2) - 1.45216501929332e-6*std::pow(-7.0*x_77 - 9.99993991851807, 2) + 1.34711364211541e-5*std::pow(-4.67551946640015*x_78 - 6.30359983444214, 2) + 3.92594615234451e-6*std::pow(-4.72591972351074*x_79 - 6.36720037460327, 2) - 8.85843070083773e-6*std::pow(-5.28800010681152*x_82 - 7.51375961303711, 2) + 2.36912853205643e-6*std::pow(-4.89039993286133*x_84 - 8.17303943634033, 2) - 1.58478722731288e-5*std::pow(-5.33200025558472*x_85 - 8.39999961853027, 2) - 7.05449318606357e-6*std::pow(-5.09136009216309*x_85 - 8.60568046569824, 2) - 1.69982554467157e-5*std::pow(-6.66607999801636*x_86 - 8.43383884429932, 2) + 3.84928321672636e-6*std::pow(-5.27888011932373*x_86 - 8.12639999389648, 2) + 1.95760392247182e-6*std::pow(-7.70527982711792*x_87 - 8.48975944519043, 2) + 1.59325339375081e-6*std::pow(-8.80000019073486*x_88 - 9.99983978271484, 2) + 2.99395734681281e-7*std::pow(-4.33304023742676*x_90 - 5.97864007949829, 2) - 0.00182838168484565*std::exp(0.649039804935455*x_22) + 0.000418702761723181*std::exp(0.715519845485687*x_22) - 0.00101700314964401*std::exp(0.543359875679016*x_67) - 3.66525932791156e-6*std::exp(0.656719863414764*x_69) - 0.00430764215136707*std::sin(0.217519998550415*x_1 + 1.81207990646362) - 0.000108148368281994*std::sin(0.322799921035767*x_1 + 1.95039975643158) + 0.00413705371551472*std::sin(0.269199937582016*x_10 + 5.06816005706787) + 0.00574272446913831*std::sin(0.367199838161469*x_101 + 8.17160034179688) - 0.000104433511242653*std::sin(0.183680012822151*x_102 + 1.7850399017334) - 0.00588989834604514*std::sin(0.315999835729599*x_102 - 4.44975996017456) - 1.34473541026226e-5*std::sin(0.324799835681915*x_102 + 5.12800025939941) + 0.00464369242519836*std::sin(0.394879847764969*x_102 + 2.00839972496033) + 0.00225354928571572*std::sin(0.467919856309891*x_102 + 5.0220799446106) + 0.00767985533385751*std::sin(0.178960010409355*x_103 - 7.6241602897644) + 0.0101984231131965*std::sin(0.323359847068787*x_103 + 5.13160037994385) - 0.0073632517227121*std::sin(0.366719841957092*x_103 - 7.41215991973877) + 0.0039530366404851*std::sin(0.418079853057861*x_103 - 1.19207990169525) + 0.00688757517983353*std::sin(0.451519846916199*x_104 - 1.14063990116119) - 0.00324177644214596*std::sin(0.310239911079407*x_105 + 1.91767990589142) - 0.00194823465336992*std::sin(0.308159917593002*x_107 + 1.90919995307922) + 4.55000311646109e-5*std::sin(0.410559862852097*x_107 + 5.20783996582031) + 1.90699707263682e-6*std::sin(1.69463980197906*x_107 - 6.01591968536377) + 0.00604592309763281*std::sin(0.444559872150421*x_108 - 4.1657600402832) - 0.00854060261561624*std::sin(0.330799847841263*x_110 - 4.43279981613159) - 0.0100620803708762*std::sin(0.394479840993881*x_110 + 5.18344020843506) - 0.000179893041771181*std::sin(0.303359925746918*x_111 - 7.49376010894775) + 0.0123262594826016*std::sin(0.141760036349297*x_112 + 8.10503959655762) + 0.0108153031320838*std::sin(0.270639955997467*x_112 - 7.53815984725952) + 0.00169927827250359*std::sin(0.362479835748672*x_112 - 7.42967987060547) - 0.00555912543774836*std::sin(0.398479819297791*x_112 - 4.41079998016357) + 0.000154140412464102*std::sin(0.271599948406219*x_113 + 5.0623197555542) + 0.00302300696679742*std::sin(0.395199835300446*x_114 - 1.21023988723755) - 0.0187485625959279*std::sin(0.20720000565052*x_115 - 1.37271988391876) + 0.000111871667675384*std::sin(0.269599944353104*x_115 + 1.86295986175537) - 0.00210267874960754*std::sin(0.457519859075546*x_115 - 1.14735984802246) + 0.0244803240628718*std::sin(0.189600005745888*x_117 + 8.18416023254395) - 0.00213976697254939*std::sin(0.350239843130112*x_117 - 7.43336009979248) + 0.000116278675681198*std::sin(1.79807984828949*x_117 + 8.98896026611328) - 0.000147941113159315*std::sin(0.238799974322319*x_118 - 1.3614399433136) + 0.00638158760748691*std::sin(0.279359966516495*x_118 - 7.5207200050354) + 4.24984717422817e-5*std::sin(0.279519945383072*x_118 + 1.8647198677063) - 0.0156978926044798*std::sin(0.373199850320816*x_119 + 1.97575974464417) + 0.00780302889815667*std::sin(0.398399829864502*x_119 + 8.18903923034668) + 0.00475814505529884*std::sin(0.3572798371315*x_12 - 1.03671979904175) + 0.00138309857451013*std::sin(0.416479855775833*x_12 - 4.17271995544434) + 0.00344562650374912*std::sin(0.328719854354858*x_120 - 7.45576000213623) + 0.00779914998762016*std::sin(0.330799847841263*x_120 + 5.12911987304688) - 0.0868138104782011*std::sin(0.126080051064491*x_13 + 8.07575988769531) + 0.0261225561619531*std::sin(0.165200024843216*x_13 + 4.96023941040039) + 0.00724886844119508*std::sin(0.277359962463379*x_13 - 1.07599985599518) - 0.000524812313012612*std::sin(0.182000011205673*x_14 + 8.18039894104004) - 0.0128661669664847*std::sin(0.205119997262955*x_14 - 4.38215970993042) + 0.0374782042790047*std::sin(0.287039935588837*x_15 + 5.13007974624634) - 0.00028513419501627*std::sin(1.16935980319977*x_15 + 5.98727989196777) - 0.00643881040085198*std::sin(0.292079925537109*x_16 + 8.31447982788086) - 4.1484097686543e-5*std::sin(0.345759838819504*x_16 + 5.15791988372803) + 0.00239884245680664*std::sin(0.358719855546951*x_16 + 8.34712028503418) + 0.00623997236032028*std::sin(0.402959853410721*x_16 + 1.97447979450226) - 0.000847597619650758*std::sin(1.44519984722137*x_16 - 3.38727998733521) + 0.00828813571582238*std::sin(0.412719875574112*x_18 - 7.16936016082764) - 2.58991589675029e-6*std::sin(1.47319984436035*x_2 - 3.38879990577698) + 0.00508932605777737*std::sin(0.243679970502853*x_21 + 8.26344013214111) - 0.0131077581745341*std::sin(0.363679856061935*x_21 + 5.15895986557007) - 0.0974812601190335*std::sin(0.179360017180443*x_23 - 7.61696004867554) - 0.0161805864499602*std::sin(0.390239834785461*x_23 + 1.97439980506897) + 0.0153395557393185*std::sin(0.186960011720657*x_24 + 4.96975994110107) + 0.0135806512724507*std::sin(0.209600001573563*x_24 - 4.37680006027222) - 0.00142741146877323*std::sin(0.271279960870743*x_24 + 1.85807991027832) + 0.000232052834748563*std::sin(0.333439826965332*x_24 + 5.13248014450073) + 0.0089737116888584*std::sin(0.547119855880737*x_24 + 8.55247974395752) - 1.37512521712892e-6*std::sin(1.16631984710693*x_25 - 8.98752021789551) - 0.000124758725115931*std::sin(0.338239848613739*x_26 - 7.44767951965332) + 0.0271865199122043*std::sin(0.339359849691391*x_26 + 8.35319995880127) - 0.00169630162364639*std::sin(0.353679865598679*x_26 + 1.9618399143219) + 0.0050136359460634*std::sin(0.32687982916832*x_27 + 8.30775928497314) + 0.0018831950208092*std::sin(0.378799855709076*x_27 - 7.41504001617432) + 0.0290829946153468*std::sin(0.136960044503212*x_28 + 8.09280014038086) - 0.00535996699067819*std::sin(0.19055999815464*x_28 - 4.42063999176025) - 0.00343287870753028*std::sin(0.457199841737747*x_28 - 7.13647985458374) + 3.07739884172067e-5*std::sin(0.300159931182861*x_3 - 1.0843198299408) - 0.00422500529968085*std::sin(0.359999865293503*x_3 - 1.0461597442627) - 0.00782370980782358*std::sin(0.281439960002899*x_30 - 7.52135992050171) - 0.00554464423018788*std::sin(0.312719851732254*x_30 - 4.26567983627319) + 0.000266761995162615*std::sin(0.283119946718216*x_33 - 1.17807984352112) - 0.00956140639761783*std::sin(0.285759925842285*x_33 + 8.2041597366333) + 0.0173064853575234*std::sin(0.292399942874908*x_33 + 8.20679950714111) - 0.00451962711442139*std::sin(0.303599923849106*x_33 - 1.19399988651276) - 0.00428249075792063*std::sin(0.318159908056259*x_34 + 8.25111961364746) - 6.00421405086647e-5*std::sin(0.328159838914871*x_34 - 7.41232013702393) - 0.0154259603910639*std::sin(0.341119825839996*x_34 - 1.19039988517761) - 0.00758598171002031*std::sin(0.350879848003387*x_34 + 2.00583982467651) - 0.00172677581887316*std::sin(0.355279833078384*x_34 + 1.97823989391327) + 0.00913688276024582*std::sin(0.384159833192825*x_34 - 1.19863986968994) + 0.0040075248903286*std::sin(0.291759938001633*x_35 + 8.24959945678711) - 7.59310706070434e-5*std::sin(0.321279853582382*x_35 + 1.77135992050171) + 1.14830868328863e-5*std::sin(0.322319835424423*x_35 - 4.42935991287231) + 9.87028815968235e-5*std::sin(0.346479833126068*x_35 + 8.19127941131592) - 0.0109652433927403*std::sin(0.285039931535721*x_36 - 7.51999998092651) - 0.000130712410652017*std::sin(0.317039847373962*x_36 - 4.27767992019653) - 0.00380641690391296*std::sin(0.322799831628799*x_36 - 7.46775960922241) - 0.00514644712240355*std::sin(0.331679850816727*x_36 + 5.1483998298645) + 0.00307947866982191*std::sin(0.352559864521027*x_36 + 5.15791988372803) + 0.0053088956957677*std::sin(0.353839844465256*x_36 + 5.14800024032593) + 0.0043346979635538*std::sin(0.26335996389389*x_37 + 1.8458399772644) - 0.00794090505515786*std::sin(0.267279952764511*x_37 + 5.08191967010498) - 0.00448259517776887*std::sin(0.292879939079285*x_37 + 5.11407995223999) - 0.0044664471672757*std::sin(0.317519843578339*x_37 + 5.12696027755737) - 0.00860239096182004*std::sin(0.225279986858368*x_38 + 5.02023983001709) - 0.00074189114577497*std::sin(0.474399864673615*x_39 - 7.7836799621582) - 0.000155636183842304*std::sin(0.256319969892502*x_41 - 4.32304000854492) - 0.00561456821149431*std::sin(0.295359939336777*x_41 - 4.28927993774414) - 1.77251180939852e-5*std::sin(0.333999842405319*x_41 + 5.13104009628296) - 0.000668643786992671*std::sin(0.360479861497879*x_41 + 4.78455972671509) - 0.0090240590300131*std::sin(0.363999843597412*x_41 - 1.21383988857269) + 0.00159391838147432*std::sin(0.465279847383499*x_41 - 4.34639978408813) + 0.0157412253693024*std::sin(0.198400005698204*x_42 + 5.00551986694336) - 9.48346672958868e-6*std::sin(0.403279840946198*x_42 + 8.20879936218262) + 7.71952068664665e-5*std::sin(0.409599870443344*x_42 + 2.00727987289429) + 0.000178416769588751*std::sin(0.189600005745888*x_43 - 7.60376024246216) + 0.00652843012551928*std::sin(0.236559987068176*x_43 - 7.55200004577637) - 0.00308538473043807*std::sin(0.26199996471405*x_43 + 5.06319952011108) + 0.000586387495257091*std::sin(0.337439835071564*x_43 + 5.13944005966187) + 0.000118346473506354*std::sin(0.356799840927124*x_43 + 5.16048002243042) - 0.00620690264720714*std::sin(0.373679846525192*x_43 - 1.21103978157043) - 0.01560927126669*std::sin(0.294879943132401*x_47 - 7.48031997680664) - 0.0136303471654859*std::sin(0.32711985707283*x_47 + 8.3133602142334) + 7.07932766977854e-5*std::sin(1.76415991783142*x_49 - 7.41623973846436) - 0.0190367348504346*std::sin(0.285839945077896*x_50 + 5.09280014038086) + 0.00850458936987699*std::sin(0.399759829044342*x_50 - 1.19031989574432) + 1.50545695750696e-5*std::sin(0.254639983177185*x_51 + 1.83439981937408) - 0.0126782049575644*std::sin(0.335119843482971*x_51 + 5.13655996322632) - 0.000397045756054689*std::sin(0.477919846773148*x_51 + 8.44704055786133) + 0.000160729114667356*std::sin(0.26639997959137*x_52 + 8.27744007110596) - 0.00244683344132587*std::sin(0.409919857978821*x_52 + 5.20424032211304) - 0.00518393398924148*std::sin(0.597679853439331*x_52 + 2.00543975830078) - 0.0218464328699461*std::sin(0.166960015892982*x_53 - 7.6497597694397) + 0.00451781314580247*std::sin(0.383759826421738*x_54 - 7.42215967178345) - 3.82119844581095e-6*std::sin(0.454879850149155*x_54 - 1.15599977970123) + 0.00136746229168653*std::sin(0.460639864206314*x_54 - 1.13079988956451) - 0.000242237138308753*std::sin(0.331519842147827*x_55 - 4.2804799079895) + 0.00331766029105159*std::sin(0.330559849739075*x_57 + 1.92791974544525) - 0.00256891595722764*std::sin(0.350719839334488*x_58 - 7.43415975570679) + 0.00830397392279262*std::sin(0.320719838142395*x_59 - 4.28952026367188) - 7.80814230707427e-5*std::sin(1.39943981170654*x_6 - 5.19679975509644) + 0.010284048462996*std::sin(0.305039942264557*x_62 - 4.27687978744507) + 0.0611589625215958*std::sin(0.130960047245026*x_64 + 4.91191959381104) + 0.00705048418605959*std::sin(0.186400011181831*x_64 - 4.42831993103027) + 0.0124771805386977*std::sin(0.220399990677834*x_65 + 5.01191997528076) - 0.00492723341830534*std::sin(0.306479841470718*x_67 - 7.49200010299683) - 0.0154326231716693*std::sin(0.14544004201889*x_68 + 4.9206395149231) - 3.32405758919645e-5*std::sin(0.167200013995171*x_71 - 4.45599985122681) - 2.39125472202294e-5*std::sin(0.207039996981621*x_73 - 7.59656000137329) + 0.000301884719207483*std::sin(0.250639975070953*x_73 - 7.52424001693726) + 0.00958912106301397*std::sin(0.23735998570919*x_75 - 7.56728029251099) + 0.00245616225328974*std::sin(0.269359946250916*x_75 + 5.09375953674316) + 0.0209723284586643*std::sin(0.171120017766953*x_76 - 7.64520025253296) + 0.000262410392741088*std::sin(0.22223998606205*x_76 - 7.56864023208618) - 0.0240733433708654*std::sin(0.242639973759651*x_79 + 1.85583996772766) + 0.000152972506339526*std::sin(0.243519976735115*x_79 - 7.54839992523193) - 0.0855147612168699*std::sin(0.134880036115646*x_80 + 4.91583967208862) - 0.0457294870611734*std::sin(0.182960003614426*x_80 - 7.60896015167236) + 0.0054519100816908*std::sin(0.281279861927032*x_84 - 1.29047977924347) - 0.00222415627072275*std::sin(0.295519828796387*x_85 - 1.26815986633301) + 8.73015663420847e-5*std::sin(0.157360032200813*x_86 - 7.64720010757446) - 0.0310692391693568*std::sin(0.173280015587807*x_86 - 7.63872003555298) + 0.000133876345334044*std::sin(0.364959836006165*x_86 + 1.95703983306885) - 0.0286731477962263*std::sin(0.184800013899803*x_88 - 7.60400009155273) + 0.0098288722112112*std::sin(0.214479997754097*x_88 + 5.01127958297729) - 0.0105443492674162*std::sin(0.314479917287827*x_9 + 8.34624004364014) - 0.00259006679099372*std::sin(0.356559842824936*x_9 - 4.25672006607056) - 0.000145443904423338*std::sin(0.336159855127335*x_92 + 5.19160032272339) + 0.00956564968014542*std::sin(0.361919850111008*x_92 - 7.40287971496582) + 0.00356238976738646*std::sin(0.367439836263657*x_92 + 1.98079979419708) + 0.00709623146829941*std::sin(0.367679834365845*x_92 - 1.3977597951889) - 4.13741640793012e-5*std::sin(0.392559856176376*x_92 + 1.97831988334656) - 0.00324453426751053*std::sin(0.345039844512939*x_93 - 1.42127990722656) + 0.0176574707713764*std::sin(0.361599832773209*x_93 - 7.40575981140137) + 0.000123702126987921*std::sin(0.409999877214432*x_93 + 1.99575984477997) + 0.00728191393728449*std::sin(0.422959864139557*x_93 - 7.60512018203735) + 0.00536752754633014*std::sin(0.36983984708786*x_94 + 5.17535972595215) + 0.00106998776732678*std::sin(0.379439830780029*x_94 + 4.98119974136353) + 0.00345076186800538*std::sin(0.398239850997925*x_94 + 5.19799995422363) + 0.00196895816742043*std::sin(0.328559845685959*x_95 + 1.94279980659485) - 0.00322343538543563*std::sin(0.344959855079651*x_95 - 7.42527961730957) + 2.16444016681125e-5*std::sin(0.373599827289581*x_95 - 7.42496013641357) + 0.00618214485657828*std::sin(0.386799842119217*x_95 + 8.18487930297852) - 0.00523125363181658*std::sin(0.343759834766388*x_96 - 4.42055988311768) - 0.00214127074373382*std::sin(0.346959829330444*x_96 + 1.94447982311249) - 4.34563378325372e-5*std::sin(0.42103984951973*x_96 - 1.15919995307922) + 4.28553776935057e-5*std::sin(0.449839860200882*x_96 + 8.23176002502441) - 0.00343081249340338*std::sin(0.312559932470322*x_97 + 1.90231990814209) + 0.0035785120010307*std::sin(0.371679842472076*x_97 - 7.43088006973267) - 0.00941800951786509*std::sin(0.411359876394272*x_97 + 8.21576023101807) + 0.000173684928481417*std::sin(0.411279857158661*x_98 + 5.21224021911621) + 0.00742811698094746*std::sin(0.463359862565994*x_98 + 2.01143980026245) - 0.00594955021528471*std::sin(0.33247983455658*x_99 - 7.45544004440308) - 0.00192486033234787*std::sin(0.396479845046997*x_99 + 2.0019998550415) + 0.00407316352486924*std::sin(0.39743983745575*x_99 - 7.39287996292114) - 0.00625146084011371*std::sin(0.468479871749878*x_99 + 8.24679946899414) + 0.0132564877472188);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (5.27023691197519e-5*x_1 - 0.000167369262269288*x_10 + 7.20429749122167e-5*x_100 + 0.000719976178345257*x_101 - 3.22177310401426e-5*x_102 + 0.000569659684875712*x_103 + 0.00138395025313211*x_104 + 0.0005391580022668*x_105 - 8.21352206696107e-5*x_106 - 5.20934465554275e-7*x_107 + 1.43016025864925e-6*x_108 - 0.000283431278693687*x_109 + 0.000191787342760779*x_11 - 0.000135619918557586*x_110 - 0.000210456903591779*x_111 + 0.000248459810558709*x_112 + 4.36955292608388e-5*x_113 - 0.000165795273435235*x_114 - 7.89474426560432e-6*x_115 - 0.000117574698492148*x_116 + 6.12306633673404e-5*x_117 + 4.70428581035836e-6*x_118 + 0.00072198920386341*x_119 + 0.000801885725580074*x_12 - 0.000455788367198013*x_120 - 6.72138680607911e-6*x_13 + 3.43645078291237e-5*x_14 + 4.61473714394286e-5*x_15 + 0.000441192602397905*x_16 - 0.000550959072544538*x_17 + 0.000381938825233442*x_18 - 0.000227704024737782*x_19 + 0.000886691465155501*x_2 + 0.00308828879218242*x_20 + 0.000148853874757974*x_21 - 0.000807813204441752*x_22 + 3.51654770676311e-5*x_23 - 1.84355232526498e-5*x_24 - 0.000299664494908398*x_25 - 1.30791732503524e-5*x_26 - 0.000684978371605547*x_27 + 0.000798118400807139*x_28 - 0.00221506203210326*x_29 + 0.000265505612504692*x_3 - 0.00207325801722421*x_30 + 0.00136930652151615*x_31 - 0.00103968123739756*x_32 + 0.00014006448941059*x_33 - 0.000558070611394812*x_34 - 0.000119540006968092*x_35 - 1.85291523090682e-5*x_36 - 5.36186681705515e-5*x_37 - 9.78151531257877e-5*x_38 - 0.000406285820750485*x_39 + 0.00304472419339136*x_4 - 0.000224778007766693*x_40 - 7.50684525947773e-5*x_41 + 0.000313283350302492*x_42 + 2.90118850389836e-5*x_43 - 0.00108688997032382*x_44 - 0.00067173465189582*x_45 - 0.000168756462758171*x_46 + 0.000273360717481604*x_47 - 0.00168661068197744*x_48 - 3.01132392992101e-5*x_49 - 0.000177358556893559*x_5 + 3.01659098376892e-5*x_50 + 0.00020222131706879*x_51 - 4.41886422273198e-5*x_52 - 0.00019191815079393*x_53 - 0.000150309906449761*x_54 + 0.000466863549671708*x_55 + 0.000150478597770016*x_56 - 0.000119530097955118*x_57 - 0.000382206647166781*x_58 - 0.000476065193558726*x_59 + 0.000530975147020256*x_6 - 0.000948446031536092*x_60 - 0.0012066522694304*x_61 - 0.0015047839829042*x_62 - 0.00164078128450548*x_63 + 0.000411952584609531*x_64 - 0.000522750535436003*x_65 + 0.000167404282615041*x_66 + 0.000175111841443582*x_67 + 0.000325326516863564*x_68 - 5.46956397211705e-6*x_69 + 0.00148539287857989*x_7 + 0.00114099182107953*x_70 - 0.000893162957190269*x_71 - 0.00158226817931584*x_72 + 3.00022523151573e-5*x_73 - 0.000347493366481198*x_74 + 0.000142443271397472*x_75 - 0.00232920643111079*x_76 - 0.000668618410724789*x_77 + 0.000827448317067786*x_78 - 0.00133315071249926*x_79 + 0.000205784623950319*x_8 + 0.00019158734709775*x_80 - 0.000308667685512468*x_81 - 0.000166184508941587*x_82 - 0.000961124522407702*x_83 - 0.000199374996349666*x_84 + 4.07605467594401e-5*x_85 + 0.000880054828756432*x_86 - 0.00016597995133974*x_87 + 0.00128898606170737*x_88 - 0.00010518321284555*x_89 + 0.000380536495506318*x_9 + 2.87760966632186e-6*x_90 - 0.00179544704207877*x_91 + 0.00203216477504929*x_92 - 6.08517035378727e-5*x_93 - 5.3842880878446e-5*x_94 + 0.000408580868719639*x_95 - 3.77605304658376e-6*x_96 + 0.000329193986354691*x_97 + 6.57219062539916e-5*x_98 + 3.8484784060404e-8*x_99 - 1.07456176224212e-5*std::pow(-5.55215978622437*x_100 - 7.38375997543335, 2) - 3.53368792587218e-7*std::pow(-9.58480072021484*x_106 - 7.96384000778198, 2) - 4.51351015392227e-7*std::pow(-7.98799991607666*x_106 - 8.19944000244141, 2) - 7.46651471797975e-6*std::pow(-5.86383962631226*x_106 - 8.48952007293701, 2) - 3.47347948174186e-8*std::pow(-8.6636791229248*x_108 - 6.04663944244385, 2) - 6.5250864633359e-7*std::pow(-8.47000026702881*x_116 - 8.86903953552246, 2) - 1.97513837329825e-5*std::pow(-6.09335994720459*x_13 - 9.55160045623779, 2) - 7.5201066405068e-7*std::pow(-5.10199975967407*x_14 - 7.75728034973145, 2) - 1.9541470300782e-6*std::pow(-3.51191973686218*x_14 - 6.0479998588562, 2) + 4.66723822791039e-6*std::pow(-5.32231998443604*x_15 - 8.46951961517334, 2) - 5.37600184954054e-7*std::pow(-5.82096004486084*x_17 - 9.23791980743408, 2) + 5.0010328232216e-7*std::pow(-5.46256017684937*x_17 - 8.0926399230957, 2) + 1.45123597573896e-7*std::pow(-6.85031986236572*x_18 - 7.45431995391846, 2) - 9.35590420477494e-7*std::pow(-5.03071975708008*x_18 - 7.24015998840332, 2) + 3.0098058739479e-5*std::pow(-3.47519993782043*x_18 - 4.50079965591431, 2) + 4.21508318787511e-6*std::pow(-5.71983957290649*x_22 - 9.39935970306396, 2) - 3.46330512752133e-5*std::pow(-4.98327970504761*x_22 - 7.76327991485596, 2) + 2.27586378919809e-6*std::pow(-5.90136003494263*x_23 - 8.54720020294189, 2) + 4.00403941498296e-6*std::pow(-4.40399980545044*x_23 - 9.9993200302124, 2) + 6.49369011479975e-7*std::pow(-3.78287982940674*x_38 - 6.56720018386841, 2) + 1.14709592757248e-6*std::pow(-5.15136003494263*x_40 - 5.74847984313965, 2) - 1.43608203631569e-6*std::pow(-5.46367979049683*x_47 - 7.07823991775513, 2) - 3.54846124282044e-7*std::pow(-4.93391990661621*x_49 - 8.67199993133545, 2) + 7.43653293200076e-6*std::pow(-0.788719892501831*x_49 - 1.1847198009491, 2) + 9.89049392526716e-5*std::pow(-3.3374400138855*x_5 - 5.49232006072998, 2) + 1.0281970250048e-6*std::pow(-9.99993991851807*x_50 - 7.19999980926514, 2) - 2.55491582033712e-7*std::pow(-7.36400032043457*x_54 - 9.79903984069824, 2) - 2.97121066886211e-8*std::pow(-8.16296005249023*x_55 - 7.95711994171143, 2) + 1.18367071330675e-5*std::pow(-6.19600009918213*x_57 - 9.98884010314941, 2) + 1.01517889092405e-6*std::pow(-6.60400009155273*x_64 - 9.96195983886719, 2) + 1.00284838162484e-7*std::pow(-6.08367967605591*x_66 - 9.94783973693848, 2) + 1.76299909312382e-7*std::pow(-3.43055987358093*x_67 - 6.46231985092163, 2) - 1.00504481808683e-6*std::pow(-3.24863982200623*x_68 - 5.47495985031128, 2) + 1.01168274875662e-7*std::pow(-7.40719985961914*x_69 - 9.41207981109619, 2) + 2.61870456279059e-6*std::pow(-6.92199993133545*x_69 - 9.16287994384766, 2) - 6.19564405575027e-7*std::pow(-5.7707200050354*x_7 - 9.56975936889648, 2) + 5.83343398140956e-7*std::pow(-5.54423999786377*x_7 - 8.90136051177979, 2) + 4.45778878908135e-6*std::pow(-2.79311990737915*x_7 - 4.79031991958618, 2) + 7.26175532732026e-8*std::pow(-7.34127998352051*x_70 - 7.9312801361084, 2) - 2.9362346087917e-7*std::pow(-4.89879989624023*x_70 - 7.14247989654541, 2) + 2.08070027336205e-5*std::pow(-4.69727993011475*x_72 - 5.92263984680176, 2) + 1.02246539527149e-5*std::pow(-5.50311994552612*x_73 - 8.97648048400879, 2) + 8.79667135902472e-6*std::pow(-4.92944002151489*x_74 - 6.36568021774292, 2) - 1.222401803433e-6*std::pow(-4.72591972351074*x_79 - 6.36720037460327, 2) - 9.88843135658972e-6*std::pow(-5.28800010681152*x_82 - 7.51375961303711, 2) + 1.27705623863512e-5*std::pow(-4.89039993286133*x_84 - 8.17303943634033, 2) - 1.82182563544232e-7*std::pow(-5.33200025558472*x_85 - 8.39999961853027, 2) - 1.80717823870205e-7*std::pow(-5.09136009216309*x_85 - 8.60568046569824, 2) - 4.35451229861411e-7*std::pow(-6.66607999801636*x_86 - 8.43383884429932, 2) - 1.1985316566914e-6*std::pow(-5.27888011932373*x_86 - 8.12639999389648, 2) + 1.05522780555904e-5*std::pow(-7.70527982711792*x_87 - 8.48975944519043, 2) - 4.96083172379649e-7*std::pow(-8.80000019073486*x_88 - 9.99983978271484, 2) + 6.67032849529164e-6*std::pow(-4.33304023742676*x_90 - 5.97864007949829, 2) - 4.68383979648894e-5*std::exp(0.649039804935455*x_22) - 0.000130369340579758*std::exp(0.715519845485687*x_22) - 0.00113525365545156*std::exp(0.543359875679016*x_67) - 4.33988300434779e-5*std::exp(0.656719863414764*x_69) - 0.0232199359755122*std::sin(0.217519998550415*x_1 + 1.81207990646362) - 0.00128054040236876*std::sin(0.322799921035767*x_1 + 1.95039975643158) + 0.0223003952106422*std::sin(0.269199937582016*x_10 + 5.06816005706787) - 0.00123655430619858*std::sin(0.183680012822151*x_102 + 1.7850399017334) - 0.000150883923740515*std::sin(0.315999835729599*x_102 - 4.44975996017456) + 0.000188851226233351*std::sin(0.324799835681915*x_102 + 5.12800025939941) + 0.00251557732662336*std::sin(0.467919856309891*x_102 + 5.0220799446106) - 0.00239123733386045*std::sin(0.178960010409355*x_103 - 7.6241602897644) - 0.0082194027001243*std::sin(0.366719841957092*x_103 - 7.41215991973877) + 4.54429677710718e-5*std::sin(0.418079853057861*x_103 - 1.19207990169525) + 7.91775754650228e-5*std::sin(0.451519846916199*x_104 - 1.14063990116119) - 0.0105017739001758*std::sin(0.308159917593002*x_107 + 1.90919995307922) + 0.00101370901204404*std::sin(0.410559862852097*x_107 + 5.20783996582031) + 2.25799689584127e-5*std::sin(1.69463980197906*x_107 - 6.01591968536377) - 9.81803015515062e-5*std::sin(0.330799847841263*x_110 - 4.43279981613159) - 0.00400789170863903*std::sin(0.303359925746918*x_111 - 7.49376010894775) + 0.0137594766944096*std::sin(0.141760036349297*x_112 + 8.10503959655762) + 0.000277060023303733*std::sin(0.270639955997467*x_112 - 7.53815984725952) + 0.00915979816930478*std::sin(0.362479835748672*x_112 - 7.42967987060547) + 0.00343414105959069*std::sin(0.271599948406219*x_113 + 5.0623197555542) - 0.000215528061914478*std::sin(0.20720000565052*x_115 - 1.37271988391876) + 0.00249242285801197*std::sin(0.269599944353104*x_115 + 1.86295986175537) - 0.00234716454670552*std::sin(0.457519859075546*x_115 - 1.14735984802246) + 0.00028141873667985*std::sin(0.189600005745888*x_117 + 8.18416023254395) - 0.0115342106793491*std::sin(0.350239843130112*x_117 - 7.43336009979248) + 0.000129798803144664*std::sin(1.79807984828949*x_117 + 8.98896026611328) - 0.0017517099479295*std::sin(0.238799974322319*x_118 - 1.3614399433136) + 0.00094683635814205*std::sin(0.279519945383072*x_118 + 1.8647198677063) - 0.000402139305547018*std::sin(0.373199850320816*x_119 + 1.97575974464417) + 8.97013670716093e-5*std::sin(0.398399829864502*x_119 + 8.18903923034668) + 0.000121891338948504*std::sin(0.3572798371315*x_12 - 1.03671979904175) + 0.0074554615307948*std::sin(0.416479855775833*x_12 - 4.17271995544434) + 0.0185733224815788*std::sin(0.328719854354858*x_120 - 7.45576000213623) + 0.000199794000309543*std::sin(0.330799847841263*x_120 + 5.12911987304688) - 0.0969079552246764*std::sin(0.126080051064491*x_13 + 8.07575988769531) + 0.000300297362692791*std::sin(0.165200024843216*x_13 + 4.96023941040039) - 0.0116924528998202*std::sin(0.182000011205673*x_14 + 8.18039894104004) - 0.00153698880270401*std::sin(1.16935980319977*x_15 + 5.98727989196777) + 0.000582592133552868*std::sin(0.345759838819504*x_16 + 5.15791988372803) + 0.0129307324761676*std::sin(0.358719855546951*x_16 + 8.34712028503418) + 0.00015985191228125*std::sin(0.402959853410721*x_16 + 1.97447979450226) - 9.74373748984524e-6*std::sin(1.44519984722137*x_16 - 3.38727998733521) + 9.52780149718435e-5*std::sin(0.412719875574112*x_18 - 7.16936016082764) + 3.63721211778869e-5*std::sin(1.47319984436035*x_2 - 3.38879990577698) + 0.00568107976155141*std::sin(0.243679970502853*x_21 + 8.26344013214111) - 0.000150683003080705*std::sin(0.363679856061935*x_21 + 5.15895986557007) - 0.00112061641840211*std::sin(0.179360017180443*x_23 - 7.61696004867554) - 0.000414504670293998*std::sin(0.390239834785461*x_23 + 1.97439980506897) + 0.0151597209958093*std::sin(0.209600001573563*x_24 - 4.37680006027222) - 0.00769432597949378*std::sin(0.271279960870743*x_24 + 1.85807991027832) + 0.0027476422908658*std::sin(0.333439826965332*x_24 + 5.13248014450073) + 0.000103159198396309*std::sin(0.547119855880737*x_24 + 8.55247974395752) + 1.93119093538671e-5*std::sin(1.16631984710693*x_25 - 8.98752021789551) - 0.00277953752435031*std::sin(0.338239848613739*x_26 - 7.44767951965332) + 0.000312528382743828*std::sin(0.339359849691391*x_26 + 8.35319995880127) + 0.000528168773449267*std::sin(0.353679865598679*x_26 + 1.9618399143219) + 0.0270255284866624*std::sin(0.32687982916832*x_27 + 8.30775928497314) - 0.000586360816049015*std::sin(0.378799855709076*x_27 - 7.41504001617432) + 0.00074503091290774*std::sin(0.136960044503212*x_28 + 8.09280014038086) - 0.0288923930960487*std::sin(0.19055999815464*x_28 - 4.42063999176025) - 3.94633823705599e-5*std::sin(0.457199841737747*x_28 - 7.13647985458374) - 0.000432182078669812*std::sin(0.300159931182861*x_3 - 1.0843198299408) + 0.00131551832282763*std::sin(0.359999865293503*x_3 - 1.0461597442627) - 0.000200423159222131*std::sin(0.281439960002899*x_30 - 7.52135992050171) + 0.00594327150214172*std::sin(0.283119946718216*x_33 - 1.17807984352112) + 0.000443347280968655*std::sin(0.292399942874908*x_33 + 8.20679950714111) - 0.0243626207893681*std::sin(0.303599923849106*x_33 - 1.19399988651276) - 0.0013376970823569*std::sin(0.328159838914871*x_34 - 7.41232013702393) - 0.000395173107330849*std::sin(0.341119825839996*x_34 - 1.19039988517761) - 0.00930802108192128*std::sin(0.355279833078384*x_34 + 1.97823989391327) + 0.000105034965916977*std::sin(0.384159833192825*x_34 - 1.19863986968994) - 0.00089906861520002*std::sin(0.321279853582382*x_35 + 1.77135992050171) - 0.000161265555497769*std::sin(0.322319835424423*x_35 - 4.42935991287231) + 0.00219903147379024*std::sin(0.346479833126068*x_35 + 8.19127941131592) - 0.000280901104002472*std::sin(0.285039931535721*x_36 - 7.51999998092651) - 0.00291218149246041*std::sin(0.317039847373962*x_36 - 4.27767992019653) + 0.0011851845917913*std::sin(0.322799831628799*x_36 - 7.46775960922241) - 0.00574484249172865*std::sin(0.331679850816727*x_36 + 5.1483998298645) + 0.0165996373511498*std::sin(0.352559864521027*x_36 + 5.15791988372803) - 0.0013496727673713*std::sin(0.26335996389389*x_37 + 1.8458399772644) - 5.15306198045042e-5*std::sin(0.292879939079285*x_37 + 5.11407995223999) - 0.0240759593340956*std::sin(0.317519843578339*x_37 + 5.12696027755737) - 0.0463703716211418*std::sin(0.225279986858368*x_38 + 5.02023983001709) - 0.000828153418682128*std::sin(0.474399864673615*x_39 - 7.7836799621582) - 0.00346746580437065*std::sin(0.256319969892502*x_41 - 4.32304000854492) - 0.0062673936537091*std::sin(0.295359939336777*x_41 - 4.28927993774414) + 0.000248927057444502*std::sin(0.333999842405319*x_41 + 5.13104009628296) + 0.000208192201155383*std::sin(0.360479861497879*x_41 + 4.78455972671509) - 0.000103737976892319*std::sin(0.363999843597412*x_41 - 1.21383988857269) + 0.000133183398545051*std::sin(0.403279840946198*x_42 + 8.20879936218262) + 0.00171985545689044*std::sin(0.409599870443344*x_42 + 2.00727987289429) + 0.00211255967656197*std::sin(0.189600005745888*x_43 - 7.60376024246216) + 0.000960680486287314*std::sin(0.26199996471405*x_43 + 5.06319952011108) + 0.00316086611149663*std::sin(0.337439835071564*x_43 + 5.13944005966187) + 0.00263667702342877*std::sin(0.356799840927124*x_43 + 5.16048002243042) - 0.00692860088165938*std::sin(0.373679846525192*x_43 - 1.21103978157043) - 0.000349174152327238*std::sin(0.32711985707283*x_47 + 8.3133602142334) + 0.000381604435711452*std::sin(1.76415991783142*x_49 - 7.41623973846436) - 0.000218840806941921*std::sin(0.285839945077896*x_50 + 5.09280014038086) + 0.00949344765908236*std::sin(0.399759829044342*x_50 - 1.19031989574432) - 0.000211422552196549*std::sin(0.254639983177185*x_51 + 1.83439981937408) - 0.00214023744567846*std::sin(0.477919846773148*x_51 + 8.44704055786133) + 0.00358093275687436*std::sin(0.26639997959137*x_52 + 8.27744007110596) - 0.000132798947410319*std::sin(0.597679853439331*x_52 + 2.00543975830078) - 0.000251140284067798*std::sin(0.166960015892982*x_53 - 7.6497597694397) + 5.36639406284124e-5*std::sin(0.454879850149155*x_54 - 1.15599977970123) + 0.00737117563301106*std::sin(0.460639864206314*x_54 - 1.13079988956451) - 0.00539687476843603*std::sin(0.331519842147827*x_55 - 4.2804799079895) + 9.54600864258567e-5*std::sin(0.320719838142395*x_59 - 4.28952026367188) + 0.000118222451589196*std::sin(0.305039942264557*x_62 - 4.27687978744507) + 0.000703065773364552*std::sin(0.130960047245026*x_64 + 4.91191959381104) + 0.0380049655110533*std::sin(0.186400011181831*x_64 - 4.42831993103027) + 0.000143434064659796*std::sin(0.220399990677834*x_65 + 5.01191997528076) - 0.0831880897689337*std::sin(0.14544004201889*x_68 + 4.9206395149231) + 0.000466822206806915*std::sin(0.167200013995171*x_71 - 4.45599985122681) + 0.000335821740874848*std::sin(0.207039996981621*x_73 - 7.59656000137329) + 0.00672578133742092*std::sin(0.250639975070953*x_73 - 7.52424001693726) + 0.000110233766860804*std::sin(0.23735998570919*x_75 - 7.56728029251099) - 0.00076476269705137*std::sin(0.269359946250916*x_75 + 5.09375953674316) + 0.0234108542872886*std::sin(0.171120017766953*x_76 - 7.64520025253296) + 0.00584632083027128*std::sin(0.22223998606205*x_76 - 7.56864023208618) - 0.000276740204161107*std::sin(0.242639973759651*x_79 + 1.85583996772766) + 0.00181128460772153*std::sin(0.243519976735115*x_79 - 7.54839992523193) - 0.00219066645162023*std::sin(0.134880036115646*x_80 + 4.91583967208862) - 0.0005256929787662*std::sin(0.182960003614426*x_80 - 7.60896015167236) - 0.00122604102859012*std::sin(0.157360032200813*x_86 - 7.64720010757446) + 0.0029826717540843*std::sin(0.364959836006165*x_86 + 1.95703983306885) - 0.0139615090914848*std::sin(0.356559842824936*x_9 - 4.25672006607056) - 0.00324038891594177*std::sin(0.336159855127335*x_92 + 5.19160032272339) - 0.00110920310855103*std::sin(0.367439836263657*x_92 + 1.98079979419708) + 8.15762279072684e-5*std::sin(0.367679834365845*x_92 - 1.3977597951889) + 0.000581048253889*std::sin(0.392559856176376*x_92 + 1.97831988334656) + 0.000452338617203412*std::sin(0.361599832773209*x_93 - 7.40575981140137) + 0.0027559972537822*std::sin(0.409999877214432*x_93 + 1.99575984477997) + 8.37107799545034e-5*std::sin(0.422959864139557*x_93 - 7.60512018203735) + 0.00576766745678357*std::sin(0.379439830780029*x_94 + 4.98119974136353) + 8.83995715967506e-5*std::sin(0.398239850997925*x_94 + 5.19799995422363) + 0.00100366461370163*std::sin(0.344959855079651*x_95 - 7.42527961730957) - 0.000303968480707523*std::sin(0.373599827289581*x_95 - 7.42496013641357) + 0.000158370521575998*std::sin(0.386799842119217*x_95 + 8.18487930297852) - 6.01369812154765e-5*std::sin(0.343759834766388*x_96 - 4.42055988311768) - 0.0115423166151249*std::sin(0.346959829330444*x_96 + 1.94447982311249) - 0.000514548644769659*std::sin(0.42103984951973*x_96 - 1.15919995307922) + 0.000954787974216753*std::sin(0.449839860200882*x_96 + 8.23176002502441) - 0.0184934689655063*std::sin(0.312559932470322*x_97 + 1.90231990814209) - 0.0011142230061037*std::sin(0.371679842472076*x_97 - 7.43088006973267) - 0.000108266717946604*std::sin(0.411359876394272*x_97 + 8.21576023101807) + 0.00386957926733857*std::sin(0.411279857158661*x_98 + 5.21224021911621) + 0.000190289096728039*std::sin(0.463359862565994*x_98 + 2.01143980026245) - 0.0103757768422654*std::sin(0.396479845046997*x_99 + 2.0019998550415) - 7.18649886950055e-5*std::sin(0.468479871749878*x_99 + 8.24679946899414) + 0.128663629293442*std::sin(-0.0121933438596939*x_1 + 0.0652019290975544*x_10 + 0.00172209080161242*x_100 - 8.19073323263742e-5*x_104 + 0.000528232558469187*x_105 + 0.00178442211663566*x_107 + 0.000568809911670868*x_109 - 0.00103271913644521*x_11 + 0.000500847867384408*x_111 + 0.00142212309707033*x_113 + 0.000260354776142334*x_115 - 0.0254229985492261*x_116 + 0.00115599164612054*x_117 + 0.000119246442113407*x_118 + 0.00110722990697131*x_119 + 0.049232242691047*x_12 - 0.00502470522742826*x_120 + 0.000190432090910103*x_16 - 0.0327658912732165*x_17 - 0.00061386995076367*x_18 - 0.00305210298263002*x_19 + 0.0288611048001473*x_2 - 0.00112211188296074*x_20 - 0.0172299823777786*x_21 - 0.00349562671536685*x_23 + 0.00609591820640363*x_25 + 0.0121290330200383*x_26 + 0.000182449296314075*x_27 - 0.00346086067850691*x_28 + 0.039596779262052*x_29 - 0.00119353955341374*x_3 - 0.00417114328795942*x_31 - 0.00105692274287818*x_32 + 0.00227451808205998*x_35 - 0.00535201513162784*x_38 - 0.00279757289707606*x_39 - 0.0545991981505905*x_4 + 0.000647020398695937*x_40 - 6.12132396359845e-5*x_43 - 0.00620810844778732*x_44 + 0.000243826361455131*x_45 + 0.000451234248580188*x_46 - 0.0106823282368732*x_48 - 0.00636853533069483*x_49 - 0.00700669090902062*x_5 + 0.000175680734096282*x_50 - 0.000208899580148374*x_54 + 0.00034807273796987*x_55 + 0.000282041745724354*x_56 + 0.0121615879633635*x_57 - 0.0110911283061876*x_59 - 0.00689414866316783*x_6 + 0.0229443921284138*x_60 + 0.0135659234926108*x_61 - 0.00941623396696941*x_62 + 0.0026252362951068*x_63 - 0.000225438345605458*x_64 + 0.000102015219216406*x_65 + 0.000654304429306082*x_66 - 0.000220861520344897*x_68 - 0.00448644656796558*x_69 + 0.00775309373782036*x_72 + 0.00538245609347145*x_73 - 0.00126203931722328*x_74 + 0.0247078227151356*x_75 - 0.000788690610144299*x_76 + 0.000740585343285888*x_79 - 0.0205703943085452*x_8 - 0.00273173546072378*x_80 + 0.0101823072594299*x_81 + 0.00824632728393181*x_82 - 0.000989394893776682*x_83 - 0.000321196103533619*x_85 + 0.000428123729468208*x_87 - 0.00133682010473699*x_89 + 0.00629380755280318*x_90 + 0.0604435442302595*x_91 - 0.000321397083346281*x_92 + 0.00274346244219235*x_93 + 0.00128321214410388*x_95 + 0.00262497307326464*x_96 - 0.00137950615320433*x_97 + 0.00133353382504181*x_98 - 7.8307876130862e-5*std::pow(-6.71752023696899*x_106 - 9.56103992462158, 2) + 0.00057196838204493*std::pow(-4.07000017166138*x_13 - 6.52231979370117, 2) - 0.000306409685867148*std::pow(-5.3167200088501*x_22 - 8.58440017700195, 2) + 0.000242250508206504*std::pow(-5.77959966659546*x_24 - 8.97016048431396, 2) - 0.000191879697867436*std::pow(-4.79911994934082*x_36 - 3.79999995231628, 2) + 0.000433301259894714*std::pow(-4.51688003540039*x_53 - 6.4747200012207, 2) + 0.000742072496618729*std::pow(-3.92007994651794*x_58 - 5.68487977981567, 2) - 0.00062530648709902*std::pow(-6.09127998352051*x_7 - 9.73591995239258, 2) - 0.000113911194714517*std::pow(-8.72799968719482*x_70 - 9.33439922332764, 2) - 0.000195391641395842*std::pow(-5.99983978271484*x_71 - 9.40424060821533, 2) + 4.00994091473393e-5*std::pow(-7.0*x_77 - 9.99993991851807, 2) - 0.000371985692985743*std::pow(-4.67551946640015*x_78 - 6.30359983444214, 2) - 0.158576921389056*std::sin(0.367199838161469*x_101 + 8.17160034179688) - 0.128228761909611*std::sin(0.394879847764969*x_102 + 2.00839972496033) - 0.281614510500162*std::sin(0.323359847068787*x_103 + 5.13160037994385) - 0.166949307237346*std::sin(0.444559872150421*x_108 - 4.1657600402832) + 0.277849605454293*std::sin(0.394479840993881*x_110 + 5.18344020843506) + 0.153507103165268*std::sin(0.398479819297791*x_112 - 4.41079998016357) - 0.0834759077696674*std::sin(0.395199835300446*x_114 - 1.21023988723755) + 0.355280347958058*std::sin(0.205119997262955*x_14 - 4.38215970993042) - 1.03490569427345*std::sin(0.287039935588837*x_15 + 5.13007974624634) + 0.153107225837829*std::sin(0.312719851732254*x_30 - 4.26567983627319) + 0.264024227321386*std::sin(0.285759925842285*x_33 + 8.2041597366333) + 0.118254707137297*std::sin(0.318159908056259*x_34 + 8.25111961364746) + 0.219276457273367*std::sin(0.267279952764511*x_37 + 5.08191967010498) - 0.0440137205324689*std::sin(0.465279847383499*x_41 - 4.34639978408813) - 0.434670872922766*std::sin(0.198400005698204*x_42 + 5.00551986694336) + 0.431027153731748*std::sin(0.294879943132401*x_47 - 7.48031997680664) + 0.35009005250285*std::sin(0.335119843482971*x_51 + 5.13655996322632) + 0.0675657201320448*std::sin(0.409919857978821*x_52 + 5.20424032211304) + 0.136058330961049*std::sin(0.306479841470718*x_67 - 7.49200010299683) - 0.150546508210624*std::sin(0.281279861927032*x_84 - 1.29047977924347) + 0.857931513840526*std::sin(0.173280015587807*x_86 - 7.63872003555298) + 0.791766961569238*std::sin(0.184800013899803*x_88 - 7.60400009155273) + 0.291166754362621*std::sin(0.314479917287827*x_9 + 8.34624004364014) - 0.148216408142545*std::sin(0.36983984708786*x_94 + 5.17535972595215) + 0.164288111306689*std::sin(0.33247983455658*x_99 - 7.45544004440308) + 4.34757610940346) + 0.135158270597458*std::sin(-0.00207937255021442*x_1 + 0.000986902437857078*x_10 + 0.00296127315075838*x_100 + 0.0249846015318885*x_101 - 0.000776203699969104*x_102 + 0.000116875219162345*x_103 - 0.00749819884082337*x_104 - 0.000370867227796419*x_106 - 0.0044423869172254*x_107 - 0.00327403272634987*x_108 - 0.000470556033314181*x_109 + 0.00384044147095902*x_11 + 0.00107578656951254*x_110 + 0.00799925207159757*x_111 + 0.000446133474823147*x_112 + 0.00101092363131687*x_113 + 0.000756094744327157*x_114 - 0.000169183148214715*x_115 + 0.000220151022782077*x_116 + 0.00278722800173347*x_117 + 0.00195811150267435*x_119 + 0.00192489457347793*x_12 - 0.000256148846476198*x_120 + 0.00287004352796181*x_14 + 0.000795840836867898*x_17 + 7.18887324432689e-5*x_18 - 6.70709417958521e-5*x_19 + 0.0428230674541081*x_20 - 0.000192364911099103*x_21 + 0.00466999032484638*x_22 - 0.00470824054291213*x_25 + 0.00105009576959267*x_26 + 0.00191759934756063*x_27 + 0.00102780536740914*x_28 + 0.00723805244691116*x_29 + 0.0133736438610164*x_3 + 0.000319449781829707*x_30 - 0.0350644468549622*x_31 - 0.0067418826676885*x_32 + 0.0223213505700072*x_33 + 0.000213177312246205*x_37 - 0.0123896379444809*x_39 - 0.000758711132843761*x_4 + 0.000860629161293444*x_40 + 0.000254211878242978*x_41 + 0.000294526317987706*x_42 - 0.000997629005645429*x_44 - 0.000676788350124285*x_45 - 5.70374761703707e-5*x_46 + 0.000721422288664335*x_47 - 0.000991406780109673*x_48 + 0.000399314388269601*x_50 + 0.000396390079453183*x_51 - 0.00890763006279767*x_52 - 0.00590393104082596*x_53 + 0.000152440965642109*x_55 + 0.000272717873307585*x_56 - 0.000213657352268249*x_59 - 0.00146792389359781*x_60 + 0.00011229476798798*x_61 + 0.0300351408793741*x_62 + 0.0230668282425794*x_63 - 0.0142387277967991*x_64 - 0.00893609306873979*x_65 + 0.000993005290755168*x_66 + 0.00111633937830649*x_67 + 0.0014344234254907*x_68 - 0.00688294549511716*x_7 + 0.000132479530872233*x_70 - 0.000213587907497205*x_71 + 1.50505706346633e-5*x_73 + 0.00548487047475831*x_74 + 1.76603425347137e-5*x_75 - 0.00107759153934235*x_76 - 0.000361117028075803*x_77 + 0.00927436941405298*x_78 + 0.000724818041670654*x_79 + 0.00162556068146056*x_8 - 0.000378250489023518*x_80 + 0.000839990712404227*x_81 + 0.000798637710760979*x_82 + 0.00217099845225372*x_83 - 0.00045172411369482*x_84 + 0.0163531815388916*x_86 - 0.0102702702548283*x_87 + 0.000145917512987948*x_89 - 0.00144039670148115*x_9 + 0.000328156690064239*x_90 - 0.0391787408670316*x_91 - 0.000147032762184192*x_94 + 0.00568063015726507*x_96 + 0.00256288551461504*x_97 - 1.53844949018897e-5*x_98 + 0.000352436830146831*std::pow(-5.6691198348999*x_15 - 7.42512035369873, 2) + 0.010931664598853*std::pow(-1.34583985805511*x_2 - 2.49487972259521, 2) + 7.45939033287529e-5*std::pow(-5.04120016098022*x_23 - 8.87744045257568, 2) + 0.000120374637200135*std::pow(-5.51895999908447*x_38 - 6.90023994445801, 2) + 0.000114085040092659*std::pow(-7.80000019073486*x_49 - 9.99882030487061, 2) - 0.000112012123210299*std::pow(-5.88295984268188*x_5 - 9.54328060150146, 2) + 0.000115657524051763*std::pow(-6.40399980545044*x_69 - 9.99507999420166, 2) + 0.000242738863963638*std::pow(-5.7838397026062*x_72 - 7.57272005081177, 2) - 0.119385350984794*std::sin(0.310239911079407*x_105 + 1.91767990589142) + 0.235015612568182*std::sin(0.279359966516495*x_118 - 7.5207200050354) + 0.266955084207408*std::sin(0.277359962463379*x_13 - 1.07599985599518) - 0.237122964321808*std::sin(0.292079925537109*x_16 + 8.31447982788086) + 0.56491194830112*std::sin(0.186960011720657*x_24 + 4.96975994110107) - 0.279370001348854*std::sin(0.350879848003387*x_34 + 2.00583982467651) + 0.147585675369848*std::sin(0.291759938001633*x_35 + 8.24959945678711) + 0.195511438648535*std::sin(0.353839844465256*x_36 + 5.14800024032593) + 0.240423402361108*std::sin(0.236559987068176*x_43 - 7.55200004577637) + 0.166378131780827*std::sin(0.383759826421738*x_54 - 7.42215967178345) + 0.122179936020916*std::sin(0.330559849739075*x_57 + 1.92791974544525) - 0.0946058245154742*std::sin(0.350719839334488*x_58 - 7.43415975570679) - 0.00287551540491855*std::sin(1.39943981170654*x_6 - 5.19679975509644) - 0.0819093116888379*std::sin(0.295519828796387*x_85 - 1.26815986633301) + 0.361969241143402*std::sin(0.214479997754097*x_88 + 5.01127958297729) + 0.352275508457261*std::sin(0.361919850111008*x_92 - 7.40287971496582) - 0.119486913802273*std::sin(0.345039844512939*x_93 - 1.42127990722656) + 0.0725110957177102*std::sin(0.328559845685959*x_95 + 1.94279980659485) + 0.150002958474543*std::sin(0.39743983745575*x_99 - 7.39287996292114) + 6.01660034791813) + 0.306929901511501);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (6.61007578175058e-5*x_1 + 0.000556351107333035*x_10 - 0.000495665415620382*x_100 - 0.000397447667958841*x_101 + 4.88476746757692e-5*x_102 - 0.000610073324858923*x_103 - 0.00162657088652269*x_104 - 0.00186167470229436*x_105 - 0.00140272258574835*x_106 + 6.39105344219465e-5*x_107 + 5.96928364933318e-5*x_108 + 0.000690358638756816*x_109 + 0.000499929087494581*x_11 - 0.000155813992175698*x_110 + 5.44569952520514e-5*x_111 + 0.000153179937854286*x_112 + 4.9342593101655e-5*x_113 + 0.000198918596979187*x_114 + 7.4311933633622e-6*x_115 + 0.00128985210932625*x_116 - 2.0843101330795e-5*x_117 + 0.00151834530278659*x_118 + 0.00180015162093099*x_119 + 0.000190447449085501*x_12 + 0.00137228496477258*x_120 + 9.01017949513669e-5*x_13 - 0.000883444760738383*x_14 + 0.00105601956808842*x_15 + 0.000108190872773867*x_16 - 0.00124862098131393*x_17 + 0.000337743828287173*x_18 - 0.000703836191189401*x_19 - 0.00144443610629503*x_2 - 0.00267828562680294*x_20 - 0.000476512255135701*x_21 - 0.00181304995417349*x_22 - 0.000883048759888249*x_23 - 0.000807179937277523*x_24 - 2.58836376133346e-5*x_25 - 0.000510155442718844*x_26 - 0.000863691393642527*x_27 + 0.000105801058336484*x_28 - 0.00296954443794123*x_29 + 0.000385297489467767*x_3 - 0.00206952099705387*x_30 - 0.000129740217253024*x_31 - 0.00188745857150415*x_32 + 8.31577048014874e-5*x_33 - 0.000954354872317359*x_34 + 0.000293325209494049*x_35 + 3.98392743439782e-5*x_36 - 5.5274763652084e-5*x_37 - 0.000303972355585744*x_38 + 0.00122766057262604*x_39 - 0.00521823859706012*x_4 - 0.000888141939192799*x_40 + 4.68945695759675e-5*x_41 + 0.00030026093638714*x_42 - 0.000945513644877942*x_43 + 0.000929331241046501*x_44 + 0.000472257761449193*x_45 - 0.000320495732959478*x_46 - 0.00121410323057583*x_47 + 0.0004120571409139*x_48 + 0.000380040478889248*x_49 - 0.000215386209958799*x_5 - 0.000730428554989875*x_50 - 0.000247519258105602*x_51 - 9.74490330013981e-5*x_52 + 0.000147901517496349*x_53 - 0.000235948912964623*x_54 + 0.000276776365297904*x_55 - 0.000249425307647794*x_56 + 0.00024728691434311*x_57 - 0.000825916915184942*x_58 + 0.000802504964430145*x_59 - 0.000784741772982669*x_6 - 0.00140071393041332*x_60 + 0.000618657826446494*x_61 + 0.000897554524875624*x_62 - 0.00174620394535903*x_63 - 0.000119663945340987*x_64 - 0.000632680930324641*x_65 + 0.000150702773331149*x_66 - 0.000886456596234518*x_67 + 0.00089278134737065*x_68 + 7.11316535867866e-5*x_69 + 0.000373556979436666*x_7 - 0.00106272064331918*x_70 + 0.000526406545570695*x_71 + 0.000902312475588731*x_72 + 1.69519225387065e-5*x_73 + 0.000950970208742057*x_74 - 0.000336479528046237*x_75 + 0.00156997732030372*x_76 + 0.000494912909860022*x_77 - 0.000520017496716637*x_78 + 0.000375481971642656*x_79 - 0.00224524886998177*x_8 - 8.56111854273844e-5*x_80 + 0.000258281578074712*x_81 + 0.000547449152692509*x_82 - 5.61533639551133e-5*x_83 - 0.000264299770856981*x_84 - 3.93649415158825e-5*x_85 + 0.00138290637714752*x_86 - 0.000618235243556821*x_87 - 0.00182658414515094*x_88 - 2.54035768832742e-5*x_89 + 0.00141779373708438*x_9 - 0.000457273595420163*x_90 - 0.00315869220796649*x_91 - 0.000846684701244788*x_92 - 0.000815413066100999*x_93 - 1.43637178594081e-5*x_94 - 0.000349047094548468*x_95 - 6.31164258676616e-6*x_96 - 0.000420527266725304*x_97 - 1.76876704939351e-5*x_98 + 0.000154532243540802*x_99 + 6.73045791512068e-6*std::pow(-5.55215978622437*x_100 - 7.38375997543335, 2) + 4.82333965248658e-7*std::pow(-9.58480072021484*x_106 - 7.96384000778198, 2) + 3.99066297959137e-6*std::pow(-7.98799991607666*x_106 - 8.19944000244141, 2) - 3.89458082182933e-8*std::pow(-6.71752023696899*x_106 - 9.56103992462158, 2) + 4.67661002352594e-6*std::pow(-5.86383962631226*x_106 - 8.48952007293701, 2) - 1.67590130390491e-6*std::pow(-8.6636791229248*x_108 - 6.04663944244385, 2) + 5.76921732750262e-6*std::pow(-8.47000026702881*x_116 - 8.86903953552246, 2) + 1.23711694991697e-5*std::pow(-6.09335994720459*x_13 - 9.55160045623779, 2) + 2.84463990273773e-7*std::pow(-4.07000017166138*x_13 - 6.52231979370117, 2) - 1.19898050248604e-6*std::pow(-5.10199975967407*x_14 - 7.75728034973145, 2) - 9.4284638010519e-5*std::pow(-3.51191973686218*x_14 - 6.0479998588562, 2) - 1.0592346576535e-6*std::pow(-5.6691198348999*x_15 - 7.42512035369873, 2) - 1.10823719685848e-5*std::pow(-5.32231998443604*x_15 - 8.46951961517334, 2) - 2.5938395654268e-5*std::pow(-5.82096004486084*x_17 - 9.23791980743408, 2) + 5.39085997218608e-6*std::pow(-5.46256017684937*x_17 - 8.0926399230957, 2) + 7.00199404314601e-6*std::pow(-6.85031986236572*x_18 - 7.45431995391846, 2) - 1.49167388986605e-6*std::pow(-5.03071975708008*x_18 - 7.24015998840332, 2) - 1.88517519225898e-5*std::pow(-3.47519993782043*x_18 - 4.50079965591431, 2) - 3.28546764086061e-5*std::pow(-1.34583985805511*x_2 - 2.49487972259521, 2) - 5.75341634719755e-6*std::pow(-5.71983957290649*x_22 - 9.39935970306396, 2) - 1.52390454851148e-7*std::pow(-5.3167200088501*x_22 - 8.58440017700195, 2) - 3.57944632704512e-5*std::pow(-4.98327970504761*x_22 - 7.76327991485596, 2) - 3.10646109344479e-6*std::pow(-5.90136003494263*x_23 - 8.54720020294189, 2) - 2.24188963515964e-7*std::pow(-5.04120016098022*x_23 - 8.87744045257568, 2) - 9.50760428476846e-6*std::pow(-4.40399980545044*x_23 - 9.9993200302124, 2) + 1.20481390883698e-7*std::pow(-5.77959966659546*x_24 - 8.97016048431396, 2) - 9.54298632955016e-8*std::pow(-4.79911994934082*x_36 - 3.79999995231628, 2) - 3.61781110026806e-7*std::pow(-5.51895999908447*x_38 - 6.90023994445801, 2) - 1.54192877643517e-6*std::pow(-3.78287982940674*x_38 - 6.56720018386841, 2) - 1.56573907734102e-6*std::pow(-5.15136003494263*x_40 - 5.74847984313965, 2) + 1.96019330945177e-6*std::pow(-5.46367979049683*x_47 - 7.07823991775513, 2) - 3.42877979964774e-7*std::pow(-7.80000019073486*x_49 - 9.99882030487061, 2) - 1.7120788693177e-5*std::pow(-4.93391990661621*x_49 - 8.67199993133545, 2) + 8.01620567831857e-5*std::pow(-0.788719892501831*x_49 - 1.1847198009491, 2) + 3.36647912002477e-7*std::pow(-5.88295984268188*x_5 - 9.54328060150146, 2) - 6.19485593688643e-5*std::pow(-3.3374400138855*x_5 - 5.49232006072998, 2) - 2.44145709553747e-6*std::pow(-9.99993991851807*x_50 - 7.19999980926514, 2) + 2.1549898429634e-7*std::pow(-4.51688003540039*x_53 - 6.4747200012207, 2) - 4.07347182761612e-7*std::pow(-7.36400032043457*x_54 - 9.79903984069824, 2) - 4.73719832848553e-8*std::pow(-8.16296005249023*x_55 - 7.95711994171143, 2) - 7.41385577004825e-6*std::pow(-6.19600009918213*x_57 - 9.98884010314941, 2) + 3.69063937950337e-7*std::pow(-3.92007994651794*x_58 - 5.68487977981567, 2) - 8.97580082799345e-6*std::pow(-6.60400009155273*x_64 - 9.96195983886719, 2) + 1.08101973927664e-6*std::pow(-6.08367967605591*x_66 - 9.94783973693848, 2) + 1.90042368808113e-6*std::pow(-3.43055987358093*x_67 - 6.46231985092163, 2) - 1.60240964472484e-6*std::pow(-3.24863982200623*x_68 - 5.47495985031128, 2) + 4.88121621760406e-6*std::pow(-7.40719985961914*x_69 - 9.41207981109619, 2) - 6.2181222863503e-6*std::pow(-6.92199993133545*x_69 - 9.16287994384766, 2) - 3.47604016989319e-7*std::pow(-6.40399980545044*x_69 - 9.99507999420166, 2) - 3.10991278623317e-7*std::pow(-6.09127998352051*x_7 - 9.73591995239258, 2) - 9.8781264392914e-7*std::pow(-5.7707200050354*x_7 - 9.56975936889648, 2) + 6.28814624146238e-6*std::pow(-5.54423999786377*x_7 - 8.90136051177979, 2) - 3.94139640429638e-5*std::pow(-2.79311990737915*x_7 - 4.79031991958618, 2) - 5.66528395669233e-8*std::pow(-8.72799968719482*x_70 - 9.33439922332764, 2) + 7.82780427676573e-7*std::pow(-7.34127998352051*x_70 - 7.9312801361084, 2) - 4.68143367502661e-7*std::pow(-4.89879989624023*x_70 - 7.14247989654541, 2) - 9.71765008738495e-8*std::pow(-5.99983978271484*x_71 - 9.40424060821533, 2) - 7.29541851124368e-7*std::pow(-5.7838397026062*x_72 - 7.57272005081177, 2) + 2.15047611369371e-5*std::pow(-4.69727993011475*x_72 - 5.92263984680176, 2) - 6.4041552141062e-6*std::pow(-5.50311994552612*x_73 - 8.97648048400879, 2) - 5.509746247766e-6*std::pow(-4.92944002151489*x_74 - 6.36568021774292, 2) + 1.99431267387377e-8*std::pow(-7.0*x_77 - 9.99993991851807, 2) - 1.85004167840814e-7*std::pow(-4.67551946640015*x_78 - 6.30359983444214, 2) + 1.0807981940412e-5*std::pow(-4.72591972351074*x_79 - 6.36720037460327, 2) - 1.02200377952014e-5*std::pow(-5.28800010681152*x_82 - 7.51375961303711, 2) - 7.99877082117814e-6*std::pow(-4.89039993286133*x_84 - 8.17303943634033, 2) - 1.96383571985472e-6*std::pow(-5.33200025558472*x_85 - 8.39999961853027, 2) - 2.88130418397205e-7*std::pow(-5.09136009216309*x_85 - 8.60568046569824, 2) - 6.94268790784346e-7*std::pow(-6.66607999801636*x_86 - 8.43383884429932, 2) + 1.05969317651147e-5*std::pow(-5.27888011932373*x_86 - 8.12639999389648, 2) - 6.60936075127159e-6*std::pow(-7.70527982711792*x_87 - 8.48975944519043, 2) + 4.38616660492796e-6*std::pow(-8.80000019073486*x_88 - 9.99983978271484, 2) - 1.58387161588213e-5*std::pow(-4.33304023742676*x_90 - 5.97864007949829, 2) - 7.46775659072296e-5*std::exp(0.649039804935455*x_22) + 0.00115267293831891*std::exp(0.715519845485687*x_22) - 0.00117332414489824*std::exp(0.543359875679016*x_67) + 5.92376299807424e-5*std::exp(0.656719863414764*x_69) + 0.0145436779314476*std::sin(0.217519998550415*x_1 + 1.81207990646362) + 0.00174788533365801*std::sin(0.322799921035767*x_1 + 1.95039975643158) - 0.013967728680631*std::sin(0.269199937582016*x_10 + 5.06816005706787) - 7.88669885254562e-5*std::sin(0.367199838161469*x_101 + 8.17160034179688) + 0.00168784610940666*std::sin(0.183680012822151*x_102 + 1.7850399017334) - 0.000240564251747468*std::sin(0.315999835729599*x_102 - 4.44975996017456) + 0.00911178597576747*std::sin(0.324799835681915*x_102 + 5.12800025939941) - 6.3773569354063e-5*std::sin(0.394879847764969*x_102 + 2.00839972496033) + 0.00259993667627673*std::sin(0.467919856309891*x_102 + 5.0220799446106) + 0.0211423525775412*std::sin(0.178960010409355*x_103 - 7.6241602897644) - 0.000140058768789738*std::sin(0.323359847068787*x_103 + 5.13160037994385) - 0.00849503861836195*std::sin(0.366719841957092*x_103 - 7.41215991973877) + 0.000489852165810426*std::sin(0.418079853057861*x_103 - 1.19207990169525) + 0.000853494142824227*std::sin(0.451519846916199*x_104 - 1.14063990116119) + 0.000358807850265072*std::sin(0.310239911079407*x_105 + 1.91767990589142) + 0.00657772775403484*std::sin(0.308159917593002*x_107 + 1.90919995307922) - 0.00240705526283121*std::sin(0.410559862852097*x_107 + 5.20783996582031) - 3.08207351395205e-5*std::sin(1.69463980197906*x_107 - 6.01591968536377) - 8.30309289831458e-5*std::sin(0.444559872150421*x_108 - 4.1657600402832) - 0.00105833390101651*std::sin(0.330799847841263*x_110 - 4.43279981613159) + 0.000138186322784033*std::sin(0.394479840993881*x_110 + 5.18344020843506) + 0.00951675156826762*std::sin(0.303359925746918*x_111 - 7.49376010894775) + 0.0142208978136201*std::sin(0.141760036349297*x_112 + 8.10503959655762) + 0.000441735179884519*std::sin(0.270639955997467*x_112 - 7.53815984725952) - 0.00573718870852716*std::sin(0.362479835748672*x_112 - 7.42967987060547) + 7.6345554181926e-5*std::sin(0.398479819297791*x_112 - 4.41079998016357) - 0.00815437883315709*std::sin(0.271599948406219*x_113 + 5.0623197555542) - 4.15160882337369e-5*std::sin(0.395199835300446*x_114 - 1.21023988723755) - 0.00232328329552761*std::sin(0.20720000565052*x_115 - 1.37271988391876) - 0.0059182659780062*std::sin(0.269599944353104*x_115 + 1.86295986175537) - 0.00242587620966812*std::sin(0.457519859075546*x_115 - 1.14735984802246) + 0.00303355138151901*std::sin(0.189600005745888*x_117 + 8.18416023254395) + 0.00722438879636991*std::sin(0.350239843130112*x_117 - 7.43336009979248) + 0.000134151578351843*std::sin(1.79807984828949*x_117 + 8.98896026611328) + 0.00239101251404881*std::sin(0.238799974322319*x_118 - 1.3614399433136) - 0.000706329931006855*std::sin(0.279359966516495*x_118 - 7.5207200050354) - 0.00224826593413647*std::sin(0.279519945383072*x_118 + 1.8647198677063) - 0.000641157379387452*std::sin(0.373199850320816*x_119 + 1.97575974464417) + 0.000966935283750451*std::sin(0.398399829864502*x_119 + 8.18903923034668) + 0.000194339449967327*std::sin(0.3572798371315*x_12 - 1.03671979904175) - 0.00466968692112361*std::sin(0.416479855775833*x_12 - 4.17271995544434) - 0.0116332973774722*std::sin(0.328719854354858*x_120 - 7.45576000213623) + 0.000318544832322601*std::sin(0.330799847841263*x_120 + 5.12911987304688) - 0.100157742854924*std::sin(0.126080051064491*x_13 + 8.07575988769531) + 0.00323705340380223*std::sin(0.165200024843216*x_13 + 4.96023941040039) - 0.000802322722944393*std::sin(0.277359962463379*x_13 - 1.07599985599518) + 0.0277637664788714*std::sin(0.182000011205673*x_14 + 8.18039894104004) + 0.000176695895470083*std::sin(0.205119997262955*x_14 - 4.38215970993042) - 0.00051470223283592*std::sin(0.287039935588837*x_15 + 5.13007974624634) + 0.000962684399920069*std::sin(1.16935980319977*x_15 + 5.98727989196777) + 0.000712663491583874*std::sin(0.292079925537109*x_16 + 8.31447982788086) + 0.028109189111328*std::sin(0.345759838819504*x_16 + 5.15791988372803) - 0.00809909246732722*std::sin(0.358719855546951*x_16 + 8.34712028503418) + 0.000254862510962226*std::sin(0.402959853410721*x_16 + 1.97447979450226) - 0.000105032552815077*std::sin(1.44519984722137*x_16 - 3.38727998733521) + 0.00102704872232809*std::sin(0.412719875574112*x_18 - 7.16936016082764) + 0.00175489982388611*std::sin(1.47319984436035*x_2 - 3.38879990577698) + 0.00587159356088538*std::sin(0.243679970502853*x_21 + 8.26344013214111) - 0.00162428641944662*std::sin(0.363679856061935*x_21 + 5.15895986557007) - 0.0120796771540621*std::sin(0.179360017180443*x_23 - 7.61696004867554) - 0.000660872300925795*std::sin(0.390239834785461*x_23 + 1.97439980506897) - 0.00169782004313742*std::sin(0.186960011720657*x_24 + 4.96975994110107) + 0.0156680990093167*std::sin(0.209600001573563*x_24 - 4.37680006027222) + 0.00481929834187923*std::sin(0.271279960870743*x_24 + 1.85807991027832) - 0.00375041947404313*std::sin(0.333439826965332*x_24 + 5.13248014450073) + 0.00111200388610772*std::sin(0.547119855880737*x_24 + 8.55247974395752) + 0.000931770411691312*std::sin(1.16631984710693*x_25 - 8.98752021789551) + 0.00660002066345799*std::sin(0.338239848613739*x_26 - 7.44767951965332) + 0.00336889760227654*std::sin(0.339359849691391*x_26 + 8.35319995880127) - 0.00466985450193024*std::sin(0.353679865598679*x_26 + 1.9618399143219) - 0.0169272896640065*std::sin(0.32687982916832*x_27 + 8.30775928497314) + 0.00518436498753934*std::sin(0.378799855709076*x_27 - 7.41504001617432) + 0.00118785222208705*std::sin(0.136960044503212*x_28 + 8.09280014038086) + 0.0180965899432651*std::sin(0.19055999815464*x_28 - 4.42063999176025) - 0.000425395265155408*std::sin(0.457199841737747*x_28 - 7.13647985458374) - 0.0208521315002517*std::sin(0.300159931182861*x_3 - 1.0843198299408) - 0.011631280513062*std::sin(0.359999865293503*x_3 - 1.0461597442627) - 0.000319547942125719*std::sin(0.281439960002899*x_30 - 7.52135992050171) + 7.61466783283752e-5*std::sin(0.312719851732254*x_30 - 4.26567983627319) - 0.0141123170236189*std::sin(0.283119946718216*x_33 - 1.17807984352112) + 0.000131310379367948*std::sin(0.285759925842285*x_33 + 8.2041597366333) + 0.000706857989018883*std::sin(0.292399942874908*x_33 + 8.20679950714111) + 0.0152593922179729*std::sin(0.303599923849106*x_33 - 1.19399988651276) + 5.88130514149458e-5*std::sin(0.318159908056259*x_34 + 8.25111961364746) + 0.00317636596291919*std::sin(0.328159838914871*x_34 - 7.41232013702393) - 0.000630050707318933*std::sin(0.341119825839996*x_34 - 1.19039988517761) + 0.000839635254959383*std::sin(0.350879848003387*x_34 + 2.00583982467651) + 0.00583002730659344*std::sin(0.355279833078384*x_34 + 1.97823989391327) + 0.00113222370949567*std::sin(0.384159833192825*x_34 - 1.19863986968994) - 0.000443562786158908*std::sin(0.291759938001633*x_35 + 8.24959945678711) + 0.0012271919289336*std::sin(0.321279853582382*x_35 + 1.77135992050171) - 0.00778081909377306*std::sin(0.322319835424423*x_35 - 4.42935991287231) - 0.00522160720604139*std::sin(0.346479833126068*x_35 + 8.19127941131592) - 0.000447859269723162*std::sin(0.285039931535721*x_36 - 7.51999998092651) + 0.00691498418625278*std::sin(0.317039847373962*x_36 - 4.27767992019653) - 0.010478922419912*std::sin(0.322799831628799*x_36 - 7.46775960922241) - 0.00593749456063316*std::sin(0.331679850816727*x_36 + 5.1483998298645) - 0.0103970906581548*std::sin(0.352559864521027*x_36 + 5.15791988372803) - 0.000587601731913053*std::sin(0.353839844465256*x_36 + 5.14800024032593) + 0.0119332602866324*std::sin(0.26335996389389*x_37 + 1.8458399772644) + 0.000109055426780878*std::sin(0.267279952764511*x_37 + 5.08191967010498) - 0.000555473970009039*std::sin(0.292879939079285*x_37 + 5.11407995223999) + 0.0150798434076213*std::sin(0.317519843578339*x_37 + 5.12696027755737) + 0.029043824717288*std::sin(0.225279986858368*x_38 + 5.02023983001709) - 0.000855925367122694*std::sin(0.474399864673615*x_39 - 7.7836799621582) + 0.00823350854528559*std::sin(0.256319969892502*x_41 - 4.32304000854492) - 0.00647756936449047*std::sin(0.295359939336777*x_41 - 4.28927993774414) + 0.012010353950306*std::sin(0.333999842405319*x_41 + 5.13104009628296) - 0.00184075117028027*std::sin(0.360479861497879*x_41 + 4.78455972671509) - 0.00111824282501732*std::sin(0.363999843597412*x_41 - 1.21383988857269) - 2.18898788158491e-5*std::sin(0.465279847383499*x_41 - 4.34639978408813) - 0.000216180150597347*std::sin(0.198400005698204*x_42 + 5.00551986694336) + 0.0064258975028754*std::sin(0.403279840946198*x_42 + 8.20879936218262) - 0.00408380223479483*std::sin(0.409599870443344*x_42 + 2.00727987289429) - 0.00288355765137087*std::sin(0.189600005745888*x_43 - 7.60376024246216) - 0.000722582824802279*std::sin(0.236559987068176*x_43 - 7.55200004577637) - 0.00849394799413727*std::sin(0.26199996471405*x_43 + 5.06319952011108) - 0.00197979093303767*std::sin(0.337439835071564*x_43 + 5.13944005966187) - 0.00626079795111323*std::sin(0.356799840927124*x_43 + 5.16048002243042) - 0.00716095003594641*std::sin(0.373679846525192*x_43 - 1.21103978157043) + 0.000214367975426391*std::sin(0.294879943132401*x_47 - 7.48031997680664) - 0.00055671152102736*std::sin(0.32711985707283*x_47 + 8.3133602142334) - 0.000239015818822762*std::sin(1.76415991783142*x_49 - 7.41623973846436) - 0.00235899300829649*std::sin(0.285839945077896*x_50 + 5.09280014038086) + 0.00981180840355747*std::sin(0.399759829044342*x_50 - 1.19031989574432) - 0.010200818308085*std::sin(0.254639983177185*x_51 + 1.83439981937408) + 0.000174114542720112*std::sin(0.335119843482971*x_51 + 5.13655996322632) + 0.00134052583691868*std::sin(0.477919846773148*x_51 + 8.44704055786133) - 0.00850293618372668*std::sin(0.26639997959137*x_52 + 8.27744007110596) + 3.3603281156497e-5*std::sin(0.409919857978821*x_52 + 5.20424032211304) - 0.000211730173928639*std::sin(0.597679853439331*x_52 + 2.00543975830078) - 0.0027071650049927*std::sin(0.166960015892982*x_53 - 7.6497597694397) - 0.000500042754851903*std::sin(0.383759826421738*x_54 - 7.42215967178345) + 0.00258920395368888*std::sin(0.454879850149155*x_54 - 1.15599977970123) - 0.00461689491718259*std::sin(0.460639864206314*x_54 - 1.13079988956451) + 0.0128148962472088*std::sin(0.331519842147827*x_55 - 4.2804799079895) - 0.000367206862714445*std::sin(0.330559849739075*x_57 + 1.92791974544525) + 0.000284333984336786*std::sin(0.350719839334488*x_58 - 7.43415975570679) + 0.0010290113603435*std::sin(0.320719838142395*x_59 - 4.28952026367188) + 8.64224540391344e-6*std::sin(1.39943981170654*x_6 - 5.19679975509644) + 0.00127437812270817*std::sin(0.305039942264557*x_62 - 4.27687978744507) + 0.00757869278091133*std::sin(0.130960047245026*x_64 + 4.91191959381104) - 0.0238041990628848*std::sin(0.186400011181831*x_64 - 4.42831993103027) + 0.00154614653643553*std::sin(0.220399990677834*x_65 + 5.01191997528076) + 6.76675441338108e-5*std::sin(0.306479841470718*x_67 - 7.49200010299683) + 0.0521043979883341*std::sin(0.14544004201889*x_68 + 4.9206395149231) + 0.022523465280041*std::sin(0.167200013995171*x_71 - 4.45599985122681) + 0.0162028909734496*std::sin(0.207039996981621*x_73 - 7.59656000137329) - 0.0159703891082578*std::sin(0.250639975070953*x_73 - 7.52424001693726) + 0.00118826414934503*std::sin(0.23735998570919*x_75 - 7.56728029251099) + 0.00676172220559474*std::sin(0.269359946250916*x_75 + 5.09375953674316) + 0.0241959322976538*std::sin(0.171120017766953*x_76 - 7.64520025253296) - 0.0138821073459026*std::sin(0.22223998606205*x_76 - 7.56864023208618) - 0.00298311917166277*std::sin(0.242639973759651*x_79 + 1.85583996772766) - 0.00247232949078421*std::sin(0.243519976735115*x_79 - 7.54839992523193) - 0.00349272488876025*std::sin(0.134880036115646*x_80 + 4.91583967208862) - 0.00566670393309755*std::sin(0.182960003614426*x_80 - 7.60896015167236) - 7.48731254938728e-5*std::sin(0.281279861927032*x_84 - 1.29047977924347) + 0.000246175127863946*std::sin(0.295519828796387*x_85 - 1.26815986633301) - 0.0591546249015042*std::sin(0.157360032200813*x_86 - 7.64720010757446) + 0.000426685511769292*std::sin(0.173280015587807*x_86 - 7.63872003555298) - 0.00708236353595197*std::sin(0.364959836006165*x_86 + 1.95703983306885) + 0.000393779090462441*std::sin(0.184800013899803*x_88 - 7.60400009155273) - 0.00108788393387801*std::sin(0.214479997754097*x_88 + 5.01127958297729) + 0.00014480950238006*std::sin(0.314479917287827*x_9 + 8.34624004364014) + 0.00874471367525179*std::sin(0.356559842824936*x_9 - 4.25672006607056) + 0.00769431375381586*std::sin(0.336159855127335*x_92 + 5.19160032272339) - 0.00105874981183148*std::sin(0.361919850111008*x_92 - 7.40287971496582) + 0.00980712490099449*std::sin(0.367439836263657*x_92 + 1.98079979419708) + 0.00087935040071169*std::sin(0.367679834365845*x_92 - 1.3977597951889) + 0.0280346992530937*std::sin(0.392559856176376*x_92 + 1.97831988334656) + 0.000359113093210762*std::sin(0.345039844512939*x_93 - 1.42127990722656) + 0.000721193473011491*std::sin(0.361599832773209*x_93 - 7.40575981140137) - 0.00654412421636495*std::sin(0.409999877214432*x_93 + 1.99575984477997) + 0.000902359790165315*std::sin(0.422959864139557*x_93 - 7.60512018203735) - 7.37142684942374e-5*std::sin(0.36983984708786*x_94 + 5.17535972595215) - 0.00361254647711411*std::sin(0.379439830780029*x_94 + 4.98119974136353) + 0.000140941302882215*std::sin(0.398239850997925*x_94 + 5.19799995422363) - 0.000217929169368111*std::sin(0.328559845685959*x_95 + 1.94279980659485) - 0.00887399624955837*std::sin(0.344959855079651*x_95 - 7.42527961730957) - 0.0146660193572893*std::sin(0.373599827289581*x_95 - 7.42496013641357) + 0.000252500631460951*std::sin(0.386799842119217*x_95 + 8.18487930297852) - 0.000648246185022597*std::sin(0.343759834766388*x_96 - 4.42055988311768) + 0.00722946590422158*std::sin(0.346959829330444*x_96 + 1.94447982311249) + 0.000702337878588463*std::sin(0.42103984951973*x_96 - 1.15919995307922) - 0.00226714707171464*std::sin(0.449839860200882*x_96 + 8.23176002502441) + 0.0115832815711979*std::sin(0.312559932470322*x_97 + 1.90231990814209) + 0.00985150880319396*std::sin(0.371679842472076*x_97 - 7.43088006973267) - 0.0011670603587887*std::sin(0.411359876394272*x_97 + 8.21576023101807) - 0.00918832823791171*std::sin(0.411279857158661*x_98 + 5.21224021911621) + 0.000303390533830546*std::sin(0.463359862565994*x_98 + 2.01143980026245) + 8.17074040522251e-5*std::sin(0.33247983455658*x_99 - 7.45544004440308) + 0.00649881019661819*std::sin(0.396479845046997*x_99 + 2.0019998550415) - 0.000450827832893059*std::sin(0.39743983745575*x_99 - 7.39287996292114) - 0.000774668162861494*std::sin(0.468479871749878*x_99 + 8.24679946899414) + 0.0448418824070476);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00288844778971639*x_1 - 0.00135823033198796*x_10 + 0.000650545128901136*x_100 + 0.00298989603041108*x_101 - 0.000261799852916369*x_102 + 0.00116448751123393*x_103 - 0.000654148264250932*x_104 - 9.0754127642902e-5*x_105 + 0.00118274583401356*x_106 - 8.73307011382016e-5*x_107 - 0.000320650733613237*x_108 + 0.00148760528251493*x_109 - 0.000793026835260652*x_11 + 0.000295026344698268*x_110 + 0.00237192019901177*x_111 - 6.55963953931648e-5*x_112 - 0.00106052108831737*x_113 + 6.14747791606923e-5*x_114 - 2.64056908576848e-6*x_115 - 0.000719574393183293*x_116 + 0.00113448200957685*x_117 - 0.00145772285048308*x_118 - 0.000777005428807785*x_119 + 0.00131583342479263*x_12 + 0.000122810224999674*x_120 - 0.000294089078753412*x_13 - 8.47504075791878e-5*x_14 - 0.00109514630737706*x_15 + 0.00049242871624411*x_16 + 0.0025667520693445*x_17 - 0.000220725357561199*x_18 + 0.00075539767832548*x_19 - 0.000349847765793588*x_2 + 0.00736315222342463*x_20 + 0.000307172477095305*x_21 + 0.00249126222305298*x_22 + 0.000780434681152218*x_23 + 0.000666877573475973*x_24 + 0.000242747852829922*x_25 + 0.000450642959849519*x_26 + 0.000979249665962022*x_27 + 0.000713790634943228*x_28 + 0.00480434486691717*x_29 + 0.00143436938549996*x_3 - 0.000215930113636722*x_30 - 0.00150927970056158*x_31 + 0.00120758109561177*x_32 + 0.00297104171266587*x_33 + 7.25371060937061e-5*x_34 - 3.87348765238316e-6*x_35 - 0.000117014515313182*x_36 + 1.40886202860252e-5*x_37 + 0.000320121647627774*x_38 - 0.00114935999839734*x_39 + 0.00228275038139447*x_4 + 0.000965779228828*x_40 + 1.26104791477548e-5*x_41 + 0.000181484145118335*x_42 + 0.000448820305276389*x_43 - 0.00215561043052274*x_44 - 0.000327649157847392*x_45 + 0.000178681868651643*x_46 + 0.000224894158712775*x_47 - 0.000526774000134678*x_48 - 5.98211023324563e-5*x_49 + 0.000271129813584993*x_5 + 0.000712264985134435*x_50 - 0.000416125818001908*x_51 - 2.75830059241655e-5*x_52 - 0.000452473124004544*x_53 + 0.00103809336308984*x_54 + 9.43247277692485e-5*x_55 + 0.000406571604034472*x_56 + 0.000774939374650628*x_57 + 0.00107111894651616*x_58 + 0.000751286735579874*x_59 - 0.000863779288892965*x_6 + 0.00161434920278053*x_60 + 0.000939880106562928*x_61 + 0.00188051533498111*x_62 + 0.00596768990980437*x_63 - 0.00032126432001067*x_64 - 0.000679777174067541*x_65 + 6.3000414804878e-5*x_66 + 0.00039635482045756*x_67 - 0.000512805658905758*x_68 + 5.14264461899162e-5*x_69 - 0.0012175079825772*x_7 + 0.000113737529780344*x_70 + 0.00012714924425477*x_71 + 0.00178481367427802*x_72 + 5.44079561482493e-5*x_73 + 0.000201905781942604*x_74 + 0.000461357783402774*x_75 - 0.000793254024417714*x_76 + 0.000574997960940178*x_77 + 0.00062104731129899*x_78 + 8.23966739604329e-5*x_79 + 0.000917131879292689*x_8 - 4.04037325493239e-6*x_80 + 0.0011755279489912*x_81 - 4.38876136408267e-5*x_82 + 0.000788871578399379*x_83 - 1.76769707390189e-5*x_84 - 5.08920583552623e-6*x_85 + 0.00114105730215198*x_86 - 0.00081323854900633*x_87 + 0.00162489073972851*x_88 + 0.00103680633412615*x_89 - 0.000862593420089306*x_9 + 8.02724398566695e-7*x_90 + 0.000877810873245813*x_91 - 2.4932484960403e-5*x_92 + 0.000270150149880045*x_93 - 9.70945950469003e-6*x_94 - 0.000140519342106793*x_95 + 0.000452797988083456*x_96 + 0.000274913355378047*x_97 + 3.26046952964545e-5*x_98 - 0.000381536239136448*x_99 + 2.58087242430113e-7*std::pow(-5.55215978622437*x_100 - 7.38375997543335, 2) - 3.0577328169176e-6*std::pow(-9.58480072021484*x_106 - 7.96384000778198, 2) + 1.25735567885831e-7*std::pow(-7.98799991607666*x_106 - 8.19944000244141, 2) - 1.21369209158526e-9*std::pow(-6.71752023696899*x_106 - 9.56103992462158, 2) + 1.79330054524409e-7*std::pow(-5.86383962631226*x_106 - 8.48952007293701, 2) + 1.58959266870071e-6*std::pow(-8.6636791229248*x_108 - 6.04663944244385, 2) + 1.81773259390748e-7*std::pow(-8.47000026702881*x_116 - 8.86903953552246, 2) + 4.74386893424173e-7*std::pow(-6.09335994720459*x_13 - 9.55160045623779, 2) + 8.8649256782889e-9*std::pow(-4.07000017166138*x_13 - 6.52231979370117, 2) + 8.94289950150458e-5*std::pow(-3.51191973686218*x_14 - 6.0479998588562, 2) + 2.72081718496061e-5*std::pow(-5.6691198348999*x_15 - 7.42512035369873, 2) - 9.66701750038481e-8*std::pow(-5.32231998443604*x_15 - 8.46951961517334, 2) + 2.46025726418446e-5*std::pow(-5.82096004486084*x_17 - 9.23791980743408, 2) - 5.68205616632564e-5*std::pow(-5.46256017684937*x_17 - 8.0926399230957, 2) - 6.64139252791133e-6*std::pow(-6.85031986236572*x_18 - 7.45431995391846, 2) - 7.2289236929142e-7*std::pow(-3.47519993782043*x_18 - 4.50079965591431, 2) + 0.000843926013305518*std::pow(-1.34583985805511*x_2 - 2.49487972259521, 2) + 3.64735043387349e-5*std::pow(-5.71983957290649*x_22 - 9.39935970306396, 2) - 4.74903714539023e-9*std::pow(-5.3167200088501*x_22 - 8.58440017700195, 2) + 3.26393808122561e-6*std::pow(-4.98327970504761*x_22 - 7.76327991485596, 2) + 1.96932596795396e-5*std::pow(-5.90136003494263*x_23 - 8.54720020294189, 2) + 5.75865961527366e-6*std::pow(-5.04120016098022*x_23 - 8.87744045257568, 2) - 8.29336691352066e-8*std::pow(-4.40399980545044*x_23 - 9.9993200302124, 2) + 3.75463542774936e-9*std::pow(-5.77959966659546*x_24 - 8.97016048431396, 2) - 2.97393931931317e-9*std::pow(-4.79911994934082*x_36 - 3.79999995231628, 2) + 9.29293857827167e-6*std::pow(-5.51895999908447*x_38 - 6.90023994445801, 2) - 1.34500560966545e-8*std::pow(-3.78287982940674*x_38 - 6.56720018386841, 2) + 9.92592706393332e-6*std::pow(-5.15136003494263*x_40 - 5.74847984313965, 2) - 1.24265505679722e-5*std::pow(-5.46367979049683*x_47 - 7.07823991775513, 2) + 8.80738081493094e-6*std::pow(-7.80000019073486*x_49 - 9.99882030487061, 2) + 1.6239070955811e-5*std::pow(-4.93391990661621*x_49 - 8.67199993133545, 2) - 0.000844921425153508*std::pow(-0.788719892501831*x_49 - 1.1847198009491, 2) - 8.6473513459855e-6*std::pow(-5.88295984268188*x_5 - 9.54328060150146, 2) - 2.37548961180031e-6*std::pow(-3.3374400138855*x_5 - 5.49232006072998, 2) - 2.12965315871934e-8*std::pow(-9.99993991851807*x_50 - 7.19999980926514, 2) + 6.71572692802073e-9*std::pow(-4.51688003540039*x_53 - 6.4747200012207, 2) - 2.84292928593704e-7*std::pow(-6.19600009918213*x_57 - 9.98884010314941, 2) + 1.15013656994602e-8*std::pow(-3.92007994651794*x_58 - 5.68487977981567, 2) - 2.82804491411457e-7*std::pow(-6.60400009155273*x_64 - 9.96195983886719, 2) - 1.13941280373968e-5*std::pow(-6.08367967605591*x_66 - 9.94783973693848, 2) - 2.00307820852446e-5*std::pow(-3.43055987358093*x_67 - 6.46231985092163, 2) - 4.62983440359365e-6*std::pow(-7.40719985961914*x_69 - 9.41207981109619, 2) - 5.42399200568946e-8*std::pow(-6.92199993133545*x_69 - 9.16287994384766, 2) + 8.92877679324632e-6*std::pow(-6.40399980545044*x_69 - 9.99507999420166, 2) - 9.69161182383205e-9*std::pow(-6.09127998352051*x_7 - 9.73591995239258, 2) - 6.62781083359689e-5*std::pow(-5.54423999786377*x_7 - 8.90136051177979, 2) - 1.24183304301012e-6*std::pow(-2.79311990737915*x_7 - 4.79031991958618, 2) - 1.76550716222975e-9*std::pow(-8.72799968719482*x_70 - 9.33439922332764, 2) - 8.25063603749114e-6*std::pow(-7.34127998352051*x_70 - 7.9312801361084, 2) - 3.02837085669004e-9*std::pow(-5.99983978271484*x_71 - 9.40424060821533, 2) + 1.87394737449809e-5*std::pow(-5.7838397026062*x_72 - 7.57272005081177, 2) - 1.9609236286678e-6*std::pow(-4.69727993011475*x_72 - 5.92263984680176, 2) - 2.45574785571401e-7*std::pow(-5.50311994552612*x_73 - 8.97648048400879, 2) - 2.11277632741886e-7*std::pow(-4.92944002151489*x_74 - 6.36568021774292, 2) + 6.2149988180035e-10*std::pow(-7.0*x_77 - 9.99993991851807, 2) - 5.76539827239327e-9*std::pow(-4.67551946640015*x_78 - 6.30359983444214, 2) + 3.40531824894083e-7*std::pow(-4.72591972351074*x_79 - 6.36720037460327, 2) + 9.31919841884037e-7*std::pow(-5.28800010681152*x_82 - 7.51375961303711, 2) - 3.0672217702015e-7*std::pow(-4.89039993286133*x_84 - 8.17303943634033, 2) + 2.06991554579855e-5*std::pow(-5.33200025558472*x_85 - 8.39999961853027, 2) + 3.33882174502879e-7*std::pow(-5.27888011932373*x_86 - 8.12639999389648, 2) - 2.53443630735624e-7*std::pow(-7.70527982711792*x_87 - 8.48975944519043, 2) + 1.38196873986326e-7*std::pow(-8.80000019073486*x_88 - 9.99983978271484, 2) - 1.38159183543904e-7*std::pow(-4.33304023742676*x_90 - 5.97864007949829, 2) + 3.63177715651143e-5*std::exp(0.715519845485687*x_22) + 0.000106990216034787*std::exp(0.543359875679016*x_67) - 0.000375534086833711*std::exp(0.656719863414764*x_69) + 0.000557694257873046*std::sin(0.217519998550415*x_1 + 1.81207990646362) - 0.0110806344358929*std::sin(0.322799921035767*x_1 + 1.95039975643158) - 0.000535608813495034*std::sin(0.269199937582016*x_10 + 5.06816005706787) - 2.45778030138633e-6*std::sin(0.367199838161469*x_101 + 8.17160034179688) - 0.0107000186809958*std::sin(0.183680012822151*x_102 + 1.7850399017334) - 0.00864253053094569*std::sin(0.324799835681915*x_102 + 5.12800025939941) - 1.98741482891691e-6*std::sin(0.394879847764969*x_102 + 2.00839972496033) - 0.000237076674745954*std::sin(0.467919856309891*x_102 + 5.0220799446106) + 0.000666141370838538*std::sin(0.178960010409355*x_103 - 7.6241602897644) - 4.36473725450709e-6*std::sin(0.323359847068787*x_103 + 5.13160037994385) + 0.000774624830618509*std::sin(0.366719841957092*x_103 - 7.41215991973877) - 0.0051631233860493*std::sin(0.418079853057861*x_103 - 1.19207990169525) - 0.0089959703686954*std::sin(0.451519846916199*x_104 - 1.14063990116119) - 0.00921656554613356*std::sin(0.310239911079407*x_105 + 1.91767990589142) + 0.00025223062663849*std::sin(0.308159917593002*x_107 + 1.90919995307922) - 2.09964486087846e-5*std::sin(0.410559862852097*x_107 + 5.20783996582031) + 0.000195386558002509*std::sin(1.69463980197906*x_107 - 6.01591968536377) - 2.58754372996903e-6*std::sin(0.444559872150421*x_108 - 4.1657600402832) + 0.0111550155250346*std::sin(0.330799847841263*x_110 - 4.43279981613159) + 4.30638507199986e-6*std::sin(0.394479840993881*x_110 + 5.18344020843506) + 8.3013459770206e-5*std::sin(0.303359925746918*x_111 - 7.49376010894775) - 0.00129674049230429*std::sin(0.141760036349297*x_112 + 8.10503959655762) - 0.000219999178623258*std::sin(0.362479835748672*x_112 - 7.42967987060547) + 2.37920329753932e-6*std::sin(0.398479819297791*x_112 - 4.41079998016357) - 7.11296490573967e-5*std::sin(0.271599948406219*x_113 + 5.0623197555542) - 1.29379130304386e-6*std::sin(0.395199835300446*x_114 - 1.21023988723755) + 0.0244877927521475*std::sin(0.20720000565052*x_115 - 1.37271988391876) - 5.16243101598616e-5*std::sin(0.269599944353104*x_115 + 1.86295986175537) + 0.000221204874096026*std::sin(0.457519859075546*x_115 - 1.14735984802246) - 0.0319741366352648*std::sin(0.189600005745888*x_117 + 8.18416023254395) + 0.000277027596964728*std::sin(0.350239843130112*x_117 - 7.43336009979248) - 1.2232686433395e-5*std::sin(1.79807984828949*x_117 + 8.98896026611328) - 0.015157708054208*std::sin(0.238799974322319*x_118 - 1.3614399433136) + 0.0181432376730649*std::sin(0.279359966516495*x_118 - 7.5207200050354) - 1.96113487188714e-5*std::sin(0.279519945383072*x_118 + 1.8647198677063) - 0.0101916588815497*std::sin(0.398399829864502*x_119 + 8.18903923034668) - 0.000179064580104896*std::sin(0.416479855775833*x_12 - 4.17271995544434) - 0.00044609232809792*std::sin(0.328719854354858*x_120 - 7.45576000213623) + 0.00913293959917134*std::sin(0.126080051064491*x_13 + 8.07575988769531) - 0.0341190818323948*std::sin(0.165200024843216*x_13 + 4.96023941040039) + 0.0206089692845529*std::sin(0.277359962463379*x_13 - 1.07599985599518) + 0.000242179938724904*std::sin(0.182000011205673*x_14 + 8.18039894104004) + 5.50648248832292e-6*std::sin(0.205119997262955*x_14 - 4.38215970993042) - 1.60399811454113e-5*std::sin(0.287039935588837*x_15 + 5.13007974624634) + 3.69152537968739e-5*std::sin(1.16935980319977*x_15 + 5.98727989196777) - 0.0183059255188168*std::sin(0.292079925537109*x_16 + 8.31447982788086) - 0.0266615706010716*std::sin(0.345759838819504*x_16 + 5.15791988372803) - 0.000310569127307514*std::sin(0.358719855546951*x_16 + 8.34712028503418) + 0.00110706059416679*std::sin(1.44519984722137*x_16 - 3.38727998733521) - 0.0108252645328027*std::sin(0.412719875574112*x_18 - 7.16936016082764) - 0.00166452277819327*std::sin(1.47319984436035*x_2 - 3.38879990577698) - 0.000535404531031854*std::sin(0.243679970502853*x_21 + 8.26344013214111) + 0.0171202492980967*std::sin(0.363679856061935*x_21 + 5.15895986557007) + 0.127321808421278*std::sin(0.179360017180443*x_23 - 7.61696004867554) + 0.0436112802480637*std::sin(0.186960011720657*x_24 + 4.96975994110107) - 0.00142870433984516*std::sin(0.209600001573563*x_24 - 4.37680006027222) + 0.000184801604168611*std::sin(0.271279960870743*x_24 + 1.85807991027832) + 0.0237756026513217*std::sin(0.333439826965332*x_24 + 5.13248014450073) - 0.0117207061037317*std::sin(0.547119855880737*x_24 + 8.55247974395752) - 0.000883784392246519*std::sin(1.16631984710693*x_25 - 8.98752021789551) + 5.75711728837567e-5*std::sin(0.338239848613739*x_26 - 7.44767951965332) - 0.0355087416358407*std::sin(0.339359849691391*x_26 + 8.35319995880127) - 0.000147135152917505*std::sin(0.353679865598679*x_26 + 1.9618399143219) - 0.000649096624077303*std::sin(0.32687982916832*x_27 + 8.30775928497314) + 0.000163346060333671*std::sin(0.378799855709076*x_27 - 7.41504001617432) + 0.000693934804250544*std::sin(0.19055999815464*x_28 - 4.42063999176025) + 0.00448373692133175*std::sin(0.457199841737747*x_28 - 7.13647985458374) + 0.0197782502360675*std::sin(0.300159931182861*x_3 - 1.0843198299408) - 0.000366471853932152*std::sin(0.359999865293503*x_3 - 1.0461597442627) + 2.37300560742312e-6*std::sin(0.312719851732254*x_30 - 4.26567983627319) - 0.000123100015073508*std::sin(0.283119946718216*x_33 - 1.17807984352112) + 4.09210583302467e-6*std::sin(0.285759925842285*x_33 + 8.2041597366333) + 0.000585139155219801*std::sin(0.303599923849106*x_33 - 1.19399988651276) + 1.83282716805421e-6*std::sin(0.318159908056259*x_34 + 8.25111961364746) + 2.77070517378487e-5*std::sin(0.328159838914871*x_34 - 7.41232013702393) - 0.0215674025985239*std::sin(0.350879848003387*x_34 + 2.00583982467651) + 0.000223559182722262*std::sin(0.355279833078384*x_34 + 1.97823989391327) - 0.0119338264087597*std::sin(0.384159833192825*x_34 - 1.19863986968994) + 0.0113936344743825*std::sin(0.291759938001633*x_35 + 8.24959945678711) - 0.00777972380987558*std::sin(0.321279853582382*x_35 + 1.77135992050171) + 0.00738010821945748*std::sin(0.322319835424423*x_35 - 4.42935991287231) - 4.5547440912492e-5*std::sin(0.346479833126068*x_35 + 8.19127941131592) + 6.03185611644163e-5*std::sin(0.317039847373962*x_36 - 4.27767992019653) - 0.000330164002331793*std::sin(0.322799831628799*x_36 - 7.46775960922241) + 0.000541413750419847*std::sin(0.331679850816727*x_36 + 5.1483998298645) - 0.000398688542607276*std::sin(0.352559864521027*x_36 + 5.15791988372803) + 0.015093510003188*std::sin(0.353839844465256*x_36 + 5.14800024032593) + 0.000375986463036977*std::sin(0.26335996389389*x_37 + 1.8458399772644) + 3.39856110538325e-6*std::sin(0.267279952764511*x_37 + 5.08191967010498) + 0.00585478812806807*std::sin(0.292879939079285*x_37 + 5.11407995223999) + 0.000578254147107479*std::sin(0.317519843578339*x_37 + 5.12696027755737) + 0.00111371926330127*std::sin(0.225279986858368*x_38 + 5.02023983001709) + 7.80480316000434e-5*std::sin(0.474399864673615*x_39 - 7.7836799621582) + 7.1819887856559e-5*std::sin(0.256319969892502*x_41 - 4.32304000854492) + 0.000590660772388061*std::sin(0.295359939336777*x_41 - 4.28927993774414) - 0.011391822742439*std::sin(0.333999842405319*x_41 + 5.13104009628296) - 5.79973540525331e-5*std::sin(0.360479861497879*x_41 + 4.78455972671509) + 0.0117864655585971*std::sin(0.363999843597412*x_41 - 1.21383988857269) - 6.82167709953354e-7*std::sin(0.465279847383499*x_41 - 4.34639978408813) - 6.73695453094921e-6*std::sin(0.198400005698204*x_42 + 5.00551986694336) - 0.00609496486254448*std::sin(0.403279840946198*x_42 + 8.20879936218262) - 3.56225073330699e-5*std::sin(0.409599870443344*x_42 + 2.00727987289429) + 0.0182801741020354*std::sin(0.189600005745888*x_43 - 7.60376024246216) + 0.0185607197902181*std::sin(0.236559987068176*x_43 - 7.55200004577637) - 0.000267622542945213*std::sin(0.26199996471405*x_43 + 5.06319952011108) - 7.59173876338947e-5*std::sin(0.337439835071564*x_43 + 5.13944005966187) - 5.46121746602171e-5*std::sin(0.356799840927124*x_43 + 5.16048002243042) + 0.000652975219756234*std::sin(0.373679846525192*x_43 - 1.21103978157043) + 6.68048060540555e-6*std::sin(0.294879943132401*x_47 - 7.48031997680664) - 9.16533976663846e-6*std::sin(1.76415991783142*x_49 - 7.41623973846436) + 0.0248641790702544*std::sin(0.285839945077896*x_50 + 5.09280014038086) - 0.000894695217304677*std::sin(0.399759829044342*x_50 - 1.19031989574432) + 0.00967547788136332*std::sin(0.254639983177185*x_51 + 1.83439981937408) + 5.4260382104517e-6*std::sin(0.335119843482971*x_51 + 5.13655996322632) + 5.14040234735584e-5*std::sin(0.477919846773148*x_51 + 8.44704055786133) - 7.41700721882892e-5*std::sin(0.26639997959137*x_52 + 8.27744007110596) + 1.04719964629722e-6*std::sin(0.409919857978821*x_52 + 5.20424032211304) + 0.0285339698846638*std::sin(0.166960015892982*x_53 - 7.6497597694397) + 0.0128444146987226*std::sin(0.383759826421738*x_54 - 7.42215967178345) - 0.00245586038567117*std::sin(0.454879850149155*x_54 - 1.15599977970123) - 0.00017704020926842*std::sin(0.460639864206314*x_54 - 1.13079988956451) + 0.000111782772351037*std::sin(0.331519842147827*x_55 - 4.2804799079895) + 0.00943230789598808*std::sin(0.330559849739075*x_57 + 1.92791974544525) - 0.00730358268833115*std::sin(0.350719839334488*x_58 - 7.43415975570679) - 0.0108459510642565*std::sin(0.320719838142395*x_59 - 4.28952026367188) - 0.00022199018547698*std::sin(1.39943981170654*x_6 - 5.19679975509644) - 0.0134321575921551*std::sin(0.305039942264557*x_62 - 4.27687978744507) - 0.0798806837325479*std::sin(0.130960047245026*x_64 + 4.91191959381104) - 0.000912799719109048*std::sin(0.186400011181831*x_64 - 4.42831993103027) - 0.0162966419211849*std::sin(0.220399990677834*x_65 + 5.01191997528076) + 2.1087651516146e-6*std::sin(0.306479841470718*x_67 - 7.49200010299683) + 0.00199800378590572*std::sin(0.14544004201889*x_68 + 4.9206395149231) - 0.0213635106073762*std::sin(0.167200013995171*x_71 - 4.45599985122681) - 0.0153684448142262*std::sin(0.207039996981621*x_73 - 7.59656000137329) - 0.000139307750574625*std::sin(0.250639975070953*x_73 - 7.52424001693726) - 0.0125245019752789*std::sin(0.23735998570919*x_75 - 7.56728029251099) + 0.000213044545669388*std::sin(0.269359946250916*x_75 + 5.09375953674316) - 0.00220631957072151*std::sin(0.171120017766953*x_76 - 7.64520025253296) - 0.000121091924215748*std::sin(0.22223998606205*x_76 - 7.56864023208618) + 0.0314425727466208*std::sin(0.242639973759651*x_79 + 1.85583996772766) + 0.0156732130906576*std::sin(0.243519976735115*x_79 - 7.54839992523193) + 0.0597280029381688*std::sin(0.182960003614426*x_80 - 7.60896015167236) - 2.33331709987469e-6*std::sin(0.281279861927032*x_84 - 1.29047977924347) - 0.00632341014866233*std::sin(0.295519828796387*x_85 - 1.26815986633301) + 0.056108171671013*std::sin(0.157360032200813*x_86 - 7.64720010757446) + 1.32970621209281e-5*std::sin(0.173280015587807*x_86 - 7.63872003555298) - 6.17785907567562e-5*std::sin(0.364959836006165*x_86 + 1.95703983306885) + 1.22715791452342e-5*std::sin(0.184800013899803*x_88 - 7.60400009155273) + 0.0279440752920124*std::sin(0.214479997754097*x_88 + 5.01127958297729) + 4.51278727713043e-6*std::sin(0.314479917287827*x_9 + 8.34624004364014) + 0.000335326223973004*std::sin(0.356559842824936*x_9 - 4.25672006607056) + 6.71165576488834e-5*std::sin(0.336159855127335*x_92 + 5.19160032272339) + 0.0271957177929428*std::sin(0.361919850111008*x_92 - 7.40287971496582) + 0.000308997383407226*std::sin(0.367439836263657*x_92 + 1.98079979419708) - 0.00926849963179179*std::sin(0.367679834365845*x_92 - 1.3977597951889) - 0.0265909169580045*std::sin(0.392559856176376*x_92 + 1.97831988334656) - 0.00922440620963733*std::sin(0.345039844512939*x_93 - 1.42127990722656) - 5.7083595013433e-5*std::sin(0.409999877214432*x_93 + 1.99575984477997) - 0.00951102242760342*std::sin(0.422959864139557*x_93 - 7.60512018203735) - 2.29720292892586e-6*std::sin(0.36983984708786*x_94 + 5.17535972595215) - 0.000138527299358692*std::sin(0.379439830780029*x_94 + 4.98119974136353) + 0.0055978665807111*std::sin(0.328559845685959*x_95 + 1.94279980659485) - 0.000279596889930607*std::sin(0.344959855079651*x_95 - 7.42527961730957) + 0.013910721827741*std::sin(0.373599827289581*x_95 - 7.42496013641357) + 0.00683262272051012*std::sin(0.343759834766388*x_96 - 4.42055988311768) + 0.000277222284574617*std::sin(0.346959829330444*x_96 + 1.94447982311249) - 0.00445243697241412*std::sin(0.42103984951973*x_96 - 1.15919995307922) - 1.97760465722846e-5*std::sin(0.449839860200882*x_96 + 8.23176002502441) + 0.000444174413792231*std::sin(0.312559932470322*x_97 + 1.90231990814209) + 0.000310395806470406*std::sin(0.371679842472076*x_97 - 7.43088006973267) + 0.0123010104924696*std::sin(0.411359876394272*x_97 + 8.21576023101807) - 8.01486632346944e-5*std::sin(0.411279857158661*x_98 + 5.21224021911621) + 2.54629791135177e-6*std::sin(0.33247983455658*x_99 - 7.45544004440308) + 0.000249204441046091*std::sin(0.396479845046997*x_99 + 2.0019998550415) + 0.0115802490631424*std::sin(0.39743983745575*x_99 - 7.39287996292114) + 0.00816513141568087*std::sin(0.468479871749878*x_99 + 8.24679946899414) - 0.218693569302559*std::sin(0.0103404727380584*x_1 - 0.0497526738165069*x_10 + 0.0186016272835654*x_100 + 0.000573253965586735*x_101 + 0.00038890678123079*x_103 - 0.0150485477737356*x_104 + 0.00342087041106083*x_105 - 0.00131369946170895*x_106 + 0.00153991845362175*x_107 + 0.0118206409172184*x_108 - 0.00103601975796236*x_109 + 0.00145380620735446*x_11 + 0.0151461700535768*x_110 - 0.0065873848898627*x_111 + 0.00103197254754908*x_113 + 0.00087882740796114*x_114 + 0.00120213899672587*x_115 + 0.0250318728142004*x_116 + 0.000802205659783*x_117 - 0.00977319729559521*x_118 - 0.00468157739207014*x_13 + 0.00483505896209464*x_15 + 0.024788815583421*x_17 + 0.00150983566271607*x_19 - 0.00831993000589068*x_2 + 0.0449495834209298*x_20 + 0.00381193388586378*x_21 - 0.00998744020142103*x_24 + 0.000612346555575418*x_25 + 0.00947481742361391*x_26 + 0.00216730042752801*x_27 + 0.00261515387330822*x_29 + 0.0147147442123515*x_3 - 0.000898405320533838*x_31 + 0.0373458518427331*x_32 - 0.0160083113408604*x_35 - 0.000843765840011873*x_37 - 0.000979666286392841*x_38 - 0.00142511269761141*x_39 + 0.0061205616730594*x_4 + 0.000125475168286267*x_40 - 2.2844237140329e-5*x_41 + 0.0124694255269149*x_42 + 0.0212132838243582*x_43 + 0.00210851877853869*x_44 + 0.000854146795617847*x_45 + 0.000597531575422243*x_46 - 0.0085511785751051*x_48 + 0.00342877512456029*x_49 + 0.00797971665108566*x_5 + 0.0157777820336634*x_50 + 0.0119084287057322*x_51 - 3.13538443229e-5*x_53 - 0.0175332751861108*x_56 - 0.0050687521172272*x_57 + 0.00398980663730007*x_58 + 0.000172142095966602*x_59 + 0.0083555513043157*x_6 + 0.00119158135389249*x_60 + 0.000374672127709174*x_61 + 0.0290276745892828*x_62 - 0.00228016334074323*x_63 + 0.000228637665541466*x_64 + 8.17534541628383e-5*x_65 + 0.00981120052730245*x_66 + 0.000351891937582801*x_67 - 0.00027139523196608*x_69 + 0.000545302395829857*x_71 - 0.00202528080643342*x_72 - 0.00360217891046487*x_73 + 0.000303420134470639*x_74 - 0.000410755330628578*x_75 - 0.00251979262147716*x_76 - 0.000545866413560375*x_77 - 0.00864532076547901*x_78 + 0.000501952729645274*x_79 + 0.0113174317842561*x_8 - 1.41458364033379e-5*x_81 + 2.87012174260406e-6*x_82 - 1.66520692975967e-5*x_83 - 0.000658889424885951*x_84 + 0.0124050944299457*x_87 - 0.00330552033298529*x_88 - 0.00228614421576273*x_89 + 0.0207282689414226*x_9 - 0.00286792599076278*x_90 + 0.061876319909235*x_91 + 0.016924648434144*x_92 + 0.000323853519458576*x_96 - 0.0113272172378263*x_97 + 0.0077282834812784*x_99 - 0.000344949511267879*std::pow(-5.10199975967407*x_14 - 7.75728034973145, 2) - 0.000429158087402962*std::pow(-5.03071975708008*x_18 - 7.24015998840332, 2) - 0.000117194742799082*std::pow(-7.36400032043457*x_54 - 9.79903984069824, 2) - 1.36290310376346e-5*std::pow(-8.16296005249023*x_55 - 7.95711994171143, 2) - 0.000461017024591028*std::pow(-3.24863982200623*x_68 - 5.47495985031128, 2) - 0.000284196021570881*std::pow(-5.7707200050354*x_7 - 9.56975936889648, 2) - 0.000134685948177228*std::pow(-4.89879989624023*x_70 - 7.14247989654541, 2) - 8.28957992239599e-5*std::pow(-5.09136009216309*x_85 - 8.60568046569824, 2) - 0.000199742764434479*std::pow(-6.66607999801636*x_86 - 8.43383884429932, 2) - 0.0214849113967753*std::exp(0.649039804935455*x_22) - 0.0692109011754161*std::sin(0.315999835729599*x_102 - 4.44975996017456) + 0.127088250472003*std::sin(0.270639955997467*x_112 - 7.53815984725952) - 0.184462486426522*std::sin(0.373199850320816*x_119 + 1.97575974464417) + 0.0559119169555289*std::sin(0.3572798371315*x_12 - 1.03671979904175) + 0.0916460976627675*std::sin(0.330799847841263*x_120 + 5.12911987304688) + 0.0733245439893615*std::sin(0.402959853410721*x_16 + 1.97447979450226) - 0.190134515734117*std::sin(0.390239834785461*x_23 + 1.97439980506897) + 0.341747878816872*std::sin(0.136960044503212*x_28 + 8.09280014038086) - 0.0919346947130251*std::sin(0.281439960002899*x_30 - 7.52135992050171) + 0.203364706383704*std::sin(0.292399942874908*x_33 + 8.20679950714111) - 0.181267070743028*std::sin(0.341119825839996*x_34 - 1.19039988517761) - 0.128850165526018*std::sin(0.285039931535721*x_36 - 7.51999998092651) - 0.160167214310327*std::sin(0.32711985707283*x_47 + 8.3133602142334) - 0.0609152691523418*std::sin(0.597679853439331*x_52 + 2.00543975830078) - 1.00486516742588*std::sin(0.134880036115646*x_80 + 4.91583967208862) + 0.207489058853811*std::sin(0.361599832773209*x_93 - 7.40575981140137) + 0.0405491444155026*std::sin(0.398239850997925*x_94 + 5.19799995422363) + 0.0726450257003242*std::sin(0.386799842119217*x_95 + 8.18487930297852) + 0.0872861703348393*std::sin(0.463359862565994*x_98 + 2.01143980026245) + 7.65478918029284) + 0.66244909403851);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00300972590686805*x_1 - 0.00369191935508024*x_10 - 6.96481021480759e-5*x_100 - 0.00131791669489394*x_101 + 0.000190210587844342*x_102 - 5.18774606529348e-5*x_103 - 0.000177202977185688*x_104 + 0.000484419407608233*x_105 + 3.45928785106855e-5*x_106 - 0.000228519697849334*x_107 + 8.05666987376438e-5*x_108 - 0.000977926294944371*x_109 + 0.00044333850990995*x_11 - 9.24835838531039e-7*x_110 - 0.000105061075504328*x_111 + 0.00101923657723663*x_112 + 0.000841023256598978*x_113 - 3.31926547425413e-5*x_114 - 1.75695547802206e-5*x_115 + 0.00154487470548658*x_116 + 0.000196263631350489*x_117 + 3.70935643936315e-5*x_118 - 0.000313741657811727*x_119 - 0.00395748707162733*x_12 - 0.00077807479265709*x_120 + 6.79654541046885e-6*x_13 + 0.00037045650224705*x_14 + 0.000426461412212563*x_15 + 9.32020280635055e-5*x_16 + 0.00317810978978619*x_17 + 0.000136087604590415*x_18 + 9.00828621330696e-5*x_19 - 0.000128685025641946*x_2 - 0.00333754391276603*x_20 + 0.00150961490620273*x_21 + 9.88235765217675e-5*x_22 + 0.000214888074765736*x_23 + 2.86153724791466e-5*x_24 - 0.00118955512891119*x_25 - 0.000813215913257807*x_26 - 0.000343931296044385*x_27 + 0.000264479402469799*x_28 - 0.00370241089118917*x_29 - 0.000632430622700344*x_3 + 0.00158722469215641*x_30 + 0.000882444897532419*x_31 + 0.00034148694682985*x_32 - 0.00101782816572619*x_33 + 1.02805211618389e-5*x_34 - 0.000146583778333951*x_35 - 4.45167387743074e-5*x_36 - 2.23858602757607e-6*x_37 + 0.000269087107471739*x_38 - 0.00101087917038977*x_39 + 0.00571402991796088*x_4 - 0.000608492340772195*x_40 + 6.78596035162776e-6*x_41 - 9.68300359569179e-5*x_42 + 0.000418340469982744*x_43 + 0.000641501811033881*x_44 - 0.000860112127658721*x_45 - 3.88316142278985e-5*x_46 - 0.000177209620901969*x_47 + 0.000770056881103349*x_48 + 0.000409940383808586*x_49 + 0.000288612425252945*x_5 - 3.00788024374602e-5*x_50 + 0.000215889045226917*x_51 - 0.000491978936352016*x_52 + 4.71059543058187e-5*x_53 - 0.000810695997599266*x_54 - 4.24867167798723e-5*x_55 + 2.86825137089624e-6*x_56 - 0.00158639944403*x_57 + 0.000428988649867244*x_58 + 0.000756690893547603*x_59 + 0.00217498445756918*x_6 - 0.00130378600622176*x_60 - 0.00109596072504196*x_61 + 0.000712226755227227*x_62 - 0.000389405535958169*x_63 - 0.000177996208240559*x_64 + 8.58907789108645e-5*x_65 - 0.000773902452679039*x_66 + 0.000763930028126825*x_67 + 0.000183057212094761*x_68 + 0.000253339804276917*x_69 + 0.00141137126598376*x_7 + 0.000478365881273077*x_70 + 0.000104998122177703*x_71 - 0.00134535834792921*x_72 - 0.000397134844755126*x_73 - 0.000854458162443093*x_74 - 0.00123139711516199*x_75 + 0.000269139004190116*x_76 + 0.000321438746381217*x_77 - 0.00011591474674526*x_78 + 7.27487112825395e-5*x_79 + 0.00120169300895857*x_8 + 0.000246917830692466*x_80 - 0.000852549246493827*x_81 - 0.000849465746972782*x_82 - 0.000135034251026642*x_83 - 4.43215858691336e-5*x_84 + 3.40824836089779e-5*x_85 - 3.93507240840023e-5*x_86 + 0.000322682799900121*x_87 - 0.000191944929494806*x_88 + 0.00011230510498368*x_89 - 0.00038561057876679*x_9 - 0.000379580769731305*x_90 - 0.00494454193443018*x_91 - 0.000162711821393699*x_92 - 0.000162717364192646*x_93 - 2.38680572295002e-6*x_94 + 8.91623688173681e-6*x_95 - 0.000194197822554305*x_96 + 0.000725173849195293*x_97 - 0.000178487631592896*x_98 + 0.000223558315225652*x_99 + 1.10457813256883e-6*std::pow(-5.55215978622437*x_100 - 7.38375997543335, 2) + 4.87767877707805e-8*std::pow(-9.58480072021484*x_106 - 7.96384000778198, 2) - 1.28109498620304e-7*std::pow(-7.98799991607666*x_106 - 8.19944000244141, 2) + 5.120620656605e-6*std::pow(-6.71752023696899*x_106 - 9.56103992462158, 2) + 7.67508129711906e-7*std::pow(-5.86383962631226*x_106 - 8.48952007293701, 2) - 3.58701683632981e-8*std::pow(-8.6636791229248*x_108 - 6.04663944244385, 2) - 1.85205200999863e-7*std::pow(-8.47000026702881*x_116 - 8.86903953552246, 2) + 2.03031108364644e-6*std::pow(-6.09335994720459*x_13 - 9.55160045623779, 2) - 3.74015138289509e-5*std::pow(-4.07000017166138*x_13 - 6.52231979370117, 2) - 2.0180220825831e-6*std::pow(-3.51191973686218*x_14 - 6.0479998588562, 2) - 1.33268853506624e-6*std::pow(-5.6691198348999*x_15 - 7.42512035369873, 2) + 1.41717177895264e-5*std::pow(-5.32231998443604*x_15 - 8.46951961517334, 2) - 5.55172680529892e-7*std::pow(-5.82096004486084*x_17 - 9.23791980743408, 2) + 4.36605157542204e-5*std::pow(-5.46256017684937*x_17 - 8.0926399230957, 2) + 1.49867241359165e-7*std::pow(-6.85031986236572*x_18 - 7.45431995391846, 2) - 3.09388056457846e-6*std::pow(-3.47519993782043*x_18 - 4.50079965591431, 2) - 4.13364973065143e-5*std::pow(-1.34583985805511*x_2 - 2.49487972259521, 2) - 5.81823359629089e-7*std::pow(-5.71983957290649*x_22 - 9.39935970306396, 2) + 2.00363979251993e-5*std::pow(-5.3167200088501*x_22 - 8.58440017700195, 2) - 3.1414580848568e-7*std::pow(-5.90136003494263*x_23 - 8.54720020294189, 2) - 2.82065979627193e-7*std::pow(-5.04120016098022*x_23 - 8.87744045257568, 2) + 1.21579644827096e-5*std::pow(-4.40399980545044*x_23 - 9.9993200302124, 2) - 1.58409730628156e-5*std::pow(-5.77959966659546*x_24 - 8.97016048431396, 2) + 1.25471816250152e-5*std::pow(-4.79911994934082*x_36 - 3.79999995231628, 2) - 4.5517915605626e-7*std::pow(-5.51895999908447*x_38 - 6.90023994445801, 2) + 1.97176015505815e-6*std::pow(-3.78287982940674*x_38 - 6.56720018386841, 2) - 1.58337849254528e-7*std::pow(-5.15136003494263*x_40 - 5.74847984313965, 2) + 1.98227659533664e-7*std::pow(-5.46367979049683*x_47 - 7.07823991775513, 2) - 4.31395960776054e-7*std::pow(-7.80000019073486*x_49 - 9.99882030487061, 2) - 3.66444952042087e-7*std::pow(-4.93391990661621*x_49 - 8.67199993133545, 2) + 0.000649231618170508*std::pow(-0.788719892501831*x_49 - 1.1847198009491, 2) + 4.23557527539334e-7*std::pow(-5.88295984268188*x_5 - 9.54328060150146, 2) - 1.01667709516853e-5*std::pow(-3.3374400138855*x_5 - 5.49232006072998, 2) + 3.12204292107081e-6*std::pow(-9.99993991851807*x_50 - 7.19999980926514, 2) - 2.83339491706046e-5*std::pow(-4.51688003540039*x_53 - 6.4747200012207, 2) - 1.21673488860494e-6*std::pow(-6.19600009918213*x_57 - 9.98884010314941, 2) - 4.85247709762203e-5*std::pow(-3.92007994651794*x_58 - 5.68487977981567, 2) + 2.88143937403528e-7*std::pow(-6.60400009155273*x_64 - 9.96195983886719, 2) + 8.75516700504675e-6*std::pow(-6.08367967605591*x_66 - 9.94783973693848, 2) + 1.53915105940904e-5*std::pow(-3.43055987358093*x_67 - 6.46231985092163, 2) + 1.04475154434902e-7*std::pow(-7.40719985961914*x_69 - 9.41207981109619, 2) + 7.95149941481108e-6*std::pow(-6.92199993133545*x_69 - 9.16287994384766, 2) - 4.37342079809641e-7*std::pow(-6.40399980545044*x_69 - 9.99507999420166, 2) + 4.08893392689835e-5*std::pow(-6.09127998352051*x_7 - 9.73591995239258, 2) + 5.0927627402067e-5*std::pow(-5.54423999786377*x_7 - 8.90136051177979, 2) + 1.26527927765522e-6*std::pow(-2.79311990737915*x_7 - 4.79031991958618, 2) + 7.44875286489637e-6*std::pow(-8.72799968719482*x_70 - 9.33439922332764, 2) + 6.33973009334339e-6*std::pow(-7.34127998352051*x_70 - 7.9312801361084, 2) + 1.27768306905362e-5*std::pow(-5.99983978271484*x_71 - 9.40424060821533, 2) - 9.17881655230443e-7*std::pow(-5.7838397026062*x_72 - 7.57272005081177, 2) - 1.05102652691523e-6*std::pow(-5.50311994552612*x_73 - 8.97648048400879, 2) - 9.04239399166703e-7*std::pow(-4.92944002151489*x_74 - 6.36568021774292, 2) - 2.62213551104851e-6*std::pow(-7.0*x_77 - 9.99993991851807, 2) + 2.43244705076814e-5*std::pow(-4.67551946640015*x_78 - 6.30359983444214, 2) - 3.4696118278203e-7*std::pow(-4.72591972351074*x_79 - 6.36720037460327, 2) - 1.31272900713838e-6*std::pow(-4.89039993286133*x_84 - 8.17303943634033, 2) - 1.59050839435268e-5*std::pow(-5.33200025558472*x_85 - 8.39999961853027, 2) - 3.40185984706088e-7*std::pow(-5.27888011932373*x_86 - 8.12639999389648, 2) - 1.08470410901937e-6*std::pow(-7.70527982711792*x_87 - 8.48975944519043, 2) - 1.40806078462677e-7*std::pow(-8.80000019073486*x_88 - 9.99983978271484, 2) + 2.02539507054544e-5*std::pow(-4.33304023742676*x_90 - 5.97864007949829, 2) - 3.70034635739521e-5*std::exp(0.715519845485687*x_22) + 5.99049935064207e-6*std::exp(0.656719863414764*x_69) + 0.00238685522037216*std::sin(0.217519998550415*x_1 + 1.81207990646362) + 0.000176757678517507*std::sin(0.322799921035767*x_1 + 1.95039975643158) - 0.00229233253618864*std::sin(0.269199937582016*x_10 + 5.06816005706787) + 0.0103694838813998*std::sin(0.367199838161469*x_101 + 8.17160034179688) + 0.000170686116674002*std::sin(0.183680012822151*x_102 + 1.7850399017334) + 0.000195024191627255*std::sin(0.324799835681915*x_102 + 5.12800025939941) + 0.00838499113304978*std::sin(0.394879847764969*x_102 + 2.00839972496033) - 0.000678718348859376*std::sin(0.178960010409355*x_103 - 7.6241602897644) + 0.018415019675122*std::sin(0.323359847068787*x_103 + 5.13160037994385) + 0.00396730731515036*std::sin(0.418079853057861*x_103 - 1.19207990169525) + 0.00691243969629596*std::sin(0.451519846916199*x_104 - 1.14063990116119) + 0.00045143831433851*std::sin(0.310239911079407*x_105 + 1.91767990589142) + 0.00107951261722847*std::sin(0.308159917593002*x_107 + 1.90919995307922) + 0.00307805115956545*std::sin(0.410559862852097*x_107 + 5.20783996582031) - 3.11679575802798e-6*std::sin(1.69463980197906*x_107 - 6.01591968536377) + 0.010916961530368*std::sin(0.444559872150421*x_108 - 4.1657600402832) - 0.00857143464993752*std::sin(0.330799847841263*x_110 - 4.43279981613159) - 0.0181688292342547*std::sin(0.394479840993881*x_110 + 5.18344020843506) - 0.0121696616826103*std::sin(0.303359925746918*x_111 - 7.49376010894775) - 0.000941566423827241*std::sin(0.362479835748672*x_112 - 7.42967987060547) - 0.0100379640240795*std::sin(0.398479819297791*x_112 - 4.41079998016357) + 0.0104275109967407*std::sin(0.271599948406219*x_113 + 5.0623197555542) + 0.00545856277521682*std::sin(0.395199835300446*x_114 - 1.21023988723755) - 0.0188162459142426*std::sin(0.20720000565052*x_115 - 1.37271988391876) + 0.0075680545176981*std::sin(0.269599944353104*x_115 + 1.86295986175537) + 0.0245686993480445*std::sin(0.189600005745888*x_117 + 8.18416023254395) + 0.00118564026196758*std::sin(0.350239843130112*x_117 - 7.43336009979248) + 0.00024179493537204*std::sin(0.238799974322319*x_118 - 1.3614399433136) - 0.000888677305095213*std::sin(0.279359966516495*x_118 - 7.5207200050354) + 0.00287499737643769*std::sin(0.279519945383072*x_118 + 1.8647198677063) + 0.00783119825172875*std::sin(0.398399829864502*x_119 + 8.18903923034668) - 0.000766371935470803*std::sin(0.416479855775833*x_12 - 4.17271995544434) - 0.00190921421021852*std::sin(0.328719854354858*x_120 - 7.45576000213623) + 0.0262168599932392*std::sin(0.165200024843216*x_13 + 4.96023941040039) - 0.00100945176459747*std::sin(0.277359962463379*x_13 - 1.07599985599518) - 0.0355032536742332*std::sin(0.182000011205673*x_14 + 8.18039894104004) - 0.0232320933541812*std::sin(0.205119997262955*x_14 - 4.38215970993042) + 0.0676733904374942*std::sin(0.287039935588837*x_15 + 5.13007974624634) + 0.000157992242151594*std::sin(1.16935980319977*x_15 + 5.98727989196777) + 0.000896645948781625*std::sin(0.292079925537109*x_16 + 8.31447982788086) + 0.000601635277465199*std::sin(0.345759838819504*x_16 + 5.15791988372803) - 0.00132919342872114*std::sin(0.358719855546951*x_16 + 8.34712028503418) - 0.000850657492598356*std::sin(1.44519984722137*x_16 - 3.38727998733521) + 0.00831805633107058*std::sin(0.412719875574112*x_18 - 7.16936016082764) + 3.75610138836008e-5*std::sin(1.47319984436035*x_2 - 3.38879990577698) - 0.0131550778858122*std::sin(0.363679856061935*x_21 + 5.15895986557007) - 0.0978331727056437*std::sin(0.179360017180443*x_23 - 7.61696004867554) - 0.0021361322439235*std::sin(0.186960011720657*x_24 + 4.96975994110107) + 0.00079092561455673*std::sin(0.271279960870743*x_24 + 1.85807991027832) - 0.000379267121780437*std::sin(0.333439826965332*x_24 + 5.13248014450073) + 0.00900610727020465*std::sin(0.547119855880737*x_24 + 8.55247974395752) + 1.99431562380378e-5*std::sin(1.16631984710693*x_25 - 8.98752021789551) - 0.00843985660404729*std::sin(0.338239848613739*x_26 - 7.44767951965332) + 0.0272846647097947*std::sin(0.339359849691391*x_26 + 8.35319995880127) + 0.000149913115171984*std::sin(0.353679865598679*x_26 + 1.9618399143219) - 0.00277804485851016*std::sin(0.32687982916832*x_27 + 8.30775928497314) - 0.00016643009009153*std::sin(0.378799855709076*x_27 - 7.41504001617432) + 0.00296994614296422*std::sin(0.19055999815464*x_28 - 4.42063999176025) - 0.00344527158410995*std::sin(0.457199841737747*x_28 - 7.13647985458374) - 0.000446308780776567*std::sin(0.300159931182861*x_3 - 1.0843198299408) + 0.000373390968483404*std::sin(0.359999865293503*x_3 - 1.0461597442627) - 0.010011815695148*std::sin(0.312719851732254*x_30 - 4.26567983627319) + 0.0180462968380761*std::sin(0.283119946718216*x_33 - 1.17807984352112) - 0.0172647756402786*std::sin(0.285759925842285*x_33 + 8.2041597366333) + 0.00250431563094643*std::sin(0.303599923849106*x_33 - 1.19399988651276) - 0.00773277894928588*std::sin(0.318159908056259*x_34 + 8.25111961364746) - 0.00406181656330888*std::sin(0.328159838914871*x_34 - 7.41232013702393) + 0.00105639696533403*std::sin(0.350879848003387*x_34 + 2.00583982467651) + 0.000956802754932139*std::sin(0.355279833078384*x_34 + 1.97823989391327) + 0.00916986739792681*std::sin(0.384159833192825*x_34 - 1.19863986968994) - 0.000558073733166486*std::sin(0.291759938001633*x_35 + 8.24959945678711) + 0.000124101731547664*std::sin(0.321279853582382*x_35 + 1.77135992050171) - 0.000166536830210522*std::sin(0.322319835424423*x_35 - 4.42935991287231) + 0.00667719364965741*std::sin(0.346479833126068*x_35 + 8.19127941131592) - 0.00884262003516977*std::sin(0.317039847373962*x_36 - 4.27767992019653) + 0.000336397612166552*std::sin(0.322799831628799*x_36 - 7.46775960922241) - 0.0017063324855702*std::sin(0.352559864521027*x_36 + 5.15791988372803) - 0.000739298025840992*std::sin(0.353839844465256*x_36 + 5.14800024032593) - 0.000383085216678109*std::sin(0.26335996389389*x_37 + 1.8458399772644) - 0.0143386797356728*std::sin(0.267279952764511*x_37 + 5.08191967010498) - 0.00449877758720642*std::sin(0.292879939079285*x_37 + 5.11407995223999) + 0.00247484873699297*std::sin(0.317519843578339*x_37 + 5.12696027755737) + 0.00476656626836708*std::sin(0.225279986858368*x_38 + 5.02023983001709) - 0.010528699077436*std::sin(0.256319969892502*x_41 - 4.32304000854492) + 0.000257063716876685*std::sin(0.333999842405319*x_41 + 5.13104009628296) + 5.90923640295704e-5*std::sin(0.360479861497879*x_41 + 4.78455972671509) - 0.00905663636796603*std::sin(0.363999843597412*x_41 - 1.21383988857269) + 0.00287809576339379*std::sin(0.465279847383499*x_41 - 4.34639978408813) + 0.0284235093669669*std::sin(0.198400005698204*x_42 + 5.00551986694336) + 0.000137536753970158*std::sin(0.403279840946198*x_42 + 8.20879936218262) + 0.00522221172000056*std::sin(0.409599870443344*x_42 + 2.00727987289429) - 0.000291604344125377*std::sin(0.189600005745888*x_43 - 7.60376024246216) - 0.00090912607446497*std::sin(0.236559987068176*x_43 - 7.55200004577637) + 0.00027267534853251*std::sin(0.26199996471405*x_43 + 5.06319952011108) - 0.000324916045723799*std::sin(0.337439835071564*x_43 + 5.13944005966187) + 0.00800607143957393*std::sin(0.356799840927124*x_43 + 5.16048002243042) - 0.0281852433753671*std::sin(0.294879943132401*x_47 - 7.48031997680664) - 3.92264018494978e-5*std::sin(1.76415991783142*x_49 - 7.41623973846436) - 0.0191054584860713*std::sin(0.285839945077896*x_50 + 5.09280014038086) - 0.000218333304772692*std::sin(0.254639983177185*x_51 + 1.83439981937408) - 0.0228926953851007*std::sin(0.335119843482971*x_51 + 5.13655996322632) + 0.000220002196622806*std::sin(0.477919846773148*x_51 + 8.44704055786133) + 0.0108732329432464*std::sin(0.26639997959137*x_52 + 8.27744007110596) - 0.00441818166040372*std::sin(0.409919857978821*x_52 + 5.20424032211304) - 0.0219252996663958*std::sin(0.166960015892982*x_53 - 7.6497597694397) - 0.000629134669658877*std::sin(0.383759826421738*x_54 - 7.42215967178345) + 5.54180496962049e-5*std::sin(0.454879850149155*x_54 - 1.15599977970123) - 0.000757707904900649*std::sin(0.460639864206314*x_54 - 1.13079988956451) - 0.0163872042584665*std::sin(0.331519842147827*x_55 - 4.2804799079895) - 0.000462005630576023*std::sin(0.330559849739075*x_57 + 1.92791974544525) + 0.000357738144534253*std::sin(0.350719839334488*x_58 - 7.43415975570679) + 0.00833395171481896*std::sin(0.320719838142395*x_59 - 4.28952026367188) + 1.08733426382957e-5*std::sin(1.39943981170654*x_6 - 5.19679975509644) + 0.0103211744305001*std::sin(0.305039942264557*x_62 - 4.27687978744507) + 0.0613797496623149*std::sin(0.130960047245026*x_64 + 4.91191959381104) - 0.00390665807286407*std::sin(0.186400011181831*x_64 - 4.42831993103027) + 0.0125222238308301*std::sin(0.220399990677834*x_65 + 5.01191997528076) - 0.00889697351589605*std::sin(0.306479841470718*x_67 - 7.49200010299683) + 0.00855118319650697*std::sin(0.14544004201889*x_68 + 4.9206395149231) + 0.000482081188097107*std::sin(0.167200013995171*x_71 - 4.45599985122681) + 0.000346798720089054*std::sin(0.207039996981621*x_73 - 7.59656000137329) + 0.0204223290891812*std::sin(0.250639975070953*x_73 - 7.52424001693726) + 0.00962373830526631*std::sin(0.23735998570919*x_75 - 7.56728029251099) - 0.000217066899910756*std::sin(0.269359946250916*x_75 + 5.09375953674316) + 0.0177519134159837*std::sin(0.22223998606205*x_76 - 7.56864023208618) - 0.0241602494338734*std::sin(0.242639973759651*x_79 + 1.85583996772766) - 0.00025001824370642*std::sin(0.243519976735115*x_79 - 7.54839992523193) - 0.0458945729664684*std::sin(0.182960003614426*x_80 - 7.60896015167236) + 0.00984436812505069*std::sin(0.281279861927032*x_84 - 1.29047977924347) + 0.000309728130733112*std::sin(0.295519828796387*x_85 - 1.26815986633301) - 0.00126611653666038*std::sin(0.157360032200813*x_86 - 7.64720010757446) - 0.0561008936621231*std::sin(0.173280015587807*x_86 - 7.63872003555298) + 0.00905665841201323*std::sin(0.364959836006165*x_86 + 1.95703983306885) - 0.0517743355962499*std::sin(0.184800013899803*x_88 - 7.60400009155273) - 0.00136873395869968*std::sin(0.214479997754097*x_88 + 5.01127958297729) - 0.0190396492737755*std::sin(0.314479917287827*x_9 + 8.34624004364014) + 0.00143515041964059*std::sin(0.356559842824936*x_9 - 4.25672006607056) - 0.00983919718741166*std::sin(0.336159855127335*x_92 + 5.19160032272339) - 0.00133207852059625*std::sin(0.361919850111008*x_92 - 7.40287971496582) - 0.000314831360202147*std::sin(0.367439836263657*x_92 + 1.98079979419708) + 0.00712184924517411*std::sin(0.367679834365845*x_92 - 1.3977597951889) + 0.000600040933126426*std::sin(0.392559856176376*x_92 + 1.97831988334656) + 0.00045182235933854*std::sin(0.345039844512939*x_93 - 1.42127990722656) + 0.00836837834326654*std::sin(0.409999877214432*x_93 + 1.99575984477997) + 0.00730820203784878*std::sin(0.422959864139557*x_93 - 7.60512018203735) + 0.00969200083927956*std::sin(0.36983984708786*x_94 + 5.17535972595215) - 0.000592877912889717*std::sin(0.379439830780029*x_94 + 4.98119974136353) - 0.000274190146040706*std::sin(0.328559845685959*x_95 + 1.94279980659485) + 0.000284875775304331*std::sin(0.344959855079651*x_95 - 7.42527961730957) - 0.000313904274875606*std::sin(0.373599827289581*x_95 - 7.42496013641357) - 0.00525013873849799*std::sin(0.343759834766388*x_96 - 4.42055988311768) + 0.0011864734983358*std::sin(0.346959829330444*x_96 + 1.94447982311249) + 7.10250326858668e-5*std::sin(0.42103984951973*x_96 - 1.15919995307922) + 0.00289914186049412*std::sin(0.449839860200882*x_96 + 8.23176002502441) + 0.00190100579905392*std::sin(0.312559932470322*x_97 + 1.90231990814209) - 0.00031625618597337*std::sin(0.371679842472076*x_97 - 7.43088006973267) - 0.00945200903824577*std::sin(0.411359876394272*x_97 + 8.21576023101807) + 0.011749686359052*std::sin(0.411279857158661*x_98 + 5.21224021911621) - 0.0107429435959393*std::sin(0.33247983455658*x_99 - 7.45544004440308) + 0.0010665609563909*std::sin(0.396479845046997*x_99 + 2.0019998550415) - 0.000567214337110443*std::sin(0.39743983745575*x_99 - 7.39287996292114) - 0.00627402894963189*std::sin(0.468479871749878*x_99 + 8.24679946899414) - 0.294046670198441*std::sin(0.00101337810079674*x_1 - 0.00113304565467129*x_10 - 0.000268907562088571*x_100 + 0.00262352638182286*x_101 + 8.32051990347648e-5*x_104 + 0.000136461577870207*x_105 + 0.000600775754550329*x_106 - 0.000156886993377951*x_107 - 6.06316159301792e-5*x_108 - 0.00106556801208413*x_109 + 0.000246400397991338*x_11 + 0.000960155989461699*x_110 - 0.000134477661708884*x_111 + 6.46067870325648e-5*x_113 - 5.79198554142446e-5*x_114 + 0.000304612894279514*x_116 - 0.000125325941567269*x_118 - 0.00782246356796861*x_119 - 0.0106809291151653*x_12 + 0.000172415810900655*x_120 + 0.00509074913906496*x_14 + 0.000356409046464054*x_15 - 0.00336534627415848*x_16 + 0.00522546489689638*x_17 - 0.00373704885613567*x_18 + 0.00301303574676731*x_19 - 0.00354001239004618*x_2 - 0.0116728977846157*x_20 - 0.000479110463579464*x_23 + 0.00281199239695458*x_25 + 0.00100508167273283*x_26 + 0.00673388263308921*x_27 - 0.00796840103338871*x_28 + 0.0252887838853314*x_29 - 0.00400567227941897*x_3 + 0.0171178884883952*x_30 - 0.0206358137149302*x_31 + 0.0133541532189259*x_32 - 0.00144554535800277*x_33 + 0.00600551964522708*x_34 + 0.000496816371096601*x_35 + 0.000502346308559956*x_37 + 0.000943415989572207*x_38 + 0.00142578182688723*x_4 + 0.00338700414956691*x_40 - 0.00272595659756799*x_42 + 0.00340714039055545*x_44 + 0.00432307577128322*x_45 + 0.00171304686904523*x_46 - 0.00038924174231442*x_47 + 0.00423525035647534*x_48 - 9.2835078182417e-5*x_49 + 0.00192193901867202*x_5 - 0.00104839715648449*x_51 - 0.000237247315872521*x_52 + 6.18839010718197e-5*x_53 + 0.00130694393674799*x_54 - 0.00412797443347803*x_55 - 0.000133046780423196*x_56 - 2.6915681396212e-5*x_57 - 0.000331392279895328*x_58 + 0.00023464687948537*x_59 + 0.0012761339591568*x_6 + 0.000347128838697965*x_60 + 0.000106504288571127*x_61 - 7.42610437949656e-6*x_62 - 0.000111589273549329*x_63 - 0.0050473880926463*x_64 + 0.00569990050741398*x_65 + 0.00132366918411865*x_66 - 0.0019782051932132*x_68 - 8.85172097343143e-5*x_69 - 0.012729369310595*x_7 - 0.000344321938228425*x_70 - 0.000152130802343572*x_71 - 0.000379186992140614*x_73 - 8.83114290087604e-5*x_74 + 0.000348562121335809*x_75 - 0.00504482958049816*x_77 + 8.40830125719428e-5*x_78 + 0.00289289288249891*x_79 + 0.000683555322089397*x_8 - 0.00122453057383641*x_80 + 0.000123139793399555*x_81 + 8.99608787033081e-5*x_83 + 0.00188158073017742*x_84 - 0.000398280732764827*x_85 - 0.0119697921222451*x_86 + 0.00322296307933647*x_87 - 0.00331855035800264*x_88 - 0.00116951613207375*x_89 - 0.00394795882032502*x_9 + 5.45236558954379e-5*x_90 + 0.0148441645672978*x_91 - 0.0020990600535661*x_92 - 0.000600030193044602*x_93 + 0.000541461145137026*x_94 + 0.000260799671771155*x_95 + 1.49053125537605e-5*x_96 - 0.00128341747554113*x_97 + 0.000110481252810443*x_98 + 0.000912217617196473*x_99 + 0.000347163759534381*std::pow(-4.98327970504761*x_22 - 7.76327991485596, 2) - 0.000208570629143947*std::pow(-4.69727993011475*x_72 - 5.92263984680176, 2) + 9.91222222486718e-5*std::pow(-5.28800010681152*x_82 - 7.51375961303711, 2) + 0.0113798499566159*std::exp(0.543359875679016*x_67) - 0.025216296282131*std::sin(0.467919856309891*x_102 + 5.0220799446106) + 0.0823917800319376*std::sin(0.366719841957092*x_103 - 7.41215991973877) - 0.13792581024692*std::sin(0.141760036349297*x_112 + 8.10503959655762) + 0.0235281165902723*std::sin(0.457519859075546*x_115 - 1.14735984802246) - 0.00130111089908543*std::sin(1.79807984828949*x_117 + 8.98896026611328) + 0.971411089287017*std::sin(0.126080051064491*x_13 + 8.07575988769531) - 0.0569474803869334*std::sin(0.243679970502853*x_21 + 8.26344013214111) - 0.151961942151025*std::sin(0.209600001573563*x_24 - 4.37680006027222) + 0.0575866417750133*std::sin(0.331679850816727*x_36 + 5.1483998298645) + 0.00830145897386475*std::sin(0.474399864673615*x_39 - 7.7836799621582) + 0.0628247256071481*std::sin(0.295359939336777*x_41 - 4.28927993774414) + 0.0694527060661154*std::sin(0.373679846525192*x_43 - 1.21103978157043) - 0.0951628822444723*std::sin(0.399759829044342*x_50 - 1.19031989574432) - 0.234671791512156*std::sin(0.171120017766953*x_76 - 7.64520025253296) - 6.35227252079306) + 0.404236257076263*std::sin(0.00717903889423961*x_1 - 0.0345415910344719*x_10 + 0.012914477814284*x_100 + 0.000397990751436089*x_101 + 0.000270004764715777*x_103 - 0.0104476954300018*x_104 + 0.00237499409894197*x_105 - 0.000912056902025253*x_106 + 0.00106911306209619*x_107 + 0.00820666937085168*x_108 - 0.000719273318156728*x_109 + 0.0010093282552616*x_11 + 0.0105154712620819*x_110 - 0.00457339751611107*x_111 + 0.000716463477474767*x_113 + 0.000610140010316534*x_114 + 0.000834604261564701*x_115 + 0.0173787788122485*x_116 + 0.000556944133856171*x_117 - 0.00678519882828194*x_118 - 0.00325026012208945*x_13 + 0.00335681716146923*x_15 + 0.0172100324350284*x_17 + 0.00104822760246297*x_19 - 0.00577624472523443*x_2 + 0.0312069685625721*x_20 + 0.0026464961827291*x_21 - 0.00693394039868207*x_24 + 0.0004251314084558*x_25 + 0.00657804382091675*x_26 + 0.00150468305065588*x_27 + 0.00181561248179706*x_29 + 0.0102159469586391*x_3 - 0.000623732289836803*x_31 + 0.0259279560721353*x_32 - 0.0111140266657395*x_35 - 0.000585797954940826*x_37 - 0.000680149017510977*x_38 - 0.000989407326337388*x_39 + 0.0042492980174653*x_4 + 8.71131461981404e-5*x_40 - 1.58599776909666e-5*x_41 + 0.00865709848226484*x_42 + 0.014727662216941*x_43 + 0.00146387294892729*x_44 + 0.000593005099714814*x_45 + 0.000414845871089063*x_46 - 0.00593679274994101*x_48 + 0.00238048207295419*x_49 + 0.00554004615207871*x_5 + 0.010953978000214*x_50 + 0.00826761744973986*x_51 - 2.17679088355004e-5*x_53 - 0.0121727572513411*x_56 - 0.00351906237912155*x_57 + 0.00276998719064857*x_58 + 0.000119512408531547*x_59 + 0.00580097538246205*x_6 + 0.000827274448851849*x_60 + 0.00026012212841216*x_61 + 0.0201529282233687*x_62 - 0.00158303993667204*x_63 + 0.00015873536299449*x_64 + 5.67586455707491e-5*x_65 + 0.00681158318085887*x_66 + 0.000244306616386922*x_67 - 0.000188420488632467*x_69 + 0.000378584926236133*x_71 - 0.00140608365298708*x_72 - 0.00250087042994251*x_73 + 0.000210654290363627*x_74 - 0.000285173470236574*x_75 - 0.00174940640464366*x_76 - 0.00037897650458337*x_77 - 0.00600215247414353*x_78 + 0.000348488725851984*x_79 + 0.00785730836686425*x_8 - 9.8209735960468e-6*x_81 + 1.99262801066348e-6*x_82 - 1.15609659427879e-5*x_83 - 0.000457444541278059*x_84 + 0.00861243558735181*x_87 - 0.00229491045886718*x_88 - 0.00158719225499193*x_89 + 0.0143909328625794*x_9 - 0.00199110357476292*x_90 + 0.0429586266037793*x_91 + 0.0117502083761467*x_92 + 0.000224840495316275*x_96 - 0.0078641020748076*x_97 + 0.00536548464497229*x_99 - 0.000239486725672276*std::pow(-5.10199975967407*x_14 - 7.75728034973145, 2) - 0.000297949879013156*std::pow(-5.03071975708008*x_18 - 7.24015998840332, 2) - 8.13643281180384e-5*std::pow(-7.36400032043457*x_54 - 9.79903984069824, 2) - 9.46217318961273e-6*std::pow(-8.16296005249023*x_55 - 7.95711994171143, 2) - 0.000320068456663911*std::pow(-3.24863982200623*x_68 - 5.47495985031128, 2) - 0.000197307641935585*std::pow(-5.7707200050354*x_7 - 9.56975936889648, 2) - 9.35078777310732e-5*std::pow(-4.89879989624023*x_70 - 7.14247989654541, 2) - 5.75517369343819e-5*std::pow(-5.09136009216309*x_85 - 8.60568046569824, 2) - 0.000138674614888768*std::pow(-6.66607999801636*x_86 - 8.43383884429932, 2) - 0.0149162440116546*std::exp(0.649039804935455*x_22) - 0.0480507771772318*std::sin(0.315999835729599*x_102 - 4.44975996017456) + 0.0882330543536334*std::sin(0.270639955997467*x_112 - 7.53815984725952) - 0.128066037030411*std::sin(0.373199850320816*x_119 + 1.97575974464417) + 0.0388177442795139*std::sin(0.3572798371315*x_12 - 1.03671979904175) + 0.0636267718403971*std::sin(0.330799847841263*x_120 + 5.12911987304688) + 0.0509067396178686*std::sin(0.402959853410721*x_16 + 1.97447979450226) - 0.132003934265866*std::sin(0.390239834785461*x_23 + 1.97439980506897) + 0.237263941040172*std::sin(0.136960044503212*x_28 + 8.09280014038086) - 0.0638271349670205*std::sin(0.281439960002899*x_30 - 7.52135992050171) + 0.141189206125054*std::sin(0.292399942874908*x_33 + 8.20679950714111) - 0.125847568488771*std::sin(0.341119825839996*x_34 - 1.19039988517761) - 0.0894562921128284*std::sin(0.285039931535721*x_36 - 7.51999998092651) - 0.11119865505605*std::sin(0.32711985707283*x_47 + 8.3133602142334) - 0.0422914017159188*std::sin(0.597679853439331*x_52 + 2.00543975830078) - 0.697643744455299*std::sin(0.134880036115646*x_80 + 4.91583967208862) + 0.144052603916093*std::sin(0.361599832773209*x_93 - 7.40575981140137) + 0.0281518932703739*std::sin(0.398239850997925*x_94 + 5.19799995422363) + 0.0504349731570963*std::sin(0.386799842119217*x_95 + 8.18487930297852) + 0.0605998224294622*std::sin(0.463359862565994*x_98 + 2.01143980026245) - 5.0764787129911) - 0.183908917753204);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00333824891228874*x_1 + 0.00366173998949588*x_10 - 0.000174457707886193*x_100 + 0.00202349593798766*x_101 - 0.000199964299575101*x_102 + 0.000313252777160674*x_103 + 0.00027296297671681*x_104 - 0.00142962275804737*x_105 - 0.000495177420779336*x_106 + 0.000538083047125575*x_107 + 2.25070059547164e-5*x_108 + 0.001687398293467*x_109 - 0.000307362621428907*x_11 - 5.4497609536176e-5*x_110 + 0.000283647396071963*x_111 - 9.51328789599831e-5*x_112 - 0.000931389357613628*x_113 - 8.56001258630324e-5*x_114 + 6.01101398743434e-5*x_115 - 0.00127283281871545*x_116 + 0.000478436764156183*x_117 + 0.000428109262305099*x_118 + 0.000523200418256477*x_119 + 0.00358252521782501*x_12 + 0.00172505203413605*x_120 - 9.3320678987323e-5*x_13 - 0.000118363468079813*x_14 - 7.01114944631967e-5*x_15 - 0.000260303104343789*x_16 - 0.00422503702668961*x_17 - 0.000169275206491589*x_18 - 0.00049359143519805*x_19 - 0.000812865321371243*x_2 + 0.00125807015386594*x_20 - 0.0017179538579802*x_21 - 0.0017251277859481*x_22 - 0.000660418754485792*x_23 - 0.000377063489339603*x_24 + 0.00165294145503827*x_25 + 0.000823014222873059*x_26 + 0.000283743266050417*x_27 - 0.000552174328779641*x_28 + 0.00494780988349078*x_29 + 0.000314446603398548*x_3 - 0.00226770096795904*x_30 - 0.0031660983009274*x_31 + 0.00041987082985623*x_32 + 0.000583353113511552*x_33 - 0.000399672044608588*x_34 + 0.000595869871921775*x_35 + 7.09926029371404e-5*x_36 - 5.34353780282107e-6*x_37 - 0.000344605968783275*x_38 + 0.00100089407702565*x_39 - 0.00489132527494357*x_4 + 0.000389308976318865*x_40 - 7.96105525873023e-5*x_41 + 0.000157824713301836*x_42 - 0.000739311117474889*x_43 - 0.000885790495786742*x_44 + 0.0011620764319971*x_45 - 3.31766355485895e-5*x_46 - 0.00123820527791621*x_47 - 0.00184200640703891*x_48 + 3.58185661392847e-5*x_49 - 0.000237799338788312*x_5 - 0.000158966109235141*x_50 - 0.000335369971945649*x_51 + 0.000731544760894512*x_52 - 2.66107148683391e-5*x_53 + 0.000865280292575696*x_54 + 1.97809251018273e-5*x_55 - 5.63447547985501e-5*x_56 + 0.001633340675741*x_57 - 0.00120627101497873*x_58 - 0.000405477141445711*x_59 - 0.00216554457937428*x_6 - 5.66934153169321e-5*x_60 - 0.000290696940507901*x_61 - 0.00361853864254643*x_62 - 0.00266792739895455*x_63 + 0.000304717980059981*x_64 + 0.000191218384697399*x_65 + 0.00138610775504407*x_66 - 0.00107486216624275*x_67 + 7.47587583865141e-5*x_68 - 0.000189953309117579*x_69 - 0.00163056889961388*x_7 + 0.000170596422837367*x_70 - 0.000977028057386994*x_71 + 4.55445381371527e-5*x_72 + 0.000396191994008087*x_73 + 0.00097340960343636*x_74 + 0.00124467412872963*x_75 - 0.00202429935831655*x_76 - 0.00171006543281346*x_77 + 0.000583694929244738*x_78 - 0.00100020023436714*x_79 - 0.00314585243128471*x_8 - 0.00032688077682224*x_80 + 0.000522384277114623*x_81 + 0.0012760658572714*x_82 - 0.00180516150124604*x_83 - 1.65756286466826e-5*x_84 - 0.000162096385253704*x_85 - 0.000787199904923686*x_86 - 0.000123899887668095*x_87 + 0.000489100512193771*x_88 - 0.00056702923625569*x_89 + 0.000663493631755995*x_9 - 0.000220041298331524*x_90 + 0.00591405122438002*x_91 + 0.00182261329794785*x_92 - 0.000626438496387761*x_93 + 5.30528756276265e-5*x_94 + 0.000350223686568174*x_95 + 6.59870499775612e-5*x_96 - 0.000983672652667028*x_97 + 0.000264385034061194*x_98 - 6.9021840389744e-5*x_99 - 1.06780262479514e-5*std::pow(-5.55215978622437*x_100 - 7.38375997543335, 2) + 1.94733492566757e-7*std::pow(-9.58480072021484*x_106 - 7.96384000778198, 2) + 5.21512478610107e-6*std::pow(-7.98799991607666*x_106 - 8.19944000244141, 2) - 5.45979918488301e-6*std::pow(-6.71752023696899*x_106 - 9.56103992462158, 2) - 7.41954934009082e-6*std::pow(-5.86383962631226*x_106 - 8.48952007293701, 2) - 5.45149778882455e-7*std::pow(-8.6636791229248*x_108 - 6.04663944244385, 2) + 7.53939594371447e-6*std::pow(-8.47000026702881*x_116 - 8.86903953552246, 2) - 1.9627144883146e-5*std::pow(-6.09335994720459*x_13 - 9.55160045623779, 2) + 3.98789069550185e-5*std::pow(-4.07000017166138*x_13 - 6.52231979370117, 2) - 1.83173835142021e-6*std::pow(-5.10199975967407*x_14 - 7.75728034973145, 2) - 3.06696160708775e-5*std::pow(-3.51191973686218*x_14 - 6.0479998588562, 2) - 9.0282774796346e-6*std::pow(-5.6691198348999*x_15 - 7.42512035369873, 2) - 1.65082122173247e-5*std::pow(-5.32231998443604*x_15 - 8.46951961517334, 2) - 8.4374363946984e-6*std::pow(-5.82096004486084*x_17 - 9.23791980743408, 2) - 4.9778517697719e-5*std::pow(-5.46256017684937*x_17 - 8.0926399230957, 2) + 2.27766127722632e-6*std::pow(-6.85031986236572*x_18 - 7.45431995391846, 2) - 2.27889967035693e-6*std::pow(-5.03071975708008*x_18 - 7.24015998840332, 2) + 2.99087379176745e-5*std::pow(-3.47519993782043*x_18 - 4.50079965591431, 2) - 0.000280033449601808*std::pow(-1.34583985805511*x_2 - 2.49487972259521, 2) - 2.32283633374826e-6*std::pow(-5.71983957290649*x_22 - 9.39935970306396, 2) - 2.13635643794251e-5*std::pow(-5.3167200088501*x_22 - 8.58440017700195, 2) + 2.11229347990596e-6*std::pow(-4.98327970504761*x_22 - 7.76327991485596, 2) - 1.25417669464225e-6*std::pow(-5.90136003494263*x_23 - 8.54720020294189, 2) - 1.91085153404781e-6*std::pow(-5.04120016098022*x_23 - 8.87744045257568, 2) - 1.41624509316434e-5*std::pow(-4.40399980545044*x_23 - 9.9993200302124, 2) + 1.68902439013041e-5*std::pow(-5.77959966659546*x_24 - 8.97016048431396, 2) - 1.33782790413255e-5*std::pow(-4.79911994934082*x_36 - 3.79999995231628, 2) - 3.08360401976262e-6*std::pow(-5.51895999908447*x_38 - 6.90023994445801, 2) - 2.29684471316677e-6*std::pow(-3.78287982940674*x_38 - 6.56720018386841, 2) - 6.32138437154604e-7*std::pow(-5.15136003494263*x_40 - 5.74847984313965, 2) + 7.91392099162555e-7*std::pow(-5.46367979049683*x_47 - 7.07823991775513, 2) - 2.92248513812434e-6*std::pow(-7.80000019073486*x_49 - 9.99882030487061, 2) - 5.56917889414579e-6*std::pow(-4.93391990661621*x_49 - 8.67199993133545, 2) - 0.000740206271885266*std::pow(-0.788719892501831*x_49 - 1.1847198009491, 2) + 2.86938379568413e-6*std::pow(-5.88295984268188*x_5 - 9.54328060150146, 2) + 9.82828139341615e-5*std::pow(-3.3374400138855*x_5 - 5.49232006072998, 2) - 3.63677486795027e-6*std::pow(-9.99993991851807*x_50 - 7.19999980926514, 2) + 3.02107269724504e-5*std::pow(-4.51688003540039*x_53 - 6.4747200012207, 2) - 6.22323261687994e-7*std::pow(-7.36400032043457*x_54 - 9.79903984069824, 2) - 7.23723850269342e-8*std::pow(-8.16296005249023*x_55 - 7.95711994171143, 2) + 1.1762252659399e-5*std::pow(-6.19600009918213*x_57 - 9.98884010314941, 2) + 5.173894392682e-5*std::pow(-3.92007994651794*x_58 - 5.68487977981567, 2) - 1.17298608307856e-5*std::pow(-6.60400009155273*x_64 - 9.96195983886719, 2) - 9.98199925444256e-6*std::pow(-6.08367967605591*x_66 - 9.94783973693848, 2) - 1.7548271459173e-5*std::pow(-3.43055987358093*x_67 - 6.46231985092163, 2) - 2.44807584013427e-6*std::pow(-3.24863982200623*x_68 - 5.47495985031128, 2) + 1.58779871792217e-6*std::pow(-7.40719985961914*x_69 - 9.41207981109619, 2) - 9.26246498378947e-6*std::pow(-6.92199993133545*x_69 - 9.16287994384766, 2) - 2.96276702781546e-6*std::pow(-6.40399980545044*x_69 - 9.99507999420166, 2) - 4.35977581981664e-5*std::pow(-6.09127998352051*x_7 - 9.73591995239258, 2) - 1.50912737959546e-6*std::pow(-5.7707200050354*x_7 - 9.56975936889648, 2) - 5.80639453781895e-5*std::pow(-5.54423999786377*x_7 - 8.90136051177979, 2) - 5.15074166498531e-5*std::pow(-2.79311990737915*x_7 - 4.79031991958618, 2) - 7.94214169481551e-6*std::pow(-8.72799968719482*x_70 - 9.33439922332764, 2) - 7.22809525262537e-6*std::pow(-7.34127998352051*x_70 - 7.9312801361084, 2) - 7.15204424458615e-7*std::pow(-4.89879989624023*x_70 - 7.14247989654541, 2) - 1.36231395503975e-5*std::pow(-5.99983978271484*x_71 - 9.40424060821533, 2) - 6.21817480892101e-6*std::pow(-5.7838397026062*x_72 - 7.57272005081177, 2) - 1.26903332488256e-6*std::pow(-4.69727993011475*x_72 - 5.92263984680176, 2) + 1.01603395095228e-5*std::pow(-5.50311994552612*x_73 - 8.97648048400879, 2) + 8.74133911765828e-6*std::pow(-4.92944002151489*x_74 - 6.36568021774292, 2) + 2.79581993784465e-6*std::pow(-7.0*x_77 - 9.99993991851807, 2) - 2.59356693566521e-5*std::pow(-4.67551946640015*x_78 - 6.30359983444214, 2) + 1.41242131428866e-5*std::pow(-4.72591972351074*x_79 - 6.36720037460327, 2) + 6.03102190304872e-7*std::pow(-5.28800010681152*x_82 - 7.51375961303711, 2) + 1.2690233838028e-5*std::pow(-4.89039993286133*x_84 - 8.17303943634033, 2) + 1.81338101231665e-5*std::pow(-5.33200025558472*x_85 - 8.39999961853027, 2) - 4.40190258719454e-7*std::pow(-5.09136009216309*x_85 - 8.60568046569824, 2) - 1.06066676450281e-6*std::pow(-6.66607999801636*x_86 - 8.43383884429932, 2) + 1.38484060887874e-5*std::pow(-5.27888011932373*x_86 - 8.12639999389648, 2) + 1.04859028128984e-5*std::pow(-7.70527982711792*x_87 - 8.48975944519043, 2) + 5.73198145128027e-6*std::pow(-8.80000019073486*x_88 - 9.99983978271484, 2) - 2.35932242971971e-5*std::pow(-4.33304023742676*x_90 - 5.97864007949829, 2) - 0.000114088395248592*std::exp(0.649039804935455*x_22) + 0.00150634950674548*std::exp(0.715519845485687*x_22) + 6.92398967504769e-5*std::exp(0.543359875679016*x_67) + 2.39161066991836e-5*std::exp(0.656719863414764*x_69) - 0.0230738794673772*std::sin(0.217519998550415*x_1 + 1.81207990646362) + 0.000705676647618967*std::sin(0.322799921035767*x_1 + 1.95039975643158) + 0.022160122737112*std::sin(0.269199937582016*x_10 + 5.06816005706787) - 0.0110563354405676*std::sin(0.367199838161469*x_101 + 8.17160034179688) + 0.000681436911934095*std::sin(0.183680012822151*x_102 + 1.7850399017334) - 0.000367521210722668*std::sin(0.315999835729599*x_102 - 4.44975996017456) + 0.00296395026266757*std::sin(0.324799835681915*x_102 + 5.12800025939941) - 0.00894039430443361*std::sin(0.394879847764969*x_102 + 2.00839972496033) - 0.000153426781342501*std::sin(0.467919856309891*x_102 + 5.0220799446106) + 0.0276294960329907*std::sin(0.178960010409355*x_103 - 7.6241602897644) - 0.0196347896386638*std::sin(0.323359847068787*x_103 + 5.13160037994385) + 0.000501306991238734*std::sin(0.366719841957092*x_103 - 7.41215991973877) - 0.00452323281088159*std::sin(0.418079853057861*x_103 - 1.19207990169525) - 0.00788105673541483*std::sin(0.451519846916199*x_104 - 1.14063990116119) + 0.00305826174649578*std::sin(0.310239911079407*x_105 + 1.91767990589142) - 0.0104357163353874*std::sin(0.308159917593002*x_107 + 1.90919995307922) - 0.00358553017443251*std::sin(0.410559862852097*x_107 + 5.20783996582031) - 1.24433065668508e-5*std::sin(1.69463980197906*x_107 - 6.01591968536377) - 0.011640076791867*std::sin(0.444559872150421*x_108 - 4.1657600402832) + 0.00977252109935309*std::sin(0.330799847841263*x_110 - 4.43279981613159) + 0.0193722920903169*std::sin(0.394479840993881*x_110 + 5.18344020843506) + 0.0141760766516287*std::sin(0.303359925746918*x_111 - 7.49376010894775) - 0.000839199892540812*std::sin(0.141760036349297*x_112 + 8.10503959655762) + 0.000674859406377545*std::sin(0.270639955997467*x_112 - 7.53815984725952) + 0.00910218181165242*std::sin(0.362479835748672*x_112 - 7.42967987060547) + 0.0107028564449237*std::sin(0.398479819297791*x_112 - 4.41079998016357) - 0.0121466971745587*std::sin(0.271599948406219*x_113 + 5.0623197555542) - 0.00582012583812854*std::sin(0.395199835300446*x_114 - 1.21023988723755) + 0.0214529034773534*std::sin(0.20720000565052*x_115 - 1.37271988391876) - 0.00881580143677265*std::sin(0.269599944353104*x_115 + 1.86295986175537) + 0.000143155170731978*std::sin(0.457519859075546*x_115 - 1.14735984802246) - 0.0280114289577157*std::sin(0.189600005745888*x_117 + 8.18416023254395) - 0.0114616589489009*std::sin(0.350239843130112*x_117 - 7.43336009979248) - 7.91651776227683e-6*std::sin(1.79807984828949*x_117 + 8.98896026611328) + 0.000965327451885978*std::sin(0.238799974322319*x_118 - 1.3614399433136) - 0.00602033039914664*std::sin(0.279359966516495*x_118 - 7.5207200050354) - 0.00334899886657081*std::sin(0.279519945383072*x_118 + 1.8647198677063) - 0.000979525987857961*std::sin(0.373199850320816*x_119 + 1.97575974464417) - 0.00892855785219037*std::sin(0.398399829864502*x_119 + 8.18903923034668) + 0.000296901428305925*std::sin(0.3572798371315*x_12 - 1.03671979904175) + 0.00740856567893409*std::sin(0.416479855775833*x_12 - 4.17271995544434) + 0.0184564937948423*std::sin(0.328719854354858*x_120 - 7.45576000213623) + 0.000486655775304254*std::sin(0.330799847841263*x_120 + 5.12911987304688) + 0.00591048245635243*std::sin(0.126080051064491*x_13 + 8.07575988769531) - 0.0298905408378262*std::sin(0.165200024843216*x_13 + 4.96023941040039) - 0.00683851507182039*std::sin(0.277359962463379*x_13 - 1.07599985599518) + 0.0413566834144064*std::sin(0.182000011205673*x_14 + 8.18039894104004) + 0.0247709355690452*std::sin(0.205119997262955*x_14 - 4.38215970993042) - 0.0721559253705526*std::sin(0.287039935588837*x_15 + 5.13007974624634) - 0.0015273209372197*std::sin(1.16935980319977*x_15 + 5.98727989196777) + 0.00607431385022637*std::sin(0.292079925537109*x_16 + 8.31447982788086) + 0.00914356841473942*std::sin(0.345759838819504*x_16 + 5.15791988372803) + 0.0128493964365209*std::sin(0.358719855546951*x_16 + 8.34712028503418) + 0.000389365327209897*std::sin(0.402959853410721*x_16 + 1.97447979450226) + 0.000969857279936309*std::sin(1.44519984722137*x_16 - 3.38727998733521) - 0.00948363772470544*std::sin(0.412719875574112*x_18 - 7.16936016082764) + 0.000570847011529418*std::sin(1.47319984436035*x_2 - 3.38879990577698) - 0.00034649293946962*std::sin(0.243679970502853*x_21 + 8.26344013214111) + 0.0149984549206906*std::sin(0.363679856061935*x_21 + 5.15895986557007) + 0.111542207755096*std::sin(0.179360017180443*x_23 - 7.61696004867554) - 0.00100964539163654*std::sin(0.390239834785461*x_23 + 1.97439980506897) - 0.0144711942242208*std::sin(0.186960011720657*x_24 + 4.96975994110107) - 0.000924601749992478*std::sin(0.209600001573563*x_24 - 4.37680006027222) - 0.00764592763824933*std::sin(0.271279960870743*x_24 + 1.85807991027832) - 0.00151416308074902*std::sin(0.333439826965332*x_24 + 5.13248014450073) - 0.0102681029390749*std::sin(0.547119855880737*x_24 + 8.55247974395752) + 0.000303093286412022*std::sin(1.16631984710693*x_25 - 8.98752021789551) + 0.00983133773707883*std::sin(0.338239848613739*x_26 - 7.44767951965332) - 0.031107973455434*std::sin(0.339359849691391*x_26 + 8.35319995880127) - 0.0061027137809056*std::sin(0.353679865598679*x_26 + 1.9618399143219) + 0.0268555342917849*std::sin(0.32687982916832*x_27 + 8.30775928497314) + 0.00677509238063483*std::sin(0.378799855709076*x_27 - 7.41504001617432) + 0.00181473715919904*std::sin(0.136960044503212*x_28 + 8.09280014038086) - 0.0287106560726683*std::sin(0.19055999815464*x_28 - 4.42063999176025) + 0.00392804596007292*std::sin(0.457199841737747*x_28 - 7.13647985458374) - 0.0067829381420632*std::sin(0.300159931182861*x_3 - 1.0843198299408) - 0.0152001257956329*std::sin(0.359999865293503*x_3 - 1.0461597442627) - 0.000488188272866348*std::sin(0.281439960002899*x_30 - 7.52135992050171) + 0.010674976108816*std::sin(0.312719851732254*x_30 - 4.26567983627319) - 0.0210215940201665*std::sin(0.283119946718216*x_33 - 1.17807984352112) + 0.0184083559961416*std::sin(0.285759925842285*x_33 + 8.2041597366333) + 0.0010798998689378*std::sin(0.292399942874908*x_33 + 8.20679950714111) - 0.0242093766406648*std::sin(0.303599923849106*x_33 - 1.19399988651276) + 0.00824498103559642*std::sin(0.318159908056259*x_34 + 8.25111961364746) + 0.00473148921046843*std::sin(0.328159838914871*x_34 - 7.41232013702393) - 0.000962557807689585*std::sin(0.341119825839996*x_34 - 1.19039988517761) + 0.00715654459442432*std::sin(0.350879848003387*x_34 + 2.00583982467651) - 0.00924947238229066*std::sin(0.355279833078384*x_34 + 1.97823989391327) - 0.0104548102253994*std::sin(0.384159833192825*x_34 - 1.19863986968994) - 0.00378066171093171*std::sin(0.291759938001633*x_35 + 8.24959945678711) + 0.000495456234867841*std::sin(0.321279853582382*x_35 + 1.77135992050171) - 0.00253100334644494*std::sin(0.322319835424423*x_35 - 4.42935991287231) - 0.0077780641289782*std::sin(0.346479833126068*x_35 + 8.19127941131592) - 0.00068421546362929*std::sin(0.285039931535721*x_36 - 7.51999998092651) + 0.0103005048693274*std::sin(0.317039847373962*x_36 - 4.27767992019653) - 0.0136941877385269*std::sin(0.322799831628799*x_36 - 7.46775960922241) + 0.000350381871985098*std::sin(0.331679850816727*x_36 + 5.1483998298645) + 0.0164952234083046*std::sin(0.352559864521027*x_36 + 5.15791988372803) - 0.00500836282583222*std::sin(0.353839844465256*x_36 + 5.14800024032593) + 0.0155947625289532*std::sin(0.26335996389389*x_37 + 1.8458399772644) + 0.0152884420040263*std::sin(0.267279952764511*x_37 + 5.08191967010498) + 0.00512917623336159*std::sin(0.292879939079285*x_37 + 5.11407995223999) - 0.0239245183243509*std::sin(0.317519843578339*x_37 + 5.12696027755737) - 0.046078695771258*std::sin(0.225279986858368*x_38 + 5.02023983001709) + 5.05096433098881e-5*std::sin(0.474399864673615*x_39 - 7.7836799621582) + 0.0122645681577937*std::sin(0.256319969892502*x_41 - 4.32304000854492) + 0.000382252624683072*std::sin(0.295359939336777*x_41 - 4.28927993774414) + 0.00390681825060555*std::sin(0.333999842405319*x_41 + 5.13104009628296) - 0.00240555193517147*std::sin(0.360479861497879*x_41 + 4.78455972671509) + 0.0103257125101878*std::sin(0.363999843597412*x_41 - 1.21383988857269) - 0.00306873442826187*std::sin(0.465279847383499*x_41 - 4.34639978408813) - 0.0303062194371122*std::sin(0.198400005698204*x_42 + 5.00551986694336) + 0.00209026426237126*std::sin(0.403279840946198*x_42 + 8.20879936218262) - 0.00608319898814826*std::sin(0.409599870443344*x_42 + 2.00727987289429) - 0.00116418351790665*std::sin(0.189600005745888*x_43 - 7.60376024246216) - 0.00615886026500014*std::sin(0.236559987068176*x_43 - 7.55200004577637) - 0.0111001602847992*std::sin(0.26199996471405*x_43 + 5.06319952011108) + 0.00314098384018398*std::sin(0.337439835071564*x_43 + 5.13944005966187) - 0.00932603431104351*std::sin(0.356799840927124*x_43 + 5.16048002243042) + 0.000422580105659768*std::sin(0.373679846525192*x_43 - 1.21103978157043) + 0.0300521712359348*std::sin(0.294879943132401*x_47 - 7.48031997680664) - 0.000850514117309565*std::sin(0.32711985707283*x_47 + 8.3133602142334) + 0.000379204092686061*std::sin(1.76415991783142*x_49 - 7.41623973846436) + 0.0217826424388953*std::sin(0.285839945077896*x_50 + 5.09280014038086) - 0.000579011864497771*std::sin(0.399759829044342*x_50 - 1.19031989574432) - 0.00331819888922777*std::sin(0.254639983177185*x_51 + 1.83439981937408) + 0.0244090566330326*std::sin(0.335119843482971*x_51 + 5.13655996322632) - 0.00212677506541069*std::sin(0.477919846773148*x_51 + 8.44704055786133) - 0.0126659054026729*std::sin(0.26639997959137*x_52 + 8.27744007110596) + 0.00471083219121538*std::sin(0.409919857978821*x_52 + 5.20424032211304) - 0.000323470047205772*std::sin(0.597679853439331*x_52 + 2.00543975830078) + 0.0249976185259785*std::sin(0.166960015892982*x_53 - 7.6497597694397) - 0.00426206290538567*std::sin(0.383759826421738*x_54 - 7.42215967178345) + 0.00084223573282401*std::sin(0.454879850149155*x_54 - 1.15599977970123) + 0.00732480995073947*std::sin(0.460639864206314*x_54 - 1.13079988956451) + 0.0190889664587693*std::sin(0.331519842147827*x_55 - 4.2804799079895) - 0.00312984986382176*std::sin(0.330559849739075*x_57 + 1.92791974544525) + 0.00242349142273092*std::sin(0.350719839334488*x_58 - 7.43415975570679) - 0.00950176047537758*std::sin(0.320719838142395*x_59 - 4.28952026367188) + 7.36612883555694e-5*std::sin(1.39943981170654*x_6 - 5.19679975509644) - 0.0117674460590914*std::sin(0.305039942264557*x_62 - 4.27687978744507) - 0.0699806885481365*std::sin(0.130960047245026*x_64 + 4.91191959381104) + 0.0377659091863421*std::sin(0.186400011181831*x_64 - 4.42831993103027) - 0.0142769211451086*std::sin(0.220399990677834*x_65 + 5.01191997528076) + 0.00948628926209521*std::sin(0.306479841470718*x_67 - 7.49200010299683) - 0.0826648255393129*std::sin(0.14544004201889*x_68 + 4.9206395149231) + 0.00732660216235364*std::sin(0.167200013995171*x_71 - 4.45599985122681) + 0.0052705982212982*std::sin(0.207039996981621*x_73 - 7.59656000137329) - 0.0237893632644454*std::sin(0.250639975070953*x_73 - 7.52424001693726) - 0.0109722805439056*std::sin(0.23735998570919*x_75 - 7.56728029251099) + 0.00883643275602741*std::sin(0.269359946250916*x_75 + 5.09375953674316) - 0.00142784401169583*std::sin(0.171120017766953*x_76 - 7.64520025253296) - 0.0206786755343952*std::sin(0.22223998606205*x_76 - 7.56864023208618) + 0.0275457443241292*std::sin(0.242639973759651*x_79 + 1.85583996772766) - 0.000998157689906828*std::sin(0.243519976735115*x_79 - 7.54839992523193) - 0.00533599847239928*std::sin(0.134880036115646*x_80 + 4.91583967208862) + 0.0523256258698633*std::sin(0.182960003614426*x_80 - 7.60896015167236) - 0.01049643718394*std::sin(0.281279861927032*x_84 - 1.29047977924347) + 0.00209824834080087*std::sin(0.295519828796387*x_85 - 1.26815986633301) - 0.0192422612296978*std::sin(0.157360032200813*x_86 - 7.64720010757446) + 0.0598168921364205*std::sin(0.173280015587807*x_86 - 7.63872003555298) - 0.0105498318034408*std::sin(0.364959836006165*x_86 + 1.95703983306885) + 0.0552037524829424*std::sin(0.184800013899803*x_88 - 7.60400009155273) - 0.00927246663401757*std::sin(0.214479997754097*x_88 + 5.01127958297729) + 0.0203007933132737*std::sin(0.314479917287827*x_9 + 8.34624004364014) - 0.0138736893288314*std::sin(0.356559842824936*x_9 - 4.25672006607056) + 0.0114613879298343*std::sin(0.336159855127335*x_92 + 5.19160032272339) - 0.00902414494622056*std::sin(0.361919850111008*x_92 - 7.40287971496582) + 0.0128162614615987*std::sin(0.367439836263657*x_92 + 1.98079979419708) - 0.00811981014349601*std::sin(0.367679834365845*x_92 - 1.3977597951889) + 0.00911933779349054*std::sin(0.392559856176376*x_92 + 1.97831988334656) + 0.00306086345329651*std::sin(0.345039844512939*x_93 - 1.42127990722656) + 0.00110180085545175*std::sin(0.361599832773209*x_93 - 7.40575981140137) - 0.00974807483871898*std::sin(0.409999877214432*x_93 + 1.99575984477997) - 0.00833227592929651*std::sin(0.422959864139557*x_93 - 7.60512018203735) - 0.0103339774278979*std::sin(0.36983984708786*x_94 + 5.17535972595215) + 0.00573138805576756*std::sin(0.379439830780029*x_94 + 4.98119974136353) + 0.000215322592196608*std::sin(0.398239850997925*x_94 + 5.19799995422363) - 0.00185749682352748*std::sin(0.328559845685959*x_95 + 1.94279980659485) - 0.0115968193830236*std::sin(0.344959855079651*x_95 - 7.42527961730957) - 0.00477067306474611*std::sin(0.373599827289581*x_95 - 7.42496013641357) + 0.000385756973900607*std::sin(0.386799842119217*x_95 + 8.18487930297852) + 0.00598582310802272*std::sin(0.343759834766388*x_96 - 4.42055988311768) - 0.0114697138972547*std::sin(0.346959829330444*x_96 + 1.94447982311249) + 0.000283556037752701*std::sin(0.42103984951973*x_96 - 1.15919995307922) - 0.00337712405736285*std::sin(0.449839860200882*x_96 + 8.23176002502441) - 0.0183771425680841*std::sin(0.312559932470322*x_97 + 1.90231990814209) + 0.0128742637508544*std::sin(0.371679842472076*x_97 - 7.43088006973267) + 0.0107764874294651*std::sin(0.411359876394272*x_97 + 8.21576023101807) - 0.0136868598982112*std::sin(0.411279857158661*x_98 + 5.21224021911621) + 0.000463503847746458*std::sin(0.463359862565994*x_98 + 2.01143980026245) + 0.0114545322963334*std::sin(0.33247983455658*x_99 - 7.45544004440308) - 0.0103105118158515*std::sin(0.396479845046997*x_99 + 2.0019998550415) - 0.00384258458830784*std::sin(0.39743983745575*x_99 - 7.39287996292114) + 0.00715318762754339*std::sin(0.468479871749878*x_99 + 8.24679946899414) + 0.00924323704599912);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00101157520492336*x_1 + 0.00282763596985886*x_10 + 0.000861737349307797*x_100 + 0.000691949512655197*x_101 - 6.35496260226167e-5*x_102 + 1.10358176188705e-5*x_103 + 0.000267437232846582*x_104 + 0.000859609098161544*x_105 + 0.000539193271032054*x_106 + 0.000116941660977107*x_107 + 0.000179596279119493*x_108 + 4.41544020809505e-5*x_109 - 0.000263556239165586*x_11 + 0.000263264946473062*x_110 - 0.000236285451371599*x_111 - 7.24193568164444e-5*x_112 + 4.6006649794509e-5*x_113 - 0.000100177909665583*x_114 + 6.14461456237885e-5*x_115 - 0.00174903927458493*x_116 + 0.000164271435641751*x_117 - 0.000952426112426192*x_118 + 0.000586613696749481*x_119 + 0.00489368748747288*x_12 - 0.000426287266503797*x_120 - 0.000152237398761051*x_13 - 0.000313882907190884*x_14 - 0.000657068860276586*x_15 + 0.000208569978206621*x_16 - 0.00324798654233088*x_17 + 0.000450729625766487*x_18 - 0.000643556952612895*x_19 + 0.00217705667122687*x_2 + 0.00503399413131992*x_20 - 0.000950632709595845*x_21 + 0.000691362215008483*x_22 + 0.000251466737351997*x_23 + 0.00012761602323524*x_24 + 3.04334352534696e-5*x_25 + 0.00110821159153414*x_26 - 0.00065166382366913*x_27 + 0.00102155446802062*x_28 - 0.000345543935146908*x_29 + 0.00125142273794711*x_3 - 0.00234270625395822*x_30 + 0.00133006543325253*x_31 - 0.000818144030429343*x_32 + 0.000676399306660763*x_33 - 0.000639349379931575*x_34 - 0.00030958263268014*x_35 + 5.33086899691124e-5*x_36 - 6.50625064654599e-5*x_37 - 0.000360319033118481*x_38 - 0.00111738470208278*x_39 - 0.00130981115393734*x_4 - 7.96541560570994e-5*x_40 - 3.89693037576716e-5*x_41 + 0.000579753302750629*x_42 + 0.000933950369840978*x_43 - 0.00102125282831025*x_44 - 0.000607928284804799*x_45 - 0.000117504872204281*x_46 + 0.000265961989204376*x_47 - 0.00194540460409242*x_48 - 0.000311534618818192*x_49 - 0.000424984180915087*x_5 + 0.000776571507379126*x_50 + 0.000725893508894596*x_51 - 1.33037555555528e-5*x_52 - 0.000264977355848748*x_53 - 6.7001857467195e-5*x_54 + 0.000563932352166073*x_55 - 0.000390857616461488*x_56 + 0.00047414836166728*x_57 + 0.000207072462636007*x_58 - 0.00131342850729622*x_59 - 0.000483581790501414*x_6 + 0.00169220402837907*x_60 - 0.000277830064431856*x_61 - 0.000542208329847216*x_62 + 0.000309383166225991*x_63 + 0.000649033718024791*x_64 - 0.000785924478807653*x_65 + 0.000382856760990045*x_66 + 0.000215643211390761*x_67 - 0.000225955387866857*x_68 - 0.000274576431019002*x_69 + 0.00153163760185641*x_7 + 0.000642878542417799*x_70 - 0.000589254527008123*x_71 - 0.000708052250259999*x_72 + 0.000296993473037112*x_73 - 4.30459845997346e-5*x_74 + 0.00125514887973242*x_75 - 0.00120723276636442*x_76 + 5.87796602864995e-5*x_77 + 0.000491436253815403*x_78 - 0.000926533332617461*x_79 - 0.000413231609881838*x_8 + 4.5939994954452e-5*x_80 - 5.46166741004532e-5*x_81 + 0.000513262275490623*x_82 - 0.000773618924443378*x_83 - 0.000187351269746778*x_84 + 1.79286269248255e-5*x_85 + 0.00147799643142468*x_86 - 0.000220288077552469*x_87 + 0.00159319163895281*x_88 - 0.00041562582744751*x_89 + 0.000448937274180618*x_9 + 0.000361689897688759*x_90 + 0.0034458366861418*x_91 + 0.00170601413140659*x_92 + 0.000594087596765791*x_93 - 7.45385769424177e-5*x_94 + 0.000349404870065993*x_95 + 0.000289497479730094*x_96 - 0.000144556336903616*x_97 + 0.000100751165487345*x_98 - 8.71190562896974e-5*x_99 - 6.81887096190367e-6*std::pow(-5.55215978622437*x_100 - 7.38375997543335, 2) + 1.09303598421952e-6*std::pow(-9.58480072021484*x_106 - 7.96384000778198, 2) - 4.04127701148254e-7*std::pow(-7.98799991607666*x_106 - 8.19944000244141, 2) - 4.76657458142621e-6*std::pow(-6.71752023696899*x_106 - 9.56103992462158, 2) - 4.73804318988849e-6*std::pow(-5.86383962631226*x_106 - 8.48952007293701, 2) + 8.17826349077491e-7*std::pow(-8.6636791229248*x_108 - 6.04663944244385, 2) - 5.84238896622397e-7*std::pow(-8.47000026702881*x_116 - 8.86903953552246, 2) - 1.25336804013229e-5*std::pow(-6.09335994720459*x_13 - 9.55160045623779, 2) + 3.48155266869811e-5*std::pow(-4.07000017166138*x_13 - 6.52231979370117, 2) - 7.6892263075561e-6*std::pow(-5.10199975967407*x_14 - 7.75728034973145, 2) + 4.60101445703098e-5*std::pow(-3.51191973686218*x_14 - 6.0479998588562, 2) + 7.42692667653648e-6*std::pow(-5.6691198348999*x_15 - 7.42512035369873, 2) + 9.74263820535086e-7*std::pow(-5.32231998443604*x_15 - 8.46951961517334, 2) + 1.26577283336615e-5*std::pow(-5.82096004486084*x_17 - 9.23791980743408, 2) - 5.88103936862513e-6*std::pow(-5.46256017684937*x_17 - 8.0926399230957, 2) - 3.41691674278532e-6*std::pow(-6.85031986236572*x_18 - 7.45431995391846, 2) - 9.56630912051562e-6*std::pow(-5.03071975708008*x_18 - 7.24015998840332, 2) + 1.90993934420366e-5*std::pow(-3.47519993782043*x_18 - 4.50079965591431, 2) + 0.00023036375453254*std::pow(-1.34583985805511*x_2 - 2.49487972259521, 2) - 1.30380432496429e-5*std::pow(-5.71983957290649*x_22 - 9.39935970306396, 2) - 1.865105647504e-5*std::pow(-5.3167200088501*x_22 - 8.58440017700195, 2) - 3.82460603759084e-5*std::pow(-4.98327970504761*x_22 - 7.76327991485596, 2) - 7.03967375999036e-6*std::pow(-5.90136003494263*x_23 - 8.54720020294189, 2) + 1.57192269124794e-6*std::pow(-5.04120016098022*x_23 - 8.87744045257568, 2) + 8.35824217132562e-7*std::pow(-4.40399980545044*x_23 - 9.9993200302124, 2) + 1.47457085009566e-5*std::pow(-5.77959966659546*x_24 - 8.97016048431396, 2) - 1.16796538960939e-5*std::pow(-4.79911994934082*x_36 - 3.79999995231628, 2) + 2.53666338965659e-6*std::pow(-5.51895999908447*x_38 - 6.90023994445801, 2) + 1.35552698012766e-7*std::pow(-3.78287982940674*x_38 - 6.56720018386841, 2) - 3.54818295358928e-6*std::pow(-5.15136003494263*x_40 - 5.74847984313965, 2) + 4.44207121543386e-6*std::pow(-5.46367979049683*x_47 - 7.07823991775513, 2) + 2.40412225732738e-6*std::pow(-7.80000019073486*x_49 - 9.99882030487061, 2) + 8.3548070985107e-6*std::pow(-4.93391990661621*x_49 - 8.67199993133545, 2) - 8.74510215891776e-5*std::pow(-0.788719892501831*x_49 - 1.1847198009491, 2) - 2.36043953073654e-6*std::pow(-5.88295984268188*x_5 - 9.54328060150146, 2) + 6.27623317669226e-5*std::pow(-3.3374400138855*x_5 - 5.49232006072998, 2) + 2.14631247201728e-7*std::pow(-9.99993991851807*x_50 - 7.19999980926514, 2) + 2.63749047166421e-5*std::pow(-4.51688003540039*x_53 - 6.4747200012207, 2) - 2.61237331841926e-6*std::pow(-7.36400032043457*x_54 - 9.79903984069824, 2) - 3.03803022117333e-7*std::pow(-8.16296005249023*x_55 - 7.95711994171143, 2) + 7.5112461089087e-6*std::pow(-6.19600009918213*x_57 - 9.98884010314941, 2) + 4.51697080131164e-5*std::pow(-3.92007994651794*x_58 - 5.68487977981567, 2) + 9.08964192950469e-7*std::pow(-6.60400009155273*x_64 - 9.96195983886719, 2) - 1.17931455792733e-6*std::pow(-6.08367967605591*x_66 - 9.94783973693848, 2) - 2.07322515968462e-6*std::pow(-3.43055987358093*x_67 - 6.46231985092163, 2) - 1.0276472695054e-5*std::pow(-3.24863982200623*x_68 - 5.47495985031128, 2) - 2.38199423140223e-6*std::pow(-7.40719985961914*x_69 - 9.41207981109619, 2) + 5.46642144157122e-7*std::pow(-6.92199993133545*x_69 - 9.16287994384766, 2) + 2.4372593249245e-6*std::pow(-6.40399980545044*x_69 - 9.99507999420166, 2) - 3.80621995420513e-5*std::pow(-6.09127998352051*x_7 - 9.73591995239258, 2) - 6.33497788570162e-6*std::pow(-5.7707200050354*x_7 - 9.56975936889648, 2) - 6.859913964101e-6*std::pow(-5.54423999786377*x_7 - 8.90136051177979, 2) + 3.99138558261662e-6*std::pow(-2.79311990737915*x_7 - 4.79031991958618, 2) - 6.93373683585473e-6*std::pow(-8.72799968719482*x_70 - 9.33439922332764, 2) - 8.53956981985627e-7*std::pow(-7.34127998352051*x_70 - 7.9312801361084, 2) - 3.00226758454004e-6*std::pow(-4.89879989624023*x_70 - 7.14247989654541, 2) - 1.18934247398585e-5*std::pow(-5.99983978271484*x_71 - 9.40424060821533, 2) + 5.11525354331619e-6*std::pow(-5.7838397026062*x_72 - 7.57272005081177, 2) + 2.29776428437675e-5*std::pow(-4.69727993011475*x_72 - 5.92263984680176, 2) + 6.48828186368798e-6*std::pow(-5.50311994552612*x_73 - 8.97648048400879, 2) + 5.5821237083949e-6*std::pow(-4.92944002151489*x_74 - 6.36568021774292, 2) + 2.4408378034989e-6*std::pow(-7.0*x_77 - 9.99993991851807, 2) - 2.26426463907283e-5*std::pow(-4.67551946640015*x_78 - 6.30359983444214, 2) - 1.09450608030994e-6*std::pow(-4.72591972351074*x_79 - 6.36720037460327, 2) - 1.09200179817199e-5*std::pow(-5.28800010681152*x_82 - 7.51375961303711, 2) + 8.1038447563751e-6*std::pow(-4.89039993286133*x_84 - 8.17303943634033, 2) + 2.14240311222449e-6*std::pow(-5.33200025558472*x_85 - 8.39999961853027, 2) - 1.84781986742335e-6*std::pow(-5.09136009216309*x_85 - 8.60568046569824, 2) - 4.45244091921863e-6*std::pow(-6.66607999801636*x_86 - 8.43383884429932, 2) - 1.07313338544545e-6*std::pow(-5.27888011932373*x_86 - 8.12639999389648, 2) + 6.69618303419457e-6*std::pow(-7.70527982711792*x_87 - 8.48975944519043, 2) - 4.44179685422667e-7*std::pow(-8.80000019073486*x_88 - 9.99983978271484, 2) + 1.39239940339545e-6*std::pow(-4.33304023742676*x_90 - 5.97864007949829, 2) - 0.000478917466270316*std::exp(0.649039804935455*x_22) - 0.000116729242013397*std::exp(0.715519845485687*x_22) - 0.00125368624044529*std::exp(0.543359875679016*x_67) + 0.000134240725003582*std::exp(0.656719863414764*x_69) - 0.0147347274697652*std::sin(0.217519998550415*x_1 + 1.81207990646362) + 0.00396095175464748*std::sin(0.322799921035767*x_1 + 1.95039975643158) + 0.0141512123996983*std::sin(0.269199937582016*x_10 + 5.06816005706787) - 0.00965252488052093*std::sin(0.367199838161469*x_101 + 8.17160034179688) + 0.00382489450531503*std::sin(0.183680012822151*x_102 + 1.7850399017334) - 0.00154277152077017*std::sin(0.315999835729599*x_102 - 4.44975996017456) - 0.00444647822683489*std::sin(0.324799835681915*x_102 + 5.12800025939941) - 0.00780524242676045*std::sin(0.394879847764969*x_102 + 2.00839972496033) + 0.00277800883178783*std::sin(0.467919856309891*x_102 + 5.0220799446106) - 0.00214105034369564*std::sin(0.178960010409355*x_103 - 7.6241602897644) - 0.0171417823319286*std::sin(0.323359847068787*x_103 + 5.13160037994385) - 0.00907687195750622*std::sin(0.366719841957092*x_103 - 7.41215991973877) - 0.000534393378199578*std::sin(0.418079853057861*x_103 - 1.19207990169525) - 0.000931100544391394*std::sin(0.451519846916199*x_104 - 1.14063990116119) - 0.00251581609006991*std::sin(0.310239911079407*x_105 + 1.91767990589142) - 0.0066641344976736*std::sin(0.308159917593002*x_107 + 1.90919995307922) + 0.000211606943283684*std::sin(0.410559862852097*x_107 + 5.20783996582031) - 6.98440810616099e-5*std::sin(1.69463980197906*x_107 - 6.01591968536377) - 0.0101621492445333*std::sin(0.444559872150421*x_108 - 4.1657600402832) + 0.00115456594479206*std::sin(0.330799847841263*x_110 - 4.43279981613159) + 0.0169126138040638*std::sin(0.394479840993881*x_110 + 5.18344020843506) - 0.000836628365142994*std::sin(0.303359925746918*x_111 - 7.49376010894775) + 0.0151949007384148*std::sin(0.141760036349297*x_112 + 8.10503959655762) + 0.00283290825755577*std::sin(0.270639955997467*x_112 - 7.53815984725952) + 0.0058125539125128*std::sin(0.362479835748672*x_112 - 7.42967987060547) + 0.00934392671808863*std::sin(0.398479819297791*x_112 - 4.41079998016357) + 0.000716860641260044*std::sin(0.271599948406219*x_113 + 5.0623197555542) - 0.00508115096202387*std::sin(0.395199835300446*x_114 - 1.21023988723755) + 0.00253453448910978*std::sin(0.20720000565052*x_115 - 1.37271988391876) + 0.000520281437856432*std::sin(0.269599944353104*x_115 + 1.86295986175537) - 0.00259202679694985*std::sin(0.457519859075546*x_115 - 1.14735984802246) - 0.00330938573687824*std::sin(0.189600005745888*x_117 + 8.18416023254395) - 0.00731929024775511*std::sin(0.350239843130112*x_117 - 7.43336009979248) + 0.00014333974856395*std::sin(1.79807984828949*x_117 + 8.98896026611328) + 0.00541836757282313*std::sin(0.238799974322319*x_118 - 1.3614399433136) + 0.00495250091103706*std::sin(0.279359966516495*x_118 - 7.5207200050354) + 0.000197647594285755*std::sin(0.279519945383072*x_118 + 1.8647198677063) - 0.00411183015791128*std::sin(0.373199850320816*x_119 + 1.97575974464417) - 0.00105485664624732*std::sin(0.398399829864502*x_119 + 8.18903923034668) + 0.00124632553088756*std::sin(0.3572798371315*x_12 - 1.03671979904175) + 0.00473102914381126*std::sin(0.416479855775833*x_12 - 4.17271995544434) + 0.0117861153994026*std::sin(0.328719854354858*x_120 - 7.45576000213623) + 0.00204287167285233*std::sin(0.330799847841263*x_120 + 5.12911987304688) - 0.10701764268404*std::sin(0.126080051064491*x_13 + 8.07575988769531) - 0.00353139176389755*std::sin(0.165200024843216*x_13 + 4.96023941040039) + 0.00562556369466562*std::sin(0.277359962463379*x_13 - 1.07599985599518) - 0.00244074402833848*std::sin(0.182000011205673*x_14 + 8.18039894104004) + 0.0216257975510298*std::sin(0.205119997262955*x_14 - 4.38215970993042) - 0.0629943681303972*std::sin(0.287039935588837*x_15 + 5.13007974624634) - 0.000975330472737221*std::sin(1.16935980319977*x_15 + 5.98727989196777) - 0.00499690928614737*std::sin(0.292079925537109*x_16 + 8.31447982788086) - 0.0137170580707123*std::sin(0.345759838819504*x_16 + 5.15791988372803) + 0.00820548425377682*std::sin(0.358719855546951*x_16 + 8.34712028503418) + 0.00163446821698702*std::sin(0.402959853410721*x_16 + 1.97447979450226) + 0.000114582938766666*std::sin(1.44519984722137*x_16 - 3.38727998733521) - 0.00112043607154913*std::sin(0.412719875574112*x_18 - 7.16936016082764) - 0.000856376991068291*std::sin(1.47319984436035*x_2 - 3.38879990577698) + 0.00627374463295274*std::sin(0.243679970502853*x_21 + 8.26344013214111) + 0.00177197931832294*std::sin(0.363679856061935*x_21 + 5.15895986557007) + 0.0131780564269623*std::sin(0.179360017180443*x_23 - 7.61696004867554) - 0.00423826465207504*std::sin(0.390239834785461*x_23 + 1.97439980506897) + 0.0119044301271914*std::sin(0.186960011720657*x_24 + 4.96975994110107) + 0.0167412221314328*std::sin(0.209600001573563*x_24 - 4.37680006027222) - 0.00488260589912648*std::sin(0.271279960870743*x_24 + 1.85807991027832) - 0.00849897319367392*std::sin(0.333439826965332*x_24 + 5.13248014450073) - 0.00121311602712835*std::sin(0.547119855880737*x_24 + 8.55247974395752) - 0.000454696462253706*std::sin(1.16631984710693*x_25 - 8.98752021789551) - 0.000580215261265246*std::sin(0.338239848613739*x_26 - 7.44767951965332) - 0.00367522427406342*std::sin(0.339359849691391*x_26 + 8.35319995880127) + 0.000472908279705227*std::sin(0.353679865598679*x_26 + 1.9618399143219) + 0.0171496509463809*std::sin(0.32687982916832*x_27 + 8.30775928497314) - 0.000525011887759639*std::sin(0.378799855709076*x_27 - 7.41504001617432) + 0.00761785911999602*std::sin(0.136960044503212*x_28 + 8.09280014038086) - 0.0183343114584196*std::sin(0.19055999815464*x_28 - 4.42063999176025) + 0.000464075549080006*std::sin(0.457199841737747*x_28 - 7.13647985458374) + 0.0101756723594638*std::sin(0.300159931182861*x_3 - 1.0843198299408) + 0.00117788013650693*std::sin(0.359999865293503*x_3 - 1.0461597442627) - 0.00204930475351671*std::sin(0.281439960002899*x_30 - 7.52135992050171) + 0.00931958631711193*std::sin(0.312719851732254*x_30 - 4.26567983627319) + 0.0012406297080632*std::sin(0.283119946718216*x_33 - 1.17807984352112) + 0.0160710675989695*std::sin(0.285759925842285*x_33 + 8.2041597366333) + 0.0045331771731071*std::sin(0.292399942874908*x_33 + 8.20679950714111) - 0.0154598435654238*std::sin(0.303599923849106*x_33 - 1.19399988651276) + 0.0071981250038333*std::sin(0.318159908056259*x_34 + 8.25111961364746) - 0.000279237914701253*std::sin(0.328159838914871*x_34 - 7.41232013702393) - 0.00404060154753641*std::sin(0.341119825839996*x_34 - 1.19039988517761) - 0.00588718413673569*std::sin(0.350879848003387*x_34 + 2.00583982467651) - 0.00590661206256465*std::sin(0.355279833078384*x_34 + 1.97823989391327) - 0.00123517439592011*std::sin(0.384159833192825*x_34 - 1.19863986968994) + 0.00311008355461126*std::sin(0.291759938001633*x_35 + 8.24959945678711) + 0.00278098793473248*std::sin(0.321279853582382*x_35 + 1.77135992050171) + 0.00379697709970509*std::sin(0.322319835424423*x_35 - 4.42935991287231) + 0.000459037379390635*std::sin(0.346479833126068*x_35 + 8.19127941131592) - 0.00287218288512435*std::sin(0.285039931535721*x_36 - 7.51999998092651) - 0.000607904059829045*std::sin(0.317039847373962*x_36 - 4.27767992019653) + 0.00106118277833213*std::sin(0.322799831628799*x_36 - 7.46775960922241) - 0.00634415925535237*std::sin(0.331679850816727*x_36 + 5.1483998298645) + 0.010533669546896*std::sin(0.352559864521027*x_36 + 5.15791988372803) + 0.00412002661203678*std::sin(0.353839844465256*x_36 + 5.14800024032593) - 0.00120846111824114*std::sin(0.26335996389389*x_37 + 1.8458399772644) + 0.0133472856012308*std::sin(0.267279952764511*x_37 + 5.08191967010498) + 0.000605982033056764*std::sin(0.292879939079285*x_37 + 5.11407995223999) - 0.0152779361551716*std::sin(0.317519843578339*x_37 + 5.12696027755737) - 0.0294253519574654*std::sin(0.225279986858368*x_38 + 5.02023983001709) - 0.000914548516090474*std::sin(0.474399864673615*x_39 - 7.7836799621582) - 0.000723817023510584*std::sin(0.256319969892502*x_41 - 4.32304000854492) - 0.00692122430029426*std::sin(0.295359939336777*x_41 - 4.28927993774414) - 0.00586095607147073*std::sin(0.333999842405319*x_41 + 5.13104009628296) + 0.000186409762647382*std::sin(0.360479861497879*x_41 + 4.78455972671509) + 0.00121992225944289*std::sin(0.363999843597412*x_41 - 1.21383988857269) - 0.00267910064593593*std::sin(0.465279847383499*x_41 - 4.34639978408813) - 0.0264582726097387*std::sin(0.198400005698204*x_42 + 5.00551986694336) - 0.00313578626741192*std::sin(0.403279840946198*x_42 + 8.20879936218262) + 0.000359011660938591*std::sin(0.409599870443344*x_42 + 2.00727987289429) - 0.00653454349600909*std::sin(0.189600005745888*x_43 - 7.60376024246216) + 0.00506645965438817*std::sin(0.236559987068176*x_43 - 7.55200004577637) + 0.000860167770142044*std::sin(0.26199996471405*x_43 + 5.06319952011108) + 0.00200579798197708*std::sin(0.337439835071564*x_43 + 5.13944005966187) + 0.000550393809984048*std::sin(0.356799840927124*x_43 + 5.16048002243042) - 0.00765141036909358*std::sin(0.373679846525192*x_43 - 1.21103978157043) + 0.026236480624872*std::sin(0.294879943132401*x_47 - 7.48031997680664) - 0.00357026729319394*std::sin(0.32711985707283*x_47 + 8.3133602142334) + 0.000242155592822979*std::sin(1.76415991783142*x_49 - 7.41623973846436) + 0.00257349120987783*std::sin(0.285839945077896*x_50 + 5.09280014038086) + 0.0104838285676737*std::sin(0.399759829044342*x_50 - 1.19031989574432) + 0.0049779172407502*std::sin(0.254639983177185*x_51 + 1.83439981937408) + 0.0213098659792739*std::sin(0.335119843482971*x_51 + 5.13655996322632) - 0.00135813533318594*std::sin(0.477919846773148*x_51 + 8.44704055786133) + 0.000747502711116943*std::sin(0.26639997959137*x_52 + 8.27744007110596) + 0.00411270309028642*std::sin(0.409919857978821*x_52 + 5.20424032211304) - 0.0013578546274104*std::sin(0.597679853439331*x_52 + 2.00543975830078) + 0.00295332174344534*std::sin(0.166960015892982*x_53 - 7.6497597694397) + 0.00350609834051828*std::sin(0.383759826421738*x_54 - 7.42215967178345) - 0.00126351069214427*std::sin(0.454879850149155*x_54 - 1.15599977970123) + 0.00467754365036729*std::sin(0.460639864206314*x_54 - 1.13079988956451) - 0.00112657198413461*std::sin(0.331519842147827*x_55 - 4.2804799079895) + 0.0025747065815829*std::sin(0.330559849739075*x_57 + 1.92791974544525) - 0.00199363534610437*std::sin(0.350719839334488*x_58 - 7.43415975570679) - 0.0011225771680522*std::sin(0.320719838142395*x_59 - 4.28952026367188) - 6.05959429968878e-5*std::sin(1.39943981170654*x_6 - 5.19679975509644) - 0.00139025460665455*std::sin(0.305039942264557*x_62 - 4.27687978744507) - 0.00826780714713695*std::sin(0.130960047245026*x_64 + 4.91191959381104) + 0.024116897216847*std::sin(0.186400011181831*x_64 - 4.42831993103027) - 0.00168673434245286*std::sin(0.220399990677834*x_65 + 5.01191997528076) + 0.00828182571145762*std::sin(0.306479841470718*x_67 - 7.49200010299683) - 0.0527888549205426*std::sin(0.14544004201889*x_68 + 4.9206395149231) - 0.0109912697935312*std::sin(0.167200013995171*x_71 - 4.45599985122681) - 0.00790688039829151*std::sin(0.207039996981621*x_73 - 7.59656000137329) + 0.00140397492090586*std::sin(0.250639975070953*x_73 - 7.52424001693726) - 0.0012963104734086*std::sin(0.23735998570919*x_75 - 7.56728029251099) - 0.000684748189642893*std::sin(0.269359946250916*x_75 + 5.09375953674316) + 0.025853134897301*std::sin(0.171120017766953*x_76 - 7.64520025253296) + 0.00122039171562153*std::sin(0.22223998606205*x_76 - 7.56864023208618) + 0.00325436783377158*std::sin(0.242639973759651*x_79 + 1.85583996772766) - 0.00560264317459194*std::sin(0.243519976735115*x_79 - 7.54839992523193) - 0.0223993234619125*std::sin(0.134880036115646*x_80 + 4.91583967208862) + 0.00618196523241825*std::sin(0.182960003614426*x_80 - 7.60896015167236) - 0.00916371628008467*std::sin(0.281279861927032*x_84 - 1.29047977924347) - 0.00172608081790183*std::sin(0.295519828796387*x_85 - 1.26815986633301) + 0.0288669808905349*std::sin(0.157360032200813*x_86 - 7.64720010757446) + 0.052222008162281*std::sin(0.173280015587807*x_86 - 7.63872003555298) + 0.000622618567262912*std::sin(0.364959836006165*x_86 + 1.95703983306885) + 0.048194593697346*std::sin(0.184800013899803*x_88 - 7.60400009155273) + 0.00762780385924367*std::sin(0.214479997754097*x_88 + 5.01127958297729) + 0.0177232242639545*std::sin(0.314479917287827*x_9 + 8.34624004364014) - 0.00885958650991241*std::sin(0.356559842824936*x_9 - 4.25672006607056) - 0.000676415801187508*std::sin(0.336159855127335*x_92 + 5.19160032272339) + 0.00742352713296644*std::sin(0.361919850111008*x_92 - 7.40287971496582) - 0.000993150978015821*std::sin(0.367439836263657*x_92 + 1.98079979419708) - 0.000959307856646962*std::sin(0.367679834365845*x_92 - 1.3977597951889) - 0.0136807076193694*std::sin(0.392559856176376*x_92 + 1.97831988334656) - 0.00251795633062925*std::sin(0.345039844512939*x_93 - 1.42127990722656) + 0.00462511259692672*std::sin(0.361599832773209*x_93 - 7.40575981140137) + 0.000575301341550805*std::sin(0.409999877214432*x_93 + 1.99575984477997) - 0.000984409440795497*std::sin(0.422959864139557*x_93 - 7.60512018203735) - 0.00902188385778625*std::sin(0.36983984708786*x_94 + 5.17535972595215) + 0.00366000182780715*std::sin(0.379439830780029*x_94 + 4.98119974136353) + 0.000903875894308615*std::sin(0.398239850997925*x_94 + 5.19799995422363) + 0.00152803153662002*std::sin(0.328559845685959*x_95 + 1.94279980659485) + 0.000898654615203679*std::sin(0.344959855079651*x_95 - 7.42527961730957) + 0.00715689941795775*std::sin(0.373599827289581*x_95 - 7.42496013641357) + 0.00161932116000083*std::sin(0.386799842119217*x_95 + 8.18487930297852) + 0.000707189827661758*std::sin(0.343759834766388*x_96 - 4.42055988311768) - 0.00732443404981684*std::sin(0.346959829330444*x_96 + 1.94447982311249) + 0.00159159551200552*std::sin(0.42103984951973*x_96 - 1.15919995307922) + 0.000199307456387938*std::sin(0.449839860200882*x_96 + 8.23176002502441) - 0.0117354425724804*std::sin(0.312559932470322*x_97 + 1.90231990814209) - 0.000997645660843108*std::sin(0.371679842472076*x_97 - 7.43088006973267) + 0.00127317866741303*std::sin(0.411359876394272*x_97 + 8.21576023101807) + 0.000807756299714003*std::sin(0.411279857158661*x_98 + 5.21224021911621) + 0.00194568507941228*std::sin(0.463359862565994*x_98 + 2.01143980026245) + 0.010000163126329*std::sin(0.33247983455658*x_99 - 7.45544004440308) - 0.00658418025868432*std::sin(0.396479845046997*x_99 + 2.0019998550415) + 0.00316102313537959*std::sin(0.39743983745575*x_99 - 7.39287996292114) + 0.000845107086237575*std::sin(0.468479871749878*x_99 + 8.24679946899414) + 0.210644132176615);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
