
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (6.37049652747223e-5*x_1 + 0.000195455481055177*x_10 + 0.00019015055742964*x_100 - 4.07736115032222e-5*x_101 + 0.000129733032991591*x_102 - 4.452942563734e-5*x_103 + 6.24372719000697e-5*x_104 + 5.85428463657282e-5*x_105 - 1.87378223502944e-5*x_106 - 4.20857720614917e-5*x_107 + 5.29603695154273e-5*x_108 + 3.66392278699016e-5*x_109 + 6.04188423757475e-5*x_11 + 1.57022266977364e-6*x_110 + 1.44693305103955e-6*x_111 - 0.000519970826150758*x_112 + 7.28507227078465e-7*x_113 - 9.16445680280378e-5*x_114 + 2.61688922813277e-5*x_115 + 8.57215820372949e-5*x_116 - 4.4326198175402e-6*x_117 + 9.05395152473351e-5*x_118 + 9.30397558424156e-5*x_119 - 0.000160565430662432*x_12 + 5.22698522122182e-5*x_120 - 0.000246118597005963*x_13 - 0.000171953826078661*x_14 - 0.00024382953048912*x_15 - 0.000133708955002926*x_16 - 2.35151599506942e-5*x_17 + 0.000524841231144057*x_18 + 0.000275170054210365*x_19 - 5.02134352675413e-5*x_2 + 0.000230263729413569*x_20 - 6.29133384694189e-6*x_21 + 6.66449125031427e-5*x_22 - 0.000208970413594163*x_23 + 7.51848154549553e-5*x_24 - 6.31575318813474e-5*x_25 + 6.99833143671279e-5*x_26 + 1.84605105745533e-5*x_27 + 0.00013098791059946*x_28 + 6.6674924340192e-5*x_29 + 9.48296419617337e-5*x_3 + 0.000246974171516659*x_30 - 6.20671112262575e-5*x_31 - 5.64457014384461e-5*x_32 - 0.000323811135231267*x_33 - 0.000150969115198962*x_34 - 0.000145076431578415*x_35 + 2.93415662084757e-5*x_36 + 0.000494231546884338*x_37 + 6.5663712316036e-5*x_38 + 6.19437285318756e-5*x_39 + 0.000346916055774276*x_4 - 0.000120537912092644*x_40 + 6.59778285859212e-5*x_41 + 5.20409603955076e-6*x_42 + 0.000360822626625732*x_43 - 0.000147998879373249*x_44 - 2.58869082534568e-5*x_45 - 4.55502360604473e-5*x_46 + 0.000423958110194291*x_47 - 4.81618692576822e-5*x_48 + 4.70656008859087e-6*x_49 - 0.000146795386722099*x_5 + 0.0002379040142546*x_50 + 0.000316443820578223*x_51 + 0.00013227815666522*x_52 + 1.0054080012686e-6*x_53 + 0.000181732873865522*x_54 + 0.000405889101448308*x_55 - 0.000191145888453213*x_56 - 0.000553883755638199*x_57 + 0.000343407157938447*x_58 + 0.000181591810386499*x_59 - 7.30345150884228e-5*x_6 - 0.000104272386306361*x_60 + 0.00017639295671009*x_61 + 3.01569609825981e-5*x_62 + 9.42725330056194e-6*x_63 + 1.87919049077721e-5*x_64 - 7.45698559946018e-5*x_65 - 6.43117035762511e-6*x_66 - 8.71950971120737e-6*x_67 + 2.59568876196937e-6*x_68 + 9.91474850944221e-5*x_69 - 1.66729060851715e-5*x_7 - 6.25683802470967e-5*x_70 + 6.42609278137253e-5*x_71 + 4.90014533304857e-5*x_72 + 9.65556600697554e-5*x_73 - 9.73605671761818e-6*x_74 + 9.64420663815081e-5*x_75 + 3.21013727315614e-5*x_76 + 9.12567505577767e-5*x_77 + 3.16609489621075e-6*x_78 - 8.38361036971297e-5*x_79 - 0.000246470408313946*x_8 + 3.59826710880318e-5*x_80 - 4.92244258646391e-5*x_81 + 6.61054532405905e-5*x_82 + 0.000305717730902538*x_83 + 3.23773401463417e-5*x_84 + 3.88404826548933e-5*x_85 - 3.48311271389196e-5*x_86 - 0.000123454110889783*x_87 - 1.08643849053421e-5*x_88 - 1.15351565827288e-5*x_89 + 0.000188531198280884*x_9 - 0.000106634828041563*x_90 - 3.36196156225019e-5*x_91 + 0.00011149403309123*x_92 - 0.000123273152790706*x_93 + 0.000126692495555187*x_94 - 8.26554238216636e-6*x_95 - 6.26613083795783e-6*x_96 + 9.51602664980885e-6*x_97 - 0.000105672249598343*x_98 + 0.000210636924214424*x_99 + 1.11681860474322e-9*std::pow(0.403359860181808 - 9.50400066375732*x_23, 2) - 8.11730943278397e-9*std::pow(1.22511982917786 - 9.68591976165771*x_15, 2) - 4.53723427153542e-7*std::pow(1.38495981693268 - 7.2836799621582*x_13, 2) + 2.83125561043712e-8*std::pow(1.60127985477448 - 5.82575988769531*x_20, 2) + 8.39026623622585e-7*std::pow(2.69591999053955 - 5.20391988754272*x_26, 2) - 5.10256297419243e-9*std::pow(2.83799982070923 - 9.29992008209229*x_49, 2) + 9.14477920924456e-9*std::pow(3.67743992805481 - 8.79703998565674*x_10, 2) - 6.47582478903081e-8*std::pow(4.87504005432129 - 9.94591999053955*x_15, 2) - 8.13739160699623e-8*std::pow(5.7087197303772 - 8.35791969299316*x_27, 2) - 1.50958097252475e-7*std::pow(-6.95183992385864*x_10 - 0.208399996161461, 2) - 3.25026392167809e-7*std::pow(-8.32151985168457*x_20 - 1.02223980426788, 2) - 3.05418393005893e-8*std::pow(-5.75559949874878*x_31 - 2.25679969787598, 2) - 3.07472989950056e-5*std::exp(0.497119843959808*x_13) - 1.41042720149183e-5*std::exp(0.530159890651703*x_15) + 3.66188359204089e-5*std::exp(0.703039824962616*x_18) - 2.65104833774132e-6*std::exp(0.755279839038849*x_22) + 3.49543293823194e-5*std::exp(0.45295986533165*x_25) + 5.33528132615406e-7*std::exp(0.489279866218567*x_27) + 1.21849680016052e-6*std::exp(0.522239863872528*x_5) + 9.49024372991527e-6*std::exp(0.521119892597198*x_9) - 0.000125502024172855*std::sin(1.43783986568451*x_100 - 1.98039984703064) - 1.2990386279727e-6*std::sin(0.660719871520996*x_11 + 4.57911968231201) - 0.000309432587049329*std::sin(0.58927983045578*x_12 - 8.00520038604736) - 0.000674117706107095*std::sin(0.533199846744537*x_14 - 7.96367979049683) - 6.57487651271323e-5*std::sin(0.846479892730713*x_2 - 1.80759990215302) - 1.7933507805352e-5*std::sin(0.99999988079071*x_2 + 10.0) - 8.94100590438325e-6*std::sin(0.458079844713211*x_21 - 2.26695990562439) - 6.71311221270681e-5*std::sin(0.574719846248627*x_21 + 1.40535986423492) + 0.000953172394060001*std::sin(0.306079924106598*x_23 - 4.82760000228882) + 2.06011636638523e-6*std::sin(0.851919889450073*x_24 + 1.59799981117249) - 0.000234611593481238*std::sin(0.436719864606857*x_27 - 1.59663987159729) + 6.00257723884525e-6*std::sin(0.896799802780151*x_28 - 8.33256053924561) + 0.000934704506098407*std::sin(0.295039921998978*x_3 - 1.59319984912872) + 9.91091372710855e-5*std::sin(1.09575986862183*x_3 + 4.79311990737915) + 6.78351778315954e-5*std::sin(0.941519796848297*x_31 + 1.78167986869812) - 3.91233598296217e-6*std::sin(1.21727991104126*x_31 + 0.782879829406738) - 0.000367898251104727*std::sin(0.253759980201721*x_32 - 4.57951974868774) + 1.75829904031466e-5*std::sin(0.583759844303131*x_32 + 7.81175994873047) - 0.0017952080975155*std::sin(0.158640027046204*x_37 + 4.62256002426147) + 0.000811859562805854*std::sin(0.322719842195511*x_37 + 1.4469598531723) + 0.000448579332181821*std::sin(0.884639859199524*x_4 - 4.60487985610962) - 9.12834357846594e-6*std::sin(0.898719847202301*x_4 - 1.56799983978271) - 1.29933235435687e-5*std::sin(0.673839807510376*x_42 - 1.62783980369568) + 7.89161517248029e-7*std::sin(0.624719858169556*x_43 - 1.80271995067596) - 7.13809183447236e-6*std::sin(0.56199985742569*x_44 - 4.96672010421753) + 0.000367640929753891*std::sin(0.579199850559235*x_44 - 7.97103977203369) - 0.000342835746947366*std::sin(0.690959870815277*x_48 + 4.54207992553711) - 1.42197606964683e-6*std::sin(0.271839946508408*x_54 - 4.83368015289307) + 1.86153560741229e-5*std::sin(0.313279926776886*x_55 + 1.26903986930847) - 0.000564375271848973*std::sin(0.355039834976196*x_57 + 1.41279983520508) + 0.000227530182543278*std::sin(0.425439864397049*x_58 - 2.00775980949402) - 0.00481428569608292*std::sin(0.136800035834312*x_59 - 4.77503967285156) - 0.000832033145540469*std::sin(0.463279843330383*x_59 + 7.72575998306274) - 2.12063271789896e-5*std::sin(1.05207991600037*x_6 + 0.561199843883514) - 0.000158167302065302*std::sin(1.05679976940155*x_6 - 2.23479986190796) + 5.68458221096896e-5*std::sin(1.185919880867*x_62 - 0.798639833927155) + 6.54328723220432e-5*std::sin(1.13583981990814*x_63 + 4.41039991378784) + 3.9299699966123e-6*std::sin(1.48607981204987*x_63 - 1.9955198764801) - 2.22171016682848e-7*std::sin(1.78023993968964*x_63 - 9.40144062042236) + 5.79848428769823e-5*std::sin(0.832319855690002*x_68 + 7.59000015258789) - 3.62889606587262e-5*std::sin(1.05863988399506*x_68 - 1.80015993118286) + 8.31813333299565e-5*std::sin(1.72903990745544*x_69 + 0.192159995436668) - 1.45462991825124e-5*std::sin(2.14935994148254*x_69 + 3.99999976158142) - 0.000233160229262372*std::sin(0.775439858436584*x_7 + 1.18935990333557) - 8.32147158712009e-6*std::sin(0.92223984003067*x_72 + 1.21383988857269) - 1.00176138396003e-5*std::sin(1.32399988174438*x_72 + 7.41775989532471) + 0.000116482092509499*std::sin(1.41735982894897*x_75 - 1.99655985832214) - 0.000146634772884169*std::sin(0.934159815311432*x_76 + 7.59712028503418) + 8.20845669233454e-6*std::sin(1.37239980697632*x_78 + 7.61064004898071) - 6.58426817976784e-5*std::sin(0.569759845733643*x_8 + 1.42455983161926) - 0.000216963858842519*std::sin(1.16767990589142*x_80 + 4.58631992340088) - 2.88043205776043e-5*std::sin(1.14367985725403*x_82 - 2.57511973381042) - 0.000113300118959712*std::sin(0.845919847488403*x_84 + 1.58383977413177) - 9.91260919824256e-5*std::sin(1.04711985588074*x_88 + 1.80127990245819) + 4.86385502469156e-5*std::sin(1.20215976238251*x_88 + 1.38447988033295) + 0.00019972965251536*std::sin(1.04359984397888*x_90 - 7.9937596321106) + 0.000246599219160681*std::sin(0.860719919204712*x_91 + 0.970399796962738) - 2.58759656404079e-6*std::sin(0.28399994969368*x_93 - 7.8187198638916) - 8.51030658539394e-5*std::sin(0.972719848155975*x_93 + 7.41607999801636) + 0.000870370783471495*std::sin(0.36015984416008*x_94 - 7.98040008544922) - 0.000106950744545979*std::sin(1.86327993869781*x_99 + 3.96928000450134) + 0.0520096278668364 - 1.11572016871078e-6*std::exp(-3.09487986564636*x_118) - 1.63719712587929e-5*std::exp(-2.20839977264404*x_106));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-2.68967433362164e-5*x_1 - 1.57103971897859e-5*x_10 + 3.08660911444122e-6*x_100 + 8.99962454202611e-5*x_101 - 0.000130556545619118*x_102 - 9.22212224105308e-5*x_103 + 1.95309577593353e-5*x_104 - 0.000114220631611063*x_105 + 9.96597069952163e-5*x_106 - 1.50600372475952e-6*x_107 - 8.30836752518387e-5*x_108 - 7.16590704339823e-5*x_109 - 4.4178362837879e-5*x_11 - 5.15412043404814e-5*x_110 - 2.38458901881547e-5*x_111 + 9.18043629318297e-5*x_112 + 1.51553185945814e-6*x_113 - 3.99682095427339e-5*x_114 - 1.34128906660141e-6*x_115 + 0.000299255341557445*x_116 - 6.30924314607075e-5*x_117 - 4.94887712494031e-5*x_118 - 5.29196613300553e-5*x_119 - 7.63988609277572e-5*x_12 - 5.57453057934026e-5*x_120 - 1.36717967762603e-5*x_13 + 0.000160523041548262*x_14 - 3.27586014947983e-5*x_15 - 0.000337066037928861*x_16 - 6.49029937815831e-5*x_17 - 0.00040770009931865*x_18 + 0.000336878162703288*x_19 - 7.02334006361644e-5*x_2 - 0.00012191716106827*x_20 - 6.95589697762291e-5*x_21 + 0.000265696252212784*x_22 - 0.000186657216147829*x_23 + 4.8279724211398e-5*x_24 - 0.000165720601576475*x_25 - 0.000177466069010173*x_26 - 0.00019679865000879*x_27 + 4.67925801402425e-5*x_28 + 1.77818788401234e-5*x_29 - 9.35545852053795e-5*x_3 - 0.000208508355969005*x_30 + 2.87386989845807e-5*x_31 - 0.000116711479732075*x_32 + 2.13761036246462e-5*x_33 + 7.11729094995685e-5*x_34 - 2.49536878330913e-6*x_35 + 0.000844029066583472*x_36 + 9.27182508728584e-5*x_37 + 4.62575042867735e-5*x_38 + 6.21247691284564e-5*x_39 + 0.000103749468428529*x_4 - 0.000146148063620157*x_40 - 0.000147097829348141*x_41 - 0.000147002757848316*x_42 - 5.47921091437324e-5*x_43 + 0.000112990891071532*x_44 + 0.000164739607490055*x_45 + 7.35402351486471e-5*x_46 - 0.000133906203687154*x_47 - 0.000111291054959316*x_48 - 0.000194532102834381*x_49 + 2.08749334477074e-5*x_5 - 0.000171640544489779*x_50 - 0.000423900040730528*x_51 - 0.000129101850402423*x_52 + 0.000105640705176131*x_53 + 5.93263953515374e-5*x_54 - 0.000706873256241845*x_55 + 0.000464510113458982*x_56 - 0.000261642017588186*x_57 - 0.000250518199503935*x_58 - 0.000142658266288929*x_59 - 0.000110518979145321*x_6 - 0.000300595744028954*x_60 - 7.53116187655535e-5*x_61 + 7.71784451083696e-6*x_62 + 1.51390775037187e-5*x_63 - 2.22431554963758e-5*x_64 + 3.17608644983939e-6*x_65 - 5.67274917257006e-6*x_66 + 9.32562594911993e-7*x_67 - 5.54831634752557e-5*x_68 + 1.789284909703e-5*x_69 - 0.000134040660782514*x_7 + 3.04452309959993e-5*x_70 - 1.11081529965697e-5*x_71 + 1.37540772399762e-5*x_72 - 0.000193420618848159*x_73 - 7.1848381187573e-6*x_74 + 2.95603363667993e-5*x_75 - 3.39631904332302e-5*x_76 - 6.47630337528722e-5*x_77 - 2.72273397849266e-5*x_78 + 4.21712096634864e-6*x_79 + 0.000128129863556551*x_8 + 3.80704240865693e-6*x_80 + 2.072352704174e-5*x_81 + 2.47800827279084e-5*x_82 - 0.0004294317677467*x_83 - 2.06671044076224e-5*x_84 - 9.32654584957869e-5*x_85 + 8.18670365920955e-5*x_86 - 1.22761829468746e-5*x_87 + 4.13167945413686e-5*x_88 - 1.0355959636822e-5*x_89 + 1.94840493528955e-5*x_9 - 0.000112887742125441*x_90 - 1.23619125194589e-5*x_91 + 3.50362925825523e-5*x_92 - 6.29821111032326e-5*x_93 + 4.07272558470168e-5*x_94 - 5.37524276671736e-5*x_95 + 5.88866414101625e-5*x_96 - 2.38694623817511e-5*x_97 + 0.000172516404643054*x_98 + 0.000132988566345802*x_99 - 3.71859759648004e-7*std::pow(0.403359860181808 - 9.50400066375732*x_23, 2) - 4.60957780261101e-7*std::pow(1.22511982917786 - 9.68591976165771*x_15, 2) + 2.14989252651613e-9*std::pow(1.38495981693268 - 7.2836799621582*x_13, 2) - 3.89774067223955e-7*std::pow(1.60127985477448 - 5.82575988769531*x_20, 2) - 1.75042167421117e-7*std::pow(2.69591999053955 - 5.20391988754272*x_26, 2) - 2.89759325020525e-7*std::pow(2.83799982070923 - 9.29992008209229*x_49, 2) + 5.19304722848974e-7*std::pow(3.67743992805481 - 8.79703998565674*x_10, 2) - 2.21429496220296e-7*std::pow(4.87504005432129 - 9.94591999053955*x_15, 2) + 9.72130849210306e-8*std::pow(5.7087197303772 - 8.35791969299316*x_27, 2) - 5.16174796477048e-7*std::pow(-6.95183992385864*x_10 - 0.208399996161461, 2) + 6.78087232899432e-8*std::pow(-8.32151985168457*x_20 - 1.02223980426788, 2) - 1.044324747857e-7*std::pow(-5.75559949874878*x_31 - 2.25679969787598, 2) + 6.4146639771611e-6*std::exp(0.497119843959808*x_13) + 4.60141254894312e-6*std::exp(0.530159890651703*x_15) - 1.73512225650113e-7*std::exp(0.703039824962616*x_18) + 3.16706629880057e-6*std::exp(0.755279839038849*x_22) + 5.90357480205858e-6*std::exp(0.45295986533165*x_25) + 3.02974705786103e-5*std::exp(0.489279866218567*x_27) - 1.67748348805785e-5*std::exp(0.522239863872528*x_5) - 2.83747885071417e-5*std::exp(0.521119892597198*x_9) + 2.61828954033713e-5*std::sin(1.43783986568451*x_100 - 1.98039984703064) + 0.000432532364629139*std::sin(0.660719871520996*x_11 + 4.57911968231201) + 6.45554612724687e-5*std::sin(0.58927983045578*x_12 - 8.00520038604736) + 0.000399794822788944*std::sin(0.533199846744537*x_14 - 7.96367979049683) - 1.11045687309722e-5*std::sin(0.846479892730713*x_2 - 1.80759990215302) + 3.74138315439723e-6*std::sin(0.99999988079071*x_2 + 10.0) - 3.05722050489043e-5*std::sin(0.458079844713211*x_21 - 2.26695990562439) + 0.000200714696778358*std::sin(0.574719846248627*x_21 + 1.40535986423492) - 0.000565292062377593*std::sin(0.306079924106598*x_23 - 4.82760000228882) - 0.000685943423217838*std::sin(0.851919889450073*x_24 + 1.59799981117249) - 8.58894695547088e-5*std::sin(0.436719864606857*x_27 - 1.59663987159729) + 0.000340868449425976*std::sin(0.896799802780151*x_28 - 8.33256053924561) - 0.000554339426171775*std::sin(0.295039921998978*x_3 - 1.59319984912872) - 3.23336098078465e-5*std::sin(1.09575986862183*x_3 + 4.79311990737915) - 4.02305897832785e-5*std::sin(0.941519796848297*x_31 + 1.78167986869812) - 0.000222169885880938*std::sin(1.21727991104126*x_31 + 0.782879829406738) - 6.21357892805659e-5*std::sin(0.253759980201721*x_32 - 4.57951974868774) - 2.10054624599505e-5*std::sin(0.583759844303131*x_32 + 7.81175994873047) - 0.00028942909670289*std::sin(0.158640027046204*x_37 + 4.62256002426147) + 0.00037771748456386*std::sin(0.322719842195511*x_37 + 1.4469598531723) - 0.000266036172899341*std::sin(0.884639859199524*x_4 - 4.60487985610962) - 0.000518371392421738*std::sin(0.898719847202301*x_4 - 1.56799983978271) - 0.000737852071360986*std::sin(0.673839807510376*x_42 - 1.62783980369568) - 0.000262761930076173*std::sin(0.624719858169556*x_43 - 1.80271995067596) - 0.000405350934883578*std::sin(0.56199985742569*x_44 - 4.96672010421753) + 5.92722271902302e-5*std::sin(0.579199850559235*x_44 - 7.97103977203369) - 5.52730575880105e-5*std::sin(0.690959870815277*x_48 + 4.54207992553711) + 0.000473466037580617*std::sin(0.271839946508408*x_54 - 4.83368015289307) - 0.00025627439017111*std::sin(0.313279926776886*x_55 + 1.26903986930847) - 9.09903566938909e-5*std::sin(0.355039834976196*x_57 + 1.41279983520508) + 8.32970203916671e-5*std::sin(0.425439864397049*x_58 - 2.00775980949402) + 0.00100438171936473*std::sin(0.136800035834312*x_59 - 4.77503967285156) + 3.94244981493062e-6*std::sin(0.463279843330383*x_59 + 7.72575998306274) + 6.91840457240084e-6*std::sin(1.05207991600037*x_6 + 0.561199843883514) + 3.18777646612482e-5*std::sin(1.05679976940155*x_6 - 2.23479986190796) - 3.3713200485235e-5*std::sin(1.185919880867*x_62 - 0.798639833927155) + 2.39544628284992e-5*std::sin(1.13583981990814*x_63 + 4.41039991378784) - 5.41032178091189e-5*std::sin(1.48607981204987*x_63 - 1.9955198764801) + 7.39748250195311e-5*std::sin(1.78023993968964*x_63 - 9.40144062042236) + 9.79328922508323e-6*std::sin(0.832319855690002*x_68 + 7.59000015258789) + 0.000108500014661323*std::sin(1.05863988399506*x_68 - 1.80015993118286) - 4.93318394053796e-5*std::sin(1.72903990745544*x_69 + 0.192159995436668) - 4.97385245090223e-5*std::sin(2.14935994148254*x_69 + 3.99999976158142) - 0.000108477745822126*std::sin(0.775439858436584*x_7 + 1.18935990333557) + 0.000114560261314577*std::sin(0.92223984003067*x_72 + 1.21383988857269) + 2.99515673289681e-5*std::sin(1.32399988174438*x_72 + 7.41775989532471) + 1.87796093743922e-5*std::sin(1.41735982894897*x_75 - 1.99655985832214) - 2.36409193562766e-5*std::sin(0.934159815311432*x_76 + 7.59712028503418) - 0.000113004404788057*std::sin(1.37239980697632*x_78 + 7.61064004898071) + 0.0001968624014221*std::sin(0.569759845733643*x_8 + 1.42455983161926) - 0.00010094238801602*std::sin(1.16767990589142*x_80 + 4.58631992340088) + 8.6121761225697e-5*std::sin(1.14367985725403*x_82 - 2.57511973381042) + 3.69633107349701e-5*std::sin(0.845919847488403*x_84 + 1.58383977413177) + 5.87880989014974e-5*std::sin(1.04711985588074*x_88 + 1.80127990245819) + 1.78061928595686e-5*std::sin(1.20215976238251*x_88 + 1.38447988033295) - 6.51602952997606e-5*std::sin(1.04359984397888*x_90 - 7.9937596321106) + 0.00011473023294185*std::sin(0.860719919204712*x_91 + 0.970399796962738) + 0.000861575042073594*std::sin(0.28399994969368*x_93 - 7.8187198638916) + 1.77546512611696e-5*std::sin(0.972719848155975*x_93 + 7.41607999801636) + 0.000404939817219775*std::sin(0.36015984416008*x_94 - 7.98040008544922) - 1.72429354727646e-5*std::sin(1.86327993869781*x_99 + 3.96928000450134) + 0.0961565999684877 + 1.33289148104579e-6*std::exp(-3.09487986564636*x_118) + 9.70962383693115e-6*std::exp(-2.20839977264404*x_106));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-4.96451597733275e-5*x_1 - 0.000367073293422783*x_10 + 0.000178036045335252*x_100 - 0.000203193509334237*x_101 - 0.000138734832524019*x_102 - 9.27819528124497e-5*x_103 - 5.81828946240049e-5*x_104 + 5.135622376552e-5*x_105 - 0.000151618751261422*x_106 - 1.99365128322073e-5*x_107 + 4.65934177981261e-5*x_108 + 9.37004201553039e-5*x_109 - 0.000162163113256993*x_11 - 0.000159306352016496*x_110 + 0.000234033159993607*x_111 - 0.000399772395726191*x_112 + 3.40528046413887e-5*x_113 - 0.000150228534773258*x_114 - 0.000219533039015661*x_115 + 0.000190582679370003*x_116 - 2.09752491144495e-5*x_117 + 4.80387133191515e-5*x_118 + 4.0144438377365e-5*x_119 - 0.000202008716513886*x_12 - 3.14833496474934e-5*x_120 - 7.40862883247012e-5*x_13 - 0.000214802090457331*x_14 + 0.00021339701654877*x_15 + 1.65779112550701e-5*x_16 - 5.57537066603836e-6*x_17 - 0.000109232572846691*x_18 + 0.000495426498377079*x_19 + 2.01350734326035e-5*x_2 - 0.000168627069198915*x_20 + 0.000164208596426617*x_21 + 1.67413856921783e-5*x_22 - 0.00027225089266547*x_23 - 3.90435016529077e-5*x_24 - 0.000299883115935117*x_25 - 0.0003460133856545*x_26 - 9.21978266822708e-6*x_27 + 5.60851939811357e-5*x_28 - 9.67131308311019e-5*x_29 - 0.000129529085960049*x_3 + 0.000440204547129699*x_30 - 4.80614922538588e-5*x_31 - 3.50109375880218e-5*x_32 + 0.000122729355200395*x_33 - 0.000196807086770996*x_34 - 0.000127734088327283*x_35 - 0.000208138158269709*x_36 + 0.000295950853983578*x_37 + 5.31854590630919e-5*x_38 - 0.000169824748240465*x_39 - 4.78769248519292e-5*x_4 - 0.000215382449500676*x_40 - 7.4403241955867e-6*x_41 + 0.000307599223422252*x_42 - 0.000169396044650536*x_43 + 4.61326547597932e-5*x_44 - 0.00017469840524718*x_45 - 0.000227328865641377*x_46 - 0.000291102692102966*x_47 - 1.60682204618559e-5*x_48 - 9.97520830758149e-5*x_49 - 0.000113657080975748*x_5 + 8.28960246715424e-5*x_50 + 0.000124284737679803*x_51 - 0.000130143935380985*x_52 + 0.000169348068221811*x_53 - 8.22509625581044e-5*x_54 + 4.29111044053063e-5*x_55 + 0.000268367617439675*x_56 - 0.000510906155972689*x_57 - 0.000782073796125317*x_58 - 0.000132861806307785*x_59 - 8.31024445347775e-6*x_6 - 0.000462612644119586*x_60 + 8.10924939552472e-5*x_61 - 1.36132799800292e-5*x_62 + 5.34604909048273e-5*x_63 + 5.27202569095613e-5*x_64 - 2.79443193597007e-7*x_65 + 3.45941498940289e-5*x_66 - 3.22038855015404e-6*x_67 - 6.40567274298092e-5*x_68 + 3.17611911536835e-5*x_69 + 2.06945914526912e-5*x_7 + 1.13726182876878e-5*x_70 - 8.52252289029831e-5*x_71 + 3.08143095844139e-5*x_72 - 9.65486661178608e-5*x_73 - 2.68017252543129e-7*x_74 + 1.3140686682975e-5*x_75 - 5.81828575468474e-5*x_76 + 3.84195705855755e-5*x_77 - 3.31928748017237e-5*x_78 - 8.44118752462303e-5*x_79 - 0.000172431816212549*x_8 + 6.23466528268339e-6*x_80 - 4.53087108625325e-5*x_81 + 8.53333609538532e-6*x_82 - 0.000140901701358359*x_83 - 1.39641993009857e-5*x_84 - 3.61779013049091e-5*x_85 - 5.10393065612107e-5*x_86 + 0.000157601541239412*x_87 + 0.000283851706487648*x_88 + 1.3229676879635e-5*x_89 + 1.69140008378472e-5*x_9 - 0.000137690285332374*x_90 - 5.91942926681364e-6*x_91 - 1.6285998486646e-5*x_92 + 0.000117313991889546*x_93 - 3.71622761427038e-5*x_94 - 2.48333122929662e-6*x_95 + 1.17322036848042e-5*x_96 + 2.27102103879355e-5*x_97 - 1.41207128652837e-5*x_98 + 0.000276153062667068*x_99 + 3.74845699578705e-7*std::pow(0.403359860181808 - 9.50400066375732*x_23, 2) - 1.70440323135131e-7*std::pow(1.22511982917786 - 9.68591976165771*x_15, 2) + 5.79022944552418e-7*std::pow(1.38495981693268 - 7.2836799621582*x_13, 2) + 6.42939501753222e-7*std::pow(1.60127985477448 - 5.82575988769531*x_20, 2) + 1.13986921455436e-6*std::pow(2.69591999053955 - 5.20391988754272*x_26, 2) - 1.0713925461881e-7*std::pow(2.83799982070923 - 9.29992008209229*x_49, 2) + 1.92014255010174e-7*std::pow(3.67743992805481 - 8.79703998565674*x_10, 2) - 2.48436602247446e-7*std::pow(4.87504005432129 - 9.94591999053955*x_15, 2) + 1.12194130195686e-7*std::pow(5.7087197303772 - 8.35791969299316*x_27, 2) - 5.79131122056768e-7*std::pow(-6.95183992385864*x_10 - 0.208399996161461, 2) - 4.41568322051735e-7*std::pow(-8.32151985168457*x_20 - 1.02223980426788, 2) - 1.1716979735274e-7*std::pow(-5.75559949874878*x_31 - 2.25679969787598, 2) - 4.17720946729701e-5*std::exp(0.497119843959808*x_13) - 1.26683990869219e-5*std::exp(0.530159890651703*x_15) - 4.67314335822069e-5*std::exp(0.703039824962616*x_18) + 3.65512779431538e-6*std::exp(0.755279839038849*x_22) - 4.04189085632717e-5*std::exp(0.45295986533165*x_25) + 1.12025675598109e-5*std::exp(0.489279866218567*x_27) + 2.76703990517532e-5*std::exp(0.522239863872528*x_5) - 2.7617052992945e-5*std::exp(0.521119892597198*x_9) - 0.000170502210169727*std::sin(1.43783986568451*x_100 - 1.98039984703064) - 0.000436005490250715*std::sin(0.660719871520996*x_11 + 4.57911968231201) - 0.000420383179778692*std::sin(0.58927983045578*x_12 - 8.00520038604736) + 0.000406812952928056*std::sin(0.533199846744537*x_14 - 7.96367979049683) + 7.60275872197338e-5*std::sin(0.846479892730713*x_2 - 1.80759990215302) - 2.43637721149195e-5*std::sin(0.99999988079071*x_2 + 10.0) - 3.43010072064005e-5*std::sin(0.458079844713211*x_21 - 2.26695990562439) + 0.000195354704264867*std::sin(0.574719846248627*x_21 + 1.40535986423492) - 0.000575215385627997*std::sin(0.306079924106598*x_23 - 4.82760000228882) + 0.00069145137562314*std::sin(0.851919889450073*x_24 + 1.59799981117249) + 0.000346477220704751*std::sin(0.436719864606857*x_27 - 1.59663987159729) + 0.000126036984631924*std::sin(0.896799802780151*x_28 - 8.33256053924561) - 0.000564070483234932*std::sin(0.295039921998978*x_3 - 1.59319984912872) + 8.90194192782594e-5*std::sin(1.09575986862183*x_3 + 4.79311990737915) - 4.09368108211165e-5*std::sin(0.941519796848297*x_31 + 1.78167986869812) - 8.21478859061526e-5*std::sin(1.21727991104126*x_31 + 0.782879829406738) + 0.000425413562061103*std::sin(0.253759980201721*x_32 - 4.57951974868774) - 2.42425141838334e-5*std::sin(0.583759844303131*x_32 + 7.81175994873047) - 0.000809459434415755*std::sin(0.158640027046204*x_37 + 4.62256002426147) + 0.000187457119243695*std::sin(0.322719842195511*x_37 + 1.4469598531723) - 0.000270706259595547*std::sin(0.884639859199524*x_4 - 4.60487985610962) - 0.000191669153687619*std::sin(0.898719847202301*x_4 - 1.56799983978271) - 0.000272822698420358*std::sin(0.673839807510376*x_42 - 1.62783980369568) + 0.000264871841995724*std::sin(0.624719858169556*x_43 - 1.80271995067596) - 0.000149879549241041*std::sin(0.56199985742569*x_44 - 4.96672010421753) + 0.000165769316369797*std::sin(0.579199850559235*x_44 - 7.97103977203369) - 0.000154584658015738*std::sin(0.690959870815277*x_48 + 4.54207992553711) - 0.000477267850255322*std::sin(0.271839946508408*x_54 - 4.83368015289307) + 0.000422729325997082*std::sin(0.313279926776886*x_55 + 1.26903986930847) - 0.000254476842535055*std::sin(0.355039834976196*x_57 + 1.41279983520508) - 0.000336019307930509*std::sin(0.425439864397049*x_58 - 2.00775980949402) - 0.00654050288814531*std::sin(0.136800035834312*x_59 - 4.77503967285156) + 0.00106180605422656*std::sin(0.463279843330383*x_59 + 7.72575998306274) - 1.90474358114423e-5*std::sin(1.05207991600037*x_6 + 0.561199843883514) - 5.44445132110444e-5*std::sin(1.05679976940155*x_6 - 2.23479986190796) - 3.43050131224292e-5*std::sin(1.185919880867*x_62 - 0.798639833927155) - 9.66320521866424e-5*std::sin(1.13583981990814*x_63 + 4.41039991378784) + 8.92442541115857e-5*std::sin(1.48607981204987*x_63 - 1.9955198764801) - 7.45688241769058e-5*std::sin(1.78023993968964*x_63 - 9.40144062042236) - 6.70498934957656e-5*std::sin(0.832319855690002*x_68 + 7.59000015258789) + 0.000105602572293461*std::sin(1.05863988399506*x_68 - 1.80015993118286) - 5.01978267799372e-5*std::sin(1.72903990745544*x_69 + 0.192159995436668) - 5.58049864211822e-5*std::sin(2.14935994148254*x_69 + 3.99999976158142) - 5.38363368519881e-5*std::sin(0.775439858436584*x_7 + 1.18935990333557) - 0.000188969260717882*std::sin(0.92223984003067*x_72 + 1.21383988857269) + 2.91517246705709e-5*std::sin(1.32399988174438*x_72 + 7.41775989532471) + 5.25217822116518e-5*std::sin(1.41735982894897*x_75 - 1.99655985832214) - 6.61176275267318e-5*std::sin(0.934159815311432*x_76 + 7.59712028503418) + 0.00018640284672558*std::sin(1.37239980697632*x_78 + 7.61064004898071) + 0.000191605282662254*std::sin(0.569759845733643*x_8 + 1.42455983161926) - 5.00966199351652e-5*std::sin(1.16767990589142*x_80 + 4.58631992340088) + 8.38219196952677e-5*std::sin(1.14367985725403*x_82 - 2.57511973381042) - 0.00010176570063731*std::sin(0.845919847488403*x_84 + 1.58383977413177) + 5.98200845731565e-5*std::sin(1.04711985588074*x_88 + 1.80127990245819) - 7.18299955198391e-5*std::sin(1.20215976238251*x_88 + 1.38447988033295) + 0.000179396352032953*std::sin(1.04359984397888*x_90 - 7.9937596321106) + 5.69393788647907e-5*std::sin(0.860719919204712*x_91 + 0.970399796962738) - 0.000868493272010219*std::sin(0.28399994969368*x_93 - 7.8187198638916) - 0.000115617743346764*std::sin(0.972719848155975*x_93 + 7.41607999801636) + 0.000200967269732661*std::sin(0.36015984416008*x_94 - 7.98040008544922) - 4.82240968667337e-5*std::sin(1.86327993869781*x_99 + 3.96928000450134) + 0.0462252156684069 + 1.53829703565781e-6*std::exp(-3.09487986564636*x_118) + 9.88006977521029e-6*std::exp(-2.20839977264404*x_106));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-8.39571290717934e-5*x_1 + 4.4277839774502e-5*x_10 - 0.000185206335050931*x_100 - 0.00011861743296939*x_101 - 0.000149413144027882*x_102 - 0.00024046524185172*x_103 - 1.62270562674921e-5*x_104 + 7.44104627593735e-5*x_105 - 6.08049592082759e-5*x_106 + 2.01562875385489e-5*x_107 - 2.53274680566653e-5*x_108 + 6.183518084986e-5*x_109 - 4.68150429676365e-5*x_11 - 0.000107742858676897*x_110 + 0.000109073801202137*x_111 + 1.68551609515747e-5*x_112 - 6.82825820472396e-6*x_113 - 0.0001156815350959*x_114 - 0.00011575841105965*x_115 + 5.68756835688336e-5*x_116 - 5.18019924843361e-5*x_117 - 9.5366115399718e-6*x_118 - 2.67303922320063e-5*x_119 - 8.16739882421284e-5*x_12 - 7.05404400788745e-5*x_120 - 5.44999670462408e-5*x_13 - 0.000175183599103807*x_14 + 0.000109585579669351*x_15 + 0.000110863929253778*x_16 - 5.36117741235283e-5*x_17 - 0.000509495664538233*x_18 + 8.09401708634568e-6*x_19 + 3.04702759937461e-5*x_2 - 0.00020300822786551*x_20 + 6.03887975399488e-5*x_21 - 0.00013911236315183*x_22 - 0.000180709134973109*x_23 - 0.000116888410746538*x_24 + 0.00010018933207791*x_25 - 9.53186997428483e-5*x_26 + 0.000495185773412063*x_27 - 8.21087442210084e-5*x_28 - 0.000124989027350391*x_29 - 0.000256005874200037*x_3 + 9.99221112744531e-5*x_30 + 4.94150291409171e-6*x_31 - 1.71507830028423e-5*x_32 - 5.7113381283328e-5*x_33 - 0.000526982008140162*x_34 - 0.000183845380318831*x_35 - 0.000233336748539004*x_36 + 7.00824655162333e-5*x_37 - 1.82569323524951e-5*x_38 - 0.000310185665462654*x_39 - 0.000251572622892635*x_4 - 0.000400725155638359*x_40 + 8.62239003792583e-5*x_41 + 0.000180743651673669*x_42 - 0.000241245205454488*x_43 - 3.34867470100029e-5*x_44 - 0.000126418910362669*x_45 - 4.38202310147001e-5*x_46 - 8.63032741625648e-5*x_47 - 1.8150225655808e-5*x_48 - 6.92104792188906e-5*x_49 + 8.1930140953386e-6*x_5 + 0.000237935636794811*x_50 + 0.000339995064891094*x_51 - 6.13523029133145e-5*x_52 + 6.22874152853093e-5*x_53 - 1.34732007255077e-5*x_54 + 0.000472309063660599*x_55 - 0.000183126922252147*x_56 - 4.01350094318596e-5*x_57 - 0.000657221667441572*x_58 - 0.000442806742530872*x_59 - 2.15266503193804e-5*x_6 + 9.94018201251361e-5*x_60 - 3.49764795575429e-5*x_61 - 3.97834329571886e-5*x_62 + 5.38271948522998e-5*x_63 + 0.000101541811178402*x_64 + 3.4021580440494e-5*x_65 + 4.11807114590778e-5*x_66 + 7.48135097985162e-6*x_67 - 5.67771324344857e-5*x_68 - 3.6040975584924e-5*x_69 - 4.5261260835854e-5*x_7 + 3.32158082149675e-5*x_70 - 5.15786470382083e-5*x_71 + 2.59887895241435e-6*x_72 - 8.81401868722625e-5*x_73 + 1.28645978771854e-5*x_74 - 3.19344505592561e-6*x_75 - 4.85351759447378e-5*x_76 + 9.63869119683432e-5*x_77 - 0.000154594705255384*x_78 - 2.1055143273117e-5*x_79 - 0.000166916238956505*x_8 - 6.63331342301676e-5*x_80 + 4.64543693253209e-5*x_81 - 1.20179146993634e-5*x_82 + 0.00021496053259192*x_83 - 0.000107598691838727*x_84 - 7.34297050395061e-6*x_85 + 5.92009540122673e-5*x_86 + 0.000114661421882353*x_87 - 2.50532289403842e-5*x_88 - 3.52304411569204e-6*x_89 - 0.000163493977354382*x_9 + 1.03737884803804e-5*x_90 - 4.69695636530606e-5*x_91 - 7.99385088849912e-5*x_92 + 7.7962038013392e-5*x_93 - 0.000133916557066105*x_94 - 9.59780898656374e-7*x_95 - 2.14845821752257e-5*x_96 - 1.91359682893486e-5*x_97 - 0.000150400759619978*x_98 + 1.55958507764712e-5*x_99 + 4.34714033331321e-7*std::pow(0.403359860181808 - 9.50400066375732*x_23, 2) - 2.02447368214581e-7*std::pow(1.22511982917786 - 9.68591976165771*x_15, 2) + 2.07888972883685e-7*std::pow(1.38495981693268 - 7.2836799621582*x_13, 2) - 7.06396561215536e-8*std::pow(1.60127985477448 - 5.82575988769531*x_20, 2) + 3.69827644677549e-7*std::pow(2.69591999053955 - 5.20391988754272*x_26, 2) - 1.27258970946995e-7*std::pow(2.83799982070923 - 9.29992008209229*x_49, 2) + 2.28072675945782e-7*std::pow(3.67743992805481 - 8.79703998565674*x_10, 2) - 2.93338579848384e-7*std::pow(4.87504005432129 - 9.94591999053955*x_15, 2) + 3.23094684834857e-8*std::pow(5.7087197303772 - 8.35791969299316*x_27, 2) - 6.83802222995021e-7*std::pow(-6.95183992385864*x_10 - 0.208399996161461, 2) - 1.43265710156455e-7*std::pow(-8.32151985168457*x_20 - 1.02223980426788, 2) - 1.38346852459133e-7*std::pow(-5.75559949874878*x_31 - 2.25679969787598, 2) - 1.355284903645e-5*std::exp(0.497119843959808*x_13) - 9.46372889272774e-7*std::exp(0.530159890651703*x_15) - 1.67781774801632e-5*std::exp(0.703039824962616*x_18) + 1.05259727997861e-6*std::exp(0.755279839038849*x_22) - 0.00010374471720471*std::exp(0.45295986533165*x_25) + 1.33063014550358e-5*std::exp(0.489279866218567*x_27) - 3.04014214157314e-6*std::exp(0.522239863872528*x_5) + 1.53031046788651e-5*std::exp(0.521119892597198*x_9) - 5.53190050176404e-5*std::sin(1.43783986568451*x_100 - 1.98039984703064) - 0.000505641935960617*std::sin(0.660719871520996*x_11 + 4.57911968231201) - 0.000136392245052775*std::sin(0.58927983045578*x_12 - 8.00520038604736) - 3.17664242041547e-5*std::sin(0.533199846744537*x_14 - 7.96367979049683) + 0.000195142838246626*std::sin(0.846479892730713*x_2 - 1.80759990215302) - 7.90476340765455e-6*std::sin(0.99999988079071*x_2 + 10.0) - 4.05005085815536e-5*std::sin(0.458079844713211*x_21 - 2.26695990562439) - 0.000108249547467563*std::sin(0.574719846248627*x_21 + 1.40535986423492) + 4.49163081389074e-5*std::sin(0.306079924106598*x_23 - 4.82760000228882) + 0.000801886260633257*std::sin(0.851919889450073*x_24 + 1.59799981117249) + 0.000478726146917896*std::sin(0.436719864606857*x_27 - 1.59663987159729) + 0.000149705511976792*std::sin(0.896799802780151*x_28 - 8.33256053924561) + 4.40460465246106e-5*std::sin(0.295039921998978*x_3 - 1.59319984912872) + 6.6500561314587e-6*std::sin(1.09575986862183*x_3 + 4.79311990737915) + 3.19659462352171e-6*std::sin(0.941519796848297*x_31 + 1.78167986869812) - 9.75744647756088e-5*std::sin(1.21727991104126*x_31 + 0.782879829406738) + 0.00109192482577776*std::sin(0.253759980201721*x_32 - 4.57951974868774) - 6.98131663944338e-6*std::sin(0.583759844303131*x_32 + 7.81175994873047) + 0.000344465762323769*std::sin(0.158640027046204*x_37 + 4.62256002426147) - 0.00052135234986592*std::sin(0.322719842195511*x_37 + 1.4469598531723) + 2.11383875934573e-5*std::sin(0.884639859199524*x_4 - 4.60487985610962) - 0.000227662767930862*std::sin(0.898719847202301*x_4 - 1.56799983978271) - 0.000324056163872746*std::sin(0.673839807510376*x_42 - 1.62783980369568) + 0.000307175744257621*std::sin(0.624719858169556*x_43 - 1.80271995067596) - 0.000178025479739202*std::sin(0.56199985742569*x_44 - 4.96672010421753) - 7.05431940198789e-5*std::sin(0.579199850559235*x_44 - 7.97103977203369) + 6.57835585119645e-5*std::sin(0.690959870815277*x_48 + 4.54207992553711) - 0.000553494497594729*std::sin(0.271839946508408*x_54 - 4.83368015289307) - 4.64452007373964e-5*std::sin(0.313279926776886*x_55 + 1.26903986930847) + 0.000108292714656977*std::sin(0.355039834976196*x_57 + 1.41279983520508) - 0.000464276491967903*std::sin(0.425439864397049*x_58 - 2.00775980949402) - 0.00212204939588193*std::sin(0.136800035834312*x_59 - 4.77503967285156) + 0.000381224564745819*std::sin(0.463279843330383*x_59 + 7.72575998306274) - 1.42290882521386e-6*std::sin(1.05207991600037*x_6 + 0.561199843883514) + 2.88494224540384e-5*std::sin(1.05679976940155*x_6 - 2.23479986190796) + 2.67874361259313e-6*std::sin(1.185919880867*x_62 - 0.798639833927155) - 0.00013351610797958*std::sin(1.13583981990814*x_63 + 4.41039991378784) - 9.80525135580591e-6*std::sin(1.48607981204987*x_63 - 1.9955198764801) - 8.64785546563554e-5*std::sin(1.78023993968964*x_63 - 9.40144062042236) - 0.000172099457570337*std::sin(0.832319855690002*x_68 + 7.59000015258789) - 5.8516280450962e-5*std::sin(1.05863988399506*x_68 - 1.80015993118286) + 3.91975095222733e-6*std::sin(1.72903990745544*x_69 + 0.192159995436668) - 6.58910777122264e-5*std::sin(2.14935994148254*x_69 + 3.99999976158142) + 0.000149728646418966*std::sin(0.775439858436584*x_7 + 1.18935990333557) + 2.07620212450082e-5*std::sin(0.92223984003067*x_72 + 1.21383988857269) - 1.61534937966467e-5*std::sin(1.32399988174438*x_72 + 7.41775989532471) - 2.23506638861994e-5*std::sin(1.41735982894897*x_75 - 1.99655985832214) + 2.81363808990295e-5*std::sin(0.934159815311432*x_76 + 7.59712028503418) - 2.04800497665294e-5*std::sin(1.37239980697632*x_78 + 7.61064004898071) - 0.000106171925670457*std::sin(0.569759845733643*x_8 + 1.42455983161926) + 0.000139327813362931*std::sin(1.16767990589142*x_80 + 4.58631992340088) - 4.6447229970837e-5*std::sin(1.14367985725403*x_82 - 2.57511973381042) - 7.60224709374856e-6*std::sin(0.845919847488403*x_84 + 1.58383977413177) - 4.67111523564333e-6*std::sin(1.04711985588074*x_88 + 1.80127990245819) - 9.92472085708774e-5*std::sin(1.20215976238251*x_88 + 1.38447988033295) + 1.34015231785434e-5*std::sin(1.04359984397888*x_90 - 7.9937596321106) - 0.000158358770746249*std::sin(0.860719919204712*x_91 + 0.970399796962738) - 0.00100720433399932*std::sin(0.28399994969368*x_93 - 7.8187198638916) - 3.75118804498846e-5*std::sin(0.972719848155975*x_93 + 7.41607999801636) - 0.000558926536073849*std::sin(0.36015984416008*x_94 - 7.98040008544922) + 2.0521782294828e-5*std::sin(1.86327993869781*x_99 + 3.96928000450134) + 0.0864604163750083 + 4.42996077469805e-7*std::exp(-3.09487986564636*x_118) - 7.71495807562159e-7*std::exp(-2.20839977264404*x_106));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-6.78300693082921e-5*x_1 + 4.96745705632335e-5*x_10 - 3.1785118616768e-5*x_100 - 0.000365940772356518*x_101 - 4.71233054301006e-6*x_102 - 5.96633580074115e-5*x_103 + 0.000158411621442628*x_104 - 0.000163780013158399*x_105 - 1.7041710794205e-5*x_106 - 4.48971750758436e-5*x_107 - 0.000134128488880364*x_108 + 0.000193764204688968*x_109 - 2.71456944140511e-5*x_11 + 0.000110656391639923*x_110 - 5.14241795579964e-5*x_111 - 9.41009713547912e-5*x_112 + 0.000129062505229365*x_113 - 7.81320241894462e-5*x_114 - 3.05578964273258e-5*x_115 - 3.85800642252802e-6*x_116 + 5.375001648647e-5*x_117 - 0.00018272879079593*x_118 - 4.67970750790191e-5*x_119 + 0.000219372952393497*x_12 + 6.55937094336774e-5*x_120 - 1.34142394842754e-5*x_13 - 0.000209193683490899*x_14 + 0.000398184267919928*x_15 - 0.000191508475266553*x_16 + 9.24856463689061e-6*x_17 - 0.000806284836280046*x_18 - 0.00085818995358642*x_19 + 5.084162384666e-5*x_2 + 9.90762863240631e-7*x_20 + 2.68531242313304e-6*x_21 - 7.00852041000634e-6*x_22 - 1.16315697025991e-5*x_23 + 6.1080147613989e-5*x_24 - 9.18372533505032e-5*x_25 - 0.000339994690126641*x_26 + 0.000372065549622766*x_27 + 7.60527550058765e-5*x_28 - 0.000290285323170164*x_29 - 0.000103021672687915*x_3 + 0.000175388122388947*x_30 - 6.09916132183957e-5*x_31 + 1.00710437879474e-5*x_32 - 5.92551258187916e-5*x_33 - 0.000275298724234341*x_34 - 6.31078350574354e-6*x_35 - 0.000429237841865104*x_36 - 0.000133711894650184*x_37 - 4.55857408999873e-5*x_38 - 0.000103029390784763*x_39 - 9.08244571489095e-5*x_4 - 9.71207583376547e-5*x_40 + 0.000144062588070263*x_41 + 0.000149543086283538*x_42 - 0.000276273033761974*x_43 + 0.000117751050561784*x_44 + 3.4508826740512e-5*x_45 + 0.000196284015719886*x_46 + 0.000328580413048373*x_47 + 0.000149168741362634*x_48 - 0.000218085770929476*x_49 + 0.000165435749386582*x_5 + 0.000203586830256157*x_50 - 0.000126423907177172*x_51 - 4.45650526700465e-5*x_52 - 5.54495859701694e-5*x_53 + 0.000148203706512121*x_54 + 0.000860688340701035*x_55 - 0.000267313006981254*x_56 + 0.000496997236823395*x_57 - 0.00023093756839455*x_58 + 0.000472423402204913*x_59 + 0.000140679770463491*x_6 - 0.000113951424576742*x_60 + 4.56416761327255e-5*x_61 + 2.28293266895086e-5*x_62 + 2.7712668721509e-5*x_63 - 1.10968346236477e-5*x_64 + 3.5690330402065e-5*x_65 + 6.71436393366666e-5*x_66 - 0.000123453463462893*x_67 - 3.27607371609853e-5*x_68 - 4.17725591903618e-5*x_69 + 5.29974757003615e-5*x_7 + 8.95694020268183e-8*x_70 - 8.81529150936424e-6*x_71 - 0.000135977852044876*x_72 - 8.91032940084206e-5*x_73 - 4.7531896496046e-5*x_74 - 2.95763605617493e-5*x_75 - 9.67540286916601e-5*x_76 + 8.51332097006787e-5*x_77 - 0.000182767290685639*x_78 - 6.15462722437525e-5*x_79 - 0.00010909957716176*x_8 - 5.44183607802585e-5*x_80 - 4.87263035512771e-5*x_81 - 2.5206164569723e-5*x_82 + 0.000249979261315118*x_83 - 7.1634286985503e-5*x_84 + 6.45894603408867e-5*x_85 - 1.64024201307996e-5*x_86 - 0.000144987806861574*x_87 - 0.000341802601582842*x_88 + 1.77996387720772e-6*x_89 + 0.000330958751339235*x_9 + 0.000224684658431213*x_90 + 6.65457749416932e-5*x_91 - 0.000197915045371786*x_92 + 1.96753035789103e-5*x_93 - 8.07583476910318e-5*x_94 - 4.43136763355108e-5*x_95 - 0.000124983559070119*x_96 - 2.65820322653831e-5*x_97 - 0.000133810491194226*x_98 - 0.000253285073717531*x_99 + 5.69160687605832e-7*std::pow(0.403359860181808 - 9.50400066375732*x_23, 2) + 3.63687573950841e-7*std::pow(1.22511982917786 - 9.68591976165771*x_15, 2) + 6.13763542557298e-8*std::pow(1.38495981693268 - 7.2836799621582*x_13, 2) - 5.21951121450262e-7*std::pow(1.60127985477448 - 5.82575988769531*x_20, 2) + 1.47750915953165e-6*std::pow(2.69591999053955 - 5.20391988754272*x_26, 2) + 2.28615006534126e-7*std::pow(2.83799982070923 - 9.29992008209229*x_49, 2) - 4.09722284516335e-7*std::pow(3.67743992805481 - 8.79703998565674*x_10, 2) - 3.10288453419599e-7*std::pow(4.87504005432129 - 9.94591999053955*x_15, 2) - 1.94556695074606e-7*std::pow(5.7087197303772 - 8.35791969299316*x_27, 2) - 7.23314111385127e-7*std::pow(-6.95183992385864*x_10 - 0.208399996161461, 2) - 5.7236499772084e-7*std::pow(-8.32151985168457*x_20 - 1.02223980426788, 2) - 1.46340896949871e-7*std::pow(-5.75559949874878*x_31 - 2.25679969787598, 2) - 5.41453806314666e-5*std::exp(0.497119843959808*x_13) - 1.00356486855977e-5*std::exp(0.530159890651703*x_15) - 4.9535256752852e-6*std::exp(0.703039824962616*x_18) - 6.3383849270635e-6*std::exp(0.755279839038849*x_22) - 3.62672682372406e-5*std::exp(0.45295986533165*x_25) - 2.39041709315338e-5*std::exp(0.489279866218567*x_27) - 2.24633822881555e-5*std::exp(0.522239863872528*x_5) + 2.22792662454277e-5*std::exp(0.521119892597198*x_9) - 0.000221006562884192*std::sin(1.43783986568451*x_100 - 1.98039984703064) - 0.000662024894269623*std::sin(0.660719871520996*x_11 + 4.57911968231201) - 0.00054490461774502*std::sin(0.58927983045578*x_12 - 8.00520038604736) + 0.000928273441493413*std::sin(0.533199846744537*x_14 - 7.96367979049683) + 6.82183907764851e-5*std::sin(0.846479892730713*x_2 - 1.80759990215302) - 3.15805497691321e-5*std::sin(0.99999988079071*x_2 + 10.0) - 4.28407343383636e-5*std::sin(0.458079844713211*x_21 - 2.26695990562439) - 0.000157596810554899*std::sin(0.574719846248627*x_21 + 1.40535986423492) - 0.00131253727732531*std::sin(0.306079924106598*x_23 - 4.82760000228882) + 0.00104989050384726*std::sin(0.851919889450073*x_24 + 1.59799981117249) - 0.000120846126792978*std::sin(0.436719864606857*x_27 - 1.59663987159729) - 0.000268939205967839*std::sin(0.896799802780151*x_28 - 8.33256053924561) - 0.00128710662959137*std::sin(0.295039921998978*x_3 - 1.59319984912872) + 7.0519377542723e-5*std::sin(1.09575986862183*x_3 + 4.79311990737915) - 9.34103842839117e-5*std::sin(0.941519796848297*x_31 + 1.78167986869812) + 0.000175288128893726*std::sin(1.21727991104126*x_31 + 0.782879829406738) + 0.000381717080333283*std::sin(0.253759980201721*x_32 - 4.57951974868774) + 4.20391283543927e-5*std::sin(0.583759844303131*x_32 + 7.81175994873047) + 4.11393334723807e-5*std::sin(0.158640027046204*x_37 + 4.62256002426147) - 0.000276101082666598*std::sin(0.322719842195511*x_37 + 1.4469598531723) - 0.000617702630705094*std::sin(0.884639859199524*x_4 - 4.60487985610962) + 0.000408985903239543*std::sin(0.898719847202301*x_4 - 1.56799983978271) + 0.000582152295196925*std::sin(0.673839807510376*x_42 - 1.62783980369568) + 0.000402177855814125*std::sin(0.624719858169556*x_43 - 1.80271995067596) + 0.000319814751847794*std::sin(0.56199985742569*x_44 - 4.96672010421753) - 8.42493013939342e-6*std::sin(0.579199850559235*x_44 - 7.97103977203369) + 7.85648980719276e-6*std::sin(0.690959870815277*x_48 + 4.54207992553711) - 0.000724677108817787*std::sin(0.271839946508408*x_54 - 4.83368015289307) - 0.000343180105083635*std::sin(0.313279926776886*x_55 + 1.26903986930847) + 1.29333320990994e-5*std::sin(0.355039834976196*x_57 + 1.41279983520508) + 0.000117198561592197*std::sin(0.425439864397049*x_58 - 2.00775980949402) - 0.00847786114563679*std::sin(0.136800035834312*x_59 - 4.77503967285156) + 0.000112551298956665*std::sin(0.463279843330383*x_59 + 7.72575998306274) - 1.50889921333819e-5*std::sin(1.05207991600037*x_6 + 0.561199843883514) + 8.39755685443651e-5*std::sin(1.05679976940155*x_6 - 2.23479986190796) - 7.8277823659331e-5*std::sin(1.185919880867*x_62 - 0.798639833927155) + 3.37038296689746e-5*std::sin(1.13583981990814*x_63 + 4.41039991378784) - 7.24502669217133e-5*std::sin(1.48607981204987*x_63 - 1.9955198764801) - 0.000113224303467232*std::sin(1.78023993968964*x_63 - 9.40144062042236) - 6.01628435582999e-5*std::sin(0.832319855690002*x_68 + 7.59000015258789) - 8.51918495767475e-5*std::sin(1.05863988399506*x_68 - 1.80015993118286) - 0.000114542344547085*std::sin(1.72903990745544*x_69 + 0.192159995436668) - 6.96984372394683e-5*std::sin(2.14935994148254*x_69 + 3.99999976158142) + 7.92942458072982e-5*std::sin(0.775439858436584*x_7 + 1.18935990333557) + 0.000153409017928383*std::sin(0.92223984003067*x_72 + 1.21383988857269) - 2.35173186514494e-5*std::sin(1.32399988174438*x_72 + 7.41775989532471) - 2.66932599844047e-6*std::sin(1.41735982894897*x_75 - 1.99655985832214) + 3.36031061172092e-6*std::sin(0.934159815311432*x_76 + 7.59712028503418) - 0.000151325551820397*std::sin(1.37239980697632*x_78 + 7.61064004898071) - 0.00015457207210173*std::sin(0.569759845733643*x_8 + 1.42455983161926) + 7.37861066991798e-5*std::sin(1.16767990589142*x_80 + 4.58631992340088) - 6.76209321309842e-5*std::sin(1.14367985725403*x_82 - 2.57511973381042) - 8.06167229838896e-5*std::sin(0.845919847488403*x_84 + 1.58383977413177) + 0.000136498593217044*std::sin(1.04711985588074*x_88 + 1.80127990245819) + 2.50532393687331e-5*std::sin(1.20215976238251*x_88 + 1.38447988033295) + 0.000142114149714395*std::sin(1.04359984397888*x_90 - 7.9937596321106) - 8.38646417610573e-5*std::sin(0.860719919204712*x_91 + 0.970399796962738) - 0.00131870854710069*std::sin(0.28399994969368*x_93 - 7.8187198638916) - 0.000149864802573872*std::sin(0.972719848155975*x_93 + 7.41607999801636) - 0.000295999858408174*std::sin(0.36015984416008*x_94 - 7.98040008544922) + 2.45090379833163e-6*std::sin(1.86327993869781*x_99 + 3.96928000450134) + 0.0598682739243864 - 2.66757259741343e-6*std::exp(-3.09487986564636*x_118) + 2.25445288956949e-5*std::exp(-2.20839977264404*x_106));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000128312023898472*x_1 - 4.07205727043788e-5*x_10 - 4.69017591162285e-5*x_100 - 0.000268596343979154*x_101 - 4.38838602768846e-5*x_102 + 3.80615869033788e-5*x_103 + 7.01996603619482e-5*x_104 - 0.000175375851136935*x_105 - 8.85311631159556e-5*x_106 - 2.41815455294377e-6*x_107 - 4.69935790747111e-5*x_108 - 0.000102989873467761*x_109 + 3.26036670470215e-5*x_11 - 0.00014832022838876*x_110 + 6.70477583294868e-5*x_111 - 9.00866082264595e-5*x_112 + 2.16396268443548e-5*x_113 - 0.000201290583976832*x_114 - 5.51412898163846e-5*x_115 + 0.000186850365353032*x_116 - 0.000100606338374487*x_117 - 0.000120956327385687*x_118 - 7.10783729534011e-5*x_119 + 0.000130031656108617*x_12 - 6.67723944778696e-6*x_120 + 7.74190949479771e-5*x_13 - 1.72423748269196e-5*x_14 + 9.92756304962404e-5*x_15 - 0.000241845889288893*x_16 - 5.61424931138999e-5*x_17 - 0.00103955590584326*x_18 - 9.97710191349577e-5*x_19 - 7.92413750709281e-5*x_2 - 1.25312412875421e-5*x_20 - 9.38260588102265e-5*x_21 + 0.000267694571359212*x_22 - 0.000132339052951595*x_23 + 0.000115753691401758*x_24 - 0.00022273248315493*x_25 - 0.000547773616730855*x_26 - 0.000233017374982288*x_27 - 5.96274113260862e-5*x_28 + 6.44152687687391e-5*x_29 - 0.000140747579825836*x_3 + 0.000147835852556024*x_30 - 2.12370620554948e-5*x_31 - 0.000279935729552655*x_32 - 8.94022569970738e-5*x_33 - 0.000145882852440795*x_34 + 6.11489557008059e-5*x_35 - 0.000179573871725032*x_36 - 0.000439480629892354*x_37 + 9.18815191573337e-5*x_38 - 6.86716757444185e-5*x_39 + 0.000335287255028024*x_4 - 0.000179245514993392*x_40 + 3.7359086282745e-5*x_41 - 6.32358296955111e-6*x_42 + 0.000132246575149044*x_43 - 4.90380127047735e-6*x_44 - 0.00023368892244611*x_45 + 0.00018374433420724*x_46 + 0.000160260834099375*x_47 + 0.000119214547471788*x_48 - 0.000330728412781365*x_49 + 3.62046239994118e-5*x_5 - 6.18897569683285e-5*x_50 - 0.000370390921091443*x_51 - 0.000142353550686587*x_52 + 6.9058732735993e-5*x_53 + 0.000110977468902678*x_54 - 0.000327047763146046*x_55 + 0.000318821067517708*x_56 - 0.000603645127122301*x_57 + 0.000411303248886323*x_58 + 0.000449399409525972*x_59 + 5.49231241573251e-6*x_6 - 0.00027798750649936*x_60 - 1.76385806815251e-5*x_61 + 2.93134159119315e-5*x_62 - 4.82379095691267e-5*x_63 - 6.90818082790874e-5*x_64 - 5.78487310466855e-5*x_65 + 7.79647133473087e-5*x_66 - 6.38929148083334e-5*x_67 + 2.06653106380654e-5*x_68 - 1.27936410111517e-5*x_69 - 5.10400469523637e-5*x_7 - 3.56455878194366e-5*x_70 + 5.50336463304581e-5*x_71 - 1.03171407165728e-5*x_72 - 3.53850955471416e-5*x_73 - 3.27925491132413e-5*x_74 + 2.23147046935758e-5*x_75 - 0.000117513821994898*x_76 - 1.45709500050049e-5*x_77 - 0.000270227176869516*x_78 - 4.19908072081907e-5*x_79 - 0.000102408973484562*x_8 - 4.44560279820799e-6*x_80 - 8.24174455925054e-5*x_81 - 8.57208052319872e-5*x_82 + 0.000136443861391423*x_83 - 6.44520361597219e-5*x_84 + 2.53404570443768e-5*x_85 - 0.00010996984864919*x_86 - 1.78469343793469e-5*x_87 + 1.04439192166168e-6*x_88 - 1.45011479197741e-5*x_89 + 0.000125038400214221*x_9 + 4.33026681111746e-5*x_90 + 8.68512795220861e-5*x_91 - 0.000172724405299487*x_92 - 3.56964669828855e-5*x_93 - 0.000102475867602904*x_94 - 0.000132431252659772*x_95 - 0.000151485005842138*x_96 - 2.1862269304674e-5*x_97 + 0.000171644325886465*x_98 - 3.7045345226866e-5*x_99 + 2.65504350787987e-7*std::pow(0.403359860181808 - 9.50400066375732*x_23, 2) + 7.63102444048965e-8*std::pow(1.22511982917786 - 9.68591976165771*x_15, 2) - 5.87109138118032e-7*std::pow(1.38495981693268 - 7.2836799621582*x_13, 2) - 2.4286288867676e-7*std::pow(1.60127985477448 - 5.82575988769531*x_20, 2) + 2.58069881423978e-7*std::pow(2.69591999053955 - 5.20391988754272*x_26, 2) + 4.79688289421851e-8*std::pow(2.83799982070923 - 9.29992008209229*x_49, 2) - 8.59694141593088e-8*std::pow(3.67743992805481 - 8.79703998565674*x_10, 2) - 3.38176894182992e-7*std::pow(4.87504005432129 - 9.94591999053955*x_15, 2) + 7.41371301523161e-8*std::pow(5.7087197303772 - 8.35791969299316*x_27, 2) - 7.88324918349999e-7*std::pow(-6.95183992385864*x_10 - 0.208399996161461, 2) - 9.99724205702214e-8*std::pow(-8.32151985168457*x_20 - 1.02223980426788, 2) - 1.59493882150804e-7*std::pow(-5.75559949874878*x_31 - 2.25679969787598, 2) - 9.45733017563699e-6*std::exp(0.497119843959808*x_13) - 1.60182498756516e-6*std::exp(0.530159890651703*x_15) + 4.73840492015007e-5*std::exp(0.703039824962616*x_18) + 2.41528397731566e-6*std::exp(0.755279839038849*x_22) - 1.30140410739663e-5*std::exp(0.45295986533165*x_25) - 5.01565974956387e-6*std::exp(0.489279866218567*x_27) - 1.0452170112775e-5*std::exp(0.522239863872528*x_5) - 3.36007935925686e-5*std::exp(0.521119892597198*x_9) - 3.86022226051875e-5*std::sin(1.43783986568451*x_100 - 1.98039984703064) - 0.000308824016813105*std::sin(0.660719871520996*x_11 + 4.57911968231201) - 9.51760394726831e-5*std::sin(0.58927983045578*x_12 - 8.00520038604736) + 0.000484681414791872*std::sin(0.533199846744537*x_14 - 7.96367979049683) + 2.44792889764285e-5*std::sin(0.846479892730713*x_2 - 1.80759990215302) - 5.51603262940677e-6*std::sin(0.99999988079071*x_2 + 10.0) - 4.66912201321099e-5*std::sin(0.458079844713211*x_21 - 2.26695990562439) + 0.000237681880721231*std::sin(0.574719846248627*x_21 + 1.40535986423492) - 0.000685317920458483*std::sin(0.306079924106598*x_23 - 4.82760000228882) + 0.0004897571155081*std::sin(0.851919889450073*x_24 + 1.59799981117249) + 0.000274809580136908*std::sin(0.436719864606857*x_27 - 1.59663987159729) - 5.64297985617694e-5*std::sin(0.896799802780151*x_28 - 8.33256053924561) - 0.000672039761489579*std::sin(0.295039921998978*x_3 - 1.59319984912872) + 1.12558444993781e-5*std::sin(1.09575986862183*x_3 + 4.79311990737915) - 4.87725654825815e-5*std::sin(0.941519796848297*x_31 + 1.78167986869812) + 3.67795902726258e-5*std::sin(1.21727991104126*x_31 + 0.782879829406738) + 0.000136974247125424*std::sin(0.253759980201721*x_32 - 4.57951974868774) - 1.60192910817301e-5*std::sin(0.583759844303131*x_32 + 7.81175994873047) + 4.4159602006209e-5*std::sin(0.158640027046204*x_37 + 4.62256002426147) + 0.00111755415612339*std::sin(0.322719842195511*x_37 + 1.4469598531723) - 0.000322522407286744*std::sin(0.884639859199524*x_4 - 4.60487985610962) + 8.58149039719061e-5*std::sin(0.898719847202301*x_4 - 1.56799983978271) + 0.000122149303713504*std::sin(0.673839807510376*x_42 - 1.62783980369568) + 0.00018760953248265*std::sin(0.624719858169556*x_43 - 1.80271995067596) + 6.71046899201876e-5*std::sin(0.56199985742569*x_44 - 4.96672010421753) - 9.04345137568896e-6*std::sin(0.579199850559235*x_44 - 7.97103977203369) + 8.43327865981083e-6*std::sin(0.690959870815277*x_48 + 4.54207992553711) - 0.000338050272089119*std::sin(0.271839946508408*x_54 - 4.83368015289307) - 0.000159681066352394*std::sin(0.313279926776886*x_55 + 1.26903986930847) + 1.38828403356071e-5*std::sin(0.355039834976196*x_57 + 1.41279983520508) - 0.00026651485122875*std::sin(0.425439864397049*x_58 - 2.00775980949402) - 0.00148078988645794*std::sin(0.136800035834312*x_59 - 4.77503967285156) - 0.00107663442910254*std::sin(0.463279843330383*x_59 + 7.72575998306274) - 2.40840680992669e-6*std::sin(1.05207991600037*x_6 + 0.561199843883514) + 4.69080363918821e-5*std::sin(1.05679976940155*x_6 - 2.23479986190796) - 4.08713689545996e-5*std::sin(1.185919880867*x_62 - 0.798639833927155) - 7.66440392103238e-5*std::sin(1.13583981990814*x_63 + 4.41039991378784) - 3.37109748152659e-5*std::sin(1.48607981204987*x_63 - 1.9955198764801) - 5.28173253004225e-5*std::sin(1.78023993968964*x_63 - 9.40144062042236) - 2.1588659837091e-5*std::sin(0.832319855690002*x_68 + 7.59000015258789) + 0.00012848330469523*std::sin(1.05863988399506*x_68 - 1.80015993118286) - 5.98062414877925e-5*std::sin(1.72903990745544*x_69 + 0.192159995436668) - 7.59628686639448e-5*std::sin(2.14935994148254*x_69 + 3.99999976158142) - 0.000320953518554734*std::sin(0.775439858436584*x_7 + 1.18935990333557) + 7.13809314934143e-5*std::sin(0.92223984003067*x_72 + 1.21383988857269) + 3.5467980011244e-5*std::sin(1.32399988174438*x_72 + 7.41775989532471) - 2.86529614766596e-6*std::sin(1.41735982894897*x_75 - 1.99655985832214) + 3.6070098056027e-6*std::sin(0.934159815311432*x_76 + 7.59712028503418) - 7.04114985778577e-5*std::sin(1.37239980697632*x_78 + 7.61064004898071) + 0.000233120078222134*std::sin(0.569759845733643*x_8 + 1.42455983161926) - 0.00029865862679505*std::sin(1.16767990589142*x_80 + 4.58631992340088) + 0.000101983474592059*std::sin(1.14367985725403*x_82 - 2.57511973381042) - 1.28675171218912e-5*std::sin(0.845919847488403*x_84 + 1.58383977413177) + 7.12703049772715e-5*std::sin(1.04711985588074*x_88 + 1.80127990245819) - 5.6972204030879e-5*std::sin(1.20215976238251*x_88 + 1.38447988033295) + 2.26833364968014e-5*std::sin(1.04359984397888*x_90 - 7.9937596321106) + 0.000339452775942365*std::sin(0.860719919204712*x_91 + 0.970399796962738) - 0.000615156429986979*std::sin(0.28399994969368*x_93 - 7.8187198638916) - 2.6176211213558e-5*std::sin(0.972719848155975*x_93 + 7.41607999801636) + 0.00119809697514094*std::sin(0.36015984416008*x_94 - 7.98040008544922) + 2.63083835236399e-6*std::sin(1.86327993869781*x_99 + 3.96928000450134) + 0.090100439375806 + 1.01649638306898e-6*std::exp(-3.09487986564636*x_118) + 1.17712235129795e-5*std::exp(-2.20839977264404*x_106));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.73791095552412e-5*x_1 + 0.000190497837419902*x_10 + 9.44489939882586e-6*x_100 + 2.59852482040671e-5*x_101 + 7.1665637902776e-5*x_102 + 0.000113238957173492*x_103 + 0.00011636962950343*x_104 + 0.000245472210530857*x_105 + 0.000148340351170998*x_106 + 3.80721721212709e-5*x_107 - 3.65332679624165e-7*x_108 - 3.1840489357387e-5*x_109 + 2.3954996328491e-5*x_11 - 7.1233200949734e-5*x_110 - 0.000210579006879338*x_111 - 0.000114481423143878*x_112 + 5.4763727308153e-5*x_113 + 7.81705979363929e-5*x_114 - 3.21987087404467e-5*x_115 + 0.000185104241935502*x_116 + 4.52927262755364e-5*x_117 + 5.37398864942919e-5*x_118 - 3.10171000963878e-5*x_119 - 3.28649722109925e-5*x_12 + 7.27273290839727e-6*x_120 - 2.00475441610354e-5*x_13 - 0.000190801198323777*x_14 - 4.08241654621871e-5*x_15 - 6.26932173775002e-5*x_16 + 4.79926019870609e-5*x_17 + 2.58425175462572e-5*x_18 + 0.000263810141007707*x_19 - 1.40645551930928e-5*x_2 + 0.000234721088861707*x_20 - 1.36157289276558e-5*x_21 + 0.000266528459764327*x_22 + 3.50624610873442e-5*x_23 + 0.000119844534007905*x_24 - 0.000132830147540533*x_25 + 0.00017951512546957*x_26 - 7.64751882729886e-5*x_27 + 0.000223110024338156*x_28 + 0.00028095546728357*x_29 - 4.63596188976027e-5*x_3 + 0.000169584654911813*x_30 - 4.86798065042711e-5*x_31 + 8.30702516446443e-6*x_32 - 3.47206641835098e-5*x_33 + 0.000793366068882747*x_34 - 5.86554635261176e-5*x_35 - 2.67557054001603e-5*x_36 + 0.000269715237243115*x_37 + 0.000293292783978968*x_38 + 7.40267960509796e-5*x_39 + 0.000663314469476284*x_4 + 0.000158257187402971*x_40 - 1.11070218573278e-5*x_41 - 5.13970623373919e-5*x_42 - 7.13659516417726e-5*x_43 + 5.82574474103378e-5*x_44 - 4.30319592589813e-5*x_45 - 2.69627207036279e-5*x_46 + 0.000147720388760263*x_47 - 4.79957948748009e-5*x_48 + 0.000210502119366447*x_49 - 0.000200105479500527*x_5 + 6.66073606544136e-5*x_50 + 0.000205799469110518*x_51 + 0.000201750652271374*x_52 + 0.000124945556569177*x_53 + 0.000224992328151323*x_54 - 0.000126266384669106*x_55 + 0.000689073974506834*x_56 - 0.000440310656407878*x_57 - 0.000346166896719693*x_58 + 0.000273633732713245*x_59 - 7.80781593803644e-5*x_6 + 7.34950046685258e-5*x_60 + 8.49798028104463e-5*x_61 + 1.42770920447068e-5*x_62 - 1.35746424837273e-5*x_63 - 2.55115621077251e-5*x_64 + 1.62419137004576e-5*x_65 - 3.09644885073037e-5*x_66 - 4.47091132564495e-5*x_67 + 1.46959076086095e-5*x_68 + 7.80468774166955e-5*x_69 + 6.77324094037367e-5*x_7 - 2.6591466334732e-5*x_70 - 8.86064342507929e-5*x_71 + 4.16842641407981e-5*x_72 + 4.03803909865995e-5*x_73 + 7.13532687384356e-5*x_74 + 2.84088612796322e-5*x_75 + 3.884549070915e-5*x_76 - 6.10790554443928e-5*x_77 + 0.000180447379874101*x_78 + 1.9344503101479e-5*x_79 - 4.84101265141829e-5*x_8 + 0.000131532989848844*x_80 + 1.52956228664577e-5*x_81 + 5.9903408182391e-5*x_82 + 1.86490968549698e-7*x_83 - 0.000117243899696147*x_84 - 6.29760206104004e-6*x_85 + 3.15500698876585e-5*x_86 + 0.000104692739487831*x_87 + 8.68767425198593e-5*x_88 + 4.01225565633002e-6*x_89 - 7.49501373041365e-5*x_9 - 0.000120868524296563*x_90 - 2.76436489511327e-5*x_91 + 0.000163211787426414*x_92 - 4.77522506152208e-5*x_93 + 8.56846551138574e-5*x_94 + 3.89774973215727e-5*x_95 + 7.30314424993261e-5*x_96 + 2.61810309000571e-6*x_97 + 4.72789076942073e-5*x_98 + 0.000397372305080442*x_99 - 2.71990832584152e-7*std::pow(0.403359860181808 - 9.50400066375732*x_23, 2) - 5.79609124938031e-8*std::pow(1.22511982917786 - 9.68591976165771*x_15, 2) + 2.75101015306618e-7*std::pow(1.38495981693268 - 7.2836799621582*x_13, 2) - 2.96632688599487e-7*std::pow(1.60127985477448 - 5.82575988769531*x_20, 2) + 5.64943472830853e-8*std::pow(2.69591999053955 - 5.20391988754272*x_26, 2) - 3.64343885729948e-8*std::pow(2.83799982070923 - 9.29992008209229*x_49, 2) + 6.52974673333831e-8*std::pow(3.67743992805481 - 8.79703998565674*x_10, 2) - 1.10626059951663e-7*std::pow(4.87504005432129 - 9.94591999053955*x_15, 2) + 1.08830525543587e-7*std::pow(5.7087197303772 - 8.35791969299316*x_27, 2) - 2.57880657072882e-7*std::pow(-6.95183992385864*x_10 - 0.208399996161461, 2) - 2.18850670030183e-8*std::pow(-8.32151985168457*x_20 - 1.02223980426788, 2) - 5.21744095242377e-8*std::pow(-5.75559949874878*x_31 - 2.25679969787598, 2) - 2.07031402643794e-6*std::exp(0.497119843959808*x_13) - 1.83095034579144e-6*std::exp(0.530159890651703*x_15) - 2.22026863462836e-5*std::exp(0.703039824962616*x_18) + 3.54554626066891e-6*std::exp(0.755279839038849*x_22) + 0.000106090096558339*std::exp(0.45295986533165*x_25) + 3.80960928785216e-6*std::exp(0.489279866218567*x_27) - 1.27662786980114e-5*std::exp(0.522239863872528*x_5) + 3.61999689129342e-5*std::exp(0.521119892597198*x_9) - 8.45045286851441e-6*std::sin(1.43783986568451*x_100 - 1.98039984703064) + 0.000316368832396471*std::sin(0.660719871520996*x_11 + 4.57911968231201) - 2.08350862073857e-5*std::sin(0.58927983045578*x_12 - 8.00520038604736) + 0.000105832728323567*std::sin(0.533199846744537*x_14 - 7.96367979049683) - 0.000199554474772938*std::sin(0.846479892730713*x_2 - 1.80759990215302) - 1.20752046411249e-6*std::sin(0.99999988079071*x_2 + 10.0) - 1.52738575769049e-5*std::sin(0.458079844713211*x_21 - 2.26695990562439) - 0.00025606766309172*std::sin(0.574719846248627*x_21 + 1.40535986423492) - 0.00014964276136377*std::sin(0.306079924106598*x_23 - 4.82760000228882) - 0.000501722270146271*std::sin(0.851919889450073*x_24 + 1.59799981117249) + 0.000334487981891144*std::sin(0.436719864606857*x_27 - 1.59663987159729) + 4.28608588792802e-5*std::sin(0.896799802780151*x_28 - 8.33256053924561) - 0.00014674340572952*std::sin(0.295039921998978*x_3 - 1.59319984912872) + 1.28658826889929e-5*std::sin(1.09575986862183*x_3 + 4.79311990737915) - 1.06497454097305e-5*std::sin(0.941519796848297*x_31 + 1.78167986869812) - 2.79356805888149e-5*std::sin(1.21727991104126*x_31 + 0.782879829406738) - 0.00111661020746366*std::sin(0.253759980201721*x_32 - 4.57951974868774) - 2.35157182868903e-5*std::sin(0.583759844303131*x_32 + 7.81175994873047) - 0.000298598389625821*std::sin(0.158640027046204*x_37 + 4.62256002426147) + 0.00063630451887091*std::sin(0.322719842195511*x_37 + 1.4469598531723) - 7.04244587618409e-5*std::sin(0.884639859199524*x_4 - 4.60487985610962) - 6.51801102010441e-5*std::sin(0.898719847202301*x_4 - 1.56799983978271) - 9.27776494352717e-5*std::sin(0.673839807510376*x_42 - 1.62783980369568) - 0.000192192982108331*std::sin(0.624719858169556*x_43 - 1.80271995067596) - 5.09688979601566e-5*std::sin(0.56199985742569*x_44 - 4.96672010421753) + 6.11500080335974e-5*std::sin(0.579199850559235*x_44 - 7.97103977203369) - 5.70241422631313e-5*std::sin(0.690959870815277*x_48 + 4.54207992553711) + 0.000346309108261057*std::sin(0.271839946508408*x_54 - 4.83368015289307) - 0.000195034425756117*std::sin(0.313279926776886*x_55 + 1.26903986930847) - 9.38729875115682e-5*std::sin(0.355039834976196*x_57 + 1.41279983520508) - 0.000324391946915065*std::sin(0.425439864397049*x_58 - 2.00775980949402) - 0.000324161260652489*std::sin(0.136800035834312*x_59 - 4.77503967285156) + 0.000504477285960118*std::sin(0.463279843330383*x_59 + 7.72575998306274) - 2.75290578913032e-6*std::sin(1.05207991600037*x_6 + 0.561199843883514) - 0.000133433998841882*std::sin(1.05679976940155*x_6 - 2.23479986190796) - 8.92447771830049e-6*std::sin(1.185919880867*x_62 - 0.798639833927155) - 9.32882688684836e-5*std::sin(1.13583981990814*x_63 + 4.41039991378784) - 4.11745785831906e-5*std::sin(1.48607981204987*x_63 - 1.9955198764801) + 5.41076944339848e-5*std::sin(1.78023993968964*x_63 - 9.40144062042236) + 0.000175990147385027*std::sin(0.832319855690002*x_68 + 7.59000015258789) - 0.000138422076936512*std::sin(1.05863988399506*x_68 - 1.80015993118286) - 1.30590064200195e-5*std::sin(1.72903990745544*x_69 + 0.192159995436668) - 2.48493407073832e-5*std::sin(2.14935994148254*x_69 + 3.99999976158142) - 0.000182742082864525*std::sin(0.775439858436584*x_7 + 1.18935990333557) + 8.71846569024749e-5*std::sin(0.92223984003067*x_72 + 1.21383988857269) - 3.82115907552723e-5*std::sin(1.32399988174438*x_72 + 7.41775989532471) + 1.93745590228333e-5*std::sin(1.41735982894897*x_75 - 1.99655985832214) - 2.43898783138054e-5*std::sin(0.934159815311432*x_76 + 7.59712028503418) - 8.60005917135728e-5*std::sin(1.37239980697632*x_78 + 7.61064004898071) - 0.000251152984270242*std::sin(0.569759845733643*x_8 + 1.42455983161926) - 0.000170047986299545*std::sin(1.16767990589142*x_80 + 4.58631992340088) - 0.000109872363570664*std::sin(1.14367985725403*x_82 - 2.57511973381042) - 1.47080892773535e-5*std::sin(0.845919847488403*x_84 + 1.58383977413177) + 1.55622447942145e-5*std::sin(1.04711985588074*x_88 + 1.80127990245819) - 6.93444440353405e-5*std::sin(1.20215976238251*x_88 + 1.38447988033295) + 2.59279653675852e-5*std::sin(1.04359984397888*x_90 - 7.9937596321106) + 0.00019327504988631*std::sin(0.860719919204712*x_91 + 0.970399796962738) + 0.000630185189301325*std::sin(0.28399994969368*x_93 - 7.8187198638916) - 5.73026173645048e-6*std::sin(0.972719848155975*x_93 + 7.41607999801636) + 0.000682163378974161*std::sin(0.36015984416008*x_94 - 7.98040008544922) - 1.77892023408925e-5*std::sin(1.86327993869781*x_99 + 3.96928000450134) + 0.0519800256337549 + 1.49217855284214e-6*std::exp(-3.09487986564636*x_118) + 2.57030837590522e-6*std::exp(-2.20839977264404*x_106));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-9.77437492082411e-5*x_1 - 0.000294840207672828*x_10 - 2.47395119889077e-5*x_100 - 0.000375735385907058*x_101 - 0.000145513175966534*x_102 - 0.000151031342494783*x_103 + 0.000201637690486482*x_104 - 8.51305458337309e-5*x_105 - 0.00020417003649737*x_106 - 8.75005335042546e-5*x_107 - 0.000176935347511808*x_108 + 4.4976558154499e-5*x_109 - 0.000119223342261658*x_11 - 5.62117444170598e-5*x_110 + 8.28893419482328e-5*x_111 + 6.02660138608341e-5*x_112 - 3.95439586643619e-5*x_113 - 0.000260050239402631*x_114 - 0.000249587194066702*x_115 - 7.89526004777884e-5*x_116 - 8.20951759147466e-6*x_117 - 0.000181199419394526*x_118 - 6.85866152843418e-5*x_119 - 7.0096145735839e-6*x_12 - 1.62996512334632e-5*x_120 + 2.00097736244115e-5*x_13 - 0.000379921386027264*x_14 + 0.000157430373344375*x_15 - 9.5282924537179e-5*x_16 + 4.63577088641795e-5*x_17 - 0.000980116347485548*x_18 - 0.000508974632542046*x_19 + 5.95007782133158e-5*x_2 - 0.000168665208909033*x_20 + 0.000140801066806784*x_21 - 0.000229277278702732*x_22 + 4.36763210959122e-5*x_23 + 9.44742528399405e-5*x_24 - 0.000196555998245487*x_25 - 0.000267568649558781*x_26 + 0.000271254062095133*x_27 - 3.29240156159785e-5*x_28 - 0.00039310224109791*x_29 + 1.56109330434586e-5*x_3 + 0.000658997136645406*x_30 - 7.31395551571558e-5*x_31 - 0.000222126595154915*x_32 - 8.74729869139293e-5*x_33 - 0.000692264328693016*x_34 - 5.99932507915336e-5*x_35 - 0.000941593131873522*x_36 - 0.000702197248151558*x_37 + 3.35508241443728e-5*x_38 - 0.000414593701752398*x_39 - 0.000289403744845489*x_4 - 0.000475808333736877*x_40 + 6.31959547709865e-5*x_41 + 0.000237905649072697*x_42 - 0.000488796995176312*x_43 + 6.00092089740291e-5*x_44 - 0.000145594907418586*x_45 + 7.77306133232464e-6*x_46 + 0.000308373666273514*x_47 - 7.64427753912678e-5*x_48 - 0.000582241104604381*x_49 + 0.000113440393979001*x_5 - 7.7348212333756e-5*x_50 - 0.000101930002695294*x_51 - 0.000248316309030643*x_52 - 4.20510455346563e-5*x_53 + 3.39672442559107e-5*x_54 + 0.000812506168297215*x_55 - 0.00081122210035723*x_56 - 0.000300663866983318*x_57 - 0.000523787333338469*x_58 + 0.000300094213094468*x_59 + 0.000172083732434116*x_6 - 0.000233125102290819*x_60 - 3.47361211478003e-5*x_61 - 4.94939737248859e-6*x_62 + 2.78966905780925e-5*x_63 + 0.0001308116347863*x_64 + 6.22190724178368e-6*x_65 + 5.98386273274726e-5*x_66 - 6.70934669001516e-5*x_67 - 4.34364799203068e-5*x_68 - 3.26825837295761e-5*x_69 + 9.82885031893191e-5*x_7 + 2.16732398166175e-5*x_70 + 1.16854144917872e-6*x_71 - 0.000139164838227836*x_72 - 2.4403713123577e-5*x_73 + 2.86119396508446e-5*x_74 + 4.51571966153218e-5*x_75 - 9.49654664365589e-5*x_76 + 3.82270560818143e-5*x_77 - 0.000283463700905601*x_78 - 4.33172449191909e-5*x_79 - 0.000266753896022766*x_8 - 7.21365291808006e-5*x_80 - 8.60215924147145e-5*x_81 - 0.000110347983604161*x_82 + 0.000473538903286656*x_83 - 3.32967955324807e-5*x_84 + 7.28864100801927e-5*x_85 - 9.20985122541186e-5*x_86 + 0.000164125375651488*x_87 - 4.63485064369908e-5*x_88 + 7.16312794842357e-5*x_89 + 0.000246916627813978*x_9 + 0.000157597010976904*x_90 + 6.16796338640251e-5*x_91 - 0.000266754570958272*x_92 - 1.60104570597867e-5*x_93 - 0.000125019395714517*x_94 - 5.71814741266038e-6*x_95 - 0.000139218223068265*x_96 - 9.94160235294654e-5*x_97 - 0.000238194152445563*x_98 - 0.000355278232692422*x_99 + 8.48753492258359e-7*std::pow(0.403359860181808 - 9.50400066375732*x_23, 2) + 5.23200142151957e-7*std::pow(1.22511982917786 - 9.68591976165771*x_15, 2) + 4.44092610831564e-7*std::pow(1.38495981693268 - 7.2836799621582*x_13, 2) - 2.47791084361174e-7*std::pow(1.60127985477448 - 5.82575988769531*x_20, 2) + 1.92101796310854e-6*std::pow(2.69591999053955 - 5.20391988754272*x_26, 2) + 3.28885044427977e-7*std::pow(2.83799982070923 - 9.29992008209229*x_49, 2) - 5.89425575289924e-7*std::pow(3.67743992805481 - 8.79703998565674*x_10, 2) - 5.80475758799844e-7*std::pow(4.87504005432129 - 9.94591999053955*x_15, 2) + 7.49965664330175e-8*std::pow(5.7087197303772 - 8.35791969299316*x_27, 2) - 1.35314834641667e-6*std::pow(-6.95183992385864*x_10 - 0.208399996161461, 2) - 7.44173689200573e-7*std::pow(-8.32151985168457*x_20 - 1.02223980426788, 2) - 2.73768947133695e-7*std::pow(-5.75559949874878*x_31 - 2.25679969787598, 2) - 7.03983783392362e-5*std::exp(0.497119843959808*x_13) + 2.40700623745026e-6*std::exp(0.530159890651703*x_15) - 3.58415578219722e-5*std::exp(0.703039824962616*x_18) + 2.44328320892925e-6*std::exp(0.755279839038849*x_22) - 9.73098468902217e-5*std::exp(0.45295986533165*x_25) - 3.43884876063807e-5*std::exp(0.489279866218567*x_27) - 1.06642664932603e-5*std::exp(0.522239863872528*x_5) - 2.31996111364524e-5*std::exp(0.521119892597198*x_9) - 0.000287346832692385*std::sin(1.43783986568451*x_100 - 1.98039984703064) - 0.000987236035814283*std::sin(0.660719871520996*x_11 + 4.57911968231201) - 0.000708470436285337*std::sin(0.58927983045578*x_12 - 8.00520038604736) + 0.000470956222234536*std::sin(0.533199846744537*x_14 - 7.96367979049683) + 0.00018303890764898*std::sin(0.846479892730713*x_2 - 1.80759990215302) - 4.10601876813923e-5*std::sin(0.99999988079071*x_2 + 10.0) - 8.01448055786189e-5*std::sin(0.458079844713211*x_21 - 2.26695990562439) + 0.000164107052761181*std::sin(0.574719846248627*x_21 + 1.40535986423492) - 0.000665911109852129*std::sin(0.306079924106598*x_23 - 4.82760000228882) + 0.00156563559471692*std::sin(0.851919889450073*x_24 + 1.59799981117249) + 4.05530877183648e-5*std::sin(0.436719864606857*x_27 - 1.59663987159729) - 0.00038689534884034*std::sin(0.896799802780151*x_28 - 8.33256053924561) - 0.000653008961357514*std::sin(0.295039921998978*x_3 - 1.59319984912872) - 1.69137628193424e-5*std::sin(1.09575986862183*x_3 + 4.79311990737915) - 4.73914255578102e-5*std::sin(0.941519796848297*x_31 + 1.78167986869812) + 0.000252169115811321*std::sin(1.21727991104126*x_31 + 0.782879829406738) + 0.00102419709142782*std::sin(0.253759980201721*x_32 - 4.57951974868774) - 1.62049950591901e-5*std::sin(0.583759844303131*x_32 + 7.81175994873047) + 0.00119109183581338*std::sin(0.158640027046204*x_37 + 4.62256002426147) - 0.000305950569969528*std::sin(0.322719842195511*x_37 + 1.4469598531723) - 0.000313389228235579*std::sin(0.884639859199524*x_4 - 4.60487985610962) + 0.000588366218808452*std::sin(0.898719847202301*x_4 - 1.56799983978271) + 0.000837483008540426*std::sin(0.673839807510376*x_42 - 1.62783980369568) + 0.000599742510444813*std::sin(0.624719858169556*x_43 - 1.80271995067596) + 0.000460084796990276*std::sin(0.56199985742569*x_44 - 4.96672010421753) - 0.000243923871860165*std::sin(0.579199850559235*x_44 - 7.97103977203369) + 0.000227466030138305*std::sin(0.690959870815277*x_48 + 4.54207992553711) - 0.00108066533803675*std::sin(0.271839946508408*x_54 - 4.83368015289307) - 0.000162921328981106*std::sin(0.313279926776886*x_55 + 1.26903986930847) + 0.00037445395860491*std::sin(0.355039834976196*x_57 + 1.41279983520508) - 3.93290515372208e-5*std::sin(0.425439864397049*x_58 - 2.00775980949402) - 0.0110226887220588*std::sin(0.136800035834312*x_59 - 4.77503967285156) + 0.000814372258050555*std::sin(0.463279843330383*x_59 + 7.72575998306274) + 3.61902845742404e-6*std::sin(1.05207991600037*x_6 + 0.561199843883514) - 6.88241413273522e-5*std::sin(1.05679976940155*x_6 - 2.23479986190796) - 3.97139748564069e-5*std::sin(1.185919880867*x_62 - 0.798639833927155) - 1.13102041189307e-5*std::sin(1.13583981990814*x_63 + 4.41039991378784) - 3.43950409626595e-5*std::sin(1.48607981204987*x_63 - 1.9955198764801) - 0.000168844273803545*std::sin(1.78023993968964*x_63 - 9.40144062042236) - 0.000161424815810278*std::sin(0.832319855690002*x_68 + 7.59000015258789) + 8.87110805357559e-5*std::sin(1.05863988399506*x_68 - 1.80015993118286) - 5.8112650284377e-5*std::sin(1.72903990745544*x_69 + 0.192159995436668) - 0.000130389167878679*std::sin(2.14935994148254*x_69 + 3.99999976158142) + 8.78668039463711e-5*std::sin(0.775439858436584*x_7 + 1.18935990333557) + 7.28293998059341e-5*std::sin(0.92223984003067*x_72 + 1.21383988857269) + 2.4488806842893e-5*std::sin(1.32399988174438*x_72 + 7.41775989532471) - 7.7284003786823e-5*std::sin(1.41735982894897*x_75 - 1.99655985832214) + 9.7289824544798e-5*std::sin(0.934159815311432*x_76 + 7.59712028503418) - 7.1840295070048e-5*std::sin(1.37239980697632*x_78 + 7.61064004898071) + 0.000160957363937053*std::sin(0.569759845733643*x_8 + 1.42455983161926) + 8.17631759441759e-5*std::sin(1.16767990589142*x_80 + 4.58631992340088) + 7.04143176369296e-5*std::sin(1.14367985725403*x_82 - 2.57511973381042) + 1.93355667525009e-5*std::sin(0.845919847488403*x_84 + 1.58383977413177) + 6.92520747964151e-5*std::sin(1.04711985588074*x_88 + 1.80127990245819) - 8.40727163304058e-6*std::sin(1.20215976238251*x_88 + 1.38447988033295) - 3.40854543148167e-5*std::sin(1.04359984397888*x_90 - 7.9937596321106) - 9.29313087050415e-5*std::sin(0.860719919204712*x_91 + 0.970399796962738) - 0.00196650701461973*std::sin(0.28399994969368*x_93 - 7.8187198638916) - 0.000194850215259159*std::sin(0.972719848155975*x_93 + 7.41607999801636) - 0.000328000616717018*std::sin(0.36015984416008*x_94 - 7.98040008544922) + 7.09601069865819e-5*std::sin(1.86327993869781*x_99 + 3.96928000450134) + 0.0632828969443317 + 1.02828013931927e-6*std::exp(-3.09487986564636*x_118) + 1.14378863879724e-5*std::exp(-2.20839977264404*x_106));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-4.09892857938611e-5*x_1 - 0.000199272969802739*x_10 + 5.75090951932346e-5*x_100 - 6.12559127984933e-5*x_101 - 9.05236825700211e-5*x_102 - 3.47452187583717e-5*x_103 + 0.000226517355710123*x_104 - 0.000279721945269993*x_105 - 2.29381902628839e-5*x_106 - 7.6002337531669e-5*x_107 - 0.000197354034012927*x_108 - 9.19144257599471e-5*x_109 - 1.76136191129823e-5*x_11 + 3.83509777449292e-5*x_110 - 0.000118101157618908*x_111 + 0.000358121738425636*x_112 + 1.94542828436503e-5*x_113 - 0.000115766176548635*x_114 - 8.07431073455642e-5*x_115 + 0.000279164121668699*x_116 - 4.60789414429235e-5*x_117 - 0.000203873063510971*x_118 - 8.94168285151822e-5*x_119 + 6.27086870985337e-5*x_12 + 1.57407687557252e-5*x_120 - 8.48232948406697e-5*x_13 + 3.74512010965062e-5*x_14 + 2.72257196542067e-5*x_15 - 0.0004645728244685*x_16 + 1.60349247970354e-5*x_17 - 0.000580830940405367*x_18 - 0.000435367518510729*x_19 - 2.58651727879286e-5*x_2 + 2.17901833423274e-5*x_20 - 2.64509438071732e-5*x_21 + 0.000375095529972994*x_22 + 0.000144767591771543*x_23 + 0.000191566925578279*x_24 - 0.00028052084406229*x_25 - 0.000254172686768784*x_26 - 0.00039283348952441*x_27 + 4.37434824638099e-5*x_28 - 8.88913425565609e-5*x_29 + 0.000115580900166383*x_3 + 0.000208198315647195*x_30 - 3.12909566710103e-5*x_31 - 0.000202980710721279*x_32 - 2.46151168541535e-5*x_33 - 4.12254614066051e-5*x_34 + 0.000146281340458435*x_35 + 0.000109280948747041*x_36 - 0.000614022703271305*x_37 + 5.06569931326178e-5*x_38 - 3.2228701833971e-5*x_39 + 0.000169671605733514*x_4 - 0.000101835009637744*x_40 - 0.000104301857703456*x_41 - 0.000164906433222391*x_42 - 0.000265895673434141*x_43 + 0.000188687573184656*x_44 + 0.000204554475592545*x_45 + 0.000300407681503227*x_46 + 0.000281706548157629*x_47 - 5.0549408445393e-5*x_48 - 0.000598017138808434*x_49 + 0.000123787972607275*x_5 - 0.000209797186733057*x_50 - 0.000767160688463254*x_51 - 0.000207458498193545*x_52 - 5.66708595752466e-6*x_53 + 0.000141344518464637*x_54 - 0.000365522261252169*x_55 - 4.28669460880175e-5*x_56 - 0.00015796772001217*x_57 + 0.000209141464857855*x_58 + 0.000596328428472565*x_59 + 8.0776278637748e-5*x_6 - 0.000164371619502461*x_60 - 9.23101211053341e-5*x_61 + 4.46417596125545e-5*x_62 - 1.87940367038703e-5*x_63 - 2.84991111003037e-5*x_64 - 1.80409279112818e-5*x_65 + 1.13708785488484e-5*x_66 - 3.4249131966785e-5*x_67 - 2.73210975515325e-5*x_68 + 1.6864556476814e-6*x_69 - 2.84683218358078e-5*x_7 - 3.84895671138796e-6*x_70 + 5.58232215765746e-5*x_71 - 0.00010501444808792*x_72 - 0.00013882082723146*x_73 + 1.1589510721852e-6*x_74 + 3.22997906344771e-5*x_75 - 8.09374953629726e-5*x_76 - 8.02952228025374e-5*x_77 - 9.01273298285409e-5*x_78 + 3.21001435444307e-5*x_79 + 1.57929611260222e-6*x_8 + 1.22819342234467e-5*x_80 - 6.55554096121395e-5*x_81 - 3.23355505522194e-5*x_82 - 9.34167674479271e-6*x_83 - 2.68157483682587e-5*x_84 + 1.66339208763932e-5*x_85 - 8.88806144235143e-5*x_86 - 0.000185965448956184*x_87 - 0.000229346487398615*x_88 + 2.45874795619246e-5*x_89 + 0.000404326454720221*x_9 - 4.01367513925368e-5*x_90 + 0.000110746546573915*x_91 - 0.000181935972008515*x_92 - 0.000163378989805344*x_93 - 1.25264663983645e-5*x_94 - 7.49704510090212e-5*x_95 - 0.000121256210817959*x_96 - 0.000113967893530746*x_97 + 8.03289255297155e-5*x_98 - 0.000261154949356844*x_99 + 1.34145320260261e-7*std::pow(0.403359860181808 - 9.50400066375732*x_23, 2) + 1.54724280296794e-7*std::pow(1.22511982917786 - 9.68591976165771*x_15, 2) - 1.35014639878024e-7*std::pow(1.38495981693268 - 7.2836799621582*x_13, 2) - 7.8964606392428e-7*std::pow(1.60127985477448 - 5.82575988769531*x_20, 2) + 2.42248481546742e-7*std::pow(2.69591999053955 - 5.20391988754272*x_26, 2) + 9.72601069835308e-8*std::pow(2.83799982070923 - 9.29992008209229*x_49, 2) - 1.74308912742554e-7*std::pow(3.67743992805481 - 8.79703998565674*x_10, 2) - 3.02266190090512e-7*std::pow(4.87504005432129 - 9.94591999053955*x_15, 2) - 5.28708786185737e-8*std::pow(5.7087197303772 - 8.35791969299316*x_27, 2) - 7.04613395302311e-7*std::pow(-6.95183992385864*x_10 - 0.208399996161461, 2) - 9.38434463799393e-8*std::pow(-8.32151985168457*x_20 - 1.02223980426788, 2) - 1.4255736843565e-7*std::pow(-5.75559949874878*x_31 - 2.25679969787598, 2) - 8.87753294531244e-6*std::exp(0.497119843959808*x_13) + 1.21859406194534e-5*std::exp(0.530159890651703*x_15) + 1.08966798905743e-5*std::exp(0.703039824962616*x_18) - 1.72245925532434e-6*std::exp(0.755279839038849*x_22) + 3.20272566339181e-5*std::exp(0.45295986533165*x_25) - 1.01695958519964e-5*std::exp(0.489279866218567*x_27) - 3.39842576771984e-5*std::exp(0.522239863872528*x_5) - 4.4379422115619e-5*std::exp(0.521119892597198*x_9) - 3.62356496575161e-5*std::sin(1.43783986568451*x_100 - 1.98039984703064) - 0.000156032458664058*std::sin(0.660719871520996*x_11 + 4.57911968231201) - 8.93411153392656e-5*std::sin(0.58927983045578*x_12 - 8.00520038604736) + 0.00097055199801179*std::sin(0.533199846744537*x_14 - 7.96367979049683) - 6.02429687910135e-5*std::sin(0.846479892730713*x_2 - 1.80759990215302) - 5.17786314800824e-6*std::sin(0.99999988079071*x_2 + 10.0) - 4.17331209280474e-5*std::sin(0.458079844713211*x_21 - 2.26695990562439) + 0.000313926648330551*std::sin(0.574719846248627*x_21 + 1.40535986423492) - 0.00137231727207837*std::sin(0.306079924106598*x_23 - 4.82760000228882) + 0.000247448393650007*std::sin(0.851919889450073*x_24 + 1.59799981117249) - 0.000439458690101151*std::sin(0.436719864606857*x_27 - 1.59663987159729) - 0.000114415306068691*std::sin(0.896799802780151*x_28 - 8.33256053924561) - 0.00134572837610693*std::sin(0.295039921998978*x_3 - 1.59319984912872) - 8.56292377481981e-5*std::sin(1.09575986862183*x_3 + 4.79311990737915) - 9.76647947138784e-5*std::sin(0.941519796848297*x_31 + 1.78167986869812) + 7.45731543506607e-5*std::sin(1.21727991104126*x_31 + 0.782879829406738) - 0.000337090480965162*std::sin(0.253759980201721*x_32 - 4.57951974868774) + 1.14241540318282e-5*std::sin(0.583759844303131*x_32 + 7.81175994873047) + 0.000407210757647208*std::sin(0.158640027046204*x_37 + 4.62256002426147) + 0.000478992797615041*std::sin(0.322719842195511*x_37 + 1.4469598531723) - 0.000645836125014487*std::sin(0.884639859199524*x_4 - 4.60487985610962) + 0.000173995632687814*std::sin(0.898719847202301*x_4 - 1.56799983978271) + 0.000247666132551579*std::sin(0.673839807510376*x_42 - 1.62783980369568) + 9.478918422267e-5*std::sin(0.624719858169556*x_43 - 1.80271995067596) + 0.000136059384076279*std::sin(0.56199985742569*x_44 - 4.96672010421753) - 8.33927508205849e-5*std::sin(0.579199850559235*x_44 - 7.97103977203369) + 7.77661400125108e-5*std::sin(0.690959870815277*x_48 + 4.54207992553711) - 0.00017079894125605*std::sin(0.271839946508408*x_54 - 4.83368015289307) - 0.000519188115629399*std::sin(0.313279926776886*x_55 + 1.26903986930847) + 0.000128018407651476*std::sin(0.355039834976196*x_57 + 1.41279983520508) + 0.000426194266426739*std::sin(0.425439864397049*x_58 - 2.00775980949402) - 0.00139000761927299*std::sin(0.136800035834312*x_59 - 4.77503967285156) - 0.000247588395901168*std::sin(0.463279843330383*x_59 + 7.72575998306274) + 1.83220405481781e-5*std::sin(1.05207991600037*x_6 + 0.561199843883514) - 8.58583964393527e-5*std::sin(1.05679976940155*x_6 - 2.23479986190796) - 8.18430160302258e-5*std::sin(1.185919880867*x_62 - 0.798639833927155) + 0.000122564464669136*std::sin(1.13583981990814*x_63 + 4.41039991378784) - 0.000109608094999459*std::sin(1.48607981204987*x_63 - 1.9955198764801) - 2.66858038171031e-5*std::sin(1.78023993968964*x_63 - 9.40144062042236) + 5.31291967694819e-5*std::sin(0.832319855690002*x_68 + 7.59000015258789) + 0.000169698813754816*std::sin(1.05863988399506*x_68 - 1.80015993118286) - 0.000119759217907041*std::sin(1.72903990745544*x_69 + 0.192159995436668) - 6.78964390954872e-5*std::sin(2.14935994148254*x_69 + 3.99999976158142) - 0.000137563287572749*std::sin(0.775439858436584*x_7 + 1.18935990333557) + 0.000232088450813264*std::sin(0.92223984003067*x_72 + 1.21383988857269) + 4.68455738157168e-5*std::sin(1.32399988174438*x_72 + 7.41775989532471) - 2.64218734356036e-5*std::sin(1.41735982894897*x_75 - 1.99655985832214) + 3.32614681530387e-5*std::sin(0.934159815311432*x_76 + 7.59712028503418) - 0.000228936429974762*std::sin(1.37239980697632*x_78 + 7.61064004898071) + 0.000307901488295036*std::sin(0.569759845733643*x_8 + 1.42455983161926) - 0.000128007515695402*std::sin(1.16767990589142*x_80 + 4.58631992340088) + 0.000134698237268404*std::sin(1.14367985725403*x_82 - 2.57511973381042) + 9.78900946011039e-5*std::sin(0.845919847488403*x_84 + 1.58383977413177) + 0.00014271547202672*std::sin(1.04711985588074*x_88 + 1.80127990245819) + 9.11064677698369e-5*std::sin(1.20215976238251*x_88 + 1.38447988033295) - 0.000172564289948596*std::sin(1.04359984397888*x_90 - 7.9937596321106) + 0.000145492219697738*std::sin(0.860719919204712*x_91 + 0.970399796962738) - 0.000310806041655629*std::sin(0.28399994969368*x_93 - 7.8187198638916) - 2.45714353962656e-5*std::sin(0.972719848155975*x_93 + 7.41607999801636) + 0.000513514104701262*std::sin(0.36015984416008*x_94 - 7.98040008544922) + 2.42598581065754e-5*std::sin(1.86327993869781*x_99 + 3.96928000450134) + 0.0879330554835764 - 7.24914179643089e-7*std::exp(-3.09487986564636*x_118) + 2.35713277854308e-5*std::exp(-2.20839977264404*x_106));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-6.25909739483053e-6*x_1 + 7.7362603337002e-5*x_10 + 9.07128985725069e-5*x_100 + 0.000230594348545609*x_101 - 9.17391840606761e-5*x_102 - 7.32788055355365e-5*x_103 + 0.000130032765480497*x_104 - 0.00011371719512138*x_105 + 8.65041057792385e-5*x_106 + 1.68435970003833e-5*x_107 - 0.00014979387531558*x_108 + 1.39606965936556e-5*x_109 - 0.000235083324962656*x_11 - 3.78960960001209e-5*x_110 - 0.000114300980991907*x_111 - 0.00104554754470567*x_112 + 7.4990286601761e-6*x_113 - 0.00015055467733661*x_114 - 0.000227742705433236*x_115 + 0.000241120010497452*x_116 - 6.3062798546365e-5*x_117 - 3.04135381859946e-5*x_118 - 0.000131611657825785*x_119 - 0.000165526763655902*x_12 - 5.73551569708543e-5*x_120 - 0.000472738466815495*x_13 - 9.10675293412273e-5*x_14 - 6.1836739218185e-5*x_15 - 0.000268294677855844*x_16 - 8.60416260929937e-5*x_17 + 0.000345961465304487*x_18 - 8.31768102069797e-5*x_19 - 6.5835329235474e-5*x_2 - 0.000110109117983649*x_20 - 6.91822745550002e-5*x_21 + 0.000248611042301456*x_22 - 0.000122012336822117*x_23 - 2.41303972337477e-5*x_24 - 0.000219433448129729*x_25 + 0.000137814157325457*x_26 - 0.000243740129889215*x_27 + 4.59237737934574e-5*x_28 - 0.000177527200865484*x_29 - 0.000215448832150678*x_3 + 0.000676366774976403*x_30 - 4.5328568348618e-5*x_31 + 1.58520365374148e-5*x_32 - 0.000383067786719163*x_33 - 0.000128297942535808*x_34 - 0.000112284177813592*x_35 + 0.000124448481707266*x_36 - 5.59120656246677e-5*x_37 + 0.000229377339197499*x_38 - 8.6995734836673e-5*x_39 + 0.000123294544892453*x_4 - 0.000507996498287268*x_40 - 3.59488102137448e-5*x_41 - 7.72574302405886e-5*x_42 + 6.18787634218204e-5*x_43 - 0.000244536529425422*x_44 + 5.42310648068579e-5*x_45 - 2.93958437360863e-5*x_46 + 0.000377015872066924*x_47 - 0.000293885974431092*x_48 + 0.000122294808533721*x_49 - 0.000146847541724719*x_5 + 0.00028108040769548*x_50 + 0.000506639126745762*x_51 - 3.16900829768461e-5*x_52 + 1.63290708406177e-5*x_53 + 9.54310209303885e-5*x_54 - 0.000133582731311418*x_55 + 7.89210473205101e-5*x_56 - 0.00040161268038917*x_57 - 0.000683704108396747*x_58 - 0.000514309392982021*x_59 - 0.000137988763187828*x_6 - 0.000405443320823031*x_60 + 4.83248491947714e-5*x_61 + 1.79197642811756e-5*x_62 + 5.88668088947265e-5*x_63 + 4.17955060160838e-5*x_64 + 4.80838488313182e-5*x_65 - 1.65329891101181e-5*x_66 - 1.46058481955932e-5*x_67 - 0.000101043065380117*x_68 + 3.0977536312883e-5*x_69 - 8.3433941073099e-5*x_7 + 6.42597827493288e-5*x_70 + 1.18781995852921e-5*x_71 + 9.40511352368166e-5*x_72 - 0.00017733633268989*x_73 - 6.33196495236533e-5*x_74 + 4.78720752374113e-5*x_75 - 5.44935848631237e-5*x_76 + 0.00010818292238087*x_77 + 0.000155922038243465*x_78 - 0.000217108228456242*x_79 - 0.000224771578345124*x_8 + 7.43031574975082e-5*x_80 + 4.26233789587219e-5*x_81 + 9.82615871269045e-5*x_82 - 0.000461438614859146*x_83 - 9.62539355055278e-5*x_84 + 6.66042797011315e-6*x_85 + 9.22762511964035e-5*x_86 - 6.59667301631915e-5*x_87 - 0.000297904926539963*x_88 - 5.3644008295745e-6*x_89 - 7.05682279157219e-5*x_9 - 0.000362816696598551*x_90 - 0.000165014324338465*x_91 + 5.50472033279499e-5*x_92 - 0.000172379239155014*x_93 + 6.15109378668479e-5*x_94 + 9.97297410408099e-5*x_95 + 8.25369922359357e-5*x_96 - 7.01935702756949e-5*x_97 - 8.42875257201501e-5*x_98 + 0.000180540674188377*x_99 + 3.60886093994071e-8*std::pow(0.403359860181808 - 9.50400066375732*x_23, 2) - 3.71783750572678e-7*std::pow(1.22511982917786 - 9.68591976165771*x_15, 2) + 5.24882654719309e-7*std::pow(1.38495981693268 - 7.2836799621582*x_13, 2) - 1.1772786193144e-6*std::pow(1.60127985477448 - 5.82575988769531*x_20, 2) + 5.61550603022311e-7*std::pow(2.69591999053955 - 5.20391988754272*x_26, 2) - 2.33704285365393e-7*std::pow(2.83799982070923 - 9.29992008209229*x_49, 2) + 4.18843255973543e-7*std::pow(3.67743992805481 - 8.79703998565674*x_10, 2) - 3.82787700909783e-9*std::pow(4.87504005432129 - 9.94591999053955*x_15, 2) - 7.46562532993847e-8*std::pow(5.7087197303772 - 8.35791969299316*x_27, 2) - 8.92317270208892e-9*std::pow(-6.95183992385864*x_10 - 0.208399996161461, 2) - 2.17536322902312e-7*std::pow(-8.32151985168457*x_20 - 1.02223980426788, 2) - 1.80533612756659e-9*std::pow(-5.75559949874878*x_31 - 2.25679969787598, 2) - 2.05788038255618e-5*std::exp(0.497119843959808*x_13) - 2.80517152722609e-5*std::exp(0.530159890651703*x_15) - 4.23619118175503e-5*std::exp(0.703039824962616*x_18) - 2.43219628315745e-6*std::exp(0.755279839038849*x_22) + 1.19082339438098e-5*std::exp(0.45295986533165*x_25) + 2.44363100633658e-5*std::exp(0.489279866218567*x_27) - 5.06669276078017e-5*std::exp(0.522239863872528*x_5) - 3.0051503266638e-5*std::exp(0.521119892597198*x_9) - 8.39970215134544e-5*std::sin(1.43783986568451*x_100 - 1.98039984703064) - 4.19768236672842e-5*std::sin(0.660719871520996*x_11 + 4.57911968231201) - 0.000207099573434355*std::sin(0.58927983045578*x_12 - 8.00520038604736) - 0.000369721768709494*std::sin(0.533199846744537*x_14 - 7.96367979049683) - 2.23992761550884e-5*std::sin(0.846479892730713*x_2 - 1.80759990215302) - 1.20026848241358e-5*std::sin(0.99999988079071*x_2 + 10.0) - 5.28505202882718e-7*std::sin(0.458079844713211*x_21 - 2.26695990562439) + 0.000212575271332117*std::sin(0.574719846248627*x_21 + 1.40535986423492) + 0.000522770104129175*std::sin(0.306079924106598*x_23 - 4.82760000228882) + 6.65701077579172e-5*std::sin(0.851919889450073*x_24 + 1.59799981117249) - 5.88306181352425e-5*std::sin(0.436719864606857*x_27 - 1.59663987159729) + 0.000274926155943607*std::sin(0.896799802780151*x_28 - 8.33256053924561) + 0.000512641338574388*std::sin(0.295039921998978*x_3 - 1.59319984912872) + 0.000197116256455297*std::sin(1.09575986862183*x_3 + 4.79311990737915) + 3.72043957626536e-5*std::sin(0.941519796848297*x_31 + 1.78167986869812) - 0.000179190279401147*std::sin(1.21727991104126*x_31 + 0.782879829406738) - 0.00012533550261415*std::sin(0.253759980201721*x_32 - 4.57951974868774) + 1.61314613907652e-5*std::sin(0.583759844303131*x_32 + 7.81175994873047) - 0.00146678286995584*std::sin(0.158640027046204*x_37 + 4.62256002426147) + 0.000152343660516165*std::sin(0.322719842195511*x_37 + 1.4469598531723) + 0.000246024607569703*std::sin(0.884639859199524*x_4 - 4.60487985610962) - 0.000418090481854914*std::sin(0.898719847202301*x_4 - 1.56799983978271) - 0.000595111791589725*std::sin(0.673839807510376*x_42 - 1.62783980369568) + 2.55007766060235e-5*std::sin(0.624719858169556*x_43 - 1.80271995067596) - 0.000326934260191455*std::sin(0.56199985742569*x_44 - 4.96672010421753) + 0.000300382679202454*std::sin(0.579199850559235*x_44 - 7.97103977203369) - 0.000280115492753658*std::sin(0.690959870815277*x_48 + 4.54207992553711) - 4.59493947672798e-5*std::sin(0.271839946508408*x_54 - 4.83368015289307) - 0.000774054473082558*std::sin(0.313279926776886*x_55 + 1.26903986930847) - 0.000461125360408305*std::sin(0.355039834976196*x_57 + 1.41279983520508) + 5.70549011872087e-5*std::sin(0.425439864397049*x_58 - 2.00775980949402) - 0.00322214451799462*std::sin(0.136800035834312*x_59 - 4.77503967285156) + 0.000962524172457931*std::sin(0.463279843330383*x_59 + 7.72575998306274) - 4.21768561586316e-5*std::sin(1.05207991600037*x_6 + 0.561199843883514) - 5.39324411739418e-6*std::sin(1.05679976940155*x_6 - 2.23479986190796) + 3.11772524349046e-5*std::sin(1.185919880867*x_62 - 0.798639833927155) + 1.64077838948655e-5*std::sin(1.13583981990814*x_63 + 4.41039991378784) - 0.000163414056805858*std::sin(1.48607981204987*x_63 - 1.9955198764801) - 7.17918111937251e-6*std::sin(1.78023993968964*x_63 - 9.40144062042236) + 1.97542646755347e-5*std::sin(0.832319855690002*x_68 + 7.59000015258789) + 0.000114911466008086*std::sin(1.05863988399506*x_68 - 1.80015993118286) + 4.56210382901288e-5*std::sin(1.72903990745544*x_69 + 0.192159995436668) - 8.59835557974252e-7*std::sin(2.14935994148254*x_69 + 3.99999976158142) - 4.37520039671102e-5*std::sin(0.775439858436584*x_7 + 1.18935990333557) + 0.000346019290686236*std::sin(0.92223984003067*x_72 + 1.21383988857269) + 3.17214566445444e-5*std::sin(1.32399988174438*x_72 + 7.41775989532471) + 9.51722188564099e-5*std::sin(1.41735982894897*x_75 - 1.99655985832214) - 0.000119808602303003*std::sin(0.934159815311432*x_76 + 7.59712028503418) - 0.000341319961568631*std::sin(1.37239980697632*x_78 + 7.61064004898071) + 0.000208495337257771*std::sin(0.569759845733643*x_8 + 1.42455983161926) - 4.07127906968881e-5*std::sin(1.16767990589142*x_80 + 4.58631992340088) + 9.12108433213961e-5*std::sin(1.14367985725403*x_82 - 2.57511973381042) - 0.000225340426929475*std::sin(0.845919847488403*x_84 + 1.58383977413177) - 5.43659864159985e-5*std::sin(1.04711985588074*x_88 + 1.80127990245819) + 1.21964815709626e-5*std::sin(1.20215976238251*x_88 + 1.38447988033295) + 0.000397238463485557*std::sin(1.04359984397888*x_90 - 7.9937596321106) + 4.62738008499015e-5*std::sin(0.860719919204712*x_91 + 0.970399796962738) - 8.36149767619488e-5*std::sin(0.28399994969368*x_93 - 7.8187198638916) - 5.69584761720555e-5*std::sin(0.972719848155975*x_93 + 7.41607999801636) + 0.000163323162323924*std::sin(0.36015984416008*x_94 - 7.98040008544922) - 8.73845880297509e-5*std::sin(1.86327993869781*x_99 + 3.96928000450134) + 0.0882215848442614 - 1.02361409588412e-6*std::exp(-3.09487986564636*x_118) - 8.97925409201503e-6*std::exp(-2.20839977264404*x_106));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000126426235846608*x_1 - 5.8420213038344e-5*x_10 - 0.000167967787098121*x_100 - 0.000176503882965985*x_101 - 0.000171823087266942*x_102 - 0.000173792333482633*x_103 + 1.12818403741364e-5*x_104 - 0.000295655313367995*x_105 - 5.16434610072398e-5*x_106 - 3.70679202145911e-5*x_107 - 0.000248287571509638*x_108 - 1.31095750208583e-5*x_109 - 9.23664253126592e-5*x_11 - 6.97916846566696e-5*x_110 + 9.4293320230997e-5*x_111 + 0.000335477439161458*x_112 - 0.00010505929282233*x_113 - 0.000243982493300148*x_114 - 5.93005718111942e-5*x_115 - 0.000124072960710393*x_116 - 6.72694019407106e-5*x_117 - 0.000176355876056782*x_118 - 8.44627133774225e-5*x_119 + 2.99255596455374e-5*x_12 - 7.6296624540394e-5*x_120 + 0.000120831992677711*x_13 + 1.89397561079759e-5*x_14 + 0.000214039317949285*x_15 - 0.000280407129766732*x_16 - 0.000104234693103424*x_17 - 0.00133965736762278*x_18 - 0.000311976196353483*x_19 - 1.68954832872715e-5*x_2 - 0.00033782123122774*x_20 - 1.22287877607372e-5*x_21 - 0.000164899747602882*x_22 - 0.000299779784874015*x_23 + 1.07722605812331e-5*x_24 - 3.20755137152689e-5*x_25 - 0.000223699740865985*x_26 + 0.000430831627645697*x_27 - 2.57431168257971e-6*x_28 - 0.000356427070641078*x_29 - 0.000235907599694832*x_3 - 9.69227868322481e-5*x_30 + 3.57540216864523e-5*x_31 - 0.000234904002208178*x_32 - 0.000158230904284945*x_33 - 0.000609999236475662*x_34 - 8.74714436603894e-5*x_35 + 0.000218728187076485*x_36 - 8.10840995240997e-5*x_37 - 0.000110418437662677*x_38 - 0.000167484521527099*x_39 - 0.000431685042872006*x_4 - 0.000592212151636138*x_40 - 2.00255135741993e-5*x_41 + 4.49703313490897e-5*x_42 - 0.000178222548283409*x_43 + 3.36367367216448e-5*x_44 + 2.22465717483067e-5*x_45 + 4.82305461307428e-5*x_46 + 7.14736344114971e-5*x_47 - 0.000116910478389657*x_48 - 0.000430970674247694*x_49 + 0.000146240585958093*x_5 - 0.00012935511044346*x_50 - 0.000269463216078639*x_51 - 0.000317360123670958*x_52 - 8.52783603389382e-5*x_53 - 8.20524027121135e-5*x_54 + 9.39611202940187e-5*x_55 - 0.000431156812976654*x_56 + 8.15178954331218e-5*x_57 - 0.000329828513278085*x_58 - 0.000144967374464237*x_59 - 2.37876983732346e-5*x_6 - 0.000363464231582089*x_60 - 8.99566494104838e-5*x_61 + 6.33325566036985e-7*x_62 + 6.55039079163414e-5*x_63 + 6.78149532040879e-5*x_64 + 5.43877125563685e-6*x_65 + 8.34236447397413e-5*x_66 - 2.9085724339221e-5*x_67 - 0.000100261288253461*x_68 - 6.0332710032267e-5*x_69 - 0.000116362640666135*x_7 + 8.31128716096243e-5*x_70 + 3.00877364860227e-5*x_71 - 4.69342093827282e-5*x_72 - 0.000163670599298585*x_73 - 9.59216442937528e-6*x_74 + 4.21346054579731e-5*x_75 - 0.000128596993807282*x_76 + 1.09104376011232e-6*x_77 - 0.000379437411690492*x_78 - 4.23502672706113e-6*x_79 + 7.49636724829483e-5*x_8 - 0.000159211175608553*x_80 - 1.58135512257039e-5*x_81 - 0.000120085911553801*x_82 - 0.000139924243215524*x_83 - 3.00127510140504e-5*x_84 - 3.74986369460595e-5*x_85 + 0.000100612459458463*x_86 - 0.000236360832278022*x_87 - 0.00034858299850966*x_88 - 8.09184290577807e-5*x_89 - 1.14084016368984e-5*x_9 + 5.56998739080054e-5*x_90 - 4.02800457164945e-5*x_91 - 0.00014476002162166*x_92 - 3.56556756743108e-5*x_93 - 7.89583383910841e-5*x_94 - 5.08363862889553e-5*x_95 + 7.11246369546624e-6*x_96 - 3.13862685739978e-5*x_97 - 3.74206290507732e-5*x_98 - 0.000176863517127653*x_99 + 1.33126275375065e-7*std::pow(0.403359860181808 - 9.50400066375732*x_23, 2) - 1.30428040113691e-7*std::pow(1.22511982917786 - 9.68591976165771*x_15, 2) + 8.69920333706805e-8*std::pow(1.38495981693268 - 7.2836799621582*x_13, 2) - 5.47977701925226e-7*std::pow(1.60127985477448 - 5.82575988769531*x_20, 2) + 1.22460666508916e-6*std::pow(2.69591999053955 - 5.20391988754272*x_26, 2) - 8.19874237629446e-8*std::pow(2.83799982070923 - 9.29992008209229*x_49, 2) + 1.46937312099624e-7*std::pow(3.67743992805481 - 8.79703998565674*x_10, 2) - 4.93325340949222e-7*std::pow(4.87504005432129 - 9.94591999053955*x_15, 2) - 2.17117213979744e-7*std::pow(5.7087197303772 - 8.35791969299316*x_27, 2) - 1.1499918114256e-6*std::pow(-6.95183992385864*x_10 - 0.208399996161461, 2) - 4.74394345747991e-7*std::pow(-8.32151985168457*x_20 - 1.02223980426788, 2) - 2.32666320924883e-7*std::pow(-5.75559949874878*x_31 - 2.25679969787598, 2) - 4.48774165475236e-5*std::exp(0.497119843959808*x_13) + 1.11717582997245e-5*std::exp(0.530159890651703*x_15) - 7.02090041144313e-6*std::exp(0.703039824962616*x_18) - 7.07337506924401e-6*std::exp(0.755279839038849*x_22) - 0.000139659268066444*std::exp(0.45295986533165*x_25) + 8.57267167880763e-6*std::exp(0.489279866218567*x_27) - 2.35834968023999e-5*std::exp(0.522239863872528*x_5) - 2.02702870139109e-5*std::exp(0.521119892597198*x_9) - 0.000183177280621542*std::sin(1.43783986568451*x_100 - 1.98039984703064) - 0.000154847146506931*std::sin(0.660719871520996*x_11 + 4.57911968231201) - 0.000451634307932097*std::sin(0.58927983045578*x_12 - 8.00520038604736) + 0.000151691718897134*std::sin(0.533199846744537*x_14 - 7.96367979049683) + 0.000262697770954018*std::sin(0.846479892730713*x_2 - 1.80759990215302) - 2.61749658098351e-5*std::sin(0.99999988079071*x_2 + 10.0) - 6.81121699537058e-5*std::sin(0.458079844713211*x_21 - 2.26695990562439) + 0.000143385897328659*std::sin(0.574719846248627*x_21 + 1.40535986423492) - 0.00021448533030712*std::sin(0.306079924106598*x_23 - 4.82760000228882) + 0.000245568633555434*std::sin(0.851919889450073*x_24 + 1.59799981117249) - 6.98809005196589e-5*std::sin(0.436719864606857*x_27 - 1.59663987159729) + 9.64487545259353e-5*std::sin(0.896799802780151*x_28 - 8.33256053924561) - 0.00021032963814251*std::sin(0.295039921998978*x_3 - 1.59319984912872) - 7.85026923555968e-5*std::sin(1.09575986862183*x_3 + 4.79311990737915) - 1.52644480833927e-5*std::sin(0.941519796848297*x_31 + 1.78167986869812) - 6.28629866520957e-5*std::sin(1.21727991104126*x_31 + 0.782879829406738) + 0.00146992951603301*std::sin(0.253759980201721*x_32 - 4.57951974868774) + 4.69139261588635e-5*std::sin(0.583759844303131*x_32 + 7.81175994873047) + 0.000599244616255809*std::sin(0.158640027046204*x_37 + 4.62256002426147) - 0.00015374350135028*std::sin(0.322719842195511*x_37 + 1.4469598531723) - 0.000100940487609116*std::sin(0.884639859199524*x_4 - 4.60487985610962) - 0.000146673226181964*std::sin(0.898719847202301*x_4 - 1.56799983978271) - 0.000208775301518785*std::sin(0.673839807510376*x_42 - 1.62783980369568) + 9.40691111469444e-5*std::sin(0.624719858169556*x_43 - 1.80271995067596) - 0.000114694078848546*std::sin(0.56199985742569*x_44 - 4.96672010421753) - 0.000122719392907817*std::sin(0.579199850559235*x_44 - 7.97103977203369) + 0.000114439365498948*std::sin(0.690959870815277*x_48 + 4.54207992553711) - 0.000169501454417552*std::sin(0.271839946508408*x_54 - 4.83368015289307) - 0.000360292444257365*std::sin(0.313279926776886*x_55 + 1.26903986930847) + 0.000188389771454051*std::sin(0.355039834976196*x_57 + 1.41279983520508) + 6.77716468124929e-5*std::sin(0.425439864397049*x_58 - 2.00775980949402) - 0.00702672142346527*std::sin(0.136800035834312*x_59 - 4.77503967285156) + 0.000159525056081962*std::sin(0.463279843330383*x_59 + 7.72575998306274) + 1.67971775798116e-5*std::sin(1.05207991600037*x_6 + 0.561199843883514) + 0.000212142324599603*std::sin(1.05679976940155*x_6 - 2.23479986190796) - 1.27915946871296e-5*std::sin(1.185919880867*x_62 - 0.798639833927155) + 1.94896934699772e-5*std::sin(1.13583981990814*x_63 + 4.41039991378784) - 7.60629283855517e-5*std::sin(1.48607981204987*x_63 - 1.9955198764801) - 2.64830831270753e-5*std::sin(1.78023993968964*x_63 - 9.40144062042236) - 0.000231677187296956*std::sin(0.832319855690002*x_68 + 7.59000015258789) + 7.7509879506063e-5*std::sin(1.05863988399506*x_68 - 1.80015993118286) - 1.87176798927931e-5*std::sin(1.72903990745544*x_69 + 0.192159995436668) - 0.000110813035212405*std::sin(2.14935994148254*x_69 + 3.99999976158142) + 4.41540281899759e-5*std::sin(0.775439858436584*x_7 + 1.18935990333557) + 0.000161058608065491*std::sin(0.92223984003067*x_72 + 1.21383988857269) + 2.13967010228765e-5*std::sin(1.32399988174438*x_72 + 7.41775989532471) - 3.88819919669094e-5*std::sin(1.41735982894897*x_75 - 1.99655985832214) + 4.89470264357323e-5*std::sin(0.934159815311432*x_76 + 7.59712028503418) - 0.000158871251964558*std::sin(1.37239980697632*x_78 + 7.61064004898071) + 0.000140633907388221*std::sin(0.569759845733643*x_8 + 1.42455983161926) + 4.10868884879953e-5*std::sin(1.16767990589142*x_80 + 4.58631992340088) + 6.15233772667241e-5*std::sin(1.14367985725403*x_82 - 2.57511973381042) + 8.97431319396794e-5*std::sin(0.845919847488403*x_84 + 1.58383977413177) + 2.23056109402662e-5*std::sin(1.04711985588074*x_88 + 1.80127990245819) + 1.44873731122624e-5*std::sin(1.20215976238251*x_88 + 1.38447988033295) - 0.000158202521961393*std::sin(1.04359984397888*x_90 - 7.9937596321106) - 4.66989971183903e-5*std::sin(0.860719919204712*x_91 + 0.970399796962738) - 0.000308444980483889*std::sin(0.28399994969368*x_93 - 7.8187198638916) - 0.000124212723088911*std::sin(0.972719848155975*x_93 + 7.41607999801636) - 0.000164823890552477*std::sin(0.36015984416008*x_94 - 7.98040008544922) + 3.57004059654288e-5*std::sin(1.86327993869781*x_99 + 3.96928000450134) + 0.0795420122009058 - 2.97690053902806e-6*std::exp(-3.09487986564636*x_118) + 3.68406353887734e-6*std::exp(-2.20839977264404*x_106));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-4.54566536913959e-5*x_1 + 1.66295704249098e-5*x_10 + 0.000117017867576778*x_100 - 0.000120642456890336*x_101 - 5.49293949516523e-5*x_102 - 0.000221649668758081*x_103 - 5.62412441906334e-5*x_104 - 8.86155207492114e-5*x_105 - 7.73150834540278e-5*x_106 - 3.20935410862258e-5*x_107 + 0.000390429518371588*x_108 + 0.000122507363675056*x_109 - 4.77681847474443e-7*x_11 - 2.73348865131706e-5*x_110 + 0.000153399035302138*x_111 - 0.000764005622353924*x_112 + 9.88513550382938e-5*x_113 - 0.000141702612555761*x_114 - 3.72289869076709e-5*x_115 + 0.000195355485159654*x_116 - 4.0432284155401e-5*x_117 + 6.98130319293494e-5*x_118 + 0.000116234262784772*x_119 - 0.000269937776359871*x_12 + 3.56964394334016e-5*x_120 - 9.86566853612608e-5*x_13 - 2.11404048086814e-5*x_14 + 0.000155914292933926*x_15 + 7.58316650677247e-6*x_16 - 7.77734790577718e-5*x_17 + 0.000477260886809808*x_18 - 8.29402462529853e-5*x_19 - 2.49672582407468e-6*x_2 - 2.05650475491198e-5*x_20 + 5.04399585544594e-5*x_21 + 0.000131569333549348*x_22 - 0.000325843114362998*x_23 - 8.90482917693076e-5*x_24 + 4.29959305676073e-5*x_25 - 0.000231790270223007*x_26 + 0.000208756879020498*x_27 - 0.000122003770208788*x_28 - 1.55751555481601e-5*x_29 - 0.000239871842561501*x_3 + 0.000507281748466948*x_30 - 5.87194698079002e-5*x_31 + 3.59710538640145e-5*x_32 - 0.000176477500250622*x_33 - 0.000801391472793327*x_34 - 0.000211634346518203*x_35 - 0.000352909687732425*x_36 + 0.000955698519469044*x_37 - 4.65781539283638e-5*x_38 - 0.000110749912237892*x_39 + 5.4388463507651e-5*x_4 - 0.000277868423555576*x_40 + 2.66099881473779e-5*x_41 + 0.000201820231596929*x_42 + 0.000283461933504974*x_43 - 0.00017310535786794*x_44 - 0.000423529522009955*x_45 + 2.9699244056191e-5*x_46 + 5.38947002793457e-5*x_47 + 0.000156265442812698*x_48 + 1.16650617753497e-5*x_49 - 5.80223174410781e-5*x_5 + 0.000573046509558201*x_50 + 0.000484789558360212*x_51 + 8.21089512309939e-5*x_52 + 9.39540442897686e-5*x_53 - 6.44192233978009e-6*x_54 + 0.0004478920765089*x_55 - 0.000283027800524314*x_56 - 2.52551376677958e-5*x_57 - 0.000368947515589103*x_58 - 0.000370994443047217*x_59 - 1.82587602622783e-5*x_6 - 0.000174317423817037*x_60 + 9.2747892498765e-5*x_61 + 1.65008658732985e-5*x_62 + 4.43381557626385e-5*x_63 + 0.000102141176047754*x_64 - 2.0147447066792e-5*x_65 + 6.26808678388514e-5*x_66 + 2.52296788444959e-5*x_67 - 8.3928415849858e-5*x_68 - 2.35565441280115e-5*x_69 - 7.90250123835376e-5*x_7 - 4.00534524307735e-5*x_70 - 1.22227586632041e-5*x_71 + 2.21015623148522e-5*x_72 - 9.64006770657006e-5*x_73 - 0.000138160472508059*x_74 - 1.64327689172911e-5*x_75 - 8.56481781585713e-5*x_76 + 0.000222022911488638*x_77 - 3.76970049138136e-5*x_78 - 0.000118708167254336*x_79 - 0.000298968096772774*x_8 + 2.8445305063457e-5*x_80 + 2.36066908639661e-6*x_81 + 9.86403391793124e-5*x_82 + 0.00015974186254519*x_83 - 4.32479654036658e-5*x_84 + 2.59839842794095e-5*x_85 - 6.40831191351756e-5*x_86 - 3.39984764754342e-5*x_87 + 2.19242570456113e-6*x_88 - 4.36512582401074e-6*x_89 + 0.000254188583453751*x_9 - 0.000105206206191819*x_90 - 8.19999962048277e-5*x_91 - 2.71496487681144e-5*x_92 + 8.66744889097171e-5*x_93 - 2.66329895101389e-5*x_94 - 2.82193297452073e-5*x_95 - 0.000116731085488729*x_96 - 5.35472167632728e-6*x_97 - 0.000244812386516479*x_98 + 0.000199491723813676*x_99 + 7.55489169467983e-7*std::pow(0.403359860181808 - 9.50400066375732*x_23, 2) - 4.33142754226205e-7*std::pow(1.22511982917786 - 9.68591976165771*x_15, 2) - 3.76803478545123e-7*std::pow(1.38495981693268 - 7.2836799621582*x_13, 2) + 4.59440331405978e-7*std::pow(1.60127985477448 - 5.82575988769531*x_20, 2) + 3.65325578713907e-7*std::pow(2.69591999053955 - 5.20391988754272*x_26, 2) - 2.7227472336192e-7*std::pow(2.83799982070923 - 9.29992008209229*x_49, 2) + 4.87968936786512e-7*std::pow(3.67743992805481 - 8.79703998565674*x_10, 2) - 1.31951804501557e-7*std::pow(4.87504005432129 - 9.94591999053955*x_15, 2) - 9.92488358591879e-8*std::pow(5.7087197303772 - 8.35791969299316*x_27, 2) - 3.07593148139617e-7*std::pow(-6.95183992385864*x_10 - 0.208399996161461, 2) - 1.41521676991993e-7*std::pow(-8.32151985168457*x_20 - 1.02223980426788, 2) - 6.22322397501503e-8*std::pow(-5.75559949874878*x_31 - 2.25679969787598, 2) - 1.33878645599365e-5*std::exp(0.497119843959808*x_13) - 2.49352325692552e-5*std::exp(0.530159890651703*x_15) + 3.04108272337762e-5*std::exp(0.703039824962616*x_18) - 3.23338821620733e-6*std::exp(0.755279839038849*x_22) - 9.82654892174899e-7*std::exp(0.45295986533165*x_25) + 2.84692664154043e-5*std::exp(0.489279866218567*x_27) + 1.97730848327199e-5*std::exp(0.522239863872528*x_5) - 4.10737634186713e-6*std::exp(0.521119892597198*x_9) - 5.46455837274349e-5*std::sin(1.43783986568451*x_100 - 1.98039984703064) - 0.000878754714495081*std::sin(0.660719871520996*x_11 + 4.57911968231201) - 0.000134731885442038*std::sin(0.58927983045578*x_12 - 8.00520038604736) - 0.000221582149626048*std::sin(0.533199846744537*x_14 - 7.96367979049683) + 1.84836461887079e-6*std::sin(0.846479892730713*x_2 - 1.80759990215302) - 7.80853543010769e-6*std::sin(0.99999988079071*x_2 + 10.0) - 1.82182486644919e-5*std::sin(0.458079844713211*x_21 - 2.26695990562439) + 2.90543415611702e-5*std::sin(0.574719846248627*x_21 + 1.40535986423492) + 0.000313307284657596*std::sin(0.306079924106598*x_23 - 4.82760000228882) + 0.00139359748847095*std::sin(0.851919889450073*x_24 + 1.59799981117249) + 7.35674454673459e-5*std::sin(0.436719864606857*x_27 - 1.59663987159729) + 0.000320299830777457*std::sin(0.896799802780151*x_28 - 8.33256053924561) + 0.000307236899209312*std::sin(0.295039921998978*x_3 - 1.59319984912872) + 0.00017521708209958*std::sin(1.09575986862183*x_3 + 4.79311990737915) + 2.22973887023258e-5*std::sin(0.941519796848297*x_31 + 1.78167986869812) - 0.000208763753205516*std::sin(1.21727991104126*x_31 + 0.782879829406738) + 1.03425533448658e-5*std::sin(0.253759980201721*x_32 - 4.57951974868774) + 2.14453403832157e-5*std::sin(0.583759844303131*x_32 + 7.81175994873047) - 0.00172915316695933*std::sin(0.158640027046204*x_37 + 4.62256002426147) + 7.38991426916148e-5*std::sin(0.322719842195511*x_37 + 1.4469598531723) + 0.000147447799994255*std::sin(0.884639859199524*x_4 - 4.60487985610962) - 0.000487091925205046*std::sin(0.898719847202301*x_4 - 1.56799983978271) - 0.000693328743078767*std::sin(0.673839807510376*x_42 - 1.62783980369568) + 0.000533840479295103*std::sin(0.624719858169556*x_43 - 1.80271995067596) - 0.000380891326455514*std::sin(0.56199985742569*x_44 - 4.96672010421753) + 0.00035411353083111*std::sin(0.579199850559235*x_44 - 7.97103977203369) - 0.000330221058161078*std::sin(0.690959870815277*x_48 + 4.54207992553711) - 0.000961917642935251*std::sin(0.271839946508408*x_54 - 4.83368015289307) + 0.000302079590850325*std::sin(0.313279926776886*x_55 + 1.26903986930847) - 0.00054360900556419*std::sin(0.355039834976196*x_57 + 1.41279983520508) - 7.13469187436659e-5*std::sin(0.425439864397049*x_58 - 2.00775980949402) - 0.00209621680468476*std::sin(0.136800035834312*x_59 - 4.77503967285156) - 0.000690978170272868*std::sin(0.463279843330383*x_59 + 7.72575998306274) - 3.74911019575146e-5*std::sin(1.05207991600037*x_6 + 0.561199843883514) + 2.23624626262226e-5*std::sin(1.05679976940155*x_6 - 2.23479986190796) + 1.86851930252131e-5*std::sin(1.185919880867*x_62 - 0.798639833927155) - 2.05178661245855e-5*std::sin(1.13583981990814*x_63 + 4.41039991378784) + 6.37733559274198e-5*std::sin(1.48607981204987*x_63 - 1.9955198764801) - 0.000150291010698353*std::sin(1.78023993968964*x_63 - 9.40144062042236) - 1.63010106421554e-6*std::sin(0.832319855690002*x_68 + 7.59000015258789) + 1.57058577969662e-5*std::sin(1.05863988399506*x_68 - 1.80015993118286) + 2.73416622661509e-5*std::sin(1.72903990745544*x_69 + 0.192159995436668) - 2.96396287497349e-5*std::sin(2.14935994148254*x_69 + 3.99999976158142) - 2.12233024548238e-5*std::sin(0.775439858436584*x_7 + 1.18935990333557) - 0.00013503618852632*std::sin(0.92223984003067*x_72 + 1.21383988857269) + 4.33562206174261e-6*std::sin(1.32399988174438*x_72 + 7.41775989532471) + 0.000112196117784674*std::sin(1.41735982894897*x_75 - 1.99655985832214) - 0.000141239326109286*std::sin(0.934159815311432*x_76 + 7.59712028503418) + 0.000133202245998395*std::sin(1.37239980697632*x_78 + 7.61064004898071) + 2.84967047419849e-5*std::sin(0.569759845733643*x_8 + 1.42455983161926) - 1.97490352988068e-5*std::sin(1.16767990589142*x_80 + 4.58631992340088) + 1.24665064724386e-5*std::sin(1.14367985725403*x_82 - 2.57511973381042) - 0.000200305610484291*std::sin(0.845919847488403*x_84 + 1.58383977413177) - 3.25826963844883e-5*std::sin(1.04711985588074*x_88 + 1.80127990245819) - 1.52516499283181e-5*std::sin(1.20215976238251*x_88 + 1.38447988033295) + 0.000353106160401564*std::sin(1.04359984397888*x_90 - 7.9937596321106) + 2.24465803191553e-5*std::sin(0.860719919204712*x_91 + 0.970399796962738) - 0.00175041960331138*std::sin(0.28399994969368*x_93 - 7.8187198638916) - 3.70552327042764e-5*std::sin(0.972719848155975*x_93 + 7.41607999801636) + 7.92250995973718e-5*std::sin(0.36015984416008*x_94 - 7.98040008544922) - 0.000103015477089414*std::sin(1.86327993869781*x_99 + 3.96928000450134) + 0.0444216854665855 - 1.36080372233723e-6*std::exp(-3.09487986564636*x_118) - 5.38145868633048e-6*std::exp(-2.20839977264404*x_106));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
