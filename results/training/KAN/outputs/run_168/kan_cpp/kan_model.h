
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00268407695270517*x_10 - 0.00114883581262034*x_100 + 0.00148823009760715*x_101 + 0.00150097733633025*x_102 - 0.000496031940133606*x_103 - 0.0118062848600204*x_104 - 0.00494158469980594*x_105 - 0.00434836191666424*x_106 - 0.00102045686743989*x_107 - 0.00202957358043941*x_108 - 0.000128058588228833*x_109 - 0.00206230091069849*x_11 - 0.00470365489350834*x_110 - 0.000108169073786058*x_111 - 0.000858903362863801*x_112 - 0.00238689503771191*x_113 - 0.00895285910286299*x_114 - 0.00568012676446082*x_115 + 0.00207538375970366*x_116 - 0.00487174604619935*x_117 + 0.00174895438325868*x_118 - 0.0156795455410666*x_119 + 0.00788260773391098*x_12 + 3.98774812379028e-5*x_13 + 0.00123630244649016*x_14 + 0.00548961622975279*x_15 - 6.73262739456853e-5*x_16 - 0.000174517004502338*x_18 - 0.00107642395711528*x_19 - 0.00278117794858488*x_2 + 0.000617363697082493*x_20 + 0.00256743381294917*x_22 - 0.000100463807146741*x_23 + 0.000329688404796868*x_24 + 0.00460481712489025*x_25 + 0.000239203790710393*x_26 - 0.0113991672466497*x_27 + 0.00404109192363815*x_28 - 1.35501122997784e-5*x_29 + 1.83565978651045e-5*x_3 + 0.000228018217279569*x_30 - 0.0001285651888644*x_31 + 0.00289613653559255*x_33 + 0.00848839494000687*x_34 - 0.00553194213814223*x_35 + 0.000610637958467713*x_36 - 0.00401715356707361*x_37 + 0.00524513382946431*x_38 + 0.0134026466056807*x_39 + 0.00201301520823503*x_4 + 0.0034759334063739*x_40 - 0.00207785853469971*x_41 + 0.000633665006607227*x_42 - 0.00502281674221551*x_43 - 0.00114354367634779*x_44 - 0.00985809129182292*x_45 + 0.000235855813813612*x_46 - 9.50619238721444e-5*x_47 - 0.00224746325028826*x_48 + 5.7319601213419e-5*x_49 + 1.21878288068883e-5*x_5 - 0.00299813014491429*x_50 + 0.00230729813833451*x_51 - 0.0033484662762888*x_52 + 0.00324581966789279*x_53 + 0.00210713397000943*x_54 + 0.00565175242820959*x_55 + 0.000745713645358493*x_56 + 0.00323448065485748*x_57 + 0.0144600240015292*x_58 - 0.0114311136530597*x_59 + 0.00116354636283656*x_61 - 0.00483116590289756*x_62 + 0.00533854469343808*x_63 + 0.000648330566048015*x_64 - 0.000712456241184676*x_65 + 0.00102116792653308*x_66 + 0.00501755038519741*x_67 - 0.000841074480464609*x_68 - 0.000706408640942789*x_69 - 1.29009010542585e-5*x_7 - 0.00107533181225386*x_70 - 0.00144067884904835*x_71 + 0.000852325641875373*x_72 - 0.00343071837796661*x_73 + 0.00246873439427574*x_74 + 0.00146181923517864*x_75 + 0.00158481035837826*x_76 + 0.00533541581840586*x_77 + 0.000962353610382111*x_78 + 0.000981631955173751*x_79 - 5.33649397264598e-5*x_8 - 0.00247083358792187*x_80 - 0.00161935056032509*x_81 + 0.00131762674892166*x_82 - 0.0030953054664101*x_83 + 0.00581016036038959*x_84 - 0.00188312244349078*x_85 + 0.000695907084568047*x_86 - 0.00058200339993449*x_87 + 0.00118702858728499*x_88 + 0.00537144682781032*x_89 - 0.00011883416070406*x_9 - 0.000982881576238547*x_90 + 0.000384655241027875*x_92 + 0.00416236862158743*x_93 - 0.000188041993796264*x_94 + 0.000375098689810403*x_95 - 0.000502891227585824*x_96 - 0.000211732079077817*x_97 + 0.00229149766624904*x_98 + 0.00284205633183115*x_99 - 7.68173070742288e-5*std::pow(-2.69463992118835*x_24 - 5.59167957305908, 2) - 0.00383236804979427*std::sin(0.323279827833176*x_1 - 4.26496028900146) - 0.00840652637221688*std::sin(0.332239836454391*x_1 - 4.25663995742798) - 0.0694558572756078*std::sin(0.333679854869843*x_1 - 4.25056028366089) + 0.00727022993946561*std::sin(0.335119843482971*x_1 - 4.24823999404907) + 0.0255656535442495*std::sin(0.357359826564789*x_1 - 4.24368000030518) - 0.00179886840130289*std::sin(0.353119850158691*x_10 - 1.14991986751556) + 0.000553830149986703*std::sin(0.224559992551804*x_101 + 1.99807977676392) + 0.0262177011723141*std::sin(0.239759981632233*x_101 + 1.97511982917786) + 0.00195775783235534*std::sin(0.23471999168396*x_102 + 1.95839977264404) + 0.0129547333905576*std::sin(0.215680003166199*x_103 + 1.97719979286194) - 0.00312818590720655*std::sin(0.254959970712662*x_108 - 7.43815994262695) - 0.00239102589789147*std::sin(0.257999956607819*x_108 - 7.44407987594604) + 0.0267803895460707*std::sin(0.21399998664856*x_109 + 1.98639988899231) - 0.0306426165275186*std::sin(0.25639995932579*x_11 - 7.42575979232788) - 0.00349400659208581*std::sin(0.257519960403442*x_11 - 7.41519975662231) - 0.00409108122044414*std::sin(0.273439943790436*x_11 - 7.41864013671875) + 0.00132671587545468*std::sin(0.216319993138313*x_110 - 7.4157600402832) - 0.0035922237549209*std::sin(0.217040002346039*x_110 - 7.41983985900879) - 0.0620934491515115*std::sin(0.222240000963211*x_110 + 1.98479974269867) + 0.00184659894145638*std::sin(0.272479951381683*x_112 + 5.14752006530762) + 0.0755554826440261*std::sin(0.274239957332611*x_112 + 1.97527980804443) + 0.0150227853844495*std::sin(0.277439951896667*x_112 - 7.43711996078491) + 0.0137215437675913*std::sin(0.28399994969368*x_113 - 7.42224025726318) - 0.00171629953196707*std::sin(0.234959989786148*x_116 - 1.19575989246368) - 0.0481341792273688*std::sin(0.252959966659546*x_116 + 5.15848016738892) + 0.000326678654203673*std::sin(0.271839946508408*x_116 + 8.16720008850098) - 0.0254652807123816*std::sin(0.229839995503426*x_118 + 5.17456007003784) - 0.00208209135164559*std::sin(0.232959985733032*x_118 + 5.16416025161743) + 0.00142617476631789*std::sin(0.270559966564178*x_12 + 5.16064023971558) - 0.0224950191946928*std::sin(0.290239930152893*x_12 - 7.44551992416382) - 0.00409564734492094*std::sin(0.294479936361313*x_12 - 7.4488000869751) - 0.00279044738863059*std::sin(0.258399993181229*x_120 - 4.23375988006592) + 0.0166061524138264*std::sin(0.259839981794357*x_120 - 4.24735975265503) - 0.00305480250716692*std::sin(0.26463994383812*x_120 + 5.15520000457764) - 0.0109474799484108*std::sin(0.269039958715439*x_120 + 5.15112018585205) - 0.0396370866111197*std::sin(0.270479947328568*x_120 - 7.42575979232788) - 0.00305006636500948*std::sin(0.228479996323586*x_13 - 1.19263982772827) - 0.00539675213521397*std::sin(0.239439979195595*x_13 + 1.98615980148315) + 0.00269307564268427*std::sin(0.29911994934082*x_13 + 5.14871978759766) - 0.0187356952837388*std::sin(0.345359832048416*x_13 - 1.13367986679077) + 0.00618644103006357*std::sin(0.284159928560257*x_14 - 7.43120002746582) - 0.0317533268118711*std::sin(0.287439942359924*x_14 - 7.43151998519897) + 0.00156068948958279*std::sin(0.302079945802689*x_14 - 7.43623971939087) - 0.0012451752625094*std::sin(0.28399994969368*x_15 + 1.96103990077972) + 0.00244372329062554*std::sin(0.284719944000244*x_15 - 7.41767978668213) - 0.0114025932869731*std::sin(0.287759929895401*x_15 - 1.19479990005493) + 0.00457098822449093*std::sin(0.291919946670532*x_15 - 7.41943979263306) + 0.0681549397199471*std::sin(0.273439943790436*x_16 - 4.2149600982666) - 0.000846083058630047*std::sin(0.356159836053848*x_16 - 1.16255986690521) + 0.000811439592071238*std::sin(0.36695984005928*x_16 - 1.16287982463837) - 0.00100358003539435*std::sin(0.397759824991226*x_16 + 8.19583988189697) + 0.0561267279066155*std::sin(0.262479960918427*x_17 + 2.02111983299255) - 0.0275365284976753*std::sin(0.354879856109619*x_17 + 2.00903987884521) + 0.00129236947042437*std::sin(0.359759837388992*x_17 + 2.01855993270874) - 0.00299864326338772*std::sin(0.380319833755493*x_17 + 1.99399983882904) - 0.00120993240404938*std::sin(0.414399862289429*x_17 + 2.00135970115662) + 0.00258230033642585*std::sin(0.239199981093407*x_18 - 1.15639984607697) - 0.0642769911738403*std::sin(0.269679963588715*x_18 - 1.15063989162445) + 0.00419742866683201*std::sin(0.33943983912468*x_18 - 1.15423989295959) + 0.147000618507074*std::sin(0.253679990768433*x_19 - 4.39103984832764) - 0.00363890989979018*std::sin(0.319279909133911*x_19 + 1.98567974567413) + 0.00227852247748548*std::sin(0.346559852361679*x_19 - 1.14703977108002) - 0.000454835850767859*std::sin(0.350719839334488*x_2 - 7.40903997421265) + 0.000926193291323029*std::sin(0.394639849662781*x_2 + 5.18232011795044) + 0.000850454245103372*std::sin(0.400079846382141*x_2 - 4.20695972442627) - 0.0013108650140842*std::sin(0.294239938259125*x_20 - 1.18247985839844) + 0.00274319057849698*std::sin(0.317519932985306*x_20 + 1.96199977397919) - 0.00139022199159036*std::sin(0.346479833126068*x_20 + 8.24399948120117) + 0.00459947325504751*std::sin(0.333359837532043*x_21 - 1.14887976646423) - 0.00242495449537524*std::sin(0.340559840202332*x_21 - 1.15839993953705) - 0.0423744737767636*std::sin(0.347039848566055*x_21 + 8.22983932495117) + 0.00154391589713292*std::sin(0.353439837694168*x_21 - 4.35775947570801) + 0.00423184220700064*std::sin(0.42647984623909*x_21 + 8.16991996765137) + 0.00605442126944454*std::sin(0.162560015916824*x_22 - 4.43807983398438) + 0.00314741387962538*std::sin(0.244959965348244*x_22 - 1.18119990825653) + 0.00131991827654374*std::sin(0.285759925842285*x_22 + 8.23952007293701) - 0.0383206016580427*std::sin(0.300879925489426*x_22 - 1.15463984012604) - 0.0642159950605628*std::sin(0.298559933900833*x_23 - 1.15375983715057) - 0.00801266558149352*std::sin(0.329759836196899*x_23 + 1.98991978168488) - 0.00259667461445323*std::sin(0.341119825839996*x_23 - 1.17207992076874) + 0.00115306264224027*std::sin(0.38647985458374*x_23 - 1.19239985942841) + 0.00902657964880519*std::sin(0.231039986014366*x_24 - 4.39135980606079) + 0.00259963821547637*std::sin(0.330239832401276*x_24 - 1.1568797826767) + 0.00970692733458642*std::sin(0.278879970312119*x_25 - 1.15535986423492) + 0.00109118295964955*std::sin(0.305199921131134*x_25 + 2.0020797252655) + 0.00215511318496974*std::sin(0.345759838819504*x_25 - 1.16223990917206) - 0.0127120383418038*std::sin(0.271199941635132*x_26 - 1.17207992076874) + 0.00294916142752282*std::sin(0.274639964103699*x_26 - 1.16543984413147) + 0.00237498429429686*std::sin(0.343679845333099*x_26 + 8.24544048309326) - 0.000904491127715276*std::sin(0.38487982749939*x_26 - 1.1729599237442) + 0.00215119463118214*std::sin(0.154640033841133*x_27 + 4.97559976577759) - 0.00906273297822126*std::sin(0.42103984951973*x_27 - 1.207279920578) + 0.00539223504780703*std::sin(0.0844800844788551*x_28 + 8.05719947814941) - 0.00146807473771227*std::sin(0.270879954099655*x_28 + 2.000159740448) + 0.0242807838437164*std::sin(0.308159917593002*x_28 + 1.98215973377228) - 0.00106486542991371*std::sin(0.371119856834412*x_28 - 1.17263984680176) - 0.022873995348776*std::sin(0.25383996963501*x_29 + 1.80247986316681) + 0.0168210010323161*std::sin(0.31535992026329*x_29 + 1.98511981964111) - 0.00593305093675611*std::sin(0.328559845685959*x_29 - 1.16903984546661) - 0.00248748909224157*std::sin(0.355519831180573*x_29 - 1.14223992824554) - 0.000541870563902168*std::sin(0.288959950208664*x_3 - 1.13039994239807) + 0.0187446326357098*std::sin(0.346479833126068*x_3 - 7.40783977508545) - 0.181645599306233*std::sin(0.348239839076996*x_3 - 7.40471982955933) + 0.00307615675774919*std::sin(0.373999834060669*x_3 - 7.40743970870972) - 0.0101264432386582*std::sin(0.199120000004768*x_30 + 8.18671989440918) + 0.0280183390052087*std::sin(0.258879989385605*x_30 - 1.16759991645813) - 0.00490628259829264*std::sin(0.268719971179962*x_30 - 1.17455983161926) + 0.0262128767954059*std::sin(0.329279839992523*x_30 - 1.15023982524872) - 0.00566720430819019*std::sin(0.375839829444885*x_31 - 7.39943981170654) - 0.0007109361979733*std::sin(0.376319825649261*x_31 + 5.16775989532471) - 0.0226295929452235*std::sin(0.380639851093292*x_31 - 7.40391969680786) - 0.00127479353979541*std::sin(0.295279920101166*x_32 - 1.14495992660522) - 0.00175157786805076*std::sin(0.299279928207397*x_32 + 2.02359986305237) + 0.0528924738510134*std::sin(0.302399933338165*x_32 - 1.13367986679077) - 0.0033666684669208*std::sin(0.303839921951294*x_32 - 1.13895988464355) + 0.034271176051077*std::sin(0.305679947137833*x_32 - 1.14007985591888) - 0.00318258668017743*std::sin(0.243359968066216*x_33 + 1.98735988140106) - 0.0020684214009683*std::sin(0.241119980812073*x_35 - 7.43616008758545) - 0.038486569343315*std::sin(0.222559988498688*x_36 + 5.17360019683838) + 0.000404221924047946*std::sin(0.190160006284714*x_37 - 1.17119991779327) - 0.00182139563136489*std::sin(0.197759985923767*x_37 - 1.19143986701965) - 0.00418690224038109*std::sin(0.235199987888336*x_38 + 1.97775971889496) - 0.0211212504759699*std::sin(0.265519946813583*x_4 + 2.03111982345581) - 0.00283014408751457*std::sin(0.312879920005798*x_4 + 2.01127982139587) - 0.00226274724564515*std::sin(0.328959852457047*x_4 + 1.99927973747253) + 0.0685787895234837*std::sin(0.231519982218742*x_40 + 1.96791982650757) + 0.0260111722568804*std::sin(0.251359969377518*x_42 - 7.43455982208252) - 0.00206919042308735*std::sin(0.135360047221184*x_44 - 1.19167983531952) + 0.0017024613342852*std::sin(0.157520025968552*x_45 - 4.39479970932007) + 0.00500598201833715*std::sin(0.174560010433197*x_45 - 4.58383989334106) - 0.073872850732279*std::sin(0.140800043940544*x_46 - 1.20887982845306) - 0.00824733503547623*std::sin(0.235679984092712*x_46 - 1.21863985061646) - 0.0029200694353621*std::sin(0.201440006494522*x_47 + 1.98727989196777) - 0.050241345681629*std::sin(0.202799990773201*x_47 - 1.19279980659485) - 0.00538768316164398*std::sin(0.23039998114109*x_47 - 1.21311986446381) + 0.00444588232089267*std::sin(0.215759992599487*x_48 - 7.39559984207153) + 0.0407425379099852*std::sin(0.280879944562912*x_49 + 8.27223968505859) + 0.0090418377959431*std::sin(0.317999929189682*x_5 + 2.01639986038208) + 0.002807138490955*std::sin(0.340559840202332*x_5 + 2.0162398815155) + 0.0138156863841266*std::sin(0.346319854259491*x_5 - 7.37375974655151) - 0.00215730600500478*std::sin(0.366399854421616*x_5 - 1.16279983520508) + 0.00436815941681935*std::sin(0.187520012259483*x_51 - 1.1943199634552) - 0.00235958774128313*std::sin(0.205520004034042*x_51 - 7.40855979919434) - 0.000976495589518068*std::sin(0.213919997215271*x_51 - 1.18455994129181) + 0.0126800310888134*std::sin(0.23879998922348*x_52 - 7.41024017333984) + 0.000763077668664112*std::sin(0.227519989013672*x_53 - 1.20567989349365) + 0.0971967413264039*std::sin(0.23047998547554*x_53 + 1.99655985832214) - 0.00172593660152858*std::sin(0.257439970970154*x_53 - 7.42767953872681) + 0.00323968468020241*std::sin(0.236959978938103*x_57 + 5.15824031829834) - 0.00591988792017474*std::sin(0.326719850301743*x_6 - 1.13911986351013) - 0.0141165938118492*std::sin(0.357119828462601*x_6 + 2.00927972793579) + 0.00129788740711877*std::sin(0.3572798371315*x_6 + 1.99695980548859) + 0.00375195312398628*std::sin(0.358879864215851*x_6 + 2.01999974250793) + 0.0709016125257865*std::sin(0.385199844837189*x_6 + 1.99791979789734) + 0.00905237616989891*std::sin(0.164240017533302*x_60 + 1.97215986251831) - 0.00157137616857129*std::sin(0.329279839992523*x_60 - 4.29544019699097) - 0.000488870572125577*std::sin(0.369679838418961*x_60 + 5.03895950317383) - 0.017954406655096*std::sin(0.399279862642288*x_60 - 4.38207960128784) + 0.00572261308148199*std::sin(0.455599844455719*x_60 - 1.2824798822403) + 0.00272095235190004*std::sin(0.178480014204979*x_61 - 4.41824007034302) - 0.0124978335782689*std::sin(0.326879858970642*x_7 + 2.02199983596802) + 0.0800369941798787*std::sin(0.332559853792191*x_7 + 2.04583978652954) + 0.00318934564447916*std::sin(0.348159849643707*x_7 + 2.00615978240967) + 0.0046725995944876*std::sin(0.355439841747284*x_7 + 2.00423979759216) + 0.0238484966585491*std::sin(0.307679921388626*x_8 + 5.17511987686157) - 0.00421551564490446*std::sin(0.311919927597046*x_8 - 4.23727989196777) + 0.00306586005488325*std::sin(0.315839916467667*x_8 - 7.43063974380493) - 0.00120696247479163*std::sin(0.317199915647507*x_8 - 4.23792028427124) - 0.0170517721427231*std::sin(0.262799948453903*x_9 + 1.97775971889496) + 0.00264356866620602*std::sin(0.316639930009842*x_9 - 7.43160009384155) - 0.00766229737338732*std::sin(0.326159834861755*x_9 + 8.27543926239014) - 0.00154562165278855*std::sin(0.345359832048416*x_91 - 7.39999961853027) + 0.00247819990929651*std::sin(0.351599842309952*x_91 - 7.40375995635986) - 0.0100104310166829*std::sin(0.362559854984283*x_91 + 2.00079965591431) + 0.0266808850170158*std::sin(0.366399854421616*x_91 - 7.41015958786011) + 0.000686826880417407*std::sin(0.375439822673798*x_91 - 1.18063986301422) - 0.00112857461743315*std::sin(0.28399994969368*x_92 - 1.16303980350494) + 0.0434218381972626*std::sin(0.289679944515228*x_92 + 1.99175977706909) - 0.00417405922893385*std::sin(0.298319935798645*x_92 + 1.99519979953766) + 0.0171216611337095*std::sin(0.282799929380417*x_94 - 7.43056011199951) - 0.0303043099265054*std::sin(0.288399934768677*x_94 + 1.98655986785889) + 0.00181918992637638*std::sin(0.293759942054749*x_94 + 1.98631989955902) - 0.0367200369806721*std::sin(0.259359985589981*x_95 - 7.42392015457153) + 0.00140065959279793*std::sin(0.27703994512558*x_95 - 7.43056011199951) + 0.0013689364560324*std::sin(0.27143993973732*x_97 + 1.98071980476379) + 0.0348943670819738*std::sin(0.276159942150116*x_97 - 1.20687985420227) + 0.00459163884019782*std::sin(0.280559957027435*x_97 + 1.96655988693237) - 0.882292055617283);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000553735107901948*x_10 + 0.00561985535913633*x_100 + 0.000862579219676562*x_101 + 0.00923510190236389*x_102 + 0.00144983119691626*x_103 + 0.00462171501859503*x_104 + 0.000770827059504748*x_105 - 0.00669341187352144*x_106 - 0.00189643759183589*x_107 + 0.00235047136261353*x_108 + 0.00677113569984911*x_109 - 0.00748217274998363*x_11 + 0.000910117134626019*x_110 + 0.0016643789978937*x_111 - 0.00259265605199367*x_112 + 0.0184412789755656*x_113 + 0.00257407121395062*x_114 - 0.00943630743987066*x_115 - 0.000335513321470103*x_116 + 0.00102235619274706*x_117 - 0.00900003400168023*x_118 + 0.0177418331948033*x_119 + 0.0039885827300724*x_12 + 1.38402899786829e-6*x_13 - 0.00405921044875852*x_14 + 0.00019052828346452*x_15 + 1.24244349380597e-5*x_16 + 0.00297713372382454*x_18 - 0.00153698618185546*x_19 - 0.000217852713843237*x_2 - 5.53290013254372e-5*x_20 - 0.000473795926869436*x_22 + 1.85396571408577e-5*x_23 + 0.00921849486070317*x_24 + 0.00746080833572626*x_25 + 8.3020535015268e-6*x_26 - 0.00250613694851482*x_27 + 0.000140254304729018*x_28 + 0.000224368980601907*x_29 + 0.000675647765521909*x_3 + 0.00122541834014008*x_30 - 0.000784534912153708*x_31 - 0.000538554798722092*x_33 - 7.76730716409357e-5*x_34 + 0.0042072210652222*x_35 + 0.023229465228237*x_36 - 0.00176292197913319*x_37 + 0.00279160374945931*x_38 - 0.00177004013664906*x_39 - 0.000387354630698168*x_4 - 0.00578074546112421*x_40 + 0.00577956389569531*x_41 - 0.00215550437115837*x_42 - 0.00539984619949699*x_43 + 0.00342452882715898*x_44 + 0.00516347689622692*x_45 + 0.00867705299901108*x_46 - 0.00576779936864309*x_47 + 0.00474968389093151*x_48 - 0.00116830561174974*x_49 + 6.54999812060489e-5*x_5 - 0.00462196513667211*x_50 + 0.000822742859297159*x_51 - 0.0192621165303402*x_52 - 0.00311749311465729*x_53 + 0.00736037663213143*x_54 + 0.00904723358688522*x_55 + 0.000977068118820458*x_56 - 0.00226414647183618*x_57 - 0.0143158655272724*x_58 + 0.00492202515457944*x_59 - 0.000422454507599941*x_61 - 0.000517708048173747*x_62 - 0.000551637500762117*x_63 - 0.00448344900108563*x_64 - 0.00716260817223056*x_65 - 0.000431702246351134*x_66 - 0.00279378921069719*x_67 + 0.000885767410128446*x_68 - 0.00292795194616163*x_69 - 6.93321829493905e-5*x_7 + 0.00228968030100921*x_70 - 0.000691365547826385*x_71 - 0.00172458831990389*x_72 - 0.00169342929063243*x_73 - 0.00217789260186471*x_74 + 0.000996072872484004*x_75 - 5.33863391968413e-5*x_76 + 0.00393713649882136*x_77 + 0.00192911539307975*x_78 - 0.00164658211497198*x_79 - 0.00196419306825561*x_8 - 0.00288130307597567*x_80 + 0.00727304785015225*x_81 + 0.000476740138589414*x_82 + 0.00233812975459097*x_83 - 0.00276293877402834*x_84 - 0.00288887987351308*x_85 - 0.00260924350477452*x_86 - 0.001952382024938*x_87 + 0.00310337093753171*x_88 + 0.00169148475034485*x_89 - 4.40264103515389e-5*x_9 - 2.80020855262658e-5*x_90 - 0.00313338932233947*x_92 - 0.00393807363354201*x_93 - 0.00313982627972264*x_94 - 0.00022405673925799*x_95 + 0.00918128663391214*x_96 - 0.0063066894948451*x_97 + 0.00366466159608783*x_98 + 0.0130656310305248*x_99 - 2.66610069714816e-6*std::pow(-2.69463992118835*x_24 - 5.59167957305908, 2) - 0.141057233400712*std::sin(0.323279827833176*x_1 - 4.26496028900146) + 0.139199123284623*std::sin(0.332239836454391*x_1 - 4.25663995742798) + 0.0128174296484033*std::sin(0.333679854869843*x_1 - 4.25056028366089) + 0.0390717601915702*std::sin(0.335119843482971*x_1 - 4.24823999404907) + 0.000887307943137191*std::sin(0.357359826564789*x_1 - 4.24368000030518) - 0.00966750094248961*std::sin(0.353119850158691*x_10 - 1.14991986751556) + 0.0203847197649035*std::sin(0.224559992551804*x_101 + 1.99807977676392) - 0.00483823184250023*std::sin(0.239759981632233*x_101 + 1.97511982917786) + 0.010521406499638*std::sin(0.23471999168396*x_102 + 1.95839977264404) + 0.000449620339991342*std::sin(0.215680003166199*x_103 + 1.97719979286194) + 0.0517979384676141*std::sin(0.254959970712662*x_108 - 7.43815994262695) - 0.088006030152592*std::sin(0.257999956607819*x_108 - 7.44407987594604) + 0.000929467823828881*std::sin(0.21399998664856*x_109 + 1.98639988899231) + 0.00565480863659865*std::sin(0.25639995932579*x_11 - 7.42575979232788) + 0.0578553653238323*std::sin(0.257519960403442*x_11 - 7.41519975662231) - 0.0219863395931572*std::sin(0.273439943790436*x_11 - 7.41864013671875) + 0.048832175946798*std::sin(0.216319993138313*x_110 - 7.4157600402832) - 0.0193053735955218*std::sin(0.217040002346039*x_110 - 7.41983985900879) - 0.00215507929627382*std::sin(0.222240000963211*x_110 + 1.98479974269867) + 0.0679674119234201*std::sin(0.272479951381683*x_112 + 5.14752006530762) + 0.00262230651688887*std::sin(0.274239957332611*x_112 + 1.97527980804443) - 0.00277231470953085*std::sin(0.277439951896667*x_112 - 7.43711996078491) - 0.00253218272449937*std::sin(0.28399994969368*x_113 - 7.42224025726318) + 0.0284192756396032*std::sin(0.234959989786148*x_116 - 1.19575989246368) - 0.00167059447515826*std::sin(0.252959966659546*x_116 + 5.15848016738892) + 0.0120239983671484*std::sin(0.271839946508408*x_116 + 8.16720008850098) + 0.0046993796752462*std::sin(0.229839995503426*x_118 + 5.17456007003784) + 0.034476224532575*std::sin(0.232959985733032*x_118 + 5.16416025161743) + 0.0524929402053405*std::sin(0.270559966564178*x_12 + 5.16064023971558) + 0.00415124565842361*std::sin(0.290239930152893*x_12 - 7.44551992416382) + 0.0678176091352278*std::sin(0.294479936361313*x_12 - 7.4488000869751) - 0.102707460107231*std::sin(0.258399993181229*x_120 - 4.23375988006592) - 0.00306451030400907*std::sin(0.259839981794357*x_120 - 4.24735975265503) + 0.050582822437892*std::sin(0.26463994383812*x_120 + 5.15520000457764) - 0.0588340829393039*std::sin(0.269039958715439*x_120 + 5.15112018585205) - 0.00137568561398166*std::sin(0.270479947328568*x_120 - 7.42575979232788) + 0.0505043992215864*std::sin(0.228479996323586*x_13 - 1.19263982772827) - 0.0290032924675177*std::sin(0.239439979195595*x_13 + 1.98615980148315) + 0.0991235169900449*std::sin(0.29911994934082*x_13 + 5.14871978759766) + 0.00345749754783576*std::sin(0.345359832048416*x_13 - 1.13367986679077) + 0.0332472483509513*std::sin(0.284159928560257*x_14 - 7.43120002746582) + 0.00585977984403699*std::sin(0.287439942359924*x_14 - 7.43151998519897) + 0.0574439977417972*std::sin(0.302079945802689*x_14 - 7.43623971939087) - 0.0458309262958211*std::sin(0.28399994969368*x_15 + 1.96103990077972) + 0.0131330881115012*std::sin(0.284719944000244*x_15 - 7.41767978668213) + 0.00210424207544063*std::sin(0.287759929895401*x_15 - 1.19479990005493) - 0.075688521658165*std::sin(0.291919946670532*x_15 - 7.41943979263306) + 0.00236545564043083*std::sin(0.273439943790436*x_16 - 4.2149600982666) - 0.0311416163392693*std::sin(0.356159836053848*x_16 - 1.16255986690521) - 0.0134361893145363*std::sin(0.36695984005928*x_16 - 1.16287982463837) - 0.00539345231202659*std::sin(0.397759824991226*x_16 + 8.19583988189697) + 0.00194799211401508*std::sin(0.262479960918427*x_17 + 2.02111983299255) + 0.00508160910576159*std::sin(0.354879856109619*x_17 + 2.00903987884521) + 0.0475679944256375*std::sin(0.359759837388992*x_17 + 2.01855993270874) - 0.016115345933029*std::sin(0.380319833755493*x_17 + 1.99399983882904) + 0.02003461625172*std::sin(0.414399862289429*x_17 + 2.00135970115662) + 0.0138778305951157*std::sin(0.239199981093407*x_18 - 1.15639984607697) - 0.00223086355804646*std::sin(0.269679963588715*x_18 - 1.15063989162445) - 0.0695029509933816*std::sin(0.33943983912468*x_18 - 1.15423989295959) + 0.00510195509853277*std::sin(0.253679990768433*x_19 - 4.39103984832764) + 0.0602547408209641*std::sin(0.319279909133911*x_19 + 1.98567974567413) + 0.0838651384051414*std::sin(0.346559852361679*x_19 - 1.14703977108002) - 0.0167410556416202*std::sin(0.350719839334488*x_2 - 7.40903997421265) - 0.0153363337525897*std::sin(0.394639849662781*x_2 + 5.18232011795044) + 0.00457052178476549*std::sin(0.400079846382141*x_2 - 4.20695972442627) + 0.0217059047489655*std::sin(0.294239938259125*x_20 - 1.18247985839844) + 0.0147424889357333*std::sin(0.317519932985306*x_20 + 1.96199977397919) - 0.0511696333438255*std::sin(0.346479833126068*x_20 + 8.24399948120117) + 0.0247185463905653*std::sin(0.333359837532043*x_21 - 1.14887976646423) - 0.0892548335117798*std::sin(0.340559840202332*x_21 - 1.15839993953705) - 0.00147069219659507*std::sin(0.347039848566055*x_21 + 8.22983932495117) - 0.0255648682690589*std::sin(0.353439837694168*x_21 - 4.35775947570801) - 0.000780946948162189*std::sin(0.42647984623909*x_21 + 8.16991996765137) + 0.222843918698289*std::sin(0.162560015916824*x_22 - 4.43807983398438) - 0.0521163240628924*std::sin(0.244959965348244*x_22 - 1.18119990825653) + 0.00709352122326112*std::sin(0.285759925842285*x_22 + 8.23952007293701) - 0.00132999432923261*std::sin(0.300879925489426*x_22 - 1.15463984012604) - 0.00222874656402094*std::sin(0.298559933900833*x_23 - 1.15375983715057) + 0.132677395482034*std::sin(0.329759836196899*x_23 + 1.98991978168488) - 0.0139550810189247*std::sin(0.341119825839996*x_23 - 1.17207992076874) + 0.0424405548054966*std::sin(0.38647985458374*x_23 - 1.19239985942841) - 0.0016657709537033*std::sin(0.231039986014366*x_24 - 4.39135980606079) - 0.0430460031205594*std::sin(0.330239832401276*x_24 - 1.1568797826767) - 0.00179132276374506*std::sin(0.278879970312119*x_25 - 1.15535986423492) + 0.0401629612350071*std::sin(0.305199921131134*x_25 + 2.0020797252655) + 0.0115820360910096*std::sin(0.345759838819504*x_25 - 1.16223990917206) + 0.00234588792831871*std::sin(0.271199941635132*x_26 - 1.17207992076874) + 0.015849420035107*std::sin(0.274639964103699*x_26 - 1.16543984413147) - 0.0393260803503185*std::sin(0.343679845333099*x_26 + 8.24544048309326) - 0.0332914308994555*std::sin(0.38487982749939*x_26 - 1.1729599237442) + 0.0115609769504924*std::sin(0.154640033841133*x_27 + 4.97559976577759) + 0.00167244271292596*std::sin(0.42103984951973*x_27 - 1.207279920578) + 0.198470957853552*std::sin(0.0844800844788551*x_28 + 8.05719947814941) + 0.0243090555310968*std::sin(0.270879954099655*x_28 + 2.000159740448) - 0.00448079184293962*std::sin(0.308159917593002*x_28 + 1.98215973377228) - 0.00572281304172067*std::sin(0.371119856834412*x_28 - 1.17263984680176) - 0.000793888477332408*std::sin(0.25383996963501*x_29 + 1.80247986316681) - 0.00310415860957414*std::sin(0.31535992026329*x_29 + 1.98511981964111) - 0.0318854761590037*std::sin(0.328559845685959*x_29 - 1.16903984546661) - 0.0915565323859959*std::sin(0.355519831180573*x_29 - 1.14223992824554) - 0.00291212752608106*std::sin(0.288959950208664*x_3 - 1.13039994239807) - 0.00345914685265502*std::sin(0.346479833126068*x_3 - 7.40783977508545) - 0.00630437953879686*std::sin(0.348239839076996*x_3 - 7.40471982955933) - 0.0509364159232198*std::sin(0.373999834060669*x_3 - 7.40743970870972) + 0.167678296409246*std::sin(0.199120000004768*x_30 + 8.18671989440918) - 0.00517052273416396*std::sin(0.258879989385605*x_30 - 1.16759991645813) - 0.180584599549192*std::sin(0.268719971179962*x_30 - 1.17455983161926) + 0.00090977114090916*std::sin(0.329279839992523*x_30 - 1.15023982524872) - 0.0304567599002951*std::sin(0.375839829444885*x_31 - 7.39943981170654) - 0.0261672918434643*std::sin(0.376319825649261*x_31 + 5.16775989532471) + 0.00417607998698289*std::sin(0.380639851093292*x_31 - 7.40391969680786) - 0.0469210805288638*std::sin(0.295279920101166*x_32 - 1.14495992660522) + 0.0290034305255047*std::sin(0.299279928207397*x_32 + 2.02359986305237) + 0.00183574075659555*std::sin(0.302399933338165*x_32 - 1.13367986679077) - 0.0180931915605574*std::sin(0.303839921951294*x_32 - 1.13895988464355) - 0.00632442540100921*std::sin(0.305679947137833*x_32 - 1.14007985591888) - 0.01710389693203*std::sin(0.243359968066216*x_33 + 1.98735988140106) - 0.0111161360268731*std::sin(0.241119980812073*x_35 - 7.43616008758545) - 0.00133575457491502*std::sin(0.222559988498688*x_36 + 5.17360019683838) + 0.0148781185797583*std::sin(0.190160006284714*x_37 - 1.17119991779327) - 0.00978856706255615*std::sin(0.197759985923767*x_37 - 1.19143986701965) + 0.069328649591303*std::sin(0.235199987888336*x_38 + 1.97775971889496) + 0.0038977294742444*std::sin(0.265519946813583*x_4 + 2.03111982345581) + 0.0468628251798725*std::sin(0.312879920005798*x_4 + 2.01127982139587) - 0.083284502482198*std::sin(0.328959852457047*x_4 + 1.99927973747253) + 0.00238016620891774*std::sin(0.231519982218742*x_40 + 1.96791982650757) + 0.000902770575134822*std::sin(0.251359969377518*x_42 - 7.43455982208252) - 0.0761602937576988*std::sin(0.135360047221184*x_44 - 1.19167983531952) + 0.00914938888349675*std::sin(0.157520025968552*x_45 - 4.39479970932007) - 0.000923807218829651*std::sin(0.174560010433197*x_45 - 4.58383989334106) - 0.00256390735810792*std::sin(0.140800043940544*x_46 - 1.20887982845306) + 0.0015219686395139*std::sin(0.235679984092712*x_46 - 1.21863985061646) - 0.107478433839952*std::sin(0.201440006494522*x_47 + 1.98727989196777) - 0.00174372796768335*std::sin(0.202799990773201*x_47 - 1.19279980659485) + 0.000994246599221096*std::sin(0.23039998114109*x_47 - 1.21311986446381) - 0.0736169606676276*std::sin(0.215759992599487*x_48 - 7.39559984207153) + 0.00141405254704429*std::sin(0.280879944562912*x_49 + 8.27223968505859) + 0.000313815349293231*std::sin(0.317999929189682*x_5 + 2.01639986038208) + 0.103321806298855*std::sin(0.340559840202332*x_5 + 2.0162398815155) - 0.00254955586496137*std::sin(0.346319854259491*x_5 - 7.37375974655151) + 0.0357216632955291*std::sin(0.366399854421616*x_5 - 1.16279983520508) + 0.0234754166833216*std::sin(0.187520012259483*x_51 - 1.1943199634552) - 0.086848891971506*std::sin(0.205520004034042*x_51 - 7.40855979919434) + 0.0161692623009485*std::sin(0.213919997215271*x_51 - 1.18455994129181) - 0.00233998128877044*std::sin(0.23879998922348*x_52 - 7.41024017333984) + 0.00410094150059003*std::sin(0.227519989013672*x_53 - 1.20567989349365) + 0.00337341036389691*std::sin(0.23047998547554*x_53 + 1.99655985832214) - 0.0635262163950349*std::sin(0.257439970970154*x_53 - 7.42767953872681) - 0.0536441863423164*std::sin(0.236959978938103*x_57 + 5.15824031829834) + 0.0980242221275808*std::sin(0.326719850301743*x_6 - 1.13911986351013) + 0.00260508551986451*std::sin(0.357119828462601*x_6 + 2.00927972793579) + 0.0477710920598102*std::sin(0.3572798371315*x_6 + 1.99695980548859) + 0.0201637931579892*std::sin(0.358879864215851*x_6 + 2.01999974250793) + 0.0024607845000511*std::sin(0.385199844837189*x_6 + 1.99791979789734) + 0.0486493926353274*std::sin(0.164240017533302*x_60 + 1.97215986251831) + 0.0260195680511249*std::sin(0.329279839992523*x_60 - 4.29544019699097) - 0.0179937650818165*std::sin(0.369679838418961*x_60 + 5.03895950317383) - 0.000623144157524004*std::sin(0.399279862642288*x_60 - 4.38207960128784) - 0.00105605478722796*std::sin(0.455599844455719*x_60 - 1.2824798822403) + 0.0146229759816843*std::sin(0.178480014204979*x_61 - 4.41824007034302) + 0.00230635844017105*std::sin(0.326879858970642*x_7 + 2.02199983596802) + 0.00277784647897669*std::sin(0.332559853792191*x_7 + 2.04583978652954) - 0.0528106494770984*std::sin(0.348159849643707*x_7 + 2.00615978240967) + 0.171983474192437*std::sin(0.355439841747284*x_7 + 2.00423979759216) + 0.00082771052499736*std::sin(0.307679921388626*x_8 + 5.17511987686157) + 0.000777934033639549*std::sin(0.311919927597046*x_8 - 4.23727989196777) + 0.0164765832501465*std::sin(0.315839916467667*x_8 - 7.43063974380493) + 0.0199854387995132*std::sin(0.317199915647507*x_8 - 4.23792028427124) - 0.000591816393060953*std::sin(0.262799948453903*x_9 + 1.97775971889496) + 0.0973013232327332*std::sin(0.316639930009842*x_9 - 7.43160009384155) + 0.0014140054040198*std::sin(0.326159834861755*x_9 + 8.27543926239014) - 0.00830649911591263*std::sin(0.345359832048416*x_91 - 7.39999961853027) + 0.0912146272167224*std::sin(0.351599842309952*x_91 - 7.40375995635986) + 0.00184733153314037*std::sin(0.362559854984283*x_91 + 2.00079965591431) + 0.000926014317003573*std::sin(0.366399854421616*x_91 - 7.41015958786011) - 0.0113727948226496*std::sin(0.375439822673798*x_91 - 1.18063986301422) + 0.0186874566678538*std::sin(0.28399994969368*x_92 - 1.16303980350494) + 0.00150704310653992*std::sin(0.289679944515228*x_92 + 1.99175977706909) - 0.0224322810387345*std::sin(0.298319935798645*x_92 + 1.99519979953766) - 0.00315964262271359*std::sin(0.282799929380417*x_94 - 7.43056011199951) - 0.0010517726395118*std::sin(0.288399934768677*x_94 + 1.98655986785889) + 0.00977671313536515*std::sin(0.293759942054749*x_94 + 1.98631989955902) - 0.00127444348054112*std::sin(0.259359985589981*x_95 - 7.42392015457153) - 0.0231927646098912*std::sin(0.27703994512558*x_95 - 7.43056011199951) - 0.0226674783465668*std::sin(0.27143993973732*x_97 + 1.98071980476379) + 0.00121107989783991*std::sin(0.276159942150116*x_97 - 1.20687985420227) - 0.000847344055830699*std::sin(0.280559957027435*x_97 + 1.96655988693237) - 1.0949358676607);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00669477779065965*x_10 + 0.00564065394048422*x_100 + 0.00115799239541531*x_101 - 0.0113897959926545*x_102 + 0.0101228944134506*x_103 + 0.0157255679562218*x_104 + 0.00613340852303782*x_105 - 0.0115039669440708*x_106 - 0.00974877888864398*x_107 + 0.00138145644358732*x_108 - 0.00541259498349407*x_109 - 0.00455005573932021*x_11 + 0.0168904282453327*x_110 + 0.010895201915765*x_111 - 0.00837945352557635*x_112 + 0.0111327698324624*x_113 - 0.0131416798291073*x_114 - 0.0217926725402636*x_115 - 0.00736982202679706*x_116 - 0.0103436292128246*x_117 - 0.0128633058296897*x_118 + 3.26708429843354e-5*x_119 + 0.00407905089278164*x_12 - 1.15417349633806e-5*x_13 + 0.00398199804823189*x_14 - 0.00158885901535468*x_15 + 0.000242530984222668*x_16 + 0.00292565449274356*x_18 - 1.11652267362544e-5*x_19 - 0.00102831759254517*x_2 - 0.00133848577036425*x_20 - 0.00924872584042689*x_22 + 0.000361903081785161*x_23 + 0.00680333542481761*x_24 - 0.00905682487777213*x_25 - 6.92327265642643e-5*x_26 + 0.00537296810473034*x_27 - 0.0011696127864003*x_28 - 0.000233946032401391*x_29 + 0.000463508195418966*x_3 + 0.00201851392982042*x_30 + 0.00086248563826708*x_31 - 0.00369878610883308*x_33 - 0.0132816946748473*x_34 + 0.00317392642261189*x_35 + 0.0110600917998756*x_36 + 0.0045214508548282*x_37 + 0.000536928376971819*x_38 - 0.00491795887409262*x_39 - 0.00136544125569223*x_4 - 0.00848597931401144*x_40 + 0.00918970654546778*x_41 + 0.000218436396333776*x_42 + 0.000125860151990194*x_43 + 0.00853796392863503*x_44 + 0.0009246863985004*x_45 + 0.00557499349103786*x_46 + 0.00117489284616064*x_47 + 0.00549411710876999*x_48 + 0.0128886513001278*x_49 + 0.000107891827742901*x_5 + 0.00367739622124835*x_50 + 0.0105540477114723*x_51 - 0.00730161454506856*x_52 - 0.00848280527101553*x_53 + 0.00874182342264338*x_54 - 0.00287223616787914*x_55 + 0.00494908981765216*x_56 - 0.00137330481495546*x_57 - 0.00711796474225387*x_58 + 0.00836998901805337*x_59 - 0.00345316326341723*x_61 + 0.00199904689091894*x_62 - 0.00522445374970376*x_63 - 0.00246991206406082*x_64 - 0.0110051787364465*x_65 - 0.000438649565348971*x_66 + 0.00157714877025425*x_67 + 0.00038246012482967*x_68 + 0.00132042957403156*x_69 - 0.000114204245590289*x_7 - 0.00517915499031979*x_70 + 0.000308890994753242*x_71 - 0.00107048294854939*x_72 + 0.000513081843715781*x_73 + 0.000758375802529807*x_74 + 0.00726880119331392*x_75 - 0.00167841807488787*x_76 - 0.00010705506308981*x_77 - 0.00121907895246209*x_78 - 0.00536118603495891*x_79 - 0.00134747664534691*x_8 - 0.000213310254794018*x_80 + 0.00180289231412172*x_81 - 0.00415679727577366*x_82 - 0.003919509916128*x_83 - 0.00697729918228329*x_84 - 0.000997030110823104*x_85 - 0.000349645832671536*x_86 + 0.00158832931791606*x_87 + 0.000585075733169048*x_88 - 0.0064337396884872*x_89 - 0.00128004924252776*x_9 + 0.00343856656326843*x_90 - 0.00377426976148641*x_92 + 0.00048793388433456*x_93 - 0.00418229641263018*x_94 - 0.0026348132897077*x_95 - 0.000790754199491438*x_96 - 0.00457080688577693*x_97 + 0.00293747742838703*x_98 + 0.011575078419772*x_99 + 2.22332246503238e-5*std::pow(-2.69463992118835*x_24 - 5.59167957305908, 2) - 0.0967681490870494*std::sin(0.323279827833176*x_1 - 4.26496028900146) - 0.145140752161143*std::sin(0.332239836454391*x_1 - 4.25663995742798) + 0.250202431203485*std::sin(0.333679854869843*x_1 - 4.25056028366089) + 0.0643591577063158*std::sin(0.335119843482971*x_1 - 4.24823999404907) - 0.00739946426437982*std::sin(0.357359826564789*x_1 - 4.24368000030518) - 0.0159243457354625*std::sin(0.353119850158691*x_10 - 1.14991986751556) + 0.0139843349663906*std::sin(0.224559992551804*x_101 + 1.99807977676392) - 0.0944446275833838*std::sin(0.239759981632233*x_101 + 1.97511982917786) + 0.0173309023418032*std::sin(0.23471999168396*x_102 + 1.95839977264404) - 0.00374948704566014*std::sin(0.215680003166199*x_103 + 1.97719979286194) - 0.0540089015806079*std::sin(0.254959970712662*x_108 - 7.43815994262695) - 0.0603739378764988*std::sin(0.257999956607819*x_108 - 7.44407987594604) - 0.0077510451704018*std::sin(0.21399998664856*x_109 + 1.98639988899231) + 0.110384601880276*std::sin(0.25639995932579*x_11 - 7.42575979232788) - 0.0603248859728008*std::sin(0.257519960403442*x_11 - 7.41519975662231) - 0.0362159854156229*std::sin(0.273439943790436*x_11 - 7.41864013671875) + 0.0334998721323349*std::sin(0.216319993138313*x_110 - 7.4157600402832) - 0.0317998876355102*std::sin(0.217040002346039*x_110 - 7.41983985900879) + 0.0179717000879111*std::sin(0.222240000963211*x_110 + 1.98479974269867) + 0.0466270356471716*std::sin(0.272479951381683*x_112 + 5.14752006530762) - 0.021868014945708*std::sin(0.274239957332611*x_112 + 1.97527980804443) - 0.0541169251100363*std::sin(0.277439951896667*x_112 - 7.43711996078491) - 0.049429432522778*std::sin(0.28399994969368*x_113 - 7.42224025726318) - 0.0296323349233516*std::sin(0.234959989786148*x_116 - 1.19575989246368) + 0.0139314701449626*std::sin(0.252959966659546*x_116 + 5.15848016738892) + 0.00824870897126772*std::sin(0.271839946508408*x_116 + 8.16720008850098) + 0.0917341660651372*std::sin(0.229839995503426*x_118 + 5.17456007003784) - 0.0359478209507312*std::sin(0.232959985733032*x_118 + 5.16416025161743) + 0.0360112313374092*std::sin(0.270559966564178*x_12 + 5.16064023971558) + 0.0810343247243714*std::sin(0.290239930152893*x_12 - 7.44551992416382) - 0.0707123620278196*std::sin(0.294479936361313*x_12 - 7.4488000869751) - 0.070459419714938*std::sin(0.258399993181229*x_120 - 4.23375988006592) - 0.0598207245558562*std::sin(0.259839981794357*x_120 - 4.24735975265503) - 0.052741919071269*std::sin(0.26463994383812*x_120 + 5.15520000457764) - 0.0969117337901268*std::sin(0.269039958715439*x_120 + 5.15112018585205) + 0.0114721575732641*std::sin(0.270479947328568*x_120 - 7.42575979232788) - 0.0526601484082583*std::sin(0.228479996323586*x_13 - 1.19263982772827) - 0.0477743379045949*std::sin(0.239439979195595*x_13 + 1.98615980148315) + 0.0680007613851082*std::sin(0.29911994934082*x_13 + 5.14871978759766) + 0.0674920257866488*std::sin(0.345359832048416*x_13 - 1.13367986679077) + 0.0547649987978166*std::sin(0.284159928560257*x_14 - 7.43120002746582) + 0.114385739068821*std::sin(0.287439942359924*x_14 - 7.43151998519897) + 0.0394077581391604*std::sin(0.302079945802689*x_14 - 7.43623971939087) - 0.0314409534461293*std::sin(0.28399994969368*x_15 + 1.96103990077972) + 0.0216328746080247*std::sin(0.284719944000244*x_15 - 7.41767978668213) + 0.0410758239021423*std::sin(0.287759929895401*x_15 - 1.19479990005493) + 0.0789192396059046*std::sin(0.291919946670532*x_15 - 7.41943979263306) - 0.0197260766295624*std::sin(0.273439943790436*x_16 - 4.2149600982666) - 0.0213637861744345*std::sin(0.356159836053848*x_16 - 1.16255986690521) + 0.0140097047831532*std::sin(0.36695984005928*x_16 - 1.16287982463837) - 0.00888411595047884*std::sin(0.397759824991226*x_16 + 8.19583988189697) - 0.0162447526210409*std::sin(0.262479960918427*x_17 + 2.02111983299255) + 0.0991954695726144*std::sin(0.354879856109619*x_17 + 2.00903987884521) + 0.032632617735212*std::sin(0.359759837388992*x_17 + 2.01855993270874) - 0.0265452614704422*std::sin(0.380319833755493*x_17 + 1.99399983882904) - 0.0208897815116895*std::sin(0.414399862289429*x_17 + 2.00135970115662) + 0.0228596173684872*std::sin(0.239199981093407*x_18 - 1.15639984607697) + 0.018603682412792*std::sin(0.269679963588715*x_18 - 1.15063989162445) + 0.0724696416655723*std::sin(0.33943983912468*x_18 - 1.15423989295959) - 0.0425463726793514*std::sin(0.253679990768433*x_19 - 4.39103984832764) - 0.0628266773358015*std::sin(0.319279909133911*x_19 + 1.98567974567413) + 0.0575332013874149*std::sin(0.346559852361679*x_19 - 1.14703977108002) - 0.0114847068040873*std::sin(0.350719839334488*x_2 - 7.40903997421265) + 0.0159909557166807*std::sin(0.394639849662781*x_2 + 5.18232011795044) + 0.0075285815357082*std::sin(0.400079846382141*x_2 - 4.20695972442627) - 0.0226324079294757*std::sin(0.294239938259125*x_20 - 1.18247985839844) + 0.0242838860022279*std::sin(0.317519932985306*x_20 + 1.96199977397919) - 0.0351034157467033*std::sin(0.346479833126068*x_20 + 8.24399948120117) + 0.0407164872435029*std::sin(0.333359837532043*x_21 - 1.14887976646423) - 0.0612306425397684*std::sin(0.340559840202332*x_21 - 1.15839993953705) + 0.0122644392364297*std::sin(0.347039848566055*x_21 + 8.22983932495117) + 0.0266560889315719*std::sin(0.353439837694168*x_21 - 4.35775947570801) - 0.0152444624570623*std::sin(0.42647984623909*x_21 + 8.16991996765137) + 0.152875489103627*std::sin(0.162560015916824*x_22 - 4.43807983398438) + 0.0543408772689999*std::sin(0.244959965348244*x_22 - 1.18119990825653) + 0.0116844761756973*std::sin(0.285759925842285*x_22 + 8.23952007293701) + 0.0110911274795868*std::sin(0.300879925489426*x_22 - 1.15463984012604) + 0.0185860283145042*std::sin(0.298559933900833*x_23 - 1.15375983715057) - 0.138340648422541*std::sin(0.329759836196899*x_23 + 1.98991978168488) - 0.0229868645716955*std::sin(0.341119825839996*x_23 - 1.17207992076874) + 0.0291150892140966*std::sin(0.38647985458374*x_23 - 1.19239985942841) - 0.0325166553573893*std::sin(0.231039986014366*x_24 - 4.39135980606079) + 0.0448833952615782*std::sin(0.330239832401276*x_24 - 1.1568797826767) - 0.0349674874646176*std::sin(0.278879970312119*x_25 - 1.15535986423492) + 0.0275526134099475*std::sin(0.305199921131134*x_25 + 2.0020797252655) + 0.0190779755937985*std::sin(0.345759838819504*x_25 - 1.16223990917206) + 0.0457928679225763*std::sin(0.271199941635132*x_26 - 1.17207992076874) + 0.0261072272810778*std::sin(0.274639964103699*x_26 - 1.16543984413147) + 0.0410046898781387*std::sin(0.343679845333099*x_26 + 8.24544048309326) - 0.0228386029623026*std::sin(0.38487982749939*x_26 - 1.1729599237442) + 0.019043286894363*std::sin(0.154640033841133*x_27 + 4.97559976577759) + 0.0326468913269794*std::sin(0.42103984951973*x_27 - 1.207279920578) + 0.136155139130391*std::sin(0.0844800844788551*x_28 + 8.05719947814941) - 0.0253466726000575*std::sin(0.270879954099655*x_28 + 2.000159740448) - 0.0874672257678352*std::sin(0.308159917593002*x_28 + 1.98215973377228) - 0.00942664024528196*std::sin(0.371119856834412*x_28 - 1.17263984680176) + 0.00662041793196908*std::sin(0.25383996963501*x_29 + 1.80247986316681) - 0.0605946786728359*std::sin(0.31535992026329*x_29 + 1.98511981964111) - 0.0525218822647525*std::sin(0.328559845685959*x_29 - 1.16903984546661) - 0.0628096550756297*std::sin(0.355519831180573*x_29 - 1.14223992824554) - 0.00479686796276946*std::sin(0.288959950208664*x_3 - 1.13039994239807) - 0.0675242210150914*std::sin(0.346479833126068*x_3 - 7.40783977508545) + 0.0525736656221977*std::sin(0.348239839076996*x_3 - 7.40471982955933) + 0.0531106054768207*std::sin(0.373999834060669*x_3 - 7.40743970870972) - 0.174835541256785*std::sin(0.199120000004768*x_30 + 8.18671989440918) - 0.100931106638987*std::sin(0.258879989385605*x_30 - 1.16759991645813) - 0.123884731259114*std::sin(0.268719971179962*x_30 - 1.17455983161926) - 0.00758679001804061*std::sin(0.329279839992523*x_30 - 1.15023982524872) - 0.0501684952005156*std::sin(0.375839829444885*x_31 - 7.39943981170654) - 0.0179512977623727*std::sin(0.376319825649261*x_31 + 5.16775989532471) + 0.0815191028392731*std::sin(0.380639851093292*x_31 - 7.40391969680786) - 0.0321888215618415*std::sin(0.295279920101166*x_32 - 1.14495992660522) - 0.0302414241009104*std::sin(0.299279928207397*x_32 + 2.02359986305237) - 0.015308662829128*std::sin(0.302399933338165*x_32 - 1.13367986679077) - 0.0298031765998536*std::sin(0.303839921951294*x_32 - 1.13895988464355) - 0.123455845259482*std::sin(0.305679947137833*x_32 - 1.14007985591888) - 0.0281736065804014*std::sin(0.243359968066216*x_33 + 1.98735988140106) - 0.0183105431680229*std::sin(0.241119980812073*x_35 - 7.43616008758545) + 0.0111391634882923*std::sin(0.222559988498688*x_36 + 5.17360019683838) + 0.0102066938515014*std::sin(0.190160006284714*x_37 - 1.17119991779327) - 0.0161237663266018*std::sin(0.197759985923767*x_37 - 1.19143986701965) - 0.0722879003154584*std::sin(0.235199987888336*x_38 + 1.97775971889496) + 0.0760855660909296*std::sin(0.265519946813583*x_4 + 2.03111982345581) - 0.0488631360205859*std::sin(0.312879920005798*x_4 + 2.01127982139587) - 0.0571348732605823*std::sin(0.328959852457047*x_4 + 1.99927973747253) - 0.0198487514311005*std::sin(0.231519982218742*x_40 + 1.96791982650757) - 0.00752841069586921*std::sin(0.251359969377518*x_42 - 7.43455982208252) - 0.0522475202666301*std::sin(0.135360047221184*x_44 - 1.19167983531952) + 0.0150709095055417*std::sin(0.157520025968552*x_45 - 4.39479970932007) - 0.018033164094121*std::sin(0.174560010433197*x_45 - 4.58383989334106) + 0.0213810109784701*std::sin(0.140800043940544*x_46 - 1.20887982845306) + 0.0297095645747722*std::sin(0.235679984092712*x_46 - 1.21863985061646) - 0.0737324053416074*std::sin(0.201440006494522*x_47 + 1.98727989196777) + 0.0145413470976644*std::sin(0.202799990773201*x_47 - 1.19279980659485) + 0.0194081748965873*std::sin(0.23039998114109*x_47 - 1.21311986446381) + 0.0767592553098865*std::sin(0.215759992599487*x_48 - 7.39559984207153) - 0.0117921082198537*std::sin(0.280879944562912*x_49 + 8.27223968505859) - 0.0026169781085236*std::sin(0.317999929189682*x_5 + 2.01639986038208) + 0.0708808737760223*std::sin(0.340559840202332*x_5 + 2.0162398815155) - 0.0497685646343223*std::sin(0.346319854259491*x_5 - 7.37375974655151) - 0.0372464205005013*std::sin(0.366399854421616*x_5 - 1.16279983520508) + 0.0386687990798362*std::sin(0.187520012259483*x_51 - 1.1943199634552) - 0.0595801174014895*std::sin(0.205520004034042*x_51 - 7.40855979919434) - 0.0168594373073162*std::sin(0.213919997215271*x_51 - 1.18455994129181) - 0.0456775674593978*std::sin(0.23879998922348*x_52 - 7.41024017333984) + 0.00675508703694883*std::sin(0.227519989013672*x_53 - 1.20567989349365) - 0.0281316420413068*std::sin(0.23047998547554*x_53 + 1.99655985832214) - 0.0435802846181433*std::sin(0.257439970970154*x_53 - 7.42767953872681) + 0.0559339554091603*std::sin(0.236959978938103*x_57 + 5.15824031829834) - 0.102208325698411*std::sin(0.326719850301743*x_6 - 1.13911986351013) + 0.0508525303779835*std::sin(0.357119828462601*x_6 + 2.00927972793579) + 0.0327719468689901*std::sin(0.3572798371315*x_6 + 1.99695980548859) + 0.033213879729241*std::sin(0.358879864215851*x_6 + 2.01999974250793) - 0.0205210458345379*std::sin(0.385199844837189*x_6 + 1.99791979789734) + 0.0801354716957196*std::sin(0.164240017533302*x_60 + 1.97215986251831) - 0.0271301972938898*std::sin(0.329279839992523*x_60 - 4.29544019699097) - 0.0123440911188733*std::sin(0.369679838418961*x_60 + 5.03895950317383) + 0.00519654192303676*std::sin(0.399279862642288*x_60 - 4.38207960128784) - 0.0206147006456502*std::sin(0.455599844455719*x_60 - 1.2824798822403) + 0.0240870237922871*std::sin(0.178480014204979*x_61 - 4.41824007034302) + 0.0450212331791*std::sin(0.326879858970642*x_7 + 2.02199983596802) - 0.0231650983315308*std::sin(0.332559853792191*x_7 + 2.04583978652954) + 0.0550648395360351*std::sin(0.348159849643707*x_7 + 2.00615978240967) + 0.117984183227844*std::sin(0.355439841747284*x_7 + 2.00423979759216) - 0.00690246773776719*std::sin(0.307679921388626*x_8 + 5.17511987686157) + 0.0151856489071345*std::sin(0.311919927597046*x_8 - 4.23727989196777) + 0.0271402930059498*std::sin(0.315839916467667*x_8 - 7.43063974380493) - 0.0208385049502123*std::sin(0.317199915647507*x_8 - 4.23792028427124) + 0.00493529251642415*std::sin(0.262799948453903*x_9 + 1.97775971889496) + 0.0667506991733242*std::sin(0.316639930009842*x_9 - 7.43160009384155) + 0.0276020699567243*std::sin(0.326159834861755*x_9 + 8.27543926239014) - 0.0136824981512795*std::sin(0.345359832048416*x_91 - 7.39999961853027) + 0.0625751011318422*std::sin(0.351599842309952*x_91 - 7.40375995635986) + 0.0360608057550883*std::sin(0.362559854984283*x_91 + 2.00079965591431) - 0.00772224558561469*std::sin(0.366399854421616*x_91 - 7.41015958786011) + 0.0118582355677528*std::sin(0.375439822673798*x_91 - 1.18063986301422) - 0.0194851192503932*std::sin(0.28399994969368*x_92 - 1.16303980350494) - 0.0125675778042685*std::sin(0.289679944515228*x_92 + 1.99175977706909) - 0.0369505419260788*std::sin(0.298319935798645*x_92 + 1.99519979953766) - 0.0616777534671763*std::sin(0.282799929380417*x_94 - 7.43056011199951) + 0.00877097305452238*std::sin(0.288399934768677*x_94 + 1.98655986785889) + 0.0161042404909142*std::sin(0.293759942054749*x_94 + 1.98631989955902) + 0.010627876222875*std::sin(0.259359985589981*x_95 - 7.42392015457153) + 0.0241827334881484*std::sin(0.27703994512558*x_95 - 7.43056011199951) + 0.0236350257040776*std::sin(0.27143993973732*x_97 + 1.98071980476379) - 0.0100994727869687*std::sin(0.276159942150116*x_97 - 1.20687985420227) - 0.016540566139255*std::sin(0.280559957027435*x_97 + 1.96655988693237) + 0.222037955024769);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00860960723337209*x_10 - 0.00907239459976793*x_100 - 0.000669871574748428*x_101 + 0.0156561861314177*x_102 - 0.00850602936658513*x_103 + 0.0265050496187211*x_104 - 0.000338141479308304*x_105 + 0.0112464274589099*x_106 + 0.0153860137681112*x_107 - 0.000160121339842222*x_108 + 0.0159908566272097*x_109 + 0.012035919023048*x_11 + 0.0121068067554781*x_110 - 0.0263072077594791*x_111 + 0.0028632446251276*x_112 - 0.0244446454756632*x_113 + 0.0314027157821847*x_114 + 0.0147380946555883*x_115 - 0.00526136908418381*x_116 + 0.0296372911711876*x_117 + 0.00135088814311581*x_118 + 0.0302665515325737*x_119 - 0.00292652012460303*x_12 - 2.1905345330432e-5*x_13 - 0.0112324395041107*x_14 - 0.0030155349714009*x_15 + 0.000171794681455819*x_16 - 0.00370241335577707*x_18 + 0.00149162252645376*x_19 + 0.000419690589490325*x_2 - 0.00104012807837763*x_20 - 0.00655125329541229*x_22 + 0.000256350852871152*x_23 - 0.0128112349136124*x_24 + 0.016253392870603*x_25 - 0.000131398510567893*x_26 + 0.00119926678806303*x_27 - 0.00221983714495928*x_28 + 0.000585876170209801*x_29 - 0.00100321340020035*x_3 + 0.0003347179510746*x_30 - 0.00193623182677562*x_31 - 0.0162319782304998*x_33 + 0.00285502291254583*x_34 + 0.00235444237557502*x_35 - 0.0297585179982748*x_36 - 0.00130409833789825*x_37 - 0.00617980208140843*x_38 - 0.00994512687556157*x_39 - 0.00127851924541759*x_4 - 0.0272731039121767*x_40 - 0.0103442977744638*x_41 + 0.00405365344812852*x_42 + 0.00651453816685232*x_43 + 0.0148416816830872*x_44 + 0.0105888135669719*x_45 - 0.0112846928530912*x_46 - 0.0108547937232491*x_47 - 0.00263756847624625*x_48 - 0.0163049072705247*x_49 + 1.78910489475841e-5*x_5 + 0.00864045431489724*x_50 + 0.00551520137950404*x_51 + 0.0165216508646238*x_52 - 0.0145402827905088*x_53 - 0.00616970762057186*x_54 - 0.00777231116915687*x_55 + 0.00217601196097425*x_56 + 0.00282726336786797*x_57 - 0.0173824461589527*x_58 + 0.0235841945284957*x_59 + 0.00892059996726672*x_61 + 0.00238576319429877*x_62 - 0.0018452333903023*x_63 - 0.000757932775407977*x_64 + 6.38399102813529e-5*x_65 - 0.00554642864212871*x_66 - 0.0067488187705206*x_67 - 0.000104739314215983*x_68 - 0.000187703067295166*x_69 - 1.89377990031522e-5*x_7 - 0.00282827471051431*x_70 + 0.00668128180975239*x_71 + 0.00507796509855918*x_72 + 0.00244410140430451*x_73 + 0.00730026650127083*x_74 - 0.0170807353760969*x_75 - 0.00190574967069153*x_76 - 0.00208031301078813*x_77 - 0.00664528183504018*x_78 - 0.002214800968123*x_79 + 0.00291646758445585*x_8 + 0.00439574665594926*x_80 - 0.00422068303141081*x_81 - 0.00169194676640804*x_82 + 0.00743042816805734*x_83 - 0.010350874705577*x_84 + 0.00592652484572684*x_85 + 0.00302802105805265*x_86 + 0.00112916417561054*x_87 + 0.00440612099547085*x_88 - 0.000575672417281584*x_89 + 0.00103756758513154*x_9 - 0.0011551384273542*x_90 + 0.00333166658591692*x_92 - 0.0261946114770999*x_93 + 0.00946799717047219*x_94 - 0.00243604506159308*x_95 + 0.00230533449512086*x_96 + 0.00891748714026531*x_97 + 0.00265821089605458*x_98 - 0.00932819133532336*x_99 + 4.21969890419116e-5*std::pow(-2.69463992118835*x_24 - 5.59167957305908, 2) + 0.209444201496726*std::sin(0.323279827833176*x_1 - 4.26496028900146) + 0.363479162885067*std::sin(0.332239836454391*x_1 - 4.25663995742798) + 0.177228683196251*std::sin(0.333679854869843*x_1 - 4.25056028366089) + 0.0106722896890098*std::sin(0.335119843482971*x_1 - 4.24823999404907) - 0.0140436269318002*std::sin(0.357359826564789*x_1 - 4.24368000030518) - 0.00264063789604453*std::sin(0.353119850158691*x_10 - 1.14991986751556) - 0.0302675818245077*std::sin(0.224559992551804*x_101 + 1.99807977676392) - 0.0668990181312447*std::sin(0.239759981632233*x_101 + 1.97511982917786) + 0.00287387866708379*std::sin(0.23471999168396*x_102 + 1.95839977264404) - 0.0071162445514266*std::sin(0.215680003166199*x_103 + 1.97719979286194) + 0.135255674526654*std::sin(0.254959970712662*x_108 - 7.43815994262695) + 0.130672864253932*std::sin(0.257999956607819*x_108 - 7.44407987594604) - 0.0147109010619403*std::sin(0.21399998664856*x_109 + 1.98639988899231) + 0.0781899581961825*std::sin(0.25639995932579*x_11 - 7.42575979232788) + 0.151072932502006*std::sin(0.257519960403442*x_11 - 7.41519975662231) - 0.00600547772070286*std::sin(0.273439943790436*x_11 - 7.41864013671875) - 0.072506853083318*std::sin(0.216319993138313*x_110 - 7.4157600402832) - 0.00527318294737131*std::sin(0.217040002346039*x_110 - 7.41983985900879) + 0.0341089357752278*std::sin(0.222240000963211*x_110 + 1.98479974269867) - 0.100919179930746*std::sin(0.272479951381683*x_112 + 5.14752006530762) - 0.0415038484765618*std::sin(0.274239957332611*x_112 + 1.97527980804443) - 0.0383332461229429*std::sin(0.277439951896667*x_112 - 7.43711996078491) - 0.0350129021329345*std::sin(0.28399994969368*x_113 - 7.42224025726318) + 0.0742089050242178*std::sin(0.234959989786148*x_116 - 1.19575989246368) + 0.0264408830608448*std::sin(0.252959966659546*x_116 + 5.15848016738892) - 0.0178534391756518*std::sin(0.271839946508408*x_116 + 8.16720008850098) + 0.0649790866444787*std::sin(0.229839995503426*x_118 + 5.17456007003784) + 0.0900249149336582*std::sin(0.232959985733032*x_118 + 5.16416025161743) - 0.0779424186939102*std::sin(0.270559966564178*x_12 + 5.16064023971558) + 0.0573999484957751*std::sin(0.290239930152893*x_12 - 7.44551992416382) + 0.177086516176804*std::sin(0.294479936361313*x_12 - 7.4488000869751) + 0.152501799810624*std::sin(0.258399993181229*x_120 - 4.23375988006592) - 0.0423734821036078*std::sin(0.259839981794357*x_120 - 4.24735975265503) + 0.13208274249325*std::sin(0.26463994383812*x_120 + 5.15520000457764) - 0.0160702864072899*std::sin(0.269039958715439*x_120 + 5.15112018585205) + 0.0217732926743515*std::sin(0.270479947328568*x_120 - 7.42575979232788) + 0.131877962431846*std::sin(0.228479996323586*x_13 - 1.19263982772827) - 0.00792212937504687*std::sin(0.239439979195595*x_13 + 1.98615980148315) - 0.147180299549405*std::sin(0.29911994934082*x_13 + 5.14871978759766) + 0.0478073806032968*std::sin(0.345359832048416*x_13 - 1.13367986679077) + 0.00908134837089727*std::sin(0.284159928560257*x_14 - 7.43120002746582) + 0.0810241283990959*std::sin(0.287439942359924*x_14 - 7.43151998519897) - 0.085293833912311*std::sin(0.302079945802689*x_14 - 7.43623971939087) + 0.068050546083056*std::sin(0.28399994969368*x_15 + 1.96103990077972) + 0.00358724869701343*std::sin(0.284719944000244*x_15 - 7.41767978668213) + 0.0290956972174952*std::sin(0.287759929895401*x_15 - 1.19479990005493) - 0.19763917935076*std::sin(0.291919946670532*x_15 - 7.41943979263306) - 0.0374386105690444*std::sin(0.273439943790436*x_16 - 4.2149600982666) + 0.0462396065075719*std::sin(0.356159836053848*x_16 - 1.16255986690521) - 0.0350848103721674*std::sin(0.36695984005928*x_16 - 1.16287982463837) - 0.00147319919081163*std::sin(0.397759824991226*x_16 + 8.19583988189697) - 0.0308313193034122*std::sin(0.262479960918427*x_17 + 2.02111983299255) + 0.0702642351108512*std::sin(0.354879856109619*x_17 + 2.00903987884521) - 0.0706297746601632*std::sin(0.359759837388992*x_17 + 2.01855993270874) - 0.00440184008584792*std::sin(0.380319833755493*x_17 + 1.99399983882904) + 0.0523147371338595*std::sin(0.414399862289429*x_17 + 2.00135970115662) + 0.00379067202603359*std::sin(0.239199981093407*x_18 - 1.15639984607697) + 0.035308390719668*std::sin(0.269679963588715*x_18 - 1.15063989162445) - 0.181487310041894*std::sin(0.33943983912468*x_18 - 1.15423989295959) - 0.0807498169950587*std::sin(0.253679990768433*x_19 - 4.39103984832764) + 0.157338223378596*std::sin(0.319279909133911*x_19 + 1.98567974567413) - 0.124524397106094*std::sin(0.346559852361679*x_19 - 1.14703977108002) + 0.0248574067882838*std::sin(0.350719839334488*x_2 - 7.40903997421265) - 0.0400465004561785*std::sin(0.394639849662781*x_2 + 5.18232011795044) + 0.00124841912106819*std::sin(0.400079846382141*x_2 - 4.20695972442627) + 0.056678834619417*std::sin(0.294239938259125*x_20 - 1.18247985839844) + 0.00402684987540217*std::sin(0.317519932985306*x_20 + 1.96199977397919) + 0.0759775499504704*std::sin(0.346479833126068*x_20 + 8.24399948120117) + 0.0067517687065518*std::sin(0.333359837532043*x_21 - 1.14887976646423) + 0.132527108918213*std::sin(0.340559840202332*x_21 - 1.15839993953705) + 0.0232769837126293*std::sin(0.347039848566055*x_21 + 8.22983932495117) - 0.0667554270345828*std::sin(0.353439837694168*x_21 - 4.35775947570801) - 0.0107982803936168*std::sin(0.42647984623909*x_21 + 8.16991996765137) - 0.330882475750647*std::sin(0.162560015916824*x_22 - 4.43807983398438) - 0.136087048510309*std::sin(0.244959965348244*x_22 - 1.18119990825653) + 0.00193756598214675*std::sin(0.285759925842285*x_22 + 8.23952007293701) + 0.0210501261998336*std::sin(0.300879925489426*x_22 - 1.15463984012604) + 0.0352748845682341*std::sin(0.298559933900833*x_23 - 1.15375983715057) + 0.34644951423274*std::sin(0.329759836196899*x_23 + 1.98991978168488) - 0.00381177265977638*std::sin(0.341119825839996*x_23 - 1.17207992076874) - 0.0630164642961896*std::sin(0.38647985458374*x_23 - 1.19239985942841) - 0.0230328857446216*std::sin(0.231039986014366*x_24 - 4.39135980606079) - 0.112402469287228*std::sin(0.330239832401276*x_24 - 1.1568797826767) - 0.0247689110302669*std::sin(0.278879970312119*x_25 - 1.15535986423492) - 0.0596346542662841*std::sin(0.305199921131134*x_25 + 2.0020797252655) + 0.00316358525302602*std::sin(0.345759838819504*x_25 - 1.16223990917206) + 0.0324369737042947*std::sin(0.271199941635132*x_26 - 1.17207992076874) + 0.0043292035267444*std::sin(0.274639964103699*x_26 - 1.16543984413147) - 0.102688942487497*std::sin(0.343679845333099*x_26 + 8.24544048309326) + 0.0494316880695654*std::sin(0.38487982749939*x_26 - 1.1729599237442) + 0.00315783303589788*std::sin(0.154640033841133*x_27 + 4.97559976577759) + 0.0231251372438745*std::sin(0.42103984951973*x_27 - 1.207279920578) - 0.294693085109931*std::sin(0.0844800844788551*x_28 + 8.05719947814941) + 0.0634762270513938*std::sin(0.270879954099655*x_28 + 2.000159740448) - 0.0619566371561569*std::sin(0.308159917593002*x_28 + 1.98215973377228) - 0.00156316271183665*std::sin(0.371119856834412*x_28 - 1.17263984680176) + 0.012565055556352*std::sin(0.25383996963501*x_29 + 1.80247986316681) - 0.0429217056694095*std::sin(0.31535992026329*x_29 + 1.98511981964111) - 0.00870938592918375*std::sin(0.328559845685959*x_29 - 1.16903984546661) + 0.135944710916875*std::sin(0.355519831180573*x_29 - 1.14223992824554) - 0.00079543558870383*std::sin(0.288959950208664*x_3 - 1.13039994239807) - 0.047830185809124*std::sin(0.346479833126068*x_3 - 7.40783977508545) + 0.0997808652160895*std::sin(0.348239839076996*x_3 - 7.40471982955933) - 0.133006051929515*std::sin(0.373999834060669*x_3 - 7.40743970870972) + 0.437844473260125*std::sin(0.199120000004768*x_30 + 8.18671989440918) - 0.0714936583035047*std::sin(0.258879989385605*x_30 - 1.16759991645813) + 0.268135113268113*std::sin(0.268719971179962*x_30 - 1.17455983161926) - 0.0143991571303572*std::sin(0.329279839992523*x_30 - 1.15023982524872) - 0.00831913799252624*std::sin(0.375839829444885*x_31 - 7.39943981170654) + 0.0388536441085374*std::sin(0.376319825649261*x_31 + 5.16775989532471) + 0.0577433367935351*std::sin(0.380639851093292*x_31 - 7.40391969680786) + 0.0696692258015167*std::sin(0.295279920101166*x_32 - 1.14495992660522) + 0.0757342603850308*std::sin(0.299279928207397*x_32 + 2.02359986305237) - 0.0290546912473007*std::sin(0.302399933338165*x_32 - 1.13367986679077) - 0.00494208043830788*std::sin(0.303839921951294*x_32 - 1.13895988464355) - 0.0874488580425648*std::sin(0.305679947137833*x_32 - 1.14007985591888) - 0.00467185870241322*std::sin(0.243359968066216*x_33 + 1.98735988140106) - 0.00303632657754753*std::sin(0.241119980812073*x_35 - 7.43616008758545) + 0.0211412949333324*std::sin(0.222559988498688*x_36 + 5.17360019683838) - 0.0220912858602495*std::sin(0.190160006284714*x_37 - 1.17119991779327) - 0.00267370660599104*std::sin(0.197759985923767*x_37 - 1.19143986701965) + 0.181032171200339*std::sin(0.235199987888336*x_38 + 1.97775971889496) + 0.053894539008576*std::sin(0.265519946813583*x_4 + 2.03111982345581) + 0.12236902118974*std::sin(0.312879920005798*x_4 + 2.01127982139587) + 0.123662258920697*std::sin(0.328959852457047*x_4 + 1.99927973747253) - 0.0376714381204967*std::sin(0.231519982218742*x_40 + 1.96791982650757) - 0.014288357565441*std::sin(0.251359969377518*x_42 - 7.43455982208252) + 0.113084111514672*std::sin(0.135360047221184*x_44 - 1.19167983531952) + 0.00249911773012853*std::sin(0.157520025968552*x_45 - 4.39479970932007) - 0.0127736325777895*std::sin(0.174560010433197*x_45 - 4.58383989334106) + 0.0405795515564295*std::sin(0.140800043940544*x_46 - 1.20887982845306) + 0.0210445077715437*std::sin(0.235679984092712*x_46 - 1.21863985061646) + 0.159585823505976*std::sin(0.201440006494522*x_47 + 1.98727989196777) + 0.0275983836706225*std::sin(0.202799990773201*x_47 - 1.19279980659485) + 0.0137476093402437*std::sin(0.23039998114109*x_47 - 1.21311986446381) - 0.192229883394446*std::sin(0.215759992599487*x_48 - 7.39559984207153) - 0.0223805349498393*std::sin(0.280879944562912*x_49 + 8.27223968505859) - 0.00496682772315191*std::sin(0.317999929189682*x_5 + 2.01639986038208) - 0.153413991581617*std::sin(0.340559840202332*x_5 + 2.0162398815155) - 0.0352531233700722*std::sin(0.346319854259491*x_5 - 7.37375974655151) + 0.093277026213537*std::sin(0.366399854421616*x_5 - 1.16279983520508) + 0.00641221296881001*std::sin(0.187520012259483*x_51 - 1.1943199634552) + 0.128954725619591*std::sin(0.205520004034042*x_51 - 7.40855979919434) + 0.0422214579153681*std::sin(0.213919997215271*x_51 - 1.18455994129181) - 0.0323553016391483*std::sin(0.23879998922348*x_52 - 7.41024017333984) + 0.00112015520870805*std::sin(0.227519989013672*x_53 - 1.20567989349365) - 0.0533917418466202*std::sin(0.23047998547554*x_53 + 1.99655985832214) + 0.0943248165740582*std::sin(0.257439970970154*x_53 - 7.42767953872681) - 0.140076628970476*std::sin(0.236959978938103*x_57 + 5.15824031829834) + 0.255962547469068*std::sin(0.326719850301743*x_6 - 1.13911986351013) + 0.0360209409346532*std::sin(0.357119828462601*x_6 + 2.00927972793579) - 0.0709313375136919*std::sin(0.3572798371315*x_6 + 1.99695980548859) + 0.00550765670029278*std::sin(0.358879864215851*x_6 + 2.01999974250793) - 0.0389474023596461*std::sin(0.385199844837189*x_6 + 1.99791979789734) + 0.0132883803763367*std::sin(0.164240017533302*x_60 + 1.97215986251831) + 0.0679427469849493*std::sin(0.329279839992523*x_60 - 4.29544019699097) + 0.0267174512686968*std::sin(0.369679838418961*x_60 + 5.03895950317383) + 0.00986264592882719*std::sin(0.399279862642288*x_60 - 4.38207960128784) - 0.0146022412026131*std::sin(0.455599844455719*x_60 - 1.2824798822403) + 0.00399420540632918*std::sin(0.178480014204979*x_61 - 4.41824007034302) + 0.0318903930462372*std::sin(0.326879858970642*x_7 + 2.02199983596802) - 0.043965615236842*std::sin(0.332559853792191*x_7 + 2.04583978652954) - 0.137900083063763*std::sin(0.348159849643707*x_7 + 2.00615978240967) - 0.255364014694235*std::sin(0.355439841747284*x_7 + 2.00423979759216) - 0.013100364885148*std::sin(0.307679921388626*x_8 + 5.17511987686157) + 0.0107566203347689*std::sin(0.311919927597046*x_8 - 4.23727989196777) + 0.00450051056488078*std::sin(0.315839916467667*x_8 - 7.43063974380493) + 0.0521863241184671*std::sin(0.317199915647507*x_8 - 4.23792028427124) + 0.00936681419405101*std::sin(0.262799948453903*x_9 + 1.97775971889496) - 0.144474674979353*std::sin(0.316639930009842*x_9 - 7.43160009384155) + 0.0195516825651569*std::sin(0.326159834861755*x_9 + 8.27543926239014) - 0.00226888587644561*std::sin(0.345359832048416*x_91 - 7.39999961853027) - 0.135437044252503*std::sin(0.351599842309952*x_91 - 7.40375995635986) + 0.0255433533888102*std::sin(0.362559854984283*x_91 + 2.00079965591431) - 0.0146562416149736*std::sin(0.366399854421616*x_91 - 7.41015958786011) - 0.0296968389186468*std::sin(0.375439822673798*x_91 - 1.18063986301422) + 0.0487970106837075*std::sin(0.28399994969368*x_92 - 1.16303980350494) - 0.023852317926467*std::sin(0.289679944515228*x_92 + 1.99175977706909) - 0.00612728478207408*std::sin(0.298319935798645*x_92 + 1.99519979953766) - 0.0436888921379051*std::sin(0.282799929380417*x_94 - 7.43056011199951) + 0.0166466475146776*std::sin(0.288399934768677*x_94 + 1.98655986785889) + 0.00267046875480864*std::sin(0.293759942054749*x_94 + 1.98631989955902) + 0.0201709101387106*std::sin(0.259359985589981*x_95 - 7.42392015457153) - 0.0605613488538754*std::sin(0.27703994512558*x_95 - 7.43056011199951) - 0.0591897122604626*std::sin(0.27143993973732*x_97 + 1.98071980476379) - 0.0191680401391794*std::sin(0.276159942150116*x_97 - 1.20687985420227) - 0.0117163639940675*std::sin(0.280559957027435*x_97 + 1.96655988693237) + 0.0564403499173589);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000374578738595833*x_10 + 0.00836120961784268*x_100 - 0.00059876993411996*x_101 + 0.00439992157144995*x_102 + 0.00214264656111683*x_103 - 0.00172259014282221*x_104 + 0.00205814422330008*x_105 - 0.00514145255041841*x_106 - 0.00419119679694557*x_107 + 0.00169693909497551*x_108 + 0.00141407469819776*x_109 - 0.00919280803060821*x_11 - 0.00346932636228434*x_110 + 0.0101715766448066*x_111 + 0.00100659563206204*x_112 + 0.0260367614868578*x_113 + 0.000134005811301455*x_114 - 0.00296314181647511*x_115 + 0.00152340460730844*x_116 - 0.00166964232270487*x_117 - 0.00423078922889509*x_118 + 0.0163194933675817*x_119 - 0.0029979092728857*x_12 - 1.35720275212716e-5*x_13 - 0.00140440782093302*x_14 - 0.00186835327203685*x_15 - 4.98447899466843e-5*x_16 + 0.0036935521535398*x_18 - 0.000318084399707459*x_19 + 0.00154458210395413*x_2 + 0.000168220465324863*x_20 + 0.00190079134947683*x_22 - 7.43780558614211e-5*x_23 + 0.0114776606433059*x_24 + 0.000183474893948416*x_25 - 8.14113712785906e-5*x_26 + 0.00327410972987868*x_27 - 0.0013753579489237*x_28 + 5.85255486644643e-5*x_29 + 0.000895033042383351*x_3 - 0.000180876895913036*x_30 - 0.000143296172361841*x_31 + 0.00401758144870976*x_33 - 0.00535826425495492*x_34 + 0.00600573679068205*x_35 + 0.0305544503940741*x_36 + 0.000453236385230622*x_37 + 0.00127176905865837*x_38 - 0.00608600001404329*x_39 - 0.000646333099455461*x_4 + 0.0046077369501066*x_40 + 0.00848965383747318*x_41 - 0.00511195531259293*x_42 - 0.00351561403696864*x_43 - 0.00265736001513061*x_44 + 0.00711065021510625*x_45 + 0.0109018947474655*x_46 - 0.000769703057955926*x_47 + 0.00466684505034487*x_48 + 0.00121763280144476*x_49 - 9.66807244092494e-6*x_5 - 0.00517814286718153*x_50 - 0.00444592214187175*x_51 - 0.0203576111046611*x_52 + 0.00162481351507172*x_53 + 0.0060126050966221*x_54 + 0.00731054817140918*x_55 - 0.00227627517998212*x_56 - 0.00499222530367007*x_57 - 0.0136307033925432*x_58 + 0.00136311605826076*x_59 - 0.00360691070266806*x_61 + 0.00178175731849611*x_62 - 0.00282128656576098*x_63 - 0.00373642652995999*x_64 - 0.00399501111221118*x_65 + 0.000973123350887239*x_66 - 0.00396945274453844*x_67 + 0.00117695629187417*x_68 - 0.00229063554735117*x_69 + 1.02337215202172e-5*x_7 + 0.00544999937121475*x_70 - 0.00216135277010891*x_71 - 0.00320835236801663*x_72 - 0.000613009114011343*x_73 - 0.00682416395471155*x_74 + 0.00477328481139397*x_75 - 0.000146306482929839*x_76 + 0.001248618668221*x_77 + 0.003610918066097*x_78 - 0.000344862201979618*x_79 - 0.00260197367240771*x_8 - 0.00278954502915296*x_80 + 0.00884061570084174*x_81 + 0.000905127369105941*x_82 + 0.00226685289100907*x_83 - 0.00179460758217238*x_84 - 0.003625606766619*x_85 - 0.00413981198616042*x_86 - 0.00185925228905625*x_87 + 0.000657204673826193*x_88 + 0.000127470842599345*x_89 + 0.000189857127494991*x_9 + 0.000406456138808023*x_90 - 0.00369047105915122*x_92 + 0.00357735013555135*x_93 - 0.00540757794352795*x_94 + 0.0013298022810829*x_95 + 0.00897877053144434*x_96 - 0.00798030120729092*x_97 - 0.000242374751765281*x_98 + 0.0108742426791308*x_99 + 2.61442441537773e-5*std::pow(-2.69463992118835*x_24 - 5.59167957305908, 2) - 0.186859028037034*std::sin(0.323279827833176*x_1 - 4.26496028900146) + 0.0363094089120078*std::sin(0.332239836454391*x_1 - 4.25663995742798) - 0.0514214201020911*std::sin(0.333679854869843*x_1 - 4.25056028366089) - 0.00576715597426253*std::sin(0.335119843482971*x_1 - 4.24823999404907) - 0.00870109502232184*std::sin(0.357359826564789*x_1 - 4.24368000030518) + 0.00142696375958758*std::sin(0.353119850158691*x_10 - 1.14991986751556) + 0.0270037121120649*std::sin(0.224559992551804*x_101 + 1.99807977676392) + 0.0194101905724531*std::sin(0.239759981632233*x_101 + 1.97511982917786) - 0.00155300380772514*std::sin(0.23471999168396*x_102 + 1.95839977264404) - 0.00440905475093717*std::sin(0.215680003166199*x_103 + 1.97719979286194) + 0.0135112383198995*std::sin(0.254959970712662*x_108 - 7.43815994262695) - 0.116581906927066*std::sin(0.257999956607819*x_108 - 7.44407987594604) - 0.00911452209785453*std::sin(0.21399998664856*x_109 + 1.98639988899231) - 0.0226861623957261*std::sin(0.25639995932579*x_11 - 7.42575979232788) + 0.0150912884199802*std::sin(0.257519960403442*x_11 - 7.41519975662231) + 0.00324527610517528*std::sin(0.273439943790436*x_11 - 7.41864013671875) + 0.0646881603613391*std::sin(0.216319993138313*x_110 - 7.4157600402832) + 0.00284955425916042*std::sin(0.217040002346039*x_110 - 7.41983985900879) + 0.0211330799893647*std::sin(0.222240000963211*x_110 + 1.98479974269867) + 0.090036676773067*std::sin(0.272479951381683*x_112 + 5.14752006530762) - 0.0257147908542683*std::sin(0.274239957332611*x_112 + 1.97527980804443) + 0.0111220707462007*std::sin(0.277439951896667*x_112 - 7.43711996078491) + 0.0101587007086058*std::sin(0.28399994969368*x_113 - 7.42224025726318) + 0.00741302873058688*std::sin(0.234959989786148*x_116 - 1.19575989246368) + 0.0163821381117406*std::sin(0.252959966659546*x_116 + 5.15848016738892) + 0.0159282341914477*std::sin(0.271839946508408*x_116 + 8.16720008850098) - 0.0188531385097297*std::sin(0.229839995503426*x_118 + 5.17456007003784) + 0.0089929541562978*std::sin(0.232959985733032*x_118 + 5.16416025161743) + 0.0695375880350036*std::sin(0.270559966564178*x_12 + 5.16064023971558) - 0.0166541149672215*std::sin(0.290239930152893*x_12 - 7.44551992416382) + 0.0176898908802087*std::sin(0.294479936361313*x_12 - 7.4488000869751) - 0.136056944440914*std::sin(0.258399993181229*x_120 - 4.23375988006592) + 0.0122943114237625*std::sin(0.259839981794357*x_120 - 4.24735975265503) + 0.0131942812604179*std::sin(0.26463994383812*x_120 + 5.15520000457764) + 0.00868415784827808*std::sin(0.269039958715439*x_120 + 5.15112018585205) + 0.0134902108570946*std::sin(0.270479947328568*x_120 - 7.42575979232788) + 0.0131738249488992*std::sin(0.228479996323586*x_13 - 1.19263982772827) + 0.00428100783295185*std::sin(0.239439979195595*x_13 + 1.98615980148315) + 0.131309282011473*std::sin(0.29911994934082*x_13 + 5.14871978759766) - 0.0138709116247312*std::sin(0.345359832048416*x_13 - 1.13367986679077) - 0.00490743355341199*std::sin(0.284159928560257*x_14 - 7.43120002746582) - 0.0235084731753162*std::sin(0.287439942359924*x_14 - 7.43151998519897) + 0.0760962718877457*std::sin(0.302079945802689*x_14 - 7.43623971939087) - 0.0607123940772742*std::sin(0.28399994969368*x_15 + 1.96103990077972) - 0.00193849898728395*std::sin(0.284719944000244*x_15 - 7.41767978668213) - 0.00844187319344544*std::sin(0.287759929895401*x_15 - 1.19479990005493) - 0.0197429798261902*std::sin(0.291919946670532*x_15 - 7.41943979263306) - 0.0231960667744113*std::sin(0.273439943790436*x_16 - 4.2149600982666) - 0.0412534119687953*std::sin(0.356159836053848*x_16 - 1.16255986690521) - 0.00350476411437673*std::sin(0.36695984005928*x_16 - 1.16287982463837) + 0.000796096223223522*std::sin(0.397759824991226*x_16 + 8.19583988189697) - 0.0191023472942788*std::sin(0.262479960918427*x_17 + 2.02111983299255) - 0.0203865801326656*std::sin(0.354879856109619*x_17 + 2.00903987884521) + 0.0630134945210175*std::sin(0.359759837388992*x_17 + 2.01855993270874) + 0.00237869277245992*std::sin(0.380319833755493*x_17 + 1.99399983882904) + 0.00522593143342892*std::sin(0.414399862289429*x_17 + 2.00135970115662) - 0.00204842610709134*std::sin(0.239199981093407*x_18 - 1.15639984607697) + 0.0218762335562638*std::sin(0.269679963588715*x_18 - 1.15063989162445) - 0.0181295040418456*std::sin(0.33943983912468*x_18 - 1.15423989295959) - 0.0500306533434123*std::sin(0.253679990768433*x_19 - 4.39103984832764) + 0.0157171537559326*std::sin(0.319279909133911*x_19 + 1.98567974567413) + 0.111096452629681*std::sin(0.346559852361679*x_19 - 1.14703977108002) - 0.0221769370495201*std::sin(0.350719839334488*x_2 - 7.40903997421265) - 0.00400040747595226*std::sin(0.394639849662781*x_2 + 5.18232011795044) - 0.00067462821964684*std::sin(0.400079846382141*x_2 - 4.20695972442627) + 0.00566187884476671*std::sin(0.294239938259125*x_20 - 1.18247985839844) - 0.00217605331124953*std::sin(0.317519932985306*x_20 + 1.96199977397919) - 0.067784598642145*std::sin(0.346479833126068*x_20 + 8.24399948120117) - 0.00364856130853789*std::sin(0.333359837532043*x_21 - 1.14887976646423) - 0.118236201260518*std::sin(0.340559840202332*x_21 - 1.15839993953705) + 0.0144218618238859*std::sin(0.347039848566055*x_21 + 8.22983932495117) - 0.0066684705611606*std::sin(0.353439837694168*x_21 - 4.35775947570801) + 0.00313303074020745*std::sin(0.42647984623909*x_21 + 8.16991996765137) + 0.295202146306351*std::sin(0.162560015916824*x_22 - 4.43807983398438) - 0.0135942876416041*std::sin(0.244959965348244*x_22 - 1.18119990825653) - 0.00104703353779579*std::sin(0.285759925842285*x_22 + 8.23952007293701) + 0.0130421542231285*std::sin(0.300879925489426*x_22 - 1.15463984012604) + 0.0218554739470208*std::sin(0.298559933900833*x_23 - 1.15375983715057) + 0.0346082481862121*std::sin(0.329759836196899*x_23 + 1.98991978168488) + 0.00205982859423295*std::sin(0.341119825839996*x_23 - 1.17207992076874) + 0.0562211566831107*std::sin(0.38647985458374*x_23 - 1.19239985942841) + 0.00668279915348774*std::sin(0.231039986014366*x_24 - 4.39135980606079) - 0.0112283388892911*std::sin(0.330239832401276*x_24 - 1.1568797826767) + 0.00718649237013354*std::sin(0.278879970312119*x_25 - 1.15535986423492) + 0.0532040202301643*std::sin(0.305199921131134*x_25 + 2.0020797252655) - 0.00170955719191789*std::sin(0.345759838819504*x_25 - 1.16223990917206) - 0.0094113166199065*std::sin(0.271199941635132*x_26 - 1.17207992076874) - 0.00233944099257101*std::sin(0.274639964103699*x_26 - 1.16543984413147) - 0.0102580152708758*std::sin(0.343679845333099*x_26 + 8.24544048309326) - 0.0441012791039395*std::sin(0.38487982749939*x_26 - 1.1729599237442) - 0.0017064487742922*std::sin(0.154640033841133*x_27 + 4.97559976577759) - 0.00670956515441141*std::sin(0.42103984951973*x_27 - 1.207279920578) + 0.262915196789239*std::sin(0.0844800844788551*x_28 + 8.05719947814941) + 0.00634089796484231*std::sin(0.270879954099655*x_28 + 2.000159740448) + 0.017976200070232*std::sin(0.308159917593002*x_28 + 1.98215973377228) + 0.000844711250819654*std::sin(0.371119856834412*x_28 - 1.17263984680176) + 0.00778500759721886*std::sin(0.25383996963501*x_29 + 1.80247986316681) + 0.0124533739060794*std::sin(0.31535992026329*x_29 + 1.98511981964111) + 0.00470643025604661*std::sin(0.328559845685959*x_29 - 1.16903984546661) - 0.121285270096628*std::sin(0.355519831180573*x_29 - 1.14223992824554) + 0.000429842258897674*std::sin(0.288959950208664*x_3 - 1.13039994239807) + 0.013877528364461*std::sin(0.346479833126068*x_3 - 7.40783977508545) + 0.0618218351905045*std::sin(0.348239839076996*x_3 - 7.40471982955933) - 0.013286514387642*std::sin(0.373999834060669*x_3 - 7.40743970870972) + 0.0437380616079263*std::sin(0.199120000004768*x_30 + 8.18671989440918) + 0.0207432869892115*std::sin(0.258879989385605*x_30 - 1.16759991645813) - 0.239221073153762*std::sin(0.268719971179962*x_30 - 1.17455983161926) - 0.0089213730214436*std::sin(0.329279839992523*x_30 - 1.15023982524872) + 0.00449554573314469*std::sin(0.375839829444885*x_31 - 7.39943981170654) - 0.0346639062907245*std::sin(0.376319825649261*x_31 + 5.16775989532471) - 0.0167537462097428*std::sin(0.380639851093292*x_31 - 7.40391969680786) - 0.0621565253386476*std::sin(0.295279920101166*x_32 - 1.14495992660522) + 0.00756540266886789*std::sin(0.299279928207397*x_32 + 2.02359986305237) - 0.0180015910857424*std::sin(0.302399933338165*x_32 - 1.13367986679077) + 0.00267063109750704*std::sin(0.303839921951294*x_32 - 1.13895988464355) + 0.0253725547454159*std::sin(0.305679947137833*x_32 - 1.14007985591888) + 0.00252460705356216*std::sin(0.243359968066216*x_33 + 1.98735988140106) + 0.00164078838485315*std::sin(0.241119980812073*x_35 - 7.43616008758545) + 0.0130986401876938*std::sin(0.222559988498688*x_36 + 5.17360019683838) + 0.0197090975755613*std::sin(0.190160006284714*x_37 - 1.17119991779327) + 0.00144483362759965*std::sin(0.197759985923767*x_37 - 1.19143986701965) + 0.0180840383755923*std::sin(0.235199987888336*x_38 + 1.97775971889496) - 0.0156370497234905*std::sin(0.265519946813583*x_4 + 2.03111982345581) + 0.0122239382122308*std::sin(0.312879920005798*x_4 + 2.01127982139587) - 0.110327282119322*std::sin(0.328959852457047*x_4 + 1.99927973747253) - 0.0233403211510648*std::sin(0.231519982218742*x_40 + 1.96791982650757) - 0.0088527242637224*std::sin(0.251359969377518*x_42 - 7.43455982208252) - 0.100889817015983*std::sin(0.135360047221184*x_44 - 1.19167983531952) - 0.0013504882427*std::sin(0.157520025968552*x_45 - 4.39479970932007) + 0.00370616265474892*std::sin(0.174560010433197*x_45 - 4.58383989334106) + 0.0251421186115516*std::sin(0.140800043940544*x_46 - 1.20887982845306) - 0.00610588791524215*std::sin(0.235679984092712*x_46 - 1.21863985061646) - 0.142377070626529*std::sin(0.201440006494522*x_47 + 1.98727989196777) + 0.0170992977773299*std::sin(0.202799990773201*x_47 - 1.19279980659485) - 0.00398875386610701*std::sin(0.23039998114109*x_47 - 1.21311986446381) - 0.0192026232972357*std::sin(0.215759992599487*x_48 - 7.39559984207153) - 0.0138664436327336*std::sin(0.280879944562912*x_49 + 8.27223968505859) - 0.00307732754426761*std::sin(0.317999929189682*x_5 + 2.01639986038208) + 0.136870771066301*std::sin(0.340559840202332*x_5 + 2.0162398815155) + 0.010228398891369*std::sin(0.346319854259491*x_5 - 7.37375974655151) + 0.00931782075209166*std::sin(0.366399854421616*x_5 - 1.16279983520508) - 0.00346507014042152*std::sin(0.187520012259483*x_51 - 1.1943199634552) - 0.115049041787084*std::sin(0.205520004034042*x_51 - 7.40855979919434) + 0.00421767280452051*std::sin(0.213919997215271*x_51 - 1.18455994129181) + 0.00938762015330324*std::sin(0.23879998922348*x_52 - 7.41024017333984) - 0.00060531619664096*std::sin(0.227519989013672*x_53 - 1.20567989349365) - 0.0330802449730961*std::sin(0.23047998547554*x_53 + 1.99655985832214) - 0.0841534089692885*std::sin(0.257439970970154*x_53 - 7.42767953872681) - 0.0139928230271424*std::sin(0.236959978938103*x_57 + 5.15824031829834) + 0.0255691377971846*std::sin(0.326719850301743*x_6 - 1.13911986351013) - 0.0104511747357642*std::sin(0.357119828462601*x_6 + 2.00927972793579) + 0.063282538692686*std::sin(0.3572798371315*x_6 + 1.99695980548859) - 0.00297626059344981*std::sin(0.358879864215851*x_6 + 2.01999974250793) - 0.0241308780452232*std::sin(0.385199844837189*x_6 + 1.99791979789734) - 0.00718085476583175*std::sin(0.164240017533302*x_60 + 1.97215986251831) + 0.00678707677023474*std::sin(0.329279839992523*x_60 - 4.29544019699097) - 0.023836405782633*std::sin(0.369679838418961*x_60 + 5.03895950317383) + 0.00611065929157665*std::sin(0.399279862642288*x_60 - 4.38207960128784) + 0.00423671815289724*std::sin(0.455599844455719*x_60 - 1.2824798822403) - 0.00215841269706766*std::sin(0.178480014204979*x_61 - 4.41824007034302) - 0.00925273081353039*std::sin(0.326879858970642*x_7 + 2.02199983596802) - 0.027240042600702*std::sin(0.332559853792191*x_7 + 2.04583978652954) - 0.0137753990221036*std::sin(0.348159849643707*x_7 + 2.00615978240967) + 0.227827131237842*std::sin(0.355439841747284*x_7 + 2.00423979759216) - 0.00811667244126585*std::sin(0.307679921388626*x_8 + 5.17511987686157) - 0.00312094342257433*std::sin(0.311919927597046*x_8 - 4.23727989196777) - 0.00243201291829738*std::sin(0.315839916467667*x_8 - 7.43063974380493) + 0.00521310373610372*std::sin(0.317199915647507*x_8 - 4.23792028427124) + 0.005803453819634*std::sin(0.262799948453903*x_9 + 1.97775971889496) + 0.128895415340636*std::sin(0.316639930009842*x_9 - 7.43160009384155) - 0.00567275716748614*std::sin(0.326159834861755*x_9 + 8.27543926239014) + 0.00122607417138779*std::sin(0.345359832048416*x_91 - 7.39999961853027) + 0.120832347080409*std::sin(0.351599842309952*x_91 - 7.40375995635986) - 0.00741119034308758*std::sin(0.362559854984283*x_91 + 2.00079965591431) - 0.00908065641313971*std::sin(0.366399854421616*x_91 - 7.41015958786011) - 0.0029665377765606*std::sin(0.375439822673798*x_91 - 1.18063986301422) + 0.00487453146016679*std::sin(0.28399994969368*x_92 - 1.16303980350494) - 0.0147783251284514*std::sin(0.289679944515228*x_92 + 1.99175977706909) + 0.00331109893627944*std::sin(0.298319935798645*x_92 + 1.99519979953766) + 0.0126759666432238*std::sin(0.282799929380417*x_94 - 7.43056011199951) + 0.0103138642554172*std::sin(0.288399934768677*x_94 + 1.98655986785889) - 0.00144308393813896*std::sin(0.293759942054749*x_94 + 1.98631989955902) + 0.0124974130013534*std::sin(0.259359985589981*x_95 - 7.42392015457153) - 0.00604971895044621*std::sin(0.27703994512558*x_95 - 7.43056011199951) - 0.00591270060377238*std::sin(0.27143993973732*x_97 + 1.98071980476379) - 0.0118760587597936*std::sin(0.276159942150116*x_97 - 1.20687985420227) + 0.00339940501809643*std::sin(0.280559957027435*x_97 + 1.96655988693237) - 0.358326039960434);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00109384392532278*x_10 + 0.00690302243148524*x_100 - 0.000780183594117521*x_101 + 0.00423574966737733*x_102 + 0.000812195443434559*x_103 - 0.00536555711036863*x_104 - 0.00126799565205863*x_105 - 0.00618942909942268*x_106 - 0.00282712347599712*x_107 - 0.00254650753738176*x_108 + 0.000805585852711934*x_109 - 0.00834679999587734*x_11 - 0.00188921534749137*x_110 + 0.0104635834562003*x_111 + 0.00450780923463911*x_112 + 0.0215610311273835*x_113 - 0.00160053105647724*x_114 + 0.000713173738131542*x_115 + 0.000790165054466246*x_116 + 0.00316237109330602*x_117 + 0.00280483036633456*x_118 + 0.00989739783651337*x_119 - 0.00304656920725718*x_12 + 3.68795416836468e-6*x_13 - 0.00102983592413631*x_14 + 0.000507691369383587*x_15 - 2.72233027150266e-5*x_16 + 0.00312657243126979*x_18 + 0.0013564794469516*x_19 - 8.46298525487352e-5*x_2 + 0.0001662757364017*x_20 + 0.00103813895815913*x_22 - 4.06224267819452e-5*x_23 + 0.00911503804583963*x_24 + 0.00246227075368672*x_25 + 2.21220746560225e-5*x_26 - 0.0017174786911604*x_27 + 0.000373728764753596*x_28 + 6.14595076899432e-5*x_29 + 0.000744611807370992*x_3 - 0.00121626686802273*x_30 - 0.000229469562226207*x_31 + 0.0029080916488524*x_33 - 0.00499841825414653*x_34 + 0.00313420474022058*x_35 + 0.0262662772541742*x_36 - 0.000997045285697069*x_37 + 0.00267629679241884*x_38 - 0.00140204775226554*x_39 + 0.000650842773852395*x_4 + 0.00457338775511602*x_40 + 0.00612331021399819*x_41 - 0.00615783954637246*x_42 - 0.00315234374198459*x_43 - 0.000242312453662988*x_44 + 0.00245068232293255*x_45 + 0.00893584964930598*x_46 + 0.000698421577947827*x_47 + 0.00108476706836351*x_48 - 0.000663540653619756*x_49 - 6.50108247832507e-5*x_5 - 0.00252471626840156*x_50 - 0.000843010484435807*x_51 - 0.017858386218319*x_52 + 0.000552601040980738*x_53 + 0.00621600917098991*x_54 + 0.0057928683764642*x_55 - 0.00297407877701263*x_56 - 0.00290765884328594*x_57 - 0.00417019778782514*x_58 - 0.00236815836636098*x_59 - 0.00222624657799265*x_61 + 0.000702283979391899*x_62 - 0.00193331730910704*x_63 - 0.0028441616653247*x_64 - 0.00434294370164584*x_65 + 0.00078140245425311*x_66 - 0.00199702492185031*x_67 + 0.000348917857511498*x_68 - 0.00167440611567045*x_69 + 6.88144074940109e-5*x_7 + 0.00463730737389945*x_70 - 0.00192908791888616*x_71 - 0.000975503887437641*x_72 - 0.00220878652969632*x_73 - 0.00506639799769023*x_74 + 0.00441921176250725*x_75 + 6.59272305593596e-5*x_76 + 0.00348282470383016*x_77 + 0.00248119112970009*x_78 - 0.000543611194796518*x_79 - 0.00216468021536283*x_8 - 0.0033592765154572*x_80 + 0.00624015991826479*x_81 + 0.000558768130218284*x_82 + 0.000655237329431989*x_83 - 0.00150992633625781*x_84 - 0.0039188464069841*x_85 - 0.00348145552088723*x_86 - 0.000922106249176702*x_87 + 0.00173441230269446*x_88 + 0.0026942450458579*x_89 + 0.000612226458437376*x_9 + 0.000322475347313467*x_90 - 0.00316914076558587*x_92 + 0.00453377878939538*x_93 - 0.00443198968553948*x_94 + 0.00166975411344869*x_95 + 0.0087554515338607*x_96 - 0.00641806745591817*x_97 - 0.000249166656208174*x_98 + 0.00941141331699736*x_99 - 7.1042277253379e-6*std::pow(-2.69463992118835*x_24 - 5.59167957305908, 2) - 0.155455086015304*std::sin(0.323279827833176*x_1 - 4.26496028900146) + 0.0381296450382498*std::sin(0.332239836454391*x_1 - 4.25663995742798) - 0.0280843973256406*std::sin(0.333679854869843*x_1 - 4.25056028366089) - 0.0387799707574998*std::sin(0.335119843482971*x_1 - 4.24823999404907) + 0.00236436594360092*std::sin(0.357359826564789*x_1 - 4.24368000030518) + 0.00959530366714154*std::sin(0.353119850158691*x_10 - 1.14991986751556) + 0.0224654084590527*std::sin(0.224559992551804*x_101 + 1.99807977676392) + 0.0106010978133412*std::sin(0.239759981632233*x_101 + 1.97511982917786) - 0.010442832224174*std::sin(0.23471999168396*x_102 + 1.95839977264404) + 0.00119808126101879*std::sin(0.215680003166199*x_103 + 1.97719979286194) + 0.0141885736122406*std::sin(0.254959970712662*x_108 - 7.43815994262695) - 0.0969888934966701*std::sin(0.257999956607819*x_108 - 7.44407987594604) + 0.00247670730926172*std::sin(0.21399998664856*x_109 + 1.98639988899231) - 0.0123903073320542*std::sin(0.25639995932579*x_11 - 7.42575979232788) + 0.0158478336019785*std::sin(0.257519960403442*x_11 - 7.41519975662231) + 0.021822144748704*std::sin(0.273439943790436*x_11 - 7.41864013671875) + 0.0538165248892908*std::sin(0.216319993138313*x_110 - 7.4157600402832) + 0.0191612003100508*std::sin(0.217040002346039*x_110 - 7.41983985900879) - 0.00574253406979974*std::sin(0.222240000963211*x_110 + 1.98479974269867) + 0.0749049135025748*std::sin(0.272479951381683*x_112 + 5.14752006530762) + 0.00698753152180017*std::sin(0.274239957332611*x_112 + 1.97527980804443) + 0.006074446277447*std::sin(0.277439951896667*x_112 - 7.43711996078491) + 0.00554829070154657*std::sin(0.28399994969368*x_113 - 7.42224025726318) + 0.00778465314157589*std::sin(0.234959989786148*x_116 - 1.19575989246368) - 0.00445155113642586*std::sin(0.252959966659546*x_116 + 5.15848016738892) + 0.0132512998826723*std::sin(0.271839946508408*x_116 + 8.16720008850098) - 0.0102968574514544*std::sin(0.229839995503426*x_118 + 5.17456007003784) + 0.00944378220686179*std::sin(0.232959985733032*x_118 + 5.16416025161743) + 0.057850947009827*std::sin(0.270559966564178*x_12 + 5.16064023971558) - 0.00909583556653517*std::sin(0.290239930152893*x_12 - 7.44551992416382) + 0.0185767072568528*std::sin(0.294479936361313*x_12 - 7.4488000869751) - 0.113190913081544*std::sin(0.258399993181229*x_120 - 4.23375988006592) + 0.00671467894477826*std::sin(0.259839981794357*x_120 - 4.24735975265503) + 0.0138557270985535*std::sin(0.26463994383812*x_120 + 5.15520000457764) + 0.0583947077056124*std::sin(0.269039958715439*x_120 + 5.15112018585205) - 0.0036657219626592*std::sin(0.270479947328568*x_120 - 7.42575979232788) + 0.0138342452865282*std::sin(0.228479996323586*x_13 - 1.19263982772827) + 0.0287866947444108*std::sin(0.239439979195595*x_13 + 1.98615980148315) + 0.109241153312943*std::sin(0.29911994934082*x_13 + 5.14871978759766) - 0.00757575719543299*std::sin(0.345359832048416*x_13 - 1.13367986679077) - 0.0329989565992319*std::sin(0.284159928560257*x_14 - 7.43120002746582) - 0.0128394217791721*std::sin(0.287439942359924*x_14 - 7.43151998519897) + 0.063307363931107*std::sin(0.302079945802689*x_14 - 7.43623971939087) - 0.0505089346906328*std::sin(0.28399994969368*x_15 + 1.96103990077972) - 0.0130350096955593*std::sin(0.284719944000244*x_15 - 7.41767978668213) - 0.00461062569774799*std::sin(0.287759929895401*x_15 - 1.19479990005493) - 0.0207327201220564*std::sin(0.291919946670532*x_15 - 7.41943979263306) + 0.00630311359273906*std::sin(0.273439943790436*x_16 - 4.2149600982666) - 0.0343202722041496*std::sin(0.356159836053848*x_16 - 1.16255986690521) - 0.00368046232721201*std::sin(0.36695984005928*x_16 - 1.16287982463837) + 0.0053531737991033*std::sin(0.397759824991226*x_16 + 8.19583988189697) + 0.00519071901520023*std::sin(0.262479960918427*x_17 + 2.02111983299255) - 0.011134364150583*std::sin(0.354879856109619*x_17 + 2.00903987884521) + 0.0524233070983769*std::sin(0.359759837388992*x_17 + 2.01855993270874) + 0.0159949958989739*std::sin(0.380319833755493*x_17 + 1.99399983882904) + 0.00548791391877985*std::sin(0.414399862289429*x_17 + 2.00135970115662) - 0.0137741904131628*std::sin(0.239199981093407*x_18 - 1.15639984607697) - 0.00594447267407129*std::sin(0.269679963588715*x_18 - 1.15063989162445) - 0.0190383587766552*std::sin(0.33943983912468*x_18 - 1.15423989295959) + 0.0135949294425361*std::sin(0.253679990768433*x_19 - 4.39103984832764) + 0.0165050743507729*std::sin(0.319279909133911*x_19 + 1.98567974567413) + 0.0924253367951763*std::sin(0.346559852361679*x_19 - 1.14703977108002) - 0.0184498319016507*std::sin(0.350719839334488*x_2 - 7.40903997421265) - 0.00420095291102291*std::sin(0.394639849662781*x_2 + 5.18232011795044) - 0.00453638894922277*std::sin(0.400079846382141*x_2 - 4.20695972442627) + 0.00594571591963138*std::sin(0.294239938259125*x_20 - 1.18247985839844) - 0.0146323914514568*std::sin(0.317519932985306*x_20 + 1.96199977397919) - 0.0563925688960506*std::sin(0.346479833126068*x_20 + 8.24399948120117) - 0.0245339473188321*std::sin(0.333359837532043*x_21 - 1.14887976646423) - 0.0983651634612684*std::sin(0.340559840202332*x_21 - 1.15839993953705) - 0.00391888134220319*std::sin(0.347039848566055*x_21 + 8.22983932495117) - 0.00700276933896833*std::sin(0.353439837694168*x_21 - 4.35775947570801) + 0.00171114060962804*std::sin(0.42647984623909*x_21 + 8.16991996765137) + 0.245589819919543*std::sin(0.162560015916824*x_22 - 4.43807983398438) - 0.0142757863004156*std::sin(0.244959965348244*x_22 - 1.18119990825653) - 0.00704054652918147*std::sin(0.285759925842285*x_22 + 8.23952007293701) - 0.00354397063786201*std::sin(0.300879925489426*x_22 - 1.15463984012604) - 0.00593883162395396*std::sin(0.298559933900833*x_23 - 1.15375983715057) + 0.0363432029955056*std::sin(0.329759836196899*x_23 + 1.98991978168488) + 0.0138508639277838*std::sin(0.341119825839996*x_23 - 1.17207992076874) + 0.0467725045980688*std::sin(0.38647985458374*x_23 - 1.19239985942841) + 0.00364988727074016*std::sin(0.231039986014366*x_24 - 4.39135980606079) - 0.0117912295751049*std::sin(0.330239832401276*x_24 - 1.1568797826767) + 0.00392498508792268*std::sin(0.278879970312119*x_25 - 1.15535986423492) + 0.044262434778377*std::sin(0.305199921131134*x_25 + 2.0020797252655) - 0.0114955409922526*std::sin(0.345759838819504*x_25 - 1.16223990917206) - 0.00514009832451342*std::sin(0.271199941635132*x_26 - 1.17207992076874) - 0.0157310559460638*std::sin(0.274639964103699*x_26 - 1.16543984413147) - 0.010772262418904*std::sin(0.343679845333099*x_26 + 8.24544048309326) - 0.0366895204824092*std::sin(0.38487982749939*x_26 - 1.1729599237442) - 0.0114746391222209*std::sin(0.154640033841133*x_27 + 4.97559976577759) - 0.00366450582859536*std::sin(0.42103984951973*x_27 - 1.207279920578) + 0.218729086632631*std::sin(0.0844800844788551*x_28 + 8.05719947814941) + 0.00665877511829284*std::sin(0.270879954099655*x_28 + 2.000159740448) + 0.00981790748243209*std::sin(0.308159917593002*x_28 + 1.98215973377228) + 0.00568007484997944*std::sin(0.371119856834412*x_28 - 1.17263984680176) - 0.00211543567635089*std::sin(0.25383996963501*x_29 + 1.80247986316681) + 0.00680155274064236*std::sin(0.31535992026329*x_29 + 1.98511981964111) + 0.0316473541753028*std::sin(0.328559845685959*x_29 - 1.16903984546661) - 0.1009017990371*std::sin(0.355519831180573*x_29 - 1.14223992824554) + 0.00289037964375864*std::sin(0.288959950208664*x_3 - 1.13039994239807) + 0.00757937100359313*std::sin(0.346479833126068*x_3 - 7.40783977508545) - 0.0167989708560077*std::sin(0.348239839076996*x_3 - 7.40471982955933) - 0.0139525839879164*std::sin(0.373999834060669*x_3 - 7.40743970870972) + 0.0459307053940997*std::sin(0.199120000004768*x_30 + 8.18671989440918) + 0.0113291836843128*std::sin(0.258879989385605*x_30 - 1.16759991645813) - 0.19901704988223*std::sin(0.268719971179962*x_30 - 1.17455983161926) + 0.00242422252463031*std::sin(0.329279839992523*x_30 - 1.15023982524872) + 0.0302293076255229*std::sin(0.375839829444885*x_31 - 7.39943981170654) - 0.0288382134417557*std::sin(0.376319825649261*x_31 + 5.16775989532471) - 0.00915025031034157*std::sin(0.380639851093292*x_31 - 7.40391969680786) - 0.051710362054419*std::sin(0.295279920101166*x_32 - 1.14495992660522) + 0.00794466577614714*std::sin(0.299279928207397*x_32 + 2.02359986305237) + 0.00489160833028137*std::sin(0.302399933338165*x_32 - 1.13367986679077) + 0.0179580708979587*std::sin(0.303839921951294*x_32 - 1.13895988464355) + 0.0138575112710248*std::sin(0.305679947137833*x_32 - 1.14007985591888) + 0.0169761643604303*std::sin(0.243359968066216*x_33 + 1.98735988140106) + 0.0110331202880267*std::sin(0.241119980812073*x_35 - 7.43616008758545) - 0.00355931968192681*std::sin(0.222559988498688*x_36 + 5.17360019683838) + 0.0163967429943265*std::sin(0.190160006284714*x_37 - 1.17119991779327) + 0.00971546566068586*std::sin(0.197759985923767*x_37 - 1.19143986701965) + 0.018990613859632*std::sin(0.235199987888336*x_38 + 1.97775971889496) - 0.0085403537390335*std::sin(0.265519946813583*x_4 + 2.03111982345581) + 0.0128367395385419*std::sin(0.312879920005798*x_4 + 2.01127982139587) - 0.0917854347839952*std::sin(0.328959852457047*x_4 + 1.99927973747253) + 0.00634231212286657*std::sin(0.231519982218742*x_40 + 1.96791982650757) + 0.00240556846046826*std::sin(0.251359969377518*x_42 - 7.43455982208252) - 0.0839340509636997*std::sin(0.135360047221184*x_44 - 1.19167983531952) - 0.00908106088928006*std::sin(0.157520025968552*x_45 - 4.39479970932007) + 0.00202416316668755*std::sin(0.174560010433197*x_45 - 4.58383989334106) - 0.00683191814853494*std::sin(0.140800043940544*x_46 - 1.20887982845306) - 0.00333480059276921*std::sin(0.235679984092712*x_46 - 1.21863985061646) - 0.118448864865483*std::sin(0.201440006494522*x_47 + 1.98727989196777) - 0.0046464263659336*std::sin(0.202799990773201*x_47 - 1.19279980659485) - 0.00217850359222924*std::sin(0.23039998114109*x_47 - 1.21311986446381) - 0.0201652748438073*std::sin(0.215759992599487*x_48 - 7.39559984207153) + 0.00376795644685978*std::sin(0.280879944562912*x_49 + 8.27223968505859) + 0.000836208365074245*std::sin(0.317999929189682*x_5 + 2.01639986038208) + 0.113867966202178*std::sin(0.340559840202332*x_5 + 2.0162398815155) + 0.00558635716205489*std::sin(0.346319854259491*x_5 - 7.37375974655151) + 0.0097849347718188*std::sin(0.366399854421616*x_5 - 1.16279983520508) - 0.0233001013528883*std::sin(0.187520012259483*x_51 - 1.1943199634552) - 0.0957136450664012*std::sin(0.205520004034042*x_51 - 7.40855979919434) + 0.00442911002251713*std::sin(0.213919997215271*x_51 - 1.18455994129181) + 0.00512715622797119*std::sin(0.23879998922348*x_52 - 7.41024017333984) - 0.0040703155089852*std::sin(0.227519989013672*x_53 - 1.20567989349365) + 0.00898896109279508*std::sin(0.23047998547554*x_53 + 1.99655985832214) - 0.0700104007134673*std::sin(0.257439970970154*x_53 - 7.42767953872681) - 0.0146943007637765*std::sin(0.236959978938103*x_57 + 5.15824031829834) + 0.0268509506861822*std::sin(0.326719850301743*x_6 - 1.13911986351013) - 0.00570802874008846*std::sin(0.357119828462601*x_6 + 2.00927972793579) + 0.0526471351107989*std::sin(0.3572798371315*x_6 + 1.99695980548859) - 0.0200132091616339*std::sin(0.358879864215851*x_6 + 2.01999974250793) + 0.00655713172801189*std::sin(0.385199844837189*x_6 + 1.99791979789734) - 0.0482860770673742*std::sin(0.164240017533302*x_60 + 1.97215986251831) + 0.00712732142579214*std::sin(0.329279839992523*x_60 - 4.29544019699097) - 0.0198304066448451*std::sin(0.369679838418961*x_60 + 5.03895950317383) - 0.00166046166429487*std::sin(0.399279862642288*x_60 - 4.38207960128784) + 0.00231393212646575*std::sin(0.455599844455719*x_60 - 1.2824798822403) - 0.0145137710248254*std::sin(0.178480014204979*x_61 - 4.41824007034302) - 0.00505348487067198*std::sin(0.326879858970642*x_7 + 2.02199983596802) + 0.00740199122778363*std::sin(0.332559853792191*x_7 + 2.04583978652954) - 0.0144659770211616*std::sin(0.348159849643707*x_7 + 2.00615978240967) + 0.189537999074785*std::sin(0.355439841747284*x_7 + 2.00423979759216) + 0.00220555962741023*std::sin(0.307679921388626*x_8 + 5.17511987686157) - 0.00170453898271195*std::sin(0.311919927597046*x_8 - 4.23727989196777) - 0.0163535354816712*std::sin(0.315839916467667*x_8 - 7.43063974380493) + 0.00547444315292813*std::sin(0.317199915647507*x_8 - 4.23792028427124) - 0.00157698410731088*std::sin(0.262799948453903*x_9 + 1.97775971889496) + 0.107232966419934*std::sin(0.316639930009842*x_9 - 7.43160009384155) - 0.00309824127585846*std::sin(0.326159834861755*x_9 + 8.27543926239014) + 0.00824446585546429*std::sin(0.345359832048416*x_91 - 7.39999961853027) + 0.100524995265913*std::sin(0.351599842309952*x_91 - 7.40375995635986) - 0.00404770645847562*std::sin(0.362559854984283*x_91 + 2.00079965591431) + 0.00246750491905784*std::sin(0.366399854421616*x_91 - 7.41015958786011) - 0.00311525402924989*std::sin(0.375439822673798*x_91 - 1.18063986301422) + 0.00511889782492367*std::sin(0.28399994969368*x_92 - 1.16303980350494) + 0.00401574382851049*std::sin(0.289679944515228*x_92 + 1.99175977706909) + 0.0222647558861151*std::sin(0.298319935798645*x_92 + 1.99519979953766) + 0.00692312431255449*std::sin(0.282799929380417*x_94 - 7.43056011199951) - 0.00280260695117935*std::sin(0.288399934768677*x_94 + 1.98655986785889) - 0.00970370025908699*std::sin(0.293759942054749*x_94 + 1.98631989955902) - 0.00339594701675037*std::sin(0.259359985589981*x_95 - 7.42392015457153) - 0.00635299893536415*std::sin(0.27703994512558*x_95 - 7.43056011199951) - 0.00620911168743175*std::sin(0.27143993973732*x_97 + 1.98071980476379) + 0.00322710518662588*std::sin(0.276159942150116*x_97 - 1.20687985420227) + 0.00185662397128379*std::sin(0.280559957027435*x_97 + 1.96655988693237) - 0.597222743178355);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0111118271097636*x_10 + 0.00011901498633535*x_100 + 0.000589209116190191*x_101 - 0.0363138652156867*x_102 + 0.0102016765555361*x_103 - 0.0305253297983909*x_104 + 0.00262283841466007*x_105 - 0.0021011626026859*x_106 - 0.0165083469530611*x_107 + 0.000888460656059937*x_108 - 0.029739750878412*x_109 + 0.000126003123562687*x_11 - 0.0123301758726339*x_110 + 0.023974618636045*x_111 - 0.00636730312823746*x_112 - 0.00669956069123275*x_113 - 0.0424471456138653*x_114 - 0.0116642798740284*x_115 + 0.00531689058306086*x_116 - 0.0438053034886378*x_117 + 0.00302157724719355*x_118 - 0.0655013086791432*x_119 + 0.00158429365712187*x_12 + 1.44024809032298e-5*x_13 + 0.0204073914967479*x_14 + 0.00198267519564214*x_15 - 0.000173599279584604*x_16 - 0.000970526922377349*x_18 - 0.001516577380259*x_19 + 0.000222531179884821*x_2 + 0.000999224275515086*x_20 + 0.00662007020719276*x_22 - 0.000259043661900416*x_23 - 0.00107303375361191*x_24 - 0.0338634407646977*x_25 + 8.63928192237997e-5*x_26 + 0.00572161318692944*x_27 + 0.00145951417821933*x_28 - 0.00109895998026896*x_29 - 7.26926489692318e-5*x_3 - 0.000331452375500327*x_30 + 0.00374939447786085*x_31 + 0.0182325991602554*x_33 - 0.00192690196083084*x_34 - 0.00917899092739701*x_35 - 0.00999749085989599*x_36 + 0.00591642655723644*x_37 + 0.00157862186430087*x_38 + 0.0131557702094831*x_39 + 0.000882437252315288*x_4 + 0.0360901238934826*x_40 + 0.0030114210965356*x_41 + 0.00293811363199279*x_42 + 0.00120862350855221*x_43 - 0.0219144635825313*x_44 - 0.0197939592404119*x_45 - 0.00247337552886368*x_46 + 0.0199258003580145*x_47 - 0.00147553922672211*x_48 + 0.0249895121518489*x_49 - 1.77165002798064e-5*x_5 - 0.00309808820012007*x_50 - 0.00667742606757521*x_51 + 0.0160006897523162*x_52 + 0.0204473568641621*x_53 - 0.00521419091244772*x_54 - 0.00643539777392458*x_55 - 0.000542719120580706*x_56 + 0.000700569624394627*x_57 + 0.0384949751601657*x_58 - 0.0308490788776451*x_59 - 0.0098150606222811*x_61 - 0.00211050746416411*x_62 + 0.00328659854848023*x_63 + 0.00814928781567258*x_64 + 0.0107116352708671*x_65 + 0.00678632198381506*x_66 + 0.0130348819781333*x_67 - 0.000919993902692848*x_68 + 0.0052870332903653*x_69 + 1.87530380315442e-5*x_7 - 0.00363357145977586*x_70 - 0.00589545349958068*x_71 - 0.00426937583900365*x_72 + 0.0015107059186921*x_73 - 0.00277974245741509*x_74 + 0.0177416751312994*x_75 + 0.00201059653735608*x_76 - 0.00597504159160377*x_77 + 0.00399826504186898*x_78 + 0.00442268260248226*x_79 + 0.000211326677160266*x_8 + 0.00103156829823637*x_80 - 0.00772372132102308*x_81 + 0.000460329736782744*x_82 - 0.012775859059462*x_83 + 0.0162028088946832*x_84 - 0.000644262481095768*x_85 + 0.00201344903600221*x_86 + 0.00176169513547451*x_87 - 0.0110360762328289*x_88 - 0.00553790585695652*x_89 - 0.00206545158751058*x_9 + 0.00182515779824017*x_90 + 0.0015331285134516*x_92 + 0.0336083905577557*x_93 - 0.00528284049698371*x_94 + 0.00143131218630749*x_95 - 0.0214494190341087*x_96 + 0.000719933518561695*x_97 - 0.00727684117034569*x_98 - 0.0100314237762724*x_99 - 2.77439738877626e-5*std::pow(-2.69463992118835*x_24 - 5.59167957305908, 2) + 0.0151762863364882*std::sin(0.323279827833176*x_1 - 4.26496028900146) - 0.68179774836944*std::sin(0.332239836454391*x_1 - 4.25663995742798) - 0.179090362192089*std::sin(0.333679854869843*x_1 - 4.25056028366089) - 0.0105681686867806*std::sin(0.335119843482971*x_1 - 4.24823999404907) + 0.0092335028572383*std::sin(0.357359826564789*x_1 - 4.24368000030518) + 0.0026148753022364*std::sin(0.353119850158691*x_10 - 1.14991986751556) - 0.00219318312562115*std::sin(0.224559992551804*x_101 + 1.99807977676392) + 0.0676017514284234*std::sin(0.239759981632233*x_101 + 1.97511982917786) - 0.00284584052945621*std::sin(0.23471999168396*x_102 + 1.95839977264404) + 0.00467883864456809*std::sin(0.215680003166199*x_103 + 1.97719979286194) - 0.253706467282753*std::sin(0.254959970712662*x_108 - 7.43815994262695) + 0.00946853047329519*std::sin(0.257999956607819*x_108 - 7.44407987594604) + 0.00967222695729671*std::sin(0.21399998664856*x_109 + 1.98639988899231) - 0.0790112959177867*std::sin(0.25639995932579*x_11 - 7.42575979232788) - 0.283375763281389*std::sin(0.257519960403442*x_11 - 7.41519975662231) + 0.00594688707358158*std::sin(0.273439943790436*x_11 - 7.41864013671875) - 0.00525383255247256*std::sin(0.216319993138313*x_110 - 7.4157600402832) + 0.00522173671517395*std::sin(0.217040002346039*x_110 - 7.41983985900879) - 0.022426183596829*std::sin(0.222240000963211*x_110 + 1.98479974269867) - 0.00731258426123832*std::sin(0.272479951381683*x_112 + 5.14752006530762) + 0.0272882429414973*std::sin(0.274239957332611*x_112 + 1.97527980804443) + 0.0387359134444078*std::sin(0.277439951896667*x_112 - 7.43711996078491) + 0.0353806912701592*std::sin(0.28399994969368*x_113 - 7.42224025726318) - 0.139197702429153*std::sin(0.234959989786148*x_116 - 1.19575989246368) - 0.0173845382304611*std::sin(0.252959966659546*x_116 + 5.15848016738892) - 0.00129365675002946*std::sin(0.271839946508408*x_116 + 8.16720008850098) - 0.06566165223484*std::sin(0.229839995503426*x_118 + 5.17456007003784) - 0.168864657362289*std::sin(0.232959985733032*x_118 + 5.16416025161743) - 0.00564769258544371*std::sin(0.270559966564178*x_12 + 5.16064023971558) - 0.0580028998722092*std::sin(0.290239930152893*x_12 - 7.44551992416382) - 0.332170865140103*std::sin(0.294479936361313*x_12 - 7.4488000869751) + 0.0110502509222821*std::sin(0.258399993181229*x_120 - 4.23375988006592) + 0.0428185896346809*std::sin(0.259839981794357*x_120 - 4.24735975265503) - 0.247754825106256*std::sin(0.26463994383812*x_120 + 5.15520000457764) + 0.0159135014646397*std::sin(0.269039958715439*x_120 + 5.15112018585205) - 0.014315657991802*std::sin(0.270479947328568*x_120 - 7.42575979232788) - 0.24737070794348*std::sin(0.228479996323586*x_13 - 1.19263982772827) + 0.00784483948933763*std::sin(0.239439979195595*x_13 + 1.98615980148315) - 0.0106646560424677*std::sin(0.29911994934082*x_13 + 5.14871978759766) - 0.048309567916942*std::sin(0.345359832048416*x_13 - 1.13367986679077) - 0.00899274891178175*std::sin(0.284159928560257*x_14 - 7.43120002746582) - 0.0818752373464534*std::sin(0.287439942359924*x_14 - 7.43151998519897) - 0.00618037471049462*std::sin(0.302079945802689*x_14 - 7.43623971939087) + 0.00493092940902922*std::sin(0.28399994969368*x_15 + 1.96103990077972) - 0.00355225077806047*std::sin(0.284719944000244*x_15 - 7.41767978668213) - 0.0294013297336445*std::sin(0.287759929895401*x_15 - 1.19479990005493) + 0.370722619699496*std::sin(0.291919946670532*x_15 - 7.41943979263306) + 0.0246154016579242*std::sin(0.273439943790436*x_16 - 4.2149600982666) + 0.00335051294536042*std::sin(0.356159836053848*x_16 - 1.16255986690521) + 0.0658104979769537*std::sin(0.36695984005928*x_16 - 1.16287982463837) + 0.00145882636354585*std::sin(0.397759824991226*x_16 + 8.19583988189697) + 0.0202711932083481*std::sin(0.262479960918427*x_17 + 2.02111983299255) - 0.0710023179555997*std::sin(0.354879856109619*x_17 + 2.00903987884521) - 0.00511781981293493*std::sin(0.359759837388992*x_17 + 2.01855993270874) + 0.00435889484965712*std::sin(0.380319833755493*x_17 + 1.99399983882904) - 0.0981296140920267*std::sin(0.414399862289429*x_17 + 2.00135970115662) - 0.00375368946821572*std::sin(0.239199981093407*x_18 - 1.15639984607697) - 0.0232148096910995*std::sin(0.269679963588715*x_18 - 1.15063989162445) + 0.340425674919131*std::sin(0.33943983912468*x_18 - 1.15423989295959) + 0.0530919590477735*std::sin(0.253679990768433*x_19 - 4.39103984832764) - 0.295127912094082*std::sin(0.319279909133911*x_19 + 1.98567974567413) - 0.00902301373280172*std::sin(0.346559852361679*x_19 - 1.14703977108002) + 0.00180116288875851*std::sin(0.350719839334488*x_2 - 7.40903997421265) + 0.0751174114751983*std::sin(0.394639849662781*x_2 + 5.18232011795044) - 0.0012362392933203*std::sin(0.400079846382141*x_2 - 4.20695972442627) - 0.106315590464649*std::sin(0.294239938259125*x_20 - 1.18247985839844) - 0.00398756311903861*std::sin(0.317519932985306*x_20 + 1.96199977397919) + 0.00550531857627581*std::sin(0.346479833126068*x_20 + 8.24399948120117) - 0.0066858970946455*std::sin(0.333359837532043*x_21 - 1.14887976646423) + 0.0096028886830806*std::sin(0.340559840202332*x_21 - 1.15839993953705) - 0.0153043153782284*std::sin(0.347039848566055*x_21 + 8.22983932495117) + 0.125216806053915*std::sin(0.353439837694168*x_21 - 4.35775947570801) + 0.0109117097293057*std::sin(0.42647984623909*x_21 + 8.16991996765137) - 0.0239756802042402*std::sin(0.162560015916824*x_22 - 4.43807983398438) + 0.255265920940591*std::sin(0.244959965348244*x_22 - 1.18119990825653) - 0.00191866269917513*std::sin(0.285759925842285*x_22 + 8.23952007293701) - 0.0138401853990631*std::sin(0.300879925489426*x_22 - 1.15463984012604) - 0.0231927798304017*std::sin(0.298559933900833*x_23 - 1.15375983715057) - 0.649854304859445*std::sin(0.329759836196899*x_23 + 1.98991978168488) + 0.00377458423993668*std::sin(0.341119825839996*x_23 - 1.17207992076874) - 0.00456616081628315*std::sin(0.38647985458374*x_23 - 1.19239985942841) + 0.0232748321318033*std::sin(0.231039986014366*x_24 - 4.39135980606079) + 0.210839460130015*std::sin(0.330239832401276*x_24 - 1.1568797826767) + 0.0250290933020258*std::sin(0.278879970312119*x_25 - 1.15535986423492) - 0.00432111551551718*std::sin(0.305199921131134*x_25 + 2.0020797252655) - 0.00313272067974501*std::sin(0.345759838819504*x_25 - 1.16223990917206) - 0.032777704287769*std::sin(0.271199941635132*x_26 - 1.17207992076874) - 0.00428696694741663*std::sin(0.274639964103699*x_26 - 1.16543984413147) + 0.192619266575544*std::sin(0.343679845333099*x_26 + 8.24544048309326) + 0.00358181055803267*std::sin(0.38487982749939*x_26 - 1.1729599237442) - 0.00312702458240277*std::sin(0.154640033841133*x_27 + 4.97559976577759) - 0.0233680526766723*std::sin(0.42103984951973*x_27 - 1.207279920578) - 0.0213534039570025*std::sin(0.0844800844788551*x_28 + 8.05719947814941) - 0.119065831271082*std::sin(0.270879954099655*x_28 + 2.000159740448) + 0.0626074537619468*std::sin(0.308159917593002*x_28 + 1.98215973377228) + 0.00154791218238641*std::sin(0.371119856834412*x_28 - 1.17263984680176) - 0.00826136132384872*std::sin(0.25383996963501*x_29 + 1.80247986316681) + 0.0433725719539703*std::sin(0.31535992026329*x_29 + 1.98511981964111) + 0.00862441541037544*std::sin(0.328559845685959*x_29 - 1.16903984546661) + 0.00985052746298099*std::sin(0.355519831180573*x_29 - 1.14223992824554) + 0.000787675159300389*std::sin(0.288959950208664*x_3 - 1.13039994239807) + 0.0483326126775181*std::sin(0.346479833126068*x_3 - 7.40783977508545) - 0.0656046268207419*std::sin(0.348239839076996*x_3 - 7.40471982955933) + 0.249486727121484*std::sin(0.373999834060669*x_3 - 7.40743970870972) - 0.821288828870638*std::sin(0.199120000004768*x_30 + 8.18671989440918) + 0.0722446554874758*std::sin(0.258879989385605*x_30 - 1.16759991645813) + 0.0194290184533335*std::sin(0.268719971179962*x_30 - 1.17455983161926) + 0.00946725935904178*std::sin(0.329279839992523*x_30 - 1.15023982524872) + 0.00823797481098733*std::sin(0.375839829444885*x_31 - 7.39943981170654) + 0.00281532753828179*std::sin(0.376319825649261*x_31 + 5.16775989532471) - 0.0583498952541603*std::sin(0.380639851093292*x_31 - 7.40391969680786) + 0.00504821862839588*std::sin(0.295279920101166*x_32 - 1.14495992660522) - 0.142058894917358*std::sin(0.299279928207397*x_32 + 2.02359986305237) + 0.0191030832669477*std::sin(0.302399933338165*x_32 - 1.13367986679077) + 0.0048938645087062*std::sin(0.303839921951294*x_32 - 1.13895988464355) + 0.0883674548480696*std::sin(0.305679947137833*x_32 - 1.14007985591888) + 0.00462627911035347*std::sin(0.243359968066216*x_33 + 1.98735988140106) + 0.00300670356547028*std::sin(0.241119980812073*x_35 - 7.43616008758545) - 0.0139001276607979*std::sin(0.222559988498688*x_36 + 5.17360019683838) - 0.00160073030124733*std::sin(0.190160006284714*x_37 - 1.17119991779327) + 0.00264762138720529*std::sin(0.197759985923767*x_37 - 1.19143986701965) - 0.339571946097637*std::sin(0.235199987888336*x_38 + 1.97775971889496) - 0.054460668200833*std::sin(0.265519946813583*x_4 + 2.03111982345581) - 0.229534266710409*std::sin(0.312879920005798*x_4 + 2.01127982139587) + 0.00896054336661491*std::sin(0.328959852457047*x_4 + 1.99927973747253) + 0.0247684827581285*std::sin(0.231519982218742*x_40 + 1.96791982650757) + 0.00939441007984893*std::sin(0.251359969377518*x_42 - 7.43455982208252) + 0.0081940528512596*std::sin(0.135360047221184*x_44 - 1.19167983531952) - 0.00247473583548996*std::sin(0.157520025968552*x_45 - 4.39479970932007) + 0.0129078117808494*std::sin(0.174560010433197*x_45 - 4.58383989334106) - 0.026680529685198*std::sin(0.140800043940544*x_46 - 1.20887982845306) - 0.0212655674634033*std::sin(0.235679984092712*x_46 - 1.21863985061646) + 0.0115635579092832*std::sin(0.201440006494522*x_47 + 1.98727989196777) - 0.0181455798929562*std::sin(0.202799990773201*x_47 - 1.19279980659485) - 0.0138920195739042*std::sin(0.23039998114109*x_47 - 1.21311986446381) + 0.360576107382242*std::sin(0.215759992599487*x_48 - 7.39559984207153) + 0.0147149119247768*std::sin(0.280879944562912*x_49 + 8.27223968505859) + 0.00326562491269873*std::sin(0.317999929189682*x_5 + 2.01639986038208) - 0.0111163481616014*std::sin(0.340559840202332*x_5 + 2.0162398815155) + 0.0356234358845713*std::sin(0.346319854259491*x_5 - 7.37375974655151) - 0.174964820382554*std::sin(0.366399854421616*x_5 - 1.16279983520508) - 0.00634965413089661*std::sin(0.187520012259483*x_51 - 1.1943199634552) + 0.00934403448011803*std::sin(0.205520004034042*x_51 - 7.40855979919434) - 0.0791970981529838*std::sin(0.213919997215271*x_51 - 1.18455994129181) + 0.0326951743074958*std::sin(0.23879998922348*x_52 - 7.41024017333984) - 0.00110922674945689*std::sin(0.227519989013672*x_53 - 1.20567989349365) + 0.0351043788964069*std::sin(0.23047998547554*x_53 + 1.99655985832214) + 0.00683475796768247*std::sin(0.257439970970154*x_53 - 7.42767953872681) + 0.262749395242364*std::sin(0.236959978938103*x_57 + 5.15824031829834) - 0.480122951605064*std::sin(0.326719850301743*x_6 - 1.13911986351013) - 0.0363993189033826*std::sin(0.357119828462601*x_6 + 2.00927972793579) - 0.00513967099898302*std::sin(0.3572798371315*x_6 + 1.99695980548859) - 0.00545392289505701*std::sin(0.358879864215851*x_6 + 2.01999974250793) + 0.0256074127229541*std::sin(0.385199844837189*x_6 + 1.99791979789734) - 0.013158736267799*std::sin(0.164240017533302*x_60 + 1.97215986251831) - 0.127443927031989*std::sin(0.329279839992523*x_60 - 4.29544019699097) + 0.00193594135209923*std::sin(0.369679838418961*x_60 + 5.03895950317383) - 0.00648456198715627*std::sin(0.399279862642288*x_60 - 4.38207960128784) + 0.0147556288216418*std::sin(0.455599844455719*x_60 - 1.2824798822403) - 0.00395523713596405*std::sin(0.178480014204979*x_61 - 4.41824007034302) - 0.0322253821339655*std::sin(0.326879858970642*x_7 + 2.02199983596802) + 0.0289068227090523*std::sin(0.332559853792191*x_7 + 2.04583978652954) + 0.258666729026669*std::sin(0.348159849643707*x_7 + 2.00615978240967) - 0.0185036271204457*std::sin(0.355439841747284*x_7 + 2.00423979759216) + 0.00861332027583085*std::sin(0.307679921388626*x_8 + 5.17511987686157) - 0.010869612057002*std::sin(0.311919927597046*x_8 - 4.23727989196777) - 0.00445660267967399*std::sin(0.315839916467667*x_8 - 7.43063974380493) - 0.09788874277478*std::sin(0.317199915647507*x_8 - 4.23792028427124) - 0.00615855904204824*std::sin(0.262799948453903*x_9 + 1.97775971889496) - 0.0104686070093567*std::sin(0.316639930009842*x_9 - 7.43160009384155) - 0.0197570610406294*std::sin(0.326159834861755*x_9 + 8.27543926239014) + 0.00224675017002428*std::sin(0.345359832048416*x_91 - 7.39999961853027) - 0.00981374203465715*std::sin(0.351599842309952*x_91 - 7.40375995635986) - 0.0258116707042109*std::sin(0.362559854984283*x_91 + 2.00079965591431) + 0.00963628907869931*std::sin(0.366399854421616*x_91 - 7.41015958786011) + 0.0557039851960526*std::sin(0.375439822673798*x_91 - 1.18063986301422) - 0.0915312221675586*std::sin(0.28399994969368*x_92 - 1.16303980350494) + 0.0156825901738446*std::sin(0.289679944515228*x_92 + 1.99175977706909) + 0.00606750576079148*std::sin(0.298319935798645*x_92 + 1.99519979953766) + 0.0441478172474175*std::sin(0.282799929380417*x_94 - 7.43056011199951) - 0.0109449551840603*std::sin(0.288399934768677*x_94 + 1.98655986785889) - 0.0026444151251495*std::sin(0.293759942054749*x_94 + 1.98631989955902) - 0.0132621122238119*std::sin(0.259359985589981*x_95 - 7.42392015457153) + 0.113598234790269*std::sin(0.27703994512558*x_95 - 7.43056011199951) + 0.111025381002594*std::sin(0.27143993973732*x_97 + 1.98071980476379) + 0.0126027381852477*std::sin(0.276159942150116*x_97 - 1.20687985420227) + 0.0118394372368518*std::sin(0.280559957027435*x_97 + 1.96655988693237) + 2.29319753670249);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00725830760682266*x_10 - 0.0066646677916643*x_100 + 0.0023788661477753*x_101 + 0.0149271540862867*x_102 - 0.00682058727855987*x_103 - 0.00900134983419742*x_104 - 0.0027432017872742*x_105 + 0.00857591420185383*x_106 + 0.00690995120653719*x_107 + 0.00848378471569262*x_108 + 0.0106276553756346*x_109 + 0.00358628765563281*x_11 - 0.0186237335612038*x_110 - 0.0205728418327714*x_111 - 0.00652042702526526*x_112 - 0.0133723447883138*x_113 + 0.00961779700742865*x_114 - 0.00154137609995271*x_115 + 0.00831070860643619*x_116 - 0.00596904994170263*x_117 - 0.00938055212576411*x_118 - 0.000689311259673125*x_119 + 0.0111920011905293*x_12 + 1.84843061849455e-5*x_13 - 0.00527987394263767*x_14 + 0.00254458767401161*x_15 - 0.000267573381215909*x_16 - 0.00276742834303395*x_18 - 0.00656473553591756*x_19 + 0.000653611256267617*x_2 + 0.00151523495629523*x_20 + 0.0102036976965794*x_22 - 0.000399271175912139*x_23 - 0.00418165387792684*x_24 + 0.0125515647999438*x_25 + 0.000110877517105768*x_26 - 0.0081099413023684*x_27 + 0.00187315693266604*x_28 + 0.000314521506634777*x_29 - 0.000405229491181156*x_3 + 0.00257615998422742*x_30 - 0.00117260722779771*x_31 + 0.00388193329032587*x_33 + 0.0248010618415044*x_34 - 0.0034606135867644*x_35 - 0.0118687232700304*x_36 - 0.00594871977773166*x_37 + 0.00180052392317402*x_38 + 0.00989937082812634*x_39 + 5.33096373904365e-6*x_4 + 0.000316726117039325*x_40 - 0.00817927665085496*x_41 + 0.00722025354973043*x_42 - 0.00668939182248996*x_43 - 0.00891661479044157*x_44 - 0.00124877537889158*x_45 - 0.0041010706084353*x_46 - 0.0093454632823958*x_47 + 0.00163846701682343*x_48 - 0.00846423268544817*x_49 + 0.000137698633212379*x_5 - 0.0114103341464571*x_50 - 0.010822563168174*x_51 + 0.0026118905022624*x_52 + 0.00871825452153312*x_53 - 0.0064595953128621*x_54 + 0.0116807154869958*x_55 + 0.00181429765670786*x_56 + 0.00238857659390229*x_57 - 0.00261300084964805*x_58 - 0.0053172331033858*x_59 + 0.00415245751256813*x_61 - 0.00596986757631884*x_62 + 0.0100144975933843*x_63 + 0.000652305930170084*x_64 + 0.00800384756408634*x_65 + 0.000374035411003686*x_66 + 0.000198688265655794*x_67 + 0.000536065304405443*x_68 - 0.003464884480714*x_69 - 0.000145754955253026*x_7 + 0.00141572822066821*x_70 - 0.000407545859921672*x_71 - 0.00214022653885734*x_72 - 0.000227034131924875*x_73 + 0.00287884848629505*x_74 - 0.00854628005150215*x_75 + 0.00252425453008343*x_76 + 0.00124786184553171*x_77 + 0.00260026591363007*x_78 + 0.0050547760705582*x_79 + 0.00117805311916622*x_8 - 4.53382497647768e-6*x_80 + 0.000223931656635433*x_81 + 0.00518841614708104*x_82 + 0.00425771190254134*x_83 + 0.0104630881688289*x_84 + 0.00144779264081341*x_85 + 0.00163216739661379*x_86 - 0.00407281913641323*x_87 - 0.000270012710546959*x_88 + 0.00515139358592634*x_89 - 0.000407004019702089*x_9 - 0.00419029353665569*x_90 + 0.00368530448437783*x_92 - 0.00664877064155812*x_93 + 0.00423162260248116*x_94 - 9.78029579618814e-6*x_95 - 0.00134816069435249*x_96 + 0.00309579463783859*x_97 + 0.00322679832068932*x_98 - 0.00420748309862152*x_99 - 3.56069285267049e-5*std::pow(-2.69463992118835*x_24 - 5.59167957305908, 2) + 0.084601109979603*std::sin(0.323279827833176*x_1 - 4.26496028900146) + 0.195129994619887*std::sin(0.332239836454391*x_1 - 4.25663995742798) - 0.276036939033293*std::sin(0.333679854869843*x_1 - 4.25056028366089) + 0.0821393819741159*std::sin(0.335119843482971*x_1 - 4.24823999404907) + 0.0118503815502014*std::sin(0.357359826564789*x_1 - 4.24368000030518) - 0.0203236953942404*std::sin(0.353119850158691*x_10 - 1.14991986751556) - 0.0122260296558835*std::sin(0.224559992551804*x_101 + 1.99807977676392) + 0.104196453171369*std::sin(0.239759981632233*x_101 + 1.97511982917786) + 0.0221188352698062*std::sin(0.23471999168396*x_102 + 1.95839977264404) + 0.0060048742072456*std::sin(0.215680003166199*x_103 + 1.97719979286194) + 0.0726105970785474*std::sin(0.254959970712662*x_108 - 7.43815994262695) + 0.0527828857571377*std::sin(0.257999956607819*x_108 - 7.44407987594604) + 0.0124134450009139*std::sin(0.21399998664856*x_109 + 1.98639988899231) - 0.121782300327287*std::sin(0.25639995932579*x_11 - 7.42575979232788) + 0.0811019269229703*std::sin(0.257519960403442*x_11 - 7.41519975662231) - 0.0462212180152714*std::sin(0.273439943790436*x_11 - 7.41864013671875) - 0.0292878017540753*std::sin(0.216319993138313*x_110 - 7.4157600402832) - 0.0405851041299567*std::sin(0.217040002346039*x_110 - 7.41983985900879) - 0.028782016580951*std::sin(0.222240000963211*x_110 + 1.98479974269867) - 0.0407644354885895*std::sin(0.272479951381683*x_112 + 5.14752006530762) + 0.0350220382980477*std::sin(0.274239957332611*x_112 + 1.97527980804443) + 0.0597047370219972*std::sin(0.277439951896667*x_112 - 7.43711996078491) + 0.0545332400892767*std::sin(0.28399994969368*x_113 - 7.42224025726318) + 0.0398382760738945*std::sin(0.234959989786148*x_116 - 1.19575989246368) - 0.0223115121411946*std::sin(0.252959966659546*x_116 + 5.15848016738892) - 0.00721156642399139*std::sin(0.271839946508408*x_116 + 8.16720008850098) - 0.10120612451123*std::sin(0.229839995503426*x_118 + 5.17456007003784) + 0.0483289359071599*std::sin(0.232959985733032*x_118 + 5.16416025161743) - 0.0314833979116049*std::sin(0.270559966564178*x_12 + 5.16064023971558) - 0.089401477219674*std::sin(0.290239930152893*x_12 - 7.44551992416382) + 0.0950670477904689*std::sin(0.294479936361313*x_12 - 7.4488000869751) + 0.0616002803881287*std::sin(0.258399993181229*x_120 - 4.23375988006592) + 0.0659974789922119*std::sin(0.259839981794357*x_120 - 4.24735975265503) + 0.0709072416352994*std::sin(0.26463994383812*x_120 + 5.15520000457764) - 0.12368511651264*std::sin(0.269039958715439*x_120 + 5.15112018585205) - 0.0183728766826616*std::sin(0.270479947328568*x_120 - 7.42575979232788) + 0.0707973075968177*std::sin(0.228479996323586*x_13 - 1.19263982772827) - 0.0609727462191587*std::sin(0.239439979195595*x_13 + 1.98615980148315) - 0.0594507588179984*std::sin(0.29911994934082*x_13 + 5.14871978759766) - 0.0744608760102375*std::sin(0.345359832048416*x_13 - 1.13367986679077) + 0.069894686558715*std::sin(0.284159928560257*x_14 - 7.43120002746582) - 0.126196572630181*std::sin(0.287439942359924*x_14 - 7.43151998519897) - 0.0344528660704423*std::sin(0.302079945802689*x_14 - 7.43623971939087) + 0.0274877589935793*std::sin(0.28399994969368*x_15 + 1.96103990077972) + 0.0276092946824305*std::sin(0.284719944000244*x_15 - 7.41767978668213) - 0.0453170844251175*std::sin(0.287759929895401*x_15 - 1.19479990005493) - 0.10610053048787*std::sin(0.291919946670532*x_15 - 7.41943979263306) + 0.0315916836944704*std::sin(0.273439943790436*x_16 - 4.2149600982666) + 0.0186776335062292*std::sin(0.356159836053848*x_16 - 1.16255986690521) - 0.0188349142350302*std::sin(0.36695984005928*x_16 - 1.16287982463837) - 0.011338491981027*std::sin(0.397759824991226*x_16 + 8.19583988189697) + 0.0260162776479201*std::sin(0.262479960918427*x_17 + 2.02111983299255) - 0.109437840612051*std::sin(0.354879856109619*x_17 + 2.00903987884521) - 0.0285295906554494*std::sin(0.359759837388992*x_17 + 2.01855993270874) - 0.0338788052738835*std::sin(0.380319833755493*x_17 + 1.99399983882904) + 0.0280846205720428*std::sin(0.414399862289429*x_17 + 2.00135970115662) + 0.0291749443238602*std::sin(0.239199981093407*x_18 - 1.15639984607697) - 0.0297941481914615*std::sin(0.269679963588715*x_18 - 1.15063989162445) - 0.0974295680417049*std::sin(0.33943983912468*x_18 - 1.15423989295959) + 0.0681388181377528*std::sin(0.253679990768433*x_19 - 4.39103984832764) + 0.0844653829333153*std::sin(0.319279909133911*x_19 + 1.98567974567413) - 0.0502993262140088*std::sin(0.346559852361679*x_19 - 1.14703977108002) + 0.0100406895510841*std::sin(0.350719839334488*x_2 - 7.40903997421265) - 0.0214985457667908*std::sin(0.394639849662781*x_2 + 5.18232011795044) + 0.00960846997573627*std::sin(0.400079846382141*x_2 - 4.20695972442627) + 0.0304274407549613*std::sin(0.294239938259125*x_20 - 1.18247985839844) + 0.0309926894515144*std::sin(0.317519932985306*x_20 + 1.96199977397919) + 0.0306897255374292*std::sin(0.346479833126068*x_20 + 8.24399948120117) + 0.0519650538871192*std::sin(0.333359837532043*x_21 - 1.14887976646423) + 0.0535318735813454*std::sin(0.340559840202332*x_21 - 1.15839993953705) - 0.0196417307061802*std::sin(0.347039848566055*x_21 + 8.22983932495117) - 0.035836954214141*std::sin(0.353439837694168*x_21 - 4.35775947570801) + 0.0168185206419242*std::sin(0.42647984623909*x_21 + 8.16991996765137) - 0.133653853968077*std::sin(0.162560015916824*x_22 - 4.43807983398438) - 0.073056911523838*std::sin(0.244959965348244*x_22 - 1.18119990825653) + 0.0149124955323782*std::sin(0.285759925842285*x_22 + 8.23952007293701) - 0.0177626498025993*std::sin(0.300879925489426*x_22 - 1.15463984012604) - 0.0297658748201523*std::sin(0.298559933900833*x_23 - 1.15375983715057) + 0.185987805495396*std::sin(0.329759836196899*x_23 + 1.98991978168488) - 0.029337345557841*std::sin(0.341119825839996*x_23 - 1.17207992076874) - 0.0254543347982398*std::sin(0.38647985458374*x_23 - 1.19239985942841) + 0.0358741438653505*std::sin(0.231039986014366*x_24 - 4.39135980606079) - 0.0603420923862261*std::sin(0.330239832401276*x_24 - 1.1568797826767) + 0.0385780352292743*std::sin(0.278879970312119*x_25 - 1.15535986423492) - 0.0240883152081743*std::sin(0.305199921131134*x_25 + 2.0020797252655) + 0.0243485648420488*std::sin(0.345759838819504*x_25 - 1.16223990917206) - 0.0505211841072142*std::sin(0.271199941635132*x_26 - 1.17207992076874) + 0.0333197572863056*std::sin(0.274639964103699*x_26 - 1.16543984413147) - 0.0551274869130343*std::sin(0.343679845333099*x_26 + 8.24544048309326) + 0.0199670157921088*std::sin(0.38487982749939*x_26 - 1.1729599237442) + 0.0243042928466613*std::sin(0.154640033841133*x_27 + 4.97559976577759) - 0.0360178272749192*std::sin(0.42103984951973*x_27 - 1.207279920578) - 0.119035819208409*std::sin(0.0844800844788551*x_28 + 8.05719947814941) + 0.0340765499312701*std::sin(0.270879954099655*x_28 + 2.000159740448) + 0.0964986037527799*std::sin(0.308159917593002*x_28 + 1.98215973377228) - 0.0120308971005039*std::sin(0.371119856834412*x_28 - 1.17263984680176) - 0.0106027241584637*std::sin(0.25383996963501*x_29 + 1.80247986316681) + 0.066851347295472*std::sin(0.31535992026329*x_29 + 1.98511981964111) - 0.0670318739880072*std::sin(0.328559845685959*x_29 - 1.16903984546661) + 0.0549123506749539*std::sin(0.355519831180573*x_29 - 1.14223992824554) - 0.00612207778838992*std::sin(0.288959950208664*x_3 - 1.13039994239807) + 0.0744963955384371*std::sin(0.346479833126068*x_3 - 7.40783977508545) - 0.0841977168691637*std::sin(0.348239839076996*x_3 - 7.40471982955933) - 0.0714029106687067*std::sin(0.373999834060669*x_3 - 7.40743970870972) + 0.23505223527383*std::sin(0.199120000004768*x_30 + 8.18671989440918) + 0.111352689883379*std::sin(0.258879989385605*x_30 - 1.16759991645813) + 0.108308217868441*std::sin(0.268719971179962*x_30 - 1.17455983161926) + 0.0121503872770681*std::sin(0.329279839992523*x_30 - 1.15023982524872) - 0.0640283269266179*std::sin(0.375839829444885*x_31 - 7.39943981170654) + 0.0156942106529796*std::sin(0.376319825649261*x_31 + 5.16775989532471) - 0.0899363108194282*std::sin(0.380639851093292*x_31 - 7.40391969680786) + 0.0281415947164336*std::sin(0.295279920101166*x_32 - 1.14495992660522) + 0.0406571471777738*std::sin(0.299279928207397*x_32 + 2.02359986305237) + 0.0245171121944403*std::sin(0.302399933338165*x_32 - 1.13367986679077) - 0.0380367704305299*std::sin(0.303839921951294*x_32 - 1.13895988464355) + 0.136203207408005*std::sin(0.305679947137833*x_32 - 1.14007985591888) - 0.0359570061972542*std::sin(0.243359968066216*x_33 + 1.98735988140106) - 0.0233691172015475*std::sin(0.241119980812073*x_35 - 7.43616008758545) - 0.0178395803763503*std::sin(0.222559988498688*x_36 + 5.17360019683838) - 0.00892336618200928*std::sin(0.190160006284714*x_37 - 1.17119991779327) - 0.0205782090437794*std::sin(0.197759985923767*x_37 - 1.19143986701965) + 0.0971852315053297*std::sin(0.235199987888336*x_38 + 1.97775971889496) - 0.083941737365752*std::sin(0.265519946813583*x_4 + 2.03111982345581) + 0.0656925317447843*std::sin(0.312879920005798*x_4 + 2.01127982139587) + 0.0499510814456211*std::sin(0.328959852457047*x_4 + 1.99927973747253) + 0.0317881497023975*std::sin(0.231519982218742*x_40 + 1.96791982650757) + 0.0120568916917588*std::sin(0.251359969377518*x_42 - 7.43455982208252) + 0.0456782345217996*std::sin(0.135360047221184*x_44 - 1.19167983531952) + 0.0192344840530991*std::sin(0.157520025968552*x_45 - 4.39479970932007) + 0.0198951680592499*std::sin(0.174560010433197*x_45 - 4.58383989334106) - 0.0342420922611418*std::sin(0.140800043940544*x_46 - 1.20887982845306) - 0.0327772085418404*std::sin(0.235679984092712*x_46 - 1.21863985061646) + 0.0644617406886086*std::sin(0.201440006494522*x_47 + 1.98727989196777) - 0.023288241581322*std::sin(0.202799990773201*x_47 - 1.19279980659485) - 0.0214121548096378*std::sin(0.23039998114109*x_47 - 1.21311986446381) - 0.103196606415649*std::sin(0.215759992599487*x_48 - 7.39559984207153) + 0.0188852836764452*std::sin(0.280879944562912*x_49 + 8.27223968505859) + 0.00419113978883824*std::sin(0.317999929189682*x_5 + 2.01639986038208) - 0.0619687433763075*std::sin(0.340559840202332*x_5 + 2.0162398815155) + 0.0549073890915398*std::sin(0.346319854259491*x_5 - 7.37375974655151) + 0.0500747979024091*std::sin(0.366399854421616*x_5 - 1.16279983520508) + 0.0493516598304907*std::sin(0.187520012259483*x_51 - 1.1943199634552) + 0.0520888754454399*std::sin(0.205520004034042*x_51 - 7.40855979919434) + 0.0226661489766737*std::sin(0.213919997215271*x_51 - 1.18455994129181) + 0.0503939783611637*std::sin(0.23879998922348*x_52 - 7.41024017333984) + 0.00862128551974334*std::sin(0.227519989013672*x_53 - 1.20567989349365) + 0.0450533552041031*std::sin(0.23047998547554*x_53 + 1.99655985832214) + 0.0381007644220341*std::sin(0.257439970970154*x_53 - 7.42767953872681) - 0.0751986761508631*std::sin(0.236959978938103*x_57 + 5.15824031829834) + 0.137410821886164*std::sin(0.326719850301743*x_6 - 1.13911986351013) - 0.0561032790933193*std::sin(0.357119828462601*x_6 + 2.00927972793579) - 0.0286514013905035*std::sin(0.3572798371315*x_6 + 1.99695980548859) + 0.0423897336626384*std::sin(0.358879864215851*x_6 + 2.01999974250793) + 0.0328648418668763*std::sin(0.385199844837189*x_6 + 1.99791979789734) + 0.102274149536372*std::sin(0.164240017533302*x_60 + 1.97215986251831) + 0.0364743545363167*std::sin(0.329279839992523*x_60 - 4.29544019699097) + 0.0107920201037079*std::sin(0.369679838418961*x_60 + 5.03895950317383) - 0.00832235988030197*std::sin(0.399279862642288*x_60 - 4.38207960128784) + 0.0227432596795394*std::sin(0.455599844455719*x_60 - 1.2824798822403) + 0.0307414409760078*std::sin(0.178480014204979*x_61 - 4.41824007034302) - 0.0496698746630318*std::sin(0.326879858970642*x_7 + 2.02199983596802) + 0.0370993417993864*std::sin(0.332559853792191*x_7 + 2.04583978652954) - 0.0740302201995071*std::sin(0.348159849643707*x_7 + 2.00615978240967) - 0.103149568895168*std::sin(0.355439841747284*x_7 + 2.00423979759216) + 0.0110544322410282*std::sin(0.307679921388626*x_8 + 5.17511987686157) - 0.0167536343327958*std::sin(0.311919927597046*x_8 - 4.23727989196777) + 0.034638223580828*std::sin(0.315839916467667*x_8 - 7.43063974380493) + 0.0280156833850971*std::sin(0.317199915647507*x_8 - 4.23792028427124) - 0.0079039640292636*std::sin(0.262799948453903*x_9 + 1.97775971889496) - 0.0583578718334044*std::sin(0.316639930009842*x_9 - 7.43160009384155) - 0.0304521057816599*std::sin(0.326159834861755*x_9 + 8.27543926239014) - 0.0174625023393957*std::sin(0.345359832048416*x_91 - 7.39999961853027) - 0.0547072881189195*std::sin(0.351599842309952*x_91 - 7.40375995635986) - 0.0397842434696938*std::sin(0.362559854984283*x_91 + 2.00079965591431) + 0.0123673219228071*std::sin(0.366399854421616*x_91 - 7.41015958786011) - 0.0159424379995492*std::sin(0.375439822673798*x_91 - 1.18063986301422) + 0.0261961658451085*std::sin(0.28399994969368*x_92 - 1.16303980350494) + 0.020127212838821*std::sin(0.289679944515228*x_92 + 1.99175977706909) - 0.0471587072544755*std::sin(0.298319935798645*x_92 + 1.99519979953766) + 0.0680462543534722*std::sin(0.282799929380417*x_94 - 7.43056011199951) - 0.014046878739989*std::sin(0.288399934768677*x_94 + 1.98655986785889) + 0.0205532888904855*std::sin(0.293759942054749*x_94 + 1.98631989955902) - 0.0170207441795027*std::sin(0.259359985589981*x_95 - 7.42392015457153) - 0.0325117279962662*std::sin(0.27703994512558*x_95 - 7.43056011199951) - 0.0317753792081577*std::sin(0.27143993973732*x_97 + 1.98071980476379) + 0.0161744961128595*std::sin(0.276159942150116*x_97 - 1.20687985420227) + 0.0182484527628127*std::sin(0.280559957027435*x_97 + 1.96655988693237) - 0.960089864260479);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0100771485204428*x_10 + 0.00555790188530911*x_100 - 0.0025437469161308*x_101 + 0.0162462400260148*x_102 - 0.00607592144026384*x_103 - 0.00284845290212832*x_104 + 0.00249075300158856*x_105 + 0.00883143907245685*x_106 + 0.00504352958593379*x_107 + 0.00524122799824194*x_108 + 0.00885331825284992*x_109 - 0.00475214578162743*x_11 - 0.0158902884442517*x_110 - 0.000958790225608717*x_111 + 0.00668683265414434*x_112 + 0.0226529509281084*x_113 + 0.0221031197919151*x_114 + 0.017977462382031*x_115 + 0.00696734267934936*x_116 + 0.00981699112740956*x_117 + 3.72475657074659e-5*x_118 + 0.0369497732316444*x_119 - 0.0120960918136542*x_12 - 4.54208425876418e-5*x_13 - 0.00749985279238141*x_14 - 0.0062527267745579*x_15 - 0.000228521094766359*x_16 + 0.00185197238903079*x_18 - 0.000839067828118171*x_19 + 0.00567637442248752*x_2 + 0.000883848238696996*x_20 + 0.00871446986875638*x_22 - 0.000340997620217196*x_23 + 0.0075565907367085*x_24 + 0.0055971177956413*x_25 - 0.000272455465765404*x_26 + 0.00989745998508759*x_27 - 0.00460284337044081*x_28 + 0.000349322523800079*x_29 + 0.000625913586254417*x_3 - 0.00128147607949348*x_30 - 0.00101197977993826*x_31 + 0.0051597667125195*x_33 + 0.000411975193475423*x_34 + 0.010028593905796*x_35 + 0.025440797876738*x_36 - 8.48764913561942e-5*x_37 - 0.00392674853704773*x_38 - 0.0155780852050588*x_39 - 0.00190913295377873*x_4 + 0.00757309290368074*x_40 + 0.00369323750180259*x_41 - 0.00525951158878871*x_42 - 0.000739872502559069*x_43 - 0.0100405484492076*x_44 + 0.0182332580689192*x_45 + 0.00789304806657837*x_46 - 0.0042977779023181*x_47 + 0.00442467442415704*x_48 - 0.0104169159206319*x_49 - 6.84963300885711e-5*x_5 - 0.00853094850414043*x_50 - 0.0179836079636039*x_51 - 0.0153727625508576*x_52 + 0.00652971148375387*x_53 - 0.00279507628902133*x_54 + 0.00796155034467103*x_55 - 0.00665949734987542*x_56 - 0.00783506975837723*x_57 - 0.0276729193510465*x_58 + 0.00672504494765755*x_59 - 0.00188679074037512*x_61 + 0.00432160518159896*x_62 - 0.00279236765220079*x_63 - 0.0033649744392939*x_64 + 0.00570196361501847*x_65 + 0.000406547366264516*x_66 - 0.0113423558232592*x_67 + 0.00216916604591821*x_68 - 0.00391781822819832*x_69 + 7.25038389571947e-5*x_7 + 0.0118607048409282*x_70 - 0.00132927892975604*x_71 - 0.00444390104329027*x_72 + 0.00239879254386065*x_73 - 0.0106127357567637*x_74 - 0.00342736792599378*x_75 - 2.96152135967613e-5*x_76 - 0.00359722811847601*x_77 + 0.00480785052943051*x_78 + 0.00361575250278407*x_79 - 0.00181960955128486*x_8 - 0.000642190918451993*x_80 + 0.0112304079295601*x_81 + 0.00399506284251303*x_82 + 0.0100668150376596*x_83 - 0.000873114283128518*x_84 - 0.00131359641701138*x_85 - 0.00509938867139102*x_86 - 0.00381492198305479*x_87 - 0.000763356905981396*x_88 + 0.000552402707041428*x_89 + 0.00121440971329234*x_9 - 0.00203368799875864*x_90 - 0.00123622101534761*x_92 - 0.00256736780183199*x_93 - 0.00216890704913663*x_94 + 0.00309649491914339*x_95 + 0.0119422697096818*x_96 - 0.00534122975735504*x_97 - 0.00391016467669246*x_98 + 0.000877037300035749*x_99 + 8.74956668353656e-5*std::pow(-2.69463992118835*x_24 - 5.59167957305908, 2) - 0.130674063218082*std::sin(0.323279827833176*x_1 - 4.26496028900146) + 0.216720639930249*std::sin(0.332239836454391*x_1 - 4.25663995742798) - 0.235749397855621*std::sin(0.333679854869843*x_1 - 4.25056028366089) - 0.0408591290248513*std::sin(0.335119843482971*x_1 - 4.24823999404907) - 0.0291195303523792*std::sin(0.357359826564789*x_1 - 4.24368000030518) + 0.0101097484838238*std::sin(0.353119850158691*x_10 - 1.14991986751556) + 0.0188842081687138*std::sin(0.224559992551804*x_101 + 1.99807977676392) + 0.0889889997326732*std::sin(0.239759981632233*x_101 + 1.97511982917786) - 0.0110027166317521*std::sin(0.23471999168396*x_102 + 1.95839977264404) - 0.0147555685021075*std::sin(0.215680003166199*x_103 + 1.97719979286194) + 0.080644777832513*std::sin(0.254959970712662*x_108 - 7.43815994262695) - 0.0815279391951709*std::sin(0.257999956607819*x_108 - 7.44407987594604) - 0.0305031265829209*std::sin(0.21399998664856*x_109 + 1.98639988899231) - 0.10400819568633*std::sin(0.25639995932579*x_11 - 7.42575979232788) + 0.0900756520624177*std::sin(0.257519960403442*x_11 - 7.41519975662231) + 0.0229921222339716*std::sin(0.273439943790436*x_11 - 7.41864013671875) + 0.045237657742947*std::sin(0.216319993138313*x_110 - 7.4157600402832) + 0.0201885133084577*std::sin(0.217040002346039*x_110 - 7.41983985900879) + 0.0707250481245005*std::sin(0.222240000963211*x_110 + 1.98479974269867) + 0.0629643561576163*std::sin(0.272479951381683*x_112 + 5.14752006530762) - 0.0860584364226532*std::sin(0.274239957332611*x_112 + 1.97527980804443) + 0.0509908414843217*std::sin(0.277439951896667*x_112 - 7.43711996078491) + 0.0465741235908009*std::sin(0.28399994969368*x_113 - 7.42224025726318) + 0.0442462815687097*std::sin(0.234959989786148*x_116 - 1.19575989246368) + 0.0548253026495972*std::sin(0.252959966659546*x_116 + 5.15848016738892) + 0.0111389163453913*std::sin(0.271839946508408*x_116 + 8.16720008850098) - 0.0864351089980233*std::sin(0.229839995503426*x_118 + 5.17456007003784) + 0.0536764116524001*std::sin(0.232959985733032*x_118 + 5.16416025161743) + 0.0486289545138708*std::sin(0.270559966564178*x_12 + 5.16064023971558) - 0.0763533478372584*std::sin(0.290239930152893*x_12 - 7.44551992416382) + 0.105585978586042*std::sin(0.294479936361313*x_12 - 7.4488000869751) - 0.0951472023904963*std::sin(0.258399993181229*x_120 - 4.23375988006592) + 0.0563651589055128*std::sin(0.259839981794357*x_120 - 4.24735975265503) + 0.078752950374574*std::sin(0.26463994383812*x_120 + 5.15520000457764) + 0.0615254949889477*std::sin(0.269039958715439*x_120 + 5.15112018585205) + 0.0451470307478997*std::sin(0.270479947328568*x_120 - 7.42575979232788) + 0.0786308524100029*std::sin(0.228479996323586*x_13 - 1.19263982772827) + 0.0303300712142342*std::sin(0.239439979195595*x_13 + 1.98615980148315) + 0.0918270719854513*std::sin(0.29911994934082*x_13 + 5.14871978759766) - 0.0635933246640526*std::sin(0.345359832048416*x_13 - 1.13367986679077) - 0.0347681702445*std::sin(0.284159928560257*x_14 - 7.43120002746582) - 0.107778205747383*std::sin(0.287439942359924*x_14 - 7.43151998519897) + 0.0532155665572064*std::sin(0.302079945802689*x_14 - 7.43623971939087) - 0.0424573289560433*std::sin(0.28399994969368*x_15 + 1.96103990077972) - 0.0137338717020059*std::sin(0.284719944000244*x_15 - 7.41767978668213) - 0.0387030641739772*std::sin(0.287759929895401*x_15 - 1.19479990005493) - 0.117840288516703*std::sin(0.291919946670532*x_15 - 7.41943979263306) - 0.077629145384628*std::sin(0.273439943790436*x_16 - 4.2149600982666) - 0.0288492936102801*std::sin(0.356159836053848*x_16 - 1.16255986690521) - 0.0209189503335899*std::sin(0.36695984005928*x_16 - 1.16287982463837) + 0.00564018008981388*std::sin(0.397759824991226*x_16 + 8.19583988189697) - 0.0639288940541887*std::sin(0.262479960918427*x_17 + 2.02111983299255) - 0.0934654076271969*std::sin(0.354879856109619*x_17 + 2.00903987884521) + 0.0440665321506423*std::sin(0.359759837388992*x_17 + 2.01855993270874) + 0.016852555286204*std::sin(0.380319833755493*x_17 + 1.99399983882904) + 0.0311921135160582*std::sin(0.414399862289429*x_17 + 2.00135970115662) - 0.0145126830245339*std::sin(0.239199981093407*x_18 - 1.15639984607697) + 0.0732121239226939*std::sin(0.269679963588715*x_18 - 1.15063989162445) - 0.108209905787462*std::sin(0.33943983912468*x_18 - 1.15423989295959) - 0.167435147512514*std::sin(0.253679990768433*x_19 - 4.39103984832764) + 0.0938112660584063*std::sin(0.319279909133911*x_19 + 1.98567974567413) + 0.0776918569401869*std::sin(0.346559852361679*x_19 - 1.14703977108002) - 0.0155087527984897*std::sin(0.350719839334488*x_2 - 7.40903997421265) - 0.0238773060247591*std::sin(0.394639849662781*x_2 + 5.18232011795044) - 0.00477960394922053*std::sin(0.400079846382141*x_2 - 4.20695972442627) + 0.0337941608859291*std::sin(0.294239938259125*x_20 - 1.18247985839844) - 0.0154168958505876*std::sin(0.317519932985306*x_20 + 1.96199977397919) - 0.047403055775397*std::sin(0.346479833126068*x_20 + 8.24399948120117) - 0.0258493160105129*std::sin(0.333359837532043*x_21 - 1.14887976646423) - 0.0826848186062528*std::sin(0.340559840202332*x_21 - 1.15839993953705) + 0.048264941601155*std::sin(0.347039848566055*x_21 + 8.22983932495117) - 0.0398022234642552*std::sin(0.353439837694168*x_21 - 4.35775947570801) + 0.0143638606051842*std::sin(0.42647984623909*x_21 + 8.16991996765137) + 0.206440461206426*std::sin(0.162560015916824*x_22 - 4.43807983398438) - 0.0811404758536291*std::sin(0.244959965348244*x_22 - 1.18119990825653) - 0.00741802000935395*std::sin(0.285759925842285*x_22 + 8.23952007293701) + 0.043647541463058*std::sin(0.300879925489426*x_22 - 1.15463984012604) + 0.0731426487509018*std::sin(0.298559933900833*x_23 - 1.15375983715057) + 0.20656689047065*std::sin(0.329759836196899*x_23 + 1.98991978168488) + 0.0145934673305944*std::sin(0.341119825839996*x_23 - 1.17207992076874) + 0.0393165214428199*std::sin(0.38647985458374*x_23 - 1.19239985942841) + 0.0306383190759199*std::sin(0.231039986014366*x_24 - 4.39135980606079) - 0.0670187938156194*std::sin(0.330239832401276*x_24 - 1.1568797826767) + 0.032947577985776*std::sin(0.278879970312119*x_25 - 1.15535986423492) + 0.0372065806830308*std::sin(0.305199921131134*x_25 + 2.0020797252655) - 0.0121118655697304*std::sin(0.345759838819504*x_25 - 1.16223990917206) - 0.043147626451517*std::sin(0.271199941635132*x_26 - 1.17207992076874) - 0.0165744643959813*std::sin(0.274639964103699*x_26 - 1.16543984413147) - 0.0612272053038922*std::sin(0.343679845333099*x_26 + 8.24544048309326) - 0.0308408611249135*std::sin(0.38487982749939*x_26 - 1.1729599237442) - 0.0120898430620337*std::sin(0.154640033841133*x_27 + 4.97559976577759) - 0.0307610319179268*std::sin(0.42103984951973*x_27 - 1.207279920578) + 0.183861584891806*std::sin(0.0844800844788551*x_28 + 8.05719947814941) + 0.0378470348554361*std::sin(0.270879954099655*x_28 + 2.000159740448) + 0.0824146500403054*std::sin(0.308159917593002*x_28 + 1.98215973377228) + 0.00598460768878325*std::sin(0.371119856834412*x_28 - 1.17263984680176) + 0.0260537052450468*std::sin(0.25383996963501*x_29 + 1.80247986316681) + 0.0570944052848074*std::sin(0.31535992026329*x_29 + 1.98511981964111) + 0.0333441026974934*std::sin(0.328559845685959*x_29 - 1.16903984546661) - 0.0848170902873787*std::sin(0.355519831180573*x_29 - 1.14223992824554) + 0.00304534512245083*std::sin(0.288959950208664*x_3 - 1.13039994239807) + 0.0636236601235549*std::sin(0.346479833126068*x_3 - 7.40783977508545) + 0.206896120735537*std::sin(0.348239839076996*x_3 - 7.40471982955933) - 0.0793034639454011*std::sin(0.373999834060669*x_3 - 7.40743970870972) + 0.261060176549547*std::sin(0.199120000004768*x_30 + 8.18671989440918) + 0.0951007849947355*std::sin(0.258879989385605*x_30 - 1.16759991645813) - 0.167291834731137*std::sin(0.268719971179962*x_30 - 1.17455983161926) - 0.0298567239889195*std::sin(0.329279839992523*x_30 - 1.15023982524872) + 0.0318500286739977*std::sin(0.375839829444885*x_31 - 7.39943981170654) - 0.0242411272797698*std::sin(0.376319825649261*x_31 + 5.16775989532471) - 0.0768101225701495*std::sin(0.380639851093292*x_31 - 7.40391969680786) - 0.0434672373438067*std::sin(0.295279920101166*x_32 - 1.14495992660522) + 0.045155758709827*std::sin(0.299279928207397*x_32 + 2.02359986305237) - 0.0602450469357724*std::sin(0.302399933338165*x_32 - 1.13367986679077) + 0.0189208790394773*std::sin(0.303839921951294*x_32 - 1.13895988464355) + 0.116324373994629*std::sin(0.305679947137833*x_32 - 1.14007985591888) + 0.0178863283391146*std::sin(0.243359968066216*x_33 + 1.98735988140106) + 0.011624652535562*std::sin(0.241119980812073*x_35 - 7.43616008758545) + 0.0438365802858065*std::sin(0.222559988498688*x_36 + 5.17360019683838) + 0.0137829458368467*std::sin(0.190160006284714*x_37 - 1.17119991779327) + 0.0102363528701141*std::sin(0.197759985923767*x_37 - 1.19143986701965) + 0.107938534025142*std::sin(0.235199987888336*x_38 + 1.97775971889496) - 0.071690456024597*std::sin(0.265519946813583*x_4 + 2.03111982345581) + 0.0729612458920083*std::sin(0.312879920005798*x_4 + 2.01127982139587) - 0.0771539614103217*std::sin(0.328959852457047*x_4 + 1.99927973747253) - 0.0781119144715817*std::sin(0.231519982218742*x_40 + 1.96791982650757) - 0.0296269805395045*std::sin(0.251359969377518*x_42 - 7.43455982208252) - 0.0705541630249429*std::sin(0.135360047221184*x_44 - 1.19167983531952) - 0.00956793497545036*std::sin(0.157520025968552*x_45 - 4.39479970932007) + 0.0169914718900678*std::sin(0.174560010433197*x_45 - 4.58383989334106) + 0.0841419021576013*std::sin(0.140800043940544*x_46 - 1.20887982845306) - 0.0279933809010793*std::sin(0.235679984092712*x_46 - 1.21863985061646) - 0.0995669865315212*std::sin(0.201440006494522*x_47 + 1.98727989196777) + 0.0572253859260189*std::sin(0.202799990773201*x_47 - 1.19279980659485) - 0.0182870546994241*std::sin(0.23039998114109*x_47 - 1.21311986446381) - 0.11461505251715*std::sin(0.215759992599487*x_48 - 7.39559984207153) - 0.0464061506289806*std::sin(0.280879944562912*x_49 + 8.27223968505859) - 0.0102987420088651*std::sin(0.317999929189682*x_5 + 2.01639986038208) + 0.0957163267887744*std::sin(0.340559840202332*x_5 + 2.0162398815155) + 0.0468936656140559*std::sin(0.346319854259491*x_5 - 7.37375974655151) + 0.0556154489058852*std::sin(0.366399854421616*x_5 - 1.16279983520508) - 0.0245493183433012*std::sin(0.187520012259483*x_51 - 1.1943199634552) - 0.0804559775227216*std::sin(0.205520004034042*x_51 - 7.40855979919434) + 0.025174101606204*std::sin(0.213919997215271*x_51 - 1.18455994129181) + 0.0430389863610268*std::sin(0.23879998922348*x_52 - 7.41024017333984) - 0.00428854234041206*std::sin(0.227519989013672*x_53 - 1.20567989349365) - 0.110708042503501*std::sin(0.23047998547554*x_53 + 1.99655985832214) - 0.058850075370672*std::sin(0.257439970970154*x_53 - 7.42767953872681) - 0.0835192213737787*std::sin(0.236959978938103*x_57 + 5.15824031829834) + 0.152614985259041*std::sin(0.326719850301743*x_6 - 1.13911986351013) - 0.0479150156870151*std::sin(0.357119828462601*x_6 + 2.00927972793579) + 0.0442546798439403*std::sin(0.3572798371315*x_6 + 1.99695980548859) - 0.0210862019584786*std::sin(0.358879864215851*x_6 + 2.01999974250793) - 0.0807576326732185*std::sin(0.385199844837189*x_6 + 1.99791979789734) - 0.0508748979037898*std::sin(0.164240017533302*x_60 + 1.97215986251831) + 0.0405101505360657*std::sin(0.329279839992523*x_60 - 4.29544019699097) - 0.0166692507654183*std::sin(0.369679838418961*x_60 + 5.03895950317383) + 0.0204502454297565*std::sin(0.399279862642288*x_60 - 4.38207960128784) + 0.0194238850550315*std::sin(0.455599844455719*x_60 - 1.2824798822403) - 0.0152919156811329*std::sin(0.178480014204979*x_61 - 4.41824007034302) - 0.0424205654662819*std::sin(0.326879858970642*x_7 + 2.02199983596802) - 0.0911629220547896*std::sin(0.332559853792191*x_7 + 2.04583978652954) - 0.0822214786971519*std::sin(0.348159849643707*x_7 + 2.00615978240967) + 0.159323834994303*std::sin(0.355439841747284*x_7 + 2.00423979759216) - 0.0271636718030797*std::sin(0.307679921388626*x_8 + 5.17511987686157) - 0.0143084444411024*std::sin(0.311919927597046*x_8 - 4.23727989196777) - 0.017230317692513*std::sin(0.315839916467667*x_8 - 7.43063974380493) + 0.0311155486019918*std::sin(0.317199915647507*x_8 - 4.23792028427124) + 0.0194221358594436*std::sin(0.262799948453903*x_9 + 1.97775971889496) + 0.0901390092289522*std::sin(0.316639930009842*x_9 - 7.43160009384155) - 0.0260076264669639*std::sin(0.326159834861755*x_9 + 8.27543926239014) + 0.00868648654316609*std::sin(0.345359832048416*x_91 - 7.39999961853027) + 0.0845003526297123*std::sin(0.351599842309952*x_91 - 7.40375995635986) - 0.0339777403523175*std::sin(0.362559854984283*x_91 + 2.00079965591431) - 0.0303897899475403*std::sin(0.366399854421616*x_91 - 7.41015958786011) - 0.0177064288452478*std::sin(0.375439822673798*x_91 - 1.18063986301422) + 0.0290947060021711*std::sin(0.28399994969368*x_92 - 1.16303980350494) - 0.0494578999575661*std::sin(0.289679944515228*x_92 + 1.99175977706909) + 0.023458463626656*std::sin(0.298319935798645*x_92 + 1.99519979953766) + 0.0581149158744535*std::sin(0.282799929380417*x_94 - 7.43056011199951) + 0.0345169064888336*std::sin(0.288399934768677*x_94 + 1.98655986785889) - 0.0102239566755692*std::sin(0.293759942054749*x_94 + 1.98631989955902) + 0.0418244825835747*std::sin(0.259359985589981*x_95 - 7.42392015457153) - 0.0361090692915485*std::sin(0.27703994512558*x_95 - 7.43056011199951) - 0.0352912453538111*std::sin(0.27143993973732*x_97 + 1.98071980476379) - 0.0397450266472516*std::sin(0.276159942150116*x_97 - 1.20687985420227) + 0.0155850943924246*std::sin(0.280559957027435*x_97 + 1.96655988693237) + 0.231909372696075);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.96827848163552e-5*x_10 - 0.005082705912032*x_100 - 0.00129932270748898*x_101 - 0.0115592498779514*x_102 + 0.00126094308569118*x_103 + 0.0163000505621229*x_104 + 0.00468366659465826*x_105 + 0.00690292488500532*x_106 + 0.00208956211435879*x_107 - 0.000687402517557586*x_108 - 0.0051569967031223*x_109 + 0.0100614828918019*x_11 + 0.0129293408734025*x_110 - 0.00380215844951363*x_111 - 0.000155189064196952*x_112 - 0.0194596402828381*x_113 + 0.00441955263650562*x_114 + 0.00637605661665699*x_115 - 0.00571092168169862*x_116 + 0.00462037297987978*x_117 + 0.00254826635904691*x_118 - 0.00187497312464124*x_119 - 0.00711088861088391*x_12 - 3.4160098577399e-5*x_13 + 0.00238704682161358*x_14 - 0.00470254955275874*x_15 + 0.000185648509556702*x_16 - 0.00264424514794517*x_18 + 0.00253553654876773*x_19 + 0.00133056367274863*x_2 - 0.00119430279121421*x_20 - 0.00707955799163959*x_22 + 0.000277023440748123*x_23 - 0.0100813900815439*x_24 - 0.0100780006992334*x_25 - 0.000204908254410711*x_26 + 0.0115631641937869*x_27 - 0.00346170555879045*x_28 - 0.000177274929486897*x_29 - 0.000771280680758998*x_3 - 0.000312796594122903*x_30 + 0.000765453592634355*x_31 - 0.00720960610266602*x_33 - 0.00989922314573035*x_34 + 0.000703005395628337*x_35 - 0.027551771660618*x_36 + 0.00577037829885749*x_37 - 0.00714006598355663*x_38 - 0.0103283320214799*x_39 - 0.00168028709911355*x_4 - 0.00742109431544849*x_40 - 0.00339630358583323*x_41 + 0.00319574139632206*x_42 + 0.0101264076728157*x_43 + 0.00518145273911536*x_44 + 0.00319873260348218*x_45 - 0.00963965189419574*x_46 + 0.00359497486995452*x_47 - 0.00182276047292174*x_48 + 0.00288733599537709*x_49 - 1.67193278941983e-5*x_5 + 0.0105051651223275*x_50 + 0.00446220093787942*x_51 + 0.0229650786593232*x_52 - 0.0065137305535559*x_53 - 0.00633304849084115*x_54 - 0.015916745431053*x_55 + 0.00159329182074307*x_56 + 0.000778026814038521*x_57 - 0.00097496826177151*x_58 + 0.0114442697094814*x_59 + 0.000635994818447807*x_61 + 0.00469332708872234*x_62 - 0.00522825449899757*x_63 + 0.00294492938130664*x_64 + 0.00261750118615773*x_65 - 0.00182842635941799*x_66 - 0.000839391025889208*x_67 - 0.000318287584624785*x_68 + 0.00400138315072547*x_69 + 1.76975241672948e-5*x_7 - 0.00510198455325421*x_70 + 0.00347607521671372*x_71 + 0.00221289321040529*x_72 + 0.00451807851114049*x_73 + 0.00336403455915071*x_74 - 0.00306405050275859*x_75 - 0.00210663985906212*x_76 - 0.00757483844353576*x_77 - 0.00493093489329518*x_78 - 0.00196956692963351*x_79 + 0.00224220998593263*x_8 + 0.00543672501923894*x_80 - 0.00703388409099182*x_81 - 0.00364124025186967*x_82 - 0.000620713078463388*x_83 - 0.006353227224319*x_84 + 0.00518440636188808*x_85 + 0.00303629273512615*x_86 + 0.00340203947112823*x_87 - 0.00238469405952331*x_88 - 0.00786740500518789*x_89 - 0.000228862510289148*x_9 + 0.00186931069301015*x_90 + 0.00218947889666373*x_92 - 0.00512067339927856*x_93 + 0.00399659212842792*x_94 - 0.00191337803815859*x_95 - 0.00909828841398506*x_96 + 0.00697410128162575*x_97 - 0.00287342392439672*x_98 - 0.0121721478021846*x_99 + 6.5803724323788e-5*std::pow(-2.69463992118835*x_24 - 5.59167957305908, 2) + 0.161022835499564*std::sin(0.323279827833176*x_1 - 4.26496028900146) - 0.109981846415314*std::sin(0.332239836454391*x_1 - 4.25663995742798) + 0.191520718844503*std::sin(0.333679854869843*x_1 - 4.25056028366089) - 0.00997333980892836*std::sin(0.335119843482971*x_1 - 4.24823999404907) - 0.0219002107996007*std::sin(0.357359826564789*x_1 - 4.24368000030518) + 0.00246769716874404*std::sin(0.353119850158691*x_10 - 1.14991986751556) - 0.0232700252108602*std::sin(0.224559992551804*x_101 + 1.99807977676392) - 0.0722938737196375*std::sin(0.239759981632233*x_101 + 1.97511982917786) - 0.00268566252900469*std::sin(0.23471999168396*x_102 + 1.95839977264404) - 0.0110973651275835*std::sin(0.215680003166199*x_103 + 1.97719979286194) - 0.0409257815620476*std::sin(0.254959970712662*x_108 - 7.43815994262695) + 0.100462629066131*std::sin(0.257999956607819*x_108 - 7.44407987594604) - 0.0229407855871649*std::sin(0.21399998664856*x_109 + 1.98639988899231) + 0.0844953352362959*std::sin(0.25639995932579*x_11 - 7.42575979232788) - 0.0457117814624233*std::sin(0.257519960403442*x_11 - 7.41519975662231) + 0.00561216681413708*std::sin(0.273439943790436*x_11 - 7.41864013671875) - 0.0557440072018832*std::sin(0.216319993138313*x_110 - 7.4157600402832) + 0.00492783150957178*std::sin(0.217040002346039*x_110 - 7.41983985900879) + 0.0531908806218749*std::sin(0.222240000963211*x_110 + 1.98479974269867) - 0.077587693488824*std::sin(0.272479951381683*x_112 + 5.14752006530762) - 0.0647228123507889*std::sin(0.274239957332611*x_112 + 1.97527980804443) - 0.0414245071435738*std::sin(0.277439951896667*x_112 - 7.43711996078491) - 0.0378364047195815*std::sin(0.28399994969368*x_113 - 7.42224025726318) - 0.0224541960816688*std::sin(0.234959989786148*x_116 - 1.19575989246368) + 0.04123300309615*std::sin(0.252959966659546*x_116 + 5.15848016738892) - 0.013725905892541*std::sin(0.271839946508408*x_116 + 8.16720008850098) + 0.0702191155493112*std::sin(0.229839995503426*x_118 + 5.17456007003784) - 0.0272398183411577*std::sin(0.232959985733032*x_118 + 5.16416025161743) - 0.0599229254097246*std::sin(0.270559966564178*x_12 + 5.16064023971558) + 0.0620287822449997*std::sin(0.290239930152893*x_12 - 7.44551992416382) - 0.0535829946063199*std::sin(0.294479936361313*x_12 - 7.4488000869751) + 0.117244937070638*std::sin(0.258399993181229*x_120 - 4.23375988006592) - 0.0457905549263784*std::sin(0.259839981794357*x_120 - 4.24735975265503) - 0.0399657129825607*std::sin(0.26463994383812*x_120 + 5.15520000457764) + 0.0150178107826058*std::sin(0.269039958715439*x_120 + 5.15112018585205) + 0.0339541702215082*std::sin(0.270479947328568*x_120 - 7.42575979232788) - 0.0399037504505591*std::sin(0.228479996323586*x_13 - 1.19263982772827) + 0.00740329306737234*std::sin(0.239439979195595*x_13 + 1.98615980148315) - 0.113153713465258*std::sin(0.29911994934082*x_13 + 5.14871978759766) + 0.0516626526479199*std::sin(0.345359832048416*x_13 - 1.13367986679077) - 0.00848659246192369*std::sin(0.284159928560257*x_14 - 7.43120002746582) + 0.0875580579558942*std::sin(0.287439942359924*x_14 - 7.43151998519897) - 0.0655747683108041*std::sin(0.302079945802689*x_14 - 7.43623971939087) + 0.0523179529883462*std::sin(0.28399994969368*x_15 + 1.96103990077972) - 0.00335231250996616*std::sin(0.284719944000244*x_15 - 7.41767978668213) + 0.0314420258949064*std::sin(0.287759929895401*x_15 - 1.19479990005493) + 0.0598018375977087*std::sin(0.291919946670532*x_15 - 7.41943979263306) - 0.0583833127644278*std::sin(0.273439943790436*x_16 - 4.2149600982666) + 0.0355494804774994*std::sin(0.356159836053848*x_16 - 1.16255986690521) + 0.0106159929368008*std::sin(0.36695984005928*x_16 - 1.16287982463837) + 0.00137671639023565*std::sin(0.397759824991226*x_16 + 8.19583988189697) - 0.0480796303728051*std::sin(0.262479960918427*x_17 + 2.02111983299255) + 0.0759304677707725*std::sin(0.354879856109619*x_17 + 2.00903987884521) - 0.0543008901903283*std::sin(0.359759837388992*x_17 + 2.01855993270874) + 0.00411355465790368*std::sin(0.380319833755493*x_17 + 1.99399983882904) - 0.015829439407323*std::sin(0.414399862289429*x_17 + 2.00135970115662) - 0.00354241323291324*std::sin(0.239199981093407*x_18 - 1.15639984607697) + 0.0550613601109292*std::sin(0.269679963588715*x_18 - 1.15063989162445) + 0.0549145907042476*std::sin(0.33943983912468*x_18 - 1.15423989295959) - 0.125924593611679*std::sin(0.253679990768433*x_19 - 4.39103984832764) - 0.0476075387142749*std::sin(0.319279909133911*x_19 + 1.98567974567413) - 0.0957356248948737*std::sin(0.346559852361679*x_19 - 1.14703977108002) + 0.0191106275352204*std::sin(0.350719839334488*x_2 - 7.40903997421265) + 0.0121173055084725*std::sin(0.394639849662781*x_2 + 5.18232011795044) - 0.00116665762279659*std::sin(0.400079846382141*x_2 - 4.20695972442627) - 0.0171499318822927*std::sin(0.294239938259125*x_20 - 1.18247985839844) - 0.00376312331629117*std::sin(0.317519932985306*x_20 + 1.96199977397919) + 0.0584123143057066*std::sin(0.346479833126068*x_20 + 8.24399948120117) - 0.00630958169089744*std::sin(0.333359837532043*x_21 - 1.14887976646423) + 0.101888191251281*std::sin(0.340559840202332*x_21 - 1.15839993953705) + 0.036299088017721*std::sin(0.347039848566055*x_21 + 8.22983932495117) + 0.0201989161228142*std::sin(0.353439837694168*x_21 - 4.35775947570801) - 0.0116690728948198*std::sin(0.42647984623909*x_21 + 8.16991996765137) - 0.254385817710583*std::sin(0.162560015916824*x_22 - 4.43807983398438) + 0.0411773394369427*std::sin(0.244959965348244*x_22 - 1.18119990825653) - 0.00181067085932545*std::sin(0.285759925842285*x_22 + 8.23952007293701) + 0.032826434607905*std::sin(0.300879925489426*x_22 - 1.15463984012604) + 0.0550091092370596*std::sin(0.298559933900833*x_23 - 1.15375983715057) - 0.104829000272166*std::sin(0.329759836196899*x_23 + 1.98991978168488) + 0.0035621319433899*std::sin(0.341119825839996*x_23 - 1.17207992076874) - 0.0484476996336807*std::sin(0.38647985458374*x_23 - 1.19239985942841) - 0.0248902985415092*std::sin(0.231039986014366*x_24 - 4.39135980606079) + 0.0340108385188476*std::sin(0.330239832401276*x_24 - 1.1568797826767) - 0.0267663199881666*std::sin(0.278879970312119*x_25 - 1.15535986423492) - 0.0458477296357299*std::sin(0.305199921131134*x_25 + 2.0020797252655) - 0.00295639564351729*std::sin(0.345759838819504*x_25 - 1.16223990917206) + 0.0350527488493926*std::sin(0.271199941635132*x_26 - 1.17207992076874) - 0.00404567521426033*std::sin(0.274639964103699*x_26 - 1.16543984413147) + 0.0310717109931885*std::sin(0.343679845333099*x_26 + 8.24544048309326) + 0.0380035852967541*std::sin(0.38487982749939*x_26 - 1.1729599237442) - 0.00295102015074626*std::sin(0.154640033841133*x_27 + 4.97559976577759) + 0.0249899893654365*std::sin(0.42103984951973*x_27 - 1.207279920578) - 0.226563045562554*std::sin(0.0844800844788551*x_28 + 8.05719947814941) - 0.0192066928931424*std::sin(0.270879954099655*x_28 + 2.000159740448) - 0.0669529303684756*std::sin(0.308159917593002*x_28 + 1.98215973377228) + 0.00146078801794963*std::sin(0.371119856834412*x_28 - 1.17263984680176) + 0.0195944656411867*std::sin(0.25383996963501*x_29 + 1.80247986316681) - 0.0463829882137914*std::sin(0.31535992026329*x_29 + 1.98511981964111) + 0.00813899059433308*std::sin(0.328559845685959*x_29 - 1.16903984546661) + 0.104515678479387*std::sin(0.355519831180573*x_29 - 1.14223992824554) + 0.000743340899978356*std::sin(0.288959950208664*x_3 - 1.13039994239807) - 0.0516872969060313*std::sin(0.346479833126068*x_3 - 7.40783977508545) + 0.155602394780989*std::sin(0.348239839076996*x_3 - 7.40471982955933) + 0.0402450887679761*std::sin(0.373999834060669*x_3 - 7.40743970870972) - 0.132483367766299*std::sin(0.199120000004768*x_30 + 8.18671989440918) - 0.0772590338322851*std::sin(0.258879989385605*x_30 - 1.16759991645813) + 0.2061450062923*std::sin(0.268719971179962*x_30 - 1.17455983161926) - 0.022454639248308*std::sin(0.329279839992523*x_30 - 1.15023982524872) + 0.00777430078591958*std::sin(0.375839829444885*x_31 - 7.39943981170654) + 0.0298710773520527*std::sin(0.376319825649261*x_31 + 5.16775989532471) + 0.0623998619847107*std::sin(0.380639851093292*x_31 - 7.40391969680786) + 0.053562410443695*std::sin(0.295279920101166*x_32 - 1.14495992660522) - 0.0229157394551324*std::sin(0.299279928207397*x_32 + 2.02359986305237) - 0.0453090833388889*std::sin(0.302399933338165*x_32 - 1.13367986679077) + 0.00461841357483571*std::sin(0.303839921951294*x_32 - 1.13895988464355) - 0.0945008892036794*std::sin(0.305679947137833*x_32 - 1.14007985591888) + 0.00436588920805328*std::sin(0.243359968066216*x_33 + 1.98735988140106) + 0.00283747139659696*std::sin(0.241119980812073*x_35 - 7.43616008758545) + 0.0329686068894426*std::sin(0.222559988498688*x_36 + 5.17360019683838) - 0.0169840055901686*std::sin(0.190160006284714*x_37 - 1.17119991779327) + 0.00249860014185946*std::sin(0.197759985923767*x_37 - 1.19143986701965) - 0.0547768743912347*std::sin(0.235199987888336*x_38 + 1.97775971889496) + 0.0582406903135752*std::sin(0.265519946813583*x_4 + 2.03111982345581) - 0.0370265266037763*std::sin(0.312879920005798*x_4 + 2.01127982139587) + 0.0950728042762411*std::sin(0.328959852457047*x_4 + 1.99927973747253) - 0.0587463936467042*std::sin(0.231519982218742*x_40 + 1.96791982650757) - 0.022281853838958*std::sin(0.251359969377518*x_42 - 7.43455982208252) + 0.0869402168019728*std::sin(0.135360047221184*x_44 - 1.19167983531952) - 0.00233544544529714*std::sin(0.157520025968552*x_45 - 4.39479970932007) - 0.0138037209859807*std::sin(0.174560010433197*x_45 - 4.58383989334106) + 0.063281425628497*std::sin(0.140800043940544*x_46 - 1.20887982845306) + 0.0227415742387011*std::sin(0.235679984092712*x_46 - 1.21863985061646) + 0.12269120664516*std::sin(0.201440006494522*x_47 + 1.98727989196777) + 0.0430380572661234*std::sin(0.202799990773201*x_47 - 1.19279980659485) + 0.0148562409636668*std::sin(0.23039998114109*x_47 - 1.21311986446381) + 0.0581650880455195*std::sin(0.215759992599487*x_48 - 7.39559984207153) - 0.034901128860056*std::sin(0.280879944562912*x_49 + 8.27223968505859) - 0.00774547591377694*std::sin(0.317999929189682*x_5 + 2.01639986038208) - 0.117946239395719*std::sin(0.340559840202332*x_5 + 2.0162398815155) - 0.0380959978237484*std::sin(0.346319854259491*x_5 - 7.37375974655151) - 0.0282238450470358*std::sin(0.366399854421616*x_5 - 1.16279983520508) - 0.00599226414656039*std::sin(0.187520012259483*x_51 - 1.1943199634552) + 0.0991417065831704*std::sin(0.205520004034042*x_51 - 7.40855979919434) - 0.0127754060591005*std::sin(0.213919997215271*x_51 - 1.18455994129181) - 0.0349644906039198*std::sin(0.23879998922348*x_52 - 7.41024017333984) - 0.00104679397399519*std::sin(0.227519989013672*x_53 - 1.20567989349365) - 0.083261283362001*std::sin(0.23047998547554*x_53 + 1.99655985832214) + 0.0725178797703241*std::sin(0.257439970970154*x_53 - 7.42767953872681) + 0.042384510219303*std::sin(0.236959978938103*x_57 + 5.15824031829834) - 0.0774493738798363*std::sin(0.326719850301743*x_6 - 1.13911986351013) + 0.0389257335598491*std::sin(0.357119828462601*x_6 + 2.00927972793579) - 0.0545327347838264*std::sin(0.3572798371315*x_6 + 1.99695980548859) - 0.00514694910123242*std::sin(0.358879864215851*x_6 + 2.01999974250793) - 0.060736184884098*std::sin(0.385199844837189*x_6 + 1.99791979789734) - 0.0124180974154008*std::sin(0.164240017533302*x_60 + 1.97215986251831) - 0.0205581764429672*std::sin(0.329279839992523*x_60 - 4.29544019699097) + 0.0205406486780883*std::sin(0.369679838418961*x_60 + 5.03895950317383) + 0.0153802166585645*std::sin(0.399279862642288*x_60 - 4.38207960128784) - 0.0157797918566515*std::sin(0.455599844455719*x_60 - 1.2824798822403) - 0.0037326167996547*std::sin(0.178480014204979*x_61 - 4.41824007034302) + 0.034462090956721*std::sin(0.326879858970642*x_7 + 2.02199983596802) - 0.068561792925494*std::sin(0.332559853792191*x_7 + 2.04583978652954) + 0.0417259290348191*std::sin(0.348159849643707*x_7 + 2.00615978240967) - 0.196326455622887*std::sin(0.355439841747284*x_7 + 2.00423979759216) - 0.0204292490771579*std::sin(0.307679921388626*x_8 + 5.17511987686157) + 0.0116240532948671*std::sin(0.311919927597046*x_8 - 4.23727989196777) - 0.00420576300730014*std::sin(0.315839916467667*x_8 - 7.43063974380493) - 0.0157905840836106*std::sin(0.317199915647507*x_8 - 4.23792028427124) + 0.01460699621021*std::sin(0.262799948453903*x_9 + 1.97775971889496) - 0.111073601736437*std::sin(0.316639930009842*x_9 - 7.43160009384155) + 0.0211283649574484*std::sin(0.326159834861755*x_9 + 8.27543926239014) + 0.00212029194229732*std::sin(0.345359832048416*x_91 - 7.39999961853027) - 0.104125379176749*std::sin(0.351599842309952*x_91 - 7.40375995635986) + 0.0276032147533757*std::sin(0.362559854984283*x_91 + 2.00079965591431) - 0.0228555473921763*std::sin(0.366399854421616*x_91 - 7.41015958786011) + 0.00898569577151712*std::sin(0.375439822673798*x_91 - 1.18063986301422) - 0.0147650426284242*std::sin(0.28399994969368*x_92 - 1.16303980350494) - 0.037196287909491*std::sin(0.289679944515228*x_92 + 1.99175977706909) + 0.00572599648420621*std::sin(0.298319935798645*x_92 + 1.99519979953766) - 0.0472120419610979*std::sin(0.282799929380417*x_94 - 7.43056011199951) + 0.0259594684085899*std::sin(0.288399934768677*x_94 + 1.98655986785889) - 0.00249557434411279*std::sin(0.293759942054749*x_94 + 1.98631989955902) + 0.0314553488356544*std::sin(0.259359985589981*x_95 - 7.42392015457153) + 0.0183247064714333*std::sin(0.27703994512558*x_95 - 7.43056011199951) + 0.0179096754584945*std::sin(0.27143993973732*x_97 + 1.98071980476379) - 0.0298914320140963*std::sin(0.276159942150116*x_97 - 1.20687985420227) - 0.0126611923866911*std::sin(0.280559957027435*x_97 + 1.96655988693237) + 1.87609335781081);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00448197497412987*x_10 + 0.000877303438537538*x_100 + 0.00048736191134449*x_101 + 0.00102114955100668*x_102 + 0.00251876684177717*x_103 + 0.0168376678025848*x_104 - 0.00162254705108867*x_105 - 0.00962511652644738*x_106 + 0.000172961196272115*x_107 - 0.00659257357354161*x_108 + 0.00360287017046278*x_109 - 0.000868554962043896*x_11 + 0.0210585799607835*x_110 + 0.000422758906873153*x_111 + 0.00100959863975547*x_112 - 0.000256218117655878*x_113 - 0.000169744821205004*x_114 - 0.00724276779790829*x_115 - 0.00924608179418951*x_116 + 0.0139075330859896*x_117 + 0.0011494673883924*x_118 + 0.00760922102355155*x_119 + 0.00291659988044032*x_12 + 1.61832587101996e-5*x_13 - 0.00230421235211228*x_14 + 0.00222782073761869*x_15 + 0.000301186117899782*x_16 + 0.00118165092054743*x_18 + 0.00341862807609457*x_19 - 0.00382878508868121*x_2 - 0.00145765947454979*x_20 - 0.0114854926281919*x_22 + 0.000449427872517793*x_23 + 0.00013331833459329*x_24 + 0.00686277500654294*x_25 + 9.70747577168268e-5*x_26 - 0.0060079819007742*x_27 + 0.00163997409168798*x_28 + 0.000148295742185317*x_29 + 1.03299842607168e-5*x_3 - 0.000585760837392291*x_31 - 0.0113183082116707*x_33 - 0.00916080558613792*x_34 - 0.000148919202745294*x_35 + 0.000252119398111524*x_36 - 0.000551155340867865*x_37 + 0.00197056922330027*x_38 + 0.000309000520151719*x_39 + 0.000851681524042514*x_4 - 0.0190735293201749*x_40 + 0.00133777589860204*x_41 - 0.00179138780987213*x_42 + 0.00105538176328423*x_43 + 0.0183947640654468*x_44 - 0.00174591845010392*x_45 + 0.000333700803533784*x_46 - 0.00262316326779459*x_47 - 0.00179222131586135*x_48 - 0.000658110850057422*x_49 + 0.00939964105370478*x_50 + 0.0174643227847306*x_51 - 0.00353175984997466*x_52 - 0.0155155466295877*x_53 + 0.00815394812344613*x_54 - 0.00423627662738091*x_55 + 0.00333430012286967*x_56 + 0.00285261717202185*x_57 - 0.000131627282567153*x_58 + 0.0102972784301017*x_59 + 0.00309615525316393*x_61 + 0.000356847260508394*x_62 - 0.00355406694020306*x_63 - 0.00250242535288396*x_64 - 0.0123195267544979*x_65 - 0.00298668500504322*x_66 + 0.0010084005411968*x_67 - 0.000962568491589485*x_68 + 0.000852866365665082*x_69 - 0.00526674403555483*x_70 + 0.00286428225246918*x_71 + 0.0047265819999958*x_72 - 0.00256753481617456*x_73 + 0.00542329441065115*x_74 - 0.000959558607865397*x_75 - 0.00167310214908597*x_76 + 0.00522144265346446*x_77 - 0.00475216843929277*x_78 - 0.00609043753602561*x_79 - 3.00305640238685e-5*x_8 - 0.000966257517020569*x_80 - 0.00182561127039062*x_81 - 0.00432018364876403*x_82 - 0.00220440572215075*x_83 - 0.0102209255826213*x_84 - 0.000508093687832331*x_85 + 0.000804037001526792*x_86 + 0.00265269763795604*x_87 + 0.00562519865239755*x_88 + 0.000644763434553161*x_89 + 0.000296707893966629*x_9 + 0.00207511184738001*x_90 - 0.00213770476941852*x_92 - 0.00913331973507697*x_93 + 0.000709552506847502*x_94 - 0.00223140957042903*x_95 + 0.00434450208270636*x_96 - 9.25372621140968e-5*x_97 + 0.00461370858175564*x_98 + 0.00837037938093708*x_99 - 3.11743448987318e-5*std::pow(-2.69463992118835*x_24 - 5.59167957305908, 2) - 0.00215662520509343*std::sin(0.323279827833176*x_1 - 4.26496028900146) + 0.0920030801212417*std::sin(0.332239836454391*x_1 - 4.25663995742798) + 0.310712873181099*std::sin(0.333679854869843*x_1 - 4.25056028366089) + 0.0103751684549393*std::sin(0.357359826564789*x_1 - 4.24368000030518) + 0.000311662148646219*std::sin(0.224559992551804*x_101 + 1.99807977676392) - 0.11728567724862*std::sin(0.239759981632233*x_101 + 1.97511982917786) + 0.00525734814418986*std::sin(0.215680003166199*x_103 + 1.97719979286194) + 0.034235631450112*std::sin(0.254959970712662*x_108 - 7.43815994262695) - 0.00134552492099519*std::sin(0.257999956607819*x_108 - 7.44407987594604) + 0.0108681380801968*std::sin(0.21399998664856*x_109 + 1.98639988899231) + 0.137080669601002*std::sin(0.25639995932579*x_11 - 7.42575979232788) + 0.0382392624732879*std::sin(0.257519960403442*x_11 - 7.41519975662231) + 0.000746595540884118*std::sin(0.216319993138313*x_110 - 7.4157600402832) - 0.025199042683579*std::sin(0.222240000963211*x_110 + 1.98479974269867) + 0.00103915432158388*std::sin(0.272479951381683*x_112 + 5.14752006530762) + 0.0306622656357765*std::sin(0.274239957332611*x_112 + 1.97527980804443) - 0.0672048836927192*std::sin(0.277439951896667*x_112 - 7.43711996078491) - 0.0613837400579572*std::sin(0.28399994969368*x_113 - 7.42224025726318) + 0.0187836017351332*std::sin(0.234959989786148*x_116 - 1.19575989246368) - 0.0195340290073093*std::sin(0.252959966659546*x_116 + 5.15848016738892) + 0.000183835010225457*std::sin(0.271839946508408*x_116 + 8.16720008850098) + 0.113919701618686*std::sin(0.229839995503426*x_118 + 5.17456007003784) + 0.0227869168504944*std::sin(0.232959985733032*x_118 + 5.16416025161743) + 0.000802564995831886*std::sin(0.270559966564178*x_12 + 5.16064023971558) + 0.100632147099012*std::sin(0.290239930152893*x_12 - 7.44551992416382) + 0.0448237659812091*std::sin(0.294479936361313*x_12 - 7.4488000869751) - 0.00157029520484885*std::sin(0.258399993181229*x_120 - 4.23375988006592) - 0.07428812387282*std::sin(0.259839981794357*x_120 - 4.24735975265503) + 0.0334325055768941*std::sin(0.26463994383812*x_120 + 5.15520000457764) - 0.0160857006820342*std::sin(0.270479947328568*x_120 - 7.42575979232788) + 0.0333806720790754*std::sin(0.228479996323586*x_13 - 1.19263982772827) + 0.001515500268965*std::sin(0.29911994934082*x_13 + 5.14871978759766) + 0.083814698155061*std::sin(0.345359832048416*x_13 - 1.13367986679077) + 0.142049465570988*std::sin(0.287439942359924*x_14 - 7.43151998519897) + 0.000878261755349759*std::sin(0.302079945802689*x_14 - 7.43623971939087) - 0.000700709410211984*std::sin(0.28399994969368*x_15 + 1.96103990077972) + 0.0510098451143178*std::sin(0.287759929895401*x_15 - 1.19479990005493) - 0.050026012794175*std::sin(0.291919946670532*x_15 - 7.41943979263306) + 0.027658944036255*std::sin(0.273439943790436*x_16 - 4.2149600982666) - 0.000476124429109062*std::sin(0.356159836053848*x_16 - 1.16255986690521) - 0.00888059330303279*std::sin(0.36695984005928*x_16 - 1.16287982463837) + 0.0227776010438293*std::sin(0.262479960918427*x_17 + 2.02111983299255) + 0.123185491080976*std::sin(0.354879856109619*x_17 + 2.00903987884521) + 0.000727267459178423*std::sin(0.359759837388992*x_17 + 2.01855993270874) + 0.0132417960739337*std::sin(0.414399862289429*x_17 + 2.00135970115662) - 0.0260851775234684*std::sin(0.269679963588715*x_18 - 1.15063989162445) - 0.0459376856550447*std::sin(0.33943983912468*x_18 - 1.15423989295959) + 0.0596564518623151*std::sin(0.253679990768433*x_19 - 4.39103984832764) + 0.0398251197035248*std::sin(0.319279909133911*x_19 + 1.98567974567413) + 0.00128221479290876*std::sin(0.346559852361679*x_19 - 1.14703977108002) - 0.000255954137807494*std::sin(0.350719839334488*x_2 - 7.40903997421265) - 0.0101364858463982*std::sin(0.394639849662781*x_2 + 5.18232011795044) + 0.0143464272374747*std::sin(0.294239938259125*x_20 - 1.18247985839844) - 0.000782332946309766*std::sin(0.346479833126068*x_20 + 8.24399948120117) - 0.00136461788585562*std::sin(0.340559840202332*x_21 - 1.15839993953705) - 0.0171965994478642*std::sin(0.347039848566055*x_21 + 8.22983932495117) - 0.0168969930854948*std::sin(0.353439837694168*x_21 - 4.35775947570801) - 0.0189312737983869*std::sin(0.42647984623909*x_21 + 8.16991996765137) + 0.00340706251129477*std::sin(0.162560015916824*x_22 - 4.43807983398438) - 0.0344460670817499*std::sin(0.244959965348244*x_22 - 1.18119990825653) - 0.0155514388399527*std::sin(0.300879925489426*x_22 - 1.15463984012604) - 0.0260604238065624*std::sin(0.298559933900833*x_23 - 1.15375983715057) + 0.0876925713235418*std::sin(0.329759836196899*x_23 + 1.98991978168488) + 0.000648873992528065*std::sin(0.38647985458374*x_23 - 1.19239985942841) - 0.0403806764136402*std::sin(0.231039986014366*x_24 - 4.39135980606079) - 0.0284510762751157*std::sin(0.330239832401276*x_24 - 1.1568797826767) - 0.0434242323137909*std::sin(0.278879970312119*x_25 - 1.15535986423492) + 0.000614051845640193*std::sin(0.305199921131134*x_25 + 2.0020797252655) + 0.0568676870763681*std::sin(0.271199941635132*x_26 - 1.17207992076874) - 0.0259924088309572*std::sin(0.343679845333099*x_26 + 8.24544048309326) - 0.000508992961654313*std::sin(0.38487982749939*x_26 - 1.1729599237442) + 0.0405424094236203*std::sin(0.42103984951973*x_27 - 1.207279920578) + 0.00303442411187858*std::sin(0.0844800844788551*x_28 + 8.05719947814941) + 0.0160669688926574*std::sin(0.270879954099655*x_28 + 2.000159740448) - 0.10862081913745*std::sin(0.308159917593002*x_28 + 1.98215973377228) - 0.00928282762536414*std::sin(0.25383996963501*x_29 + 1.80247986316681) - 0.0752492556501589*std::sin(0.31535992026329*x_29 + 1.98511981964111) - 0.00139980857893102*std::sin(0.355519831180573*x_29 - 1.14223992824554) - 0.0838546796687657*std::sin(0.346479833126068*x_3 - 7.40783977508545) - 0.0737162337210999*std::sin(0.348239839076996*x_3 - 7.40471982955933) - 0.0336662117166551*std::sin(0.373999834060669*x_3 - 7.40743970870972) + 0.110826270849346*std::sin(0.199120000004768*x_30 + 8.18671989440918) - 0.125340884923867*std::sin(0.258879989385605*x_30 - 1.16759991645813) - 0.00276095943221247*std::sin(0.268719971179962*x_30 - 1.17455983161926) + 0.0106378275043971*std::sin(0.329279839992523*x_30 - 1.15023982524872) - 0.000400071940857773*std::sin(0.376319825649261*x_31 + 5.16775989532471) + 0.101234166832441*std::sin(0.380639851093292*x_31 - 7.40391969680786) - 0.000717376787274034*std::sin(0.295279920101166*x_32 - 1.14495992660522) + 0.0191696964712395*std::sin(0.299279928207397*x_32 + 2.02359986305237) + 0.0214650615229888*std::sin(0.302399933338165*x_32 - 1.13367986679077) - 0.153313140112448*std::sin(0.305679947137833*x_32 - 1.14007985591888) - 0.0156187925921186*std::sin(0.222559988498688*x_36 + 5.17360019683838) + 0.000227471677700674*std::sin(0.190160006284714*x_37 - 1.17119991779327) + 0.0458224818701193*std::sin(0.235199987888336*x_38 + 1.97775971889496) + 0.094486551285733*std::sin(0.265519946813583*x_4 + 2.03111982345581) + 0.0309737889003489*std::sin(0.312879920005798*x_4 + 2.01127982139587) - 0.00127333744549301*std::sin(0.328959852457047*x_4 + 1.99927973747253) + 0.0278309526689963*std::sin(0.231519982218742*x_40 + 1.96791982650757) + 0.0105559708617845*std::sin(0.251359969377518*x_42 - 7.43455982208252) - 0.00116441535953408*std::sin(0.135360047221184*x_44 - 1.19167983531952) - 0.0223944116021544*std::sin(0.174560010433197*x_45 - 4.58383989334106) - 0.0299794123888678*std::sin(0.140800043940544*x_46 - 1.20887982845306) + 0.0368947021241347*std::sin(0.235679984092712*x_46 - 1.21863985061646) - 0.00164323866160583*std::sin(0.201440006494522*x_47 + 1.98727989196777) - 0.020389168770809*std::sin(0.202799990773201*x_47 - 1.19279980659485) + 0.0241019631836253*std::sin(0.23039998114109*x_47 - 1.21311986446381) - 0.048656823195195*std::sin(0.215759992599487*x_48 - 7.39559984207153) + 0.0165343198978352*std::sin(0.280879944562912*x_49 + 8.27223968505859) + 0.00366939926306899*std::sin(0.317999929189682*x_5 + 2.01639986038208) + 0.00157968794884053*std::sin(0.340559840202332*x_5 + 2.0162398815155) - 0.0618048898935486*std::sin(0.346319854259491*x_5 - 7.37375974655151) + 0.0236100844078063*std::sin(0.366399854421616*x_5 - 1.16279983520508) - 0.00132783342579893*std::sin(0.205520004034042*x_51 - 7.40855979919434) + 0.0106870064974028*std::sin(0.213919997215271*x_51 - 1.18455994129181) - 0.056724501664376*std::sin(0.23879998922348*x_52 - 7.41024017333984) + 0.0394448185252601*std::sin(0.23047998547554*x_53 + 1.99655985832214) - 0.000971252846513437*std::sin(0.257439970970154*x_53 - 7.42767953872681) - 0.035455901284661*std::sin(0.236959978938103*x_57 + 5.15824031829834) + 0.0647887008870441*std::sin(0.326719850301743*x_6 - 1.13911986351013) + 0.0631510083506028*std::sin(0.357119828462601*x_6 + 2.00927972793579) + 0.000730372620582713*std::sin(0.3572798371315*x_6 + 1.99695980548859) + 0.0287736111423339*std::sin(0.385199844837189*x_6 + 1.99791979789734) + 0.0171975250105055*std::sin(0.329279839992523*x_60 - 4.29544019699097) - 0.000275106822772689*std::sin(0.369679838418961*x_60 + 5.03895950317383) - 0.00728633802506501*std::sin(0.399279862642288*x_60 - 4.38207960128784) - 0.0256002822857024*std::sin(0.455599844455719*x_60 - 1.2824798822403) + 0.055909435603596*std::sin(0.326879858970642*x_7 + 2.02199983596802) + 0.0324809727944551*std::sin(0.332559853792191*x_7 + 2.04583978652954) - 0.0349049785691648*std::sin(0.348159849643707*x_7 + 2.00615978240967) + 0.00262945675567937*std::sin(0.355439841747284*x_7 + 2.00423979759216) + 0.00967830412788949*std::sin(0.307679921388626*x_8 + 5.17511987686157) + 0.018858236430236*std::sin(0.311919927597046*x_8 - 4.23727989196777) + 0.0132092924419511*std::sin(0.317199915647507*x_8 - 4.23792028427124) - 0.00692002682934685*std::sin(0.262799948453903*x_9 + 1.97775971889496) + 0.00148764073357755*std::sin(0.316639930009842*x_9 - 7.43160009384155) + 0.0342775184907158*std::sin(0.326159834861755*x_9 + 8.27543926239014) + 0.0013945811879775*std::sin(0.351599842309952*x_91 - 7.40375995635986) + 0.0447819651931222*std::sin(0.362559854984283*x_91 + 2.00079965591431) + 0.0108277567048807*std::sin(0.366399854421616*x_91 - 7.41015958786011) - 0.00751680131728432*std::sin(0.375439822673798*x_91 - 1.18063986301422) + 0.0123513965641816*std::sin(0.28399994969368*x_92 - 1.16303980350494) + 0.0176216455855496*std::sin(0.289679944515228*x_92 + 1.99175977706909) - 0.0765942676854171*std::sin(0.282799929380417*x_94 - 7.43056011199951) - 0.0122982312912122*std::sin(0.288399934768677*x_94 + 1.98655986785889) - 0.0149018904870423*std::sin(0.259359985589981*x_95 - 7.42392015457153) - 0.0153291610628458*std::sin(0.27703994512558*x_95 - 7.43056011199951) - 0.0149819752973694*std::sin(0.27143993973732*x_97 + 1.98071980476379) + 0.0141609889212239*std::sin(0.276159942150116*x_97 - 1.20687985420227) - 0.0205408348929678*std::sin(0.280559957027435*x_97 + 1.96655988693237) - 0.0933643877506256*std::sin(0.0102713194205995*x_100 - 0.0300133872225271*x_101 - 0.0395118625535936*x_103 - 0.076456123647392*x_104 - 0.0422722153298188*x_105 + 0.021743414770545*x_106 + 0.0339300069021813*x_107 - 0.0907629226491335*x_108 - 0.0270653269059104*x_109 + 0.075019751031912*x_111 + 0.139102060679519*x_112 + 0.0331504989359154*x_113 + 0.0440321857733534*x_114 + 0.212322466816606*x_115 - 0.00154974991639279*x_116 + 0.162007421299091*x_117 + 0.202502365303839*x_118 + 0.0231565831148587*x_119 - 0.126238548251933*x_12 + 0.0566518262539098*x_19 - 0.0168338521771924*x_24 - 0.0413717274404237*x_30 - 0.0817419135110555*x_34 + 0.0313033418298097*x_36 - 0.0111890137022287*x_38 - 0.0281625742864227*x_39 + 0.0155366967698045*x_4 + 0.0692735709705388*x_40 - 0.012862903160718*x_41 - 0.070300645501072*x_42 + 0.0453326693393067*x_43 + 0.00495857433291862*x_44 - 0.00589276725082205*x_46 + 0.0607364994846801*x_47 - 0.0658972429456997*x_48 - 0.0582135166416514*x_49 - 0.00221136511593237*x_5 + 0.0580342258701783*x_50 + 0.015278357992654*x_52 - 0.0141030694360182*x_54 - 0.0567023741820272*x_55 - 0.0629330254740805*x_56 - 0.00664201329501067*x_57 + 0.0863183433997227*x_58 - 0.0362746849572441*x_59 + 0.0275877272762379*x_62 - 0.0333984743949036*x_63 + 0.011628959095962*x_64 + 0.0232325879677921*x_65 + 8.64066066089092e-5*x_66 - 0.0172220874116574*x_67 - 0.00846574991790507*x_68 + 0.0123792314825699*x_69 + 0.00234074526377978*x_7 + 0.0406138228522356*x_70 - 0.000734502470793563*x_71 + 0.0301048473087613*x_72 - 0.0103297903191374*x_73 - 0.0322193060880655*x_74 + 0.00458299245766876*x_75 - 0.00470678267019556*x_76 + 0.00369096009465516*x_77 - 0.00880462903090481*x_78 + 0.00521564572509458*x_79 - 0.00521331806238207*x_80 - 0.0109367474006413*x_81 - 0.00372672864153221*x_82 + 0.00194024461475266*x_83 - 0.0255927456731889*x_84 - 0.00941941504295047*x_85 - 0.014205240190994*x_86 + 0.0175600825890131*x_87 + 0.0050731780493242*x_88 + 0.0278317473526246*x_89 + 0.016642316531291*x_9 + 0.00220989952594887*x_90 + 0.0478117707941326*x_93 + 0.0259861437655678*x_95 + 0.0364281122666806*x_96 + 0.00858057838594065*x_97 - 0.0486128399955767*x_98 - 0.0530617289225833*x_99 - 1.31911377552784*std::sin(0.335119843482971*x_1 - 4.24823999404907) + 0.32638748819199*std::sin(0.353119850158691*x_10 - 1.14991986751556) - 0.355216457706327*std::sin(0.23471999168396*x_102 + 1.95839977264404) + 0.742287608455996*std::sin(0.273439943790436*x_11 - 7.41864013671875) + 0.651774686543519*std::sin(0.217040002346039*x_110 - 7.41983985900879) + 1.9863156636728*std::sin(0.269039958715439*x_120 + 5.15112018585205) + 0.979189123857793*std::sin(0.239439979195595*x_13 + 1.98615980148315) - 1.12247063052965*std::sin(0.284159928560257*x_14 - 7.43120002746582) - 0.443390248050299*std::sin(0.284719944000244*x_15 - 7.41767978668213) + 0.182090010983988*std::sin(0.397759824991226*x_16 + 8.19583988189697) + 0.544075176378705*std::sin(0.380319833755493*x_17 + 1.99399983882904) - 0.468533729289433*std::sin(0.239199981093407*x_18 - 1.15639984607697) - 0.154306799030135*std::sin(0.400079846382141*x_2 - 4.20695972442627) - 0.497725726850881*std::sin(0.317519932985306*x_20 + 1.96199977397919) - 0.834530486851563*std::sin(0.333359837532043*x_21 - 1.14887976646423) - 0.23948656310144*std::sin(0.285759925842285*x_22 + 8.23952007293701) + 0.471141804730934*std::sin(0.341119825839996*x_23 - 1.17207992076874) - 0.391024701252327*std::sin(0.345759838819504*x_25 - 1.16223990917206) - 0.535097169923439*std::sin(0.274639964103699*x_26 - 1.16543984413147) - 0.390313717098536*std::sin(0.154640033841133*x_27 + 4.97559976577759) + 0.193209660406669*std::sin(0.371119856834412*x_28 - 1.17263984680176) + 1.07649541854224*std::sin(0.328559845685959*x_29 - 1.16903984546661) + 0.0983172377418544*std::sin(0.288959950208664*x_3 - 1.13039994239807) + 1.02826008722*std::sin(0.375839829444885*x_31 - 7.39943981170654) + 0.61084983409436*std::sin(0.303839921951294*x_32 - 1.13895988464355) + 0.577449952283359*std::sin(0.243359968066216*x_33 + 1.98735988140106) + 0.375295305146075*std::sin(0.241119980812073*x_35 - 7.43616008758545) + 0.33047483890121*std::sin(0.197759985923767*x_37 - 1.19143986701965) - 0.308895346785164*std::sin(0.157520025968552*x_45 - 4.39479970932007) - 0.792560800470582*std::sin(0.187520012259483*x_51 - 1.1943199634552) - 0.138453153877343*std::sin(0.227519989013672*x_53 - 1.20567989349365) - 0.680756054787011*std::sin(0.358879864215851*x_6 + 2.01999974250793) - 1.64246718554975*std::sin(0.164240017533302*x_60 + 1.97215986251831) - 0.493690813059764*std::sin(0.178480014204979*x_61 - 4.41824007034302) - 0.55627102112458*std::sin(0.315839916467667*x_8 - 7.43063974380493) + 0.280438284748026*std::sin(0.345359832048416*x_91 - 7.39999961853027) + 0.757343175470524*std::sin(0.298319935798645*x_92 + 1.99519979953766) - 0.330074634800472*std::sin(0.293759942054749*x_94 + 1.98631989955902) + 1.2048790569088) - 0.71726628897611);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00186294843832297*x_10 - 0.00820661638979952*x_100 + 0.000117931625692307*x_101 + 0.00440853496240573*x_102 - 0.00761756370280324*x_103 - 0.0168168729156929*x_104 - 0.00808075057819518*x_105 + 0.007058361026498*x_106 + 0.00738447953324918*x_107 - 0.00413958542453464*x_108 + 0.00132731399970594*x_109 + 0.00627084307177825*x_11 - 0.0109458922655734*x_110 - 0.0102005361198779*x_111 + 0.00561492928098424*x_112 - 0.0212640005494612*x_113 + 0.00200103622121157*x_114 + 0.0135323256307532*x_115 + 0.00476163209324073*x_116 + 0.00536254776891526*x_117 + 0.0135829990120164*x_118 - 0.0188806703438132*x_119 + 0.00214545129770381*x_12 + 3.76385957210053e-5*x_13 - 0.000418273031705856*x_14 + 0.00518140663655418*x_15 - 0.000156962268902239*x_16 - 0.00376350058772974*x_18 + 0.000299733088993789*x_19 - 0.00185721652793058*x_2 + 0.00106845265675304*x_20 + 0.00598563106079411*x_22 - 0.000234218027943013*x_23 - 0.010054915000761*x_24 + 0.00716757392223289*x_25 + 0.000225773907829538*x_26 - 0.0114389803031673*x_27 + 0.00381420843201767*x_28 + 7.40943300770875e-5*x_29 - 0.000731170348893408*x_3 - 0.00151996299131342*x_30 - 0.000422787233274984*x_31 + 0.00208931545240482*x_33 + 0.0143280190472645*x_34 - 0.00845244959514346*x_35 - 0.0219332365427093*x_36 - 0.00510059075175869*x_37 + 0.00198632290161234*x_38 + 0.0138300945405682*x_39 + 0.00255162376415752*x_4 + 0.00621112741735134*x_40 - 0.011136866273255*x_41 + 0.00202598388645229*x_42 - 0.000520260927108211*x_43 - 0.00457481764469716*x_44 - 0.0105014249087363*x_45 - 0.00897209751323953*x_46 + 0.000920774111911656*x_47 - 0.00791319393747123*x_48 - 0.00836334788258804*x_49 - 8.12437223303988e-5*x_5 - 0.000409366679687987*x_50 - 0.0025221962087972*x_51 + 0.0135325381484107*x_52 + 0.00636753397009867*x_53 - 0.00728520077025349*x_54 + 0.000208985351644221*x_55 - 0.00210582914074378*x_56 + 0.00525885414436345*x_57 + 0.0218176105735588*x_58 - 0.013422534106937*x_59 + 0.00438829836941505*x_61 - 0.00460201186246091*x_62 + 0.00725604980400486*x_63 + 0.0041091458409405*x_64 + 0.00858733426394206*x_65 + 0.000479371776999441*x_66 + 0.00416644894684886*x_67 - 0.00147519962980325*x_68 + 0.000309979172132007*x_69 + 8.59970417759525e-5*x_7 - 2.76447548250756e-5*x_70 - 1.52013212605957e-5*x_71 + 0.00314970577530467*x_72 - 0.00210906073353236*x_73 + 0.00411667430875835*x_74 - 0.0054369290234744*x_75 + 0.00195607428719136*x_76 + 0.00247922550617472*x_77 - 0.000678083986232958*x_78 + 0.00401971554757964*x_79 + 0.00212560420428697*x_8 + 8.79495680278377e-5*x_80 - 0.00697432031263478*x_81 + 0.00265721923666463*x_82 - 0.00098865820353753*x_83 + 0.00837346301128773*x_84 + 0.00123636754378809*x_85 + 0.00264141372943382*x_86 + 1.97468530759633e-6*x_87 - 0.000136791362630767*x_88 + 0.00709295749243832*x_89 + 0.000759671744778845*x_9 - 0.00271290191825872*x_90 + 0.00438731008332962*x_92 + 0.00162689234099812*x_93 + 0.00505504707043019*x_94 + 0.00143215244869883*x_95 - 0.00450642615063407*x_96 + 0.00686515673101958*x_97 - 0.00104263218344325*x_98 - 0.0116972344225543*x_99 - 7.25044680754583e-5*std::pow(-2.69463992118835*x_24 - 5.59167957305908, 2) + 0.152648867979114*std::sin(0.323279827833176*x_1 - 4.26496028900146) + 0.0459683230695411*std::sin(0.332239836454391*x_1 - 4.25663995742798) - 0.161927109694567*std::sin(0.333679854869843*x_1 - 4.25056028366089) - 0.0484631472790517*std::sin(0.335119843482971*x_1 - 4.24823999404907) + 0.0241302927924316*std::sin(0.357359826564789*x_1 - 4.24368000030518) + 0.0119912059169868*std::sin(0.353119850158691*x_10 - 1.14991986751556) - 0.0220598711683529*std::sin(0.224559992551804*x_101 + 1.99807977676392) + 0.061123089400836*std::sin(0.239759981632233*x_101 + 1.97511982917786) - 0.013050358373277*std::sin(0.23471999168396*x_102 + 1.95839977264404) + 0.0122274014713134*std::sin(0.215680003166199*x_103 + 1.97719979286194) + 0.0171054552186144*std::sin(0.254959970712662*x_108 - 7.43815994262695) + 0.0952380856638945*std::sin(0.257999956607819*x_108 - 7.44407987594604) + 0.0252768285279143*std::sin(0.21399998664856*x_109 + 1.98639988899231) - 0.0714391920625334*std::sin(0.25639995932579*x_11 - 7.42575979232788) + 0.0191058252505966*std::sin(0.257519960403442*x_11 - 7.41519975662231) + 0.027271031778607*std::sin(0.273439943790436*x_11 - 7.41864013671875) - 0.052845048775769*std::sin(0.216319993138313*x_110 - 7.4157600402832) + 0.0239456620139357*std::sin(0.217040002346039*x_110 - 7.41983985900879) - 0.0586072679865035*std::sin(0.222240000963211*x_110 + 1.98479974269867) - 0.0735527575541394*std::sin(0.272479951381683*x_112 + 5.14752006530762) + 0.0713134876492887*std::sin(0.274239957332611*x_112 + 1.97527980804443) + 0.0350236295725629*std::sin(0.277439951896667*x_112 - 7.43711996078491) + 0.0319899575066343*std::sin(0.28399994969368*x_113 - 7.42224025726318) + 0.0093850191953611*std::sin(0.234959989786148*x_116 - 1.19575989246368) - 0.0454317287868059*std::sin(0.252959966659546*x_116 + 5.15848016738892) - 0.0130120922910336*std::sin(0.271839946508408*x_116 + 8.16720008850098) - 0.059368920996169*std::sin(0.229839995503426*x_118 + 5.17456007003784) + 0.0113852313874919*std::sin(0.232959985733032*x_118 + 5.16416025161743) - 0.0568066429920504*std::sin(0.270559966564178*x_12 + 5.16064023971558) - 0.0524441506245671*std::sin(0.290239930152893*x_12 - 7.44551992416382) + 0.0223956997211662*std::sin(0.294479936361313*x_12 - 7.4488000869751) + 0.111147632350343*std::sin(0.258399993181229*x_120 - 4.23375988006592) + 0.0387150395804375*std::sin(0.259839981794357*x_120 - 4.24735975265503) + 0.0167041822443081*std::sin(0.26463994383812*x_120 + 5.15520000457764) + 0.072975591898995*std::sin(0.269039958715439*x_120 + 5.15112018585205) - 0.0374116978355292*std::sin(0.270479947328568*x_120 - 7.42575979232788) + 0.016678284209477*std::sin(0.228479996323586*x_13 - 1.19263982772827) + 0.0359745971908882*std::sin(0.239439979195595*x_13 + 1.98615980148315) - 0.10726917219236*std::sin(0.29911994934082*x_13 + 5.14871978759766) - 0.0436797860456242*std::sin(0.345359832048416*x_13 - 1.13367986679077) - 0.0412386410429236*std::sin(0.284159928560257*x_14 - 7.43120002746582) - 0.0740286656232665*std::sin(0.287439942359924*x_14 - 7.43151998519897) - 0.0621645626819438*std::sin(0.302079945802689*x_14 - 7.43623971939087) + 0.0495971659788416*std::sin(0.28399994969368*x_15 + 1.96103990077972) - 0.0162897903819999*std::sin(0.284719944000244*x_15 - 7.41767978668213) - 0.0265836323444337*std::sin(0.287759929895401*x_15 - 1.19479990005493) - 0.0249949448972057*std::sin(0.291919946670532*x_15 - 7.41943979263306) + 0.0643284415884909*std::sin(0.273439943790436*x_16 - 4.2149600982666) + 0.0337007352733558*std::sin(0.356159836053848*x_16 - 1.16255986690521) - 0.00443709038289864*std::sin(0.36695984005928*x_16 - 1.16287982463837) + 0.00668983614914488*std::sin(0.397759824991226*x_16 + 8.19583988189697) + 0.0529755429691493*std::sin(0.262479960918427*x_17 + 2.02111983299255) - 0.0641977602113128*std::sin(0.354879856109619*x_17 + 2.00903987884521) - 0.0514769808399895*std::sin(0.359759837388992*x_17 + 2.01855993270874) + 0.0199888712352854*std::sin(0.380319833755493*x_17 + 1.99399983882904) + 0.00661611719026597*std::sin(0.414399862289429*x_17 + 2.00135970115662) - 0.0172135410523411*std::sin(0.239199981093407*x_18 - 1.15639984607697) - 0.0606682169949917*std::sin(0.269679963588715*x_18 - 1.15063989162445) - 0.0229522573861152*std::sin(0.33943983912468*x_18 - 1.15423989295959) + 0.138747400261242*std::sin(0.253679990768433*x_19 - 4.39103984832764) + 0.0198981813043899*std::sin(0.319279909133911*x_19 + 1.98567974567413) - 0.0907569086094947*std::sin(0.346559852361679*x_19 - 1.14703977108002) + 0.0181167823220315*std::sin(0.350719839334488*x_2 - 7.40903997421265) - 0.00506458322442056*std::sin(0.394639849662781*x_2 + 5.18232011795044) - 0.00566910395925785*std::sin(0.400079846382141*x_2 - 4.20695972442627) + 0.00716803395361151*std::sin(0.294239938259125*x_20 - 1.18247985839844) - 0.0182860308583277*std::sin(0.317519932985306*x_20 + 1.96199977397919) + 0.0553745909835906*std::sin(0.346479833126068*x_20 + 8.24399948120117) - 0.0306599587112662*std::sin(0.333359837532043*x_21 - 1.14887976646423) + 0.0965895117092856*std::sin(0.340559840202332*x_21 - 1.15839993953705) - 0.039995396847131*std::sin(0.347039848566055*x_21 + 8.22983932495117) - 0.00844239601581011*std::sin(0.353439837694168*x_21 - 4.35775947570801) + 0.00986597825067438*std::sin(0.42647984623909*x_21 + 8.16991996765137) - 0.241156522818573*std::sin(0.162560015916824*x_22 - 4.43807983398438) - 0.0172105970582976*std::sin(0.244959965348244*x_22 - 1.18119990825653) - 0.00879853792315587*std::sin(0.285759925842285*x_22 + 8.23952007293701) - 0.0361691257526526*std::sin(0.300879925489426*x_22 - 1.15463984012604) - 0.060610645453938*std::sin(0.298559933900833*x_23 - 1.15375983715057) + 0.0438146249461126*std::sin(0.329759836196899*x_23 + 1.98991978168488) + 0.017309359583374*std::sin(0.341119825839996*x_23 - 1.17207992076874) - 0.0459281845480454*std::sin(0.38647985458374*x_23 - 1.19239985942841) + 0.0210442720065906*std::sin(0.231039986014366*x_24 - 4.39135980606079) - 0.0142152660994305*std::sin(0.330239832401276*x_24 - 1.1568797826767) + 0.0226304123073112*std::sin(0.278879970312119*x_25 - 1.15535986423492) - 0.0434634255855321*std::sin(0.305199921131134*x_25 + 2.0020797252655) - 0.0143659235754367*std::sin(0.345759838819504*x_25 - 1.16223990917206) - 0.0296364296368378*std::sin(0.271199941635132*x_26 - 1.17207992076874) - 0.0196590267160439*std::sin(0.274639964103699*x_26 - 1.16543984413147) - 0.0129868200599642*std::sin(0.343679845333099*x_26 + 8.24544048309326) + 0.0360272147531084*std::sin(0.38487982749939*x_26 - 1.1729599237442) - 0.0143398026066488*std::sin(0.154640033841133*x_27 + 4.97559976577759) - 0.0211285586941042*std::sin(0.42103984951973*x_27 - 1.207279920578) - 0.214780669609548*std::sin(0.0844800844788551*x_28 + 8.05719947814941) + 0.00802768359312158*std::sin(0.270879954099655*x_28 + 2.000159740448) + 0.0566074238106382*std::sin(0.308159917593002*x_28 + 1.98215973377228) + 0.00709836285674234*std::sin(0.371119856834412*x_28 - 1.17263984680176) - 0.0215897553388709*std::sin(0.25383996963501*x_29 + 1.80247986316681) + 0.0392159306093372*std::sin(0.31535992026329*x_29 + 1.98511981964111) + 0.0395495498431596*std::sin(0.328559845685959*x_29 - 1.16903984546661) + 0.0990803568726795*std::sin(0.355519831180573*x_29 - 1.14223992824554) + 0.00361209386267414*std::sin(0.288959950208664*x_3 - 1.13039994239807) + 0.0437006222951466*std::sin(0.346479833126068*x_3 - 7.40783977508545) - 0.171447269600586*std::sin(0.348239839076996*x_3 - 7.40471982955933) - 0.0168209509364183*std::sin(0.373999834060669*x_3 - 7.40743970870972) + 0.0553731224680923*std::sin(0.199120000004768*x_30 + 8.18671989440918) + 0.0653210374404136*std::sin(0.258879989385605*x_30 - 1.16759991645813) + 0.195424467296455*std::sin(0.268719971179962*x_30 - 1.17455983161926) + 0.024741178273041*std::sin(0.329279839992523*x_30 - 1.15023982524872) + 0.0377774237314543*std::sin(0.375839829444885*x_31 - 7.39943981170654) + 0.0283176366194332*std::sin(0.376319825649261*x_31 + 5.16775989532471) - 0.0527578914567869*std::sin(0.380639851093292*x_31 - 7.40391969680786) + 0.0507769056177432*std::sin(0.295279920101166*x_32 - 1.14495992660522) + 0.00957792716693547*std::sin(0.299279928207397*x_32 + 2.02359986305237) + 0.0499228732147184*std::sin(0.302399933338165*x_32 - 1.13367986679077) + 0.022442116839583*std::sin(0.303839921951294*x_32 - 1.13895988464355) + 0.079898696833643*std::sin(0.305679947137833*x_32 - 1.14007985591888) + 0.0212150328523343*std::sin(0.243359968066216*x_33 + 1.98735988140106) + 0.0137880385936785*std::sin(0.241119980812073*x_35 - 7.43616008758545) - 0.0363257753306801*std::sin(0.222559988498688*x_36 + 5.17360019683838) - 0.0161007550205338*std::sin(0.190160006284714*x_37 - 1.17119991779327) + 0.0121413717958343*std::sin(0.197759985923767*x_37 - 1.19143986701965) + 0.0228946970870763*std::sin(0.235199987888336*x_38 + 1.97775971889496) - 0.0492413912499487*std::sin(0.265519946813583*x_4 + 2.03111982345581) + 0.0154757116064234*std::sin(0.312879920005798*x_4 + 2.01127982139587) + 0.0901285578740628*std::sin(0.328959852457047*x_4 + 1.99927973747253) + 0.0647284947239074*std::sin(0.231519982218742*x_40 + 1.96791982650757) + 0.0245507982554225*std::sin(0.251359969377518*x_42 - 7.43455982208252) + 0.0824189043467433*std::sin(0.135360047221184*x_44 - 1.19167983531952) - 0.0113485591332506*std::sin(0.157520025968552*x_45 - 4.39479970932007) + 0.0116707824394961*std::sin(0.174560010433197*x_45 - 4.58383989334106) - 0.0697253256012475*std::sin(0.140800043940544*x_46 - 1.20887982845306) - 0.0192275666496799*std::sin(0.235679984092712*x_46 - 1.21863985061646) + 0.11631066952256*std::sin(0.201440006494522*x_47 + 1.98727989196777) - 0.0474205902651828*std::sin(0.202799990773201*x_47 - 1.19279980659485) - 0.0125606679772633*std::sin(0.23039998114109*x_47 - 1.21311986446381) - 0.0243108444328905*std::sin(0.215759992599487*x_48 - 7.39559984207153) + 0.0384550845599573*std::sin(0.280879944562912*x_49 + 8.27223968505859) + 0.00853419190008765*std::sin(0.317999929189682*x_5 + 2.01639986038208) - 0.111812463557065*std::sin(0.340559840202332*x_5 + 2.0162398815155) + 0.0322094385179212*std::sin(0.346319854259491*x_5 - 7.37375974655151) + 0.0117965179679522*std::sin(0.366399854421616*x_5 - 1.16279983520508) - 0.0291180272038621*std::sin(0.187520012259483*x_51 - 1.1943199634552) + 0.0939858575492511*std::sin(0.205520004034042*x_51 - 7.40855979919434) + 0.0053396447887561*std::sin(0.213919997215271*x_51 - 1.18455994129181) + 0.0295618089760427*std::sin(0.23879998922348*x_52 - 7.41024017333984) - 0.00508665417046528*std::sin(0.227519989013672*x_53 - 1.20567989349365) + 0.0917397172193123*std::sin(0.23047998547554*x_53 + 1.99655985832214) + 0.0687465987096935*std::sin(0.257439970970154*x_53 - 7.42767953872681) - 0.017715149567028*std::sin(0.236959978938103*x_57 + 5.15824031829834) + 0.0323709589907946*std::sin(0.326719850301743*x_6 - 1.13911986351013) - 0.0329109642346567*std::sin(0.357119828462601*x_6 + 2.00927972793579) - 0.0516967683914554*std::sin(0.3572798371315*x_6 + 1.99695980548859) - 0.0250104134732788*std::sin(0.358879864215851*x_6 + 2.01999974250793) + 0.0669209049063246*std::sin(0.385199844837189*x_6 + 1.99791979789734) - 0.060342883677684*std::sin(0.164240017533302*x_60 + 1.97215986251831) + 0.00859255347361909*std::sin(0.329279839992523*x_60 - 4.29544019699097) + 0.0194724354377387*std::sin(0.369679838418961*x_60 + 5.03895950317383) - 0.0169463725522205*std::sin(0.399279862642288*x_60 - 4.38207960128784) + 0.0133415126172538*std::sin(0.455599844455719*x_60 - 1.2824798822403) - 0.0181377914684094*std::sin(0.178480014204979*x_61 - 4.41824007034302) - 0.0291370396702814*std::sin(0.326879858970642*x_7 + 2.02199983596802) + 0.0755433887283131*std::sin(0.332559853792191*x_7 + 2.04583978652954) - 0.0174398871156089*std::sin(0.348159849643707*x_7 + 2.00615978240967) - 0.186116528827781*std::sin(0.355439841747284*x_7 + 2.00423979759216) + 0.0225095441442199*std::sin(0.307679921388626*x_8 + 5.17511987686157) - 0.00982791503879877*std::sin(0.311919927597046*x_8 - 4.23727989196777) - 0.0204369364674716*std::sin(0.315839916467667*x_8 - 7.43063974380493) + 0.00659987710945628*std::sin(0.317199915647507*x_8 - 4.23792028427124) - 0.0160944156472107*std::sin(0.262799948453903*x_9 + 1.97775971889496) - 0.10529723635053*std::sin(0.316639930009842*x_9 - 7.43160009384155) - 0.0178636290150379*std::sin(0.326159834861755*x_9 + 8.27543926239014) + 0.010303070249562*std::sin(0.345359832048416*x_91 - 7.39999961853027) - 0.0987103550245818*std::sin(0.351599842309952*x_91 - 7.40375995635986) - 0.0233379908464188*std::sin(0.362559854984283*x_91 + 2.00079965591431) + 0.0251829105916444*std::sin(0.366399854421616*x_91 - 7.41015958786011) - 0.00375568677643327*std::sin(0.375439822673798*x_91 - 1.18063986301422) + 0.00617123890715517*std::sin(0.28399994969368*x_92 - 1.16303980350494) + 0.0409839579290244*std::sin(0.289679944515228*x_92 + 1.99175977706909) + 0.0278241608377761*std::sin(0.298319935798645*x_92 + 1.99519979953766) + 0.0399168797175733*std::sin(0.282799929380417*x_94 - 7.43056011199951) - 0.0286029015504532*std::sin(0.288399934768677*x_94 + 1.98655986785889) - 0.0121266686287265*std::sin(0.293759942054749*x_94 + 1.98631989955902) - 0.0346584233475164*std::sin(0.259359985589981*x_95 - 7.42392015457153) - 0.0076590460579508*std::sin(0.27703994512558*x_95 - 7.43056011199951) - 0.00748557852391242*std::sin(0.27143993973732*x_97 + 1.98071980476379) + 0.0329352540523654*std::sin(0.276159942150116*x_97 - 1.20687985420227) + 0.0107047963313479*std::sin(0.280559957027435*x_97 + 1.96655988693237) - 0.273294420948612);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
