
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (9.76798992396337e-7*x_1 + 8.52680935501737e-9*x_10 + 7.92609409571147e-8*x_100 - 1.40532077889056e-6*x_101 - 3.52547091039361e-7*x_102 - 1.65842052659453e-6*x_103 - 2.32129037660886e-6*x_104 + 6.35801189733342e-8*x_105 + 1.99803820705269e-6*x_106 - 1.750598310175e-6*x_107 + 9.32368327479775e-7*x_108 - 1.78270179672852e-6*x_109 - 9.29620914315627e-7*x_11 - 4.36608019344015e-7*x_110 - 9.83028837690687e-7*x_111 + 8.54030552129262e-7*x_112 + 1.64486561925629e-6*x_113 - 4.3467103102232e-7*x_114 - 5.54123090263616e-7*x_115 - 1.22211153632227e-6*x_116 - 1.15167249089257e-7*x_117 - 8.59128769731069e-8*x_118 - 4.87367268573322e-7*x_119 + 1.64869964529565e-6*x_12 - 6.59047673887784e-7*x_120 + 1.28240187996612e-6*x_13 - 1.33378981915256e-6*x_14 + 7.30712804117007e-7*x_15 - 1.79381495782779e-6*x_16 - 1.928719869415e-6*x_17 - 4.69586356785028e-7*x_18 - 3.8992041491204e-8*x_19 + 1.18104093883282e-6*x_2 + 3.24698703349328e-6*x_20 + 9.17675768442998e-8*x_21 - 2.07508552687861e-7*x_22 + 1.23533154677835e-6*x_23 - 1.29822518226251e-7*x_24 + 5.27558677891377e-8*x_25 + 7.42395157625125e-7*x_26 + 1.15930666600048e-7*x_27 + 2.41621271583788e-8*x_28 - 3.77612743547902e-7*x_29 - 8.76980431774113e-8*x_3 + 2.56843448095591e-6*x_30 - 3.15161162760835e-5*x_31 - 7.45136809394819e-7*x_32 - 1.40837369603301e-6*x_33 + 4.6845716978485e-7*x_34 + 3.08311249137133e-8*x_35 - 5.60751257805579e-6*x_36 - 2.75631869924841e-6*x_37 + 9.57601912546286e-7*x_38 - 2.22618544983645e-6*x_39 + 9.5355257955106e-8*x_4 + 2.79597661038832e-7*x_40 - 1.70714809519504e-6*x_41 + 4.96388964841531e-7*x_42 + 1.17887853267439e-6*x_43 + 2.19250611181903e-6*x_44 + 3.09763433917531e-6*x_45 - 6.52245279819542e-8*x_46 - 1.49788572179171e-7*x_47 + 2.37919742427538e-6*x_48 - 2.63175509375979e-7*x_49 + 9.70100201362237e-8*x_5 - 1.17877146737304e-6*x_50 - 1.31758484387028e-6*x_51 - 1.05107524461351e-6*x_52 - 2.86600407271286e-7*x_53 + 2.63501226265961e-6*x_54 + 1.27182947752072e-7*x_55 - 1.34880418122336e-6*x_56 + 9.70721504586479e-7*x_57 + 3.87505349807737e-8*x_58 - 3.53225211401095e-7*x_59 - 3.10914344103329e-7*x_6 - 5.0606527624305e-7*x_60 + 7.76628334917181e-7*x_61 + 1.19773442393773e-6*x_62 + 6.31887470638643e-7*x_63 + 7.91761734493418e-7*x_64 + 1.79579630485887e-6*x_65 - 2.87466548829207e-6*x_66 + 2.08366074302598e-6*x_67 - 1.17612072944452e-7*x_68 + 1.13000436278764e-6*x_69 - 5.86971779474554e-7*x_7 + 2.95528784614625e-7*x_70 + 1.93354023492116e-7*x_71 + 1.16000235814657e-6*x_72 + 9.57734504712682e-7*x_73 + 4.36231056863777e-7*x_74 - 2.69076941631938e-7*x_75 - 4.77962181467223e-7*x_76 - 1.77824311096631e-7*x_77 + 8.26957684853585e-7*x_78 + 4.1750136280033e-7*x_79 - 1.44121008209026e-6*x_8 + 2.51031969243626e-7*x_80 + 2.74280829527924e-6*x_81 - 2.54297494776665e-7*x_82 + 2.7183309268478e-7*x_83 + 2.88665861858246e-8*x_84 - 1.1859638268244e-7*x_85 - 3.18521537831552e-7*x_86 + 1.32691716045078e-7*x_87 + 2.29797287635402e-7*x_88 + 3.17654864303342e-7*x_89 + 1.033350642951e-7*x_9 - 2.33881173170449e-7*x_90 + 3.85987936908384e-5*x_91 + 5.51171509758206e-7*x_92 - 7.32797925294365e-6*x_93 - 1.09779651002131e-6*x_94 - 1.52447048856566e-7*x_95 - 3.66381583472772e-7*x_96 + 4.94763831155001e-7*x_97 + 3.21743963846278e-7*x_98 + 1.10137785453679e-8*x_99 + 5.01440318825592e-10*std::pow(-5.49200010299683*x_48 - 8.94799995422363, 2) + 1.65500946640183e-5*std::sin(0.327279835939407*x_1 + 1.424959897995) - 5.57424603499335e-6*std::sin(0.315999925136566*x_32 + 7.97824001312256) - 1.81386592554039e-7*std::sin(0.470959842205048*x_58 - 7.32839965820313) + 4.00679155494602e-5*std::sin(0.42375984787941*x_92 + 1.57359981536865) - 1.66902589532755e-5*std::sin(0.375199824571609*x_93 - 4.79816007614136) + 3.05596449715609e-7*std::sin(0.479359865188599*x_97 + 2.02711987495422) + 0.0640498645313252);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.14714187697227e-6*x_1 - 3.55165844874904e-6*x_10 - 5.2842523711385e-7*x_100 - 9.0783574281128e-8*x_101 + 9.48072810629288e-7*x_102 + 1.18579796690164e-6*x_103 + 8.23566190141216e-8*x_104 - 1.06745345191807e-6*x_105 - 3.23448548737744e-6*x_106 - 1.01534493100379e-6*x_107 - 3.60015465771372e-7*x_108 + 2.64783265559466e-7*x_109 - 8.15674032983647e-7*x_11 - 5.34209061148647e-6*x_110 - 1.42002763559286e-6*x_111 + 3.02929884691307e-6*x_112 - 1.46993373914714e-6*x_113 - 1.27977115062664e-7*x_114 + 5.82486977281478e-7*x_115 + 3.29776777329242e-6*x_116 + 1.45199832921468e-6*x_117 - 3.50850349570146e-6*x_118 + 6.99096321483401e-7*x_119 - 4.80315558902958e-7*x_12 + 2.44027688114493e-7*x_120 - 2.38310920164715e-6*x_13 + 2.32688734423554e-6*x_14 - 2.96149852382523e-8*x_15 + 1.96528481577624e-6*x_16 + 1.7625288900251e-6*x_17 - 5.2490462112329e-7*x_18 - 1.18417491981823e-6*x_19 - 5.16016422706201e-6*x_2 - 4.73436002028381e-6*x_20 - 5.93371996697577e-7*x_21 + 1.7569259920364e-6*x_22 - 1.04991176451114e-6*x_23 + 2.7937139759712e-7*x_24 + 3.79553449354072e-7*x_25 - 7.28223396543716e-7*x_26 + 1.33289479497327e-6*x_27 - 6.17720294279865e-8*x_28 - 8.82926090450012e-7*x_29 + 2.11556304097461e-6*x_3 - 3.04220706733124e-6*x_30 - 6.32062470565678e-5*x_31 - 4.09772754969887e-6*x_32 + 1.30228619430671e-6*x_33 + 4.80627876560359e-6*x_34 + 5.20648346145258e-6*x_35 + 4.85735413629007e-7*x_36 + 1.25666681610889e-6*x_37 - 3.01663187237178e-6*x_38 - 1.67324445832477e-6*x_39 + 1.13421621622684e-6*x_4 - 1.43052600334365e-6*x_40 - 1.57541856332902e-6*x_41 - 4.36430385575547e-7*x_42 + 9.10541191237213e-7*x_43 + 7.81673757076696e-7*x_44 - 2.35094183504062e-6*x_45 - 2.78446699335976e-7*x_46 + 1.34344622858816e-6*x_47 - 2.16101864494984e-6*x_48 + 1.41316747961817e-6*x_49 + 3.55826513221122e-6*x_5 + 1.48141051965313e-6*x_50 + 1.85020513610583e-6*x_51 - 1.92644377828778e-6*x_52 + 1.24219272969933e-7*x_53 - 3.10324530713576e-6*x_54 + 1.22865260873888e-7*x_55 + 2.19506888165155e-6*x_56 + 1.1841323129976e-6*x_57 - 5.56876986017721e-8*x_58 - 1.70727505771526e-7*x_59 - 1.2510873147142e-7*x_6 + 2.07700788398371e-6*x_60 + 1.75526481731653e-7*x_61 - 1.21589046046615e-6*x_62 + 1.35592778124704e-6*x_63 - 9.59329973028941e-7*x_64 + 3.47716322970601e-6*x_65 - 7.60255859830099e-7*x_66 - 1.7326880116583e-6*x_67 + 1.14617561263338e-6*x_68 - 2.08816665420492e-6*x_69 - 1.57772516380966e-7*x_7 + 8.99151739397405e-8*x_70 - 1.51536462971144e-6*x_71 - 2.86063964815683e-6*x_72 + 4.37626650808605e-7*x_73 + 2.15232615529098e-6*x_74 - 9.596340854087e-8*x_75 - 1.38513491678207e-6*x_76 - 8.78111160768864e-7*x_77 - 1.44242156820565e-6*x_78 - 3.94882231777624e-7*x_79 + 2.82782570855927e-6*x_8 + 1.14872509715036e-6*x_80 - 3.4704236304805e-6*x_81 - 2.06035952851781e-7*x_82 - 8.32044792665167e-7*x_83 + 7.34831220095533e-7*x_84 + 6.47303772174379e-7*x_85 - 1.9262461755972e-7*x_86 + 6.76643647706704e-7*x_87 + 2.06117607627134e-6*x_88 + 3.39347955493292e-7*x_89 - 3.6737670103055e-6*x_9 + 1.63877012826304e-6*x_90 + 1.04627711131161e-5*x_91 + 2.22905327517863e-7*x_92 + 1.46662923033323e-6*x_93 - 5.51668798501673e-6*x_94 + 1.19224538751645e-6*x_95 + 5.30360175634594e-7*x_96 - 1.45981774726973e-6*x_97 + 1.14259588223569e-6*x_98 + 1.29770139528573e-6*x_99 + 7.06775380689335e-9*std::pow(-5.49200010299683*x_48 - 8.94799995422363, 2) - 0.000132299190415878*std::exp(0.000606815983836757*x_1 + 0.000304943273838306*x_10 + 0.00323833827963234*x_100 - 0.00162966713758864*x_101 + 0.000214178195510426*x_102 - 0.000602313027438822*x_103 - 0.00429209142525182*x_104 - 0.00124366091946374*x_105 - 0.000399798342002642*x_106 - 0.000305996671228533*x_107 - 0.000227282127898409*x_108 + 0.00111953836254851*x_109 - 0.0018417482838407*x_11 - 0.00217308829054326*x_110 + 0.000279954597167567*x_111 + 0.00269471073030092*x_112 + 0.00271753402624536*x_113 - 0.000344755036102085*x_114 - 0.000267372446283153*x_115 + 0.00208446076020329*x_116 + 0.00144530994001586*x_117 - 9.48510621418255e-5*x_118 - 0.0030556603621594*x_119 + 0.00401331981800741*x_12 + 0.00257501936061467*x_120 + 0.000207982721729241*x_13 - 0.00255773725632195*x_14 + 0.00227401454127257*x_15 - 0.00495119993167907*x_16 + 0.0016642746116157*x_17 - 2.34035646854141e-5*x_18 - 0.00270929650714981*x_19 + 0.00428930106992593*x_2 + 0.00496534740933383*x_20 - 0.000324346613429601*x_21 - 4.19898891122341e-5*x_22 + 0.00122256939843211*x_23 - 0.00169609904745161*x_24 + 0.000245093615042978*x_25 - 0.000342469579238402*x_26 + 0.00413752468578285*x_27 - 0.00117694313596627*x_28 - 7.66031174498451e-5*x_29 - 0.00197401307359137*x_3 + 0.00288435105011497*x_30 + 0.0219764184356595*x_31 + 0.000898873863619525*x_32 - 0.00223705334462327*x_33 + 0.000903831084172886*x_34 + 0.00369359016009691*x_35 + 0.000113034841778127*x_36 + 0.000710116589507039*x_37 - 0.00141858954840218*x_38 - 0.00079029428190264*x_39 - 0.000393059405019077*x_4 - 0.000886724247473593*x_40 - 0.00128991543348416*x_41 - 0.000175671962516618*x_42 - 0.00183527231626537*x_43 + 0.00378605033746578*x_44 - 0.000303736491847566*x_45 + 0.000227838162712988*x_46 - 0.00035132790688736*x_47 - 0.00214663196444113*x_48 - 0.000446103613192643*x_49 + 0.000108523565753695*x_5 - 0.000415287130243452*x_50 + 0.00240929947246852*x_51 + 0.00331644675886247*x_52 - 0.000910781003776689*x_53 + 0.00704925816796199*x_54 + 0.000497696662536081*x_55 + 0.000304948596073842*x_56 + 0.00588902892761526*x_57 + 0.00675639478492869*x_58 + 0.00316091639529102*x_59 + 0.000355960138274207*x_6 - 0.000460290384481596*x_60 - 0.00494279819792577*x_61 + 0.00132335076120218*x_62 + 0.00157669395471923*x_63 + 0.00735927587543361*x_64 + 0.000890909717771173*x_65 - 0.000693542996333492*x_66 + 0.000400578679911903*x_67 + 0.000304558290237031*x_68 + 0.00319208257182504*x_69 + 0.00659193840685429*x_7 + 0.000545183967283757*x_70 - 0.00172884091046312*x_71 - 0.00166246984451359*x_72 + 0.00361595778144777*x_73 - 7.83885901856216e-5*x_74 - 0.00036191286742471*x_75 - 0.000805167894038626*x_76 + 0.000305499941320459*x_77 - 0.00298151366354763*x_78 + 0.0018654739229805*x_79 - 0.00624703912995148*x_8 - 0.00104332421794442*x_80 + 0.000204149801814025*x_81 - 0.000551360718684864*x_82 - 0.00238080599459302*x_83 - 0.00255449260414158*x_84 - 0.00162264829603038*x_85 + 0.000411726101466092*x_86 + 0.00106589480741675*x_87 - 0.00187848539853061*x_88 - 0.000943609959972888*x_89 + 0.00863653079237624*x_9 - 0.000305524804002876*x_90 - 0.00347868561638029*x_91 + 0.00482693634296843*x_92 + 0.00213785349928086*x_93 + 0.000668767984069961*x_94 + 0.00348853547533757*x_95 + 0.00058375195775178*x_96 - 0.00546291531049364*x_97 - 0.000413467774652516*x_98 + 0.000681662792723504*x_99) - 2.03680570062489e-5*std::sin(0.327279835939407*x_1 + 1.424959897995) + 7.93591753433273e-5*std::sin(0.315999925136566*x_32 + 7.97824001312256) - 2.55662684453804e-6*std::sin(0.470959842205048*x_58 - 7.32839965820313) - 1.40208740525233e-5*std::sin(0.42375984787941*x_92 + 1.57359981536865) - 0.000235247619360416*std::sin(0.375199824571609*x_93 - 4.79816007614136) + 4.30735301841937e-6*std::sin(0.479359865188599*x_97 + 2.02711987495422) + 0.0729508136589708);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.15870802543731e-6*x_1 - 1.14203158604748e-6*x_10 + 1.10300157191352e-6*x_100 - 4.84201482883005e-7*x_101 - 9.26531600457977e-7*x_102 - 1.21683713287014e-6*x_103 - 6.06737103166833e-8*x_104 + 2.04090749782612e-6*x_105 + 2.44951833936201e-6*x_106 + 4.23180625804914e-7*x_107 + 1.16357919358517e-6*x_108 - 1.20919812971277e-6*x_109 - 1.07663200793151e-7*x_11 - 1.07648437715067e-6*x_110 + 1.04256334707778e-6*x_111 + 4.5618865966071e-7*x_112 + 8.41316988005615e-7*x_113 - 9.48767938274496e-7*x_114 + 7.18872993438495e-8*x_115 - 6.86918842957985e-7*x_116 - 8.80190144002503e-7*x_117 + 6.98574141629362e-7*x_118 + 1.47309446066788e-6*x_119 - 1.45670284572587e-6*x_12 - 7.55625822105774e-7*x_120 + 7.89355019321439e-7*x_13 + 1.10883950726441e-6*x_14 + 4.46812966858978e-7*x_15 - 1.57187211438396e-6*x_16 + 1.3838311425399e-6*x_17 + 6.73845351841066e-7*x_18 - 3.12937381199203e-7*x_19 - 5.09213652074152e-8*x_2 + 1.30285855190203e-6*x_20 - 1.23079055847836e-6*x_21 + 1.00046027914129e-6*x_22 - 2.76951279043503e-7*x_23 + 6.32947896174043e-7*x_24 + 4.67796376996053e-7*x_25 - 5.57014140710082e-7*x_26 - 1.19203410384011e-6*x_27 + 2.53340455044883e-7*x_28 - 4.5188976268664e-7*x_29 + 2.98080058690431e-7*x_3 - 6.61035169352185e-7*x_30 - 3.35000746057384e-5*x_31 - 3.80192264804961e-6*x_32 + 4.26215919292913e-7*x_33 + 3.29613936819033e-7*x_34 + 3.48128560250687e-6*x_35 + 2.75260888736427e-6*x_36 + 8.2635892067532e-7*x_37 + 1.44465869340939e-8*x_38 + 2.75594710392538e-6*x_39 + 1.43100151738261e-7*x_4 + 5.96911315702515e-7*x_40 + 4.3289786799341e-8*x_41 + 2.58619374617959e-7*x_42 + 6.48675089359675e-7*x_43 - 2.11670449397416e-6*x_44 + 3.51169641712e-7*x_45 - 7.20099641047365e-7*x_46 + 1.09181488345771e-7*x_47 - 1.19299230182252e-6*x_48 + 2.09070457557003e-7*x_49 + 1.2448999751935e-6*x_5 + 1.36005493297851e-6*x_50 - 7.19946336055703e-7*x_51 - 9.59577580045684e-7*x_52 - 2.73357914015015e-7*x_53 - 1.33110446082562e-8*x_54 - 1.21074795055034e-6*x_55 - 8.58375507673847e-7*x_56 - 1.9588267878175e-8*x_57 - 3.68825292412659e-6*x_58 + 2.79969078501413e-7*x_59 - 1.27483332501013e-8*x_6 + 4.45876454748897e-7*x_60 - 1.93092875900822e-6*x_61 + 6.20679962192187e-7*x_62 + 6.15667690964212e-7*x_63 - 1.92968981911781e-6*x_64 + 5.09293296571237e-7*x_65 + 9.47088923287426e-7*x_66 + 2.50144613644265e-6*x_67 + 2.35522323235183e-6*x_68 + 6.45162250207538e-7*x_69 + 1.11615842653545e-7*x_7 + 1.05346943429207e-6*x_70 + 1.82067199449872e-7*x_71 + 2.38349845762989e-6*x_72 - 5.702183782619e-7*x_73 - 8.34714474926442e-8*x_74 - 1.04967738347441e-6*x_75 + 3.55394513851341e-8*x_76 - 1.97054184840552e-8*x_77 + 5.83953712938576e-7*x_78 + 4.66697576484508e-7*x_79 + 4.21527637740816e-7*x_8 + 5.25158828347687e-7*x_80 + 1.58235692733838e-6*x_81 - 1.35801091594142e-6*x_82 - 5.70941138462717e-7*x_83 + 8.45426361149525e-7*x_84 - 5.7034294765091e-7*x_85 + 1.12773296403795e-7*x_86 - 3.42102390424801e-7*x_87 - 9.87740771160832e-8*x_88 + 1.01688296599771e-6*x_89 - 1.37134637405085e-6*x_9 - 1.14243124151781e-7*x_90 + 3.22341468691977e-5*x_91 - 8.00829787439494e-7*x_92 + 3.049044766212e-6*x_93 + 1.14822025486874e-6*x_94 - 2.62723123038241e-7*x_95 - 1.38128846445997e-6*x_96 - 2.60309568225607e-6*x_97 + 3.32993153921655e-9*x_98 - 9.88627292012329e-7*x_99 + 3.29324839035948e-11*std::pow(-5.49200010299683*x_48 - 8.94799995422363, 2) + 1.29986401767146e-5*std::sin(0.327279835939407*x_1 + 1.424959897995) + 5.44676077481813e-5*std::sin(0.315999925136566*x_32 + 7.97824001312256) - 1.1912705890113e-8*std::sin(0.470959842205048*x_58 - 7.32839965820313) + 3.31862674893754e-5*std::sin(0.42375984787941*x_92 + 1.57359981536865) - 1.09614576987526e-6*std::sin(0.375199824571609*x_93 - 4.79816007614136) + 2.00702851035706e-8*std::sin(0.479359865188599*x_97 + 2.02711987495422) + 0.0676550327797035);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.72904624957053e-6*x_1 - 1.50257183574651e-6*x_10 + 3.27873664365934e-6*x_100 - 2.09278217916954e-6*x_101 + 1.78476238469297e-7*x_102 - 1.1120860030589e-6*x_103 - 1.82783327169336e-6*x_104 + 2.91645590856028e-6*x_105 - 9.08346970250721e-7*x_106 - 1.91162150730899e-6*x_107 + 3.51437220806649e-6*x_108 - 2.20895733195136e-6*x_109 - 1.39948946200252e-7*x_11 - 3.08663990467657e-6*x_110 + 1.88476008591599e-7*x_111 + 2.23307582342434e-6*x_112 + 2.2225996408692e-6*x_113 - 1.31010718290537e-7*x_114 - 1.41951076974171e-6*x_115 - 1.66775000162457e-6*x_116 - 7.16545409258346e-7*x_117 - 6.8545315640705e-7*x_118 - 4.42402462089398e-7*x_119 - 4.04524296541361e-8*x_12 - 1.01803936288217e-6*x_120 - 3.82508199996663e-8*x_13 + 9.98916951322756e-7*x_14 - 2.20802809897985e-7*x_15 + 2.52051882400155e-7*x_16 + 2.87478691050637e-6*x_17 - 3.25825617327566e-7*x_18 - 4.0552653491507e-8*x_19 + 1.41324631579517e-6*x_2 + 3.5680263521726e-6*x_20 - 1.06626676279236e-6*x_21 + 1.54596101732172e-6*x_22 - 4.72084667042305e-8*x_23 + 5.01430961889608e-7*x_24 + 1.07817788063043e-7*x_25 + 8.1804839002702e-7*x_26 + 1.88894650383496e-7*x_27 + 1.98476533710209e-6*x_28 + 3.60256283210951e-7*x_29 + 5.58786415687145e-7*x_3 + 1.19756008621018e-7*x_30 - 2.10866445611907e-5*x_31 - 8.10339629360771e-7*x_32 - 9.46798515357666e-7*x_33 + 2.77172325175248e-6*x_34 + 5.545957530455e-7*x_35 + 3.18743083841509e-6*x_36 + 1.61786395148984e-6*x_37 + 1.35457509890606e-7*x_38 + 5.04098711447465e-6*x_39 - 1.00836262378971e-8*x_4 + 2.11138547212203e-6*x_40 - 1.80653758905385e-7*x_41 + 1.86775049272094e-6*x_42 + 7.57339425558973e-7*x_43 - 1.16264793142598e-6*x_44 - 2.38813778728566e-6*x_45 - 1.84365839803378e-6*x_46 + 5.42018371894807e-7*x_47 - 1.30597014156412e-6*x_48 + 2.0198321632434e-6*x_49 + 2.70504568404685e-6*x_5 + 6.91285142345632e-7*x_50 - 1.53339258035913e-6*x_51 - 7.30987215426673e-7*x_52 - 6.74365058467256e-7*x_53 + 3.60433843209202e-6*x_54 - 1.78020700673169e-6*x_55 - 8.91030946489319e-8*x_56 + 2.2387066331655e-6*x_57 - 6.64523972431856e-7*x_58 + 6.81669648697596e-7*x_59 + 6.5998420006309e-7*x_6 + 4.70598974910607e-7*x_60 - 4.91963577640788e-6*x_61 + 5.06738996278917e-8*x_62 + 1.41150275033566e-6*x_63 + 6.99083657178456e-7*x_64 + 1.82692342358708e-6*x_65 + 1.58751378421414e-7*x_66 + 4.83746316459462e-7*x_67 + 2.17413985784646e-6*x_68 + 1.30751108670498e-6*x_69 + 1.84366724366073e-6*x_7 - 1.64637746346979e-6*x_70 - 4.58665235778473e-8*x_71 + 6.7624196940845e-8*x_72 + 1.23568756475604e-7*x_73 + 1.11823273458795e-6*x_74 - 1.01764953953723e-6*x_75 + 5.14730414671718e-7*x_76 - 1.72194024408756e-6*x_77 - 4.33198305827308e-7*x_78 - 1.81747519166523e-7*x_79 + 3.3980969037867e-6*x_8 + 2.14247632188564e-6*x_80 + 2.2887714056171e-7*x_81 - 1.1210470098647e-6*x_82 - 3.89465240942749e-6*x_83 + 1.25547192626471e-6*x_84 - 9.13305475156864e-7*x_85 - 1.44890556695873e-6*x_86 + 5.49783856287886e-7*x_87 - 8.89365910024313e-7*x_88 + 6.60747896884997e-7*x_89 - 1.04294056789697e-6*x_9 - 1.8608348512996e-7*x_90 + 1.76850195246578e-5*x_91 - 6.31309966936334e-7*x_92 + 3.51973252162621e-6*x_93 - 9.75687491496511e-7*x_94 - 2.14539350870001e-6*x_95 - 1.60962650210251e-6*x_96 + 7.10332876213886e-7*x_97 - 3.42946362548443e-7*x_98 - 1.47456446342081e-6*x_99 + 2.23433729821448e-9*std::pow(-5.49200010299683*x_48 - 8.94799995422363, 2) + 1.56041331395486e-5*std::sin(0.327279835939407*x_1 + 1.424959897995) - 7.24503405728522e-6*std::sin(0.315999925136566*x_32 + 7.97824001312256) - 8.08229442117285e-7*std::sin(0.470959842205048*x_58 - 7.32839965820313) + 9.69172986774352e-5*std::sin(0.42375984787941*x_92 + 1.57359981536865) - 7.43691057462258e-5*std::sin(0.375199824571609*x_93 - 4.79816007614136) + 1.36168856026713e-6*std::sin(0.479359865188599*x_97 + 2.02711987495422) + 0.0672007833067418);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-5.28775508368634e-7*x_1 + 1.21356141208127e-6*x_10 + 9.04835999825167e-7*x_100 - 2.84089359958243e-7*x_101 - 1.3111509291461e-6*x_102 - 2.16531900366421e-6*x_103 - 1.1559545799738e-6*x_104 + 4.38817160677302e-8*x_105 + 6.92518117260516e-6*x_106 + 4.09121312039508e-6*x_107 - 2.06973308411023e-6*x_108 + 1.10941067960964e-6*x_109 - 4.43207631516058e-7*x_11 + 2.99470837436565e-7*x_110 + 5.14373084333805e-6*x_111 - 5.69675758256319e-7*x_112 + 2.10187716882675e-6*x_113 - 1.82177173519244e-6*x_114 + 1.48215713287792e-7*x_115 - 5.51337072431814e-6*x_116 + 7.22644670331248e-7*x_117 + 1.08663589773608e-6*x_118 - 7.90409167278069e-7*x_119 + 2.44484479174887e-6*x_12 - 9.42917414389183e-7*x_120 + 4.55459908773453e-6*x_13 - 2.33341243860339e-6*x_14 + 6.99634251648865e-7*x_15 - 4.30985518903538e-6*x_16 + 7.46261642851123e-7*x_17 + 9.27383343613967e-8*x_18 - 6.49642520874379e-7*x_19 - 1.06143781580684e-7*x_2 + 6.02668795196252e-6*x_20 + 2.13290476610303e-7*x_21 - 2.64530243054299e-7*x_22 + 1.22031049367597e-6*x_23 + 2.43298659146966e-7*x_24 + 1.42006002081795e-6*x_25 - 2.02862565083075e-6*x_26 + 5.41459628975733e-7*x_27 - 1.47831731037887e-6*x_28 + 8.82156269214803e-7*x_29 - 3.04675481470422e-6*x_3 + 3.83060649523609e-6*x_30 - 9.52018730606844e-5*x_31 + 4.70718355508181e-6*x_32 - 4.94291187644628e-7*x_33 - 7.48827610268264e-7*x_34 + 5.14539693779007e-6*x_35 + 2.04531589845857e-6*x_36 - 1.16427795908933e-6*x_37 + 3.18858909349187e-6*x_38 - 3.05054409110957e-6*x_39 - 1.13247477769149e-6*x_4 - 2.0342574117244e-6*x_40 - 1.56552059514623e-6*x_41 - 3.97184398556551e-7*x_42 + 2.10114289595805e-6*x_43 - 8.49016746656901e-7*x_44 + 4.26426872754695e-6*x_45 + 1.09899205334627e-6*x_46 - 1.42712908214329e-6*x_47 - 2.37047919078541e-6*x_48 - 2.34444983462528e-6*x_49 + 1.0140825972428e-6*x_5 + 4.49680720942796e-9*x_50 - 2.39765569918751e-6*x_51 + 5.6653944271862e-7*x_52 - 3.6548726575616e-7*x_53 + 4.10156845971529e-6*x_54 + 1.89783117930518e-6*x_55 - 3.79554161408155e-6*x_56 + 1.02829647174959e-6*x_57 + 2.89753623488598e-8*x_58 + 1.91170869860337e-6*x_59 - 3.26423093679478e-6*x_6 - 6.46460516080226e-8*x_60 - 2.2729118569398e-6*x_61 + 3.1903501108221e-6*x_62 + 7.17836322174176e-7*x_63 + 2.3164578903419e-6*x_64 + 4.19386511438335e-6*x_65 + 1.30286851018405e-6*x_66 + 5.27791291636772e-6*x_67 - 1.66655685111833e-6*x_68 + 2.48209395505105e-6*x_69 + 3.59476736469413e-6*x_7 + 2.59393175419408e-7*x_70 - 4.02784031656457e-7*x_71 + 2.26662953804628e-6*x_72 + 5.41846256003004e-7*x_73 + 1.43500927336042e-6*x_74 + 5.65838931220316e-8*x_75 - 3.83113715638996e-7*x_76 + 9.23695915290769e-8*x_77 - 1.16069954471869e-6*x_78 + 1.48111173051593e-6*x_79 - 6.81764031899475e-7*x_8 - 9.23579945637114e-7*x_80 + 6.27328395309356e-6*x_81 + 2.18366179094422e-7*x_82 + 2.81774105102479e-6*x_83 + 4.70579530960597e-7*x_84 + 5.19913147316138e-7*x_85 + 1.30944679683676e-6*x_86 + 5.37750488019554e-7*x_87 - 8.90869274825646e-7*x_88 - 8.14669086544559e-9*x_89 + 3.40581903823968e-6*x_9 - 6.77787951795929e-8*x_90 + 0.000104704053377897*x_91 + 8.93705401772951e-7*x_92 + 1.97387535283095e-6*x_93 - 1.09840270111669e-7*x_94 + 1.57684274497077e-6*x_95 - 2.4417649663137e-6*x_96 + 3.01768151150122e-7*x_97 - 3.66333166148654e-7*x_98 - 1.80789181360797e-7*x_99 + 6.09806469106114e-11*std::pow(-5.49200010299683*x_48 - 8.94799995422363, 2) + 3.02934079808962e-5*std::sin(0.327279835939407*x_1 + 1.424959897995) + 2.63504184215584e-5*std::sin(0.315999925136566*x_32 + 7.97824001312256) - 2.20586006740794e-8*std::sin(0.470959842205048*x_58 - 7.32839965820313) + 7.85574521984511e-6*std::sin(0.42375984787941*x_92 + 1.57359981536865) - 2.02971869206705e-6*std::sin(0.375199824571609*x_93 - 4.79816007614136) + 3.71638827146758e-8*std::sin(0.479359865188599*x_97 + 2.02711987495422) + 0.0487442604086483);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.01928126868492e-6*x_1 - 6.38651381542558e-7*x_10 + 1.5325813146692e-7*x_100 + 2.84630663813878e-7*x_101 - 4.00036095090355e-7*x_102 - 5.59377029611852e-7*x_103 - 8.6092195733095e-7*x_104 + 1.4457642454998e-7*x_105 + 2.83861633844192e-6*x_106 + 1.16783433148758e-6*x_107 - 2.44339492138849e-7*x_108 - 7.15351425911875e-7*x_109 + 4.80578390858273e-8*x_11 - 2.14066304834405e-6*x_110 - 1.78133670554546e-8*x_111 - 5.80494768105153e-7*x_112 - 3.45178140205081e-8*x_113 - 5.44165825222613e-7*x_114 - 5.33908265572887e-7*x_115 + 2.1986484419328e-6*x_116 + 3.40481388022955e-8*x_117 + 1.76629413423307e-7*x_118 + 9.18045559793257e-7*x_119 - 1.02721275883063e-6*x_12 - 1.90029338205932e-7*x_120 + 1.12122361586195e-7*x_13 + 1.0374227240109e-6*x_14 + 1.30121574720019e-6*x_15 - 2.47296649793435e-6*x_16 + 7.6815257793759e-7*x_17 - 6.33792758237989e-7*x_18 - 1.03241923286408e-6*x_19 - 7.22926991131627e-7*x_2 - 5.1659125979476e-7*x_20 - 1.19579254313611e-6*x_21 + 9.78095787747735e-7*x_22 + 4.07829862771114e-7*x_23 + 9.11942778852023e-8*x_24 + 7.52192092178811e-7*x_25 - 1.76220889801869e-6*x_26 - 3.13362043711575e-7*x_27 + 2.38864868417923e-7*x_28 - 3.94257451377257e-7*x_29 - 7.17761770498355e-7*x_3 - 5.62367505301847e-7*x_30 - 2.98106914359045e-5*x_31 - 6.65945940548394e-6*x_32 + 3.7028617139841e-7*x_33 - 6.7335173300654e-9*x_34 + 3.65065348608509e-6*x_35 + 8.44794600653984e-7*x_36 + 8.76194435809916e-8*x_37 - 4.22681665934429e-7*x_38 - 6.36846035373055e-7*x_39 - 4.47973407760247e-9*x_4 - 2.86042141452906e-7*x_40 - 9.88998981119508e-7*x_41 - 1.14681553625087e-6*x_42 + 4.61197456989961e-7*x_43 - 8.9854928845014e-7*x_44 - 2.2119271405116e-6*x_45 - 9.08773571674829e-7*x_46 + 2.96896790481131e-7*x_47 - 1.8297752195176e-6*x_48 + 3.843828459272e-8*x_49 + 5.30430116480199e-7*x_5 + 1.30453473007362e-6*x_50 + 1.07782747838519e-6*x_51 - 7.26600985550932e-7*x_52 + 3.31166018053914e-7*x_53 - 2.57542685029217e-6*x_54 - 4.52131919049899e-7*x_55 - 1.12940192732375e-6*x_56 + 4.66752364926592e-7*x_57 - 4.20084486369956e-6*x_58 - 1.99868779472179e-7*x_59 - 3.14734386730531e-7*x_6 - 3.64179444615993e-7*x_60 + 1.98297444146894e-6*x_61 + 1.73751748410967e-9*x_62 + 1.47365032463635e-6*x_63 - 1.80132902508093e-7*x_64 + 1.7879082199698e-6*x_65 + 4.34409716137635e-7*x_66 + 1.24755399910672e-6*x_67 - 1.44062264846512e-6*x_68 - 3.74332611474604e-7*x_69 + 3.44998386696575e-7*x_7 + 8.18341358442128e-7*x_70 - 3.14651570806287e-7*x_71 + 2.52829348686165e-6*x_72 + 7.96462181320851e-7*x_73 - 7.73662529605731e-7*x_74 - 9.58838887432392e-7*x_75 - 6.23268044174542e-7*x_76 + 1.14586982552315e-7*x_77 - 1.521868402283e-6*x_78 + 2.97746135176593e-7*x_79 - 4.06637872649859e-6*x_8 - 4.61661494426843e-7*x_80 + 9.17781157508809e-7*x_81 + 9.24011338166268e-7*x_82 - 2.01782578472324e-6*x_83 + 9.94395153848699e-7*x_84 + 2.44389325480468e-7*x_85 - 7.92507654136864e-7*x_86 - 5.05546578294593e-7*x_87 + 1.89225187612571e-6*x_88 + 4.09104089296543e-7*x_89 - 1.14336020460322e-6*x_9 - 2.3034308400599e-8*x_90 + 3.02711308804441e-5*x_91 + 7.1021023081851e-7*x_92 + 1.49927078129513e-6*x_93 + 3.55454516899071e-7*x_94 + 1.38906312405347e-6*x_95 - 2.82147335351351e-7*x_96 + 1.08317902431099e-6*x_97 + 9.36967160033357e-7*x_98 - 2.74216287240492e-7*x_99 + 8.82822449715611e-10*std::pow(-5.49200010299683*x_48 - 8.94799995422363, 2) - 0.000378679160320171*std::exp(-0.000246849005651238*x_1 + 0.000238406300566551*x_10 - 0.000327205939574832*x_100 + 0.000629978985492296*x_101 - 0.000129462848588462*x_102 + 9.03349772952941e-6*x_103 - 0.000181991600602045*x_104 - 0.00134129208421445*x_105 - 0.000795985039740274*x_106 + 6.50170106331876e-5*x_107 - 0.00152728710505003*x_108 - 0.000381036822369851*x_109 + 5.95166413919112e-5*x_11 + 0.000262633705419888*x_110 + 0.000677430625358775*x_111 - 0.000484588227044771*x_112 - 0.000648784789580158*x_113 + 0.00014380017291818*x_114 + 0.00124877407322454*x_115 + 0.000167645399842563*x_116 + 0.000349609786640547*x_117 + 0.00037742719026121*x_118 + 0.000293208826014279*x_119 + 0.00181871197433242*x_12 + 0.000168730287282615*x_120 - 0.000296338026585718*x_13 - 0.00168481284847633*x_14 - 2.54629954813873e-5*x_15 - 0.000285005258182503*x_16 + 8.24360680059636e-5*x_17 - 0.000130366171394002*x_18 - 0.00038142416781144*x_19 - 0.000350985400817004*x_2 - 0.000608689667865963*x_20 + 0.000813273115212194*x_21 - 0.000390053272016224*x_22 - 9.85817643867375e-5*x_23 + 5.43293781145925e-6*x_24 + 0.000393931138723883*x_25 + 4.4379998576928e-5*x_26 - 0.000100730471372703*x_27 - 0.00122460826287395*x_28 + 0.000296181297550784*x_29 + 0.000180575417295234*x_3 + 6.41466450159256e-5*x_30 + 0.000555262866257007*x_31 - 0.000121326538673405*x_32 - 9.5466963023163e-5*x_33 - 0.00063876777886381*x_34 + 0.000789195831042051*x_35 + 0.000120696888582421*x_36 - 0.000352414221033118*x_37 - 0.000329147537082992*x_38 - 0.00194542393400026*x_39 - 0.000113069065118574*x_4 - 0.00152643602324186*x_40 - 5.43391898093869e-5*x_41 - 0.000589880934309076*x_42 + 0.000282299896627065*x_43 + 0.000238902199643064*x_44 + 0.00234591374632934*x_45 + 0.000887559518304826*x_46 - 0.000867955932078237*x_47 - 0.000381829009084906*x_48 - 0.000963658411709461*x_49 + 0.000346170383384067*x_5 + 0.000176245926485916*x_50 + 0.00103599791123133*x_51 - 0.000147308963191617*x_52 - 7.96348687027499e-5*x_53 - 0.0015802112799994*x_54 + 0.00169612738321063*x_55 + 0.000262169738636016*x_56 + 0.000579425329982289*x_57 + 0.000270529365172174*x_58 + 8.0235715382425e-5*x_59 - 0.000985292730829697*x_6 + 0.000734978852766332*x_60 + 0.000827226678085733*x_61 + 0.000187355751406034*x_62 - 0.000366165324852316*x_63 - 5.11656821086205e-6*x_64 + 0.000407302470340963*x_65 + 0.000137098063014552*x_66 + 0.000763028314256039*x_67 - 0.000755017258916551*x_68 - 0.000300540316012406*x_69 - 3.40100267720901e-5*x_7 + 0.00114675323828851*x_70 + 1.2398229891425e-5*x_71 - 0.000182857724984284*x_72 - 6.5056570150477e-7*x_73 + 0.000772938781156943*x_74 + 7.11473323717076e-5*x_75 - 0.000553085617652267*x_76 - 0.000129038188438116*x_77 - 0.000256436828870055*x_78 + 6.03144584703414e-5*x_79 - 0.00150051319018058*x_8 - 0.000226495783441819*x_80 + 0.000128880416375747*x_81 - 2.75032220272381e-5*x_82 + 0.00297879264175803*x_83 - 0.000115084734246111*x_84 + 0.000871017069497435*x_85 + 6.66743171759386e-5*x_86 + 0.00015752442395834*x_87 + 0.000393058934510872*x_88 - 0.000244302024161882*x_89 + 0.000671787055384216*x_9 + 0.000210348272122081*x_90 + 0.00467706462651283*x_91 + 0.000244756307958992*x_92 - 6.89702368728063e-5*x_93 - 0.000250580699529607*x_94 + 0.0011145977582612*x_95 + 0.0008848116532496*x_96 - 1.84806829958938e-5*x_97 + 0.000176497305754834*x_98 + 0.000141620314934541*x_99) - 5.26798389579344e-6*std::sin(0.327279835939407*x_1 + 1.424959897995) + 0.000100124484916052*std::sin(0.315999925136566*x_32 + 7.97824001312256) - 3.19344396476064e-7*std::sin(0.470959842205048*x_58 - 7.32839965820313) - 1.37328275904692e-5*std::sin(0.42375984787941*x_92 + 1.57359981536865) - 2.93844247108567e-5*std::sin(0.375199824571609*x_93 - 4.79816007614136) + 5.38024957774014e-7*std::sin(0.479359865188599*x_97 + 2.02711987495422) + 0.0653806636210046);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-2.09921005975128e-6*x_1 + 5.54677786252562e-7*x_10 + 1.15167719022801e-6*x_100 - 4.35167987484365e-7*x_101 + 2.38453910124307e-7*x_102 + 1.42668898517123e-7*x_103 - 2.96274932030244e-7*x_104 - 1.92242625107723e-6*x_105 - 5.14221729245001e-6*x_106 - 7.42107104487405e-7*x_107 - 3.32660177733106e-6*x_108 - 1.32278966697399e-6*x_109 - 1.3756884324948e-6*x_11 - 4.39011038233575e-7*x_110 + 4.94934966478118e-7*x_111 - 1.84854868440252e-6*x_112 - 3.84250280236236e-7*x_113 - 2.51694416448052e-8*x_114 + 2.00065175852405e-6*x_115 + 3.52376829380272e-6*x_116 - 1.07895713371896e-6*x_117 + 2.17984525346722e-6*x_118 + 1.86038930103276e-7*x_119 + 2.03402743547088e-6*x_12 - 1.02779686840275e-6*x_120 - 2.31555001274045e-6*x_13 - 4.39136879225321e-6*x_14 - 2.39393880300486e-7*x_15 - 1.67213841972462e-6*x_16 + 5.84698115461906e-7*x_17 - 3.58333534107923e-7*x_18 - 1.25957598970786e-6*x_19 + 1.09680633073057e-6*x_2 - 1.7411874135865e-6*x_20 + 1.07997055858157e-6*x_21 - 1.34383682561891e-6*x_22 + 3.72334259421862e-7*x_23 - 2.97735365832689e-7*x_24 - 1.09489543291902e-6*x_25 - 9.10137101605107e-7*x_26 - 7.78334859486695e-7*x_27 - 1.16770506644987e-6*x_28 + 6.74812518233709e-7*x_29 - 9.95270005874555e-7*x_3 + 9.0398615092166e-7*x_30 + 7.71525095547061e-5*x_31 - 5.23403365768721e-6*x_32 - 3.14831835098541e-6*x_33 - 2.01997769532896e-6*x_34 - 2.99651608396537e-6*x_35 - 4.84920355063591e-6*x_36 - 1.33154547021493e-6*x_37 - 1.07801924080839e-6*x_38 - 2.3944068249601e-6*x_39 - 1.31685868491121e-6*x_4 - 4.77997654993348e-7*x_40 + 1.14145140470232e-6*x_41 - 1.86022937969791e-6*x_42 - 1.91716038679824e-6*x_43 + 2.05844317166115e-6*x_44 + 4.69315253638549e-9*x_45 - 2.74600570916817e-7*x_46 - 1.04216143833381e-6*x_47 - 5.1706638593695e-7*x_48 - 1.61368058934115e-6*x_49 - 1.74913803913377e-6*x_5 - 4.02028205940109e-7*x_50 + 9.96850862071533e-7*x_51 + 5.50500403059122e-7*x_52 - 2.44819907787604e-7*x_53 - 2.2415588952309e-6*x_54 + 3.15720962037908e-7*x_55 + 4.36668381448522e-7*x_56 + 2.79884471332024e-6*x_57 - 4.38050203504291e-7*x_58 + 1.87352277738054e-7*x_59 - 1.01189032755398e-6*x_6 + 1.58012361283082e-7*x_60 - 2.29040949306884e-6*x_61 - 1.23959471924475e-6*x_62 - 2.4220392711564e-6*x_63 + 6.47795263606838e-7*x_64 + 1.25097844399156e-7*x_65 - 1.59605226522004e-6*x_66 + 1.5372130098781e-7*x_67 - 3.15519798690044e-6*x_68 - 8.74507008618271e-7*x_69 - 9.587190019403e-7*x_7 + 2.45182475197065e-8*x_70 - 1.51768831163582e-7*x_71 - 1.0832114138181e-6*x_72 + 7.06806210770118e-7*x_73 - 1.72242847920438e-6*x_74 - 5.26997118788292e-7*x_75 - 5.64001143439288e-7*x_76 - 6.88247015829572e-7*x_77 - 1.22938089097943e-6*x_78 + 5.50503328270251e-7*x_79 - 9.22948758333046e-6*x_8 - 4.34013670792853e-7*x_80 - 7.11770328455057e-7*x_81 + 4.12077607775393e-7*x_82 + 2.43329839216086e-6*x_83 - 1.24855369437751e-6*x_84 + 5.81480453754978e-7*x_85 - 1.94950200202187e-6*x_86 - 6.47049495639434e-7*x_87 + 6.47080727282222e-7*x_88 - 9.40626418015244e-7*x_89 + 3.67086786699361e-6*x_9 - 2.5053914415193e-7*x_90 - 3.99701942676548e-5*x_91 + 1.62581429302959e-6*x_92 - 2.93203588879189e-6*x_93 + 1.99579813210419e-7*x_94 + 1.9990525699549e-6*x_95 + 1.75540333064854e-6*x_96 - 6.75492543981303e-7*x_97 - 9.45331663310312e-7*x_98 - 8.30987330920603e-8*x_99 - 2.18047326699186e-9*std::pow(-5.49200010299683*x_48 - 8.94799995422363, 2) - 1.12826437428615e-5*std::sin(0.327279835939407*x_1 + 1.424959897995) - 6.93419463271912e-5*std::sin(0.315999925136566*x_32 + 7.97824001312256) + 7.88745143153096e-7*std::sin(0.470959842205048*x_58 - 7.32839965820313) - 4.00217579770291e-5*std::sin(0.42375984787941*x_92 + 1.57359981536865) + 7.2576261023491e-5*std::sin(0.375199824571609*x_93 - 4.79816007614136) - 1.32886180882529e-6*std::sin(0.479359865188599*x_97 + 2.02711987495422) + 0.0667484887839551);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-2.04667787162928e-6*x_1 + 1.03085230510076e-6*x_10 + 3.95796748463035e-7*x_100 - 4.42281068580962e-7*x_101 - 6.02879345517022e-7*x_102 + 8.99006864042856e-7*x_103 + 3.96600673766909e-6*x_104 + 3.43557339509195e-6*x_105 + 1.4743822873807e-6*x_106 + 3.48117372109241e-6*x_107 - 2.62919046479006e-6*x_108 + 4.31937487003642e-7*x_109 + 1.6819366815531e-6*x_11 + 9.25391614147518e-7*x_110 + 1.75665779317212e-6*x_111 - 1.57327037465046e-6*x_112 + 6.95549527328786e-7*x_113 + 2.4667663377525e-7*x_114 + 4.99141602347426e-7*x_115 - 2.59918034980878e-6*x_116 + 3.82910466143495e-7*x_117 - 7.26989097830163e-7*x_118 - 1.25745030135512e-6*x_119 - 1.03552603669413e-6*x_12 - 9.20796374589015e-7*x_120 + 3.14449730144546e-7*x_13 + 2.82748574554179e-6*x_14 - 3.53845459236948e-7*x_15 + 3.60575425814229e-6*x_16 + 4.04572225786012e-7*x_17 - 1.13929473012633e-7*x_18 + 2.05183895556498e-6*x_19 - 2.60381629413294e-6*x_2 + 2.41913121779247e-6*x_20 - 1.37115900371948e-7*x_21 + 4.76736197659268e-7*x_22 - 6.76412018200932e-7*x_23 + 8.88058995562824e-8*x_24 - 3.8496904807864e-7*x_25 + 6.62145888528167e-7*x_26 + 2.19589922769175e-7*x_27 + 6.16604075152562e-8*x_28 + 6.62300733129218e-7*x_29 + 8.05610146855776e-7*x_3 + 6.60155089600148e-7*x_30 - 3.65453979658598e-5*x_31 + 1.17011031013989e-5*x_32 + 2.15788897634602e-6*x_33 + 5.17146852084659e-7*x_34 + 4.92771859783356e-6*x_35 + 1.46159848021232e-6*x_36 + 4.11330484926053e-7*x_37 - 6.6941747912945e-7*x_38 - 3.28326855465407e-6*x_39 + 8.44282177244413e-7*x_4 + 5.89138644874495e-8*x_40 - 1.11205105386561e-7*x_41 + 2.07074805980305e-6*x_42 + 3.16358936123e-6*x_43 - 8.99601576934777e-7*x_44 + 4.72491659849369e-8*x_45 + 2.3527024647695e-6*x_46 - 3.21428583222183e-7*x_47 - 8.96811077801499e-7*x_48 - 2.41702399177413e-7*x_49 + 1.75995805628369e-7*x_5 - 3.01914625671102e-7*x_50 - 4.4737389464234e-7*x_51 - 1.09575852671865e-6*x_52 + 3.3930994756989e-7*x_53 + 3.84087337753306e-8*x_54 + 1.99811717558585e-6*x_55 + 4.08614800411781e-7*x_56 - 5.09277273104085e-7*x_57 + 4.891088989538e-7*x_58 - 1.51178463993381e-8*x_59 + 1.02701580972821e-7*x_6 - 1.53978518235887e-6*x_60 + 3.10599746718423e-6*x_61 + 1.55367199908912e-7*x_62 + 3.27944880898254e-6*x_63 - 2.48305621840553e-6*x_64 + 7.27524732288831e-7*x_65 + 1.89708056495741e-6*x_66 - 6.18554936802177e-7*x_67 - 1.08640928153988e-6*x_68 - 2.4836369845998e-6*x_69 - 2.12138801198946e-7*x_7 + 2.34096902092094e-6*x_70 + 6.09138141920794e-7*x_71 + 1.21001951949935e-6*x_72 - 2.36021419752202e-6*x_73 + 9.90487073852447e-7*x_74 + 1.43627703331411e-6*x_75 + 3.985428895173e-7*x_76 - 6.10914286720641e-7*x_77 + 1.09442093586883e-6*x_78 - 2.35236431190068e-7*x_79 + 7.36016064969459e-6*x_8 + 4.96007819587072e-7*x_80 + 8.96912371730943e-7*x_81 + 1.60913318763334e-7*x_82 + 4.70594330024077e-7*x_83 + 1.31426829542074e-8*x_84 + 5.36287779722774e-7*x_85 + 2.40303269907946e-7*x_86 - 3.25812791865038e-7*x_87 - 2.55103666365416e-6*x_88 + 7.37322750869222e-7*x_89 - 1.57602720961329e-6*x_9 + 6.82791221287332e-7*x_90 + 2.55040177775454e-5*x_91 - 3.02296322047763e-6*x_92 + 1.46666689419941e-6*x_93 - 6.60621789078185e-7*x_94 - 2.1171873802509e-6*x_95 + 1.14560524420328e-6*x_96 + 2.67565473043358e-6*x_97 + 7.91318523686117e-7*x_98 - 1.03834143205741e-6*x_99 + 1.3717406669487e-9*std::pow(-5.49200010299683*x_48 - 8.94799995422363, 2) + 3.7013737004081e-5*std::sin(0.327279835939407*x_1 + 1.424959897995) + 4.76860520099744e-5*std::sin(0.315999925136566*x_32 + 7.97824001312256) - 4.96201354586669e-7*std::sin(0.470959842205048*x_58 - 7.32839965820313) - 6.47815345361779e-5*std::sin(0.42375984787941*x_92 + 1.57359981536865) - 4.56578900590477e-5*std::sin(0.375199824571609*x_93 - 4.79816007614136) + 8.35989971312715e-7*std::sin(0.479359865188599*x_97 + 2.02711987495422) + 0.0729798549624116);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.0505728314628e-6*x_1 - 3.13316905448073e-7*x_10 + 3.23413494197479e-7*x_100 + 6.34151097530267e-7*x_101 - 2.422642757019e-7*x_102 - 6.22208329554768e-7*x_103 - 1.81645534147136e-6*x_104 + 8.79579907927924e-7*x_105 + 3.10186577547775e-7*x_106 - 9.61196378300471e-7*x_107 + 2.32097555803833e-6*x_108 + 2.07038542309503e-6*x_109 + 2.3334523591832e-6*x_11 - 6.96817428729383e-7*x_110 + 3.97904606104313e-7*x_111 + 2.55773965808734e-6*x_112 + 1.92181237428141e-6*x_113 + 7.8305872623735e-7*x_114 - 1.69518256278432e-6*x_115 - 2.16463273810862e-6*x_116 + 1.2701148880913e-6*x_117 - 1.65138078164692e-6*x_118 + 7.71789761026666e-8*x_119 + 2.87821532708431e-6*x_12 + 1.66420676716385e-6*x_120 + 8.27014284773341e-7*x_13 - 6.87589955045831e-8*x_14 + 1.39376207078494e-7*x_15 + 1.38722580913814e-6*x_16 + 1.55980500908636e-6*x_17 - 2.22525626129654e-7*x_18 + 1.09465410212043e-6*x_19 - 2.01341705838106e-7*x_2 + 3.22922271742331e-6*x_20 + 1.61720076368088e-6*x_21 + 2.62777078154183e-7*x_22 + 5.35566499547374e-7*x_23 + 2.47446453109455e-7*x_24 + 2.11453161640889e-6*x_25 - 1.02007309450215e-6*x_26 + 8.61093072301678e-7*x_27 + 6.40425846399748e-7*x_28 + 1.21952811091559e-6*x_29 + 2.30340631286853e-7*x_3 + 2.67379233286437e-6*x_30 - 7.102047841741e-6*x_31 + 7.38873118199509e-6*x_32 + 1.3837110870408e-6*x_33 + 1.40303695465232e-7*x_34 + 2.00209635239663e-6*x_35 + 4.53586891910471e-6*x_36 + 9.03563680124203e-7*x_37 + 2.02469973134065e-6*x_38 - 2.39556634629054e-6*x_39 - 2.12912114935192e-7*x_4 - 4.97393394396723e-7*x_40 - 2.10198960787758e-6*x_41 + 2.47849754595322e-6*x_42 + 3.52113278228267e-6*x_43 - 3.98786041619989e-6*x_44 + 8.1444783354474e-7*x_45 + 9.00270105330664e-7*x_46 - 8.9045602219533e-7*x_47 - 1.14371858596354e-6*x_48 - 6.73487500557831e-7*x_49 + 2.25917912925019e-6*x_5 + 2.2027819064958e-6*x_50 + 1.36215668622095e-7*x_51 + 5.31429881609315e-8*x_52 - 5.73700026264244e-7*x_53 + 4.17728514623941e-6*x_54 + 8.1146613644771e-7*x_55 + 1.89103777858127e-6*x_56 - 1.1208108787258e-6*x_57 - 3.36154545937681e-7*x_58 + 2.53586530420775e-6*x_59 + 3.99809802226486e-7*x_6 + 7.986811873463e-7*x_60 - 2.49379964094322e-6*x_61 + 1.19731465480813e-6*x_62 + 7.00767868150433e-7*x_63 + 1.96738874842419e-6*x_64 + 3.58972433301815e-6*x_65 + 2.34256357962837e-6*x_66 - 3.4824936011679e-7*x_67 + 1.73364594132249e-6*x_68 + 1.01976912806395e-6*x_69 + 1.42348961438096e-6*x_7 + 7.87855937817315e-7*x_70 + 2.85266569687191e-7*x_71 - 1.06881155483982e-7*x_72 - 1.7597597543842e-7*x_73 + 2.33026835406655e-6*x_74 - 3.58422725697947e-7*x_75 - 1.39327847819624e-8*x_76 - 2.32608129337734e-7*x_77 - 1.68066533238963e-6*x_78 - 5.55887675097056e-7*x_79 + 1.0175873025677e-5*x_8 + 6.75573676504014e-8*x_80 - 5.84756992846313e-7*x_81 - 3.23162409949659e-7*x_82 + 1.50024088700722e-6*x_83 + 3.49054129169044e-6*x_84 + 8.79476782854375e-7*x_85 + 4.44867412585812e-7*x_86 + 1.46416882015883e-6*x_87 - 5.96761003681863e-7*x_88 + 4.40398192600015e-9*x_89 + 5.9435729725773e-7*x_9 - 9.59941310288228e-8*x_90 + 2.22532589827174e-5*x_91 + 6.00458025516125e-7*x_92 + 3.24703582457112e-6*x_93 - 1.37819482016002e-6*x_94 - 2.01563677109335e-6*x_95 - 2.19000596107894e-6*x_96 + 1.36593522473642e-6*x_97 - 4.14093465424611e-7*x_98 + 5.24979337246334e-8*x_99 + 2.66333035603267e-9*std::pow(-5.49200010299683*x_48 - 8.94799995422363, 2) + 4.02141431018102e-5*std::sin(0.327279835939407*x_1 + 1.424959897995) - 9.12657040155485e-6*std::sin(0.315999925136566*x_32 + 7.97824001312256) - 9.63409602279164e-7*std::sin(0.470959842205048*x_58 - 7.32839965820313) + 7.75018931494127e-5*std::sin(0.42375984787941*x_92 + 1.57359981536865) - 8.86479839204267e-5*std::sin(0.375199824571609*x_93 - 4.79816007614136) + 1.62313294457377e-6*std::sin(0.479359865188599*x_97 + 2.02711987495422) + 0.0671800658113595);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.72668341119607e-6*x_1 - 2.45349586307494e-6*x_10 - 1.64051844873178e-6*x_100 + 1.43801708027244e-6*x_101 - 1.55076382857022e-6*x_102 - 1.04355616731752e-6*x_103 - 1.02251945516497e-6*x_104 + 8.88667249123452e-7*x_105 + 3.01031204647437e-7*x_106 - 2.98124165542396e-6*x_107 + 1.39236932948012e-6*x_108 - 1.41759698990583e-8*x_109 - 2.26284568514198e-7*x_11 - 3.99849201642088e-7*x_110 - 2.49763139112405e-6*x_111 + 5.42532300766096e-7*x_112 + 1.35595683329731e-6*x_113 - 1.70752452927492e-6*x_114 + 1.11072820829193e-6*x_115 + 6.61164996764125e-6*x_116 - 2.0257645257783e-6*x_117 + 1.9980870167889e-6*x_118 + 4.56749543092433e-6*x_119 + 1.22552573443494e-7*x_12 + 1.20720742284833e-6*x_120 - 2.55971067260129e-6*x_13 + 5.88808916573152e-7*x_14 + 1.55901502822191e-6*x_15 - 3.42884742672366e-6*x_16 - 7.77949178890924e-7*x_17 + 1.43594830696156e-6*x_18 - 6.61252709449016e-7*x_19 - 5.63588467662197e-7*x_2 - 1.34855727289566e-6*x_20 - 1.31934502788584e-6*x_21 + 5.87970154007255e-8*x_22 + 8.10470707699319e-7*x_23 + 3.61713554947145e-7*x_24 + 1.44293661618078e-6*x_25 - 3.33245057125261e-6*x_26 - 2.16900373158656e-6*x_27 - 3.92678107957402e-7*x_28 - 1.54430289302637e-6*x_29 + 1.4195484139172e-6*x_3 + 1.31660291378006e-6*x_30 + 8.05305846898394e-5*x_31 - 7.11521538489323e-6*x_32 + 4.50825635792616e-7*x_33 - 2.37998092067414e-6*x_34 + 5.09204575299821e-6*x_35 - 5.9285507878291e-6*x_36 - 1.88703279698179e-6*x_37 - 2.24215056690452e-6*x_38 - 2.79530342315479e-6*x_39 - 1.59586354927835e-7*x_4 - 1.48033295117481e-7*x_40 - 2.18777079414855e-6*x_41 - 1.47074237108196e-6*x_42 + 1.31626875645893e-6*x_43 - 2.08033951625754e-6*x_44 + 9.25997293736316e-7*x_45 + 4.90740359086205e-7*x_46 + 4.59814191166895e-8*x_47 + 1.10084515942888e-6*x_48 - 1.71599074680114e-6*x_49 - 6.76302877105154e-7*x_5 + 3.3486882886297e-6*x_50 + 3.48305852512464e-6*x_51 - 1.10861191949998e-6*x_52 - 4.36984710163366e-7*x_53 - 1.51654575912322e-6*x_54 - 2.56822649397216e-6*x_55 + 2.66470200682747e-6*x_56 - 7.43769225336485e-7*x_57 - 7.17220094960364e-6*x_58 + 1.09103777706962e-6*x_59 + 1.06372005667765e-6*x_6 + 5.72266157632277e-7*x_60 - 1.24385943734205e-7*x_61 + 4.06152983303961e-7*x_62 - 3.82470690751118e-7*x_63 - 2.54788554783746e-6*x_64 + 1.27586662550917e-6*x_65 - 1.42410990295539e-6*x_66 + 1.03450961389982e-6*x_67 + 2.62742000365961e-6*x_68 + 2.63989846373755e-7*x_69 - 3.84610008463816e-6*x_7 + 3.4478924323285e-6*x_70 - 5.24327106968227e-7*x_71 + 2.40770186481741e-6*x_72 + 2.63355645118863e-7*x_73 - 1.57324301847968e-6*x_74 - 1.64406215944855e-6*x_75 - 1.11247573458392e-6*x_76 + 1.99984382871433e-6*x_77 - 1.95264959635284e-7*x_78 + 7.49334435905909e-7*x_79 - 1.89455589254466e-6*x_8 - 1.68374910190625e-6*x_80 - 8.39908194083145e-7*x_81 - 1.45008319809757e-6*x_82 + 9.96729433619563e-7*x_83 + 1.85959533038104e-6*x_84 - 2.9811187293609e-7*x_85 + 7.48890726765204e-7*x_86 - 8.42611597712858e-7*x_87 + 1.74382472008281e-6*x_88 + 5.8355519759111e-7*x_89 - 2.13102367758774e-7*x_9 - 5.57552093374015e-7*x_90 - 2.80158390198099e-5*x_91 + 2.35632171892306e-6*x_92 - 6.12106164813053e-6*x_93 + 1.44126628358722e-6*x_94 + 3.53146404819032e-6*x_95 - 6.14583037596807e-8*x_96 - 6.06531987135593e-6*x_97 + 5.66258960975508e-7*x_98 + 1.2218088718278e-6*x_99 - 1.20488591609239e-9*std::pow(-5.49200010299683*x_48 - 8.94799995422363, 2) + 2.47434012896083e-5*std::sin(0.327279835939407*x_1 + 1.424959897995) + 0.000110545319240607*std::sin(0.315999925136566*x_32 + 7.97824001312256) + 4.35844790558945e-7*std::sin(0.470959842205048*x_58 - 7.32839965820313) + 7.06095707801042e-6*std::sin(0.42375984787941*x_92 + 1.57359981536865) + 4.01041902570485e-5*std::sin(0.375199824571609*x_93 - 4.79816007614136) - 7.34302457234681e-7*std::sin(0.479359865188599*x_97 + 2.02711987495422) + 0.0637329296342577);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-5.37732500102371e-7*x_1 + 1.54112919675703e-6*x_10 - 2.05216975577867e-6*x_100 + 3.70831369544897e-6*x_101 - 6.88496978688447e-7*x_102 + 6.79894108558765e-7*x_103 + 6.72952780721709e-7*x_104 - 5.02753940881678e-7*x_105 + 2.61485355233271e-6*x_106 + 7.24967547065813e-7*x_107 + 5.36420820259088e-7*x_108 + 8.23211196615525e-7*x_109 + 1.21550121672995e-7*x_11 + 4.64035687354711e-6*x_110 - 2.72778861795595e-7*x_111 - 3.68114464926768e-6*x_112 - 7.61436508868917e-7*x_113 - 1.16217521804937e-6*x_114 + 1.34509811184367e-6*x_115 + 1.16381713343815e-6*x_116 - 1.01994890437129e-6*x_117 + 3.12968029062998e-6*x_118 + 9.93976985342228e-7*x_119 + 7.7794441340254e-7*x_12 + 1.31925621209174e-6*x_120 + 3.26608480130851e-7*x_13 - 1.1161929804427e-7*x_14 - 3.90671278248374e-7*x_15 - 3.09076152475568e-6*x_16 - 1.32261696441692e-6*x_17 + 1.15990455840017e-6*x_18 - 2.98809837588586e-7*x_19 + 2.47007738591327e-6*x_2 + 7.38677094564831e-7*x_20 - 1.98356768169769e-6*x_21 - 9.07273036494158e-7*x_22 - 3.84188956918045e-7*x_23 + 7.15012676010275e-8*x_24 + 4.0685632489514e-7*x_25 - 3.49262307444281e-7*x_26 - 8.55343824383164e-7*x_27 - 8.90189702105172e-7*x_28 - 8.12704453742522e-7*x_29 + 1.13219012323466e-7*x_3 + 1.60087258248929e-7*x_30 + 8.09626054921846e-5*x_31 - 1.80706292714203e-7*x_32 + 5.75921987610227e-7*x_33 - 2.66165667143918e-6*x_34 - 3.12608958362423e-6*x_35 + 1.65624906401661e-6*x_36 + 1.86318822090333e-7*x_37 - 5.88336965874698e-7*x_38 + 2.96915391894368e-6*x_39 - 2.95073062622835e-7*x_4 + 2.20036626686839e-7*x_40 + 1.12575987898313e-6*x_41 - 1.54791912853304e-6*x_42 - 6.79102804046646e-7*x_43 + 5.14650321958269e-7*x_44 + 1.96496452774507e-6*x_45 + 1.50289306336746e-6*x_46 + 9.98618151255114e-8*x_47 - 7.04209620577774e-7*x_48 + 1.97786718706496e-8*x_49 - 1.7519189256326e-6*x_5 - 8.76246650746385e-7*x_50 + 2.50797775033588e-6*x_51 + 2.15130860080005e-6*x_52 + 3.78539845680013e-7*x_53 - 7.61782332436609e-7*x_54 - 4.03761624890682e-7*x_55 + 1.43144401161897e-7*x_56 - 1.26846648060401e-6*x_57 + 7.79921735522982e-7*x_58 - 8.74660654660522e-7*x_59 - 8.05520487967038e-7*x_6 - 6.14589367057572e-7*x_60 + 4.3735403847465e-6*x_61 + 8.26430712674604e-7*x_62 - 7.37442482621632e-7*x_63 + 1.0996551055559e-6*x_64 - 5.1745682470897e-6*x_65 + 7.78151198662616e-7*x_66 - 7.5687215490109e-7*x_67 - 1.38593179902496e-6*x_68 + 2.43803505215524e-6*x_69 + 5.43606730915744e-7*x_7 - 6.1897164306665e-7*x_70 - 9.27413936249066e-7*x_71 - 6.19011148337119e-7*x_72 + 5.32508748089367e-7*x_73 - 1.06892181487589e-6*x_74 + 4.63072555641152e-7*x_75 + 5.73389945778639e-7*x_76 + 2.07410283053006e-6*x_77 + 1.99303825005456e-7*x_78 - 1.78017108025932e-7*x_79 - 6.02552907939194e-6*x_8 - 2.02904650950768e-6*x_80 + 9.72434986437754e-7*x_81 + 1.65167218978968e-6*x_82 - 3.48880047879856e-7*x_83 - 2.14065264508626e-6*x_84 - 4.75968430842304e-7*x_85 + 2.00451760311123e-6*x_86 - 5.95954084977548e-7*x_87 + 2.29635779195777e-7*x_88 - 1.64550493007922e-6*x_89 + 1.62011602986264e-6*x_9 - 8.45890023875821e-7*x_90 - 4.71277005547039e-5*x_91 + 9.22834285628199e-7*x_92 + 1.08930708810115e-7*x_93 + 4.18379210939509e-6*x_94 + 4.69658088827832e-6*x_95 + 1.26088602519894e-6*x_96 + 2.51136504587226e-6*x_97 + 7.84658735977266e-7*x_98 + 1.45896342665479e-6*x_99 - 5.29476999804012e-9*std::pow(-5.49200010299683*x_48 - 8.94799995422363, 2) + 0.000466778966532985*std::exp(-0.000576987977122589*x_1 + 0.000815488335553875*x_10 - 0.000786681079665003*x_100 - 0.000175339445557236*x_101 + 0.000284041506013027*x_102 + 0.000660191480957019*x_103 + 0.00131353914069286*x_104 + 0.000163899792028316*x_105 + 0.000393969807790409*x_106 + 0.000248500439442195*x_107 - 6.73458355544023e-5*x_108 + 0.000902864398142477*x_109 + 0.000643006312045565*x_11 + 0.00276078714589049*x_110 + 0.00116138843797926*x_111 - 9.51102338780689e-5*x_112 + 0.000155623668101159*x_113 + 0.000121873364728791*x_114 + 0.000387175347939324*x_115 - 0.00311905426749344*x_116 + 9.98904952670512e-5*x_117 - 0.000472448712754877*x_118 - 0.00110491386771678*x_119 + 0.000814066957097754*x_12 + 0.000378809768969711*x_120 + 1.90660982004671e-5*x_13 + 0.00129570415285963*x_14 - 0.000584044035994159*x_15 + 0.00319622687816356*x_16 - 0.00110913505563872*x_17 + 0.000302157950465307*x_18 + 0.00144725884819914*x_19 - 0.000383999157081977*x_2 + 0.00108639664563984*x_20 + 0.000194696524664929*x_21 - 0.000124311133111362*x_22 + 3.61146690360825e-5*x_23 - 0.000195658662442009*x_24 + 0.000551687650959681*x_25 + 0.00142337557433607*x_26 + 0.000875246806824376*x_27 - 3.81671071392697e-5*x_28 + 0.000746225814789621*x_29 + 0.000337141232634411*x_3 + 7.97282858037298e-5*x_30 - 0.000809562172160212*x_31 + 0.0126261982073118*x_32 + 0.00146235824380522*x_33 - 0.000201462634280284*x_34 + 0.00190536248014179*x_35 - 0.000410831645068813*x_36 - 0.000244322327398001*x_37 - 0.000275952341352367*x_38 - 0.000147164074785283*x_39 + 0.000296711152074518*x_4 - 0.00136434677494575*x_40 - 0.000233761880854784*x_41 - 6.02822184954448e-5*x_42 + 0.000156107210727109*x_43 + 0.000193263138654884*x_44 + 0.000839195198326706*x_45 + 0.00155452416556839*x_46 - 0.000546114326892577*x_47 + 0.00217156204864468*x_48 - 0.000227990420011388*x_49 - 2.32494084838064e-5*x_5 - 0.000570629151701376*x_50 + 0.000355163381226977*x_51 + 0.000459062102702024*x_52 - 9.68161314560341e-5*x_53 + 0.00129968630108402*x_54 + 0.00208029456257159*x_55 + 0.000189384127094572*x_56 - 0.000204831992520922*x_57 + 0.00422635796694172*x_58 + 0.000177195110025166*x_59 - 0.000303169017152936*x_6 - 8.18399693482632e-5*x_60 + 0.00125275426203188*x_61 + 0.000708896707595418*x_62 + 0.00166676909141452*x_63 - 8.61176772333714e-5*x_64 - 4.40220924168243e-5*x_65 + 0.000415069638365309*x_66 - 0.00111351612952047*x_67 + 0.000173144129500972*x_68 + 6.86577513567425e-5*x_69 + 0.000375236622953887*x_7 - 0.000319047314855481*x_70 + 0.000154635984985752*x_71 - 0.000357301762038305*x_72 - 0.00127550966214784*x_73 + 0.00232501449771249*x_74 + 0.00199625758646489*x_75 + 0.000466241364990204*x_76 - 0.000137655208802289*x_77 + 0.00123949789691072*x_78 - 0.000265048319008955*x_79 + 0.00736691792946106*x_8 + 0.000246651807851855*x_80 - 4.54791808701417e-6*x_81 - 0.000629815559947078*x_82 + 0.000817433029085303*x_83 - 0.000200213101351144*x_84 + 0.000272499864691341*x_85 + 0.0013904020527334*x_86 + 0.000711781900455988*x_87 - 0.00222902017544724*x_88 + 0.000222329435539641*x_89 - 0.000218166686893838*x_9 + 0.000147089088068827*x_90 - 0.00398577439280239*x_91 - 0.00116536481394818*x_92 - 0.00111003629265799*x_93 - 7.47654540254512e-5*x_94 + 0.000231485829967173*x_95 + 0.000943256421478642*x_96 + 0.00108892215964701*x_97 + 0.000513114267087675*x_98 + 0.000245294489413008*x_99) + 7.56058862164293e-5*std::exp(0.000937532446123844*x_1 + 0.000471138238058591*x_10 + 0.00500324198694301*x_100 - 0.00251784043032416*x_101 + 0.000330905930120157*x_102 - 0.000930575365494799*x_103 - 0.006631293637753*x_104 - 0.00192145970941849*x_105 - 0.00061768959209688*x_106 - 0.000472765740066293*x_107 - 0.000351151543473763*x_108 + 0.00172969000080252*x_109 - 0.00284550641328866*x_11 - 0.0033574276797959*x_110 + 0.00043253066049218*x_111 + 0.00416333585447352*x_112 + 0.00419859791256912*x_113 - 0.000532647525641403*x_114 - 0.000413091201067299*x_115 + 0.00322049788966713*x_116 + 0.00223300802807247*x_117 - 0.000146545164721951*x_118 - 0.00472100407729149*x_119 + 0.00620059070010587*x_12 + 0.00397841234291346*x_120 + 0.000321333905249875*x_13 - 0.00395171144191003*x_14 + 0.00351335902841674*x_15 - 0.0076496181821803*x_16 + 0.00257130907756316*x_17 - 3.61585749749079e-5*x_18 - 0.0041858709217954*x_19 + 0.00662698253072233*x_2 + 0.00767147607598245*x_20 - 0.000501116453719588*x_21 - 6.48744998491208e-5*x_22 + 0.00188887324856057*x_23 - 0.00262047792276579*x_24 + 0.000378670342510942*x_25 - 0.000529116488191842*x_26 + 0.00639248757923837*x_27 - 0.00181838054138661*x_28 - 0.000118352037514532*x_29 - 0.00304985589513151*x_3 + 0.00445633069583354*x_30 + 0.0339536299007043*x_31 + 0.00138876271318309*x_32 - 0.00345625387293422*x_33 + 0.00139642163324315*x_34 + 0.00570660745598649*x_35 + 0.000174639156733184*x_36 + 0.00109713217998021*x_37 - 0.00219172494592199*x_38 - 0.00122100694610112*x_39 - 0.000607277915010643*x_4 - 0.00136999152117734*x_40 - 0.00199292306705724*x_41 - 0.000271413689026832*x_42 - 0.002835501024697*x_43 + 0.00584945869683481*x_44 - 0.000469273756400473*x_45 + 0.000352010618866845*x_46 - 0.000542802629972063*x_47 - 0.00331655257962277*x_48 - 0.000689231369709101*x_49 + 0.000167669222257195*x_5 - 0.000641619814625112*x_50 + 0.00372237463750782*x_51 + 0.00512391981275211*x_52 - 0.00140715927908649*x_53 + 0.0108911242116289*x_54 + 0.000768942779827385*x_55 + 0.000471146460927852*x_56 + 0.00909856668720593*x_57 + 0.0104386494397231*x_58 + 0.00488362495221842*x_59 + 0.000549959440832026*x_6 - 0.000711149972289467*x_60 - 0.00763663747928647*x_61 + 0.0020445807448663*x_62 + 0.00243599670992559*x_63 + 0.0113701024642943*x_64 + 0.00137645808486516*x_65 - 0.00107152593070046*x_66 + 0.00061889521641852*x_67 + 0.000470543437283669*x_68 + 0.00493177678490008*x_69 + 0.0101845638610244*x_7 + 0.00084231080269722*x_70 - 0.00267106419560216*x_71 - 0.00256852070718237*x_72 + 0.00558666520694889*x_73 - 0.000121110598043666*x_74 - 0.000559156424547414*x_75 - 0.00124398671977218*x_76 + 0.000471998290924899*x_77 - 0.00460644721397029*x_78 + 0.00288216259422502*x_79 - 0.00965169348292966*x_8 - 0.00161193892745715*x_80 + 0.000315412032920164*x_81 - 0.000851853901436255*x_82 - 0.0036783521319662*x_83 - 0.00394669844492823*x_84 - 0.0025069962998623*x_85 + 0.000636118014887988*x_86 + 0.00164681055332412*x_87 - 0.0029022653614973*x_88 - 0.00145788011114452*x_89 + 0.0133434649967602*x_9 - 0.000472036703840981*x_90 - 0.00537457931579173*x_91 + 0.00745763057903345*x_92 + 0.00330298982561802*x_93 + 0.00103324846525976*x_94 + 0.00538979737630459*x_95 + 0.000901898459266422*x_96 - 0.00844021991911192*x_97 - 0.000638808904986979*x_98 + 0.00105317098184019*x_99) + 7.81473021827808e-7*std::sin(0.327279835939407*x_1 + 1.424959897995) + 3.76964486689744e-5*std::sin(0.315999925136566*x_32 + 7.97824001312256) + 1.91528333930382e-6*std::sin(0.470959842205048*x_58 - 7.32839965820313) + 1.34789289180192e-6*std::sin(0.42375984787941*x_92 + 1.57359981536865) + 0.000176234497003142*std::sin(0.375199824571609*x_93 - 4.79816007614136) - 3.22683049749848e-6*std::sin(0.479359865188599*x_97 + 2.02711987495422) + 0.0657266720225995);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.10597297272254e-6*x_1 + 1.60728325081922e-6*x_10 - 5.62305118071224e-7*x_100 - 1.96540851198997e-7*x_101 + 2.39629232078958e-7*x_102 - 1.98919680125183e-7*x_103 - 2.30074814704793e-6*x_104 - 3.96739479175799e-6*x_105 + 2.71819415329421e-6*x_106 + 8.921983225948e-7*x_107 - 8.74581252311119e-7*x_108 - 4.68254052517675e-7*x_109 - 5.47918925762669e-7*x_11 + 4.62613732080898e-7*x_110 - 3.6526213110492e-7*x_111 + 1.05566929974255e-6*x_112 - 2.15048577792229e-6*x_113 + 1.42424038412109e-6*x_114 - 7.59351060800147e-7*x_115 + 7.74604646537326e-7*x_116 + 1.57898719986464e-6*x_117 + 5.65714328169448e-7*x_118 - 1.0101602002612e-6*x_119 - 1.04868031595545e-6*x_12 + 1.99109299924476e-6*x_120 + 1.26168884489295e-6*x_13 - 1.50757762122971e-6*x_14 + 1.8022022241641e-6*x_15 - 2.84105784303129e-6*x_16 - 1.64908711230472e-6*x_17 - 6.37488532855137e-7*x_18 - 1.97793321690028e-6*x_19 + 2.3723405984788e-6*x_2 - 2.92299840434756e-6*x_20 + 1.50186415899072e-6*x_21 - 4.17971899835938e-7*x_22 + 8.23519973597607e-7*x_23 - 1.33496089420783e-6*x_24 - 1.87870855827122e-7*x_25 + 1.53101841530597e-6*x_26 + 1.41737085587315e-6*x_27 - 1.56765220775235e-6*x_28 - 9.01918413596594e-7*x_29 - 2.03211534846291e-6*x_3 - 1.8877912554923e-6*x_30 - 2.7664829494611e-5*x_31 - 8.62058572210539e-6*x_32 - 4.10757037284168e-7*x_33 - 1.72041511172123e-6*x_34 + 1.5806236783373e-7*x_35 + 1.54622828663634e-7*x_36 - 5.26423688124144e-8*x_37 + 5.38175314395144e-7*x_38 + 4.5334823991657e-7*x_39 - 1.23968864716317e-8*x_4 - 2.16879133599459e-6*x_40 + 7.81962655669648e-7*x_41 - 2.34974926554854e-6*x_42 - 4.91628170952676e-6*x_43 + 2.01843021623518e-6*x_44 + 7.75957766294753e-7*x_45 - 1.12265650184535e-6*x_46 - 2.27040017820265e-7*x_47 + 2.70269445963002e-6*x_48 - 5.60814574278371e-7*x_49 - 2.45694295683308e-6*x_5 - 5.35008280708983e-7*x_50 + 1.19717813304189e-6*x_51 + 1.77147111078443e-6*x_52 + 3.30813428155212e-7*x_53 - 1.85390236452399e-6*x_54 + 9.91216174065263e-7*x_55 - 2.38933070699744e-6*x_56 + 7.86408381538522e-7*x_57 + 2.19243552591556e-6*x_58 - 3.79173842555661e-7*x_59 + 8.4581756997449e-7*x_6 + 3.30179026289265e-7*x_60 + 1.16331335858403e-6*x_61 + 2.31741602853433e-7*x_62 - 8.39876896652493e-7*x_63 + 1.69804952991873e-6*x_64 - 2.44303629857058e-6*x_65 - 5.9567143906287e-7*x_66 + 2.31193371089605e-6*x_67 + 5.44035149117771e-7*x_68 - 1.65822318661988e-7*x_69 + 1.71037883138188e-6*x_7 + 8.07689391514773e-7*x_70 + 7.96662505845145e-7*x_71 + 1.52751468727133e-6*x_72 + 1.83354800979425e-6*x_73 - 1.79923211483222e-6*x_74 - 3.69518918367263e-7*x_75 - 5.24314662485582e-7*x_76 + 1.31751910374641e-6*x_77 + 3.41497128505617e-7*x_78 + 1.2058393215784e-6*x_79 - 9.06719846107713e-6*x_8 - 1.347626157765e-6*x_80 + 3.73762357957473e-8*x_81 - 5.99878914672356e-7*x_82 + 1.5043471414425e-7*x_83 - 1.72274551083244e-6*x_84 - 7.22048893386668e-7*x_85 + 6.02886700847537e-7*x_86 - 1.68925020909323e-7*x_87 + 1.30014979207798e-6*x_88 + 6.72799175800709e-7*x_89 + 2.66553454349439e-6*x_9 - 1.37366103354256e-7*x_90 + 8.77653202611111e-6*x_91 + 2.24711124746976e-6*x_92 + 1.82958282096998e-6*x_93 + 2.71075239668982e-6*x_94 - 1.23327852886614e-6*x_95 + 1.36978953279582e-6*x_96 - 6.12362117717027e-6*x_97 + 1.93643769545531e-7*x_98 - 7.12558394292812e-7*x_99 - 2.52263231861259e-9*std::pow(-5.49200010299683*x_48 - 8.94799995422363, 2) - 5.74598958201936e-5*std::sin(0.327279835939407*x_1 + 1.424959897995) + 1.03295786929437e-5*std::sin(0.315999925136566*x_32 + 7.97824001312256) + 9.12514736771659e-7*std::sin(0.470959842205048*x_58 - 7.32839965820313) - 4.13671847173514e-5*std::sin(0.42375984787941*x_92 + 1.57359981536865) + 8.39649008283876e-5*std::sin(0.375199824571609*x_93 - 4.79816007614136) - 1.53738630812812e-6*std::sin(0.479359865188599*x_97 + 2.02711987495422) + 0.0447423895884656);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
