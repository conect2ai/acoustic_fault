
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00193164151513408*x_1 - 0.00277541129005503*x_10 + 0.0039915897348081*x_100 - 0.000305510508066891*x_101 + 0.000393812797717656*x_102 + 0.00314810715031204*x_103 + 0.00144376005243274*x_104 + 0.000966379743100901*x_105 - 0.00241649518860058*x_106 + 0.000322451634447232*x_107 - 0.00247010303143801*x_109 - 0.00932339982943771*x_11 + 0.0003558845941956*x_111 - 0.00165141191377471*x_112 - 0.00269786252439692*x_113 - 0.00249152876652925*x_114 - 0.00221585723617318*x_115 + 0.00210272690967193*x_116 - 0.000621538696614548*x_117 - 0.00341109427535776*x_119 - 0.0032320094688504*x_12 + 0.00277003113800262*x_120 + 0.0067453775769134*x_13 - 6.90091786663001e-5*x_14 + 0.00453329195378637*x_16 + 0.00763506256362204*x_17 + 0.000789546916172362*x_18 + 0.000214141847821859*x_19 - 0.00875162008920046*x_2 - 0.0114102771428971*x_20 + 0.000754318123040418*x_21 - 0.00565575252581871*x_22 + 0.00310369632242527*x_23 - 0.000194416643647582*x_24 + 0.0098192971839236*x_25 - 1.83087693509685e-5*x_27 - 0.000204825955735614*x_28 + 0.0116132334068848*x_29 + 0.00127324024026833*x_3 + 0.00267171587324183*x_30 + 0.0141248129536785*x_31 - 0.00180504965670643*x_32 + 0.00345703071126785*x_33 + 0.00142197151880226*x_34 - 0.000785387995070956*x_35 + 0.00189598340911372*x_37 - 0.000106220193794162*x_38 + 0.00106121821207203*x_39 - 0.00435136097411107*x_4 - 0.000415402251885745*x_40 - 0.000873818227635661*x_41 - 0.000858759375583159*x_42 + 0.00144350448412177*x_43 - 0.0012991192477189*x_44 - 0.000104825212875184*x_45 - 0.00266106130920823*x_46 + 0.00263099025929459*x_47 + 0.000635398992485182*x_48 - 0.00330866648044932*x_5 - 0.000253249521887332*x_50 - 0.00170210837608786*x_51 + 0.00278384046627186*x_52 - 0.000352672895838768*x_53 + 0.000151928473097182*x_54 + 0.000789443949470177*x_56 - 0.000519922253999841*x_57 - 0.00196743457814719*x_58 - 0.00066841522548919*x_59 + 1.44106729847646e-5*x_6 - 0.000568206062952352*x_60 - 0.00204970898891651*x_61 - 6.01589518124709e-5*x_62 + 0.00524659344865499*x_63 + 0.00113778426022203*x_64 + 0.0048424276137173*x_65 - 0.000319570786648573*x_66 - 7.55355853424193e-5*x_67 - 0.00162897557045618*x_68 + 0.00119201834433447*x_69 + 0.000445451164633003*x_7 - 9.44636504736188e-5*x_70 - 0.000344279836034834*x_71 + 0.00229391367838754*x_72 + 0.000196959802882523*x_73 + 0.00164218286125916*x_74 - 7.71856497459858e-6*x_75 + 8.03257553912726e-5*x_78 - 0.000410476199253524*x_79 - 0.00599073161963361*x_8 + 0.000396795273134694*x_80 + 0.00216453750243227*x_82 + 0.000628924806481763*x_83 - 0.00145838138282458*x_84 - 0.00066578987479448*x_85 - 6.62991947538148e-5*x_88 - 0.00246374534893513*x_89 - 0.00498324756994621*x_9 - 0.00325081274625313*x_90 - 0.00771355257747327*x_91 - 0.000370214948906955*x_92 - 0.00182300983440503*x_93 + 0.0013487617904214*x_94 - 0.00144474357594982*x_95 - 0.00129752073916102*x_96 - 0.00107291357345148*x_97 - 0.000269176842062518*x_98 + 0.000295688926400978*x_99 + 2.93579690871903e-5*std::pow(-2.17063999176025*x_108 - 3.15591979026794, 2) - 1.31634781137661e-5*std::pow(-6.25112009048462*x_110 - 8.66423988342285, 2) - 1.56528296829465e-6*std::pow(-3.51968002319336*x_110 - 5.79135990142822, 2) + 1.5354336253807e-5*std::pow(-6.72800016403198*x_118 - 8.75936031341553, 2) - 5.81270225867378e-5*std::pow(-5.40447998046875*x_13 - 8.20039939880371, 2) + 0.000135673249430304*std::pow(-5.76688003540039*x_14 - 8.3450403213501, 2) + 7.00414162598733e-5*std::pow(-6.59999990463257*x_15 - 9.99973964691162, 2) - 0.000208922550267154*std::pow(-5.93840026855469*x_15 - 8.39935970306396, 2) - 1.18617866009051e-5*std::pow(-6.46104001998901*x_17 - 9.48311996459961, 2) + 0.000365948730639638*std::pow(-4.0065598487854*x_17 - 6.20688009262085, 2) + 0.000232396274100319*std::pow(-3.45199990272522*x_18 - 5.2752799987793, 2) - 3.32858001786083e-6*std::pow(-4.59431982040405*x_19 - 7.38895988464355, 2) - 8.84813068325947e-6*std::pow(-5.7294397354126*x_22 - 9.58975982666016, 2) + 4.54357885265649e-5*std::pow(-5.72079992294312*x_22 - 8.28072071075439, 2) - 4.10636085641029e-5*std::pow(-5.72383975982666*x_24 - 8.38159942626953, 2) - 0.000111055777282662*std::pow(-6.12911987304688*x_27 - 7.76647996902466, 2) + 0.000201046407830756*std::pow(-5.51200008392334*x_4 - 9.19999980926514, 2) - 0.000184943636327207*std::pow(-4.58247995376587*x_4 - 7.77960014343262, 2) - 1.17633894400752e-5*std::pow(-3.95839977264404*x_41 - 9.7038402557373, 2) - 1.05904725986406e-5*std::pow(-4.11559963226318*x_5 - 6.37784004211426, 2) - 0.000268712455398436*std::pow(-3.50720000267029*x_5 - 5.56712007522583, 2) + 5.66247251371543e-6*std::pow(-7.74287986755371*x_55 - 9.17280006408691, 2) - 1.99715485161838e-5*std::pow(-3.28671979904175*x_6 - 5.13399982452393, 2) + 0.000382378001544755*std::pow(-3.16847991943359*x_6 - 5.34823989868164, 2) + 1.04348353193388e-6*std::pow(-5.31584024429321*x_64 - 8.99736022949219, 2) + 4.22537753652227e-5*std::pow(-5.60232019424438*x_66 - 7.61072015762329, 2) + 0.000538447795861896*std::pow(-1.15495979785919*x_66 - 1.92279982566833, 2) + 1.75098480286648e-5*std::pow(-5.68575954437256*x_67 - 8.73624038696289, 2) + 0.000137621316418463*std::pow(-5.72591972351074*x_7 - 9.18144035339355, 2) + 0.000126434850908206*std::pow(-5.31304025650024*x_7 - 8.78575992584229, 2) + 2.30400580688418e-5*std::pow(-7.10591983795166*x_70 - 9.93296051025391, 2) + 7.71480058967097e-6*std::pow(-5.73503971099854*x_70 - 6.75536012649536, 2) + 4.83087033209234e-5*std::pow(-3.84744000434875*x_75 - 5.66079998016357, 2) - 2.86381497127184e-6*std::pow(-5.71463966369629*x_78 - 9.38111972808838, 2) - 0.000369498066520014*std::pow(-2.51511979103088*x_8 - 5.22399997711182, 2) - 4.06529467028565e-5*std::pow(-6.33008003234863*x_81 - 8.87975978851318, 2) - 7.23789238414314e-5*std::pow(-4.91448020935059*x_81 - 6.35383987426758, 2) - 4.95914159639689e-6*std::pow(-2.30607986450195*x_85 - 3.7727198600769, 2) + 1.0916802709573e-6*std::pow(-5.80800008773804*x_87 - 8.01583957672119, 2) - 1.22868026874704e-6*std::pow(-9.5959997177124*x_88 - 9.99096012115479, 2) - 0.00127569457064084*std::exp(0.57999986410141*x_106) + 0.00106862641397692*std::exp(0.719279825687408*x_15) - 0.00215534063703422*std::exp(0.612959861755371*x_2) + 0.000591792915135885*std::exp(0.513279855251312*x_76) - 0.0033313338272745*std::exp(0.612399816513062*x_76) + 0.000716706000206309*std::log(0.681119859218597*x_91 + 1.02415990829468) - 0.0838357046423416*std::sin(0.305919945240021*x_1 + 1.97895979881287) + 0.00495656374092945*std::sin(0.351679861545563*x_1 - 4.35207986831665) + 0.463939749796169*std::sin(0.212640002369881*x_10 + 5.01351976394653) + 0.0217269144428044*std::sin(0.41143986582756*x_100 - 0.988239824771881) + 0.000232253391809768*std::sin(0.513359844684601*x_100 - 7.22968006134033) - 0.0148829162932185*std::sin(0.303999930620193*x_101 - 4.3010401725769) + 0.0450797622979768*std::sin(0.363119840621948*x_102 + 5.16175985336304) + 0.0123649774352831*std::sin(0.411119878292084*x_102 - 1.00239980220795) - 0.00143286713124615*std::sin(0.388159841299057*x_103 - 7.40567970275879) - 0.0236969372385201*std::sin(0.437279850244522*x_103 + 2.00919985771179) - 0.14413630295899*std::sin(0.136880040168762*x_104 - 7.68391990661621) - 0.0325824774521095*std::sin(0.34215983748436*x_104 - 7.4378399848938) - 0.0206674025284893*std::sin(0.345919847488403*x_105 + 8.34463977813721) - 0.0129292977016358*std::sin(0.376319825649261*x_105 + 5.18792009353638) + 0.00389602708308821*std::sin(0.364719837903976*x_106 + 1.98247981071472) + 0.0262301393307961*std::sin(0.296479940414429*x_108 + 5.10391998291016) + 0.00290146573789975*std::sin(0.708239853382111*x_108 - 4.02719974517822) + 0.00152947734087184*std::sin(0.85207986831665*x_108 + 8.40624046325684) - 0.00970459628745716*std::sin(0.597919821739197*x_110 - 7.19352006912231) + 0.00194309324434517*std::sin(0.816159844398499*x_110 + 5.6101598739624) - 0.018374777271865*std::sin(0.339759826660156*x_111 - 1.04287981987) + 0.00664883783046574*std::sin(0.361119836568832*x_111 + 1.97559976577759) - 0.00107867066056501*std::sin(0.268239974975586*x_112 + 5.07903957366943) - 0.017029407118774*std::sin(0.331439822912216*x_112 - 7.43304014205933) - 0.0172216041393585*std::sin(0.369279861450195*x_112 + 1.9748797416687) - 0.0172100127822805*std::sin(0.409679859876633*x_114 + 5.21720027923584) + 0.00140048580380028*std::sin(0.516719877719879*x_115 - 7.04375982284546) - 1.82604957724019e-5*std::sin(1.55183982849121*x_115 + 1.80663990974426) + 0.041327571951733*std::sin(0.259839832782745*x_116 + 8.09823989868164) + 0.00121317142075908*std::sin(0.394879847764969*x_117 - 7.39591979980469) - 0.0093417362407673*std::sin(0.542399823665619*x_117 - 7.43400001525879) + 0.00100609599779642*std::sin(0.976639807224274*x_117 - 7.98496007919312) - 0.00330667433638121*std::sin(0.239919975399971*x_118 - 1.36119985580444) + 0.0088413591290705*std::sin(0.364959836006165*x_118 + 1.96375977993011) - 0.0416921049327239*std::sin(0.384399831295013*x_118 - 7.41703987121582) - 0.0292056254385679*std::sin(0.353999853134155*x_119 + 5.16960000991821) + 0.000868020875098389*std::sin(0.429279863834381*x_119 + 2.01151990890503) - 0.0508110451120166*std::sin(0.283679932355881*x_12 - 7.49535989761353) + 0.0198179497652009*std::sin(0.342879861593246*x_12 + 2.14535975456238) - 0.0229692480775603*std::sin(0.169520005583763*x_120 - 7.63551998138428) + 0.000730601347068582*std::sin(0.322559833526611*x_120 + 5.33591985702515) - 0.744278761523562*std::sin(0.142560034990311*x_14 - 4.49032020568848) + 0.028409693252383*std::sin(0.213919997215271*x_14 + 5.01495981216431) - 0.000788060952020378*std::sin(0.510799825191498*x_15 - 0.896399855613708) + 0.00151468538691286*std::sin(0.338079839944839*x_16 - 4.24959993362427) + 0.0556331214039421*std::sin(0.354879856109619*x_16 + 5.17128038406372) + 0.0127408906749906*std::sin(0.37271985411644*x_16 - 4.2260799407959) + 0.53441157339591*std::sin(0.134800046682358*x_18 + 4.90247964859009) - 0.00568741673136942*std::sin(0.208719998598099*x_18 - 7.57600021362305) + 0.00876876876057159*std::sin(0.295359939336777*x_21 + 8.31112003326416) + 0.0719697133553684*std::sin(0.324959844350815*x_21 - 4.26024007797241) - 0.430285238112635*std::sin(0.161600023508072*x_23 + 4.94087982177734) - 0.02845476260611*std::sin(0.183360010385513*x_23 - 4.41607999801636) - 0.02260599961065*std::sin(0.241919979453087*x_24 - 4.34632015228271) - 0.00432775852667346*std::sin(0.316399842500687*x_26 - 4.28280019760132) - 0.028473242485822*std::sin(0.321759849786758*x_26 - 4.27472019195557) + 0.0693088225829166*std::sin(0.33095982670784*x_26 - 4.2707200050354) - 0.0110790709226979*std::sin(0.398319840431213*x_26 - 1.17639982700348) + 0.119865747028502*std::sin(0.214399993419647*x_27 - 7.57800006866455) + 0.0527560679339823*std::sin(0.291999936103821*x_28 - 4.28151988983154) + 0.0559757702304909*std::sin(0.320719838142395*x_28 + 8.30399990081787) - 1.26132262642135e-5*std::sin(1.78887987136841*x_29 - 0.204079851508141) - 0.070819352407765*std::sin(0.293919950723648*x_3 - 1.08967983722687) - 0.0172661510703176*std::sin(0.317679852247238*x_3 + 8.32208061218262) + 0.00323914655293991*std::sin(0.2880799472332*x_30 - 4.29983997344971) - 0.00686851942953199*std::sin(0.276319950819016*x_32 - 7.44519996643066) + 0.0298876780727073*std::sin(0.251519978046417*x_33 + 2.01743984222412) + 0.0152663421165449*std::sin(0.345679849386215*x_34 + 5.20056009292603) - 0.00351355196581977*std::sin(0.355519831180573*x_34 + 1.9975198507309) - 0.00358190814111608*std::sin(0.321999847888947*x_35 + 1.98599982261658) - 0.0283950317850773*std::sin(0.323519825935364*x_35 + 5.18839979171753) + 0.0316632653082863*std::sin(0.323599845170975*x_35 + 1.97183978557587) + 0.0242457797386889*std::sin(0.325279831886292*x_36 + 5.12784004211426) + 0.00514650128638708*std::sin(0.343599855899811*x_36 - 7.43511962890625) - 0.0170424388153275*std::sin(0.356639832258224*x_36 + 5.1573600769043) + 0.0155382373607668*std::sin(0.36015984416008*x_36 - 4.23160028457642) + 0.00136010508422541*std::sin(0.436079859733582*x_37 + 2.03319978713989) + 0.012424813507273*std::sin(0.3781598508358*x_38 + 5.18815994262695) - 0.0173199915221842*std::sin(0.451279848814011*x_38 + 8.45608043670654) + 0.00686781651364832*std::sin(0.371439844369888*x_39 + 5.17072010040283) + 0.0016484392097116*std::sin(0.401119858026505*x_39 - 7.40167951583862) - 0.0297143652795815*std::sin(0.33095982670784*x_40 - 7.4703197479248) - 0.00949704188134451*std::sin(0.373999834060669*x_40 - 4.22448015213013) - 0.0403676545648573*std::sin(0.372079849243164*x_42 - 7.41975975036621) - 0.00992461482303147*std::sin(0.475279837846756*x_42 + 2.04271984100342) - 0.0490149478141056*std::sin(0.244559973478317*x_43 + 8.25592041015625) - 0.00133961928761435*std::sin(0.446799874305725*x_43 + 2.02879977226257) - 0.0229085640210333*std::sin(0.451839864253998*x_43 + 2.04807996749878) + 0.0310809825736963*std::sin(0.365279853343964*x_44 - 4.22080039978027) + 0.0243932421437557*std::sin(0.370959848165512*x_44 + 8.3645601272583) - 0.0249932556837854*std::sin(0.270159959793091*x_45 - 7.5237603187561) - 0.023196136369979*std::sin(0.366239845752716*x_45 - 7.4172797203064) - 0.0108507694409039*std::sin(0.380239844322205*x_45 + 5.16648006439209) - 0.00178699086204245*std::sin(0.703439831733704*x_46 + 2.05855989456177) - 0.0200037046724981*std::sin(0.339919835329056*x_47 + 5.1384801864624) + 0.0100697565206244*std::sin(0.476239860057831*x_48 - 7.34207963943481) - 0.00590342349278195*std::sin(0.163760021328926*x_49 - 7.27447986602783) - 0.0305853174024195*std::sin(0.238639980554581*x_49 - 4.35871982574463) - 0.0232896663125793*std::sin(0.326239824295044*x_49 + 8.32384014129639) + 0.000604434956280564*std::sin(0.56063985824585*x_49 - 4.21432018280029) + 0.0158361761443506*std::sin(0.322959840297699*x_50 + 4.94575977325439) - 0.0252403125138093*std::sin(0.398319840431213*x_50 - 1.00463974475861) - 0.000964144647391023*std::sin(0.917439818382263*x_50 - 4.02711963653564) - 0.0236542900623214*std::sin(0.210559993982315*x_51 + 5.01375961303711) - 0.00176060454615128*std::sin(0.274559944868088*x_51 - 4.30599975585938) - 0.0131465456960699*std::sin(0.350959837436676*x_51 - 1.05951988697052) + 0.0123182982265691*std::sin(0.363839834928513*x_53 - 4.24128007888794) - 0.0090569283337801*std::sin(0.366159826517105*x_53 - 7.44087982177734) + 0.00410842385076007*std::sin(0.488159865140915*x_54 + 2.25639986991882) - 0.00430282836903322*std::sin(0.683279812335968*x_54 + 8.4498405456543) - 0.0192234875969826*std::sin(0.318879842758179*x_55 + 5.11352014541626) - 0.00115516006366098*std::sin(0.322879940271378*x_55 + 8.36727905273438) + 0.0131286430996849*std::sin(0.4129598736763*x_55 - 4.18151998519897) + 0.0219586927871046*std::sin(0.315759837627411*x_56 + 8.30768013000488) + 0.0215243115774276*std::sin(0.354159832000732*x_56 - 7.45271968841553) - 0.00873867014844197*std::sin(0.538079857826233*x_57 + 2.13239979743958) - 0.0045741150963604*std::sin(0.313599914312363*x_58 + 5.13840007781982) + 0.0229132725525517*std::sin(0.465279877185822*x_58 + 2.05847978591919) - 0.0210540168050681*std::sin(0.337039858102798*x_59 + 5.13671970367432) + 0.0280923465567665*std::sin(0.369119822978973*x_59 - 7.42424011230469) + 0.0110873319338796*std::sin(0.464319854974747*x_6 - 6.90000009536743) + 0.000653370107742727*std::sin(1.47391986846924*x_60 + 3.38039994239807) - 0.0355440850000382*std::sin(0.347919851541519*x_62 + 8.34496021270752) + 0.00944579964147958*std::sin(0.376559853553772*x_62 - 4.21199989318848) - 0.0812207364259578*std::sin(0.296799927949905*x_63 - 4.28799962997437) + 0.00129892107592254*std::sin(0.385599851608276*x_63 - 7.40111970901489) + 0.0143393101112274*std::sin(0.241439983248711*x_64 - 4.3517599105835) + 0.0600876628473004*std::sin(0.278079956769943*x_64 - 4.28567981719971) + 0.00360464411717597*std::sin(0.199440002441406*x_66 + 5.00719976425171) - 0.0119768682615467*std::sin(0.186240002512932*x_67 - 4.4201602935791) + 0.0206041158425934*std::sin(0.296319931745529*x_67 - 7.49088001251221) - 0.000410711254809608*std::sin(0.319439828395844*x_68 - 7.65296030044556) + 0.00506525427122728*std::sin(0.473519861698151*x_68 + 2.26967978477478) - 0.00102904127282284*std::sin(0.418239861726761*x_7 - 7.17655992507935) - 0.00149424047398974*std::sin(0.734559834003448*x_70 + 5.98959970474243) - 0.00539090945278579*std::sin(0.402959853410721*x_72 - 7.19704008102417) + 0.0204140782122745*std::sin(0.498719841241837*x_72 + 8.48984050750732) + 0.000584528351786906*std::sin(0.578239858150482*x_72 - 7.01944017410278) - 0.075837157110768*std::sin(0.275039941072464*x_73 + 5.07879972457886) - 0.00158311151122642*std::sin(0.411759853363037*x_73 + 5.19583988189697) + 0.0154761721279237*std::sin(0.305759936571121*x_75 + 5.14759969711304) - 0.0135634505010867*std::sin(0.391919851303101*x_75 + 8.38992023468018) + 0.179595921697681*std::sin(0.150800034403801*x_76 + 4.92391967773438) + 0.000133692502863312*std::sin(1.22431993484497*x_76 - 0.768399834632874) + 0.0155436793369919*std::sin(0.406159847974777*x_77 - 1.00543987751007) - 0.00146772750181225*std::sin(0.468479871749878*x_77 + 5.25504016876221) - 0.00692934709613022*std::sin(0.491839855909348*x_77 - 0.899999797344208) - 0.00228890136035349*std::sin(0.890239894390106*x_77 + 8.64192008972168) + 0.00180004011189988*std::sin(0.407439857721329*x_78 - 4.18200016021729) + 5.09634463374556e-5*std::sin(0.752559840679169*x_79 - 1.39367985725403) + 0.000728503951015179*std::sin(1.52543985843658*x_8 + 2.39687991142273) + 0.00820913065656836*std::sin(0.430959850549698*x_80 - 7.16616010665894) - 0.000999401420396103*std::sin(0.530399858951569*x_80 + 5.34944009780884) - 0.0128340456574182*std::sin(0.347279846668243*x_81 - 1.04183983802795) + 0.00113607172012391*std::sin(0.423119872808456*x_81 - 4.17736005783081) - 0.0202359046941393*std::sin(0.386639833450317*x_82 - 4.22040033340454) - 0.000379349709650288*std::sin(0.61303985118866*x_82 - 0.966639816761017) + 0.00131789992059962*std::sin(0.99999988079071*x_82 - 10.0) + 0.068349698831811*std::sin(0.32575985789299*x_83 + 5.12007999420166) - 0.0101325516945359*std::sin(0.461679875850677*x_83 + 2.05015993118286) + 0.000501622220902047*std::sin(0.637919843196869*x_83 + 2.00751972198486) + 0.00117165357356668*std::sin(0.36303985118866*x_84 + 5.15488004684448) - 0.00137402356472354*std::sin(0.632639825344086*x_84 + 5.43271970748901) + 0.0750192026653709*std::sin(0.1564000248909*x_85 - 7.65104007720947) - 0.00543971874137103*std::sin(0.5065598487854*x_85 + 8.51416015625) - 0.022026857731298*std::sin(0.186640009284019*x_86 + 8.16335964202881) + 0.0642921145146175*std::sin(0.249119967222214*x_86 - 7.53016042709351) + 0.0207679776463951*std::sin(0.301999926567078*x_86 - 7.48448038101196) + 0.000934523757800689*std::sin(0.489359855651855*x_86 - 4.12224006652832) + 0.0664411465494781*std::sin(0.211119994521141*x_87 + 5.01863956451416) + 0.0184544184560165*std::sin(0.32015985250473*x_87 + 5.12007999420166) + 0.00285042143797113*std::sin(0.5136798620224*x_87 + 5.15128040313721) - 0.0169438920880098*std::sin(0.531839847564697*x_88 + 2.15471982955933) - 0.0131004108791541*std::sin(0.392159849405289*x_9 - 7.39575958251953) - 0.0103147047813909*std::sin(0.53007984161377*x_9 - 4.06080007553101) - 0.00124837145642207*std::sin(0.60999983549118*x_9 + 5.19591999053955) - 0.0617563536836123*std::sin(0.238079980015755*x_90 - 7.55304002761841) + 0.0168750505330624*std::sin(0.406159847974777*x_90 - 4.18832015991211) - 0.00407992192945403*std::sin(0.196719989180565*x_91 - 7.39048004150391) - 0.112503499037625*std::sin(0.353599846363068*x_92 - 7.40887975692749) - 0.00305838525963822*std::sin(0.373679846525192*x_92 + 5.19736003875732) + 0.171015404000676*std::sin(0.375119835138321*x_92 + 1.9987998008728) + 0.0153561456764988*std::sin(0.356559842824936*x_93 + 1.99455988407135) + 0.00159418819774492*std::sin(0.406799852848053*x_94 - 7.39671945571899) - 0.0170678563602204*std::sin(0.45143985748291*x_94 + 2.01095986366272) + 0.0332580376523254*std::sin(0.3643998503685*x_95 - 4.23271989822388) - 0.0015204044063455*std::sin(0.422319859266281*x_96 - 1.19247984886169) + 0.0174517157821716*std::sin(0.440079867839813*x_96 - 4.17288017272949) + 0.00097890106380037*std::sin(0.403919845819473*x_97 - 4.20703983306885) + 0.0124174594606231*std::sin(0.487279862165451*x_98 + 8.24639987945557) + 0.00815917175359862*std::sin(0.600959837436676*x_98 - 7.4047999382019) + 0.00028015518137103*std::sin(0.687439858913422*x_98 + 2.02071976661682) + 0.0211176128992397*std::sin(0.33111983537674*x_99 + 5.1448802947998) + 0.00146158043919396*std::sin(0.446559846401215*x_99 - 7.37319993972778) + 0.00518004889928034*std::sin(0.511439859867096*x_99 + 5.16400003433228) - 0.0860560461878777*std::sin(0.0117205986083597*x_100 - 0.0352888661328132*x_103 + 0.0286850256628506*x_105 + 0.0375415959612337*x_116 - 0.00485572941998164*x_119 - 0.015369193985583*x_12 + 0.00294560122405152*x_13 + 0.0221335876758685*x_14 - 0.00463912201181006*x_2 - 0.000969641916434832*x_20 + 0.0203886632172638*x_22 + 0.00390534505316932*x_23 - 0.0577003220065767*x_28 - 0.148824972439106*x_29 - 0.0132402631617098*x_30 - 0.00750183670650497*x_31 - 0.0261973915028644*x_32 - 0.00403052853851946*x_33 + 0.00441913143151838*x_36 + 0.00389533873116357*x_37 - 0.00553550803900457*x_38 + 0.364061798422618*x_4 + 0.00243393404635503*x_40 - 0.0163360858928944*x_41 + 0.00225476495928086*x_43 + 0.0193755199848144*x_44 - 0.00598673918668886*x_45 + 0.000339130062908866*x_46 - 0.00323325645196451*x_47 + 0.0953758809068108*x_5 + 0.0491265860922733*x_53 - 0.0193523944239939*x_54 - 0.0149025909728623*x_56 - 0.00352212898043877*x_59 + 0.0228420863419071*x_6 - 0.00151802872854444*x_61 + 0.0650623205164735*x_62 - 0.0040089296679863*x_67 - 0.00998697079907088*x_68 - 0.02266871805316*x_70 - 0.00422289799390913*x_73 + 0.0332651201573907*x_74 + 0.00408818188472329*x_76 + 0.0339150412318709*x_79 + 0.0110386239226807*x_80 - 0.0154237155235686*x_83 - 0.00655183617424983*x_84 + 0.0656313968870496*x_90 - 0.361006758168167*x_91 - 0.0255204600012265*x_93 - 0.00531886229097171*x_95 - 0.0465954566710958*x_98 + 0.000951117591995496*std::pow(-6.29008007049561*x_17 - 9.74312019348145, 2) + 0.00102262782924933*std::pow(-4.49232006072998*x_18 - 7.14559984207153, 2) - 0.00424862770058348*std::pow(-1.62839984893799*x_25 - 3.46207976341248, 2) + 0.000104980520157482*std::pow(-7.26232004165649*x_66 - 9.61312007904053, 2) + 0.00319088992070465*std::pow(-5.07807970046997*x_7 - 8.11320018768311, 2) + 0.000196839060173058*std::pow(-5.9539999961853*x_72 - 9.1340799331665, 2) + 0.000433394409681591*std::pow(-4.57719993591309*x_8 - 8.7577600479126, 2) + 0.000327546431352306*std::pow(-6.81415987014771*x_85 - 8.80992031097412, 2) + 0.00243417689768444*std::pow(-6.0*x_9 - 9.99997997283936, 2) + 6.23517125764636*std::sin(0.299839943647385*x_1 - 7.41623973846436) + 1.27052867890748*std::sin(0.308879911899567*x_10 - 4.25407981872559) + 0.38468090124784*std::sin(0.353999853134155*x_101 + 1.96231985092163) - 0.68265889808491*std::sin(0.371919840574265*x_102 - 7.40231990814209) + 0.27024136082343*std::sin(0.332559853792191*x_104 + 5.15224027633667) + 0.0414822212655466*std::sin(0.700959861278534*x_106 - 0.957199811935425) - 0.304269973303363*std::sin(0.385039836168289*x_107 + 5.18535995483398) + 0.472450194893632*std::sin(0.367439836263657*x_108 - 4.22936010360718) - 0.513907784614368*std::sin(0.397519826889038*x_109 + 5.19832038879395) + 0.100263536425661*std::sin(0.327279835939407*x_11 - 1.06439983844757) + 0.0790027551933843*std::sin(0.609279870986938*x_110 + 2.20576000213623) - 0.382073490574676*std::sin(0.368559837341309*x_111 + 5.17408037185669) + 0.193242685111723*std::sin(0.438159853219986*x_112 - 1.17311990261078) + 0.400513384967851*std::sin(0.327199816703796*x_113 + 1.92543983459473) - 0.11687563853676*std::sin(0.469839870929718*x_114 - 0.924239873886108) - 0.424663731385756*std::sin(0.360399842262268*x_115 + 5.16368007659912) + 0.370065229173854*std::sin(0.288879930973053*x_117 + 8.30072021484375) + 0.154372824159942*std::sin(0.427439838647842*x_118 + 8.43224048614502) + 0.315220444844755*std::sin(0.289919942617416*x_120 - 7.49015998840332) - 1.9790634981145*std::sin(0.281919956207275*x_15 - 4.2772798538208) - 0.509071935750448*std::sin(0.326799839735031*x_16 - 4.26232004165649) + 1.48921733302726*std::sin(0.213279992341995*x_19 + 5.02807998657227) - 0.608489016971447*std::sin(0.330719828605652*x_21 - 4.2402400970459) - 2.51622876064556*std::sin(0.158160030841827*x_24 + 4.95127964019775) + 0.955857727496763*std::sin(0.324319839477539*x_26 - 4.26200008392334) + 1.35298829142815*std::sin(0.305119842290878*x_27 - 4.31576013565063) + 0.959242415064367*std::sin(0.343599855899811*x_3 - 1.05495977401733) + 0.274116612770637*std::sin(0.341839849948883*x_34 + 1.98831987380981) - 0.303705847598458*std::sin(0.231999978423119*x_35 - 1.14375984668732) - 0.168718082535619*std::sin(0.409199863672256*x_39 + 1.98799991607666) - 0.314881136148983*std::sin(0.386159837245941*x_42 + 1.99703979492188) - 0.227859721532241*std::sin(0.462239861488342*x_48 + 5.23808002471924) + 0.257968002004944*std::sin(0.374799847602844*x_49 - 4.23487997055054) - 0.382513525289959*std::sin(0.27727997303009*x_50 + 5.07631969451904) - 0.654676263266836*std::sin(0.325199842453003*x_51 - 4.27367973327637) + 0.468984046574313*std::sin(0.226319998502731*x_52 + 8.22552013397217) + 0.714943820509347*std::sin(0.238079980015755*x_55 - 4.34976005554199) + 0.882167211576089*std::sin(0.304559946060181*x_57 - 4.27871990203857) + 0.265706790083389*std::sin(0.498079836368561*x_58 - 1.10559988021851) + 1.10079040378245*std::sin(0.151360034942627*x_60 + 1.74399983882904) - 0.685867465107478*std::sin(0.271359950304031*x_63 + 5.09839963912964) + 0.9651273877503*std::sin(0.211040005087852*x_64 + 5.00703954696655) - 0.0298071273397493*std::sin(0.521519839763641*x_65 + 8.33312034606934) + 0.751310113247854*std::sin(0.298079937696457*x_69 - 7.49047994613647) + 0.210222785502079*std::sin(0.271119952201843*x_71 + 5.07599973678589) + 0.197247977616549*std::sin(0.437039852142334*x_75 + 5.22632026672363) - 0.0580537929862661*std::sin(0.492559850215912*x_77 - 0.874159812927246) + 0.397415976540607*std::sin(0.428879857063293*x_78 - 4.15312004089355) + 0.87620597776089*std::sin(0.207440003752708*x_81 - 7.58808040618896) - 0.0044259067552479*std::sin(0.997999846935272*x_82 - 4.60471963882446) - 0.505167619246983*std::sin(0.155040040612221*x_86 - 1.27311992645264) - 0.100533791802134*std::sin(0.399999856948853*x_87 + 8.40015983581543) + 0.247382903933399*std::sin(0.279199928045273*x_88 + 5.0959997177124) - 0.220406512717584*std::sin(0.501599848270416*x_89 + 8.48872089385986) + 0.472889662983391*std::sin(0.326319843530655*x_92 - 4.21528005599976) - 0.177073725823558*std::sin(0.392959833145142*x_94 + 5.19432020187378) - 0.276624064035293*std::sin(0.346799850463867*x_96 + 5.1637601852417) - 0.100768466428828*std::sin(0.437839865684509*x_97 + 5.22304010391235) + 0.0739554800146855*std::sin(0.531919836997986*x_99 - 1.00535976886749) - 0.839907307209518) + 1.03315002189956);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.07643239495066e-6*x_1 - 0.0074017116458163*x_10 - 0.000130171025519872*x_100 + 0.00738202576110127*x_101 - 0.00153753804664335*x_102 + 8.78400466172839e-5*x_103 - 0.000740804003157191*x_104 - 0.00104950071804233*x_105 + 1.56763890959929e-5*x_106 + 0.00119418321232355*x_107 - 0.00023081835496012*x_109 + 0.0387502293076101*x_11 + 0.00238996968534181*x_111 + 4.27277681653417e-5*x_112 + 0.00567873909882584*x_113 - 0.00459668575355778*x_114 + 2.94772397093795e-5*x_115 - 0.0143650311850227*x_116 + 1.01528027893343e-5*x_117 + 4.41329065951403e-5*x_119 + 0.0156071501936696*x_12 - 4.32117428941364e-5*x_120 - 0.0159007562013144*x_13 + 0.0024199683916676*x_14 - 7.40510919818271e-5*x_16 - 0.000145078052633245*x_17 - 1.96087015801588e-5*x_19 - 6.93252295805598e-5*x_2 + 0.0138973974665453*x_20 + 0.000288815000848555*x_21 - 6.00753495130589e-5*x_22 + 0.0022222676876423*x_23 - 0.00294362580796451*x_24 + 0.00204142931785434*x_25 + 0.00067734764634579*x_27 + 0.00155904241256748*x_28 + 0.000213572426521058*x_29 - 2.01256920678054e-5*x_3 + 3.144005750691e-5*x_30 + 3.04399508855661e-5*x_31 + 0.000109883069165678*x_32 - 0.0186173033836203*x_33 + 9.90608778685908e-6*x_34 - 1.86645843570856e-5*x_36 - 4.73125579677188e-5*x_37 - 0.00743169270802736*x_38 - 2.69383126266857e-5*x_39 + 0.00244240990056654*x_4 - 0.00242773954368004*x_40 + 0.00411059454895367*x_41 - 0.000773977054067417*x_42 - 9.52319509841747e-6*x_43 - 0.0028632708587963*x_44 + 0.00384322821617825*x_45 - 0.000485367025798666*x_46 - 0.00435910691509063*x_47 - 0.00374080191131074*x_48 - 0.000316759897567088*x_5 + 0.00922385119033904*x_50 + 4.40394619168831e-5*x_51 - 0.000948537894874202*x_52 - 0.00255298910996276*x_53 - 0.0017286300970708*x_54 + 0.0034257891281268*x_56 - 9.48396731597886e-5*x_57 + 3.10085891955043e-5*x_58 - 0.000130875347667177*x_59 - 9.64755300961646e-5*x_6 - 0.00199848460232623*x_60 - 0.00341654723898214*x_61 + 0.00902518137022065*x_62 - 0.000144426173230573*x_63 - 1.85856476415124e-5*x_64 + 0.00864865472489799*x_65 + 5.22017243937991e-6*x_66 + 1.6932061679832e-5*x_67 + 7.65340071363164e-5*x_68 - 0.00036147075681835*x_69 + 0.00353629729149589*x_70 + 0.0013756227851647*x_71 - 5.93515227932529e-5*x_72 + 1.30769245704384e-5*x_73 + 0.00112050992096782*x_74 + 0.000281125485245079*x_75 - 1.72667902815259e-5*x_76 - 1.86638122875619e-5*x_78 - 0.000125467771051951*x_79 + 0.0332149525073863*x_8 - 5.65052519411355e-5*x_80 - 3.53576092880693e-5*x_82 + 6.51433984144765e-5*x_83 + 5.10856947585175e-5*x_84 + 1.08756435194508e-5*x_85 + 1.25809345717246e-5*x_88 - 0.00568015462067059*x_89 + 0.00012893394137655*x_9 + 0.0014979023505559*x_90 + 0.00153801477309318*x_91 + 9.57874796487524e-6*x_92 - 0.0110129720815409*x_93 - 2.10454720100241e-5*x_94 - 0.00277109728093284*x_95 + 1.62618508283686e-5*x_96 + 1.85658528344018e-5*x_97 + 0.000196799947042032*x_98 - 7.65050063581131e-6*x_99 - 0.00106927561439303*std::pow(-2.17063999176025*x_108 - 3.15591979026794, 2) + 5.70107183726306e-5*std::pow(-3.51968002319336*x_110 - 5.79135990142822, 2) - 2.5081229663598e-7*std::pow(-6.72800016403198*x_118 - 8.75936031341553, 2) + 1.50394818186261e-6*std::pow(-5.40447998046875*x_13 - 8.20039939880371, 2) - 2.21621558361036e-6*std::pow(-5.76688003540039*x_14 - 8.3450403213501, 2) - 1.81221497251009e-6*std::pow(-6.59999990463257*x_15 - 9.99973964691162, 2) + 3.41273916275986e-6*std::pow(-5.93840026855469*x_15 - 8.39935970306396, 2) + 0.000432029855941769*std::pow(-6.46104001998901*x_17 - 9.48311996459961, 2) - 4.01712752933636e-6*std::pow(-6.29008007049561*x_17 - 9.74312019348145, 2) - 9.46836606466719e-6*std::pow(-4.0065598487854*x_17 - 6.20688009262085, 2) - 4.31915721012386e-6*std::pow(-4.49232006072998*x_18 - 7.14559984207153, 2) - 6.01289965236516e-6*std::pow(-3.45199990272522*x_18 - 5.2752799987793, 2) + 0.000121233503349094*std::pow(-4.59431982040405*x_19 - 7.38895988464355, 2) + 0.000322266514569641*std::pow(-5.7294397354126*x_22 - 9.58975982666016, 2) - 1.17558182932996e-6*std::pow(-5.72079992294312*x_22 - 8.28072071075439, 2) + 1.79444470815716e-5*std::pow(-1.62839984893799*x_25 - 3.46207976341248, 2) + 1.81409043637767e-6*std::pow(-6.12911987304688*x_27 - 7.76647996902466, 2) - 5.20176960854797e-6*std::pow(-5.51200008392334*x_4 - 9.19999980926514, 2) + 0.000385726071888433*std::pow(-4.11559963226318*x_5 - 6.37784004211426, 2) + 0.000727403511687068*std::pow(-3.28671979904175*x_6 - 5.13399982452393, 2) - 9.89344842752532e-6*std::pow(-3.16847991943359*x_6 - 5.34823989868164, 2) - 3.80057452681375e-5*std::pow(-5.31584024429321*x_64 - 8.99736022949219, 2) - 4.43394319606561e-7*std::pow(-7.26232004165649*x_66 - 9.61312007904053, 2) - 1.09325208499251e-6*std::pow(-5.60232019424438*x_66 - 7.61072015762329, 2) - 4.53040650208862e-7*std::pow(-5.68575954437256*x_67 - 8.73624038696289, 2) - 2.24803715813005e-6*std::pow(-5.72591972351074*x_7 - 9.18144035339355, 2) - 3.2713092067243e-6*std::pow(-5.31304025650024*x_7 - 8.78575992584229, 2) - 1.34769999539713e-5*std::pow(-5.07807970046997*x_7 - 8.11320018768311, 2) - 5.96126412477721e-7*std::pow(-7.10591983795166*x_70 - 9.93296051025391, 2) - 8.31366819544259e-7*std::pow(-5.9539999961853*x_72 - 9.1340799331665, 2) - 1.83047882706037e-6*std::pow(-4.57719993591309*x_8 - 8.7577600479126, 2) + 1.05183308141897e-6*std::pow(-6.33008003234863*x_81 - 8.87975978851318, 2) + 1.18230601548856e-6*std::pow(-4.91448020935059*x_81 - 6.35383987426758, 2) - 1.38342072273169e-6*std::pow(-6.81415987014771*x_85 - 8.80992031097412, 2) + 0.000180621798517494*std::pow(-2.30607986450195*x_85 - 3.7727198600769, 2) - 3.97611663457315e-5*std::pow(-5.80800008773804*x_87 - 8.01583957672119, 2) + 4.47509786986706e-5*std::pow(-9.5959997177124*x_88 - 9.99096012115479, 2) - 1.02809569597458e-5*std::pow(-6.0*x_9 - 9.99997997283936, 2) + 3.30066541300024e-5*std::exp(0.57999986410141*x_106) + 8.61931891527848e-5*std::exp(0.612399816513062*x_76) - 1.85436762106963e-5*std::log(0.681119859218597*x_91 + 1.02415990829468) - 0.0263347858561496*std::sin(0.299839943647385*x_1 - 7.41623973846436) + 0.00216912117567824*std::sin(0.305919945240021*x_1 + 1.97895979881287) - 0.180527907895136*std::sin(0.351679861545563*x_1 - 4.35207986831665) - 0.00757843206138252*std::sin(0.212640002369881*x_10 + 5.01351976394653) - 0.00536618792019439*std::sin(0.308879911899567*x_10 - 4.25407981872559) - 0.000354908035107156*std::sin(0.41143986582756*x_100 - 0.988239824771881) - 0.00845913038073921*std::sin(0.513359844684601*x_100 - 7.22968006134033) + 0.000243111675714257*std::sin(0.303999930620193*x_101 - 4.3010401725769) - 0.00162473310494707*std::sin(0.353999853134155*x_101 + 1.96231985092163) - 0.00116637019289389*std::sin(0.363119840621948*x_102 + 5.16175985336304) + 0.00288326898348055*std::sin(0.371919840574265*x_102 - 7.40231990814209) - 0.000201981273376534*std::sin(0.411119878292084*x_102 - 1.00239980220795) + 0.0521878702697902*std::sin(0.388159841299057*x_103 - 7.40567970275879) + 0.000613122160564886*std::sin(0.437279850244522*x_103 + 2.00919985771179) + 0.00235445912973283*std::sin(0.136880040168762*x_104 - 7.68391990661621) - 0.00114138779396509*std::sin(0.332559853792191*x_104 + 5.15224027633667) + 0.000843021980896365*std::sin(0.34215983748436*x_104 - 7.4378399848938) + 0.000534737563930134*std::sin(0.345919847488403*x_105 + 8.34463977813721) - 0.141901053870199*std::sin(0.364719837903976*x_106 + 1.98247981071472) - 0.000175203754431911*std::sin(0.700959861278534*x_106 - 0.957199811935425) + 0.00128511058610844*std::sin(0.385039836168289*x_107 + 5.18535995483398) - 0.000678664906630779*std::sin(0.296479940414429*x_108 + 5.10391998291016) - 0.00199543431865839*std::sin(0.367439836263657*x_108 - 4.22936010360718) - 2.49839340610796e-5*std::sin(0.85207986831665*x_108 + 8.40624046325684) + 0.00217053403962737*std::sin(0.397519826889038*x_109 + 5.19832038879395) - 0.000423471730261141*std::sin(0.327279835939407*x_11 - 1.06439983844757) + 0.000158524083525827*std::sin(0.597919821739197*x_110 - 7.19352006912231) - 0.000333674979257737*std::sin(0.609279870986938*x_110 + 2.20576000213623) - 5.02745783626149e-5*std::sin(0.816159844398499*x_110 + 5.6101598739624) + 0.000475419377087737*std::sin(0.339759826660156*x_111 - 1.04287981987) + 0.00161372048013222*std::sin(0.368559837341309*x_111 + 5.17408037185669) + 0.0392873304647849*std::sin(0.268239974975586*x_112 + 5.07903957366943) + 0.00028131402195111*std::sin(0.369279861450195*x_112 + 1.9748797416687) - 0.000816177217978383*std::sin(0.438159853219986*x_112 - 1.17311990261078) - 0.00169160297124403*std::sin(0.327199816703796*x_113 + 1.92543983459473) + 0.000445282869858336*std::sin(0.409679859876633*x_114 + 5.21720027923584) + 0.000493634382358272*std::sin(0.469839870929718*x_114 - 0.924239873886108) + 0.00179360405108405*std::sin(0.360399842262268*x_115 + 5.16368007659912) - 3.62354372307105e-5*std::sin(0.516719877719879*x_115 - 7.04375982284546) + 0.000665083568218478*std::sin(1.55183982849121*x_115 + 1.80663990974426) - 0.000675083772053826*std::sin(0.259839832782745*x_116 + 8.09823989868164) - 0.00156300254802931*std::sin(0.288879930973053*x_117 + 8.30072021484375) - 0.0441861156145926*std::sin(0.394879847764969*x_117 - 7.39591979980469) + 0.000241703197747264*std::sin(0.542399823665619*x_117 - 7.43400001525879) + 0.120435654868729*std::sin(0.239919975399971*x_118 - 1.36119985580444) + 0.00107871971797677*std::sin(0.384399831295013*x_118 - 7.41703987121582) - 0.000652006993597111*std::sin(0.427439838647842*x_118 + 8.43224048614502) + 0.000755651077998204*std::sin(0.353999853134155*x_119 + 5.16960000991821) - 0.0316150463872442*std::sin(0.429279863834381*x_119 + 2.01151990890503) + 0.00131465840695222*std::sin(0.283679932355881*x_12 - 7.49535989761353) - 0.000323725194828534*std::sin(0.342879861593246*x_12 + 2.14535975456238) - 0.00133136085112125*std::sin(0.289919942617416*x_120 - 7.49015998840332) - 0.0266099539086986*std::sin(0.322559833526611*x_120 + 5.33591985702515) + 0.0192570794164108*std::sin(0.142560034990311*x_14 - 4.49032020568848) + 0.00835874609773607*std::sin(0.281919956207275*x_15 - 4.2772798538208) + 0.0287027469832175*std::sin(0.510799825191498*x_15 - 0.896399855613708) + 0.00215010941310122*std::sin(0.326799839735031*x_16 - 4.26232004165649) - 0.055167853842113*std::sin(0.338079839944839*x_16 - 4.24959993362427) - 0.000329651141813931*std::sin(0.37271985411644*x_16 - 4.2260799407959) - 0.00872958569205763*std::sin(0.134800046682358*x_18 + 4.90247964859009) + 0.20714702715583*std::sin(0.208719998598099*x_18 - 7.57600021362305) - 0.00628983839224057*std::sin(0.213279992341995*x_19 + 5.02807998657227) - 0.00117562158314837*std::sin(0.324959844350815*x_21 - 4.26024007797241) + 0.00257000606649109*std::sin(0.330719828605652*x_21 - 4.2402400970459) + 0.00702868733598504*std::sin(0.161600023508072*x_23 + 4.94087982177734) + 0.0106275101097542*std::sin(0.158160030841827*x_24 + 4.95127964019775) + 0.00058489581094389*std::sin(0.241919979453087*x_24 - 4.34632015228271) + 0.157625571571726*std::sin(0.316399842500687*x_26 - 4.28280019760132) + 0.000736701784516575*std::sin(0.321759849786758*x_26 - 4.27472019195557) - 0.00403714790218529*std::sin(0.324319839477539*x_26 - 4.26200008392334) + 0.000180976056325834*std::sin(0.398319840431213*x_26 - 1.17639982700348) - 0.00310134364859502*std::sin(0.214399993419647*x_27 - 7.57800006866455) - 0.00571446323578412*std::sin(0.305119842290878*x_27 - 4.31576013565063) - 0.000861767668838508*std::sin(0.291999936103821*x_28 - 4.28151988983154) - 0.00144828780350627*std::sin(0.320719838142395*x_28 + 8.30399990081787) + 0.000459398782766276*std::sin(1.78887987136841*x_29 - 0.204079851508141) + 0.00115683049596235*std::sin(0.293919950723648*x_3 - 1.08967983722687) + 0.628867556849233*std::sin(0.317679852247238*x_3 + 8.32208061218262) - 0.00405144342328642*std::sin(0.343599855899811*x_3 - 1.05495977401733) - 0.117976158712393*std::sin(0.2880799472332*x_30 - 4.29983997344971) + 0.25016513612271*std::sin(0.276319950819016*x_32 - 7.44519996643066) - 0.000773298151139065*std::sin(0.251519978046417*x_33 + 2.01743984222412) - 0.00115775525621292*std::sin(0.341839849948883*x_34 + 1.98831987380981) - 0.000249374916908689*std::sin(0.345679849386215*x_34 + 5.20056009292603) + 0.127970549522549*std::sin(0.355519831180573*x_34 + 1.9975198507309) + 0.00128272795233292*std::sin(0.231999978423119*x_35 - 1.14375984668732) + 0.130460217357557*std::sin(0.321999847888947*x_35 + 1.98599982261658) + 0.000463831390516869*std::sin(0.323519825935364*x_35 + 5.18839979171753) - 0.000819238766636835*std::sin(0.323599845170975*x_35 + 1.97183978557587) - 0.000396053570761347*std::sin(0.325279831886292*x_36 + 5.12784004211426) - 0.187445811003908*std::sin(0.343599855899811*x_36 - 7.43511962890625) + 0.000440947148678906*std::sin(0.356639832258224*x_36 + 5.1573600769043) - 0.0495377318252158*std::sin(0.436079859733582*x_37 + 2.03319978713989) - 0.000321473126485384*std::sin(0.3781598508358*x_38 + 5.18815994262695) + 0.000282921174812597*std::sin(0.451279848814011*x_38 + 8.45608043670654) - 0.0600394340466493*std::sin(0.401119858026505*x_39 - 7.40167951583862) + 0.000712595434838609*std::sin(0.409199863672256*x_39 + 1.98799991607666) + 0.000768813946572658*std::sin(0.33095982670784*x_40 - 7.4703197479248) + 0.000659403570682477*std::sin(0.372079849243164*x_42 - 7.41975975036621) + 0.00132992775145598*std::sin(0.386159837245941*x_42 + 1.99703979492188) + 0.000256784293338128*std::sin(0.475279837846756*x_42 + 2.04271984100342) + 0.000800656663208116*std::sin(0.244559973478317*x_43 + 8.25592041015625) + 0.0487915983752973*std::sin(0.446799874305725*x_43 + 2.02879977226257) + 0.000592724204256369*std::sin(0.451839864253998*x_43 + 2.04807996749878) - 0.000804173087697062*std::sin(0.365279853343964*x_44 - 4.22080039978027) - 0.000398462361598729*std::sin(0.370959848165512*x_44 + 8.3645601272583) + 0.000600164700812087*std::sin(0.366239845752716*x_45 - 7.4172797203064) + 0.000177246763308693*std::sin(0.380239844322205*x_45 + 5.16648006439209) + 4.62356669647658e-5*std::sin(0.703439831733704*x_46 + 2.05855989456177) + 0.000517565392719497*std::sin(0.339919835329056*x_47 + 5.1384801864624) + 0.000962385269600204*std::sin(0.462239861488342*x_48 + 5.23808002471924) - 0.000260539613712255*std::sin(0.476239860057831*x_48 - 7.34207963943481) + 0.000791348506289302*std::sin(0.238639980554581*x_49 - 4.35871982574463) + 0.000380435506894367*std::sin(0.326239824295044*x_49 + 8.32384014129639) - 0.00108955019995768*std::sin(0.374799847602844*x_49 - 4.23487997055054) - 0.0220147230660967*std::sin(0.56063985824585*x_49 - 4.21432018280029) + 0.00161557900486512*std::sin(0.27727997303009*x_50 + 5.07631969451904) - 0.00040973693920779*std::sin(0.322959840297699*x_50 + 4.94575977325439) + 0.000412299212727527*std::sin(0.398319840431213*x_50 - 1.00463974475861) + 0.0641247186478743*std::sin(0.274559944868088*x_51 - 4.30599975585938) + 0.00276508190165483*std::sin(0.325199842453003*x_51 - 4.27367973327637) + 0.000214748150903859*std::sin(0.350959837436676*x_51 - 1.05951988697052) - 0.0019807947410168*std::sin(0.226319998502731*x_52 + 8.22552013397217) + 0.000234334226916971*std::sin(0.366159826517105*x_53 - 7.44087982177734) + 7.02864811235384e-5*std::sin(0.683279812335968*x_54 + 8.4498405456543) - 0.00301962714964757*std::sin(0.238079980015755*x_55 - 4.34976005554199) + 0.000314014685744362*std::sin(0.318879842758179*x_55 + 5.11352014541626) + 0.0420732266297103*std::sin(0.322879940271378*x_55 + 8.36727905273438) - 0.000339683645255195*std::sin(0.4129598736763*x_55 - 4.18151998519897) - 0.000556908780497253*std::sin(0.354159832000732*x_56 - 7.45271968841553) - 0.00372590962560704*std::sin(0.304559946060181*x_57 - 4.27871990203857) + 0.000142745729495899*std::sin(0.538079857826233*x_57 + 2.13239979743958) + 0.166598367735841*std::sin(0.313599914312363*x_58 + 5.13840007781982) - 0.000592846030338304*std::sin(0.465279877185822*x_58 + 2.05847978591919) - 0.00112223564168986*std::sin(0.498079836368561*x_58 - 1.10559988021851) - 0.000726846682457511*std::sin(0.369119822978973*x_59 - 7.42424011230469) - 0.000181110999520562*std::sin(0.464319854974747*x_6 - 6.90000009536743) - 0.00464928361359205*std::sin(0.151360034942627*x_60 + 1.74399983882904) - 1.69049564538894e-5*std::sin(1.47391986846924*x_60 + 3.38039994239807) + 0.000580610808785281*std::sin(0.347919851541519*x_62 + 8.34496021270752) - 0.000244395679751932*std::sin(0.376559853553772*x_62 - 4.21199989318848) + 0.00289682064420531*std::sin(0.271359950304031*x_63 + 5.09839963912964) + 0.00132673657139749*std::sin(0.296799927949905*x_63 - 4.28799962997437) - 0.0473092885744316*std::sin(0.385599851608276*x_63 - 7.40111970901489) - 0.00407629911514304*std::sin(0.211040005087852*x_64 + 5.00703954696655) - 0.00155467676254571*std::sin(0.278079956769943*x_64 - 4.28567981719971) + 0.000125892984016543*std::sin(0.521519839763641*x_65 + 8.33312034606934) - 0.13128830681763*std::sin(0.199440002441406*x_66 + 5.00719976425171) + 0.43622135886973*std::sin(0.186240002512932*x_67 - 4.4201602935791) - 0.000336567177454727*std::sin(0.296319931745529*x_67 - 7.49088001251221) + 0.0149589206263009*std::sin(0.319439828395844*x_68 - 7.65296030044556) - 0.00317322333683748*std::sin(0.298079937696457*x_69 - 7.49047994613647) + 0.0374797294719386*std::sin(0.418239861726761*x_7 - 7.17655992507935) + 2.44083416445227e-5*std::sin(0.734559834003448*x_70 + 5.98959970474243) - 0.000887894142681545*std::sin(0.271119952201843*x_71 + 5.07599973678589) - 0.000333462922492503*std::sin(0.498719841241837*x_72 + 8.48984050750732) - 0.0212896849448555*std::sin(0.578239858150482*x_72 - 7.01944017410278) + 0.00196217094010232*std::sin(0.275039941072464*x_73 + 5.07879972457886) + 0.0576600693594271*std::sin(0.411759853363037*x_73 + 5.19583988189697) - 0.00025280247940225*std::sin(0.305759936571121*x_75 + 5.14759969711304) + 0.000350933624553943*std::sin(0.391919851303101*x_75 + 8.38992023468018) - 0.000833093917784577*std::sin(0.437039852142334*x_75 + 5.22632026672363) - 0.00293369018646328*std::sin(0.150800034403801*x_76 + 4.92391967773438) - 0.0048693468105491*std::sin(1.22431993484497*x_76 - 0.768399834632874) - 0.000253905206206328*std::sin(0.406159847974777*x_77 - 1.00543987751007) + 0.0534575542879296*std::sin(0.468479871749878*x_77 + 5.25504016876221) + 0.000245195222914801*std::sin(0.492559850215912*x_77 - 0.874159812927246) + 5.92218366978921e-5*std::sin(0.890239894390106*x_77 + 8.64192008972168) - 0.0655610403726344*std::sin(0.407439857721329*x_78 - 4.18200016021729) - 0.00167852079847444*std::sin(0.428879857063293*x_78 - 4.15312004089355) - 0.00185619005974927*std::sin(0.752559840679169*x_79 - 1.39367985725403) - 1.88489302195737e-5*std::sin(1.52543985843658*x_8 + 2.39687991142273) - 0.00013409572900608*std::sin(0.430959850549698*x_80 - 7.16616010665894) + 0.0364001871057757*std::sin(0.530399858951569*x_80 + 5.34944009780884) - 0.00370073183826572*std::sin(0.207440003752708*x_81 - 7.58808040618896) - 0.0413779911996731*std::sin(0.423119872808456*x_81 - 4.17736005783081) + 0.0138166707871191*std::sin(0.61303985118866*x_82 - 0.966639816761017) + 1.86932005236912e-5*std::sin(0.997999846935272*x_82 - 4.60471963882446) - 3.40986532813551e-5*std::sin(0.99999988079071*x_82 - 10.0) - 0.00176844436054793*std::sin(0.32575985789299*x_83 + 5.12007999420166) + 0.00016551471319115*std::sin(0.461679875850677*x_83 + 2.05015993118286) - 0.0182700787937768*std::sin(0.637919843196869*x_83 + 2.00751972198486) - 0.0426739530588967*std::sin(0.36303985118866*x_84 + 5.15488004684448) - 0.00194100761457389*std::sin(0.1564000248909*x_85 - 7.65104007720947) + 0.00213361919418264*std::sin(0.155040040612221*x_86 - 1.27311992645264) + 0.000359807593369009*std::sin(0.186640009284019*x_86 + 8.16335964202881) - 0.00166346054604941*std::sin(0.249119967222214*x_86 - 7.53016042709351) - 0.0340372136205845*std::sin(0.489359855651855*x_86 - 4.12224006652832) - 0.00171906347697143*std::sin(0.211119994521141*x_87 + 5.01863956451416) + 0.000424613177251414*std::sin(0.399999856948853*x_87 + 8.40015983581543) - 4.6561488261058e-5*std::sin(0.5136798620224*x_87 + 5.15128040313721) - 0.00104484312144101*std::sin(0.279199928045273*x_88 + 5.0959997177124) + 0.000276777609809883*std::sin(0.531839847564697*x_88 + 2.15471982955933) + 0.00093090599662363*std::sin(0.501599848270416*x_89 + 8.48872089385986) + 0.000168490174539543*std::sin(0.53007984161377*x_9 - 4.06080007553101) + 0.045468170911007*std::sin(0.60999983549118*x_9 + 5.19591999053955) + 0.00100878687578632*std::sin(0.238079980015755*x_90 - 7.55304002761841) + 0.148598869861746*std::sin(0.196719989180565*x_91 - 7.39048004150391) - 0.00199729045019932*std::sin(0.326319843530655*x_92 - 4.21528005599976) + 0.111392472954716*std::sin(0.373679846525192*x_92 + 5.19736003875732) - 0.00279352786916493*std::sin(0.375119835138321*x_92 + 1.9987998008728) + 0.000747886217976023*std::sin(0.392959833145142*x_94 + 5.19432020187378) - 0.0580635043091447*std::sin(0.406799852848053*x_94 - 7.39671945571899) + 0.000278802559850055*std::sin(0.45143985748291*x_94 + 2.01095986366272) - 0.000860501072197444*std::sin(0.3643998503685*x_95 - 4.23271989822388) + 0.00116834569380811*std::sin(0.346799850463867*x_96 + 5.1637601852417) + 0.0553761519024931*std::sin(0.422319859266281*x_96 - 1.19247984886169) - 0.000451536566866378*std::sin(0.440079867839813*x_96 - 4.17288017272949) - 0.0356535233522621*std::sin(0.403919845819473*x_97 - 4.20703983306885) + 0.00042560434586323*std::sin(0.437839865684509*x_97 + 5.22304010391235) - 0.000321282851728547*std::sin(0.487279862165451*x_98 + 8.24639987945557) - 0.000133279652883731*std::sin(0.600959837436676*x_98 - 7.4047999382019) - 0.0102038088123952*std::sin(0.687439858913422*x_98 + 2.02071976661682) - 0.000344955125586406*std::sin(0.33111983537674*x_99 + 5.1448802947998) - 0.0532336660435363*std::sin(0.446559846401215*x_99 - 7.37319993972778) - 0.000312357375378759*std::sin(0.531919836997986*x_99 - 1.00535976886749) + 0.0239467918872833*std::sin(0.0592353528330396*x_1 + 0.000758834829518754*x_10 - 0.0259118085386988*x_100 - 0.0020484863938178*x_101 - 0.0104263524896008*x_102 + 0.0177569134353684*x_103 - 0.0422103495454422*x_104 + 0.0432005199982989*x_106 - 0.00647439589668491*x_107 + 0.023500189932703*x_109 - 0.0357853624699946*x_11 + 0.0611926195082195*x_113 + 0.00733781990412087*x_114 + 0.0121969586323468*x_115 - 0.0278459774016602*x_116 + 0.0582660114612058*x_119 + 0.0831883179357246*x_12 - 0.121288809653641*x_13 + 0.0369606185345239*x_17 - 0.0234133549589279*x_18 + 0.0232164081163573*x_19 + 0.170294141912071*x_20 + 0.120447832572638*x_22 - 0.00527784441648862*x_25 - 8.55369178061476e-6*x_27 + 0.00500301518805751*x_28 + 0.134547643740219*x_29 - 0.014690375043406*x_3 - 0.0267276946534369*x_30 + 0.00878029383360139*x_31 + 0.0434666184797285*x_32 + 0.0187234795835325*x_33 - 0.053520965630093*x_34 + 0.0232900256240919*x_35 - 0.00290266684279998*x_37 + 0.00921966476137006*x_38 + 0.0260959516826385*x_42 - 0.0428059209393062*x_43 + 0.0407888958149436*x_44 + 0.0143749376222266*x_46 - 0.0436877880828502*x_47 + 0.0200308454899197*x_48 - 0.0113415746875121*x_52 - 0.0398621402172504*x_57 + 0.00205020832080936*x_58 - 0.000427336482327125*x_6 + 0.00242873618948297*x_60 - 0.014403276679312*x_61 - 0.00578792065708021*x_62 + 0.00994668807397234*x_63 - 0.00472863822701433*x_65 + 0.00223994475239819*x_67 - 0.0130571963154488*x_69 - 0.0132094825789219*x_7 + 0.00926993314866625*x_71 + 0.00279845171385336*x_73 - 0.0180840840575855*x_74 + 0.0100864665825926*x_79 - 0.000439888176914812*x_80 - 0.0186502403277299*x_83 - 0.0124532407079556*x_88 + 0.00794874800982883*x_89 + 0.204646197230304*x_91 - 0.0158757234126651*x_94 + 0.00860225545065027*x_95 + 0.00895542997404544*x_96 + 0.014767425598158*x_97 + 0.00798221463581422*x_98 + 0.000390351959153754*std::pow(-6.25112009048462*x_110 - 8.66423988342285, 2) + 0.00121770704629784*std::pow(-5.72383975982666*x_24 - 8.38159942626953, 2) + 0.00548434920842433*std::pow(-4.58247995376587*x_4 - 7.77960014343262, 2) + 0.0003488334978443*std::pow(-3.95839977264404*x_41 - 9.7038402557373, 2) + 0.00796844363679994*std::pow(-3.50720000267029*x_5 - 5.56712007522583, 2) - 0.000167915897324396*std::pow(-7.74287986755371*x_55 - 9.17280006408691, 2) - 0.0159672200766532*std::pow(-1.15495979785919*x_66 - 1.92279982566833, 2) - 0.000228775973844575*std::pow(-5.73503971099854*x_70 - 6.75536012649536, 2) - 0.00143255428561689*std::pow(-3.84744000434875*x_75 - 5.66079998016357, 2) + 8.49240432527279e-5*std::pow(-5.71463966369629*x_78 - 9.38111972808838, 2) + 0.0109571568337075*std::pow(-2.51511979103088*x_8 - 5.22399997711182, 2) - 0.0316892245874668*std::exp(0.719279825687408*x_15) + 0.0639148280597775*std::exp(0.612959861755371*x_2) - 0.0175491250747035*std::exp(0.513279855251312*x_76) + 0.383407534444686*std::sin(0.376319825649261*x_105 + 5.18792009353638) - 0.0860405453192659*std::sin(0.708239853382111*x_108 - 4.02719974517822) - 0.197165737716666*std::sin(0.361119836568832*x_111 + 1.97559976577759) + 0.504992857859392*std::sin(0.331439822912216*x_112 - 7.43304014205933) - 0.0298349372743569*std::sin(0.976639807224274*x_117 - 7.98496007919312) - 0.262183127269786*std::sin(0.364959836006165*x_118 + 1.96375977993011) + 0.681133884971302*std::sin(0.169520005583763*x_120 - 7.63551998138428) - 0.842465746832318*std::sin(0.213919997215271*x_14 + 5.01495981216431) - 1.64975379198273*std::sin(0.354879856109619*x_16 + 5.17128038406372) - 0.260030520465236*std::sin(0.295359939336777*x_21 + 8.31112003326416) + 0.843802240908815*std::sin(0.183360010385513*x_23 - 4.41607999801636) - 2.05529529870893*std::sin(0.33095982670784*x_26 - 4.2707200050354) - 0.460773462997466*std::sin(0.36015984416008*x_36 - 4.23160028457642) - 0.203659367838924*std::sin(0.371439844369888*x_39 + 5.17072010040283) + 0.281626852151724*std::sin(0.373999834060669*x_40 - 4.22448015213013) + 0.741154141593739*std::sin(0.270159959793091*x_45 - 7.5237603187561) + 0.175061097546234*std::sin(0.163760021328926*x_49 - 7.27447986602783) + 0.0285909049845348*std::sin(0.917439818382263*x_50 - 4.02711963653564) + 0.701448233393734*std::sin(0.210559993982315*x_51 + 5.01375961303711) - 0.365288854862214*std::sin(0.363839834928513*x_53 - 4.24128007888794) - 0.121831881005754*std::sin(0.488159865140915*x_54 + 2.25639986991882) - 0.651166711094206*std::sin(0.315759837627411*x_56 + 8.30768013000488) + 0.624339299756926*std::sin(0.337039858102798*x_59 + 5.13671970367432) - 0.425220275861378*std::sin(0.241439983248711*x_64 - 4.3517599105835) - 0.150205888694245*std::sin(0.473519861698151*x_68 + 2.26967978477478) + 0.159862921359267*std::sin(0.402959853410721*x_72 - 7.19704008102417) + 0.205484005918017*std::sin(0.491839855909348*x_77 - 0.899999797344208) + 0.380582914556811*std::sin(0.347279846668243*x_81 - 1.04183983802795) + 0.600078867783822*std::sin(0.386639833450317*x_82 - 4.22040033340454) + 0.0407455222531459*std::sin(0.632639825344086*x_84 + 5.43271970748901) + 0.161310320083182*std::sin(0.5065598487854*x_85 + 8.51416015625) - 0.615857047192847*std::sin(0.301999926567078*x_86 - 7.48448038101196) - 0.547250379959664*std::sin(0.32015985250473*x_87 + 5.12007999420166) + 0.388481752938006*std::sin(0.392159849405289*x_9 - 7.39575958251953) - 0.500415542113501*std::sin(0.406159847974777*x_90 - 4.18832015991211) + 3.33619738502568*std::sin(0.353599846363068*x_92 - 7.40887975692749) - 0.455373686047537*std::sin(0.356559842824936*x_93 + 1.99455988407135) - 0.153610027598383*std::sin(0.511439859867096*x_99 + 5.16400003433228) + 13.3690533346287) - 0.131605160585349);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00127153555150377*x_1 - 0.00336798168848824*x_10 + 0.00286278317797325*x_100 - 0.000240851521224927*x_101 - 0.000223143610914907*x_102 + 0.00105645783159235*x_103 - 0.000903381103309604*x_104 - 0.000320699155062557*x_105 + 0.000869417639033387*x_106 - 0.000441747951509535*x_107 - 0.0017759318229141*x_109 - 0.0103259719325756*x_11 + 2.42355254961367e-5*x_111 - 0.00189119329970914*x_112 + 0.000143761991819094*x_113 + 2.07567876087798e-5*x_114 + 0.000157326758382732*x_115 - 0.000199861711852761*x_116 - 3.57210853195639e-5*x_117 + 0.00122732894418271*x_119 + 0.00198120069934592*x_12 - 7.30413598935061e-5*x_120 - 0.00250670666729428*x_13 - 0.000289197291707755*x_14 + 0.000260537452521834*x_16 + 0.00130146191793147*x_17 - 0.000501089961650402*x_18 + 0.000932999697614589*x_19 - 0.0099110793802697*x_2 + 0.0037545856499754*x_20 + 0.000873545069875827*x_21 + 0.00221980220313735*x_22 + 0.00357628802985381*x_23 - 1.58255049895929e-5*x_24 + 0.011088625469617*x_25 - 1.83065139269296e-7*x_27 + 0.000860985939957076*x_28 + 0.022992788461248*x_29 + 0.000576390729507942*x_3 - 0.000803375231630397*x_30 + 0.00680752197227231*x_31 + 0.00197214152788763*x_32 + 0.000659038932821119*x_33 - 0.00158390750790566*x_34 + 0.000498450481243951*x_35 - 5.77403383676966e-5*x_36 + 0.000160050458993649*x_37 + 0.000269645124114025*x_38 + 0.00115611008404027*x_39 - 0.00500073932556767*x_4 - 5.95028216672152e-5*x_40 - 0.000138593325965389*x_41 + 0.000558502591825176*x_42 - 0.000945588196750993*x_43 + 0.000619798912332739*x_44 + 7.82226896202071e-5*x_45 + 0.000177322768998012*x_46 - 0.000833090522990286*x_47 + 0.000498165203283806*x_48 - 0.00508790697040543*x_5 - 0.00194925077709916*x_51 - 0.000813139361599764*x_52 - 0.000665868263453167*x_53 + 0.000370007191895418*x_54 + 0.000245417219720594*x_56 - 0.00299245448097976*x_57 - 6.52206576818764e-5*x_58 + 7.35760888576175e-6*x_59 - 0.000307600336824223*x_6 + 2.08631985774451e-5*x_60 - 0.00145832790394609*x_61 - 0.000973976215285548*x_62 + 0.00660539083280692*x_63 + 6.53907614377436e-5*x_64 + 0.00041190588131153*x_65 - 1.83663791131466e-5*x_66 + 0.000100319688177753*x_67 - 0.000846210623788666*x_68 + 0.000653088371396329*x_69 - 0.000282707844753776*x_7 + 0.000296189301231452*x_70 + 0.000112368332815573*x_71 + 0.00262698491060389*x_72 + 0.000131811788885523*x_73 - 0.000938627325062749*x_74 - 5.34161540543962e-5*x_76 + 0.00198331653747752*x_78 - 0.00212729205669144*x_79 - 0.000292018940476892*x_8 + 0.000283776263305543*x_80 + 0.000124400345823889*x_82 - 0.000197624171547674*x_83 + 4.84461594049149e-5*x_84 - 3.82642899822284e-5*x_85 - 0.000823373344512059*x_88 - 0.00085478459422431*x_89 - 0.00570680418160035*x_9 - 0.00452715616660816*x_90 + 0.009050032655057*x_91 - 0.000423969347068978*x_92 + 0.00018364468352735*x_93 + 0.000591732839365956*x_94 + 0.000182800347837049*x_95 + 0.000134448257008625*x_96 - 0.000763202560879761*x_97 + 0.000779650340162542*x_98 + 0.000338622309638979*x_99 + 8.35426826209404e-6*std::pow(-6.25112009048462*x_110 - 8.66423988342285, 2) + 8.82444742917839e-7*std::pow(-6.72800016403198*x_118 - 8.75936031341553, 2) - 6.65669387093192e-5*std::pow(-5.40447998046875*x_13 - 8.20039939880371, 2) + 7.79741590488272e-6*std::pow(-5.76688003540039*x_14 - 8.3450403213501, 2) + 8.02112761982181e-5*std::pow(-6.59999990463257*x_15 - 9.99973964691162, 2) - 1.20072012956292e-5*std::pow(-5.93840026855469*x_15 - 8.39935970306396, 2) - 1.24272953724799e-5*std::pow(-6.29008007049561*x_17 - 9.74312019348145, 2) + 0.000419083683271262*std::pow(-4.0065598487854*x_17 - 6.20688009262085, 2) - 1.33616475997845e-5*std::pow(-4.49232006072998*x_18 - 7.14559984207153, 2) + 0.000266139703117008*std::pow(-3.45199990272522*x_18 - 5.2752799987793, 2) + 5.20329653139244e-5*std::pow(-5.72079992294312*x_22 - 8.28072071075439, 2) + 2.60612277993136e-5*std::pow(-5.72383975982666*x_24 - 8.38159942626953, 2) + 5.55125378893223e-5*std::pow(-1.62839984893799*x_25 - 3.46207976341248, 2) - 6.38260001694575e-6*std::pow(-6.12911987304688*x_27 - 7.76647996902466, 2) + 0.00023023790506091*std::pow(-5.51200008392334*x_4 - 9.19999980926514, 2) + 0.000117375418403198*std::pow(-4.58247995376587*x_4 - 7.77960014343262, 2) + 7.4656948721705e-6*std::pow(-3.95839977264404*x_41 - 9.7038402557373, 2) + 0.000170539725015142*std::pow(-3.50720000267029*x_5 - 5.56712007522583, 2) - 3.5937169490821e-6*std::pow(-7.74287986755371*x_55 - 9.17280006408691, 2) + 0.00043789844825854*std::pow(-3.16847991943359*x_6 - 5.34823989868164, 2) - 1.37167469441548e-6*std::pow(-7.26232004165649*x_66 - 9.61312007904053, 2) + 4.83889308243333e-5*std::pow(-5.60232019424438*x_66 - 7.61072015762329, 2) - 0.00034172862923358*std::pow(-1.15495979785919*x_66 - 1.92279982566833, 2) + 2.00522395378902e-5*std::pow(-5.68575954437256*x_67 - 8.73624038696289, 2) + 7.90937525266152e-6*std::pow(-5.72591972351074*x_7 - 9.18144035339355, 2) + 0.000144792913804753*std::pow(-5.31304025650024*x_7 - 8.78575992584229, 2) - 4.16921439361343e-5*std::pow(-5.07807970046997*x_7 - 8.11320018768311, 2) + 2.63854239401155e-5*std::pow(-7.10591983795166*x_70 - 9.93296051025391, 2) - 4.89623738936218e-6*std::pow(-5.73503971099854*x_70 - 6.75536012649536, 2) - 2.57189769403773e-6*std::pow(-5.9539999961853*x_72 - 9.1340799331665, 2) - 3.06593639955116e-5*std::pow(-3.84744000434875*x_75 - 5.66079998016357, 2) + 1.81753472116048e-6*std::pow(-5.71463966369629*x_78 - 9.38111972808838, 2) - 5.6627281287004e-6*std::pow(-4.57719993591309*x_8 - 8.7577600479126, 2) + 0.000234503825155834*std::pow(-2.51511979103088*x_8 - 5.22399997711182, 2) - 4.65556653531347e-5*std::pow(-6.33008003234863*x_81 - 8.87975978851318, 2) - 4.15976306537415e-6*std::pow(-4.91448020935059*x_81 - 6.35383987426758, 2) - 4.27971923227353e-6*std::pow(-6.81415987014771*x_85 - 8.80992031097412, 2) - 3.18049372138356e-5*std::pow(-6.0*x_9 - 9.99997997283936, 2) - 0.00146092262284625*std::exp(0.57999986410141*x_106) - 0.000678209182798457*std::exp(0.719279825687408*x_15) + 0.00136789788552509*std::exp(0.612959861755371*x_2) - 0.000375584380201269*std::exp(0.513279855251312*x_76) - 0.0038150361885396*std::exp(0.612399816513062*x_76) + 0.000820770138658708*std::log(0.681119859218597*x_91 + 1.02415990829468) - 0.0814687012088565*std::sin(0.299839943647385*x_1 - 7.41623973846436) - 0.0960084649829048*std::sin(0.305919945240021*x_1 + 1.97895979881287) + 0.0266635552635327*std::sin(0.212640002369881*x_10 + 5.01351976394653) - 0.0166007182548934*std::sin(0.308879911899567*x_10 - 4.25407981872559) + 0.00124868969344895*std::sin(0.41143986582756*x_100 - 0.988239824771881) - 0.000855351284819011*std::sin(0.303999930620193*x_101 - 4.3010401725769) - 0.00502623779035444*std::sin(0.353999853134155*x_101 + 1.96231985092163) + 0.0516252448582281*std::sin(0.363119840621948*x_102 + 5.16175985336304) + 0.00891961607749653*std::sin(0.371919840574265*x_102 - 7.40231990814209) + 0.000710640248702243*std::sin(0.411119878292084*x_102 - 1.00239980220795) - 0.0271376805237407*std::sin(0.437279850244522*x_103 + 2.00919985771179) - 0.00828380469903005*std::sin(0.136880040168762*x_104 - 7.68391990661621) - 0.00353097160758812*std::sin(0.332559853792191*x_104 + 5.15224027633667) - 0.0373133816774438*std::sin(0.34215983748436*x_104 - 7.4378399848938) - 0.0236682640219846*std::sin(0.345919847488403*x_105 + 8.34463977813721) + 0.00820564447377942*std::sin(0.376319825649261*x_105 + 5.18792009353638) - 0.000542006394069467*std::sin(0.700959861278534*x_106 - 0.957199811935425) + 0.00397558920478401*std::sin(0.385039836168289*x_107 + 5.18535995483398) + 0.0300386980008225*std::sin(0.296479940414429*x_108 + 5.10391998291016) - 0.00617303072736842*std::sin(0.367439836263657*x_108 - 4.22936010360718) - 0.00184142997148602*std::sin(0.708239853382111*x_108 - 4.02719974517822) + 8.79021545805777e-5*std::sin(0.85207986831665*x_108 + 8.40624046325684) + 0.00671471528585686*std::sin(0.397519826889038*x_109 + 5.19832038879395) - 0.00131004262011062*std::sin(0.327279835939407*x_11 - 1.06439983844757) - 0.000557742766241895*std::sin(0.597919821739197*x_110 - 7.19352006912231) - 0.00103224941089362*std::sin(0.609279870986938*x_110 + 2.20576000213623) + 0.0022252261193975*std::sin(0.816159844398499*x_110 + 5.6101598739624) - 0.0210427546091566*std::sin(0.339759826660156*x_111 - 1.04287981987) - 0.0042197187085973*std::sin(0.361119836568832*x_111 + 1.97559976577759) + 0.00499216938192054*std::sin(0.368559837341309*x_111 + 5.17408037185669) + 0.0108077997460163*std::sin(0.331439822912216*x_112 - 7.43304014205933) - 0.000989760402936396*std::sin(0.369279861450195*x_112 + 1.9748797416687) - 0.00252490748427444*std::sin(0.438159853219986*x_112 - 1.17311990261078) - 0.00523310490470962*std::sin(0.327199816703796*x_113 + 1.92543983459473) - 0.0197088688717052*std::sin(0.409679859876633*x_114 + 5.21720027923584) + 0.00152709622255666*std::sin(0.469839870929718*x_114 - 0.924239873886108) + 0.00554865315111871*std::sin(0.360399842262268*x_115 + 5.16368007659912) + 0.00160383326921196*std::sin(0.516719877719879*x_115 - 7.04375982284546) + 0.00237517910273218*std::sin(0.259839832782745*x_116 + 8.09823989868164) - 0.00483526952790262*std::sin(0.288879930973053*x_117 + 8.30072021484375) - 0.0106981358429266*std::sin(0.542399823665619*x_117 - 7.43400001525879) - 0.000638523936483053*std::sin(0.976639807224274*x_117 - 7.98496007919312) - 0.00561121348988489*std::sin(0.364959836006165*x_118 + 1.96375977993011) - 0.047745707077595*std::sin(0.384399831295013*x_118 - 7.41703987121582) - 0.0020170341706061*std::sin(0.427439838647842*x_118 + 8.43224048614502) - 0.0334462181618786*std::sin(0.353999853134155*x_119 + 5.16960000991821) - 0.0581886973598363*std::sin(0.283679932355881*x_12 - 7.49535989761353) + 0.00113897763450212*std::sin(0.342879861593246*x_12 + 2.14535975456238) + 0.0145775499879359*std::sin(0.169520005583763*x_120 - 7.63551998138428) - 0.00411866798437771*std::sin(0.289919942617416*x_120 - 7.49015998840332) - 0.8523464044121*std::sin(0.142560034990311*x_14 - 4.49032020568848) - 0.0180303561583774*std::sin(0.213919997215271*x_14 + 5.01495981216431) + 0.025858428925031*std::sin(0.281919956207275*x_15 - 4.2772798538208) + 0.00665153012062138*std::sin(0.326799839735031*x_16 - 4.26232004165649) - 0.0353078431436844*std::sin(0.354879856109619*x_16 + 5.17128038406372) + 0.0145908400417148*std::sin(0.37271985411644*x_16 - 4.2260799407959) + 0.0307137134228608*std::sin(0.134800046682358*x_18 + 4.90247964859009) - 0.0194581025806892*std::sin(0.213279992341995*x_19 + 5.02807998657227) - 0.0055651436437209*std::sin(0.295359939336777*x_21 + 8.31112003326416) + 0.00413624491153122*std::sin(0.324959844350815*x_21 - 4.26024007797241) + 0.00795051296333283*std::sin(0.330719828605652*x_21 - 4.2402400970459) - 0.0247293624453157*std::sin(0.161600023508072*x_23 + 4.94087982177734) + 0.0180589596526957*std::sin(0.183360010385513*x_23 - 4.41607999801636) + 0.0328770262441108*std::sin(0.158160030841827*x_24 + 4.95127964019775) - 0.0258883411463151*std::sin(0.241919979453087*x_24 - 4.34632015228271) - 0.0326074948115739*std::sin(0.321759849786758*x_26 - 4.27472019195557) - 0.0124892299476319*std::sin(0.324319839477539*x_26 - 4.26200008392334) - 0.0439871963764678*std::sin(0.33095982670784*x_26 - 4.2707200050354) - 0.000636736601995713*std::sin(0.398319840431213*x_26 - 1.17639982700348) + 0.137269990457305*std::sin(0.214399993419647*x_27 - 7.57800006866455) - 0.0176781349378764*std::sin(0.305119842290878*x_27 - 4.31576013565063) + 0.00303199786925444*std::sin(0.291999936103821*x_28 - 4.28151988983154) + 0.0641033292317671*std::sin(0.320719838142395*x_28 + 8.30399990081787) - 0.0040701313424462*std::sin(0.293919950723648*x_3 - 1.08967983722687) - 0.0125334542501789*std::sin(0.343599855899811*x_3 - 1.05495977401733) + 0.0342273033417627*std::sin(0.251519978046417*x_33 + 2.01743984222412) - 0.00358160562066497*std::sin(0.341839849948883*x_34 + 1.98831987380981) + 0.000877387541971407*std::sin(0.345679849386215*x_34 + 5.20056009292603) + 0.0039682183425257*std::sin(0.231999978423119*x_35 - 1.14375984668732) - 0.00163191987654391*std::sin(0.323519825935364*x_35 + 5.18839979171753) + 0.0362607019475053*std::sin(0.323599845170975*x_35 + 1.97183978557587) + 0.00139345397382742*std::sin(0.325279831886292*x_36 + 5.12784004211426) - 0.0195169635324838*std::sin(0.356639832258224*x_36 + 5.1573600769043) - 0.00986142128319295*std::sin(0.36015984416008*x_36 - 4.23160028457642) + 0.014228869162861*std::sin(0.3781598508358*x_38 + 5.18815994262695) - 0.000995414924715058*std::sin(0.451279848814011*x_38 + 8.45608043670654) - 0.00435869464240268*std::sin(0.371439844369888*x_39 + 5.17072010040283) + 0.00220446920969002*std::sin(0.409199863672256*x_39 + 1.98799991607666) - 0.0340288259114018*std::sin(0.33095982670784*x_40 - 7.4703197479248) + 0.00602734587981887*std::sin(0.373999834060669*x_40 - 4.22448015213013) - 0.00232001071005914*std::sin(0.372079849243164*x_42 - 7.41975975036621) + 0.00411423457948615*std::sin(0.386159837245941*x_42 + 1.99703979492188) - 0.0113656471162359*std::sin(0.475279837846756*x_42 + 2.04271984100342) - 0.00281698813338319*std::sin(0.244559973478317*x_43 + 8.25592041015625) - 0.0262348372451227*std::sin(0.451839864253998*x_43 + 2.04807996749878) + 0.0355938730376448*std::sin(0.365279853343964*x_44 - 4.22080039978027) + 0.00140192893633822*std::sin(0.370959848165512*x_44 + 8.3645601272583) + 0.0158620966982191*std::sin(0.270159959793091*x_45 - 7.5237603187561) - 0.0265641644680713*std::sin(0.366239845752716*x_45 - 7.4172797203064) - 0.000623615654331203*std::sin(0.380239844322205*x_45 + 5.16648006439209) - 0.00204645801374374*std::sin(0.703439831733704*x_46 + 2.05855989456177) - 0.0229081986937572*std::sin(0.339919835329056*x_47 + 5.1384801864624) + 0.00297721342429505*std::sin(0.462239861488342*x_48 + 5.23808002471924) + 0.0115318630698127*std::sin(0.476239860057831*x_48 - 7.34207963943481) + 0.00374663771210071*std::sin(0.163760021328926*x_49 - 7.27447986602783) - 0.0350262383712124*std::sin(0.238639980554581*x_49 - 4.35871982574463) - 0.00133850420246923*std::sin(0.326239824295044*x_49 + 8.32384014129639) - 0.00337060799268562*std::sin(0.374799847602844*x_49 - 4.23487997055054) + 0.00499791887223276*std::sin(0.27727997303009*x_50 + 5.07631969451904) + 0.0181355541687677*std::sin(0.322959840297699*x_50 + 4.94575977325439) - 0.00145061178283704*std::sin(0.398319840431213*x_50 - 1.00463974475861) + 0.00061189929881398*std::sin(0.917439818382263*x_50 - 4.02711963653564) + 0.0150123153639278*std::sin(0.210559993982315*x_51 + 5.01375961303711) + 0.00855399517939618*std::sin(0.325199842453003*x_51 - 4.27367973327637) - 0.000755558556570595*std::sin(0.350959837436676*x_51 - 1.05951988697052) - 0.00612774205924629*std::sin(0.226319998502731*x_52 + 8.22552013397217) - 0.00781787055273891*std::sin(0.363839834928513*x_53 - 4.24128007888794) - 0.0103719744528424*std::sin(0.366159826517105*x_53 - 7.44087982177734) - 0.00260743206977651*std::sin(0.488159865140915*x_54 + 2.25639986991882) - 0.000247292244429625*std::sin(0.683279812335968*x_54 + 8.4498405456543) - 0.00934145063341545*std::sin(0.238079980015755*x_55 - 4.34976005554199) - 0.00110481269200403*std::sin(0.318879842758179*x_55 + 5.11352014541626) + 0.0150348932675703*std::sin(0.4129598736763*x_55 - 4.18151998519897) - 0.0139361959387111*std::sin(0.315759837627411*x_56 + 8.30768013000488) + 0.0246495943843822*std::sin(0.354159832000732*x_56 - 7.45271968841553) - 0.0115263902155065*std::sin(0.304559946060181*x_57 - 4.27871990203857) - 0.000502229038436857*std::sin(0.538079857826233*x_57 + 2.13239979743958) + 0.0262402294450849*std::sin(0.465279877185822*x_58 + 2.05847978591919) - 0.00347172294007513*std::sin(0.498079836368561*x_58 - 1.10559988021851) + 0.0133620387304956*std::sin(0.337039858102798*x_59 + 5.13671970367432) + 0.0321712936294777*std::sin(0.369119822978973*x_59 - 7.42424011230469) + 0.000637211379007756*std::sin(0.464319854974747*x_6 - 6.90000009536743) - 0.0143829192164293*std::sin(0.151360034942627*x_60 + 1.74399983882904) + 0.000748238013597046*std::sin(1.47391986846924*x_60 + 3.38039994239807) - 0.00204279041644223*std::sin(0.347919851541519*x_62 + 8.34496021270752) + 0.01081730902106*std::sin(0.376559853553772*x_62 - 4.21199989318848) + 0.00896153919031395*std::sin(0.271359950304031*x_63 + 5.09839963912964) - 0.00466791990811266*std::sin(0.296799927949905*x_63 - 4.28799962997437) - 0.0126103472594582*std::sin(0.211040005087852*x_64 + 5.00703954696655) - 0.00910051601310996*std::sin(0.241439983248711*x_64 - 4.3517599105835) + 0.0688122596331827*std::sin(0.278079956769943*x_64 - 4.28567981719971) + 0.000389459703798581*std::sin(0.521519839763641*x_65 + 8.33312034606934) + 0.00118416018818518*std::sin(0.296319931745529*x_67 - 7.49088001251221) - 0.00321468935731328*std::sin(0.473519861698151*x_68 + 2.26967978477478) - 0.00981661234345732*std::sin(0.298079937696457*x_69 - 7.49047994613647) - 8.58770206104071e-5*std::sin(0.734559834003448*x_70 + 5.98959970474243) - 0.00274676934949616*std::sin(0.271119952201843*x_71 + 5.07599973678589) + 0.00342136807278405*std::sin(0.402959853410721*x_72 - 7.19704008102417) + 0.00117323834141438*std::sin(0.498719841241837*x_72 + 8.48984050750732) - 0.0868485459021825*std::sin(0.275039941072464*x_73 + 5.07879972457886) + 0.000889446896891533*std::sin(0.305759936571121*x_75 + 5.14759969711304) - 0.0155328337494913*std::sin(0.391919851303101*x_75 + 8.38992023468018) - 0.0025772406063085*std::sin(0.437039852142334*x_75 + 5.22632026672363) + 0.0103217406686862*std::sin(0.150800034403801*x_76 + 4.92391967773438) + 0.000893326672660841*std::sin(0.406159847974777*x_77 - 1.00543987751007) + 0.00439774533918161*std::sin(0.491839855909348*x_77 - 0.899999797344208) + 0.000758530426736704*std::sin(0.492559850215912*x_77 - 0.874159812927246) - 0.0026212448149906*std::sin(0.890239894390106*x_77 + 8.64192008972168) - 0.00519263418927073*std::sin(0.428879857063293*x_78 - 4.15312004089355) + 0.000834281126034979*std::sin(1.52543985843658*x_8 + 2.39687991142273) + 0.000471795333387875*std::sin(0.430959850549698*x_80 - 7.16616010665894) - 0.0114485007788802*std::sin(0.207440003752708*x_81 - 7.58808040618896) + 0.00814519227998767*std::sin(0.347279846668243*x_81 - 1.04183983802795) + 0.0128428197228673*std::sin(0.386639833450317*x_82 - 4.22040033340454) + 5.78288646970796e-5*std::sin(0.997999846935272*x_82 - 4.60471963882446) + 0.00150925609700139*std::sin(0.99999988079071*x_82 - 10.0) + 0.0782739251119955*std::sin(0.32575985789299*x_83 + 5.12007999420166) - 0.000582338228587998*std::sin(0.461679875850677*x_83 + 2.05015993118286) + 0.000872031036093315*std::sin(0.632639825344086*x_84 + 5.43271970748901) + 0.0859118262662762*std::sin(0.1564000248909*x_85 - 7.65104007720947) + 0.00345234513576079*std::sin(0.5065598487854*x_85 + 8.51416015625) + 0.00660051635026895*std::sin(0.155040040612221*x_86 - 1.27311992645264) - 0.00126592804056663*std::sin(0.186640009284019*x_86 + 8.16335964202881) + 0.0736271884561231*std::sin(0.249119967222214*x_86 - 7.53016042709351) - 0.0131805025252188*std::sin(0.301999926567078*x_86 - 7.48448038101196) + 0.0760882552264959*std::sin(0.211119994521141*x_87 + 5.01863956451416) - 0.0117121904309826*std::sin(0.32015985250473*x_87 + 5.12007999420166) + 0.00131357377484658*std::sin(0.399999856948853*x_87 + 8.40015983581543) + 0.000163819482096744*std::sin(0.5136798620224*x_87 + 5.15128040313721) - 0.00323230318012741*std::sin(0.279199928045273*x_88 + 5.0959997177124) - 0.000973799729957333*std::sin(0.531839847564697*x_88 + 2.15471982955933) + 0.00287982985343902*std::sin(0.501599848270416*x_89 + 8.48872089385986) + 0.00831424232123373*std::sin(0.392159849405289*x_9 - 7.39575958251953) - 0.000592806934707521*std::sin(0.53007984161377*x_9 - 4.06080007553101) - 0.00354926248514105*std::sin(0.238079980015755*x_90 - 7.55304002761841) - 0.010709836554684*std::sin(0.406159847974777*x_90 - 4.18832015991211) - 0.00617877281415577*std::sin(0.326319843530655*x_92 - 4.21528005599976) + 0.0714009172394676*std::sin(0.353599846363068*x_92 - 7.40887975692749) + 0.00982860097133464*std::sin(0.375119835138321*x_92 + 1.9987998008728) - 0.00974585587065352*std::sin(0.356559842824936*x_93 + 1.99455988407135) + 0.00231364398265203*std::sin(0.392959833145142*x_94 + 5.19432020187378) - 0.000980924207271994*std::sin(0.45143985748291*x_94 + 2.01095986366272) + 0.0380870317362461*std::sin(0.3643998503685*x_95 - 4.23271989822388) + 0.00361436796021185*std::sin(0.346799850463867*x_96 + 5.1637601852417) + 0.0199856666167747*std::sin(0.440079867839813*x_96 - 4.17288017272949) + 0.00131664003177097*std::sin(0.437839865684509*x_97 + 5.22304010391235) + 0.0142204473247758*std::sin(0.487279862165451*x_98 + 8.24639987945557) + 0.000468924094243515*std::sin(0.600959837436676*x_98 - 7.4047999382019) + 0.00121367190205227*std::sin(0.33111983537674*x_99 + 5.1448802947998) - 0.0032875443512225*std::sin(0.511439859867096*x_99 + 5.16400003433228) - 0.000966301751004078*std::sin(0.531919836997986*x_99 - 1.00535976886749) - 0.167944729328156*std::sin(-0.0353554063356716*x_10 + 0.0348798036408014*x_101 - 0.0072691944536769*x_102 - 0.00350238380296875*x_104 - 0.00431635609565139*x_105 + 0.00564355280442346*x_107 - 0.0013118809005546*x_109 + 0.182098546507284*x_11 + 0.0113318997253174*x_111 + 0.0267638445833986*x_113 - 0.0219154131246067*x_114 - 0.0670708534933676*x_116 + 0.0734808115909277*x_12 - 0.0749455545848021*x_13 + 0.0118831321680997*x_14 - 0.00148948206914838*x_2 + 0.0652931703493197*x_20 + 0.00145877195280247*x_21 + 0.0109719061848655*x_23 - 0.0139381820420925*x_24 + 0.010842234226514*x_25 + 0.00320237392809704*x_27 + 0.00621868383451097*x_28 + 0.00134442511659427*x_31 - 0.0878232817941729*x_33 - 0.0352461983633076*x_38 + 0.0184892106912258*x_4 - 0.0114665238407555*x_40 + 0.0190362006439323*x_41 - 0.00365921982937772*x_42 - 0.0131501162349828*x_44 + 0.0180505243392108*x_45 - 0.00245712860953931*x_46 - 0.0205934357692197*x_47 - 0.0175924695738962*x_48 + 0.0436086560984507*x_50 - 0.00433030875064012*x_52 - 0.0111213067660095*x_53 - 0.00854656392213203*x_54 + 0.0159670438608589*x_56 - 0.00067689814122427*x_57 - 0.000741038518928086*x_59 - 0.00949027708859088*x_60 - 0.0164285232904161*x_61 + 0.0439685681804409*x_62 + 0.0412789499005204*x_65 - 0.00161474430099679*x_69 + 0.0162663005900599*x_70 + 0.00650057708702505*x_71 + 0.00603685421292074*x_74 + 0.00132910910568497*x_75 + 0.156641726000426*x_8 - 0.027073314711088*x_89 + 0.00800038151756892*x_90 - 0.0527424688786846*x_93 - 0.0133025810243529*x_95 - 0.00505533660293267*std::pow(-2.17063999176025*x_108 - 3.15591979026794, 2) + 0.000269536092911131*std::pow(-3.51968002319336*x_110 - 5.79135990142822, 2) + 0.00204255695622679*std::pow(-6.46104001998901*x_17 - 9.48311996459961, 2) + 0.000573169497866399*std::pow(-4.59431982040405*x_19 - 7.38895988464355, 2) + 0.00152361625484954*std::pow(-5.7294397354126*x_22 - 9.58975982666016, 2) + 0.00182364126112605*std::pow(-4.11559963226318*x_5 - 6.37784004211426, 2) + 0.00343902876698521*std::pow(-3.28671979904175*x_6 - 5.13399982452393, 2) - 0.0001796841081846*std::pow(-5.31584024429321*x_64 - 8.99736022949219, 2) + 0.000853946332491029*std::pow(-2.30607986450195*x_85 - 3.7727198600769, 2) - 0.000187983413160481*std::pow(-5.80800008773804*x_87 - 8.01583957672119, 2) + 0.00021157431964898*std::pow(-9.5959997177124*x_88 - 9.99096012115479, 2) - 0.853502435058516*std::sin(0.351679861545563*x_1 - 4.35207986831665) - 0.0399931980745727*std::sin(0.513359844684601*x_100 - 7.22968006134033) + 0.246734562401606*std::sin(0.388159841299057*x_103 - 7.40567970275879) - 0.670881839975323*std::sin(0.364719837903976*x_106 + 1.98247981071472) + 0.185743205078964*std::sin(0.268239974975586*x_112 + 5.07903957366943) + 0.00314439164343283*std::sin(1.55183982849121*x_115 + 1.80663990974426) - 0.208903751849483*std::sin(0.394879847764969*x_117 - 7.39591979980469) + 0.569397418365014*std::sin(0.239919975399971*x_118 - 1.36119985580444) - 0.149470070254594*std::sin(0.429279863834381*x_119 + 2.01151990890503) - 0.125806922168852*std::sin(0.322559833526611*x_120 + 5.33591985702515) + 0.135701259315955*std::sin(0.510799825191498*x_15 - 0.896399855613708) - 0.26082337152296*std::sin(0.338079839944839*x_16 - 4.24959993362427) + 0.979352689310133*std::sin(0.208719998598099*x_18 - 7.57600021362305) + 0.745224440545257*std::sin(0.316399842500687*x_26 - 4.28280019760132) + 0.00217195216144472*std::sin(1.78887987136841*x_29 - 0.204079851508141) + 2.97316906487333*std::sin(0.317679852247238*x_3 + 8.32208061218262) - 0.557769377122384*std::sin(0.2880799472332*x_30 - 4.29983997344971) + 1.18273432255972*std::sin(0.276319950819016*x_32 - 7.44519996643066) + 0.60502100149921*std::sin(0.355519831180573*x_34 + 1.9975198507309) + 0.61679168883748*std::sin(0.321999847888947*x_35 + 1.98599982261658) - 0.886208996706955*std::sin(0.343599855899811*x_36 - 7.43511962890625) - 0.234205199811306*std::sin(0.436079859733582*x_37 + 2.03319978713989) - 0.283855298362603*std::sin(0.401119858026505*x_39 - 7.40167951583862) + 0.230677619373417*std::sin(0.446799874305725*x_43 + 2.02879977226257) - 0.104081523810528*std::sin(0.56063985824585*x_49 - 4.21432018280029) + 0.303169765558877*std::sin(0.274559944868088*x_51 - 4.30599975585938) + 0.198914404968818*std::sin(0.322879940271378*x_55 + 8.36727905273438) + 0.787646155085952*std::sin(0.313599914312363*x_58 + 5.13840007781982) - 0.223669533813123*std::sin(0.385599851608276*x_63 - 7.40111970901489) - 0.620706742076948*std::sin(0.199440002441406*x_66 + 5.00719976425171) + 2.06237360395335*std::sin(0.186240002512932*x_67 - 4.4201602935791) + 0.0707229997248469*std::sin(0.319439828395844*x_68 - 7.65296030044556) + 0.177197203150527*std::sin(0.418239861726761*x_7 - 7.17655992507935) - 0.100653678170456*std::sin(0.578239858150482*x_72 - 7.01944017410278) + 0.272606103830221*std::sin(0.411759853363037*x_73 + 5.19583988189697) - 0.0230213677674822*std::sin(1.22431993484497*x_76 - 0.768399834632874) + 0.252737392733337*std::sin(0.468479871749878*x_77 + 5.25504016876221) - 0.309960428032639*std::sin(0.407439857721329*x_78 - 4.18200016021729) - 0.00877572201660737*std::sin(0.752559840679169*x_79 - 1.39367985725403) + 0.172093327251162*std::sin(0.530399858951569*x_80 + 5.34944009780884) - 0.195627460920143*std::sin(0.423119872808456*x_81 - 4.17736005783081) + 0.0653226545341568*std::sin(0.61303985118866*x_82 - 0.966639816761017) - 0.0863775408523395*std::sin(0.637919843196869*x_83 + 2.00751972198486) - 0.201754528006262*std::sin(0.36303985118866*x_84 + 5.15488004684448) - 0.160921627279095*std::sin(0.489359855651855*x_86 - 4.12224006652832) + 0.214965071288276*std::sin(0.60999983549118*x_9 + 5.19591999053955) + 0.70254787059082*std::sin(0.196719989180565*x_91 - 7.39048004150391) + 0.526642933065318*std::sin(0.373679846525192*x_92 + 5.19736003875732) - 0.274513469378221*std::sin(0.406799852848053*x_94 - 7.39671945571899) + 0.261808166083675*std::sin(0.422319859266281*x_96 - 1.19247984886169) - 0.16856323963632*std::sin(0.403919845819473*x_97 - 4.20703983306885) - 0.0482417138147397*std::sin(0.687439858913422*x_98 + 2.02071976661682) - 0.251678890676793*std::sin(0.446559846401215*x_99 - 7.37319993972778) + 3.84970438872623) + 0.969316876494381);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000120458759829246*x_1 + 0.00595555576992435*x_10 - 0.00630867246565925*x_100 + 0.000290097451087673*x_101 - 1.09407522884692e-5*x_102 + 0.000105300257535667*x_103 - 8.10282488579476e-5*x_104 - 6.31026475891143e-5*x_105 + 9.11439771489005e-5*x_106 + 0.00054874548177162*x_107 + 0.00405644902047834*x_109 + 0.0162322139057819*x_11 - 1.74342477867008e-5*x_111 + 0.00329926432850756*x_112 + 0.00217571607639347*x_113 + 5.37496860875405e-5*x_114 + 3.07444125850565e-5*x_115 - 0.00159499138644831*x_116 + 2.03102708502459e-6*x_117 + 0.000134621751886357*x_119 + 0.000100794042529767*x_12 + 0.000416810937724186*x_120 - 0.000154944753605116*x_13 - 6.78734244545405e-5*x_14 - 1.48136210868526e-5*x_16 + 4.62737921649188e-5*x_17 - 4.76976214963384e-5*x_18 - 0.0006506133055795*x_19 + 0.0174034379164961*x_2 - 0.000461828194203998*x_20 - 0.00152600217237465*x_21 + 0.000203572145086161*x_22 - 0.00635255152318164*x_23 + 2.06489351663995e-5*x_24 - 0.0195756030053468*x_25 - 4.5548966371923e-6*x_27 + 0.00013442749190815*x_28 - 0.0310495834516558*x_29 - 0.00158395120820901*x_3 + 0.000898333226539748*x_30 - 0.0104519884639309*x_31 - 0.00116851598279961*x_32 + 0.000160181357147859*x_33 + 0.000655875012736525*x_34 + 4.74463753189869e-5*x_35 - 1.01897303123395e-5*x_36 - 0.000332005357799558*x_37 + 8.14868120888694e-5*x_38 - 0.00201160298835824*x_39 - 0.000851790960454839*x_4 + 1.22098222596993e-5*x_40 + 0.000578292173816213*x_41 + 5.83473800238355e-5*x_42 - 9.2403189451467e-5*x_43 + 5.7051037856307e-5*x_44 - 1.17715880217489e-5*x_45 + 3.91423758108635e-5*x_46 - 5.57587306019642e-5*x_47 + 6.17839351108059e-5*x_48 + 0.00648682440535147*x_5 - 6.17894787844053e-5*x_50 + 0.0034005479805729*x_51 + 0.00127165509795862*x_52 - 9.6155795745162e-5*x_53 - 0.00014763827629065*x_54 + 8.85617860385624e-6*x_56 + 0.00365190015253916*x_57 + 1.03798213812904e-5*x_58 + 1.13696561580089e-5*x_59 - 5.35403530600463e-5*x_6 + 2.01638802175193e-5*x_60 + 0.00187404772700725*x_61 - 0.00022411270475109*x_62 - 0.0111317378251529*x_63 - 3.71798354955639e-6*x_64 - 0.0005063116021278*x_65 + 1.04427435781747e-6*x_66 + 1.38070872861566e-5*x_67 + 0.00164766607446578*x_68 - 0.00165851145162771*x_69 - 2.69103211102021e-5*x_7 + 2.92221671659443e-5*x_70 + 0.000168040558205443*x_71 - 0.0045828829916096*x_72 + 1.44862601321862e-5*x_73 + 0.000201361549743539*x_74 - 1.88322608939097e-6*x_75 - 9.42661957868245e-6*x_76 - 0.0036286303524027*x_78 + 0.00341926855682993*x_79 - 0.000205343411396231*x_8 - 0.000789448612327265*x_80 - 7.07314656020169e-6*x_82 - 2.42987563309351e-6*x_83 - 6.56808095727905e-5*x_84 + 2.17562844599734e-6*x_85 + 0.000946078847937457*x_88 + 0.00169365213778128*x_89 + 0.00995575410986679*x_9 + 0.00623912702954479*x_90 + 0.00125197687689326*x_91 + 0.000739631926244901*x_92 + 0.000190833914735039*x_93 - 0.00165738765965282*x_94 + 5.26629436365501e-5*x_95 + 2.14970944018017e-5*x_96 + 0.00195041387426228*x_97 + 0.000123702172788787*x_98 - 0.00059074051668888*x_99 + 7.1629497838626e-6*std::pow(-2.17063999176025*x_108 - 3.15591979026794, 2) + 7.95223923727777e-7*std::pow(-6.25112009048462*x_110 - 8.66423988342285, 2) - 3.81908001406068e-7*std::pow(-3.51968002319336*x_110 - 5.79135990142822, 2) - 5.01739842972267e-8*std::pow(-6.72800016403198*x_118 - 8.75936031341553, 2) + 0.000116128756576804*std::pow(-5.40447998046875*x_13 - 8.20039939880371, 2) - 4.43344953109383e-7*std::pow(-5.76688003540039*x_14 - 8.3450403213501, 2) - 0.000139931863308499*std::pow(-6.59999990463257*x_15 - 9.99973964691162, 2) + 6.82704649889483e-7*std::pow(-5.93840026855469*x_15 - 8.39935970306396, 2) - 2.8941164668727e-6*std::pow(-6.46104001998901*x_17 - 9.48311996459961, 2) - 2.1931078330535e-6*std::pow(-6.29008007049561*x_17 - 9.74312019348145, 2) - 0.000731108685235447*std::pow(-4.0065598487854*x_17 - 6.20688009262085, 2) - 2.35799770869534e-6*std::pow(-4.49232006072998*x_18 - 7.14559984207153, 2) - 0.000464291634825791*std::pow(-3.45199990272522*x_18 - 5.2752799987793, 2) - 8.12128776643093e-7*std::pow(-4.59431982040405*x_19 - 7.38895988464355, 2) - 2.15882493700477e-6*std::pow(-5.7294397354126*x_22 - 9.58975982666016, 2) - 9.07736434943506e-5*std::pow(-5.72079992294312*x_22 - 8.28072071075439, 2) + 2.48070940237426e-6*std::pow(-5.72383975982666*x_24 - 8.38159942626953, 2) + 9.79657906477019e-6*std::pow(-1.62839984893799*x_25 - 3.46207976341248, 2) + 3.62901445779853e-7*std::pow(-6.12911987304688*x_27 - 7.76647996902466, 2) - 0.000401659474657931*std::pow(-5.51200008392334*x_4 - 9.19999980926514, 2) + 1.11727009288525e-5*std::pow(-4.58247995376587*x_4 - 7.77960014343262, 2) + 7.10642630012178e-7*std::pow(-3.95839977264404*x_41 - 9.7038402557373, 2) - 2.58393294121067e-6*std::pow(-4.11559963226318*x_5 - 6.37784004211426, 2) + 1.6233291178036e-5*std::pow(-3.50720000267029*x_5 - 5.56712007522583, 2) - 3.42077798241513e-7*std::pow(-7.74287986755371*x_55 - 9.17280006408691, 2) - 4.87278935073951e-6*std::pow(-3.28671979904175*x_6 - 5.13399982452393, 2) - 0.000763931814939495*std::pow(-3.16847991943359*x_6 - 5.34823989868164, 2) + 2.54595953736844e-7*std::pow(-5.31584024429321*x_64 - 8.99736022949219, 2) - 2.42066389070107e-7*std::pow(-7.26232004165649*x_66 - 9.61312007904053, 2) - 8.44164757710893e-5*std::pow(-5.60232019424438*x_66 - 7.61072015762329, 2) - 3.25283762579497e-5*std::pow(-1.15495979785919*x_66 - 1.92279982566833, 2) - 3.49819548452424e-5*std::pow(-5.68575954437256*x_67 - 8.73624038696289, 2) - 4.49710730233067e-7*std::pow(-5.72591972351074*x_7 - 9.18144035339355, 2) - 0.000252597180632018*std::pow(-5.31304025650024*x_7 - 8.78575992584229, 2) - 7.35762406079223e-6*std::pow(-5.07807970046997*x_7 - 8.11320018768311, 2) - 4.60304549574921e-5*std::pow(-7.10591983795166*x_70 - 9.93296051025391, 2) - 4.6606177658165e-7*std::pow(-5.73503971099854*x_70 - 6.75536012649536, 2) - 4.53875828130479e-7*std::pow(-5.9539999961853*x_72 - 9.1340799331665, 2) - 2.91839559978382e-6*std::pow(-3.84744000434875*x_75 - 5.66079998016357, 2) + 1.73007024329193e-7*std::pow(-5.71463966369629*x_78 - 9.38111972808838, 2) - 9.99330348501003e-7*std::pow(-4.57719993591309*x_8 - 8.7577600479126, 2) + 2.23218893766828e-5*std::pow(-2.51511979103088*x_8 - 5.22399997711182, 2) + 8.12182689168558e-5*std::pow(-6.33008003234863*x_81 - 8.87975978851318, 2) + 2.36515530742641e-7*std::pow(-4.91448020935059*x_81 - 6.35383987426758, 2) - 7.55263755326338e-7*std::pow(-6.81415987014771*x_85 - 8.80992031097412, 2) - 1.20996388137606e-6*std::pow(-2.30607986450195*x_85 - 3.7727198600769, 2) + 2.66355310126429e-7*std::pow(-5.80800008773804*x_87 - 8.01583957672119, 2) - 2.99781467829734e-7*std::pow(-9.5959997177124*x_88 - 9.99096012115479, 2) - 5.61277855259656e-6*std::pow(-6.0*x_9 - 9.99997997283936, 2) + 0.00254863947382197*std::exp(0.57999986410141*x_106) - 6.45572000483036e-5*std::exp(0.719279825687408*x_15) + 0.000130207109666542*std::exp(0.612959861755371*x_2) - 3.57510287130347e-5*std::exp(0.513279855251312*x_76) + 0.00665548720522115*std::exp(0.612399816513062*x_76) - 0.0014318671924215*std::log(0.681119859218597*x_91 + 1.02415990829468) - 0.0143771948291742*std::sin(0.299839943647385*x_1 - 7.41623973846436) + 0.167490707481663*std::sin(0.305919945240021*x_1 + 1.97895979881287) + 0.00120933491929737*std::sin(0.351679861545563*x_1 - 4.35207986831665) - 0.00151603464561099*std::sin(0.212640002369881*x_10 + 5.01351976394653) - 0.00292961293249248*std::sin(0.308879911899567*x_10 - 4.25407981872559) - 7.09979152508248e-5*std::sin(0.41143986582756*x_100 - 0.988239824771881) + 5.66667053066357e-5*std::sin(0.513359844684601*x_100 - 7.22968006134033) + 4.86335062648988e-5*std::sin(0.303999930620193*x_101 - 4.3010401725769) - 0.000887005670857903*std::sin(0.353999853134155*x_101 + 1.96231985092163) - 0.0900623584259821*std::sin(0.363119840621948*x_102 + 5.16175985336304) + 0.0015740898804664*std::sin(0.371919840574265*x_102 - 7.40231990814209) - 4.04055358315885e-5*std::sin(0.411119878292084*x_102 - 1.00239980220795) - 0.000349600317296529*std::sin(0.388159841299057*x_103 - 7.40567970275879) + 0.0473427974412676*std::sin(0.437279850244522*x_103 + 2.00919985771179) + 0.000471000014704744*std::sin(0.136880040168762*x_104 - 7.68391990661621) - 0.000623128465107507*std::sin(0.332559853792191*x_104 + 5.15224027633667) + 0.0650947257286241*std::sin(0.34215983748436*x_104 - 7.4378399848938) + 0.0412902579643458*std::sin(0.345919847488403*x_105 + 8.34463977813721) + 0.000781076761056559*std::sin(0.376319825649261*x_105 + 5.18792009353638) + 0.000950578232092567*std::sin(0.364719837903976*x_106 + 1.98247981071472) - 9.56506168696325e-5*std::sin(0.700959861278534*x_106 - 0.957199811935425) + 0.00070159238713539*std::sin(0.385039836168289*x_107 + 5.18535995483398) - 0.0524037414917699*std::sin(0.296479940414429*x_108 + 5.10391998291016) - 0.00108938603582656*std::sin(0.367439836263657*x_108 - 4.22936010360718) - 0.000175281559228742*std::sin(0.708239853382111*x_108 - 4.02719974517822) - 4.99793483842981e-6*std::sin(0.85207986831665*x_108 + 8.40624046325684) + 0.00118497985673918*std::sin(0.397519826889038*x_109 + 5.19832038879395) - 0.000231189864381989*std::sin(0.327279835939407*x_11 - 1.06439983844757) + 3.17121009784497e-5*std::sin(0.597919821739197*x_110 - 7.19352006912231) - 0.000182166288065293*std::sin(0.609279870986938*x_110 + 2.20576000213623) - 0.00388199829161862*std::sin(0.816159844398499*x_110 + 5.6101598739624) + 0.0367099490391627*std::sin(0.339759826660156*x_111 - 1.04287981987) - 0.000401665491603109*std::sin(0.361119836568832*x_111 + 1.97559976577759) + 0.000880993446061065*std::sin(0.368559837341309*x_111 + 5.17408037185669) - 0.00026318114008521*std::sin(0.268239974975586*x_112 + 5.07903957366943) + 0.00102877004319907*std::sin(0.331439822912216*x_112 - 7.43304014205933) + 5.62757309321647e-5*std::sin(0.369279861450195*x_112 + 1.9748797416687) - 0.000445583227526737*std::sin(0.438159853219986*x_112 - 1.17311990261078) - 0.000923512559548921*std::sin(0.327199816703796*x_113 + 1.92543983459473) + 0.03438293062568*std::sin(0.409679859876633*x_114 + 5.21720027923584) + 0.000269494414281963*std::sin(0.469839870929718*x_114 - 0.924239873886108) + 0.000979198958734262*std::sin(0.360399842262268*x_115 + 5.16368007659912) - 0.00279795296165574*std::sin(0.516719877719879*x_115 - 7.04375982284546) - 4.4553154837683e-6*std::sin(1.55183982849121*x_115 + 1.80663990974426) - 0.000135047774900372*std::sin(0.259839832782745*x_116 + 8.09823989868164) - 0.000853304533185166*std::sin(0.288879930973053*x_117 + 8.30072021484375) + 0.000295997517413634*std::sin(0.394879847764969*x_117 - 7.39591979980469) + 0.0186633370441426*std::sin(0.542399823665619*x_117 - 7.43400001525879) - 6.07796510997941e-5*std::sin(0.976639807224274*x_117 - 7.98496007919312) - 0.000806784084850763*std::sin(0.239919975399971*x_118 - 1.36119985580444) - 0.000534118736472323*std::sin(0.364959836006165*x_118 + 1.96375977993011) + 0.0832943455461201*std::sin(0.384399831295013*x_118 - 7.41703987121582) - 0.00035595624844395*std::sin(0.427439838647842*x_118 + 8.43224048614502) + 0.0583483002620298*std::sin(0.353999853134155*x_119 + 5.16960000991821) + 0.000211785424298547*std::sin(0.429279863834381*x_119 + 2.01151990890503) + 0.101512570688124*std::sin(0.283679932355881*x_12 - 7.49535989761353) - 6.47599143255621e-5*std::sin(0.342879861593246*x_12 + 2.14535975456238) + 0.00138760405292977*std::sin(0.169520005583763*x_120 - 7.63551998138428) - 0.000726842224921137*std::sin(0.289919942617416*x_120 - 7.49015998840332) + 0.000178256906856614*std::sin(0.322559833526611*x_120 + 5.33591985702515) + 1.48695328396152*std::sin(0.142560034990311*x_14 - 4.49032020568848) - 0.00171626887246739*std::sin(0.213919997215271*x_14 + 5.01495981216431) + 0.00456336808019604*std::sin(0.281919956207275*x_15 - 4.2772798538208) - 0.000192276278007525*std::sin(0.510799825191498*x_15 - 0.896399855613708) + 0.00117382925021883*std::sin(0.326799839735031*x_16 - 4.26232004165649) + 0.000369562871756729*std::sin(0.338079839944839*x_16 - 4.24959993362427) - 0.00336087382906804*std::sin(0.354879856109619*x_16 + 5.17128038406372) - 0.025454319280844*std::sin(0.37271985411644*x_16 - 4.2260799407959) - 0.00174631826792085*std::sin(0.134800046682358*x_18 + 4.90247964859009) - 0.00138765322375364*std::sin(0.208719998598099*x_18 - 7.57600021362305) - 0.00343387003422872*std::sin(0.213279992341995*x_19 + 5.02807998657227) - 0.000529733451886923*std::sin(0.295359939336777*x_21 + 8.31112003326416) - 0.000235178337121074*std::sin(0.324959844350815*x_21 - 4.26024007797241) + 0.00140306733959918*std::sin(0.330719828605652*x_21 - 4.2402400970459) + 0.00140606043944354*std::sin(0.161600023508072*x_23 + 4.94087982177734) + 0.00171899157447676*std::sin(0.183360010385513*x_23 - 4.41607999801636) + 0.00580197554032037*std::sin(0.158160030841827*x_24 + 4.95127964019775) + 0.0451632736227482*std::sin(0.241919979453087*x_24 - 4.34632015228271) - 0.00105591490035226*std::sin(0.316399842500687*x_26 - 4.28280019760132) + 0.0568851129550674*std::sin(0.321759849786758*x_26 - 4.27472019195557) - 0.00220403774160009*std::sin(0.324319839477539*x_26 - 4.26200008392334) - 0.00418704185679466*std::sin(0.33095982670784*x_26 - 4.2707200050354) + 3.62035272195813e-5*std::sin(0.398319840431213*x_26 - 1.17639982700348) - 0.23947313210131*std::sin(0.214399993419647*x_27 - 7.57800006866455) - 0.0031197501181061*std::sin(0.305119842290878*x_27 - 4.31576013565063) - 0.000172393132490292*std::sin(0.291999936103821*x_28 - 4.28151988983154) - 0.111830888733305*std::sin(0.320719838142395*x_28 + 8.30399990081787) - 3.07745764275226e-6*std::sin(1.78887987136841*x_29 - 0.204079851508141) + 0.000231419256222551*std::sin(0.293919950723648*x_3 - 1.08967983722687) - 0.00421270874391765*std::sin(0.317679852247238*x_3 + 8.32208061218262) - 0.00221184222853148*std::sin(0.343599855899811*x_3 - 1.05495977401733) + 0.000790308213499818*std::sin(0.2880799472332*x_30 - 4.29983997344971) - 0.00167582640396911*std::sin(0.276319950819016*x_32 - 7.44519996643066) - 0.059710935415144*std::sin(0.251519978046417*x_33 + 2.01743984222412) - 0.000632064106159676*std::sin(0.341839849948883*x_34 + 1.98831987380981) - 4.98864423033392e-5*std::sin(0.345679849386215*x_34 + 5.20056009292603) - 0.0008572594452775*std::sin(0.355519831180573*x_34 + 1.9975198507309) + 0.000700291613695107*std::sin(0.231999978423119*x_35 - 1.14375984668732) - 0.000873937433104595*std::sin(0.321999847888947*x_35 + 1.98599982261658) + 9.27875914239196e-5*std::sin(0.323519825935364*x_35 + 5.18839979171753) - 0.0632582827363274*std::sin(0.323599845170975*x_35 + 1.97183978557587) - 7.92289130428135e-5*std::sin(0.325279831886292*x_36 + 5.12784004211426) + 0.00125567712696652*std::sin(0.343599855899811*x_36 - 7.43511962890625) + 0.0340481438853501*std::sin(0.356639832258224*x_36 + 5.1573600769043) - 0.000938686415174758*std::sin(0.36015984416008*x_36 - 4.23160028457642) + 0.000331847355998945*std::sin(0.436079859733582*x_37 + 2.03319978713989) - 0.0248228462269027*std::sin(0.3781598508358*x_38 + 5.18815994262695) + 5.65972353540652e-5*std::sin(0.451279848814011*x_38 + 8.45608043670654) - 0.000414894296797922*std::sin(0.371439844369888*x_39 + 5.17072010040283) + 0.000402197006402136*std::sin(0.401119858026505*x_39 - 7.40167951583862) + 0.000389033860272017*std::sin(0.409199863672256*x_39 + 1.98799991607666) + 0.0593646833920936*std::sin(0.33095982670784*x_40 - 7.4703197479248) + 0.000573729438634594*std::sin(0.373999834060669*x_40 - 4.22448015213013) + 0.000131911014111785*std::sin(0.372079849243164*x_42 - 7.41975975036621) + 0.000726059839478178*std::sin(0.386159837245941*x_42 + 1.99703979492188) + 0.0198278378560082*std::sin(0.475279837846756*x_42 + 2.04271984100342) + 0.000160168123278176*std::sin(0.244559973478317*x_43 + 8.25592041015625) - 0.000326849097026341*std::sin(0.446799874305725*x_43 + 2.02879977226257) + 0.0457677502877929*std::sin(0.451839864253998*x_43 + 2.04807996749878) - 0.0620949723355034*std::sin(0.365279853343964*x_44 - 4.22080039978027) - 7.97107818956215e-5*std::sin(0.370959848165512*x_44 + 8.3645601272583) + 0.00150987715251383*std::sin(0.270159959793091*x_45 - 7.5237603187561) + 0.0463422751442673*std::sin(0.366239845752716*x_45 - 7.4172797203064) + 3.5457497252983e-5*std::sin(0.380239844322205*x_45 + 5.16648006439209) + 0.00357012999441758*std::sin(0.703439831733704*x_46 + 2.05855989456177) + 0.0399642928051303*std::sin(0.339919835329056*x_47 + 5.1384801864624) + 0.000525403950400396*std::sin(0.462239861488342*x_48 + 5.23808002471924) - 0.0201178084087535*std::sin(0.476239860057831*x_48 - 7.34207963943481) + 0.000356633980228016*std::sin(0.163760021328926*x_49 - 7.27447986602783) + 0.0611047103634076*std::sin(0.238639980554581*x_49 - 4.35871982574463) + 7.61045826103536e-5*std::sin(0.326239824295044*x_49 + 8.32384014129639) - 0.000594828284783615*std::sin(0.374799847602844*x_49 - 4.23487997055054) + 0.000147474003620297*std::sin(0.56063985824585*x_49 - 4.21432018280029) + 0.000882008087772062*std::sin(0.27727997303009*x_50 + 5.07631969451904) - 0.0316382185554138*std::sin(0.322959840297699*x_50 + 4.94575977325439) + 8.24787879326899e-5*std::sin(0.398319840431213*x_50 - 1.00463974475861) + 5.82453119846502e-5*std::sin(0.917439818382263*x_50 - 4.02711963653564) + 0.00142898838694331*std::sin(0.210559993982315*x_51 + 5.01375961303711) - 0.000429563840600419*std::sin(0.274559944868088*x_51 - 4.30599975585938) + 0.00150956690651926*std::sin(0.325199842453003*x_51 - 4.27367973327637) + 4.29594979824566e-5*std::sin(0.350959837436676*x_51 - 1.05951988697052) - 0.00108139371490473*std::sin(0.226319998502731*x_52 + 8.22552013397217) - 0.00074416543748699*std::sin(0.363839834928513*x_53 - 4.24128007888794) + 0.0180943351130302*std::sin(0.366159826517105*x_53 - 7.44087982177734) - 0.000248195568580124*std::sin(0.488159865140915*x_54 + 2.25639986991882) + 1.40605259291495e-5*std::sin(0.683279812335968*x_54 + 8.4498405456543) - 0.0016485331636676*std::sin(0.238079980015755*x_55 - 4.34976005554199) + 6.28173663052213e-5*std::sin(0.318879842758179*x_55 + 5.11352014541626) - 0.000281843526156497*std::sin(0.322879940271378*x_55 + 8.36727905273438) - 0.0262289883579019*std::sin(0.4129598736763*x_55 - 4.18151998519897) - 0.00132655500979126*std::sin(0.315759837627411*x_56 + 8.30768013000488) - 0.0430022290566914*std::sin(0.354159832000732*x_56 - 7.45271968841553) - 0.00203412053152272*std::sin(0.304559946060181*x_57 - 4.27871990203857) + 2.85557051479747e-5*std::sin(0.538079857826233*x_57 + 2.13239979743958) - 0.00111602259146507*std::sin(0.313599914312363*x_58 + 5.13840007781982) - 0.0457771572019302*std::sin(0.465279877185822*x_58 + 2.05847978591919) - 0.000612672552302177*std::sin(0.498079836368561*x_58 - 1.10559988021851) + 0.00127190228215198*std::sin(0.337039858102798*x_59 + 5.13671970367432) - 0.0561241420906064*std::sin(0.369119822978973*x_59 - 7.42424011230469) - 3.62305220592448e-5*std::sin(0.464319854974747*x_6 - 6.90000009536743) - 0.00253822668974128*std::sin(0.151360034942627*x_60 + 1.74399983882904) - 0.00130533192343361*std::sin(1.47391986846924*x_60 + 3.38039994239807) + 0.000116148841159384*std::sin(0.347919851541519*x_62 + 8.34496021270752) - 0.018871239544427*std::sin(0.376559853553772*x_62 - 4.21199989318848) + 0.00158148826477692*std::sin(0.271359950304031*x_63 + 5.09839963912964) + 0.00026540827859197*std::sin(0.296799927949905*x_63 - 4.28799962997437) + 0.000316919280499331*std::sin(0.385599851608276*x_63 - 7.40111970901489) - 0.00222541192780258*std::sin(0.211040005087852*x_64 + 5.00703954696655) - 0.000866257561386806*std::sin(0.241439983248711*x_64 - 4.3517599105835) - 0.120045811079532*std::sin(0.278079956769943*x_64 - 4.28567981719971) + 6.87299288750164e-5*std::sin(0.521519839763641*x_65 + 8.33312034606934) + 0.00087948470561246*std::sin(0.199440002441406*x_66 + 5.00719976425171) - 0.0029221948449707*std::sin(0.186240002512932*x_67 - 4.4201602935791) - 6.73289009473267e-5*std::sin(0.296319931745529*x_67 - 7.49088001251221) - 0.000100208024783024*std::sin(0.319439828395844*x_68 - 7.65296030044556) - 0.000305999017997517*std::sin(0.473519861698151*x_68 + 2.26967978477478) - 0.00173238736017826*std::sin(0.298079937696457*x_69 - 7.49047994613647) - 0.000251072236668042*std::sin(0.418239861726761*x_7 - 7.17655992507935) + 4.88278990631412e-6*std::sin(0.734559834003448*x_70 + 5.98959970474243) - 0.000484736315941382*std::sin(0.271119952201843*x_71 + 5.07599973678589) + 0.000325672298039698*std::sin(0.402959853410721*x_72 - 7.19704008102417) - 6.67079073125717e-5*std::sin(0.498719841241837*x_72 + 8.48984050750732) + 0.00014261705973798*std::sin(0.578239858150482*x_72 - 7.01944017410278) + 0.15151085270971*std::sin(0.275039941072464*x_73 + 5.07879972457886) - 0.000386257926203675*std::sin(0.411759853363037*x_73 + 5.19583988189697) - 5.05721123005295e-5*std::sin(0.305759936571121*x_75 + 5.14759969711304) + 0.0270976659647729*std::sin(0.391919851303101*x_75 + 8.38992023468018) - 0.000454818718952748*std::sin(0.437039852142334*x_75 + 5.22632026672363) - 0.000586872842052757*std::sin(0.150800034403801*x_76 + 4.92391967773438) + 3.2619173405515e-5*std::sin(1.22431993484497*x_76 - 0.768399834632874) - 5.07927083322791e-5*std::sin(0.406159847974777*x_77 - 1.00543987751007) - 0.000358105779069795*std::sin(0.468479871749878*x_77 + 5.25504016876221) + 0.00041861144440949*std::sin(0.491839855909348*x_77 - 0.899999797344208) + 0.0001338617109053*std::sin(0.492559850215912*x_77 - 0.874159812927246) + 0.00457286915923081*std::sin(0.890239894390106*x_77 + 8.64192008972168) + 0.000439185588491647*std::sin(0.407439857721329*x_78 - 4.18200016021729) - 0.000916370487168887*std::sin(0.428879857063293*x_78 - 4.15312004089355) + 1.24343957800219e-5*std::sin(0.752559840679169*x_79 - 1.39367985725403) - 0.00145543766440884*std::sin(1.52543985843658*x_8 + 2.39687991142273) - 2.68253075774877e-5*std::sin(0.430959850549698*x_80 - 7.16616010665894) - 0.000243840511138823*std::sin(0.530399858951569*x_80 + 5.34944009780884) - 0.00202037498766483*std::sin(0.207440003752708*x_81 - 7.58808040618896) + 0.000775322453289935*std::sin(0.347279846668243*x_81 - 1.04183983802795) + 0.000277186226947308*std::sin(0.423119872808456*x_81 - 4.17736005783081) + 0.00122247899772219*std::sin(0.386639833450317*x_82 - 4.22040033340454) - 9.25562293726065e-5*std::sin(0.61303985118866*x_82 - 0.966639816761017) + 1.02053530026017e-5*std::sin(0.997999846935272*x_82 - 4.60471963882446) - 0.00263295920315763*std::sin(0.99999988079071*x_82 - 10.0) - 0.13655207482704*std::sin(0.32575985789299*x_83 + 5.12007999420166) + 3.31105481349889e-5*std::sin(0.461679875850677*x_83 + 2.05015993118286) + 0.000122389078349387*std::sin(0.637919843196869*x_83 + 2.00751972198486) + 0.000285867720843237*std::sin(0.36303985118866*x_84 + 5.15488004684448) + 8.30066644233789e-5*std::sin(0.632639825344086*x_84 + 5.43271970748901) - 0.149876706860614*std::sin(0.1564000248909*x_85 - 7.65104007720947) + 0.000328620934687828*std::sin(0.5065598487854*x_85 + 8.51416015625) + 0.0011648265914745*std::sin(0.155040040612221*x_86 - 1.27311992645264) + 7.19780520407302e-5*std::sin(0.186640009284019*x_86 + 8.16335964202881) - 0.12844565202243*std::sin(0.249119967222214*x_86 - 7.53016042709351) - 0.00125462226085868*std::sin(0.301999926567078*x_86 - 7.48448038101196) + 0.000228011233647415*std::sin(0.489359855651855*x_86 - 4.12224006652832) - 0.132739084008898*std::sin(0.211119994521141*x_87 + 5.01863956451416) - 0.00111485694949882*std::sin(0.32015985250473*x_87 + 5.12007999420166) + 0.000231813025164687*std::sin(0.399999856948853*x_87 + 8.40015983581543) - 9.31443717951545e-6*std::sin(0.5136798620224*x_87 + 5.15128040313721) - 0.000570420933169353*std::sin(0.279199928045273*x_88 + 5.0959997177124) + 5.53682400531587e-5*std::sin(0.531839847564697*x_88 + 2.15471982955933) + 0.000508218177820466*std::sin(0.501599848270416*x_89 + 8.48872089385986) + 0.000791413944835162*std::sin(0.392159849405289*x_9 - 7.39575958251953) + 3.37057771288367e-5*std::sin(0.53007984161377*x_9 - 4.06080007553101) - 0.000304585852904259*std::sin(0.60999983549118*x_9 + 5.19591999053955) + 0.00020180372949741*std::sin(0.238079980015755*x_90 - 7.55304002761841) - 0.00101944514831324*std::sin(0.406159847974777*x_90 - 4.18832015991211) - 0.00099544610241825*std::sin(0.196719989180565*x_91 - 7.39048004150391) - 0.00109039937099998*std::sin(0.326319843530655*x_92 - 4.21528005599976) + 0.00679649201864385*std::sin(0.353599846363068*x_92 - 7.40887975692749) - 0.000746204887995908*std::sin(0.373679846525192*x_92 + 5.19736003875732) - 0.000558833938053576*std::sin(0.375119835138321*x_92 + 1.9987998008728) - 0.000927686004615307*std::sin(0.356559842824936*x_93 + 1.99455988407135) + 0.000408300486080643*std::sin(0.392959833145142*x_94 + 5.19432020187378) + 0.00038896048880492*std::sin(0.406799852848053*x_94 - 7.39671945571899) + 5.57733231088182e-5*std::sin(0.45143985748291*x_94 + 2.01095986366272) - 0.0664443900078634*std::sin(0.3643998503685*x_95 - 4.23271989822388) + 0.000637845842356962*std::sin(0.346799850463867*x_96 + 5.1637601852417) - 0.000370958235614742*std::sin(0.422319859266281*x_96 - 1.19247984886169) - 0.0348658156521126*std::sin(0.440079867839813*x_96 - 4.17288017272949) + 0.000238838699725697*std::sin(0.403919845819473*x_97 - 4.20703983306885) + 0.000232354143073088*std::sin(0.437839865684509*x_97 + 5.22304010391235) - 0.0248081539847191*std::sin(0.487279862165451*x_98 + 8.24639987945557) - 2.66620548538482e-5*std::sin(0.600959837436676*x_98 - 7.4047999382019) + 6.83540979926028e-5*std::sin(0.687439858913422*x_98 + 2.02071976661682) - 6.90068760047284e-5*std::sin(0.33111983537674*x_99 + 5.1448802947998) + 0.000356605978428875*std::sin(0.446559846401215*x_99 - 7.37319993972778) - 0.000312933920289621*std::sin(0.511439859867096*x_99 + 5.16400003433228) - 0.000170528170104761*std::sin(0.531919836997986*x_99 - 1.00535976886749) - 1.35934380061439);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00138937578319533*x_1 + 0.00019947325553093*x_10 + 0.000229214313522837*x_100 + 0.000202536353045387*x_101 + 0.000211309406616994*x_102 - 0.00208583735350713*x_103 + 0.00095574985744588*x_104 - 0.000414879270841067*x_105 - 0.000567863168882253*x_106 + 1.78246132954938e-5*x_107 - 0.000446442866690517*x_109 + 0.00304134202413465*x_11 - 0.000142554326486968*x_111 + 0.000197627322761161*x_112 - 0.0014273316168076*x_113 + 0.000794847978815647*x_114 + 0.000517509220599886*x_115 + 0.000310756202433095*x_116 + 0.000274714076454832*x_117 - 0.000701789163410303*x_119 - 0.00163565577607659*x_12 - 0.00129314523226389*x_120 + 0.00151593838571731*x_13 + 5.97480431743571e-5*x_14 - 0.00200367108141114*x_16 - 0.0047742597070355*x_17 + 0.000537652062600451*x_18 - 0.000861560775032765*x_19 + 0.00105764782456197*x_2 - 0.0012022784796516*x_20 - 8.56420996793344e-5*x_21 - 0.00204866846900458*x_22 - 0.000334180055669578*x_23 + 6.77961902930903e-5*x_24 - 0.000972041479803845*x_25 + 1.25826170713929e-5*x_27 - 0.000126773496320284*x_28 - 0.00521197221463722*x_29 + 0.000244255411707507*x_3 - 0.000326955490405922*x_30 - 0.00489167503310397*x_31 - 0.000651430951818436*x_32 - 0.0023537723045866*x_33 + 0.00127484581714036*x_34 - 0.000534819992127421*x_35 + 2.75252869011671e-6*x_36 - 0.000675366234243109*x_37 - 0.000351489277394153*x_38 - 0.000144538588895199*x_39 + 0.00217407636558308*x_4 + 0.000170201418994607*x_40 + 0.000309491642832793*x_41 - 0.000613407004223735*x_42 + 0.000984377243198546*x_43 - 0.000975448788214037*x_44 + 6.60871760076971e-5*x_45 + 0.000628823142920001*x_46 + 0.000462703751282706*x_47 - 0.00106226286595229*x_48 + 0.000439759203651711*x_5 + 0.000168670277417599*x_50 + 0.000203694256175435*x_51 - 0.00101607137655813*x_52 + 0.00017200807813816*x_53 - 5.73524157509015e-5*x_54 - 0.000337435190116285*x_56 + 0.00113631250643913*x_57 + 0.000791949083424518*x_58 + 0.000292275113651043*x_59 + 2.40407010744714e-5*x_6 + 0.000146822243880116*x_60 + 0.0011271930549953*x_61 + 0.000343498276596875*x_62 - 0.000896420121188726*x_63 - 0.000502889609213792*x_64 - 0.00183932418543089*x_65 + 0.000141247188621227*x_66 - 5.39339499230951e-5*x_67 + 0.000452093675401975*x_68 + 0.000229183029890598*x_69 + 0.000303335663210194*x_7 + 4.87954811479181e-5*x_70 - 0.000216005698926189*x_71 - 0.000274516621276345*x_72 - 0.000195657256429153*x_73 - 6.52752288964863e-5*x_74 + 5.14075006274053e-6*x_75 + 2.54639132202725e-6*x_76 + 0.000550831865350677*x_78 - 0.000741231120519044*x_79 + 0.00285164185193555*x_8 - 2.87330228068422e-5*x_80 - 0.000956704585203477*x_82 + 0.000418667469457081*x_83 + 0.000654334785373393*x_84 + 0.000294272668079059*x_85 + 0.00034415989719067*x_88 + 0.000489090845233414*x_89 + 0.000596353864041995*x_9 + 0.00045529394788482*x_90 - 0.00456514883991351*x_91 + 4.43042638776935e-5*x_92 + 0.000713108769630127*x_93 + 0.000267220905435434*x_94 + 0.000292189707238891*x_95 + 0.00023436460104605*x_96 - 0.000395016860610968*x_97 - 0.000212322157060678*x_98 - 3.53856057397436e-5*x_99 - 1.95531140728341e-5*std::pow(-2.17063999176025*x_108 - 3.15591979026794, 2) - 8.9638386445388e-6*std::pow(-6.25112009048462*x_110 - 8.66423988342285, 2) + 1.04251613401568e-6*std::pow(-3.51968002319336*x_110 - 5.79135990142822, 2) - 6.78646772359759e-6*std::pow(-6.72800016403198*x_118 - 8.75936031341553, 2) + 6.9561614265196e-6*std::pow(-5.40447998046875*x_13 - 8.20039939880371, 2) - 5.99662605399871e-5*std::pow(-5.76688003540039*x_14 - 8.3450403213501, 2) - 8.38197754441488e-6*std::pow(-6.59999990463257*x_15 - 9.99973964691162, 2) + 9.23417411656714e-5*std::pow(-5.93840026855469*x_15 - 8.39935970306396, 2) + 7.9002353952444e-6*std::pow(-6.46104001998901*x_17 - 9.48311996459961, 2) + 5.92419234460924e-7*std::pow(-6.29008007049561*x_17 - 9.74312019348145, 2) - 4.37937181516684e-5*std::pow(-4.0065598487854*x_17 - 6.20688009262085, 2) + 6.36960561807373e-7*std::pow(-4.49232006072998*x_18 - 7.14559984207153, 2) - 2.78112644622598e-5*std::pow(-3.45199990272522*x_18 - 5.2752799987793, 2) + 2.21691441245461e-6*std::pow(-4.59431982040405*x_19 - 7.38895988464355, 2) + 5.89306801391124e-6*std::pow(-5.7294397354126*x_22 - 9.58975982666016, 2) - 5.43737947458716e-6*std::pow(-5.72079992294312*x_22 - 8.28072071075439, 2) - 2.79627890250511e-5*std::pow(-5.72383975982666*x_24 - 8.38159942626953, 2) - 2.64632763716252e-6*std::pow(-1.62839984893799*x_25 - 3.46207976341248, 2) + 4.90855765817267e-5*std::pow(-6.12911987304688*x_27 - 7.76647996902466, 2) - 2.40595716907014e-5*std::pow(-5.51200008392334*x_4 - 9.19999980926514, 2) - 0.000125939732648443*std::pow(-4.58247995376587*x_4 - 7.77960014343262, 2) - 8.01043036972372e-6*std::pow(-3.95839977264404*x_41 - 9.7038402557373, 2) + 7.05350966858253e-6*std::pow(-4.11559963226318*x_5 - 6.37784004211426, 2) - 0.000182983180520537*std::pow(-3.50720000267029*x_5 - 5.56712007522583, 2) + 3.85593302191157e-6*std::pow(-7.74287986755371*x_55 - 9.17280006408691, 2) + 1.33015320367808e-5*std::pow(-3.28671979904175*x_6 - 5.13399982452393, 2) - 4.5759837444386e-5*std::pow(-3.16847991943359*x_6 - 5.34823989868164, 2) - 6.94985149430164e-7*std::pow(-5.31584024429321*x_64 - 8.99736022949219, 2) + 6.53888435125274e-8*std::pow(-7.26232004165649*x_66 - 9.61312007904053, 2) - 5.05658245064573e-6*std::pow(-5.60232019424438*x_66 - 7.61072015762329, 2) + 0.000366662907698086*std::pow(-1.15495979785919*x_66 - 1.92279982566833, 2) - 2.09543382786319e-6*std::pow(-5.68575954437256*x_67 - 8.73624038696289, 2) - 6.08272872571315e-5*std::pow(-5.72591972351074*x_7 - 9.18144035339355, 2) - 1.5130677501037e-5*std::pow(-5.31304025650024*x_7 - 8.78575992584229, 2) + 1.98749826517969e-6*std::pow(-5.07807970046997*x_7 - 8.11320018768311, 2) - 2.75724363765737e-6*std::pow(-7.10591983795166*x_70 - 9.93296051025391, 2) + 5.25349205300711e-6*std::pow(-5.73503971099854*x_70 - 6.75536012649536, 2) + 1.22604445886732e-7*std::pow(-5.9539999961853*x_72 - 9.1340799331665, 2) + 3.28964288885622e-5*std::pow(-3.84744000434875*x_75 - 5.66079998016357, 2) - 1.95015140287651e-6*std::pow(-5.71463966369629*x_78 - 9.38111972808838, 2) + 2.69946835768787e-7*std::pow(-4.57719993591309*x_8 - 8.7577600479126, 2) - 0.000251614430405799*std::pow(-2.51511979103088*x_8 - 5.22399997711182, 2) + 4.86500851315389e-6*std::pow(-6.33008003234863*x_81 - 8.87975978851318, 2) + 3.19907824342985e-5*std::pow(-4.91448020935059*x_81 - 6.35383987426758, 2) + 2.04017681667547e-7*std::pow(-6.81415987014771*x_85 - 8.80992031097412, 2) + 3.30290767217935e-6*std::pow(-2.30607986450195*x_85 - 3.7727198600769, 2) - 7.27085337738991e-7*std::pow(-5.80800008773804*x_87 - 8.01583957672119, 2) + 8.18330633924332e-7*std::pow(-9.5959997177124*x_88 - 9.99096012115479, 2) + 1.51616711372479e-6*std::pow(-6.0*x_9 - 9.99997997283936, 2) + 0.000152664577840204*std::exp(0.57999986410141*x_106) + 0.000727694813133289*std::exp(0.719279825687408*x_15) - 0.00146770675101344*std::exp(0.612959861755371*x_2) + 0.00040298894839288*std::exp(0.513279855251312*x_76) + 0.000398666486547928*std::exp(0.612399816513062*x_76) - 8.57694478562156e-5*std::log(0.681119859218597*x_91 + 1.02415990829468) + 0.00388367896280601*std::sin(0.299839943647385*x_1 - 7.41623973846436) + 0.0100327639167812*std::sin(0.305919945240021*x_1 + 1.97895979881287) - 0.00330119075838779*std::sin(0.351679861545563*x_1 - 4.35207986831665) - 0.205056870296493*std::sin(0.212640002369881*x_10 + 5.01351976394653) + 0.000791369683048176*std::sin(0.308879911899567*x_10 - 4.25407981872559) - 0.00960308548426504*std::sin(0.41143986582756*x_100 - 0.988239824771881) - 0.000154686349398757*std::sin(0.513359844684601*x_100 - 7.22968006134033) + 0.00657810467267117*std::sin(0.303999930620193*x_101 - 4.3010401725769) + 0.000239604825887884*std::sin(0.353999853134155*x_101 + 1.96231985092163) - 0.00539477319943453*std::sin(0.363119840621948*x_102 + 5.16175985336304) - 0.000425205321828718*std::sin(0.371919840574265*x_102 - 7.40231990814209) - 0.00546520011548889*std::sin(0.411119878292084*x_102 - 1.00239980220795) + 0.000954323999227013*std::sin(0.388159841299057*x_103 - 7.40567970275879) + 0.00283585350512791*std::sin(0.437279850244522*x_103 + 2.00919985771179) + 0.0637068481281526*std::sin(0.136880040168762*x_104 - 7.68391990661621) + 0.000168324276036998*std::sin(0.332559853792191*x_104 + 5.15224027633667) + 0.00389920148575649*std::sin(0.34215983748436*x_104 - 7.4378399848938) + 0.00247330384143626*std::sin(0.345919847488403*x_105 + 8.34463977813721) - 0.00880437050018472*std::sin(0.376319825649261*x_105 + 5.18792009353638) - 0.00259484781662619*std::sin(0.364719837903976*x_106 + 1.98247981071472) + 2.58378837408678e-5*std::sin(0.700959861278534*x_106 - 0.957199811935425) - 0.000189519556962077*std::sin(0.385039836168289*x_107 + 5.18535995483398) - 0.00313900618516711*std::sin(0.296479940414429*x_108 + 5.10391998291016) + 0.000294273373908035*std::sin(0.367439836263657*x_108 - 4.22936010360718) + 0.00197579017357062*std::sin(0.708239853382111*x_108 - 4.02719974517822) - 0.000676014152368653*std::sin(0.85207986831665*x_108 + 8.40624046325684) - 0.000320095915486121*std::sin(0.397519826889038*x_109 + 5.19832038879395) + 6.24507926186234e-5*std::sin(0.327279835939407*x_11 - 1.06439983844757) + 0.00428933744752681*std::sin(0.597919821739197*x_110 - 7.19352006912231) + 4.92081653686731e-5*std::sin(0.609279870986938*x_110 + 2.20576000213623) - 0.000232533332569637*std::sin(0.816159844398499*x_110 + 5.6101598739624) + 0.00219894140782293*std::sin(0.339759826660156*x_111 - 1.04287981987) + 0.00452761108963083*std::sin(0.361119836568832*x_111 + 1.97559976577759) - 0.000237980757268061*std::sin(0.368559837341309*x_111 + 5.17408037185669) + 0.00071842062407*std::sin(0.268239974975586*x_112 + 5.07903957366943) - 0.0115963924052271*std::sin(0.331439822912216*x_112 - 7.43304014205933) + 0.00761178202094881*std::sin(0.369279861450195*x_112 + 1.9748797416687) + 0.000120364384533015*std::sin(0.438159853219986*x_112 - 1.17311990261078) + 0.000249466348757359*std::sin(0.327199816703796*x_113 + 1.92543983459473) + 0.00205955202483265*std::sin(0.409679859876633*x_114 + 5.21720027923584) - 7.27979136247611e-5*std::sin(0.469839870929718*x_114 - 0.924239873886108) - 0.000264508789205595*std::sin(0.360399842262268*x_115 + 5.16368007659912) - 0.0001675985607597*std::sin(0.516719877719879*x_115 - 7.04375982284546) + 1.21619297235404e-5*std::sin(1.55183982849121*x_115 + 1.80663990974426) - 0.0182663860233979*std::sin(0.259839832782745*x_116 + 8.09823989868164) + 0.000230501214164083*std::sin(0.288879930973053*x_117 + 8.30072021484375) - 0.000808001367858744*std::sin(0.394879847764969*x_117 - 7.39591979980469) + 0.00111794174899941*std::sin(0.542399823665619*x_117 - 7.43400001525879) + 0.000685113927126297*std::sin(0.976639807224274*x_117 - 7.98496007919312) + 0.00220232470130865*std::sin(0.239919975399971*x_118 - 1.36119985580444) + 0.00602063648729184*std::sin(0.364959836006165*x_118 + 1.96375977993011) + 0.00498936637758548*std::sin(0.384399831295013*x_118 - 7.41703987121582) + 9.61536523770208e-5*std::sin(0.427439838647842*x_118 + 8.43224048614502) + 0.0034950877590537*std::sin(0.353999853134155*x_119 + 5.16960000991821) - 0.000578122796505214*std::sin(0.429279863834381*x_119 + 2.01151990890503) + 0.00608064573618811*std::sin(0.283679932355881*x_12 - 7.49535989761353) - 0.00875934160918659*std::sin(0.342879861593246*x_12 + 2.14535975456238) - 0.015641203014446*std::sin(0.169520005583763*x_120 - 7.63551998138428) + 0.000196340238255467*std::sin(0.289919942617416*x_120 - 7.49015998840332) - 0.000486598083081688*std::sin(0.322559833526611*x_120 + 5.33591985702515) + 0.0890691279389431*std::sin(0.142560034990311*x_14 - 4.49032020568848) + 0.0193459436825351*std::sin(0.213919997215271*x_14 + 5.01495981216431) - 0.00123269224790882*std::sin(0.281919956207275*x_15 - 4.2772798538208) + 0.000524867563060556*std::sin(0.510799825191498*x_15 - 0.896399855613708) - 0.000317083827489808*std::sin(0.326799839735031*x_16 - 4.26232004165649) - 0.00100881692690673*std::sin(0.338079839944839*x_16 - 4.24959993362427) + 0.0378840849847622*std::sin(0.354879856109619*x_16 + 5.17128038406372) - 0.00152472444499667*std::sin(0.37271985411644*x_16 - 4.2260799407959) - 0.236204732918305*std::sin(0.134800046682358*x_18 + 4.90247964859009) + 0.003787956442012*std::sin(0.208719998598099*x_18 - 7.57600021362305) + 0.000927583507867789*std::sin(0.213279992341995*x_19 + 5.02807998657227) + 0.00597120514819223*std::sin(0.295359939336777*x_21 + 8.31112003326416) - 0.0318099153678282*std::sin(0.324959844350815*x_21 - 4.26024007797241) - 0.000379007391563221*std::sin(0.330719828605652*x_21 - 4.2402400970459) + 0.190181902501183*std::sin(0.161600023508072*x_23 + 4.94087982177734) - 0.0193766342349204*std::sin(0.183360010385513*x_23 - 4.41607999801636) - 0.00156727446601289*std::sin(0.158160030841827*x_24 + 4.95127964019775) + 0.00270529911049321*std::sin(0.241919979453087*x_24 - 4.34632015228271) + 0.00288239135004231*std::sin(0.316399842500687*x_26 - 4.28280019760132) + 0.00340744222314604*std::sin(0.321759849786758*x_26 - 4.27472019195557) + 0.000595371705815187*std::sin(0.324319839477539*x_26 - 4.26200008392334) + 0.0471967284715211*std::sin(0.33095982670784*x_26 - 4.2707200050354) + 0.00489684190716454*std::sin(0.398319840431213*x_26 - 1.17639982700348) - 0.0143445414668609*std::sin(0.214399993419647*x_27 - 7.57800006866455) + 0.000842731008855373*std::sin(0.305119842290878*x_27 - 4.31576013565063) - 0.0233176704182912*std::sin(0.291999936103821*x_28 - 4.28151988983154) - 0.00669871733264907*std::sin(0.320719838142395*x_28 + 8.30399990081787) + 8.40071229853038e-6*std::sin(1.78887987136841*x_29 - 0.204079851508141) + 0.0313014669847558*std::sin(0.293919950723648*x_3 - 1.08967983722687) + 0.0114996722175859*std::sin(0.317679852247238*x_3 + 8.32208061218262) + 0.000597479914131976*std::sin(0.343599855899811*x_3 - 1.05495977401733) - 0.00215734957210976*std::sin(0.2880799472332*x_30 - 4.29983997344971) + 0.00457459926871154*std::sin(0.276319950819016*x_32 - 7.44519996643066) - 0.00357671017859837*std::sin(0.251519978046417*x_33 + 2.01743984222412) + 0.000170738040445551*std::sin(0.341839849948883*x_34 + 1.98831987380981) - 0.0067475751682618*std::sin(0.345679849386215*x_34 + 5.20056009292603) + 0.00234011018216109*std::sin(0.355519831180573*x_34 + 1.9975198507309) - 0.000189168181989043*std::sin(0.231999978423119*x_35 - 1.14375984668732) + 0.00238563704027521*std::sin(0.321999847888947*x_35 + 1.98599982261658) + 0.0125503286846525*std::sin(0.323519825935364*x_35 + 5.18839979171753) - 0.00378919777710085*std::sin(0.323599845170975*x_35 + 1.97183978557587) - 0.0107163995180365*std::sin(0.325279831886292*x_36 + 5.12784004211426) - 0.00342769373555277*std::sin(0.343599855899811*x_36 - 7.43511962890625) + 0.00203949815809161*std::sin(0.356639832258224*x_36 + 5.1573600769043) + 0.010580961302074*std::sin(0.36015984416008*x_36 - 4.23160028457642) - 0.000905862724492921*std::sin(0.436079859733582*x_37 + 2.03319978713989) - 0.00148689894312102*std::sin(0.3781598508358*x_38 + 5.18815994262695) + 0.00765526829003392*std::sin(0.451279848814011*x_38 + 8.45608043670654) + 0.0046767274223871*std::sin(0.371439844369888*x_39 + 5.17072010040283) - 0.00109790019241104*std::sin(0.401119858026505*x_39 - 7.40167951583862) - 0.000105088832481547*std::sin(0.409199863672256*x_39 + 1.98799991607666) + 0.00355596953659378*std::sin(0.33095982670784*x_40 - 7.4703197479248) - 0.00646713203676556*std::sin(0.373999834060669*x_40 - 4.22448015213013) + 0.0178421118473171*std::sin(0.372079849243164*x_42 - 7.41975975036621) - 0.000196128894253961*std::sin(0.386159837245941*x_42 + 1.99703979492188) + 0.00118769583805911*std::sin(0.475279837846756*x_42 + 2.04271984100342) + 0.0216641316052833*std::sin(0.244559973478317*x_43 + 8.25592041015625) + 0.000892218690846745*std::sin(0.446799874305725*x_43 + 2.02879977226257) + 0.00274150751730444*std::sin(0.451839864253998*x_43 + 2.04807996749878) - 0.00371951499416388*std::sin(0.365279853343964*x_44 - 4.22080039978027) - 0.010781576471041*std::sin(0.370959848165512*x_44 + 8.3645601272583) - 0.0170194768597565*std::sin(0.270159959793091*x_45 - 7.5237603187561) + 0.00277592179816812*std::sin(0.366239845752716*x_45 - 7.4172797203064) + 0.00479593486619359*std::sin(0.380239844322205*x_45 + 5.16648006439209) + 0.000213852290224114*std::sin(0.703439831733704*x_46 + 2.05855989456177) + 0.00239387796996967*std::sin(0.339919835329056*x_47 + 5.1384801864624) - 0.000141926174986834*std::sin(0.462239861488342*x_48 + 5.23808002471924) - 0.00120506519628951*std::sin(0.476239860057831*x_48 - 7.34207963943481) - 0.00402001167034547*std::sin(0.163760021328926*x_49 - 7.27447986602783) + 0.00366019788498699*std::sin(0.238639980554581*x_49 - 4.35871982574463) + 0.0102938066557249*std::sin(0.326239824295044*x_49 + 8.32384014129639) + 0.000160679612646579*std::sin(0.374799847602844*x_49 - 4.23487997055054) - 0.000402568229929745*std::sin(0.56063985824585*x_49 - 4.21432018280029) - 0.000238254840127381*std::sin(0.27727997303009*x_50 + 5.07631969451904) - 0.00189514261588955*std::sin(0.322959840297699*x_50 + 4.94575977325439) + 0.0111559733600345*std::sin(0.398319840431213*x_50 - 1.00463974475861) - 0.000656546618949499*std::sin(0.917439818382263*x_50 - 4.02711963653564) - 0.0161076911084789*std::sin(0.210559993982315*x_51 + 5.01375961303711) + 0.00117260500635472*std::sin(0.274559944868088*x_51 - 4.30599975585938) - 0.00040777587752379*std::sin(0.325199842453003*x_51 - 4.27367973327637) + 0.00581064570740123*std::sin(0.350959837436676*x_51 - 1.05951988697052) + 0.000292114426422319*std::sin(0.226319998502731*x_52 + 8.22552013397217) + 0.00838830259935627*std::sin(0.363839834928513*x_53 - 4.24128007888794) + 0.00108385829369089*std::sin(0.366159826517105*x_53 - 7.44087982177734) + 0.00279768372487168*std::sin(0.488159865140915*x_54 + 2.25639986991882) + 0.00190180841189952*std::sin(0.683279812335968*x_54 + 8.4498405456543) + 0.000445314516725627*std::sin(0.238079980015755*x_55 - 4.34976005554199) + 0.0084965950957049*std::sin(0.318879842758179*x_55 + 5.11352014541626) + 0.000769364407669495*std::sin(0.322879940271378*x_55 + 8.36727905273438) - 0.00157112744896394*std::sin(0.4129598736763*x_55 - 4.18151998519897) + 0.0149530524749957*std::sin(0.315759837627411*x_56 + 8.30768013000488) - 0.00257585163086355*std::sin(0.354159832000732*x_56 - 7.45271968841553) + 0.000549472356043762*std::sin(0.304559946060181*x_57 - 4.27871990203857) + 0.00386240746127094*std::sin(0.538079857826233*x_57 + 2.13239979743958) + 0.00304647075537769*std::sin(0.313599914312363*x_58 + 5.13840007781982) - 0.00274207099542298*std::sin(0.465279877185822*x_58 + 2.05847978591919) + 0.000165499844075028*std::sin(0.498079836368561*x_58 - 1.10559988021851) - 0.0143370018037006*std::sin(0.337039858102798*x_59 + 5.13671970367432) - 0.00336185974788231*std::sin(0.369119822978973*x_59 - 7.42424011230469) - 0.00490049319399467*std::sin(0.464319854974747*x_6 - 6.90000009536743) + 0.000685645406834008*std::sin(0.151360034942627*x_60 + 1.74399983882904) - 7.81899319535744e-5*std::sin(1.47391986846924*x_60 + 3.38039994239807) + 0.0157101408768327*std::sin(0.347919851541519*x_62 + 8.34496021270752) - 0.00113039519632448*std::sin(0.376559853553772*x_62 - 4.21199989318848) - 0.000427203830567515*std::sin(0.271359950304031*x_63 + 5.09839963912964) + 0.0358987778520821*std::sin(0.296799927949905*x_63 - 4.28799962997437) - 0.000865112702234016*std::sin(0.385599851608276*x_63 - 7.40111970901489) + 0.000601145466154948*std::sin(0.211040005087852*x_64 + 5.00703954696655) + 0.00976453646978197*std::sin(0.241439983248711*x_64 - 4.3517599105835) - 0.0071907946408986*std::sin(0.278079956769943*x_64 - 4.28567981719971) - 1.85658594780541e-5*std::sin(0.521519839763641*x_65 + 8.33312034606934) - 0.00240077974759724*std::sin(0.199440002441406*x_66 + 5.00719976425171) + 0.00797688255130394*std::sin(0.186240002512932*x_67 - 4.4201602935791) - 0.00910681939145079*std::sin(0.296319931745529*x_67 - 7.49088001251221) + 0.000273543581725247*std::sin(0.319439828395844*x_68 - 7.65296030044556) + 0.00344924962752507*std::sin(0.473519861698151*x_68 + 2.26967978477478) + 0.000467965860245756*std::sin(0.298079937696457*x_69 - 7.49047994613647) + 0.000685366257229926*std::sin(0.418239861726761*x_7 - 7.17655992507935) + 0.000660439798920662*std::sin(0.734559834003448*x_70 + 5.98959970474243) + 0.000130940719319567*std::sin(0.271119952201843*x_71 + 5.07599973678589) - 0.00367100868512519*std::sin(0.402959853410721*x_72 - 7.19704008102417) - 0.00902282460176339*std::sin(0.498719841241837*x_72 + 8.48984050750732) - 0.000389309952175201*std::sin(0.578239858150482*x_72 - 7.01944017410278) + 0.00907556388603315*std::sin(0.275039941072464*x_73 + 5.07879972457886) + 0.00105439037275005*std::sin(0.411759853363037*x_73 + 5.19583988189697) - 0.0068403179984386*std::sin(0.305759936571121*x_75 + 5.14759969711304) + 0.00162316160345867*std::sin(0.391919851303101*x_75 + 8.38992023468018) + 0.000122859146841555*std::sin(0.437039852142334*x_75 + 5.22632026672363) - 0.0793796557365918*std::sin(0.150800034403801*x_76 + 4.92391967773438) - 8.90424249513106e-5*std::sin(1.22431993484497*x_76 - 0.768399834632874) - 0.00687015553018722*std::sin(0.406159847974777*x_77 - 1.00543987751007) + 0.000977541845130313*std::sin(0.468479871749878*x_77 + 5.25504016876221) - 0.00471862745885963*std::sin(0.491839855909348*x_77 - 0.899999797344208) - 3.61597597267864e-5*std::sin(0.492559850215912*x_77 - 0.874159812927246) + 0.000273916788499535*std::sin(0.890239894390106*x_77 + 8.64192008972168) - 0.00119887004237676*std::sin(0.407439857721329*x_78 - 4.18200016021729) + 0.000247537076977798*std::sin(0.428879857063293*x_78 - 4.15312004089355) - 3.3942881975982e-5*std::sin(0.752559840679169*x_79 - 1.39367985725403) - 8.71813290549503e-5*std::sin(1.52543985843658*x_8 + 2.39687991142273) - 0.00362835614113788*std::sin(0.430959850549698*x_80 - 7.16616010665894) + 0.00066562540206788*std::sin(0.530399858951569*x_80 + 5.34944009780884) + 0.000545759303522219*std::sin(0.207440003752708*x_81 - 7.58808040618896) - 0.00873950740339905*std::sin(0.347279846668243*x_81 - 1.04183983802795) - 0.00075665111140798*std::sin(0.423119872808456*x_81 - 4.17736005783081) - 0.0137798979066812*std::sin(0.386639833450317*x_82 - 4.22040033340454) + 0.000252656037761312*std::sin(0.61303985118866*x_82 - 0.966639816761017) - 2.75674881193009e-6*std::sin(0.997999846935272*x_82 - 4.60471963882446) - 0.000157715365138623*std::sin(0.99999988079071*x_82 - 10.0) - 0.00817952679097921*std::sin(0.32575985789299*x_83 + 5.12007999420166) + 0.00447848958730484*std::sin(0.461679875850677*x_83 + 2.05015993118286) - 0.00033409247341451*std::sin(0.637919843196869*x_83 + 2.00751972198486) - 0.000780349482273591*std::sin(0.36303985118866*x_84 + 5.15488004684448) - 0.000935658905764077*std::sin(0.632639825344086*x_84 + 5.43271970748901) - 0.00897767786145257*std::sin(0.1564000248909*x_85 - 7.65104007720947) - 0.00370424599394672*std::sin(0.5065598487854*x_85 + 8.51416015625) - 0.000314651959744387*std::sin(0.155040040612221*x_86 - 1.27311992645264) + 0.00973565750904185*std::sin(0.186640009284019*x_86 + 8.16335964202881) - 0.00769394865096706*std::sin(0.249119967222214*x_86 - 7.53016042709351) + 0.0141422197831583*std::sin(0.301999926567078*x_86 - 7.48448038101196) - 0.000622415317142065*std::sin(0.489359855651855*x_86 - 4.12224006652832) - 0.0079511270351333*std::sin(0.211119994521141*x_87 + 5.01863956451416) + 0.0125667720862874*std::sin(0.32015985250473*x_87 + 5.12007999420166) - 6.26191256245379e-5*std::sin(0.399999856948853*x_87 + 8.40015983581543) - 0.0012598586332669*std::sin(0.5136798620224*x_87 + 5.15128040313721) + 0.000154086510227895*std::sin(0.279199928045273*x_88 + 5.0959997177124) + 0.00748903598739983*std::sin(0.531839847564697*x_88 + 2.15471982955933) - 0.000137283821299535*std::sin(0.501599848270416*x_89 + 8.48872089385986) - 0.00892089220516055*std::sin(0.392159849405289*x_9 - 7.39575958251953) + 0.00455899948524254*std::sin(0.53007984161377*x_9 - 4.06080007553101) + 0.00083144543889248*std::sin(0.60999983549118*x_9 + 5.19591999053955) + 0.0272957094382374*std::sin(0.238079980015755*x_90 - 7.55304002761841) + 0.0114912813155832*std::sin(0.406159847974777*x_90 - 4.18832015991211) + 0.00271732621074529*std::sin(0.196719989180565*x_91 - 7.39048004150391) + 0.000294547103835329*std::sin(0.326319843530655*x_92 - 4.21528005599976) - 0.076610695410711*std::sin(0.353599846363068*x_92 - 7.40887975692749) + 0.00203695819975753*std::sin(0.373679846525192*x_92 + 5.19736003875732) - 0.0755871501251527*std::sin(0.375119835138321*x_92 + 1.9987998008728) + 0.0104569636426269*std::sin(0.356559842824936*x_93 + 1.99455988407135) - 0.000110293282322164*std::sin(0.392959833145142*x_94 + 5.19432020187378) - 0.00106176771259267*std::sin(0.406799852848053*x_94 - 7.39671945571899) + 0.007543826993558*std::sin(0.45143985748291*x_94 + 2.01095986366272) - 0.00398004694449337*std::sin(0.3643998503685*x_95 - 4.23271989822388) - 0.00017229984770383*std::sin(0.346799850463867*x_96 + 5.1637601852417) + 0.00101262593150848*std::sin(0.422319859266281*x_96 - 1.19247984886169) - 0.00208847704128275*std::sin(0.440079867839813*x_96 - 4.17288017272949) - 0.000651971671121449*std::sin(0.403919845819473*x_97 - 4.20703983306885) - 6.27652965752846e-5*std::sin(0.437839865684509*x_97 + 5.22304010391235) - 0.00148601887162659*std::sin(0.487279862165451*x_98 + 8.24639987945557) - 0.00360627479050792*std::sin(0.600959837436676*x_98 - 7.4047999382019) - 0.000186590094266209*std::sin(0.687439858913422*x_98 + 2.02071976661682) - 0.00933378011078692*std::sin(0.33111983537674*x_99 + 5.1448802947998) - 0.00097344775346371*std::sin(0.446559846401215*x_99 - 7.37319993972778) + 0.00352742049651838*std::sin(0.511439859867096*x_99 + 5.16400003433228) + 4.60643870150366e-5*std::sin(0.531919836997986*x_99 - 1.00535976886749) - 0.367112840841135);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000451552911587524*x_1 + 5.73859758390174e-6*x_10 + 5.99422152190272e-5*x_100 - 1.54914331985441e-5*x_101 - 7.88480429182146e-5*x_102 - 0.000431904889379084*x_103 - 0.000319210716870681*x_104 + 0.000677602590884423*x_105 + 0.000274378060586653*x_106 - 2.59080582025367e-5*x_107 + 0.000195206831796783*x_109 - 0.000335177384445464*x_11 + 2.29901218110446e-5*x_111 + 0.000493709360382486*x_113 - 7.3791594236187e-5*x_114 - 6.14366389214032e-6*x_115 + 0.000609068075021318*x_116 - 3.38854671358539e-5*x_117 + 0.000255766765215193*x_119 + 0.000293544333440545*x_12 + 0.000162658730018998*x_120 - 0.000731887132279332*x_13 + 0.000483245144289858*x_14 + 0.000247149077529637*x_16 + 0.000763715225806742*x_17 - 0.000177060694859707*x_18 + 0.000210941778735228*x_19 - 0.000104321242140521*x_2 + 0.000958230049659618*x_20 + 0.00126911746780186*x_22 + 8.52658439904923e-5*x_23 - 1.50122714479631e-5*x_24 - 4.43367701651842e-5*x_25 - 6.46862704190924e-8*x_27 - 0.00122194300806421*x_28 - 0.00221543230495074*x_29 - 0.000111094203180109*x_3 - 0.000369314669986537*x_30 + 0.000403935780506987*x_31 - 0.000297797199980821*x_32 + 0.000248685108445851*x_33 - 0.000404745897401312*x_34 + 0.000176128031524573*x_35 + 9.64834005915918e-5*x_36 + 0.00015261919616248*x_37 - 5.11347670119796e-5*x_38 + 2.96693877716696e-6*x_39 + 0.00771722615191075*x_4 + 2.68627909039852e-5*x_40 - 0.00038283383269607*x_41 + 0.000197347511540263*x_42 - 0.000274486113726121*x_43 + 0.000731489080952886*x_44 - 0.000130709159511967*x_45 - 3.31439819036946e-6*x_46 - 0.000344376907506803*x_47 + 0.000217378442707996*x_48 + 0.00208499133574391*x_5 + 7.92144980196189e-5*x_52 + 0.00104983800859219*x_53 - 0.000422523034798071*x_54 - 0.000277275242935404*x_56 - 0.000301452664850582*x_57 - 8.79882012893402e-5*x_58 - 0.00011357477558689*x_59 + 0.000495482195471346*x_6 - 1.11503189491053e-5*x_60 - 0.000234436034809036*x_61 + 0.00137674260756708*x_62 + 7.52206381793539e-5*x_63 + 6.20304920151339e-5*x_64 + 0.000221081132388264*x_65 - 1.74225763376319e-5*x_66 - 7.05881045783453e-5*x_67 - 0.000262594795387243*x_68 - 0.00010287490469663*x_69 - 9.98951311447678e-5*x_7 - 0.000494928706854369*x_70 + 7.47630730714485e-5*x_71 - 5.51531639651747e-5*x_73 + 0.000656652716851571*x_74 + 8.92577413882254e-5*x_76 - 9.47965767636688e-5*x_78 + 0.000907943859597686*x_79 - 0.000277012809718778*x_8 + 0.000237680933478279*x_80 + 0.0001180077198773*x_82 - 0.000477787950750859*x_83 - 0.000224894489987867*x_84 - 3.62979828039954e-5*x_85 - 9.41761424996036e-5*x_88 - 2.35745905845111e-5*x_89 + 0.00143293777416872*x_90 - 0.00637858349419953*x_91 - 0.000671903014294582*x_93 - 0.000120058258364854*x_94 - 0.00011823590502141*x_95 + 1.34496589320548e-5*x_96 + 0.000132770615046848*x_97 - 0.000956959377285982*x_98 + 2.95198997533056e-6*std::pow(-6.25112009048462*x_110 - 8.66423988342285, 2) + 8.37098091165012e-7*std::pow(-6.72800016403198*x_118 - 8.75936031341553, 2) + 7.39672599602619e-6*std::pow(-5.76688003540039*x_14 - 8.3450403213501, 2) - 1.13901809325426e-5*std::pow(-5.93840026855469*x_15 - 8.39935970306396, 2) + 2.07658588707513e-5*std::pow(-6.29008007049561*x_17 - 9.74312019348145, 2) + 2.23271500371901e-5*std::pow(-4.49232006072998*x_18 - 7.14559984207153, 2) + 9.208763807292e-6*std::pow(-5.72383975982666*x_24 - 8.38159942626953, 2) - 9.27607731863916e-5*std::pow(-1.62839984893799*x_25 - 3.46207976341248, 2) - 6.05461399564654e-6*std::pow(-6.12911987304688*x_27 - 7.76647996902466, 2) + 4.14747345436118e-5*std::pow(-4.58247995376587*x_4 - 7.77960014343262, 2) + 2.63801158044212e-6*std::pow(-3.95839977264404*x_41 - 9.7038402557373, 2) + 6.02604013716626e-5*std::pow(-3.50720000267029*x_5 - 5.56712007522583, 2) - 1.26984387800911e-6*std::pow(-7.74287986755371*x_55 - 9.17280006408691, 2) + 2.29205167070305e-6*std::pow(-7.26232004165649*x_66 - 9.61312007904053, 2) - 0.000120750190936307*std::pow(-1.15495979785919*x_66 - 1.92279982566833, 2) + 7.50293202996303e-6*std::pow(-5.72591972351074*x_7 - 9.18144035339355, 2) + 6.96670635924578e-5*std::pow(-5.07807970046997*x_7 - 8.11320018768311, 2) - 1.73009092320109e-6*std::pow(-5.73503971099854*x_70 - 6.75536012649536, 2) + 4.29760965227147e-6*std::pow(-5.9539999961853*x_72 - 9.1340799331665, 2) - 1.08335203425794e-5*std::pow(-3.84744000434875*x_75 - 5.66079998016357, 2) + 6.42227913727076e-7*std::pow(-5.71463966369629*x_78 - 9.38111972808838, 2) + 9.46234957965439e-6*std::pow(-4.57719993591309*x_8 - 8.7577600479126, 2) + 8.28621872459691e-5*std::pow(-2.51511979103088*x_8 - 5.22399997711182, 2) - 3.94600313466611e-6*std::pow(-4.91448020935059*x_81 - 6.35383987426758, 2) + 7.15135859574387e-6*std::pow(-6.81415987014771*x_85 - 8.80992031097412, 2) + 5.31456618499782e-5*std::pow(-6.0*x_9 - 9.99997997283936, 2) - 0.000239645968502375*std::exp(0.719279825687408*x_15) + 0.000483348238129691*std::exp(0.612959861755371*x_2) - 0.000132713158167964*std::exp(0.513279855251312*x_76) + 0.136133205253407*std::sin(0.299839943647385*x_1 - 7.41623973846436) + 0.0252933811367883*std::sin(0.212640002369881*x_10 + 5.01351976394653) + 0.0277395975634102*std::sin(0.308879911899567*x_10 - 4.25407981872559) + 0.00118452261995159*std::sin(0.41143986582756*x_100 - 0.988239824771881) - 0.000811396898835851*std::sin(0.303999930620193*x_101 - 4.3010401725769) + 0.00839878199374519*std::sin(0.353999853134155*x_101 + 1.96231985092163) - 0.0149045695861348*std::sin(0.371919840574265*x_102 - 7.40231990814209) + 0.000674122204781568*std::sin(0.411119878292084*x_102 - 1.00239980220795) - 0.00785812047359825*std::sin(0.136880040168762*x_104 - 7.68391990661621) + 0.00590021045465606*std::sin(0.332559853792191*x_104 + 5.15224027633667) + 0.00289947359454936*std::sin(0.376319825649261*x_105 + 5.18792009353638) + 0.000905686068363349*std::sin(0.700959861278534*x_106 - 0.957199811935425) - 0.00664316103224259*std::sin(0.385039836168289*x_107 + 5.18535995483398) + 0.0103150589929016*std::sin(0.367439836263657*x_108 - 4.22936010360718) - 0.000650671326986743*std::sin(0.708239853382111*x_108 - 4.02719974517822) + 8.3385080368193e-5*std::sin(0.85207986831665*x_108 + 8.40624046325684) - 0.0112202072779377*std::sin(0.397519826889038*x_109 + 5.19832038879395) + 0.00218906522686584*std::sin(0.327279835939407*x_11 - 1.06439983844757) - 0.000529081745604159*std::sin(0.597919821739197*x_110 - 7.19352006912231) + 0.00172487616521144*std::sin(0.609279870986938*x_110 + 2.20576000213623) - 0.0014910422954711*std::sin(0.361119836568832*x_111 + 1.97559976577759) - 0.00834185409911607*std::sin(0.368559837341309*x_111 + 5.17408037185669) + 0.00381894805202523*std::sin(0.331439822912216*x_112 - 7.43304014205933) - 0.000938899064964923*std::sin(0.369279861450195*x_112 + 1.9748797416687) + 0.0042190895853539*std::sin(0.438159853219986*x_112 - 1.17311990261078) + 0.0087444544166613*std::sin(0.327199816703796*x_113 + 1.92543983459473) - 0.00255175914703803*std::sin(0.469839870929718*x_114 - 0.924239873886108) - 0.00927173168459805*std::sin(0.360399842262268*x_115 + 5.16368007659912) + 0.00225312452595941*std::sin(0.259839832782745*x_116 + 8.09823989868164) + 0.00807967635828658*std::sin(0.288879930973053*x_117 + 8.30072021484375) - 0.000225623142610711*std::sin(0.976639807224274*x_117 - 7.98496007919312) - 0.00198272852294402*std::sin(0.364959836006165*x_118 + 1.96375977993011) + 0.00337043947768747*std::sin(0.427439838647842*x_118 + 8.43224048614502) + 0.0010804483922345*std::sin(0.342879861593246*x_12 + 2.14535975456238) + 0.00515099348970159*std::sin(0.169520005583763*x_120 - 7.63551998138428) + 0.00688224392641936*std::sin(0.289919942617416*x_120 - 7.49015998840332) - 0.00637104638747005*std::sin(0.213919997215271*x_14 + 5.01495981216431) - 0.043209119086818*std::sin(0.281919956207275*x_15 - 4.2772798538208) - 0.0111146256381136*std::sin(0.326799839735031*x_16 - 4.26232004165649) - 0.0124760656158981*std::sin(0.354879856109619*x_16 + 5.17128038406372) + 0.0291354116903157*std::sin(0.134800046682358*x_18 + 4.90247964859009) + 0.0325142518924905*std::sin(0.213279992341995*x_19 + 5.02807998657227) - 0.00196644969160003*std::sin(0.295359939336777*x_21 + 8.31112003326416) + 0.00392369352055413*std::sin(0.324959844350815*x_21 - 4.26024007797241) - 0.0132852101119491*std::sin(0.330719828605652*x_21 - 4.2402400970459) - 0.0234585817013915*std::sin(0.161600023508072*x_23 + 4.94087982177734) + 0.00638115346397727*std::sin(0.183360010385513*x_23 - 4.41607999801636) - 0.0549371095328647*std::sin(0.158160030841827*x_24 + 4.95127964019775) + 0.0208693507898115*std::sin(0.324319839477539*x_26 - 4.26200008392334) - 0.0155429247269206*std::sin(0.33095982670784*x_26 - 4.2707200050354) - 0.000604016283606705*std::sin(0.398319840431213*x_26 - 1.17639982700348) + 0.0295399476889382*std::sin(0.305119842290878*x_27 - 4.31576013565063) + 0.00287619100135042*std::sin(0.291999936103821*x_28 - 4.28151988983154) - 0.00386097736418815*std::sin(0.293919950723648*x_3 - 1.08967983722687) + 0.0209432490595333*std::sin(0.343599855899811*x_3 - 1.05495977401733) + 0.00598481927243165*std::sin(0.341839849948883*x_34 + 1.98831987380981) + 0.00083230076726131*std::sin(0.345679849386215*x_34 + 5.20056009292603) - 0.00663084441138308*std::sin(0.231999978423119*x_35 - 1.14375984668732) - 0.00154805955223005*std::sin(0.323519825935364*x_35 + 5.18839979171753) + 0.00132184782217672*std::sin(0.325279831886292*x_36 + 5.12784004211426) - 0.00348454417038319*std::sin(0.36015984416008*x_36 - 4.23160028457642) - 0.000944263014861341*std::sin(0.451279848814011*x_38 + 8.45608043670654) - 0.00154014959613885*std::sin(0.371439844369888*x_39 + 5.17072010040283) - 0.00368364114002743*std::sin(0.409199863672256*x_39 + 1.98799991607666) + 0.00212976936541603*std::sin(0.373999834060669*x_40 - 4.22448015213013) - 0.00220079110047314*std::sin(0.372079849243164*x_42 - 7.41975975036621) - 0.00687483576096295*std::sin(0.386159837245941*x_42 + 1.99703979492188) - 0.00267223008376981*std::sin(0.244559973478317*x_43 + 8.25592041015625) + 0.00132988727733515*std::sin(0.370959848165512*x_44 + 8.3645601272583) + 0.00560488949742321*std::sin(0.270159959793091*x_45 - 7.5237603187561) - 0.000591569588975243*std::sin(0.380239844322205*x_45 + 5.16648006439209) - 0.004974887289951*std::sin(0.462239861488342*x_48 + 5.23808002471924) + 0.00132387859957761*std::sin(0.163760021328926*x_49 - 7.27447986602783) - 0.00126972178359689*std::sin(0.326239824295044*x_49 + 8.32384014129639) + 0.00563224481166963*std::sin(0.374799847602844*x_49 - 4.23487997055054) - 0.00835146142724531*std::sin(0.27727997303009*x_50 + 5.07631969451904) - 0.00137606843281678*std::sin(0.398319840431213*x_50 - 1.00463974475861) + 0.000216215297299767*std::sin(0.917439818382263*x_50 - 4.02711963653564) + 0.00530461831850582*std::sin(0.210559993982315*x_51 + 5.01375961303711) - 0.0142936215284453*std::sin(0.325199842453003*x_51 - 4.27367973327637) - 0.000716732271957707*std::sin(0.350959837436676*x_51 - 1.05951988697052) + 0.0102393821812962*std::sin(0.226319998502731*x_52 + 8.22552013397217) - 0.00276245324857842*std::sin(0.363839834928513*x_53 - 4.24128007888794) - 0.000921339019751128*std::sin(0.488159865140915*x_54 + 2.25639986991882) - 0.000234584507906377*std::sin(0.683279812335968*x_54 + 8.4498405456543) + 0.015609449979854*std::sin(0.238079980015755*x_55 - 4.34976005554199) - 0.00104803910159115*std::sin(0.318879842758179*x_55 + 5.11352014541626) - 0.00492437032360821*std::sin(0.315759837627411*x_56 + 8.30768013000488) + 0.0192604573505565*std::sin(0.304559946060181*x_57 - 4.27871990203857) - 0.000476420730903799*std::sin(0.538079857826233*x_57 + 2.13239979743958) + 0.00580120665447445*std::sin(0.498079836368561*x_58 - 1.10559988021851) + 0.00472149123596791*std::sin(0.337039858102798*x_59 + 5.13671970367432) + 0.000604466663002922*std::sin(0.464319854974747*x_6 - 6.90000009536743) + 0.0240336824422148*std::sin(0.151360034942627*x_60 + 1.74399983882904) - 0.00193781647177107*std::sin(0.347919851541519*x_62 + 8.34496021270752) - 0.0149746225959085*std::sin(0.271359950304031*x_63 + 5.09839963912964) - 0.0044280470546767*std::sin(0.296799927949905*x_63 - 4.28799962997437) + 0.0210717363394268*std::sin(0.211040005087852*x_64 + 5.00703954696655) - 0.00321567744753053*std::sin(0.241439983248711*x_64 - 4.3517599105835) - 0.000650782411017246*std::sin(0.521519839763641*x_65 + 8.33312034606934) + 0.0011233091262868*std::sin(0.296319931745529*x_67 - 7.49088001251221) - 0.00113591405720697*std::sin(0.473519861698151*x_68 + 2.26967978477478) + 0.0164034393971623*std::sin(0.298079937696457*x_69 - 7.49047994613647) - 8.14640130216101e-5*std::sin(0.734559834003448*x_70 + 5.98959970474243) + 0.00458981805393109*std::sin(0.271119952201843*x_71 + 5.07599973678589) + 0.00120894421102094*std::sin(0.402959853410721*x_72 - 7.19704008102417) + 0.00111294852619573*std::sin(0.498719841241837*x_72 + 8.48984050750732) + 0.000843740421772639*std::sin(0.305759936571121*x_75 + 5.14759969711304) + 0.00430653759345642*std::sin(0.437039852142334*x_75 + 5.22632026672363) + 0.00979133195659135*std::sin(0.150800034403801*x_76 + 4.92391967773438) + 0.000847420825465564*std::sin(0.406159847974777*x_77 - 1.00543987751007) + 0.00155394820324656*std::sin(0.491839855909348*x_77 - 0.899999797344208) - 0.00126749508389949*std::sin(0.492559850215912*x_77 - 0.874159812927246) + 0.00867682834517808*std::sin(0.428879857063293*x_78 - 4.15312004089355) + 0.000447550938649902*std::sin(0.430959850549698*x_80 - 7.16616010665894) + 0.0191303050527294*std::sin(0.207440003752708*x_81 - 7.58808040618896) + 0.00287811274468658*std::sin(0.347279846668243*x_81 - 1.04183983802795) + 0.0045380246225633*std::sin(0.386639833450317*x_82 - 4.22040033340454) - 9.66313270073736e-5*std::sin(0.997999846935272*x_82 - 4.60471963882446) - 0.000552413308001105*std::sin(0.461679875850677*x_83 + 2.05015993118286) + 0.000308133135777393*std::sin(0.632639825344086*x_84 + 5.43271970748901) + 0.00121988999065163*std::sin(0.5065598487854*x_85 + 8.51416015625) - 0.0110293822505661*std::sin(0.155040040612221*x_86 - 1.27311992645264) - 0.00120087513106671*std::sin(0.186640009284019*x_86 + 8.16335964202881) - 0.0046573452160743*std::sin(0.301999926567078*x_86 - 7.48448038101196) - 0.00413851550569638*std::sin(0.32015985250473*x_87 + 5.12007999420166) - 0.00219496574332576*std::sin(0.399999856948853*x_87 + 8.40015983581543) + 0.000155401204278684*std::sin(0.5136798620224*x_87 + 5.15128040313721) + 0.00540113915813463*std::sin(0.279199928045273*x_88 + 5.0959997177124) - 0.000923758571475999*std::sin(0.531839847564697*x_88 + 2.15471982955933) - 0.00481216053178572*std::sin(0.501599848270416*x_89 + 8.48872089385986) + 0.00293784676464281*std::sin(0.392159849405289*x_9 - 7.39575958251953) - 0.000562344053217676*std::sin(0.53007984161377*x_9 - 4.06080007553101) - 0.00336687466858396*std::sin(0.238079980015755*x_90 - 7.55304002761841) - 0.00378433264949186*std::sin(0.406159847974777*x_90 - 4.18832015991211) + 0.0103246539498312*std::sin(0.326319843530655*x_92 - 4.21528005599976) + 0.0252295934614247*std::sin(0.353599846363068*x_92 - 7.40887975692749) + 0.00932353348802583*std::sin(0.375119835138321*x_92 + 1.9987998008728) - 0.00344370900342317*std::sin(0.356559842824936*x_93 + 1.99455988407135) - 0.00386607085297978*std::sin(0.392959833145142*x_94 + 5.19432020187378) - 0.000930516939530787*std::sin(0.45143985748291*x_94 + 2.01095986366272) - 0.0060395647418934*std::sin(0.346799850463867*x_96 + 5.1637601852417) - 0.00220008942121743*std::sin(0.437839865684509*x_97 + 5.22304010391235) + 0.000444827245380367*std::sin(0.600959837436676*x_98 - 7.4047999382019) + 0.0011513043062042*std::sin(0.33111983537674*x_99 + 5.1448802947998) - 0.00116165745027571*std::sin(0.511439859867096*x_99 + 5.16400003433228) + 0.00161467843054142*std::sin(0.531919836997986*x_99 - 1.00535976886749) + 0.0985363125801086*std::sin(-0.0585590820445213*x_10 + 0.0577713423431281*x_101 - 0.0120399508456776*x_102 - 0.00580099061858382*x_104 - 0.00714917114341285*x_105 + 0.00934740414405546*x_107 - 0.00217286546105137*x_109 + 0.301609423573482*x_11 + 0.0187690006850701*x_111 + 0.0443288971396935*x_113 - 0.0362984507381718*x_114 - 0.111089307678284*x_116 + 0.121706107230047*x_12 - 0.12413215784132*x_13 + 0.0196820057722135*x_14 - 0.00246702588744116*x_2 + 0.108144934981981*x_20 + 0.00241616078902814*x_21 + 0.0181727441728219*x_23 - 0.0230857803755706*x_24 + 0.0179579687923361*x_25 + 0.00530408492020258*x_27 + 0.0102999924089869*x_28 + 0.00222676837476838*x_31 - 0.145461509201076*x_33 - 0.0583782011191866*x_38 + 0.030623639155111*x_4 - 0.0189919783124876*x_40 + 0.0315296174152378*x_41 - 0.00606075778547261*x_42 - 0.0217805087060308*x_44 + 0.0298970439114993*x_45 - 0.00406973673202502*x_46 - 0.0341088625411045*x_47 - 0.0291383688073786*x_48 + 0.072228921542445*x_50 - 0.00717228089529822*x_52 - 0.0184201960280107*x_53 - 0.0141556550973626*x_54 + 0.0264461797604383*x_56 - 0.00112114490811955*x_57 - 0.00122738047516874*x_59 - 0.0157187251471445*x_60 - 0.0272105271284398*x_61 + 0.0728250431352215*x_62 + 0.0683702342715655*x_65 - 0.00267449744758245*x_69 + 0.0269418380252953*x_70 + 0.0107668915854536*x_71 + 0.00999882840516433*x_74 + 0.00220140049945908*x_75 + 0.259445347547867*x_8 - 0.0448414718340878*x_89 + 0.0132510143774562*x_90 - 0.0873572356367272*x_93 - 0.0220330358025902*x_95 - 0.00837314293840041*std::pow(-2.17063999176025*x_108 - 3.15591979026794, 2) + 0.000446432040092768*std::pow(-3.51968002319336*x_110 - 5.79135990142822, 2) + 0.00338308261103515*std::pow(-6.46104001998901*x_17 - 9.48311996459961, 2) + 0.000949339383411671*std::pow(-4.59431982040405*x_19 - 7.38895988464355, 2) + 0.00252356226442463*std::pow(-5.7294397354126*x_22 - 9.58975982666016, 2) + 0.00302049302491848*std::pow(-4.11559963226318*x_5 - 6.37784004211426, 2) + 0.00569605581130511*std::pow(-3.28671979904175*x_6 - 5.13399982452393, 2) - 0.000297610394670033*std::pow(-5.31584024429321*x_64 - 8.99736022949219, 2) + 0.00141438943937428*std::pow(-2.30607986450195*x_85 - 3.7727198600769, 2) - 0.000311356515316503*std::pow(-5.80800008773804*x_87 - 8.01583957672119, 2) + 0.000350430082042021*std::pow(-9.5959997177124*x_88 - 9.99096012115479, 2) - 1.41365421302945*std::sin(0.351679861545563*x_1 - 4.35207986831665) - 0.0662406463395326*std::sin(0.513359844684601*x_100 - 7.22968006134033) + 0.408665915071579*std::sin(0.388159841299057*x_103 - 7.40567970275879) - 1.11118012154358*std::sin(0.364719837903976*x_106 + 1.98247981071472) + 0.307646063579735*std::sin(0.268239974975586*x_112 + 5.07903957366943) + 0.00520804898916155*std::sin(1.55183982849121*x_115 + 1.80663990974426) - 0.346006826447349*std::sin(0.394879847764969*x_117 - 7.39591979980469) + 0.943091696398746*std::sin(0.239919975399971*x_118 - 1.36119985580444) - 0.24756694985027*std::sin(0.429279863834381*x_119 + 2.01151990890503) - 0.208373729525532*std::sin(0.322559833526611*x_120 + 5.33591985702515) + 0.22476169846223*std::sin(0.510799825191498*x_15 - 0.896399855613708) - 0.432001178748482*std::sin(0.338079839944839*x_16 - 4.24959993362427) + 1.62209971338872*std::sin(0.208719998598099*x_18 - 7.57600021362305) + 1.23431360797125*std::sin(0.316399842500687*x_26 - 4.28280019760132) + 0.00359739960591238*std::sin(1.78887987136841*x_29 - 0.204079851508141) + 4.92445340746903*std::sin(0.317679852247238*x_3 + 8.32208061218262) - 0.923832197167442*std::sin(0.2880799472332*x_30 - 4.29983997344971) + 1.9589602668989*std::sin(0.276319950819016*x_32 - 7.44519996643066) + 1.00209495908705*std::sin(0.355519831180573*x_34 + 1.9975198507309) + 1.021590722734*std::sin(0.321999847888947*x_35 + 1.98599982261658) - 1.46782601942255*std::sin(0.343599855899811*x_36 - 7.43511962890625) - 0.387913559267067*std::sin(0.436079859733582*x_37 + 2.03319978713989) - 0.470148908706411*std::sin(0.401119858026505*x_39 - 7.40167951583862) + 0.382070835517274*std::sin(0.446799874305725*x_43 + 2.02879977226257) - 0.172389999828402*std::sin(0.56063985824585*x_49 - 4.21432018280029) + 0.502139418402567*std::sin(0.274559944868088*x_51 - 4.30599975585938) + 0.329461493097131*std::sin(0.322879940271378*x_55 + 8.36727905273438) + 1.30457660081235*std::sin(0.313599914312363*x_58 + 5.13840007781982) - 0.370463358759576*std::sin(0.385599851608276*x_63 - 7.40111970901489) - 1.02807521683603*std::sin(0.199440002441406*x_66 + 5.00719976425171) + 3.41590488124325*std::sin(0.186240002512932*x_67 - 4.4201602935791) + 0.117138349479057*std::sin(0.319439828395844*x_68 - 7.65296030044556) + 0.293491339311299*std::sin(0.418239861726761*x_7 - 7.17655992507935) - 0.166712466605699*std::sin(0.578239858150482*x_72 - 7.01944017410278) + 0.451516892451179*std::sin(0.411759853363037*x_73 + 5.19583988189697) - 0.0381302409898461*std::sin(1.22431993484497*x_76 - 0.768399834632874) + 0.41860838979688*std::sin(0.468479871749878*x_77 + 5.25504016876221) - 0.51338677777845*std::sin(0.407439857721329*x_78 - 4.18200016021729) - 0.0145352091471207*std::sin(0.752559840679169*x_79 - 1.39367985725403) + 0.285037800842574*std::sin(0.530399858951569*x_80 + 5.34944009780884) - 0.324017334871522*std::sin(0.423119872808456*x_81 - 4.17736005783081) + 0.108193769572722*std::sin(0.61303985118866*x_82 - 0.966639816761017) - 0.143066931646963*std::sin(0.637919843196869*x_83 + 2.00751972198486) - 0.334165582660894*std::sin(0.36303985118866*x_84 + 5.15488004684448) - 0.266534138657789*std::sin(0.489359855651855*x_86 - 4.12224006652832) + 0.356046176552518*std::sin(0.60999983549118*x_9 + 5.19591999053955) + 1.16362849866678*std::sin(0.196719989180565*x_91 - 7.39048004150391) + 0.872277536078656*std::sin(0.373679846525192*x_92 + 5.19736003875732) - 0.454676057828994*std::sin(0.406799852848053*x_94 - 7.39671945571899) + 0.433632291821555*std::sin(0.422319859266281*x_96 - 1.19247984886169) - 0.279190924461089*std::sin(0.403919845819473*x_97 - 4.20703983306885) - 0.079902644886177*std::sin(0.687439858913422*x_98 + 2.02071976661682) - 0.41685519515997*std::sin(0.446559846401215*x_99 - 7.37319993972778) - 7.51382904084406) - 0.0692748427391052*std::sin(-0.055521200083975*x_10 + 0.0585770252330256*x_100 - 0.00323212652983437*x_101 - 0.00537270653586991*x_107 - 0.0376895473788006*x_109 - 0.155725524132011*x_11 - 0.0310267221957125*x_112 - 0.0196624584988248*x_113 + 0.014545680515299*x_116 - 0.00401143072597768*x_120 + 0.0065432989657926*x_19 - 0.163542099966116*x_2 + 0.00693046001390687*x_20 + 0.0143312903089494*x_21 + 0.0595093596519943*x_23 + 0.183848493572422*x_25 + 0.297790027970891*x_29 + 0.0146142493183335*x_3 - 0.00874169462575484*x_30 + 0.0983222870009828*x_31 + 0.0124204289705142*x_32 - 0.0071932948292517*x_34 + 0.00293168475549748*x_37 + 0.0189157106913184*x_39 - 0.0053230054540022*x_41 - 0.0630726052903814*x_5 - 0.0319792071810608*x_51 - 0.0122113921369853*x_52 + 0.00192193359782885*x_54 - 0.0350976188857294*x_57 - 0.0175958444349746*x_61 + 0.104874907981963*x_63 + 0.00397602444382011*x_65 - 0.0152532014648621*x_68 + 0.01537055723844*x_69 - 0.00149192749994613*x_71 + 0.0430980434660864*x_72 - 0.0030796954020266*x_74 + 0.0341775577615412*x_78 - 0.0327488467267647*x_79 + 0.00717628836657432*x_80 + 0.000805877372983215*x_84 - 0.00913563190122248*x_88 - 0.0153671307747306*x_89 - 0.093625240738256*x_9 - 0.0602033550841216*x_90 - 0.00695559737496423*x_92 - 0.000473793593875433*x_93 + 0.0152821465190011*x_94 - 0.0180709268062213*x_97 + 0.00555540268255763*x_99 - 0.00109209032998939*std::pow(-5.40447998046875*x_13 - 8.20039939880371, 2) + 0.00131593792339918*std::pow(-6.59999990463257*x_15 - 9.99973964691162, 2) + 0.00687544367866216*std::pow(-4.0065598487854*x_17 - 6.20688009262085, 2) + 0.00436626051664354*std::pow(-3.45199990272522*x_18 - 5.2752799987793, 2) + 0.000853647461664851*std::pow(-5.72079992294312*x_22 - 8.28072071075439, 2) + 0.00377725932105744*std::pow(-5.51200008392334*x_4 - 9.19999980926514, 2) + 0.00718411677227332*std::pow(-3.16847991943359*x_6 - 5.34823989868164, 2) + 0.000793863807716032*std::pow(-5.60232019424438*x_66 - 7.61072015762329, 2) + 0.000328974973441207*std::pow(-5.68575954437256*x_67 - 8.73624038696289, 2) + 0.00237545760828296*std::pow(-5.31304025650024*x_7 - 8.78575992584229, 2) + 0.000432876543467013*std::pow(-7.10591983795166*x_70 - 9.93296051025391, 2) - 0.000763787443499524*std::pow(-6.33008003234863*x_81 - 8.87975978851318, 2) - 0.0239677458541407*std::exp(0.57999986410141*x_106) - 0.0625890901826974*std::exp(0.612399816513062*x_76) + 0.0134654702312116*std::log(0.681119859218597*x_91 + 1.02415990829468) - 1.57510497309795*std::sin(0.305919945240021*x_1 + 1.97895979881287) + 0.846958441925651*std::sin(0.363119840621948*x_102 + 5.16175985336304) - 0.445217987381618*std::sin(0.437279850244522*x_103 + 2.00919985771179) - 0.612159490871026*std::sin(0.34215983748436*x_104 - 7.4378399848938) - 0.388299098129121*std::sin(0.345919847488403*x_105 + 8.34463977813721) + 0.492811780866486*std::sin(0.296479940414429*x_108 + 5.10391998291016) + 0.0365068301795528*std::sin(0.816159844398499*x_110 + 5.6101598739624) - 0.345225261527347*std::sin(0.339759826660156*x_111 - 1.04287981987) - 0.323341669710956*std::sin(0.409679859876633*x_114 + 5.21720027923584) + 0.0263123231769773*std::sin(0.516719877719879*x_115 - 7.04375982284546) - 0.175512513110917*std::sin(0.542399823665619*x_117 - 7.43400001525879) - 0.7833111452765*std::sin(0.384399831295013*x_118 - 7.41703987121582) - 0.548715205138155*std::sin(0.353999853134155*x_119 + 5.16960000991821) - 0.954637766637447*std::sin(0.283679932355881*x_12 - 7.49535989761353) - 13.9835071900244*std::sin(0.142560034990311*x_14 - 4.49032020568848) + 0.239375816658185*std::sin(0.37271985411644*x_16 - 4.2260799407959) - 0.424721454426731*std::sin(0.241919979453087*x_24 - 4.34632015228271) - 0.534955196368578*std::sin(0.321759849786758*x_26 - 4.27472019195557) + 2.25203730384511*std::sin(0.214399993419647*x_27 - 7.57800006866455) + 1.05167260702554*std::sin(0.320719838142395*x_28 + 8.30399990081787) + 0.561529608029272*std::sin(0.251519978046417*x_33 + 2.01743984222412) + 0.594889335807085*std::sin(0.323599845170975*x_35 + 1.97183978557587) - 0.320193290511002*std::sin(0.356639832258224*x_36 + 5.1573600769043) + 0.233437359757529*std::sin(0.3781598508358*x_38 + 5.18815994262695) - 0.558273407780003*std::sin(0.33095982670784*x_40 - 7.4703197479248) - 0.186463634206079*std::sin(0.475279837846756*x_42 + 2.04271984100342) - 0.430406033682196*std::sin(0.451839864253998*x_43 + 2.04807996749878) + 0.583949409496277*std::sin(0.365279853343964*x_44 - 4.22080039978027) - 0.435808942131313*std::sin(0.366239845752716*x_45 - 7.4172797203064) - 0.0335739790783851*std::sin(0.703439831733704*x_46 + 2.05855989456177) - 0.375829544756057*std::sin(0.339919835329056*x_47 + 5.1384801864624) + 0.189190555995046*std::sin(0.476239860057831*x_48 - 7.34207963943481) - 0.574636853711123*std::sin(0.238639980554581*x_49 - 4.35871982574463) + 0.297530030984243*std::sin(0.322959840297699*x_50 + 4.94575977325439) - 0.170161542989213*std::sin(0.366159826517105*x_53 - 7.44087982177734) + 0.246660908076841*std::sin(0.4129598736763*x_55 - 4.18151998519897) + 0.404398702828974*std::sin(0.354159832000732*x_56 - 7.45271968841553) + 0.430494497558563*std::sin(0.465279877185822*x_58 + 2.05847978591919) + 0.52779892476989*std::sin(0.369119822978973*x_59 - 7.42424011230469) + 0.0122755156692432*std::sin(1.47391986846924*x_60 + 3.38039994239807) + 0.177467655978489*std::sin(0.376559853553772*x_62 - 4.21199989318848) + 1.1289268334582*std::sin(0.278079956769943*x_64 - 4.28567981719971) - 1.42482828551848*std::sin(0.275039941072464*x_73 + 5.07879972457886) - 0.254830068259958*std::sin(0.391919851303101*x_75 + 8.38992023468018) - 0.0430038720495538*std::sin(0.890239894390106*x_77 + 8.64192008972168) + 0.0136871300964289*std::sin(1.52543985843658*x_8 + 2.39687991142273) + 0.0247606998454624*std::sin(0.99999988079071*x_82 - 10.0) + 1.28415394131917*std::sin(0.32575985789299*x_83 + 5.12007999420166) + 1.40946055979578*std::sin(0.1564000248909*x_85 - 7.65104007720947) + 1.20792005906051*std::sin(0.249119967222214*x_86 - 7.53016042709351) + 1.24829606663266*std::sin(0.211119994521141*x_87 + 5.01863956451416) + 0.624851913932616*std::sin(0.3643998503685*x_95 - 4.23271989822388) + 0.32788278496448*std::sin(0.440079867839813*x_96 - 4.17288017272949) + 0.233299191950627*std::sin(0.487279862165451*x_98 + 8.24639987945557) + 19.3336036301631) + 0.104921895929924);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (5.30056325316894e-7*x_1 - 0.0003645860323072*x_10 + 0.00160722419889192*x_100 + 7.00112168530016e-5*x_101 - 1.79546124160597e-5*x_102 - 0.00392822825838342*x_103 - 8.65074446904926e-6*x_104 + 0.00321452184651433*x_105 - 7.71936002431501e-6*x_106 - 9.48933093854914e-6*x_107 - 0.000188872517585676*x_109 - 0.000337404548048096*x_11 + 3.13812745621273e-5*x_111 - 0.000154940048578819*x_112 - 2.7518055028356e-5*x_113 - 7.32044933255775e-5*x_114 - 1.45151682856545e-5*x_115 + 0.00411803211674024*x_116 - 4.99943829582377e-6*x_117 - 0.000556302298292403*x_119 - 0.0015424744048462*x_12 + 3.96642806345936e-6*x_120 + 0.00016315406131626*x_13 + 0.00251208475279794*x_14 + 3.6464203312452e-5*x_16 + 7.14392653209153e-5*x_17 + 3.78942087016497e-5*x_19 - 0.00134118921800721*x_2 + 4.16100159932132e-5*x_20 + 7.51701517214196e-5*x_21 + 0.00227418340003548*x_22 + 0.0007623399121213*x_23 - 3.66416385777972e-5*x_24 + 0.000944222720145731*x_25 + 7.90973237222916e-6*x_27 - 0.00645690966165531*x_28 - 0.015204251160827*x_29 + 7.29800745641914e-5*x_3 - 0.00151083681433602*x_30 - 0.000273200439546066*x_31 - 0.00288459428950958*x_32 - 0.000640242553516606*x_33 - 3.59215982679613e-5*x_34 + 0.000495695844200611*x_36 + 0.000464790074755053*x_37 - 0.000707976946656579*x_38 + 9.48982865456134e-5*x_39 + 0.0408484965584482*x_4 + 0.000240816594515688*x_40 - 0.00181584940073111*x_41 - 9.03812302729152e-6*x_42 + 0.000252917940388267*x_43 + 0.00214088003411768*x_44 - 0.000626951014563938*x_45 + 1.43511187999923e-5*x_46 - 0.000405190137599313*x_47 - 3.37301970644789e-5*x_48 + 0.0103837727439926*x_5 + 0.000107711593522839*x_50 - 0.000159696531360646*x_51 - 4.73348690104167e-5*x_52 + 0.00547972451977514*x_53 - 0.00218227826317531*x_54 - 0.00162509613431527*x_56 - 0.000176941046122321*x_57 - 1.52692346675274e-5*x_58 - 0.000402320146162556*x_59 + 0.00256220649872468*x_6 - 2.77955642013266e-5*x_60 - 0.000312353313021138*x_61 + 0.00740666860821064*x_62 + 0.000523720270382602*x_63 + 9.15193572648489e-6*x_64 + 0.000159706759242002*x_65 - 2.57051481701744e-6*x_66 - 0.000449683338662448*x_67 - 0.00120298619233119*x_68 + 7.21589967643021e-5*x_69 - 0.00250258260847321*x_70 + 9.29340836105734e-6*x_71 + 0.000215221347139603*x_72 - 0.000471340905329389*x_73 + 0.00374079848869821*x_74 + 3.28284502544275e-6*x_75 + 0.000458573093377598*x_76 + 0.000156688348575519*x_78 + 0.00365417948698839*x_79 + 0.000346028366569017*x_8 + 0.00127404379237745*x_80 + 1.74107770623937e-5*x_82 - 0.00173008470230959*x_83 - 0.000742973602904869*x_84 - 5.35537918258286e-6*x_85 - 4.56211662206849e-5*x_88 - 0.000155956743986851*x_89 - 0.000467542116008424*x_9 + 0.00708102100605522*x_90 - 0.040500816079075*x_91 - 3.47345938888957e-5*x_92 - 0.00301220306948473*x_93 + 7.63153938436284e-5*x_94 - 0.000639384916139786*x_95 - 8.00765281068265e-6*x_96 - 8.71297435478306e-5*x_97 - 0.00522663210823667*x_98 + 2.77423556404332e-5*x_99 - 1.2486474246464e-5*std::pow(-2.17063999176025*x_108 - 3.15591979026794, 2) + 6.65743104163424e-7*std::pow(-3.51968002319336*x_110 - 5.79135990142822, 2) + 1.23504871204895e-7*std::pow(-6.72800016403198*x_118 - 8.75936031341553, 2) - 5.45363856722177e-6*std::pow(-5.40447998046875*x_13 - 8.20039939880371, 2) + 1.09130781818619e-6*std::pow(-5.76688003540039*x_14 - 8.3450403213501, 2) + 6.57148004523513e-6*std::pow(-6.59999990463257*x_15 - 9.99973964691162, 2) - 1.68049938701488e-6*std::pow(-5.93840026855469*x_15 - 8.39935970306396, 2) + 5.0450319798817e-6*std::pow(-6.46104001998901*x_17 - 9.48311996459961, 2) + 0.000106687263097823*std::pow(-6.29008007049561*x_17 - 9.74312019348145, 2) + 3.43343254518859e-5*std::pow(-4.0065598487854*x_17 - 6.20688009262085, 2) + 0.000114708596695576*std::pow(-4.49232006072998*x_18 - 7.14559984207153, 2) + 2.18040633583271e-5*std::pow(-3.45199990272522*x_18 - 5.2752799987793, 2) + 1.41570517180117e-6*std::pow(-4.59431982040405*x_19 - 7.38895988464355, 2) + 3.76326971316535e-6*std::pow(-5.7294397354126*x_22 - 9.58975982666016, 2) + 4.26291176828903e-6*std::pow(-5.72079992294312*x_22 - 8.28072071075439, 2) - 0.000476570368492348*std::pow(-1.62839984893799*x_25 - 3.46207976341248, 2) - 8.93293545427851e-7*std::pow(-6.12911987304688*x_27 - 7.76647996902466, 2) + 1.88627319059926e-5*std::pow(-5.51200008392334*x_4 - 9.19999980926514, 2) + 4.50431918393524e-6*std::pow(-4.11559963226318*x_5 - 6.37784004211426, 2) + 8.4942601263977e-6*std::pow(-3.28671979904175*x_6 - 5.13399982452393, 2) + 3.58757652410267e-5*std::pow(-3.16847991943359*x_6 - 5.34823989868164, 2) - 4.4381238393588e-7*std::pow(-5.31584024429321*x_64 - 8.99736022949219, 2) + 1.17757094059098e-5*std::pow(-7.26232004165649*x_66 - 9.61312007904053, 2) + 3.96436646309629e-6*std::pow(-5.60232019424438*x_66 - 7.61072015762329, 2) + 1.64282253357848e-6*std::pow(-5.68575954437256*x_67 - 8.73624038696289, 2) + 1.10697738269839e-6*std::pow(-5.72591972351074*x_7 - 9.18144035339355, 2) + 1.18624685812008e-5*std::pow(-5.31304025650024*x_7 - 8.78575992584229, 2) + 0.000357923473765398*std::pow(-5.07807970046997*x_7 - 8.11320018768311, 2) + 2.16168218641795e-6*std::pow(-7.10591983795166*x_70 - 9.93296051025391, 2) + 2.2079520742069e-5*std::pow(-5.9539999961853*x_72 - 9.1340799331665, 2) + 4.86140344789717e-5*std::pow(-4.57719993591309*x_8 - 8.7577600479126, 2) - 3.81417227553805e-6*std::pow(-6.33008003234863*x_81 - 8.87975978851318, 2) - 5.82190562927686e-7*std::pow(-4.91448020935059*x_81 - 6.35383987426758, 2) + 3.67410219225573e-5*std::pow(-6.81415987014771*x_85 - 8.80992031097412, 2) + 2.10921244736226e-6*std::pow(-2.30607986450195*x_85 - 3.7727198600769, 2) - 4.64311327128856e-7*std::pow(-5.80800008773804*x_87 - 8.01583957672119, 2) + 5.22579899423034e-7*std::pow(-9.5959997177124*x_88 - 9.99096012115479, 2) + 0.000273042653500969*std::pow(-6.0*x_9 - 9.99997997283936, 2) - 0.000119689204793876*std::exp(0.57999986410141*x_106) - 0.000312554984449864*std::exp(0.612399816513062*x_76) + 6.7243345868126e-5*std::log(0.681119859218597*x_91 + 1.02415990829468) + 0.699401800600541*std::sin(0.299839943647385*x_1 - 7.41623973846436) - 0.00786569846176852*std::sin(0.305919945240021*x_1 + 1.97895979881287) - 0.00210811603889444*std::sin(0.351679861545563*x_1 - 4.35207986831665) + 0.00373176789268245*std::sin(0.212640002369881*x_10 + 5.01351976394653) + 0.142515739989145*std::sin(0.308879911899567*x_10 - 4.25407981872559) + 0.000174763644978337*std::sin(0.41143986582756*x_100 - 0.988239824771881) - 9.87815603618151e-5*std::sin(0.513359844684601*x_100 - 7.22968006134033) - 0.000119712935132018*std::sin(0.303999930620193*x_101 - 4.3010401725769) + 0.0431498196075111*std::sin(0.353999853134155*x_101 + 1.96231985092163) + 0.00422950839951552*std::sin(0.363119840621948*x_102 + 5.16175985336304) - 0.0765741377080948*std::sin(0.371919840574265*x_102 - 7.40231990814209) + 9.94595220758846e-5*std::sin(0.411119878292084*x_102 - 1.00239980220795) + 0.000609424258189452*std::sin(0.388159841299057*x_103 - 7.40567970275879) - 0.00222331241302067*std::sin(0.437279850244522*x_103 + 2.00919985771179) - 0.00115938163907841*std::sin(0.136880040168762*x_104 - 7.68391990661621) + 0.0303130878923113*std::sin(0.332559853792191*x_104 + 5.15224027633667) - 0.00305697845409685*std::sin(0.34215983748436*x_104 - 7.4378399848938) - 0.00193907305927247*std::sin(0.345919847488403*x_105 + 8.34463977813721) - 0.00165705065265341*std::sin(0.364719837903976*x_106 + 1.98247981071472) + 0.00465307832731205*std::sin(0.700959861278534*x_106 - 0.957199811935425) - 0.0341300917654956*std::sin(0.385039836168289*x_107 + 5.18535995483398) + 0.00246098446319988*std::sin(0.296479940414429*x_108 + 5.10391998291016) + 0.0529949384465526*std::sin(0.367439836263657*x_108 - 4.22936010360718) + 1.2302576866411e-5*std::sin(0.85207986831665*x_108 + 8.40624046325684) - 0.0576452538430516*std::sin(0.397519826889038*x_109 + 5.19832038879395) + 0.0112466033430421*std::sin(0.327279835939407*x_11 - 1.06439983844757) - 7.8060353424963e-5*std::sin(0.597919821739197*x_110 - 7.19352006912231) + 0.00886177250815628*std::sin(0.609279870986938*x_110 + 2.20576000213623) + 0.000182306400456966*std::sin(0.816159844398499*x_110 + 5.6101598739624) - 0.0017239725954382*std::sin(0.339759826660156*x_111 - 1.04287981987) - 0.0428573452480491*std::sin(0.368559837341309*x_111 + 5.17408037185669) + 0.000458778104969059*std::sin(0.268239974975586*x_112 + 5.07903957366943) - 0.000138524516202762*std::sin(0.369279861450195*x_112 + 1.9748797416687) + 0.0216761138283539*std::sin(0.438159853219986*x_112 - 1.17311990261078) + 0.0449257560115313*std::sin(0.327199816703796*x_113 + 1.92543983459473) - 0.00161469115869078*std::sin(0.409679859876633*x_114 + 5.21720027923584) - 0.0131099898721633*std::sin(0.469839870929718*x_114 - 0.924239873886108) - 0.0476347105970362*std::sin(0.360399842262268*x_115 + 5.16368007659912) + 0.000131397464596689*std::sin(0.516719877719879*x_115 - 7.04375982284546) + 7.76651850516623e-6*std::sin(1.55183982849121*x_115 + 1.80663990974426) + 0.000332424428300785*std::sin(0.259839832782745*x_116 + 8.09823989868164) + 0.0415103734811521*std::sin(0.288879930973053*x_117 + 8.30072021484375) - 0.00051598370639555*std::sin(0.394879847764969*x_117 - 7.39591979980469) - 0.000876467618334296*std::sin(0.542399823665619*x_117 - 7.43400001525879) + 0.0014063882900089*std::sin(0.239919975399971*x_118 - 1.36119985580444) - 0.00391166898442924*std::sin(0.384399831295013*x_118 - 7.41703987121582) + 0.0173160650637863*std::sin(0.427439838647842*x_118 + 8.43224048614502) - 0.00274015282709401*std::sin(0.353999853134155*x_119 + 5.16960000991821) - 0.000369184948390669*std::sin(0.429279863834381*x_119 + 2.01151990890503) - 0.00476723325799528*std::sin(0.283679932355881*x_12 - 7.49535989761353) + 0.000159408605675764*std::sin(0.342879861593246*x_12 + 2.14535975456238) + 0.0353584107958802*std::sin(0.289919942617416*x_120 - 7.49015998840332) - 0.000310737942311692*std::sin(0.322559833526611*x_120 + 5.33591985702515) - 0.0698302988520017*std::sin(0.142560034990311*x_14 - 4.49032020568848) - 0.221992390728106*std::sin(0.281919956207275*x_15 - 4.2772798538208) + 0.000335176549604717*std::sin(0.510799825191498*x_15 - 0.896399855613708) - 0.0571028146279764*std::sin(0.326799839735031*x_16 - 4.26232004165649) - 0.000644223039373495*std::sin(0.338079839944839*x_16 - 4.24959993362427) + 0.00119538572033687*std::sin(0.37271985411644*x_16 - 4.2260799407959) + 0.00429861841317316*std::sin(0.134800046682358*x_18 + 4.90247964859009) + 0.00241896100967486*std::sin(0.208719998598099*x_18 - 7.57600021362305) + 0.167046138937644*std::sin(0.213279992341995*x_19 + 5.02807998657227) + 0.000578899017950326*std::sin(0.324959844350815*x_21 - 4.26024007797241) - 0.0682544707322329*std::sin(0.330719828605652*x_21 - 4.2402400970459) - 0.00346106285781596*std::sin(0.161600023508072*x_23 + 4.94087982177734) - 0.282246445718747*std::sin(0.158160030841827*x_24 + 4.95127964019775) - 0.00212095761731601*std::sin(0.241919979453087*x_24 - 4.34632015228271) + 0.00184067382957365*std::sin(0.316399842500687*x_26 - 4.28280019760132) - 0.00267143862603355*std::sin(0.321759849786758*x_26 - 4.27472019195557) + 0.107218966104474*std::sin(0.324319839477539*x_26 - 4.26200008392334) - 8.91161431376388e-5*std::sin(0.398319840431213*x_26 - 1.17639982700348) + 0.0112461370253056*std::sin(0.214399993419647*x_27 - 7.57800006866455) + 0.151765269647701*std::sin(0.305119842290878*x_27 - 4.31576013565063) + 0.000424351223508451*std::sin(0.291999936103821*x_28 - 4.28151988983154) + 0.00525180210122443*std::sin(0.320719838142395*x_28 + 8.30399990081787) + 5.36463283428026e-6*std::sin(1.78887987136841*x_29 - 0.204079851508141) - 0.000569645919781549*std::sin(0.293919950723648*x_3 - 1.08967983722687) + 0.00734360575265909*std::sin(0.317679852247238*x_3 + 8.32208061218262) + 0.107598627942367*std::sin(0.343599855899811*x_3 - 1.05495977401733) - 0.00137766750464542*std::sin(0.2880799472332*x_30 - 4.29983997344971) + 0.00292130530941973*std::sin(0.276319950819016*x_32 - 7.44519996643066) + 0.00280414489799129*std::sin(0.251519978046417*x_33 + 2.01743984222412) + 0.0307477765444207*std::sin(0.341839849948883*x_34 + 1.98831987380981) + 0.000122797077366744*std::sin(0.345679849386215*x_34 + 5.20056009292603) + 0.00149437708053055*std::sin(0.355519831180573*x_34 + 1.9975198507309) - 0.0340668135462659*std::sin(0.231999978423119*x_35 - 1.14375984668732) + 0.00152345019590476*std::sin(0.321999847888947*x_35 + 1.98599982261658) - 0.000228399631576738*std::sin(0.323519825935364*x_35 + 5.18839979171753) + 0.00297073541986037*std::sin(0.323599845170975*x_35 + 1.97183978557587) + 0.000195024509974931*std::sin(0.325279831886292*x_36 + 5.12784004211426) - 0.00218889990588298*std::sin(0.343599855899811*x_36 - 7.43511962890625) - 0.00159896890407721*std::sin(0.356639832258224*x_36 + 5.1573600769043) - 0.000578477246032511*std::sin(0.436079859733582*x_37 + 2.03319978713989) + 0.00116573048331676*std::sin(0.3781598508358*x_38 + 5.18815994262695) - 0.000139315909646492*std::sin(0.451279848814011*x_38 + 8.45608043670654) - 0.00070111095484144*std::sin(0.401119858026505*x_39 - 7.40167951583862) - 0.0189251787710841*std::sin(0.409199863672256*x_39 + 1.98799991607666) - 0.00278788421078039*std::sin(0.33095982670784*x_40 - 7.4703197479248) - 0.000324703191037662*std::sin(0.372079849243164*x_42 - 7.41975975036621) - 0.0353203503957764*std::sin(0.386159837245941*x_42 + 1.99703979492188) - 0.000931154904467006*std::sin(0.475279837846756*x_42 + 2.04271984100342) - 0.000394258971330969*std::sin(0.244559973478317*x_43 + 8.25592041015625) + 0.00056976426690774*std::sin(0.446799874305725*x_43 + 2.02879977226257) - 0.0021493450499438*std::sin(0.451839864253998*x_43 + 2.04807996749878) + 0.00291610403780998*std::sin(0.365279853343964*x_44 - 4.22080039978027) + 0.000196210645607516*std::sin(0.370959848165512*x_44 + 8.3645601272583) - 0.00217632588576308*std::sin(0.366239845752716*x_45 - 7.4172797203064) - 8.7279766452983e-5*std::sin(0.380239844322205*x_45 + 5.16648006439209) - 0.00016766044175005*std::sin(0.703439831733704*x_46 + 2.05855989456177) - 0.00187680308459736*std::sin(0.339919835329056*x_47 + 5.1384801864624) - 0.0255591214641543*std::sin(0.462239861488342*x_48 + 5.23808002471924) + 0.000944772501317485*std::sin(0.476239860057831*x_48 - 7.34207963943481) - 0.00286959935592179*std::sin(0.238639980554581*x_49 - 4.35871982574463) - 0.000187333870432003*std::sin(0.326239824295044*x_49 + 8.32384014129639) + 0.0289363800358047*std::sin(0.374799847602844*x_49 - 4.23487997055054) - 0.000257077098652337*std::sin(0.56063985824585*x_49 - 4.21432018280029) - 0.0429067041284195*std::sin(0.27727997303009*x_50 + 5.07631969451904) + 0.00148579399279007*std::sin(0.322959840297699*x_50 + 4.94575977325439) - 0.000203024181225444*std::sin(0.398319840431213*x_50 - 1.00463974475861) + 0.000748816897328147*std::sin(0.274559944868088*x_51 - 4.30599975585938) - 0.0734353137097471*std::sin(0.325199842453003*x_51 - 4.27367973327637) - 0.000105746181804492*std::sin(0.350959837436676*x_51 - 1.05951988697052) + 0.0526061391216411*std::sin(0.226319998502731*x_52 + 8.22552013397217) - 0.000849746150131149*std::sin(0.366159826517105*x_53 - 7.44087982177734) - 3.46104354333424e-5*std::sin(0.683279812335968*x_54 + 8.4498405456543) + 0.0801955511292915*std::sin(0.238079980015755*x_55 - 4.34976005554199) - 0.000154626961434791*std::sin(0.318879842758179*x_55 + 5.11352014541626) + 0.000491310428954031*std::sin(0.322879940271378*x_55 + 8.36727905273438) + 0.00123176572887233*std::sin(0.4129598736763*x_55 - 4.18151998519897) + 0.00201947064424971*std::sin(0.354159832000732*x_56 - 7.45271968841553) + 0.0989530697253013*std::sin(0.304559946060181*x_57 - 4.27871990203857) - 7.02907838766256e-5*std::sin(0.538079857826233*x_57 + 2.13239979743958) + 0.00194545372608854*std::sin(0.313599914312363*x_58 + 5.13840007781982) + 0.00214978681743749*std::sin(0.465279877185822*x_58 + 2.05847978591919) + 0.0298044431719845*std::sin(0.498079836368561*x_58 - 1.10559988021851) + 0.00263570191294637*std::sin(0.369119822978973*x_59 - 7.42424011230469) + 8.91825918010753e-5*std::sin(0.464319854974747*x_6 - 6.90000009536743) + 0.12347612578325*std::sin(0.151360034942627*x_60 + 1.74399983882904) + 6.13009966739388e-5*std::sin(1.47391986846924*x_60 + 3.38039994239807) - 0.00028590409689231*std::sin(0.347919851541519*x_62 + 8.34496021270752) + 0.000886231135375167*std::sin(0.376559853553772*x_62 - 4.21199989318848) - 0.0769340440298626*std::sin(0.271359950304031*x_63 + 5.09839963912964) - 0.000653310988221159*std::sin(0.296799927949905*x_63 - 4.28799962997437) - 0.000552454582758348*std::sin(0.385599851608276*x_63 - 7.40111970901489) + 0.108258747820867*std::sin(0.211040005087852*x_64 + 5.00703954696655) + 0.00563759127743493*std::sin(0.278079956769943*x_64 - 4.28567981719971) - 0.00334347809718696*std::sin(0.521519839763641*x_65 + 8.33312034606934) - 0.00153312021697116*std::sin(0.199440002441406*x_66 + 5.00719976425171) + 0.00509397828769932*std::sin(0.186240002512932*x_67 - 4.4201602935791) + 0.000165732248621251*std::sin(0.296319931745529*x_67 - 7.49088001251221) + 0.000174682911160593*std::sin(0.319439828395844*x_68 - 7.65296030044556) + 0.0842747735871008*std::sin(0.298079937696457*x_69 - 7.49047994613647) + 0.000437669830412671*std::sin(0.418239861726761*x_7 - 7.17655992507935) - 1.20191439238207e-5*std::sin(0.734559834003448*x_70 + 5.98959970474243) + 0.0235807788803088*std::sin(0.271119952201843*x_71 + 5.07599973678589) + 0.000164203652876788*std::sin(0.498719841241837*x_72 + 8.48984050750732) - 0.000248610460391141*std::sin(0.578239858150482*x_72 - 7.01944017410278) - 0.00711525253560992*std::sin(0.275039941072464*x_73 + 5.07879972457886) + 0.000673325905327512*std::sin(0.411759853363037*x_73 + 5.19583988189697) + 0.000124484876051225*std::sin(0.305759936571121*x_75 + 5.14759969711304) - 0.00127256056590463*std::sin(0.391919851303101*x_75 + 8.38992023468018) + 0.0221253891848841*std::sin(0.437039852142334*x_75 + 5.22632026672363) + 0.00144460631912349*std::sin(0.150800034403801*x_76 + 4.92391967773438) - 5.68618349924092e-5*std::sin(1.22431993484497*x_76 - 0.768399834632874) + 0.000125027880256914*std::sin(0.406159847974777*x_77 - 1.00543987751007) + 0.000624251003118676*std::sin(0.468479871749878*x_77 + 5.25504016876221) - 0.00651191854537966*std::sin(0.492559850215912*x_77 - 0.874159812927246) - 0.000214751077551979*std::sin(0.890239894390106*x_77 + 8.64192008972168) - 0.000765589555363592*std::sin(0.407439857721329*x_78 - 4.18200016021729) + 0.0445783183964773*std::sin(0.428879857063293*x_78 - 4.15312004089355) - 2.16756737604629e-5*std::sin(0.752559840679169*x_79 - 1.39367985725403) + 6.83502623534737e-5*std::sin(1.52543985843658*x_8 + 2.39687991142273) + 6.60313547706921e-5*std::sin(0.430959850549698*x_80 - 7.16616010665894) + 0.000425063466093111*std::sin(0.530399858951569*x_80 + 5.34944009780884) + 0.0982843956036341*std::sin(0.207440003752708*x_81 - 7.58808040618896) - 0.000483191811849575*std::sin(0.423119872808456*x_81 - 4.17736005783081) + 0.000161344279840485*std::sin(0.61303985118866*x_82 - 0.966639816761017) - 0.00049645583513274*std::sin(0.997999846935272*x_82 - 4.60471963882446) + 0.000123649027850954*std::sin(0.99999988079071*x_82 - 10.0) + 0.00641275842145413*std::sin(0.32575985789299*x_83 + 5.12007999420166) - 8.15026759427857e-5*std::sin(0.461679875850677*x_83 + 2.05015993118286) - 0.000213348986237623*std::sin(0.637919843196869*x_83 + 2.00751972198486) - 0.000498325416471036*std::sin(0.36303985118866*x_84 + 5.15488004684448) + 0.00703850977963972*std::sin(0.1564000248909*x_85 - 7.65104007720947) - 0.0566648657922825*std::sin(0.155040040612221*x_86 - 1.27311992645264) - 0.000177176283115331*std::sin(0.186640009284019*x_86 + 8.16335964202881) + 0.00603206460062441*std::sin(0.249119967222214*x_86 - 7.53016042709351) - 0.000397469824967511*std::sin(0.489359855651855*x_86 - 4.12224006652832) + 0.00623369274990768*std::sin(0.211119994521141*x_87 + 5.01863956451416) - 0.0112769180030757*std::sin(0.399999856948853*x_87 + 8.40015983581543) + 2.29277857900898e-5*std::sin(0.5136798620224*x_87 + 5.15128040313721) + 0.0277490451022706*std::sin(0.279199928045273*x_88 + 5.0959997177124) - 0.000136290698304879*std::sin(0.531839847564697*x_88 + 2.15471982955933) - 0.0247230918749382*std::sin(0.501599848270416*x_89 + 8.48872089385986) - 8.29678511974973e-5*std::sin(0.53007984161377*x_9 - 4.06080007553101) + 0.000530954917022389*std::sin(0.60999983549118*x_9 + 5.19591999053955) - 0.000496746351108948*std::sin(0.238079980015755*x_90 - 7.55304002761841) + 0.00173526445063054*std::sin(0.196719989180565*x_91 - 7.39048004150391) + 0.0530442337682981*std::sin(0.326319843530655*x_92 - 4.21528005599976) + 0.00130078646335589*std::sin(0.373679846525192*x_92 + 5.19736003875732) + 0.00137558765784614*std::sin(0.375119835138321*x_92 + 1.9987998008728) - 0.0198624348173544*std::sin(0.392959833145142*x_94 + 5.19432020187378) - 0.000678037020069086*std::sin(0.406799852848053*x_94 - 7.39671945571899) - 0.000137287823235603*std::sin(0.45143985748291*x_94 + 2.01095986366272) + 0.00312036138682628*std::sin(0.3643998503685*x_95 - 4.23271989822388) - 0.0310290384146969*std::sin(0.346799850463867*x_96 + 5.1637601852417) + 0.000646655441582537*std::sin(0.422319859266281*x_96 - 1.19247984886169) + 0.00163736840488987*std::sin(0.440079867839813*x_96 - 4.17288017272949) - 0.000416344294344012*std::sin(0.403919845819473*x_97 - 4.20703983306885) - 0.0113032415553381*std::sin(0.437839865684509*x_97 + 5.22304010391235) + 0.00116504050625188*std::sin(0.487279862165451*x_98 + 8.24639987945557) + 6.56295029566623e-5*std::sin(0.600959837436676*x_98 - 7.4047999382019) - 0.000119155056223871*std::sin(0.687439858913422*x_98 + 2.02071976661682) + 0.000169862638030267*std::sin(0.33111983537674*x_99 + 5.1448802947998) - 0.000621636546415397*std::sin(0.446559846401215*x_99 - 7.37319993972778) + 0.00829561751381201*std::sin(0.531919836997986*x_99 - 1.00535976886749) + 0.0185492876917124*std::sin(0.0420627582402736*x_1 + 0.000538845207325977*x_10 - 0.0183998589694163*x_100 - 0.00145462099608847*x_101 - 0.00740370611675223*x_102 + 0.0126091045499567*x_103 - 0.0299733798019528*x_104 + 0.03067649539734*x_106 - 0.00459743947371542*x_107 + 0.0166873794189414*x_109 - 0.0254110253104861*x_11 + 0.043452604523487*x_113 + 0.00521055298695797*x_114 + 0.00866100559348512*x_115 - 0.0197733035998201*x_116 + 0.0413744332818545*x_119 + 0.0590716512756837*x_12 - 0.0861266394764526*x_13 + 0.0262455693681883*x_17 - 0.0166257182937178*x_18 + 0.0164858672245669*x_19 + 0.12092510601181*x_20 + 0.0855294654249444*x_22 - 0.0037477736369068*x_25 - 6.07393815048121e-6*x_27 + 0.00355261863503754*x_28 + 0.0955416780650397*x_29 - 0.0104315693982848*x_3 - 0.0189792160383707*x_30 + 0.00623484725147688*x_31 + 0.030865450734941*x_32 + 0.0132954588345011*x_33 - 0.038004997529599*x_34 + 0.0165381426864658*x_35 - 0.00206117069995156*x_37 + 0.0065468425756987*x_38 + 0.0185306181896234*x_42 - 0.0303962923762315*x_43 + 0.0289640118864071*x_44 + 0.0102075787009658*x_46 - 0.0310225022776645*x_47 + 0.0142238134980909*x_48 - 0.0080536012926176*x_52 - 0.0283059268951104*x_57 + 0.00145584372871838*x_58 - 0.000303449718515882*x_6 + 0.00172463466969753*x_60 - 0.0102277021382365*x_61 - 0.00410997648648863*x_62 + 0.00706309856760994*x_63 - 0.00335778478621098*x_65 + 0.00159057471738638*x_67 - 0.0092718565121161*x_69 - 0.00937999430445509*x_7 + 0.00658253793194867*x_71 + 0.00198716800453053*x_73 - 0.0128414269406821*x_74 + 0.00716235465935386*x_79 - 0.000312362620519449*x_80 - 0.0132434519676018*x_83 - 0.0088429903453618*x_88 + 0.00564437029340692*x_89 + 0.145318346345501*x_91 - 0.0112732799562885*x_94 + 0.00610842299465394*x_95 + 0.00635921063891878*x_96 + 0.0104862826514656*x_97 + 0.00566813479434454*x_98 + 0.000277187174570915*std::pow(-6.25112009048462*x_110 - 8.66423988342285, 2) + 0.00086468830936607*std::pow(-5.72383975982666*x_24 - 8.38159942626953, 2) + 0.00389441176301256*std::pow(-4.58247995376587*x_4 - 7.77960014343262, 2) + 0.000247705101500632*std::pow(-3.95839977264404*x_41 - 9.7038402557373, 2) + 0.00565835606973902*std::pow(-3.50720000267029*x_5 - 5.56712007522583, 2) - 0.000119236325201986*std::pow(-7.74287986755371*x_55 - 9.17280006408691, 2) - 0.011338251326814*std::pow(-1.15495979785919*x_66 - 1.92279982566833, 2) - 0.000162452792441883*std::pow(-5.73503971099854*x_70 - 6.75536012649536, 2) - 0.00101725036992371*std::pow(-3.84744000434875*x_75 - 5.66079998016357, 2) + 6.03041820345773e-5*std::pow(-5.71463966369629*x_78 - 9.38111972808838, 2) + 0.00778062789962702*std::pow(-2.51511979103088*x_8 - 5.22399997711182, 2) - 0.0225023761806797*std::exp(0.719279825687408*x_15) + 0.0453856326005971*std::exp(0.612959861755371*x_2) - 0.012461554967456*std::exp(0.513279855251312*x_76) + 0.272255969746684*std::sin(0.376319825649261*x_105 + 5.18792009353638) - 0.0610970051419524*std::sin(0.708239853382111*x_108 - 4.02719974517822) - 0.140006505611892*std::sin(0.361119836568832*x_111 + 1.97559976577759) + 0.358593162314325*std::sin(0.331439822912216*x_112 - 7.43304014205933) - 0.0211856550803735*std::sin(0.976639807224274*x_117 - 7.98496007919312) - 0.186175062181393*std::sin(0.364959836006165*x_118 + 1.96375977993011) + 0.483670115269845*std::sin(0.169520005583763*x_120 - 7.63551998138428) - 0.59823114643379*std::sin(0.213919997215271*x_14 + 5.01495981216431) - 1.17148276475596*std::sin(0.354879856109619*x_16 + 5.17128038406372) - 0.184646505748862*std::sin(0.295359939336777*x_21 + 8.31112003326416) + 0.599180184880268*std::sin(0.183360010385513*x_23 - 4.41607999801636) - 1.4594559688981*std::sin(0.33095982670784*x_26 - 4.2707200050354) - 0.327193168448314*std::sin(0.36015984416008*x_36 - 4.23160028457642) - 0.144617603222876*std::sin(0.371439844369888*x_39 + 5.17072010040283) + 0.199981963970339*std::sin(0.373999834060669*x_40 - 4.22448015213013) + 0.526290230168875*std::sin(0.270159959793091*x_45 - 7.5237603187561) + 0.124310099816896*std::sin(0.163760021328926*x_49 - 7.27447986602783) + 0.0203022733337099*std::sin(0.917439818382263*x_50 - 4.02711963653564) + 0.498095242928152*std::sin(0.210559993982315*x_51 + 5.01375961303711) - 0.259389976679021*std::sin(0.363839834928513*x_53 - 4.24128007888794) - 0.0865122720066669*std::sin(0.488159865140915*x_54 + 2.25639986991882) - 0.462390559571251*std::sin(0.315759837627411*x_56 + 8.30768013000488) + 0.443340535163141*std::sin(0.337039858102798*x_59 + 5.13671970367432) - 0.301947009800596*std::sin(0.241439983248711*x_64 - 4.3517599105835) - 0.106660527543738*std::sin(0.473519861698151*x_68 + 2.26967978477478) + 0.113517943105221*std::sin(0.402959853410721*x_72 - 7.19704008102417) + 0.145913270535152*std::sin(0.491839855909348*x_77 - 0.899999797344208) + 0.270250219839205*std::sin(0.347279846668243*x_81 - 1.04183983802795) + 0.426113311282741*std::sin(0.386639833450317*x_82 - 4.22040033340454) + 0.0289332125148045*std::sin(0.632639825344086*x_84 + 5.43271970748901) + 0.114545734444169*std::sin(0.5065598487854*x_85 + 8.51416015625) - 0.437317325679754*std::sin(0.301999926567078*x_86 - 7.48448038101196) - 0.388600039135785*std::sin(0.32015985250473*x_87 + 5.12007999420166) + 0.275859149529278*std::sin(0.392159849405289*x_9 - 7.39575958251953) - 0.355342830942931*std::sin(0.406159847974777*x_90 - 4.18832015991211) + 2.36901879260685*std::sin(0.353599846363068*x_92 - 7.40887975692749) - 0.323358811066559*std::sin(0.356559842824936*x_93 + 1.99455988407135) - 0.109077791304193*std::sin(0.511439859867096*x_99 + 5.16400003433228) + 4.70836960973368) + 0.0742391186150108);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00201095146425251*x_1 + 0.002790577737312*x_10 - 0.00204395154480561*x_100 + 0.000358128461225973*x_101 + 0.000329307506411112*x_102 - 0.00116479990397871*x_103 + 0.00142067458933586*x_104 + 0.000401342436195227*x_105 - 0.00145621264951278*x_106 + 0.000518490418891823*x_107 + 0.00118755188656397*x_109 + 0.0100750786177767*x_11 + 3.38992215182254e-5*x_111 + 0.00164051795168789*x_112 - 0.000952581216202149*x_113 - 0.000298557859505326*x_114 - 0.000395340915317402*x_115 + 0.000506577980631644*x_116 + 6.40216482046319e-6*x_117 - 0.00203452445965091*x_119 - 0.0028032183052072*x_12 + 0.000181369821082795*x_120 + 0.00388409437096467*x_13 + 0.000368503486618328*x_14 - 4.66952137099497e-5*x_16 - 0.00134581754948981*x_17 + 0.000794580022233194*x_18 - 0.00114055168172949*x_19 + 0.00857389832097043*x_2 - 0.00588148555258235*x_20 - 0.000752834683946303*x_21 - 0.00376871364714123*x_22 - 0.00305154673760841*x_23 - 4.42021957018336e-5*x_24 - 0.00950433010803381*x_25 + 1.1097651341102e-5*x_27 - 0.00100491157015409*x_28 - 0.0225228446413385*x_29 - 0.000274171137480815*x_3 + 0.00114979336198125*x_30 - 0.00569819175692679*x_31 - 0.00251024232597937*x_32 - 0.00102846648231426*x_33 + 0.00219668411592947*x_34 - 0.000790394589355764*x_35 + 6.55675072873016e-5*x_36 - 1.5621166210517e-5*x_37 - 0.000513968348695235*x_38 - 0.00100071657894537*x_39 + 0.00550776786219913*x_4 + 2.38031440867131e-6*x_40 + 0.000108255870787184*x_41 - 0.000897968548108619*x_42 + 0.00148616074158779*x_43 - 0.00114115513801203*x_44 - 2.79095375799546e-5*x_45 - 0.000468539375625016*x_46 + 0.00135446966771589*x_47 - 0.000751609066394913*x_48 + 0.00474953518897076*x_5 + 0.000147170394650956*x_50 + 0.00169087998178958*x_51 + 0.000984783797046452*x_52 + 0.00069566646191185*x_53 - 0.000417599142762661*x_54 - 0.000176313876213635*x_56 + 0.00320628274433362*x_57 - 5.00245788573394e-5*x_58 - 4.78300190163281e-5*x_59 + 0.000353414986893449*x_6 - 0.000108875017093334*x_60 + 0.00135865922922981*x_61 + 0.0013101521607845*x_62 - 0.00588275438515319*x_63 - 1.17197567967158e-5*x_64 + 4.10280314627638e-5*x_65 + 3.29174170341006e-6*x_66 - 0.000135498364680505*x_67 + 0.000666741304651023*x_68 - 0.000374254551359753*x_69 + 0.000448290771641271*x_7 - 0.000281444677023948*x_70 - 0.000214651774830391*x_71 - 0.0022787812886825*x_72 - 0.000160627969650599*x_73 + 0.00127780813348418*x_74 + 4.48547442453256e-6*x_75 + 6.06571448874758e-5*x_76 - 0.00178920592212741*x_78 + 0.0018752433517229*x_79 + 0.000580971675437077*x_8 - 0.000200730924402508*x_80 - 2.22958376141769e-5*x_82 + 0.000404089349880864*x_83 - 0.000124357214746406*x_84 + 6.85797447117476e-6*x_85 + 0.000905666811616032*x_88 + 0.000467214438930256*x_89 + 0.00495037429972007*x_9 + 0.00418399901493184*x_90 - 0.0122930450152548*x_91 + 0.000367772731078851*x_92 - 0.000509922492102483*x_93 - 0.000269258553790375*x_94 - 0.000403056317041049*x_95 - 0.000293666392992755*x_96 + 0.000450340513303288*x_97 - 0.000962238555053149*x_98 - 0.000293738338587705*x_99 - 1.70607386127054e-5*std::pow(-2.17063999176025*x_108 - 3.15591979026794, 2) - 1.32473910265e-5*std::pow(-6.25112009048462*x_110 - 8.66423988342285, 2) + 9.09629800947187e-7*std::pow(-3.51968002319336*x_110 - 5.79135990142822, 2) - 1.58157475859702e-7*std::pow(-6.72800016403198*x_118 - 8.75936031341553, 2) + 5.77435727793353e-5*std::pow(-5.40447998046875*x_13 - 8.20039939880371, 2) - 1.39750350108818e-6*std::pow(-5.76688003540039*x_14 - 8.3450403213501, 2) - 6.95793700999316e-5*std::pow(-6.59999990463257*x_15 - 9.99973964691162, 2) + 2.1520085697115e-6*std::pow(-5.93840026855469*x_15 - 8.39935970306396, 2) + 6.89321662805457e-6*std::pow(-6.46104001998901*x_17 - 9.48311996459961, 2) + 1.41119155677201e-5*std::pow(-6.29008007049561*x_17 - 9.74312019348145, 2) - 0.00036353465601413*std::pow(-4.0065598487854*x_17 - 6.20688009262085, 2) + 1.51729267811039e-5*std::pow(-4.49232006072998*x_18 - 7.14559984207153, 2) - 0.000230863212495247*std::pow(-3.45199990272522*x_18 - 5.2752799987793, 2) + 1.93433113399441e-6*std::pow(-4.59431982040405*x_19 - 7.38895988464355, 2) + 5.14189671464755e-6*std::pow(-5.7294397354126*x_22 - 9.58975982666016, 2) - 4.5136059698485e-5*std::pow(-5.72079992294312*x_22 - 8.28072071075439, 2) - 4.1325375778831e-5*std::pow(-5.72383975982666*x_24 - 8.38159942626953, 2) - 6.30377104722871e-5*std::pow(-1.62839984893799*x_25 - 3.46207976341248, 2) + 1.1439310123424e-6*std::pow(-6.12911987304688*x_27 - 7.76647996902466, 2) - 0.000199720153656175*std::pow(-5.51200008392334*x_4 - 9.19999980926514, 2) - 0.000186122592153446*std::pow(-4.58247995376587*x_4 - 7.77960014343262, 2) - 1.18383772406404e-5*std::pow(-3.95839977264404*x_41 - 9.7038402557373, 2) + 6.15442043193861e-6*std::pow(-4.11559963226318*x_5 - 6.37784004211426, 2) - 0.000270425410335229*std::pow(-3.50720000267029*x_5 - 5.56712007522583, 2) + 5.698568943382e-6*std::pow(-7.74287986755371*x_55 - 9.17280006408691, 2) + 1.16060265583646e-5*std::pow(-3.28671979904175*x_6 - 5.13399982452393, 2) - 0.000379855547021499*std::pow(-3.16847991943359*x_6 - 5.34823989868164, 2) - 6.06397524710058e-7*std::pow(-5.31584024429321*x_64 - 8.99736022949219, 2) + 1.55761627078048e-6*std::pow(-7.26232004165649*x_66 - 9.61312007904053, 2) - 4.19750375027828e-5*std::pow(-5.60232019424438*x_66 - 7.61072015762329, 2) + 0.000541880226296724*std::pow(-1.15495979785919*x_66 - 1.92279982566833, 2) - 1.73943398268776e-5*std::pow(-5.68575954437256*x_67 - 8.73624038696289, 2) - 1.4175695822629e-6*std::pow(-5.72591972351074*x_7 - 9.18144035339355, 2) - 0.000125600790998164*std::pow(-5.31304025650024*x_7 - 8.78575992584229, 2) + 4.7343850566783e-5*std::pow(-5.07807970046997*x_7 - 8.11320018768311, 2) - 2.28880684186605e-5*std::pow(-7.10591983795166*x_70 - 9.93296051025391, 2) + 7.76397994660422e-6*std::pow(-5.73503971099854*x_70 - 6.75536012649536, 2) + 2.92053918565806e-6*std::pow(-5.9539999961853*x_72 - 9.1340799331665, 2) + 4.86166556699164e-5*std::pow(-3.84744000434875*x_75 - 5.66079998016357, 2) - 2.88207086486571e-6*std::pow(-5.71463966369629*x_78 - 9.38111972808838, 2) + 6.43035663352284e-6*std::pow(-4.57719993591309*x_8 - 8.7577600479126, 2) - 0.000371853497109349*std::pow(-2.51511979103088*x_8 - 5.22399997711182, 2) + 4.03847691171167e-5*std::pow(-6.33008003234863*x_81 - 8.87975978851318, 2) + 7.45539742713664e-7*std::pow(-4.91448020935059*x_81 - 6.35383987426758, 2) + 4.85986971816379e-6*std::pow(-6.81415987014771*x_85 - 8.80992031097412, 2) + 2.88189616482831e-6*std::pow(-2.30607986450195*x_85 - 3.7727198600769, 2) - 6.34406000501461e-7*std::pow(-5.80800008773804*x_87 - 8.01583957672119, 2) + 7.14020538730939e-7*std::pow(-9.5959997177124*x_88 - 9.99096012115479, 2) + 3.61163531682214e-5*std::pow(-6.0*x_9 - 9.99997997283936, 2) + 0.00126727912433639*std::exp(0.57999986410141*x_106) + 0.00107543856151468*std::exp(0.719279825687408*x_15) - 0.00216908023603868*std::exp(0.612959861755371*x_2) + 0.000595565403441415*std::exp(0.513279855251312*x_76) + 0.00330935782957815*std::exp(0.612399816513062*x_76) - 0.000711978065323127*std::log(0.681119859218597*x_91 + 1.02415990829468) + 0.0925124412361803*std::sin(0.299839943647385*x_1 - 7.41623973846436) + 0.0832826609224334*std::sin(0.305919945240021*x_1 + 1.97895979881287) - 0.00288039810077011*std::sin(0.351679861545563*x_1 - 4.35207986831665) - 0.00477881548025566*std::sin(0.212640002369881*x_10 + 5.01351976394653) + 0.0188510796078244*std::sin(0.308879911899567*x_10 - 4.25407981872559) - 0.000223798273640233*std::sin(0.41143986582756*x_100 - 0.988239824771881) - 0.000134968955032711*std::sin(0.513359844684601*x_100 - 7.22968006134033) + 0.000153301610402276*std::sin(0.303999930620193*x_101 - 4.3010401725769) + 0.00570758489235231*std::sin(0.353999853134155*x_101 + 1.96231985092163) - 0.0447823820881937*std::sin(0.363119840621948*x_102 + 5.16175985336304) - 0.0101287420319029*std::sin(0.371919840574265*x_102 - 7.40231990814209) - 0.000127365559012143*std::sin(0.411119878292084*x_102 - 1.00239980220795) + 0.000832679246998522*std::sin(0.388159841299057*x_103 - 7.40567970275879) + 0.0235406143164819*std::sin(0.437279850244522*x_103 + 2.00919985771179) + 0.00148467725852304*std::sin(0.136880040168762*x_104 - 7.68391990661621) + 0.00400962330940052*std::sin(0.332559853792191*x_104 + 5.15224027633667) + 0.0323675387859312*std::sin(0.34215983748436*x_104 - 7.4378399848938) + 0.0205310647088937*std::sin(0.345919847488403*x_105 + 8.34463977813721) - 0.0130117177900327*std::sin(0.376319825649261*x_105 + 5.18792009353638) - 0.00226409052667037*std::sin(0.364719837903976*x_106 + 1.98247981071472) + 0.00061547973561575*std::sin(0.700959861278534*x_106 - 0.957199811935425) - 0.00451451241064821*std::sin(0.385039836168289*x_107 + 5.18535995483398) - 0.0260571054916806*std::sin(0.296479940414429*x_108 + 5.10391998291016) + 0.0070098348683718*std::sin(0.367439836263657*x_108 - 4.22936010360718) + 0.00291996164294554*std::sin(0.708239853382111*x_108 - 4.02719974517822) - 1.57543948249096e-5*std::sin(0.85207986831665*x_108 + 8.40624046325684) - 0.0076249491409958*std::sin(0.397519826889038*x_109 + 5.19832038879395) + 0.0014876294713374*std::sin(0.327279835939407*x_11 - 1.06439983844757) + 9.99622795600231e-5*std::sin(0.597919821739197*x_110 - 7.19352006912231) + 0.00117217915039004*std::sin(0.609279870986938*x_110 + 2.20576000213623) - 0.00193027513157847*std::sin(0.816159844398499*x_110 + 5.6101598739624) + 0.01825356334257*std::sin(0.339759826660156*x_111 - 1.04287981987) + 0.00669122201979833*std::sin(0.361119836568832*x_111 + 1.97559976577759) - 0.00566889823617043*std::sin(0.368559837341309*x_111 + 5.17408037185669) + 0.000626845751299726*std::sin(0.268239974975586*x_112 + 5.07903957366943) - 0.0171379640777416*std::sin(0.331439822912216*x_112 - 7.43304014205933) + 0.000177391285166143*std::sin(0.369279861450195*x_112 + 1.9748797416687) + 0.00286717907367765*std::sin(0.438159853219986*x_112 - 1.17311990261078) + 0.00594249451379601*std::sin(0.327199816703796*x_113 + 1.92543983459473) + 0.0170964825205694*std::sin(0.409679859876633*x_114 + 5.21720027923584) - 0.00173410644155338*std::sin(0.469839870929718*x_114 - 0.924239873886108) - 0.0063008178719684*std::sin(0.360399842262268*x_115 + 5.16368007659912) - 0.00139124714013166*std::sin(0.516719877719879*x_115 - 7.04375982284546) + 1.06116858555891e-5*std::sin(1.55183982849121*x_115 + 1.80663990974426) - 0.000425695018999969*std::sin(0.259839832782745*x_116 + 8.09823989868164) + 0.00549072934051581*std::sin(0.288879930973053*x_117 + 8.30072021484375) - 0.000705007912519603*std::sin(0.394879847764969*x_117 - 7.39591979980469) + 0.00928011108257204*std::sin(0.542399823665619*x_117 - 7.43400001525879) + 0.00101250953416844*std::sin(0.976639807224274*x_117 - 7.98496007919312) + 0.00192160112856567*std::sin(0.239919975399971*x_118 - 1.36119985580444) + 0.00889771993209186*std::sin(0.364959836006165*x_118 + 1.96375977993011) + 0.041417072273296*std::sin(0.384399831295013*x_118 - 7.41703987121582) + 0.00229045943301817*std::sin(0.427439838647842*x_118 + 8.43224048614502) + 0.0290129630424718*std::sin(0.353999853134155*x_119 + 5.16960000991821) - 0.000504431257368106*std::sin(0.429279863834381*x_119 + 2.01151990890503) + 0.0504758570257345*std::sin(0.283679932355881*x_12 - 7.49535989761353) - 0.000204134966159894*std::sin(0.342879861593246*x_12 + 2.14535975456238) - 0.0231156696002639*std::sin(0.169520005583763*x_120 - 7.63551998138428) + 0.00467698667368295*std::sin(0.289919942617416*x_120 - 7.49015998840332) - 0.000424572918358517*std::sin(0.322559833526611*x_120 + 5.33591985702515) + 0.739368935851103*std::sin(0.142560034990311*x_14 - 4.49032020568848) + 0.0285907958523249*std::sin(0.213919997215271*x_14 + 5.01495981216431) - 0.0293637476833473*std::sin(0.281919956207275*x_15 - 4.2772798538208) + 0.00045796430513873*std::sin(0.510799825191498*x_15 - 0.896399855613708) - 0.00755319871661062*std::sin(0.326799839735031*x_16 - 4.26232004165649) - 0.00088022612837617*std::sin(0.338079839944839*x_16 - 4.24959993362427) + 0.0559877645477322*std::sin(0.354879856109619*x_16 + 5.17128038406372) - 0.012656842123077*std::sin(0.37271985411644*x_16 - 4.2260799407959) - 0.00550471112012753*std::sin(0.134800046682358*x_18 + 4.90247964859009) + 0.00330511725614421*std::sin(0.208719998598099*x_18 - 7.57600021362305) + 0.0220958054424941*std::sin(0.213279992341995*x_19 + 5.02807998657227) + 0.00882466682348699*std::sin(0.295359939336777*x_21 + 8.31112003326416) - 0.000741324666496677*std::sin(0.324959844350815*x_21 - 4.26024007797241) - 0.00902826916845287*std::sin(0.330719828605652*x_21 - 4.2402400970459) + 0.00443215688615076*std::sin(0.161600023508072*x_23 + 4.94087982177734) - 0.0286361525085957*std::sin(0.183360010385513*x_23 - 4.41607999801636) - 0.0373337725199676*std::sin(0.158160030841827*x_24 + 4.95127964019775) + 0.0224568733383743*std::sin(0.241919979453087*x_24 - 4.34632015228271) + 0.00251498176809169*std::sin(0.316399842500687*x_26 - 4.28280019760132) + 0.0282854114416459*std::sin(0.321759849786758*x_26 - 4.27472019195557) + 0.0141822458744418*std::sin(0.324319839477539*x_26 - 4.26200008392334) + 0.0697506438957049*std::sin(0.33095982670784*x_26 - 4.2707200050354) + 0.000114120067649949*std::sin(0.398319840431213*x_26 - 1.17639982700348) - 0.119075021896423*std::sin(0.214399993419647*x_27 - 7.57800006866455) + 0.0200745488186053*std::sin(0.305119842290878*x_27 - 4.31576013565063) - 0.000543414342554391*std::sin(0.291999936103821*x_28 - 4.28151988983154) - 0.0556065117108056*std::sin(0.320719838142395*x_28 + 8.30399990081787) + 7.32989927598742e-6*std::sin(1.78887987136841*x_29 - 0.204079851508141) + 0.000729475363420784*std::sin(0.293919950723648*x_3 - 1.08967983722687) + 0.0100338442820523*std::sin(0.317679852247238*x_3 + 8.32208061218262) + 0.0142324651381576*std::sin(0.343599855899811*x_3 - 1.05495977401733) - 0.00188235884109797*std::sin(0.2880799472332*x_30 - 4.29983997344971) + 0.00399148913521622*std::sin(0.276319950819016*x_32 - 7.44519996643066) - 0.029690516341542*std::sin(0.251519978046417*x_33 + 2.01743984222412) + 0.00406712117164476*std::sin(0.341839849948883*x_34 + 1.98831987380981) - 0.000157251091473572*std::sin(0.345679849386215*x_34 + 5.20056009292603) + 0.00204182351691226*std::sin(0.355519831180573*x_34 + 1.9975198507309) - 0.00450614236851652*std::sin(0.231999978423119*x_35 - 1.14375984668732) + 0.00208154720610312*std::sin(0.321999847888947*x_35 + 1.98599982261658) + 0.000292483275072886*std::sin(0.323519825935364*x_35 + 5.18839979171753) - 0.0314543904606872*std::sin(0.323599845170975*x_35 + 1.97183978557587) - 0.000249743867812622*std::sin(0.325279831886292*x_36 + 5.12784004211426) - 0.00299077613155853*std::sin(0.343599855899811*x_36 - 7.43511962890625) + 0.0169300139982528*std::sin(0.356639832258224*x_36 + 5.1573600769043) + 0.0156372885951308*std::sin(0.36015984416008*x_36 - 4.23160028457642) - 0.000790395182271179*std::sin(0.436079859733582*x_37 + 2.03319978713989) - 0.0123428500394338*std::sin(0.3781598508358*x_38 + 5.18815994262695) + 0.000178404725269769*std::sin(0.451279848814011*x_38 + 8.45608043670654) + 0.00691159662121571*std::sin(0.371439844369888*x_39 + 5.17072010040283) - 0.00095795422334222*std::sin(0.401119858026505*x_39 - 7.40167951583862) - 0.00250330280454067*std::sin(0.409199863672256*x_39 + 1.98799991607666) + 0.0295183468506909*std::sin(0.33095982670784*x_40 - 7.4703197479248) - 0.00955758244970579*std::sin(0.373999834060669*x_40 - 4.22448015213013) + 0.00041580738149923*std::sin(0.372079849243164*x_42 - 7.41975975036621) - 0.00467195228497391*std::sin(0.386159837245941*x_42 + 1.99703979492188) + 0.00985914455682686*std::sin(0.475279837846756*x_42 + 2.04271984100342) + 0.000504878901798954*std::sin(0.244559973478317*x_43 + 8.25592041015625) + 0.000778490311732743*std::sin(0.446799874305725*x_43 + 2.02879977226257) + 0.0227574418050515*std::sin(0.451839864253998*x_43 + 2.04807996749878) - 0.0308759489034445*std::sin(0.365279853343964*x_44 - 4.22080039978027) - 0.000251262805615211*std::sin(0.370959848165512*x_44 + 8.3645601272583) - 0.0251525795999269*std::sin(0.270159959793091*x_45 - 7.5237603187561) + 0.023043117109268*std::sin(0.366239845752716*x_45 - 7.4172797203064) + 0.000111768446225309*std::sin(0.380239844322205*x_45 + 5.16648006439209) + 0.00177520251866295*std::sin(0.703439831733704*x_46 + 2.05855989456177) + 0.0198717451059719*std::sin(0.339919835329056*x_47 + 5.1384801864624) - 0.00338079873467678*std::sin(0.462239861488342*x_48 + 5.23808002471924) - 0.0100033287899994*std::sin(0.476239860057831*x_48 - 7.34207963943481) - 0.00594105590695845*std::sin(0.163760021328926*x_49 - 7.27447986602783) + 0.0303835535145513*std::sin(0.238639980554581*x_49 - 4.35871982574463) + 0.000239895413043269*std::sin(0.326239824295044*x_49 + 8.32384014129639) + 0.0038275211121155*std::sin(0.374799847602844*x_49 - 4.23487997055054) - 0.000351254092776607*std::sin(0.56063985824585*x_49 - 4.21432018280029) - 0.00567542711630176*std::sin(0.27727997303009*x_50 + 5.07631969451904) - 0.015731708748253*std::sin(0.322959840297699*x_50 + 4.94575977325439) + 0.00025998806142495*std::sin(0.398319840431213*x_50 - 1.00463974475861) - 0.000970290757481387*std::sin(0.917439818382263*x_50 - 4.02711963653564) - 0.0238050785059703*std::sin(0.210559993982315*x_51 + 5.01375961303711) + 0.00102313664385367*std::sin(0.274559944868088*x_51 - 4.30599975585938) - 0.00971355826993877*std::sin(0.325199842453003*x_51 - 4.27367973327637) + 0.000135416109768281*std::sin(0.350959837436676*x_51 - 1.05951988697052) + 0.0069584069557361*std::sin(0.226319998502731*x_52 + 8.22552013397217) + 0.0123968233910569*std::sin(0.363839834928513*x_53 - 4.24128007888794) + 0.00899718198396382*std::sin(0.366159826517105*x_53 - 7.44087982177734) + 0.0041346137231542*std::sin(0.488159865140915*x_54 + 2.25639986991882) + 4.43213215247308e-5*std::sin(0.683279812335968*x_54 + 8.4498405456543) + 0.0106077596667342*std::sin(0.238079980015755*x_55 - 4.34976005554199) + 0.000198011703358731*std::sin(0.318879842758179*x_55 + 5.11352014541626) + 0.000671295887103963*std::sin(0.322879940271378*x_55 + 8.36727905273438) - 0.0130420366394879*std::sin(0.4129598736763*x_55 - 4.18151998519897) + 0.0220986723468887*std::sin(0.315759837627411*x_56 + 8.30768013000488) - 0.0213823209375919*std::sin(0.354159832000732*x_56 - 7.45271968841553) + 0.0130888854450206*std::sin(0.304559946060181*x_57 - 4.27871990203857) + 9.00127488549319e-5*std::sin(0.538079857826233*x_57 + 2.13239979743958) + 0.00265814647503954*std::sin(0.313599914312363*x_58 + 5.13840007781982) - 0.0227621192755345*std::sin(0.465279877185822*x_58 + 2.05847978591919) + 0.00394234300677773*std::sin(0.498079836368561*x_58 - 1.10559988021851) - 0.021188229348257*std::sin(0.337039858102798*x_59 + 5.13671970367432) - 0.0279070281902425*std::sin(0.369119822978973*x_59 - 7.42424011230469) - 0.000114205160268409*std::sin(0.464319854974747*x_6 - 6.90000009536743) + 0.0163326400086269*std::sin(0.151360034942627*x_60 + 1.74399983882904) - 0.000649059984312567*std::sin(1.47391986846924*x_60 + 3.38039994239807) + 0.000366122160699385*std::sin(0.347919851541519*x_62 + 8.34496021270752) - 0.00938348800238121*std::sin(0.376559853553772*x_62 - 4.21199989318848) - 0.0101763481610471*std::sin(0.271359950304031*x_63 + 5.09839963912964) + 0.000836614911140206*std::sin(0.296799927949905*x_63 - 4.28799962997437) - 0.000754839440324835*std::sin(0.385599851608276*x_63 - 7.40111970901489) + 0.0143197816154903*std::sin(0.211040005087852*x_64 + 5.00703954696655) + 0.0144307185723976*std::sin(0.241439983248711*x_64 - 4.3517599105835) - 0.0596912791737399*std::sin(0.278079956769943*x_64 - 4.28567981719971) - 0.000442254110190842*std::sin(0.521519839763641*x_65 + 8.33312034606934) - 0.00209475971898201*std::sin(0.199440002441406*x_66 + 5.00719976425171) + 0.00696009380629166*std::sin(0.186240002512932*x_67 - 4.4201602935791) - 0.000212232876766489*std::sin(0.296319931745529*x_67 - 7.49088001251221) + 0.000238675820619361*std::sin(0.319439828395844*x_68 - 7.65296030044556) + 0.00509754362788231*std::sin(0.473519861698151*x_68 + 2.26967978477478) + 0.0111473333818624*std::sin(0.298079937696457*x_69 - 7.49047994613647) + 0.000598004723186948*std::sin(0.418239861726761*x_7 - 7.17655992507935) + 1.53914371671407e-5*std::sin(0.734559834003448*x_70 + 5.98959970474243) + 0.00311911610549869*std::sin(0.271119952201843*x_71 + 5.07599973678589) - 0.00542527475582789*std::sin(0.402959853410721*x_72 - 7.19704008102417) - 0.000210275392481088*std::sin(0.498719841241837*x_72 + 8.48984050750732) - 0.000339685807009831*std::sin(0.578239858150482*x_72 - 7.01944017410278) + 0.0753368778603611*std::sin(0.275039941072464*x_73 + 5.07879972457886) + 0.00091999046690133*std::sin(0.411759853363037*x_73 + 5.19583988189697) - 0.000159412447354459*std::sin(0.305759936571121*x_75 + 5.14759969711304) + 0.0134739757223882*std::sin(0.391919851303101*x_75 + 8.38992023468018) + 0.00292660637281269*std::sin(0.437039852142334*x_75 + 5.22632026672363) - 0.00184992937375324*std::sin(0.150800034403801*x_76 + 4.92391967773438) - 7.76924602330393e-5*std::sin(1.22431993484497*x_76 - 0.768399834632874) - 0.00016010780595623*std::sin(0.406159847974777*x_77 - 1.00543987751007) + 0.000852937585318996*std::sin(0.468479871749878*x_77 + 5.25504016876221) - 0.00697351944124711*std::sin(0.491839855909348*x_77 - 0.899999797344208) - 0.000861355348594971*std::sin(0.492559850215912*x_77 - 0.874159812927246) + 0.00227380203568945*std::sin(0.890239894390106*x_77 + 8.64192008972168) - 0.00104605375631751*std::sin(0.407439857721329*x_78 - 4.18200016021729) + 0.00589653766621808*std::sin(0.428879857063293*x_78 - 4.15312004089355) - 2.9616286950358e-5*std::sin(0.752559840679169*x_79 - 1.39367985725403) - 0.000723698187924667*std::sin(1.52543985843658*x_8 + 2.39687991142273) - 8.45582226534496e-5*std::sin(0.430959850549698*x_80 - 7.16616010665894) + 0.000580780174265665*std::sin(0.530399858951569*x_80 + 5.34944009780884) + 0.0130004374665713*std::sin(0.207440003752708*x_81 - 7.58808040618896) - 0.0129158585448606*std::sin(0.347279846668243*x_81 - 1.04183983802795) - 0.000660203115711352*std::sin(0.423119872808456*x_81 - 4.17736005783081) - 0.0203649020373956*std::sin(0.386639833450317*x_82 - 4.22040033340454) + 0.000220450747799621*std::sin(0.61303985118866*x_82 - 0.966639816761017) - 6.56680340751769e-5*std::sin(0.997999846935272*x_82 - 4.60471963882446) - 0.00130920605588333*std::sin(0.99999988079071*x_82 - 10.0) - 0.0678988125196149*std::sin(0.32575985789299*x_83 + 5.12007999420166) + 0.000104370438001083*std::sin(0.461679875850677*x_83 + 2.05015993118286) - 0.000291506730854509*std::sin(0.637919843196869*x_83 + 2.00751972198486) - 0.000680880727951484*std::sin(0.36303985118866*x_84 + 5.15488004684448) - 0.00138278252025827*std::sin(0.632639825344086*x_84 + 5.43271970748901) - 0.0745243192611745*std::sin(0.1564000248909*x_85 - 7.65104007720947) - 0.00547439518783117*std::sin(0.5065598487854*x_85 + 8.51416015625) - 0.00749526961792687*std::sin(0.155040040612221*x_86 - 1.27311992645264) + 0.000226887842125971*std::sin(0.186640009284019*x_86 + 8.16335964202881) - 0.0638679950976744*std::sin(0.249119967222214*x_86 - 7.53016042709351) + 0.0209003667825215*std::sin(0.301999926567078*x_86 - 7.48448038101196) - 0.000543077946292866*std::sin(0.489359855651855*x_86 - 4.12224006652832) - 0.0660028504917369*std::sin(0.211119994521141*x_87 + 5.01863956451416) + 0.0185720594010669*std::sin(0.32015985250473*x_87 + 5.12007999420166) - 0.00149163930259969*std::sin(0.399999856948853*x_87 + 8.40015983581543) - 2.93607911350853e-5*std::sin(0.5136798620224*x_87 + 5.15128040313721) + 0.00367046796588121*std::sin(0.279199928045273*x_88 + 5.0959997177124) + 0.00017453070973448*std::sin(0.531839847564697*x_88 + 2.15471982955933) - 0.00327021403475514*std::sin(0.501599848270416*x_89 + 8.48872089385986) - 0.0131839217586784*std::sin(0.392159849405289*x_9 - 7.39575958251953) + 0.000106246707477069*std::sin(0.53007984161377*x_9 - 4.06080007553101) + 0.000725463639747214*std::sin(0.60999983549118*x_9 + 5.19591999053955) + 0.00063612186521429*std::sin(0.238079980015755*x_90 - 7.55304002761841) + 0.0169826235187521*std::sin(0.406159847974777*x_90 - 4.18832015991211) + 0.00237095697566597*std::sin(0.196719989180565*x_91 - 7.39048004150391) + 0.0070163553413707*std::sin(0.326319843530655*x_92 - 4.21528005599976) - 0.113220672433243*std::sin(0.353599846363068*x_92 - 7.40887975692749) + 0.00177731338760778*std::sin(0.373679846525192*x_92 + 5.19736003875732) - 0.00176154567561771*std::sin(0.375119835138321*x_92 + 1.9987998008728) + 0.0154540361353079*std::sin(0.356559842824936*x_93 + 1.99455988407135) - 0.00262727709918702*std::sin(0.392959833145142*x_94 + 5.19432020187378) - 0.000926427439868557*std::sin(0.406799852848053*x_94 - 7.39671945571899) + 0.000175807604812557*std::sin(0.45143985748291*x_94 + 2.01095986366272) - 0.0330386424800828*std::sin(0.3643998503685*x_95 - 4.23271989822388) - 0.00410432471075999*std::sin(0.346799850463867*x_96 + 5.1637601852417) + 0.000883549610847708*std::sin(0.422319859266281*x_96 - 1.19247984886169) - 0.0173365910646527*std::sin(0.440079867839813*x_96 - 4.17288017272949) - 0.000568866842512085*std::sin(0.403919845819473*x_97 - 4.20703983306885) - 0.00149512121539962*std::sin(0.437839865684509*x_97 + 5.22304010391235) - 0.0123355445056381*std::sin(0.487279862165451*x_98 + 8.24639987945557) - 8.40436205332534e-5*std::sin(0.600959837436676*x_98 - 7.4047999382019) - 0.000162806027425504*std::sin(0.687439858913422*x_98 + 2.02071976661682) - 0.000217522157722573*std::sin(0.33111983537674*x_99 + 5.1448802947998) - 0.000849365354956088*std::sin(0.446559846401215*x_99 - 7.37319993972778) + 0.00521307003453696*std::sin(0.511439859867096*x_99 + 5.16400003433228) + 0.00109729175290283*std::sin(0.531919836997986*x_99 - 1.00535976886749) - 0.890953678378611);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000189369146993126*x_1 + 8.00382227758825e-5*x_10 - 0.000178240928349817*x_100 - 6.92111847035231e-5*x_101 - 3.78628737249225e-5*x_102 - 0.0053200000986399*x_103 - 0.000198032799420604*x_104 - 0.00146843514215352*x_105 + 0.0016218050418029*x_106 - 0.000662133636624123*x_107 - 0.000346008228768277*x_109 + 0.00129906915700684*x_11 - 0.000640415062470578*x_111 + 8.57680763999214e-6*x_112 - 0.000580653536289433*x_113 + 0.00356463662016916*x_114 + 0.00271580419675036*x_115 - 0.000140666688149287*x_116 + 0.000915089673709794*x_117 + 0.00242623710998698*x_119 + 0.000323590204019574*x_12 - 0.00439155075757856*x_120 - 0.00373484385037237*x_13 - 8.99482188918727e-5*x_14 - 0.00667435298464488*x_16 - 0.0128974393474841*x_17 - 0.000113198404939354*x_18 - 0.000844755324267825*x_19 + 0.000144288149706951*x_2 + 0.00904100075376305*x_20 - 6.47940271817335e-6*x_21 + 0.00286521854349197*x_22 - 4.76393071723194e-5*x_23 + 0.00042946854254692*x_24 + 2.44116540991814e-5*x_25 - 5.56848093476081e-6*x_27 + 0.000194475621486048*x_28 + 0.000592746478161398*x_29 - 7.50645815407096e-5*x_3 - 0.00337685833613186*x_30 - 0.0135019640681405*x_31 + 0.00176171576485065*x_32 - 0.00501373189960154*x_33 - 0.00025677359557627*x_34 + 0.000112602134818725*x_35 - 1.38639144695043e-5*x_36 - 0.00244466388909378*x_37 + 0.000122774359160092*x_38 - 8.53522131352767e-5*x_39 + 0.00507434803430114*x_4 + 0.0007217902901162*x_40 + 0.000726494508281238*x_41 + 0.000132483785425378*x_42 - 0.000214030940880952*x_43 + 0.000159115881161751*x_44 - 1.23723474230315e-5*x_45 + 0.00329785829434734*x_46 - 0.00169400631229079*x_47 - 0.0016523800937863*x_48 - 0.000353045625728483*x_5 - 7.52662025902755e-5*x_50 + 8.84010585266772e-6*x_51 - 0.00449943351076184*x_52 + 0.000479400104284842*x_53 + 7.4932900244193e-5*x_54 - 0.00127962112251921*x_56 - 0.000181854224715112*x_57 + 0.00280477007543876*x_58 + 0.00100277059929665*x_59 - 7.3727383955636e-5*x_6 + 0.000825249039348041*x_60 + 0.00246282235283215*x_61 - 0.000307987393174878*x_62 + 1.9099164235502e-5*x_63 - 0.00167515656403999*x_64 - 0.00703129035800269*x_65 + 0.000470503169753212*x_66 + 2.34066481295509e-5*x_67 + 0.00123858676431722*x_68 + 4.69799136137224e-5*x_69 - 6.3864933523248e-5*x_7 + 4.30426441229599e-5*x_70 - 9.18426390891316e-5*x_71 - 1.19137183147153e-5*x_72 - 0.000402145280664605*x_73 - 0.00201423959287266*x_74 - 2.29397106361685e-6*x_75 - 1.28256434242569e-5*x_76 + 0.00255056909669592*x_78 - 0.00251134158620829*x_79 + 0.00721047898507156*x_8 - 3.87414335497341e-5*x_80 - 0.00318684247275715*x_82 - 4.17817647731009e-5*x_83 + 0.0022306543161149*x_84 + 0.000980240558799512*x_85 - 5.76832814772343e-5*x_88 + 0.00234937839042986*x_89 + 2.58810993631465e-5*x_9 - 0.000203068056432615*x_90 + 0.00331816701724848*x_91 + 1.92275614323663e-6*x_92 + 0.00326906331070841*x_93 - 8.0980108130656e-5*x_94 + 0.00189497383705257*x_95 + 0.00150900626634474*x_96 - 0.000493251298897351*x_97 + 0.000184773783691009*x_98 - 1.53569622567405e-6*x_99 + 8.72523996289544e-6*std::pow(-2.17063999176025*x_108 - 3.15591979026794, 2) + 1.88726558917637e-6*std::pow(-6.25112009048462*x_110 - 8.66423988342285, 2) - 4.65204846685502e-7*std::pow(-3.51968002319336*x_110 - 5.79135990142822, 2) - 2.26061460518207e-5*std::pow(-6.72800016403198*x_118 - 8.75936031341553, 2) + 3.01889726756533e-7*std::pow(-5.40447998046875*x_13 - 8.20039939880371, 2) - 0.000199751343284936*std::pow(-5.76688003540039*x_14 - 8.3450403213501, 2) - 3.6376857226398e-7*std::pow(-6.59999990463257*x_15 - 9.99973964691162, 2) + 0.000307596082747445*std::pow(-5.93840026855469*x_15 - 8.39935970306396, 2) - 3.52534380611202e-6*std::pow(-6.46104001998901*x_17 - 9.48311996459961, 2) - 2.98389245719623e-6*std::pow(-6.29008007049561*x_17 - 9.74312019348145, 2) - 1.90059902233676e-6*std::pow(-4.0065598487854*x_17 - 6.20688009262085, 2) - 3.20823785817484e-6*std::pow(-4.49232006072998*x_18 - 7.14559984207153, 2) - 1.20697817581643e-6*std::pow(-3.45199990272522*x_18 - 5.2752799987793, 2) - 9.89259826021366e-7*std::pow(-4.59431982040405*x_19 - 7.38895988464355, 2) - 2.62967997565548e-6*std::pow(-5.7294397354126*x_22 - 9.58975982666016, 2) - 2.3597626668017e-7*std::pow(-5.72079992294312*x_22 - 8.28072071075439, 2) + 5.88734487501395e-6*std::pow(-5.72383975982666*x_24 - 8.38159942626953, 2) + 1.33290018562353e-5*std::pow(-1.62839984893799*x_25 - 3.46207976341248, 2) + 0.000163507108327646*std::pow(-6.12911987304688*x_27 - 7.76647996902466, 2) - 1.04415885115811e-6*std::pow(-5.51200008392334*x_4 - 9.19999980926514, 2) + 2.65156182705593e-5*std::pow(-4.58247995376587*x_4 - 7.77960014343262, 2) + 1.68653299002469e-6*std::pow(-3.95839977264404*x_41 - 9.7038402557373, 2) - 3.14750705231606e-6*std::pow(-4.11559963226318*x_5 - 6.37784004211426, 2) + 3.85256667024962e-5*std::pow(-3.50720000267029*x_5 - 5.56712007522583, 2) - 8.11836311986289e-7*std::pow(-7.74287986755371*x_55 - 9.17280006408691, 2) - 5.93557928740873e-6*std::pow(-3.28671979904175*x_6 - 5.13399982452393, 2) - 1.98592642917156e-6*std::pow(-3.16847991943359*x_6 - 5.34823989868164, 2) + 3.10125137962129e-7*std::pow(-5.31584024429321*x_64 - 8.99736022949219, 2) - 3.29350003497708e-7*std::pow(-7.26232004165649*x_66 - 9.61312007904053, 2) - 2.19450096216512e-7*std::pow(-5.60232019424438*x_66 - 7.61072015762329, 2) - 7.71979858146534e-5*std::pow(-1.15495979785919*x_66 - 1.92279982566833, 2) - 9.09395149052083e-8*std::pow(-5.68575954437256*x_67 - 8.73624038696289, 2) - 0.000202619476828783*std::pow(-5.72591972351074*x_7 - 9.18144035339355, 2) - 6.56654700251069e-7*std::pow(-5.31304025650024*x_7 - 8.78575992584229, 2) - 1.00106153500515e-5*std::pow(-5.07807970046997*x_7 - 8.11320018768311, 2) - 1.19661330054849e-7*std::pow(-7.10591983795166*x_70 - 9.93296051025391, 2) - 1.10608135284679e-6*std::pow(-5.73503971099854*x_70 - 6.75536012649536, 2) - 6.17533091465272e-7*std::pow(-5.9539999961853*x_72 - 9.1340799331665, 2) - 6.92608386988264e-6*std::pow(-3.84744000434875*x_75 - 5.66079998016357, 2) + 4.10589010164208e-7*std::pow(-5.71463966369629*x_78 - 9.38111972808838, 2) - 1.35966606119303e-6*std::pow(-4.57719993591309*x_8 - 8.7577600479126, 2) + 5.29754355333455e-5*std::pow(-2.51511979103088*x_8 - 5.22399997711182, 2) + 2.11135998814661e-7*std::pow(-6.33008003234863*x_81 - 8.87975978851318, 2) + 0.000106563285861824*std::pow(-4.91448020935059*x_81 - 6.35383987426758, 2) - 1.02759462564784e-6*std::pow(-6.81415987014771*x_85 - 8.80992031097412, 2) - 1.47386559029449e-6*std::pow(-2.30607986450195*x_85 - 3.7727198600769, 2) + 3.24449293429405e-7*std::pow(-5.80800008773804*x_87 - 8.01583957672119, 2) - 3.65165933333259e-7*std::pow(-9.5959997177124*x_88 - 9.99096012115479, 2) - 7.63661837990303e-6*std::pow(-6.0*x_9 - 9.99997997283936, 2) + 6.62547414639856e-6*std::exp(0.57999986410141*x_106) - 0.000153210408476651*std::exp(0.719279825687408*x_15) + 0.000309014090506538*std::exp(0.612959861755371*x_2) - 8.48461474240856e-5*std::exp(0.513279855251312*x_76) + 1.73016854140428e-5*std::exp(0.612399816513062*x_76) - 3.72229935301066e-6*std::log(0.681119859218597*x_91 + 1.02415990829468) - 0.0195612831069429*std::sin(0.299839943647385*x_1 - 7.41623973846436) + 0.000435410878462789*std::sin(0.305919945240021*x_1 + 1.97895979881287) + 0.00147309944712307*std::sin(0.351679861545563*x_1 - 4.35207986831665) - 0.6830571878701*std::sin(0.212640002369881*x_10 + 5.01351976394653) - 0.00398596448383375*std::sin(0.308879911899567*x_10 - 4.25407981872559) - 0.0319884749839101*std::sin(0.41143986582756*x_100 - 0.988239824771881) + 6.90261158637436e-5*std::sin(0.513359844684601*x_100 - 7.22968006134033) + 0.0219120757706541*std::sin(0.303999930620193*x_101 - 4.3010401725769) - 0.00120683966874447*std::sin(0.353999853134155*x_101 + 1.96231985092163) - 0.00023412720137313*std::sin(0.363119840621948*x_102 + 5.16175985336304) + 0.00214167076077287*std::sin(0.371919840574265*x_102 - 7.40231990814209) - 0.018204921476835*std::sin(0.411119878292084*x_102 - 1.00239980220795) - 0.000425850627403353*std::sin(0.388159841299057*x_103 - 7.40567970275879) + 0.000123072911522837*std::sin(0.437279850244522*x_103 + 2.00919985771179) + 0.212211473176023*std::sin(0.136880040168762*x_104 - 7.68391990661621) - 0.000847814365930997*std::sin(0.332559853792191*x_104 + 5.15224027633667) + 0.000169221040014399*std::sin(0.34215983748436*x_104 - 7.4378399848938) + 0.00010733865635011*std::sin(0.345919847488403*x_105 + 8.34463977813721) + 0.00185369082803398*std::sin(0.376319825649261*x_105 + 5.18792009353638) + 0.00115790609019739*std::sin(0.364719837903976*x_106 + 1.98247981071472) - 0.000130140045966678*std::sin(0.700959861278534*x_106 - 0.957199811935425) + 0.000954570587204008*std::sin(0.385039836168289*x_107 + 5.18535995483398) - 0.000136229403175495*std::sin(0.296479940414429*x_108 + 5.10391998291016) - 0.00148219377373337*std::sin(0.367439836263657*x_108 - 4.22936010360718) - 0.000415987051293525*std::sin(0.708239853382111*x_108 - 4.02719974517822) - 0.00225184518426359*std::sin(0.85207986831665*x_108 + 8.40624046325684) + 0.00161225654441738*std::sin(0.397519826889038*x_109 + 5.19832038879395) - 0.000314551652277468*std::sin(0.327279835939407*x_11 - 1.06439983844757) + 0.0142880498005127*std::sin(0.597919821739197*x_110 - 7.19352006912231) - 0.000247851293366022*std::sin(0.609279870986938*x_110 + 2.20576000213623) - 1.00916899316922e-5*std::sin(0.816159844398499*x_110 + 5.6101598739624) + 9.54316296097559e-5*std::sin(0.339759826660156*x_111 - 1.04287981987) - 0.000953252836142861*std::sin(0.361119836568832*x_111 + 1.97559976577759) + 0.00119865957292251*std::sin(0.368559837341309*x_111 + 5.17408037185669) - 0.000320582814377008*std::sin(0.268239974975586*x_112 + 5.07903957366943) + 0.00244152903826587*std::sin(0.331439822912216*x_112 - 7.43304014205933) + 0.0253553193043072*std::sin(0.369279861450195*x_112 + 1.9748797416687) - 0.000606250368372903*std::sin(0.438159853219986*x_112 - 1.17311990261078) - 0.00125651010818162*std::sin(0.327199816703796*x_113 + 1.92543983459473) + 8.93822842648834e-5*std::sin(0.409679859876633*x_114 + 5.21720027923584) + 0.00036666794852164*std::sin(0.469839870929718*x_114 - 0.924239873886108) + 0.0013322757518008*std::sin(0.360399842262268*x_115 + 5.16368007659912) - 7.27359251894892e-6*std::sin(0.516719877719879*x_115 - 7.04375982284546) - 5.42705140748864e-6*std::sin(1.55183982849121*x_115 + 1.80663990974426) - 0.0608464678684082*std::sin(0.259839832782745*x_116 + 8.09823989868164) - 0.00116098667009798*std::sin(0.288879930973053*x_117 + 8.30072021484375) + 0.000360556676478973*std::sin(0.394879847764969*x_117 - 7.39591979980469) + 4.851743777085e-5*std::sin(0.542399823665619*x_117 - 7.43400001525879) - 0.00014424533847658*std::sin(0.976639807224274*x_117 - 7.98496007919312) - 0.000982749419021047*std::sin(0.239919975399971*x_118 - 1.36119985580444) - 0.00126759756818338*std::sin(0.364959836006165*x_118 + 1.96375977993011) + 0.000216532992847915*std::sin(0.384399831295013*x_118 - 7.41703987121582) - 0.000484305946481866*std::sin(0.427439838647842*x_118 + 8.43224048614502) + 0.000151682950391038*std::sin(0.353999853134155*x_119 + 5.16960000991821) + 0.000257977328252606*std::sin(0.429279863834381*x_119 + 2.01151990890503) + 0.000263893312309108*std::sin(0.283679932355881*x_12 - 7.49535989761353) - 0.0291779116618405*std::sin(0.342879861593246*x_12 + 2.14535975456238) + 0.00329313203785413*std::sin(0.169520005583763*x_120 - 7.63551998138428) - 0.000988924940135855*std::sin(0.289919942617416*x_120 - 7.49015998840332) + 0.000217136003224742*std::sin(0.322559833526611*x_120 + 5.33591985702515) + 0.00386550182596664*std::sin(0.142560034990311*x_14 - 4.49032020568848) - 0.00407313599117904*std::sin(0.213919997215271*x_14 + 5.01495981216431) + 0.0062088144452744*std::sin(0.281919956207275*x_15 - 4.2772798538208) - 0.000234213098710763*std::sin(0.510799825191498*x_15 - 0.896399855613708) + 0.00159708528371247*std::sin(0.326799839735031*x_16 - 4.26232004165649) + 0.000450167156653637*std::sin(0.338079839944839*x_16 - 4.24959993362427) - 0.00797619555688171*std::sin(0.354879856109619*x_16 + 5.17128038406372) - 6.61713577152211e-5*std::sin(0.37271985411644*x_16 - 4.2260799407959) - 0.7868126554136*std::sin(0.134800046682358*x_18 + 4.90247964859009) - 0.00169031023919966*std::sin(0.208719998598099*x_18 - 7.57600021362305) - 0.00467204518615082*std::sin(0.213279992341995*x_19 + 5.02807998657227) - 0.00125719018926805*std::sin(0.295359939336777*x_21 + 8.31112003326416) - 0.105960806414913*std::sin(0.324959844350815*x_21 - 4.26024007797241) + 0.00190898139547444*std::sin(0.330719828605652*x_21 - 4.2402400970459) + 0.633507745038792*std::sin(0.161600023508072*x_23 + 4.94087982177734) + 0.00407959764513405*std::sin(0.183360010385513*x_23 - 4.41607999801636) + 0.00789403548273983*std::sin(0.158160030841827*x_24 + 4.95127964019775) + 0.000117406994919339*std::sin(0.241919979453087*x_24 - 4.34632015228271) - 0.00128621743331588*std::sin(0.316399842500687*x_26 - 4.28280019760132) + 0.000147879230887675*std::sin(0.321759849786758*x_26 - 4.27472019195557) - 0.00299876344127575*std::sin(0.324319839477539*x_26 - 4.26200008392334) - 0.00993689925691263*std::sin(0.33095982670784*x_26 - 4.2707200050354) + 0.0163116849375296*std::sin(0.398319840431213*x_26 - 1.17639982700348) - 0.000622537264211403*std::sin(0.214399993419647*x_27 - 7.57800006866455) - 0.00424466079845822*std::sin(0.305119842290878*x_27 - 4.31576013565063) - 0.0776726103376612*std::sin(0.291999936103821*x_28 - 4.28151988983154) - 0.000290716937284259*std::sin(0.320719838142395*x_28 + 8.30399990081787) - 3.74867299351363e-6*std::sin(1.78887987136841*x_29 - 0.204079851508141) + 0.104267133229438*std::sin(0.293919950723648*x_3 - 1.08967983722687) - 0.00513153041604157*std::sin(0.317679852247238*x_3 + 8.32208061218262) - 0.00300938204804734*std::sin(0.343599855899811*x_3 - 1.05495977401733) + 0.000962680043209051*std::sin(0.2880799472332*x_30 - 4.29983997344971) - 0.0020413360350129*std::sin(0.276319950819016*x_32 - 7.44519996643066) - 0.00015522527329338*std::sin(0.251519978046417*x_33 + 2.01743984222412) - 0.000859971995179285*std::sin(0.341839849948883*x_34 + 1.98831987380981) - 0.0224765925311884*std::sin(0.345679849386215*x_34 + 5.20056009292603) - 0.00104423381375031*std::sin(0.355519831180573*x_34 + 1.9975198507309) + 0.000952800784552956*std::sin(0.231999978423119*x_35 - 1.14375984668732) - 0.00106454938907621*std::sin(0.321999847888947*x_35 + 1.98599982261658) + 0.0418059253795742*std::sin(0.323519825935364*x_35 + 5.18839979171753) - 0.000164447000495757*std::sin(0.323599845170975*x_35 + 1.97183978557587) - 0.0356969932697141*std::sin(0.325279831886292*x_36 + 5.12784004211426) + 0.00152954921914781*std::sin(0.343599855899811*x_36 - 7.43511962890625) + 8.85119685865004e-5*std::sin(0.356639832258224*x_36 + 5.1573600769043) - 0.00222773802136401*std::sin(0.36015984416008*x_36 - 4.23160028457642) + 0.000404225619264613*std::sin(0.436079859733582*x_37 + 2.03319978713989) - 6.45297726907369e-5*std::sin(0.3781598508358*x_38 + 5.18815994262695) + 0.025500174771131*std::sin(0.451279848814011*x_38 + 8.45608043670654) - 0.000984648104928353*std::sin(0.371439844369888*x_39 + 5.17072010040283) + 0.000489919027650151*std::sin(0.401119858026505*x_39 - 7.40167951583862) + 0.000529310590096866*std::sin(0.409199863672256*x_39 + 1.98799991607666) + 0.000154325152326714*std::sin(0.33095982670784*x_40 - 7.4703197479248) + 0.00136160368762145*std::sin(0.373999834060669*x_40 - 4.22448015213013) + 0.0594331842013911*std::sin(0.372079849243164*x_42 - 7.41975975036621) + 0.000987860444361101*std::sin(0.386159837245941*x_42 + 1.99703979492188) + 5.1544688232017e-5*std::sin(0.475279837846756*x_42 + 2.04271984100342) + 0.0721645697145201*std::sin(0.244559973478317*x_43 + 8.25592041015625) - 0.000398137204540428*std::sin(0.446799874305725*x_43 + 2.02879977226257) + 0.000118978399803196*std::sin(0.451839864253998*x_43 + 2.04807996749878) - 0.0001614228446416*std::sin(0.365279853343964*x_44 - 4.22080039978027) - 0.0359141017536621*std::sin(0.370959848165512*x_44 + 8.3645601272583) + 0.00358331673481999*std::sin(0.270159959793091*x_45 - 7.5237603187561) + 0.000120471941601529*std::sin(0.366239845752716*x_45 - 7.4172797203064) + 0.015975557308437*std::sin(0.380239844322205*x_45 + 5.16648006439209) + 9.2809533165647e-6*std::sin(0.703439831733704*x_46 + 2.05855989456177) + 0.000103891661209509*std::sin(0.339919835329056*x_47 + 5.1384801864624) + 0.000714852621905984*std::sin(0.462239861488342*x_48 + 5.23808002471924) - 5.2298499204563e-5*std::sin(0.476239860057831*x_48 - 7.34207963943481) + 0.000846381778430681*std::sin(0.163760021328926*x_49 - 7.27447986602783) + 0.000158848547585593*std::sin(0.238639980554581*x_49 - 4.35871982574463) + 0.0342893101634266*std::sin(0.326239824295044*x_49 + 8.32384014129639) - 0.000809309786569671*std::sin(0.374799847602844*x_49 - 4.23487997055054) + 0.000179639130344723*std::sin(0.56063985824585*x_49 - 4.21432018280029) + 0.00120004007127402*std::sin(0.27727997303009*x_50 + 5.07631969451904) - 8.22470974141569e-5*std::sin(0.322959840297699*x_50 + 4.94575977325439) + 0.0371612410754191*std::sin(0.398319840431213*x_50 - 1.00463974475861) + 0.000138230716857937*std::sin(0.917439818382263*x_50 - 4.02711963653564) + 0.00339134743000256*std::sin(0.210559993982315*x_51 + 5.01375961303711) - 0.000523254762593142*std::sin(0.274559944868088*x_51 - 4.30599975585938) + 0.00205388227523877*std::sin(0.325199842453003*x_51 - 4.27367973327637) + 0.0193556222274735*std::sin(0.350959837436676*x_51 - 1.05951988697052) - 0.00147131960432195*std::sin(0.226319998502731*x_52 + 8.22552013397217) - 0.00176609101024021*std::sin(0.363839834928513*x_53 - 4.24128007888794) + 4.7038253436401e-5*std::sin(0.366159826517105*x_53 - 7.44087982177734) - 0.000589030261780302*std::sin(0.488159865140915*x_54 + 2.25639986991882) + 0.00633504209745079*std::sin(0.683279812335968*x_54 + 8.4498405456543) - 0.00224295659263445*std::sin(0.238079980015755*x_55 - 4.34976005554199) + 0.0283026866846818*std::sin(0.318879842758179*x_55 + 5.11352014541626) - 0.00034331559928624*std::sin(0.322879940271378*x_55 + 8.36727905273438) - 6.81851968614715e-5*std::sin(0.4129598736763*x_55 - 4.18151998519897) - 0.00314824736458205*std::sin(0.315759837627411*x_56 + 8.30768013000488) - 0.000111789117205096*std::sin(0.354159832000732*x_56 - 7.45271968841553) - 0.00276757796381942*std::sin(0.304559946060181*x_57 - 4.27871990203857) + 0.0128659194646323*std::sin(0.538079857826233*x_57 + 2.13239979743958) - 0.00135943503840874*std::sin(0.313599914312363*x_58 + 5.13840007781982) - 0.000119002854131497*std::sin(0.465279877185822*x_58 + 2.05847978591919) - 0.000833588289637482*std::sin(0.498079836368561*x_58 - 1.10559988021851) + 0.0030185427503839*std::sin(0.337039858102798*x_59 + 5.13671970367432) - 0.000145901001781348*std::sin(0.369119822978973*x_59 - 7.42424011230469) - 0.0163238476010419*std::sin(0.464319854974747*x_6 - 6.90000009536743) - 0.00345345329583181*std::sin(0.151360034942627*x_60 + 1.74399983882904) - 3.39335673013366e-6*std::sin(1.47391986846924*x_60 + 3.38039994239807) + 0.0523314563070067*std::sin(0.347919851541519*x_62 + 8.34496021270752) - 4.90579036369539e-5*std::sin(0.376559853553772*x_62 - 4.21199989318848) + 0.00215173683358828*std::sin(0.271359950304031*x_63 + 5.09839963912964) + 0.11958106164481*std::sin(0.296799927949905*x_63 - 4.28799962997437) + 0.000386041624562906*std::sin(0.385599851608276*x_63 - 7.40111970901489) - 0.00302784467113007*std::sin(0.211040005087852*x_64 + 5.00703954696655) - 0.00205584620656961*std::sin(0.241439983248711*x_64 - 4.3517599105835) - 0.000312072549240617*std::sin(0.278079956769943*x_64 - 4.28567981719971) + 9.35123723799094e-5*std::sin(0.521519839763641*x_65 + 8.33312034606934) + 0.00107130656108371*std::sin(0.199440002441406*x_66 + 5.00719976425171) - 0.00355954627772866*std::sin(0.186240002512932*x_67 - 4.4201602935791) - 0.0303353817649272*std::sin(0.296319931745529*x_67 - 7.49088001251221) - 0.000122064106104647*std::sin(0.319439828395844*x_68 - 7.65296030044556) - 0.000726212328071464*std::sin(0.473519861698151*x_68 + 2.26967978477478) - 0.0023570466983289*std::sin(0.298079937696457*x_69 - 7.49047994613647) - 0.000305832873194907*std::sin(0.418239861726761*x_7 - 7.17655992507935) + 0.00219996604432696*std::sin(0.734559834003448*x_70 + 5.98959970474243) - 0.000659521166751173*std::sin(0.271119952201843*x_71 + 5.07599973678589) + 0.000772901950128846*std::sin(0.402959853410721*x_72 - 7.19704008102417) - 0.0300555898966681*std::sin(0.498719841241837*x_72 + 8.48984050750732) + 0.000173722852534846*std::sin(0.578239858150482*x_72 - 7.01944017410278) + 0.000393869453815541*std::sin(0.275039941072464*x_73 + 5.07879972457886) - 0.000470503520950283*std::sin(0.411759853363037*x_73 + 5.19583988189697) - 0.0227855246663765*std::sin(0.305759936571121*x_75 + 5.14759969711304) + 7.04434217241855e-5*std::sin(0.391919851303101*x_75 + 8.38992023468018) - 0.000618815967195376*std::sin(0.437039852142334*x_75 + 5.22632026672363) - 0.264418570044178*std::sin(0.150800034403801*x_76 + 4.92391967773438) + 3.97336466040309e-5*std::sin(1.22431993484497*x_76 - 0.768399834632874) - 0.0228849153402892*std::sin(0.406159847974777*x_77 - 1.00543987751007) - 0.000436211190747546*std::sin(0.468479871749878*x_77 + 5.25504016876221) + 0.00099346982742422*std::sin(0.491839855909348*x_77 - 0.899999797344208) + 0.000182129188295122*std::sin(0.492559850215912*x_77 - 0.874159812927246) + 1.18876862343785e-5*std::sin(0.890239894390106*x_77 + 8.64192008972168) + 0.00053497508197924*std::sin(0.407439857721329*x_78 - 4.18200016021729) - 0.00124679276752817*std::sin(0.428879857063293*x_78 - 4.15312004089355) + 1.51464257391178e-5*std::sin(0.752559840679169*x_79 - 1.39367985725403) - 3.78357343840979e-6*std::sin(1.52543985843658*x_8 + 2.39687991142273) - 0.0120862799611315*std::sin(0.430959850549698*x_80 - 7.16616010665894) - 0.000297023857008533*std::sin(0.530399858951569*x_80 + 5.34944009780884) - 0.00274887609060579*std::sin(0.207440003752708*x_81 - 7.58808040618896) + 0.00184003441414421*std::sin(0.347279846668243*x_81 - 1.04183983802795) + 0.000337642510069459*std::sin(0.423119872808456*x_81 - 4.17736005783081) + 0.00290124891499326*std::sin(0.386639833450317*x_82 - 4.22040033340454) - 0.000112743399814999*std::sin(0.61303985118866*x_82 - 0.966639816761017) + 1.38851703452675e-5*std::sin(0.997999846935272*x_82 - 4.60471963882446) - 6.84467273940591e-6*std::sin(0.99999988079071*x_82 - 10.0) - 0.000354982433057471*std::sin(0.32575985789299*x_83 + 5.12007999420166) + 0.0149181273418777*std::sin(0.461679875850677*x_83 + 2.05015993118286) + 0.000149083004859509*std::sin(0.637919843196869*x_83 + 2.00751972198486) + 0.000348217499391462*std::sin(0.36303985118866*x_84 + 5.15488004684448) + 0.000196995609367733*std::sin(0.632639825344086*x_84 + 5.43271970748901) - 0.000389621308408613*std::sin(0.1564000248909*x_85 - 7.65104007720947) + 0.000779899803582392*std::sin(0.5065598487854*x_85 + 8.51416015625) + 0.00158483647172198*std::sin(0.155040040612221*x_86 - 1.27311992645264) + 0.0324300806433711*std::sin(0.186640009284019*x_86 + 8.16335964202881) - 0.000333908877827951*std::sin(0.249119967222214*x_86 - 7.53016042709351) - 0.00297753293089281*std::sin(0.301999926567078*x_86 - 7.48448038101196) + 0.000277742101765329*std::sin(0.489359855651855*x_86 - 4.12224006652832) - 0.000345070135792386*std::sin(0.211119994521141*x_87 + 5.01863956451416) - 0.00264583483326328*std::sin(0.32015985250473*x_87 + 5.12007999420166) + 0.000315399510613976*std::sin(0.399999856948853*x_87 + 8.40015983581543) - 0.00419666746063604*std::sin(0.5136798620224*x_87 + 5.15128040313721) - 0.000776101701091935*std::sin(0.279199928045273*x_88 + 5.0959997177124) + 0.0249464446327249*std::sin(0.531839847564697*x_88 + 2.15471982955933) + 0.000691470052020697*std::sin(0.501599848270416*x_89 + 8.48872089385986) + 0.00187822355479464*std::sin(0.392159849405289*x_9 - 7.39575958251953) + 0.0151863108189858*std::sin(0.53007984161377*x_9 - 4.06080007553101) - 0.000371018188886386*std::sin(0.60999983549118*x_9 + 5.19591999053955) + 0.0909237057156075*std::sin(0.238079980015755*x_90 - 7.55304002761841) - 0.00241939872664468*std::sin(0.406159847974777*x_90 - 4.18832015991211) - 0.00121255996144155*std::sin(0.196719989180565*x_91 - 7.39048004150391) - 0.00148357249443967*std::sin(0.326319843530655*x_92 - 4.21528005599976) + 0.0161297782060808*std::sin(0.353599846363068*x_92 - 7.40887975692749) - 0.000908957469437804*std::sin(0.373679846525192*x_92 + 5.19736003875732) - 0.251785497988676*std::sin(0.375119835138321*x_92 + 1.9987998008728) - 0.00220163129130194*std::sin(0.356559842824936*x_93 + 1.99455988407135) + 0.000555524321387013*std::sin(0.392959833145142*x_94 + 5.19432020187378) + 0.000473795531633331*std::sin(0.406799852848053*x_94 - 7.39671945571899) + 0.0251289568818042*std::sin(0.45143985748291*x_94 + 2.01095986366272) - 0.000172729643675398*std::sin(0.3643998503685*x_95 - 4.23271989822388) + 0.000867838493473881*std::sin(0.346799850463867*x_96 + 5.1637601852417) - 0.000451866859271146*std::sin(0.422319859266281*x_96 - 1.19247984886169) - 9.06375980474618e-5*std::sin(0.440079867839813*x_96 - 4.17288017272949) + 0.000290931115031339*std::sin(0.403919845819473*x_97 - 4.20703983306885) + 0.000316135743288446*std::sin(0.437839865684509*x_97 + 5.22304010391235) - 6.44915785594211e-5*std::sin(0.487279862165451*x_98 + 8.24639987945557) - 0.0120127256088981*std::sin(0.600959837436676*x_98 - 7.4047999382019) + 8.32626118329589e-5*std::sin(0.687439858913422*x_98 + 2.02071976661682) - 0.0310914020361942*std::sin(0.33111983537674*x_99 + 5.1448802947998) + 0.000434384272943653*std::sin(0.446559846401215*x_99 - 7.37319993972778) - 0.000742670588530777*std::sin(0.511439859867096*x_99 + 5.16400003433228) - 0.000232016735723664*std::sin(0.531919836997986*x_99 - 1.00535976886749) - 0.516827217005225);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00272119017801365*x_1 + 0.000194050184831579*x_10 + 0.00374737217096187*x_100 - 0.00254338510708871*x_101 + 0.0010006381782035*x_102 - 0.00118196239251605*x_103 + 0.00219042990307455*x_104 + 0.000607457156597675*x_105 - 0.00198457213609916*x_106 - 0.000330952789667479*x_107 - 0.00255238991471679*x_109 - 0.0178985755121643*x_11 - 0.000813221664996315*x_111 - 0.0012899577831412*x_112 - 0.00554926351838325*x_113 + 0.00123564688854007*x_114 - 0.000560311409396525*x_115 + 0.00708683424525214*x_116 - 0.00272705363003254*x_119 - 0.00925433244963911*x_12 - 0.000166778051960053*x_120 + 0.0109807977221559*x_13 - 0.000623073823866256*x_14 - 0.00169791969354755*x_17 + 0.00107557714272692*x_18 - 0.000794487423572519*x_19 - 0.00674063233002487*x_2 - 0.0122306962567748*x_20 + 0.000491146258552562*x_21 - 0.0053216095308699*x_22 + 0.00172728673148195*x_23 + 0.00100025872819614*x_24 + 0.00710800587079166*x_25 - 0.000229421995432512*x_27 - 0.00127493335760061*x_28 + 0.00465536410326857*x_29 + 0.00128245319793715*x_3 + 0.000726981336973993*x_30 + 0.00351012696268758*x_31 - 0.0017522896200185*x_32 + 0.00540058357420592*x_33 + 0.00215961284524061*x_34 - 0.00106991156366702*x_35 + 4.58625595948204e-5*x_36 + 0.000295657896775165*x_37 + 0.00204841856327802*x_38 + 0.000786433967339455*x_39 + 0.00245144193866052*x_4 + 0.000848142636308659*x_40 - 0.0017569591812833*x_41 - 0.000936211928053625*x_42 + 0.00198984516698535*x_43 - 0.000728998714810305*x_44 - 0.00135750805673144*x_45 - 0.000480511990588309*x_46 + 0.00345126712173932*x_47 + 0.000342315428648569*x_48 - 0.00163245944546076*x_5 - 0.00312952856804779*x_50 - 0.00132955801588331*x_51 + 0.000324079019417712*x_52 + 0.00130795344156325*x_53 + 0.000492398047769274*x_54 - 0.00130051965967937*x_56 + 0.000420580283273683*x_57 - 9.41837345207216e-5*x_58 + 1.66265338023914e-5*x_59 + 0.00025669062440209*x_6 + 0.000569486804728924*x_60 + 0.00109332803176527*x_61 - 0.00221423946343037*x_62 + 0.00390331092072488*x_63 - 0.00257980658358957*x_65 - 0.000144505373926101*x_67 - 0.000737809193606013*x_68 + 0.00135475165735463*x_69 + 0.000606825359033828*x_7 - 0.00140259379546059*x_70 - 0.00095438280429659*x_71 + 0.00179183144956635*x_72 - 0.00017238301391849*x_73 + 0.000614720462545203*x_74 - 9.53820935665413e-5*x_75 + 4.24279042676415e-5*x_76 + 0.0014209559864287*x_78 - 0.00147293810276131*x_79 - 0.0112412259474344*x_8 + 0.000433127958650941*x_80 + 0.000696696085315465*x_83 - 3.44912438519487e-5*x_84 + 0.000192264335989469*x_88 + 0.000938833724546924*x_89 - 0.00389253519037441*x_9 - 0.00239600090645526*x_90 - 0.0131477578457979*x_91 - 0.000289183849767781*x_92 + 0.0035004525400511*x_93 + 0.00136467475807602*x_94 + 0.000504269651564953*x_95 - 0.000411400066341278*x_96 - 0.00142970659001552*x_97 - 0.000850268127742037*x_98 + 0.00023096977127152*x_99 + 0.000362790824928391*std::pow(-2.17063999176025*x_108 - 3.15591979026794, 2) - 1.79322290898064e-5*std::pow(-6.25112009048462*x_110 - 8.66423988342285, 2) - 1.93429694549871e-5*std::pow(-3.51968002319336*x_110 - 5.79135990142822, 2) - 4.54044230704371e-5*std::pow(-5.40447998046875*x_13 - 8.20039939880371, 2) + 5.47110441029447e-5*std::pow(-6.59999990463257*x_15 - 9.99973964691162, 2) - 0.000146581915570739*std::pow(-6.46104001998901*x_17 - 9.48311996459961, 2) + 9.87087347831785e-6*std::pow(-6.29008007049561*x_17 - 9.74312019348145, 2) + 0.00028585140350613*std::pow(-4.0065598487854*x_17 - 6.20688009262085, 2) + 1.06130198861623e-5*std::pow(-4.49232006072998*x_18 - 7.14559984207153, 2) + 0.00018153034990737*std::pow(-3.45199990272522*x_18 - 5.2752799987793, 2) - 4.11328960437795e-5*std::pow(-4.59431982040405*x_19 - 7.38895988464355, 2) - 0.000109340691112538*std::pow(-5.7294397354126*x_22 - 9.58975982666016, 2) + 3.549099322472e-5*std::pow(-5.72079992294312*x_22 - 8.28072071075439, 2) - 5.59397774403981e-5*std::pow(-5.72383975982666*x_24 - 8.38159942626953, 2) - 4.40930404840358e-5*std::pow(-1.62839984893799*x_25 - 3.46207976341248, 2) + 0.000157042211207667*std::pow(-5.51200008392334*x_4 - 9.19999980926514, 2) - 0.000251943416979819*std::pow(-4.58247995376587*x_4 - 7.77960014343262, 2) - 1.60249284033402e-5*std::pow(-3.95839977264404*x_41 - 9.7038402557373, 2) - 0.000130871664829117*std::pow(-4.11559963226318*x_5 - 6.37784004211426, 2) - 0.000366059279154338*std::pow(-3.50720000267029*x_5 - 5.56712007522583, 2) + 7.71382407089562e-6*std::pow(-7.74287986755371*x_55 - 9.17280006408691, 2) - 0.00024679822162648*std::pow(-3.28671979904175*x_6 - 5.13399982452393, 2) + 0.000298684704331088*std::pow(-3.16847991943359*x_6 - 5.34823989868164, 2) + 1.28948378624278e-5*std::pow(-5.31584024429321*x_64 - 8.99736022949219, 2) + 1.08950716597345e-6*std::pow(-7.26232004165649*x_66 - 9.61312007904053, 2) + 3.30054457914641e-5*std::pow(-5.60232019424438*x_66 - 7.61072015762329, 2) + 0.000733512005326252*std::pow(-1.15495979785919*x_66 - 1.92279982566833, 2) + 1.36773657485416e-5*std::pow(-5.68575954437256*x_67 - 8.73624038696289, 2) + 9.87613197100797e-5*std::pow(-5.31304025650024*x_7 - 8.78575992584229, 2) + 3.31156430662093e-5*std::pow(-5.07807970046997*x_7 - 8.11320018768311, 2) + 1.79971465520034e-5*std::pow(-7.10591983795166*x_70 - 9.93296051025391, 2) + 1.05096518078665e-5*std::pow(-5.73503971099854*x_70 - 6.75536012649536, 2) + 2.04283200616949e-6*std::pow(-5.9539999961853*x_72 - 9.1340799331665, 2) + 6.58095624496344e-5*std::pow(-3.84744000434875*x_75 - 5.66079998016357, 2) - 3.90129308468696e-6*std::pow(-5.71463966369629*x_78 - 9.38111972808838, 2) + 4.49784697515877e-6*std::pow(-4.57719993591309*x_8 - 8.7577600479126, 2) - 0.000503356629593825*std::pow(-2.51511979103088*x_8 - 5.22399997711182, 2) - 3.17549998092895e-5*std::pow(-6.33008003234863*x_81 - 8.87975978851318, 2) + 3.39933716857216e-6*std::pow(-6.81415987014771*x_85 - 8.80992031097412, 2) - 6.12825453065327e-5*std::pow(-2.30607986450195*x_85 - 3.7727198600769, 2) + 1.34904286084101e-5*std::pow(-5.80800008773804*x_87 - 8.01583957672119, 2) - 1.51834047834893e-5*std::pow(-9.5959997177124*x_88 - 9.99096012115479, 2) + 2.52623359962005e-5*std::pow(-6.0*x_9 - 9.99997997283936, 2) - 0.000996475880174392*std::exp(0.57999986410141*x_106) + 0.00145575914672674*std::exp(0.719279825687408*x_15) - 0.00293615879753295*std::exp(0.612959861755371*x_2) + 0.000806182532931249*std::exp(0.513279855251312*x_76) - 0.00260218541654567*std::exp(0.612399816513062*x_76) + 0.000559836389382047*std::log(0.681119859218597*x_91 + 1.02415990829468) + 0.0647097552582779*std::sin(0.299839943647385*x_1 - 7.41623973846436) - 0.0654860963557692*std::sin(0.305919945240021*x_1 + 1.97895979881287) + 0.0612506894820103*std::sin(0.351679861545563*x_1 - 4.35207986831665) + 0.0131857805445044*std::sin(0.308879911899567*x_10 - 4.25407981872559) + 0.00287006908948097*std::sin(0.513359844684601*x_100 - 7.22968006134033) + 0.00399228921607487*std::sin(0.353999853134155*x_101 + 1.96231985092163) + 0.0352128925275294*std::sin(0.363119840621948*x_102 + 5.16175985336304) - 0.00708475972745537*std::sin(0.371919840574265*x_102 - 7.40231990814209) - 0.0177066420028484*std::sin(0.388159841299057*x_103 - 7.40567970275879) - 0.0185102507572244*std::sin(0.437279850244522*x_103 + 2.00919985771179) + 0.00280461459628764*std::sin(0.332559853792191*x_104 + 5.15224027633667) - 0.0254509611035211*std::sin(0.34215983748436*x_104 - 7.4378399848938) - 0.0161438079297846*std::sin(0.345919847488403*x_105 + 8.34463977813721) - 0.0176132118238245*std::sin(0.376319825649261*x_105 + 5.18792009353638) + 0.0481451177777026*std::sin(0.364719837903976*x_106 + 1.98247981071472) + 0.000430510129512708*std::sin(0.700959861278534*x_106 - 0.957199811935425) - 0.00315776980155243*std::sin(0.385039836168289*x_107 + 5.18535995483398) + 0.0204889961737642*std::sin(0.296479940414429*x_108 + 5.10391998291016) + 0.00490317510458132*std::sin(0.367439836263657*x_108 - 4.22936010360718) + 0.00395258364533844*std::sin(0.708239853382111*x_108 - 4.02719974517822) - 0.00533342960338712*std::sin(0.397519826889038*x_109 + 5.19832038879395) + 0.00104055344036902*std::sin(0.327279835939407*x_11 - 1.06439983844757) + 0.00081990513845538*std::sin(0.609279870986938*x_110 + 2.20576000213623) + 0.00151779712439091*std::sin(0.816159844398499*x_110 + 5.6101598739624) - 0.0143529828976164*std::sin(0.339759826660156*x_111 - 1.04287981987) + 0.0090575212817193*std::sin(0.361119836568832*x_111 + 1.97559976577759) - 0.00396522902806297*std::sin(0.368559837341309*x_111 + 5.17408037185669) - 0.013329662471209*std::sin(0.268239974975586*x_112 + 5.07903957366943) - 0.0231986734112529*std::sin(0.331439822912216*x_112 - 7.43304014205933) + 0.00200550816366066*std::sin(0.438159853219986*x_112 - 1.17311990261078) + 0.0041566016470119*std::sin(0.327199816703796*x_113 + 1.92543983459473) - 0.0134431571864577*std::sin(0.409679859876633*x_114 + 5.21720027923584) - 0.00121295689450293*std::sin(0.469839870929718*x_114 - 0.924239873886108) - 0.00440723838841476*std::sin(0.360399842262268*x_115 + 5.16368007659912) + 0.00109395333031211*std::sin(0.516719877719879*x_115 - 7.04375982284546) - 0.000225653903551579*std::sin(1.55183982849121*x_115 + 1.80663990974426) + 0.00384060508042533*std::sin(0.288879930973053*x_117 + 8.30072021484375) + 0.0149917543413715*std::sin(0.394879847764969*x_117 - 7.39591979980469) - 0.00729705609564471*std::sin(0.542399823665619*x_117 - 7.43400001525879) + 0.00137057575231239*std::sin(0.976639807224274*x_117 - 7.98496007919312) - 0.0408621967923767*std::sin(0.239919975399971*x_118 - 1.36119985580444) + 0.012044330229253*std::sin(0.364959836006165*x_118 + 1.96375977993011) - 0.0325667114333559*std::sin(0.384399831295013*x_118 - 7.41703987121582) + 0.00160210959044128*std::sin(0.427439838647842*x_118 + 8.43224048614502) - 0.0228132203308829*std::sin(0.353999853134155*x_119 + 5.16960000991821) + 0.010726559742493*std::sin(0.429279863834381*x_119 + 2.01151990890503) - 0.0396897361373441*std::sin(0.283679932355881*x_12 - 7.49535989761353) - 0.0312903485680323*std::sin(0.169520005583763*x_120 - 7.63551998138428) + 0.00327141581128107*std::sin(0.289919942617416*x_120 - 7.49015998840332) + 0.00902839922644567*std::sin(0.322559833526611*x_120 + 5.33591985702515) - 0.581374140059034*std::sin(0.142560034990311*x_14 - 4.49032020568848) + 0.0387017111564219*std::sin(0.213919997215271*x_14 + 5.01495981216431) - 0.0205390853453354*std::sin(0.281919956207275*x_15 - 4.2772798538208) - 0.00973845575040384*std::sin(0.510799825191498*x_15 - 0.896399855613708) - 0.00528324227355772*std::sin(0.326799839735031*x_16 - 4.26232004165649) + 0.018717710322301*std::sin(0.338079839944839*x_16 - 4.24959993362427) + 0.0757874073534715*std::sin(0.354879856109619*x_16 + 5.17128038406372) + 0.00995221782843297*std::sin(0.37271985411644*x_16 - 4.2260799407959) - 0.0702821983890345*std::sin(0.208719998598099*x_18 - 7.57600021362305) + 0.0154553716593432*std::sin(0.213279992341995*x_19 + 5.02807998657227) + 0.0119454424500212*std::sin(0.295359939336777*x_21 + 8.31112003326416) - 0.00631501104597338*std::sin(0.330719828605652*x_21 - 4.2402400970459) - 0.0387631078457298*std::sin(0.183360010385513*x_23 - 4.41607999801636) - 0.0261138853364353*std::sin(0.158160030841827*x_24 + 4.95127964019775) - 0.0176580929931593*std::sin(0.241919979453087*x_24 - 4.34632015228271) - 0.0534802350026253*std::sin(0.316399842500687*x_26 - 4.28280019760132) - 0.022241138294745*std::sin(0.321759849786758*x_26 - 4.27472019195557) + 0.00992006747724802*std::sin(0.324319839477539*x_26 - 4.26200008392334) + 0.0944174232493952*std::sin(0.33095982670784*x_26 - 4.2707200050354) + 0.0936300338042401*std::sin(0.214399993419647*x_27 - 7.57800006866455) + 0.0140415615847382*std::sin(0.305119842290878*x_27 - 4.31576013565063) + 0.0437240278296769*std::sin(0.320719838142395*x_28 + 8.30399990081787) - 0.000155867824092747*std::sin(1.78887987136841*x_29 - 0.204079851508141) - 0.213366298313595*std::sin(0.317679852247238*x_3 + 8.32208061218262) + 0.00995519438797349*std::sin(0.343599855899811*x_3 - 1.05495977401733) + 0.0400277228480961*std::sin(0.2880799472332*x_30 - 4.29983997344971) - 0.0848776637946613*std::sin(0.276319950819016*x_32 - 7.44519996643066) + 0.0233459881379826*std::sin(0.251519978046417*x_33 + 2.01743984222412) + 0.00284483267446158*std::sin(0.341839849948883*x_34 + 1.98831987380981) - 0.0434186851387042*std::sin(0.355519831180573*x_34 + 1.9975198507309) - 0.00315191520112674*std::sin(0.231999978423119*x_35 - 1.14375984668732) - 0.0442633959274868*std::sin(0.321999847888947*x_35 + 1.98599982261658) + 0.024732942268007*std::sin(0.323599845170975*x_35 + 1.97183978557587) + 0.063597840900993*std::sin(0.343599855899811*x_36 - 7.43511962890625) - 0.0133122611083079*std::sin(0.356639832258224*x_36 + 5.1573600769043) + 0.0211672955731713*std::sin(0.36015984416008*x_36 - 4.23160028457642) + 0.0168074856959617*std::sin(0.436079859733582*x_37 + 2.03319978713989) + 0.00970532230880542*std::sin(0.3781598508358*x_38 + 5.18815994262695) + 0.00935582966789784*std::sin(0.371439844369888*x_39 + 5.17072010040283) + 0.0203705719206755*std::sin(0.401119858026505*x_39 - 7.40167951583862) - 0.00175098732294437*std::sin(0.409199863672256*x_39 + 1.98799991607666) - 0.0232106093239231*std::sin(0.33095982670784*x_40 - 7.4703197479248) - 0.0129375480568206*std::sin(0.373999834060669*x_40 - 4.22448015213013) - 0.00326789440316683*std::sin(0.386159837245941*x_42 + 1.99703979492188) - 0.00775235665242666*std::sin(0.475279837846756*x_42 + 2.04271984100342) - 0.0165543326583735*std::sin(0.446799874305725*x_43 + 2.02879977226257) - 0.0178944333712442*std::sin(0.451839864253998*x_43 + 2.04807996749878) + 0.0242781071422531*std::sin(0.365279853343964*x_44 - 4.22080039978027) - 0.0340475961404943*std::sin(0.270159959793091*x_45 - 7.5237603187561) - 0.0181190630875763*std::sin(0.366239845752716*x_45 - 7.4172797203064) - 0.00139586177843715*std::sin(0.703439831733704*x_46 + 2.05855989456177) - 0.0156253774837834*std::sin(0.339919835329056*x_47 + 5.1384801864624) - 0.00236477014091454*std::sin(0.462239861488342*x_48 + 5.23808002471924) + 0.00786573034248343*std::sin(0.476239860057831*x_48 - 7.34207963943481) - 0.00804206468623233*std::sin(0.163760021328926*x_49 - 7.27447986602783) - 0.0238909310899385*std::sin(0.238639980554581*x_49 - 4.35871982574463) + 0.00267723941884286*std::sin(0.374799847602844*x_49 - 4.23487997055054) + 0.00746929924727871*std::sin(0.56063985824585*x_49 - 4.21432018280029) - 0.00396979578935219*std::sin(0.27727997303009*x_50 + 5.07631969451904) + 0.012370020164083*std::sin(0.322959840297699*x_50 + 4.94575977325439) - 0.00131342662959614*std::sin(0.917439818382263*x_50 - 4.02711963653564) - 0.0322235616368508*std::sin(0.210559993982315*x_51 + 5.01375961303711) - 0.0217566540033451*std::sin(0.274559944868088*x_51 - 4.30599975585938) - 0.00679435079147968*std::sin(0.325199842453003*x_51 - 4.27367973327637) + 0.00486720277917695*std::sin(0.226319998502731*x_52 + 8.22552013397217) + 0.0167808647445834*std::sin(0.363839834928513*x_53 - 4.24128007888794) - 0.00707458575178087*std::sin(0.366159826517105*x_53 - 7.44087982177734) + 0.00559678810213602*std::sin(0.488159865140915*x_54 + 2.25639986991882) + 0.00741981859629653*std::sin(0.238079980015755*x_55 - 4.34976005554199) - 0.0142748795454914*std::sin(0.322879940271378*x_55 + 8.36727905273438) + 0.0102551006246598*std::sin(0.4129598736763*x_55 - 4.18151998519897) + 0.0299136980490925*std::sin(0.315759837627411*x_56 + 8.30768013000488) + 0.0168131603111632*std::sin(0.354159832000732*x_56 - 7.45271968841553) + 0.00915529373599186*std::sin(0.304559946060181*x_57 - 4.27871990203857) - 0.0565245839791439*std::sin(0.313599914312363*x_58 + 5.13840007781982) + 0.0178981113190831*std::sin(0.465279877185822*x_58 + 2.05847978591919) + 0.00275755398629564*std::sin(0.498079836368561*x_58 - 1.10559988021851) - 0.0286812838784822*std::sin(0.337039858102798*x_59 + 5.13671970367432) + 0.0219436112730773*std::sin(0.369119822978973*x_59 - 7.42424011230469) + 0.0114242054750413*std::sin(0.151360034942627*x_60 + 1.74399983882904) + 0.000510363192080929*std::sin(1.47391986846924*x_60 + 3.38039994239807) + 0.00737834253458175*std::sin(0.376559853553772*x_62 - 4.21199989318848) - 0.00711805882673923*std::sin(0.271359950304031*x_63 + 5.09839963912964) + 0.0160514048928687*std::sin(0.385599851608276*x_63 - 7.40111970901489) + 0.0100162697179801*std::sin(0.211040005087852*x_64 + 5.00703954696655) + 0.0195340313313849*std::sin(0.241439983248711*x_64 - 4.3517599105835) + 0.0469359265935476*std::sin(0.278079956769943*x_64 - 4.28567981719971) - 0.000309343855269757*std::sin(0.521519839763641*x_65 + 8.33312034606934) + 0.0445443555363012*std::sin(0.199440002441406*x_66 + 5.00719976425171) - 0.148004036102112*std::sin(0.186240002512932*x_67 - 4.4201602935791) - 0.0050753604412223*std::sin(0.319439828395844*x_68 - 7.65296030044556) + 0.00690025076995252*std::sin(0.473519861698151*x_68 + 2.26967978477478) + 0.007797234677671*std::sin(0.298079937696457*x_69 - 7.49047994613647) - 0.0127163677822542*std::sin(0.418239861726761*x_7 - 7.17655992507935) + 0.00218173077168822*std::sin(0.271119952201843*x_71 + 5.07599973678589) - 0.00734388149349835*std::sin(0.402959853410721*x_72 - 7.19704008102417) + 0.00722330357079547*std::sin(0.578239858150482*x_72 - 7.01944017410278) - 0.0592382374441822*std::sin(0.275039941072464*x_73 + 5.07879972457886) - 0.0195632855054019*std::sin(0.411759853363037*x_73 + 5.19583988189697) - 0.0105947392011574*std::sin(0.391919851303101*x_75 + 8.38992023468018) + 0.0020470758266831*std::sin(0.437039852142334*x_75 + 5.22632026672363) + 0.00165210383785318*std::sin(1.22431993484497*x_76 - 0.768399834632874) - 0.0181374287019359*std::sin(0.468479871749878*x_77 + 5.25504016876221) - 0.00943965101751065*std::sin(0.491839855909348*x_77 - 0.899999797344208) - 0.000602492951793286*std::sin(0.492559850215912*x_77 - 0.874159812927246) - 0.00178791620673343*std::sin(0.890239894390106*x_77 + 8.64192008972168) + 0.022243978633566*std::sin(0.407439857721329*x_78 - 4.18200016021729) + 0.00412445617209554*std::sin(0.428879857063293*x_78 - 4.15312004089355) + 0.000629780305410384*std::sin(0.752559840679169*x_79 - 1.39367985725403) + 0.000569052054077255*std::sin(1.52543985843658*x_8 + 2.39687991142273) - 0.0123500935866272*std::sin(0.530399858951569*x_80 + 5.34944009780884) + 0.00909342695394544*std::sin(0.207440003752708*x_81 - 7.58808040618896) - 0.017483452693037*std::sin(0.347279846668243*x_81 - 1.04183983802795) + 0.0140389955210289*std::sin(0.423119872808456*x_81 - 4.17736005783081) - 0.0275667931893552*std::sin(0.386639833450317*x_82 - 4.22040033340454) - 0.00468781044395961*std::sin(0.61303985118866*x_82 - 0.966639816761017) - 4.59328751518784e-5*std::sin(0.997999846935272*x_82 - 4.60471963882446) + 0.00102944349970978*std::sin(0.99999988079071*x_82 - 10.0) + 0.053389602707856*std::sin(0.32575985789299*x_83 + 5.12007999420166) + 0.00619879184363847*std::sin(0.637919843196869*x_83 + 2.00751972198486) + 0.0144786979379313*std::sin(0.36303985118866*x_84 + 5.15488004684448) - 0.00187179293530693*std::sin(0.632639825344086*x_84 + 5.43271970748901) + 0.058599313445697*std::sin(0.1564000248909*x_85 - 7.65104007720947) - 0.00741037298891137*std::sin(0.5065598487854*x_85 + 8.51416015625) - 0.0052427225580679*std::sin(0.155040040612221*x_86 - 1.27311992645264) + 0.0502201254701924*std::sin(0.249119967222214*x_86 - 7.53016042709351) + 0.0282916209278814*std::sin(0.301999926567078*x_86 - 7.48448038101196) + 0.0115483684855988*std::sin(0.489359855651855*x_86 - 4.12224006652832) + 0.051898786364222*std::sin(0.211119994521141*x_87 + 5.01863956451416) + 0.0251399255282204*std::sin(0.32015985250473*x_87 + 5.12007999420166) - 0.0010433582004223*std::sin(0.399999856948853*x_87 + 8.40015983581543) + 0.00256738532225257*std::sin(0.279199928045273*x_88 + 5.0959997177124) - 0.00228741936763886*std::sin(0.501599848270416*x_89 + 8.48872089385986) - 0.017846314403023*std::sin(0.392159849405289*x_9 - 7.39575958251953) - 0.0154267384486767*std::sin(0.60999983549118*x_9 + 5.19591999053955) + 0.0229883978569822*std::sin(0.406159847974777*x_90 - 4.18832015991211) - 0.0504175965998921*std::sin(0.196719989180565*x_91 - 7.39048004150391) + 0.00490773598532654*std::sin(0.326319843530655*x_92 - 4.21528005599976) - 0.153260293420301*std::sin(0.353599846363068*x_92 - 7.40887975692749) - 0.0377939668782168*std::sin(0.373679846525192*x_92 + 5.19736003875732) + 0.020919237288771*std::sin(0.356559842824936*x_93 + 1.99455988407135) - 0.0018377037273294*std::sin(0.392959833145142*x_94 + 5.19432020187378) + 0.0197001655541404*std::sin(0.406799852848053*x_94 - 7.39671945571899) + 0.0259786575134719*std::sin(0.3643998503685*x_95 - 4.23271989822388) - 0.00287085546532862*std::sin(0.346799850463867*x_96 + 5.1637601852417) - 0.0187883830507717*std::sin(0.422319859266281*x_96 - 1.19247984886169) + 0.0136319572449516*std::sin(0.440079867839813*x_96 - 4.17288017272949) + 0.0120967606241663*std::sin(0.403919845819473*x_97 - 4.20703983306885) - 0.00104579369690367*std::sin(0.437839865684509*x_97 + 5.22304010391235) + 0.00969957788511899*std::sin(0.487279862165451*x_98 + 8.24639987945557) + 0.00346201500027829*std::sin(0.687439858913422*x_98 + 2.02071976661682) + 0.0180614664338528*std::sin(0.446559846401215*x_99 - 7.37319993972778) + 0.00705663220278779*std::sin(0.511439859867096*x_99 + 5.16400003433228) + 0.00076752358740588*std::sin(0.531919836997986*x_99 - 1.00535976886749) - 0.0372334942221642*std::sin(-0.00085638963389155*x_1 - 0.0486939884002451*x_103 - 0.0122331021501456*x_105 + 0.0124718441972142*x_106 - 0.0054954007930529*x_107 - 0.00416901504810616*x_109 + 0.0153881383558131*x_11 - 0.00548022498267554*x_111 - 0.00737704900378087*x_113 + 0.0308175753796222*x_114 + 0.0234515447893094*x_115 + 0.00807738145425251*x_117 + 0.0187950647904216*x_119 - 0.0387734542351207*x_120 - 0.0288510810227328*x_13 - 0.0589136743273999*x_16 - 0.115421405898861*x_17 - 0.00843136627699571*x_19 + 0.000723405439434537*x_2 + 0.0735210873589316*x_20 + 0.0207152982102153*x_22 + 0.00357852062342318*x_24 + 0.00105449157994758*x_25 - 0.00390451200289249*x_29 - 0.0290544537640656*x_30 - 0.119502195841273*x_31 + 0.0130003080795825*x_32 - 0.0465042000652845*x_33 - 0.0213398429585002*x_37 - 0.000707238184396571*x_39 + 0.0551539453754794*x_4 + 0.00626386366740944*x_40 + 0.00623731781592623*x_41 + 0.0284682732706284*x_46 - 0.0134916318010305*x_47 - 0.0157082036069682*x_48 - 0.000629030503797546*x_5 - 0.0393276880383148*x_52 + 0.00542259285366097*x_53 - 0.0114644854325331*x_56 + 0.0246698580172781*x_58 + 0.00874250530036474*x_59 + 0.00703613911965035*x_60 + 0.0220184414657425*x_61 - 0.0147863962976344*x_64 - 0.0612239417595677*x_65 + 0.00415307230178281*x_66 + 0.01061907099001*x_68 + 0.00098481914750901*x_69 - 0.00111089293339763*x_71 - 0.00378605342089851*x_73 - 0.0160020471795303*x_74 + 0.0225969471811499*x_78 - 0.0217384759969187*x_79 + 0.0660323826389078*x_8 - 0.028129857681288*x_82 + 0.0195102373571409*x_84 + 0.00865246012257405*x_85 + 0.0199484963366397*x_89 + 0.0105585287906614*x_91 + 0.0273442231646219*x_93 + 0.0160096345053838*x_95 + 0.0129376266848081*x_96 - 0.00502817543200246*x_97 - 0.000199541607906951*std::pow(-6.72800016403198*x_118 - 8.75936031341553, 2) - 0.00176317998341161*std::pow(-5.76688003540039*x_14 - 8.3450403213501, 2) + 0.00271511193445384*std::pow(-5.93840026855469*x_15 - 8.39935970306396, 2) + 0.00144325668006939*std::pow(-6.12911987304688*x_27 - 7.76647996902466, 2) - 0.00178849663746308*std::pow(-5.72591972351074*x_7 - 9.18144035339355, 2) + 0.000940620721284063*std::pow(-4.91448020935059*x_81 - 6.35383987426758, 2) - 6.02925988567711*std::sin(0.212640002369881*x_10 + 5.01351976394653) - 0.282358245326236*std::sin(0.41143986582756*x_100 - 0.988239824771881) + 0.19341513683192*std::sin(0.303999930620193*x_101 - 4.3010401725769) - 0.16069255214844*std::sin(0.411119878292084*x_102 - 1.00239980220795) + 1.87316398278494*std::sin(0.136880040168762*x_104 - 7.68391990661621) - 0.0198767542152234*std::sin(0.85207986831665*x_108 + 8.40624046325684) + 0.12611881850685*std::sin(0.597919821739197*x_110 - 7.19352006912231) + 0.223808214428843*std::sin(0.369279861450195*x_112 + 1.9748797416687) - 0.537084118897965*std::sin(0.259839832782745*x_116 + 8.09823989868164) - 0.257549756381483*std::sin(0.342879861593246*x_12 + 2.14535975456238) - 6.94509634781923*std::sin(0.134800046682358*x_18 + 4.90247964859009) - 0.935302710983152*std::sin(0.324959844350815*x_21 - 4.26024007797241) + 5.59189318589608*std::sin(0.161600023508072*x_23 + 4.94087982177734) + 0.14398119133819*std::sin(0.398319840431213*x_26 - 1.17639982700348) - 0.68560636216268*std::sin(0.291999936103821*x_28 - 4.28151988983154) + 0.920352870797046*std::sin(0.293919950723648*x_3 - 1.08967983722687) - 0.19839805527495*std::sin(0.345679849386215*x_34 + 5.20056009292603) + 0.369015645177008*std::sin(0.323519825935364*x_35 + 5.18839979171753) - 0.315092869795411*std::sin(0.325279831886292*x_36 + 5.12784004211426) + 0.225086835415272*std::sin(0.451279848814011*x_38 + 8.45608043670654) + 0.524609241725237*std::sin(0.372079849243164*x_42 - 7.41975975036621) + 0.636987580357108*std::sin(0.244559973478317*x_43 + 8.25592041015625) - 0.317009259076357*std::sin(0.370959848165512*x_44 + 8.3645601272583) + 0.141014235032708*std::sin(0.380239844322205*x_45 + 5.16648006439209) + 0.302667428067831*std::sin(0.326239824295044*x_49 + 8.32384014129639) + 0.328017601010313*std::sin(0.398319840431213*x_50 - 1.00463974475861) + 0.170849642944713*std::sin(0.350959837436676*x_51 - 1.05951988697052) + 0.0559186198030313*std::sin(0.683279812335968*x_54 + 8.4498405456543) + 0.249824255589697*std::sin(0.318879842758179*x_55 + 5.11352014541626) + 0.113565852900756*std::sin(0.538079857826233*x_57 + 2.13239979743958) - 0.144088549639251*std::sin(0.464319854974747*x_6 - 6.90000009536743) + 0.46192318282273*std::sin(0.347919851541519*x_62 + 8.34496021270752) + 1.05552699080717*std::sin(0.296799927949905*x_63 - 4.28799962997437) - 0.267766599400399*std::sin(0.296319931745529*x_67 - 7.49088001251221) + 0.0194188235721118*std::sin(0.734559834003448*x_70 + 5.98959970474243) - 0.265296911770154*std::sin(0.498719841241837*x_72 + 8.48984050750732) - 0.201124960376255*std::sin(0.305759936571121*x_75 + 5.14759969711304) - 2.33398946048226*std::sin(0.150800034403801*x_76 + 4.92391967773438) - 0.202002269354001*std::sin(0.406159847974777*x_77 - 1.00543987751007) - 0.106684073062667*std::sin(0.430959850549698*x_80 - 7.16616010665894) + 0.131680433716351*std::sin(0.461679875850677*x_83 + 2.05015993118286) + 0.28625624293926*std::sin(0.186640009284019*x_86 + 8.16335964202881) - 0.0370434558383583*std::sin(0.5136798620224*x_87 + 5.15128040313721) + 0.220199129129078*std::sin(0.531839847564697*x_88 + 2.15471982955933) + 0.134047655537955*std::sin(0.53007984161377*x_9 - 4.06080007553101) + 0.802572114404683*std::sin(0.238079980015755*x_90 - 7.55304002761841) - 2.22247892237547*std::sin(0.375119835138321*x_92 + 1.9987998008728) + 0.221810141796187*std::sin(0.45143985748291*x_94 + 2.01095986366272) - 0.106034818046815*std::sin(0.600959837436676*x_98 - 7.4047999382019) - 0.274439895246275*std::sin(0.33111983537674*x_99 + 5.1448802947998) - 1.50705257527124) + 0.436786104045339);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000509881853966775*x_1 - 0.00029455295622869*x_10 - 0.00146779722342616*x_100 + 2.0669299422595e-5*x_101 - 0.000100512994595315*x_102 + 0.00475731460271308*x_103 - 0.000367763469656127*x_104 - 0.00367648070741235*x_105 + 0.000353372892532726*x_106 - 6.3284572947875e-5*x_107 + 3.75789062731917e-5*x_109 - 0.000748670887384253*x_11 + 2.48496710687982e-5*x_111 - 0.000138406045442197*x_112 + 0.000488602792256635*x_113 - 1.35849978000313e-5*x_114 + 7.16375682339247e-5*x_115 - 0.00510120144650337*x_116 - 1.14011520804174e-5*x_117 + 0.00109798480888108*x_119 + 0.0028009276960562*x_12 + 3.68339314618e-5*x_120 - 0.00149264538050869*x_13 - 0.00282714728590444*x_14 + 8.3156127320104e-5*x_16 + 0.000480309032403708*x_17 - 0.000201058025664112*x_18 + 0.000240456357050822*x_19 - 0.000136488269756703*x_2 + 0.00161276302966506*x_20 + 6.61331228562848e-5*x_21 - 0.00161571331728513*x_22 - 0.000219966649404891*x_23 - 2.6101657705285e-5*x_24 + 0.000789687358149888*x_25 + 4.76303949829878e-6*x_27 + 0.00746926551351298*x_28 + 0.0216195664485393*x_29 - 6.09587798344277e-5*x_3 + 0.0014744242921418*x_30 + 0.00164900910056073*x_31 + 0.00377778130363535*x_32 + 0.000611878694130761*x_33 - 0.00049169010607688*x_34 + 0.000199998956914157*x_35 - 0.000568043704651563*x_36 - 0.00048244166230965*x_37 + 0.00073748539167277*x_38 + 8.53787082350794e-5*x_39 - 0.0468471333332069*x_4 - 0.000339021682359464*x_40 + 0.00209607301854105*x_41 + 0.000218567888713165*x_42 - 0.00065742009092469*x_43 - 0.00216015983726324*x_44 + 0.000796808449397543*x_45 + 3.59561127114236e-5*x_46 + 2.83893125725985e-5*x_47 + 0.000167613698094149*x_48 - 0.0125402708316499*x_5 + 6.58614378782314e-5*x_50 - 0.000142654953184806*x_51 - 0.000102896452015792*x_52 - 0.00633927669859106*x_53 + 0.00248325997629505*x_54 + 0.00195590466183948*x_56 - 0.000499897124095678*x_57 - 1.72154854941018e-5*x_58 + 0.000439282127215425*x_59 - 0.00293983565096657*x_6 - 3.40811708576104e-6*x_60 - 6.29384943953508e-5*x_61 - 0.0083465342993737*x_62 + 0.000553248311934234*x_63 + 2.08708668601873e-5*x_64 + 0.000125890141137646*x_65 - 5.86202461549796e-6*x_66 + 0.000534550703851712*x_67 + 0.00120071334024855*x_68 - 4.7389144810982e-5*x_69 - 0.000113434084607759*x_7 + 0.00293844760649474*x_70 + 8.43343458380608e-5*x_71 + 0.000192254590246766*x_72 + 0.000572194666493099*x_73 - 0.0044132907663004*x_74 + 2.00733167745043e-6*x_75 - 0.000525502809562221*x_76 + 0.000120566110249632*x_78 - 0.00438829382793197*x_79 + 0.000143369308186811*x_8 - 0.00139069107918731*x_80 + 3.97050439231165e-5*x_82 + 0.0018224386112108*x_83 + 0.000818242083139167*x_84 - 1.22128705058591e-5*x_85 - 0.000147692820263742*x_88 - 6.93377558581724e-5*x_89 - 0.000417649638992365*x_9 - 0.00869286298979426*x_90 + 0.0481469667840739*x_91 - 3.10279867877877e-5*x_92 + 0.00316008356439932*x_93 - 6.81583485317795e-5*x_94 + 0.000714879063841373*x_95 + 5.86418187212173e-5*x_96 + 5.32978881276244e-5*x_97 + 0.00605801600656567*x_98 + 2.4781906102799e-5*x_99 - 7.63499193545266e-6*std::pow(-2.17063999176025*x_108 - 3.15591979026794, 2) + 3.35207809215077e-6*std::pow(-6.25112009048462*x_110 - 8.66423988342285, 2) + 4.07075939215617e-7*std::pow(-3.51968002319336*x_110 - 5.79135990142822, 2) + 2.81651204787468e-7*std::pow(-6.72800016403198*x_118 - 8.75936031341553, 2) - 4.87166845682405e-6*std::pow(-5.40447998046875*x_13 - 8.20039939880371, 2) + 2.48871286441973e-6*std::pow(-5.76688003540039*x_14 - 8.3450403213501, 2) + 5.87022254159565e-6*std::pow(-6.59999990463257*x_15 - 9.99973964691162, 2) - 3.8323563465939e-6*std::pow(-5.93840026855469*x_15 - 8.39935970306396, 2) + 3.08484026156586e-6*std::pow(-6.46104001998901*x_17 - 9.48311996459961, 2) - 0.000122258495563858*std::pow(-6.29008007049561*x_17 - 9.74312019348145, 2) + 3.0670431901301e-5*std::pow(-4.0065598487854*x_17 - 6.20688009262085, 2) - 0.000131450559823469*std::pow(-4.49232006072998*x_18 - 7.14559984207153, 2) + 1.94773024255378e-5*std::pow(-3.45199990272522*x_18 - 5.2752799987793, 2) + 8.65648489423781e-7*std::pow(-4.59431982040405*x_19 - 7.38895988464355, 2) + 2.30109263382234e-6*std::pow(-5.7294397354126*x_22 - 9.58975982666016, 2) + 3.80800680863184e-6*std::pow(-5.72079992294312*x_22 - 8.28072071075439, 2) + 1.04568428999349e-5*std::pow(-5.72383975982666*x_24 - 8.38159942626953, 2) + 0.000546126825174663*std::pow(-1.62839984893799*x_25 - 3.46207976341248, 2) - 2.03714396723043e-6*std::pow(-6.12911987304688*x_27 - 7.76647996902466, 2) + 1.68498471072617e-5*std::pow(-5.51200008392334*x_4 - 9.19999980926514, 2) + 4.70958743773653e-5*std::pow(-4.58247995376587*x_4 - 7.77960014343262, 2) + 2.99554568258648e-6*std::pow(-3.95839977264404*x_41 - 9.7038402557373, 2) + 2.75421547870402e-6*std::pow(-4.11559963226318*x_5 - 6.37784004211426, 2) + 6.84275939113047e-5*std::pow(-3.50720000267029*x_5 - 5.56712007522583, 2) - 1.44194793325795e-6*std::pow(-7.74287986755371*x_55 - 9.17280006408691, 2) + 5.19390872736145e-6*std::pow(-3.28671979904175*x_6 - 5.13399982452393, 2) + 3.20473811630258e-5*std::pow(-3.16847991943359*x_6 - 5.34823989868164, 2) - 2.71373960761104e-7*std::pow(-5.31584024429321*x_64 - 8.99736022949219, 2) - 1.34943991846866e-5*std::pow(-7.26232004165649*x_66 - 9.61312007904053, 2) + 3.54131994841673e-6*std::pow(-5.60232019424438*x_66 - 7.61072015762329, 2) - 0.000137115665379348*std::pow(-1.15495979785919*x_66 - 1.92279982566833, 2) + 1.46751322412463e-6*std::pow(-5.68575954437256*x_67 - 8.73624038696289, 2) + 2.5244470964407e-6*std::pow(-5.72591972351074*x_7 - 9.18144035339355, 2) + 1.05965977199956e-5*std::pow(-5.31304025650024*x_7 - 8.78575992584229, 2) - 0.000410163164364094*std::pow(-5.07807970046997*x_7 - 8.11320018768311, 2) + 1.93100418948657e-6*std::pow(-7.10591983795166*x_70 - 9.93296051025391, 2) - 1.96457302685856e-6*std::pow(-5.73503971099854*x_70 - 6.75536012649536, 2) - 2.53020736526087e-5*std::pow(-5.9539999961853*x_72 - 9.1340799331665, 2) - 1.23018053938898e-5*std::pow(-3.84744000434875*x_75 - 5.66079998016357, 2) + 7.29270132271081e-7*std::pow(-5.71463966369629*x_78 - 9.38111972808838, 2) - 5.57093559822502e-5*std::pow(-4.57719993591309*x_8 - 8.7577600479126, 2) + 9.40926374601947e-5*std::pow(-2.51511979103088*x_8 - 5.22399997711182, 2) - 3.40715332242807e-6*std::pow(-6.33008003234863*x_81 - 8.87975978851318, 2) - 1.32767778197544e-6*std::pow(-4.91448020935059*x_81 - 6.35383987426758, 2) - 4.21034520457415e-5*std::pow(-6.81415987014771*x_85 - 8.80992031097412, 2) + 1.2897011364379e-6*std::pow(-2.30607986450195*x_85 - 3.7727198600769, 2) - 2.83908264910892e-7*std::pow(-5.80800008773804*x_87 - 8.01583957672119, 2) + 3.19537223956907e-7*std::pow(-9.5959997177124*x_88 - 9.99096012115479, 2) - 0.000312893808243858*std::pow(-6.0*x_9 - 9.99997997283936, 2) - 0.000106916898952788*std::exp(0.57999986410141*x_106) - 0.00027212558565654*std::exp(0.719279825687408*x_15) + 0.000548857229683775*std::exp(0.612959861755371*x_2) - 0.000150699993479875*std::exp(0.513279855251312*x_76) - 0.00027920153490172*std::exp(0.612399816513062*x_76) + 6.00676562920709e-5*std::log(0.681119859218597*x_91 + 1.02415990829468) - 0.801480977702768*std::sin(0.299839943647385*x_1 - 7.41623973846436) - 0.00702633198272395*std::sin(0.305919945240021*x_1 + 1.97895979881287) - 0.00128903072542799*std::sin(0.351679861545563*x_1 - 4.35207986831665) + 0.00851024670288102*std::sin(0.212640002369881*x_10 + 5.01351976394653) - 0.163316214694408*std::sin(0.308879911899567*x_10 - 4.25407981872559) + 0.000398546151912809*std::sin(0.41143986582756*x_100 - 0.988239824771881) - 6.04010709386171e-5*std::sin(0.513359844684601*x_100 - 7.22968006134033) - 0.000273003745355434*std::sin(0.303999930620193*x_101 - 4.3010401725769) - 0.0494476273538769*std::sin(0.353999853134155*x_101 + 1.96231985092163) + 0.00377816798891547*std::sin(0.363119840621948*x_102 + 5.16175985336304) + 0.0877502956159572*std::sin(0.371919840574265*x_102 - 7.40231990814209) + 0.000226816108117592*std::sin(0.411119878292084*x_102 - 1.00239980220795) + 0.000372639161760441*std::sin(0.388159841299057*x_103 - 7.40567970275879) - 0.00198605771516976*std::sin(0.437279850244522*x_103 + 2.00919985771179) - 0.00264395430130987*std::sin(0.136880040168762*x_104 - 7.68391990661621) - 0.0347373474021063*std::sin(0.332559853792191*x_104 + 5.15224027633667) - 0.00273076136682835*std::sin(0.34215983748436*x_104 - 7.4378399848938) - 0.00173215018595325*std::sin(0.345919847488403*x_105 + 8.34463977813721) + 0.0032924440788354*std::sin(0.376319825649261*x_105 + 5.18792009353638) - 0.00101322183667885*std::sin(0.364719837903976*x_106 + 1.98247981071472) - 0.00533220498417279*std::sin(0.700959861278534*x_106 - 0.957199811935425) + 0.0391114510912133*std::sin(0.385039836168289*x_107 + 5.18535995483398) + 0.00219836724313993*std::sin(0.296479940414429*x_108 + 5.10391998291016) - 0.0607296621812674*std::sin(0.367439836263657*x_108 - 4.22936010360718) - 0.000738857895389259*std::sin(0.708239853382111*x_108 - 4.02719974517822) + 2.8055861785942e-5*std::sin(0.85207986831665*x_108 + 8.40624046325684) + 0.0660587009790114*std::sin(0.397519826889038*x_109 + 5.19832038879395) - 0.0128880689690487*std::sin(0.327279835939407*x_11 - 1.06439983844757) - 0.000178015590589961*std::sin(0.597919821739197*x_110 - 7.19352006912231) - 0.0101551670126071*std::sin(0.609279870986938*x_110 + 2.20576000213623) + 0.000162852071994894*std::sin(0.816159844398499*x_110 + 5.6101598739624) - 0.0015400035792808*std::sin(0.339759826660156*x_111 - 1.04287981987) - 0.00169312574056394*std::sin(0.361119836568832*x_111 + 1.97559976577759) + 0.0491124657409481*std::sin(0.368559837341309*x_111 + 5.17408037185669) + 0.000280524915397391*std::sin(0.268239974975586*x_112 + 5.07903957366943) + 0.00433653644058263*std::sin(0.331439822912216*x_112 - 7.43304014205933) - 0.000315903304059823*std::sin(0.369279861450195*x_112 + 1.9748797416687) - 0.024839788643707*std::sin(0.438159853219986*x_112 - 1.17311990261078) - 0.0514827654450426*std::sin(0.327199816703796*x_113 + 1.92543983459473) - 0.00144238381189859*std::sin(0.409679859876633*x_114 + 5.21720027923584) + 0.0150234207166649*std::sin(0.469839870929718*x_114 - 0.924239873886108) + 0.0545870977013774*std::sin(0.360399842262268*x_115 + 5.16368007659912) + 0.000117375743862036*std::sin(0.516719877719879*x_115 - 7.04375982284546) + 4.74892311336646e-6*std::sin(1.55183982849121*x_115 + 1.80663990974426) + 0.000758089456863387*std::sin(0.259839832782745*x_116 + 8.09823989868164) - 0.0475689005860634*std::sin(0.288879930973053*x_117 + 8.30072021484375) - 0.000315503909221661*std::sin(0.394879847764969*x_117 - 7.39591979980469) - 0.000782937775768677*std::sin(0.542399823665619*x_117 - 7.43400001525879) - 0.000256202222821872*std::sin(0.976639807224274*x_117 - 7.98496007919312) + 0.00085995157963616*std::sin(0.239919975399971*x_118 - 1.36119985580444) - 0.00225145102117051*std::sin(0.364959836006165*x_118 + 1.96375977993011) - 0.0034942459369266*std::sin(0.384399831295013*x_118 - 7.41703987121582) - 0.0198433815088429*std::sin(0.427439838647842*x_118 + 8.43224048614502) - 0.00244774491930284*std::sin(0.353999853134155*x_119 + 5.16960000991821) - 0.000225742194955593*std::sin(0.429279863834381*x_119 + 2.01151990890503) - 0.00425851101114118*std::sin(0.283679932355881*x_12 - 7.49535989761353) + 0.000363529190420223*std::sin(0.342879861593246*x_12 + 2.14535975456238) + 0.00584911621446358*std::sin(0.169520005583763*x_120 - 7.63551998138428) - 0.0405190458908811*std::sin(0.289919942617416*x_120 - 7.49015998840332) - 0.00019000413061043*std::sin(0.322559833526611*x_120 + 5.33591985702515) - 0.0623785496700408*std::sin(0.142560034990311*x_14 - 4.49032020568848) - 0.00723452491302013*std::sin(0.213919997215271*x_14 + 5.01495981216431) + 0.254392651277941*std::sin(0.281919956207275*x_15 - 4.2772798538208) + 0.000204947385680914*std::sin(0.510799825191498*x_15 - 0.896399855613708) + 0.065437091609305*std::sin(0.326799839735031*x_16 - 4.26232004165649) - 0.000393917259040703*std::sin(0.338079839944839*x_16 - 4.24959993362427) - 0.014166967563162*std::sin(0.354879856109619*x_16 + 5.17128038406372) + 0.00106782340555246*std::sin(0.37271985411644*x_16 - 4.2260799407959) + 0.00980294172351504*std::sin(0.134800046682358*x_18 + 4.90247964859009) + 0.00147910029977213*std::sin(0.208719998598099*x_18 - 7.57600021362305) - 0.191426877429048*std::sin(0.213279992341995*x_19 + 5.02807998657227) - 0.002232965892708*std::sin(0.295359939336777*x_21 + 8.31112003326416) + 0.00132017145773542*std::sin(0.324959844350815*x_21 - 4.26024007797241) + 0.0782163555885657*std::sin(0.330719828605652*x_21 - 4.2402400970459) - 0.00789290749618942*std::sin(0.161600023508072*x_23 + 4.94087982177734) + 0.00724600181843602*std::sin(0.183360010385513*x_23 - 4.41607999801636) + 0.323440913468557*std::sin(0.158160030841827*x_24 + 4.95127964019775) - 0.00189462543129307*std::sin(0.241919979453087*x_24 - 4.34632015228271) + 0.00112550024668279*std::sin(0.316399842500687*x_26 - 4.28280019760132) - 0.00238636336610383*std::sin(0.321759849786758*x_26 - 4.27472019195557) - 0.122867801752736*std::sin(0.324319839477539*x_26 - 4.26200008392334) - 0.0176494831962378*std::sin(0.33095982670784*x_26 - 4.2707200050354) - 0.000203228170968965*std::sin(0.398319840431213*x_26 - 1.17639982700348) + 0.0100460362988838*std::sin(0.214399993419647*x_27 - 7.57800006866455) - 0.173915732836433*std::sin(0.305119842290878*x_27 - 4.31576013565063) + 0.000967727282237386*std::sin(0.291999936103821*x_28 - 4.28151988983154) + 0.00469137041676948*std::sin(0.320719838142395*x_28 + 8.30399990081787) + 3.28026371719729e-6*std::sin(1.78887987136841*x_29 - 0.204079851508141) - 0.00129906989128037*std::sin(0.293919950723648*x_3 - 1.08967983722687) + 0.00449032846198146*std::sin(0.317679852247238*x_3 + 8.32208061218262) - 0.123302876041606*std::sin(0.343599855899811*x_3 - 1.05495977401733) - 0.000842389939712699*std::sin(0.2880799472332*x_30 - 4.29983997344971) + 0.00178626424386618*std::sin(0.276319950819016*x_32 - 7.44519996643066) + 0.00250490825153223*std::sin(0.251519978046417*x_33 + 2.01743984222412) - 0.0352354797855084*std::sin(0.341839849948883*x_34 + 1.98831987380981) + 0.000280037090418443*std::sin(0.345679849386215*x_34 + 5.20056009292603) + 0.000913753292816591*std::sin(0.355519831180573*x_34 + 1.9975198507309) + 0.039038937281595*std::sin(0.231999978423119*x_35 - 1.14375984668732) + 0.000931530368798098*std::sin(0.321999847888947*x_35 + 1.98599982261658) - 0.000520862301049487*std::sin(0.323519825935364*x_35 + 5.18839979171753) + 0.00265372152190062*std::sin(0.323599845170975*x_35 + 1.97183978557587) + 0.000444750783201074*std::sin(0.325279831886292*x_36 + 5.12784004211426) - 0.00133842690891404*std::sin(0.343599855899811*x_36 - 7.43511962890625) - 0.00142833931464653*std::sin(0.356639832258224*x_36 + 5.1573600769043) - 0.00395681024403383*std::sin(0.36015984416008*x_36 - 4.23160028457642) - 0.000353716270992335*std::sin(0.436079859733582*x_37 + 2.03319978713989) + 0.00104133274596992*std::sin(0.3781598508358*x_38 + 5.18815994262695) - 0.000317708066209792*std::sin(0.451279848814011*x_38 + 8.45608043670654) - 0.0017488886354615*std::sin(0.371439844369888*x_39 + 5.17072010040283) - 0.000428702000293461*std::sin(0.401119858026505*x_39 - 7.40167951583862) + 0.0216873487766604*std::sin(0.409199863672256*x_39 + 1.98799991607666) - 0.00249038277904351*std::sin(0.33095982670784*x_40 - 7.4703197479248) + 0.00241842055386569*std::sin(0.373999834060669*x_40 - 4.22448015213013) - 0.000740481278688773*std::sin(0.372079849243164*x_42 - 7.41975975036621) + 0.0404754304946085*std::sin(0.386159837245941*x_42 + 1.99703979492188) - 0.000831789257867857*std::sin(0.475279837846756*x_42 + 2.04271984100342) - 0.000899102304146481*std::sin(0.244559973478317*x_43 + 8.25592041015625) + 0.000348388624129152*std::sin(0.446799874305725*x_43 + 2.02879977226257) - 0.00191998357675842*std::sin(0.451839864253998*x_43 + 2.04807996749878) + 0.00260491997823265*std::sin(0.365279853343964*x_44 - 4.22080039978027) + 0.000447455749626283*std::sin(0.370959848165512*x_44 + 8.3645601272583) + 0.00636452950391012*std::sin(0.270159959793091*x_45 - 7.5237603187561) - 0.00194408522654313*std::sin(0.366239845752716*x_45 - 7.4172797203064) - 0.000199040338532633*std::sin(0.380239844322205*x_45 + 5.16648006439209) - 0.000149769016678161*std::sin(0.703439831733704*x_46 + 2.05855989456177) - 0.00167652518116191*std::sin(0.339919835329056*x_47 + 5.1384801864624) + 0.0292895294846605*std::sin(0.462239861488342*x_48 + 5.23808002471924) + 0.000843953690148529*std::sin(0.476239860057831*x_48 - 7.34207963943481) + 0.00150330607061577*std::sin(0.163760021328926*x_49 - 7.27447986602783) - 0.00256337791616587*std::sin(0.238639980554581*x_49 - 4.35871982574463) - 0.000427212382717596*std::sin(0.326239824295044*x_49 + 8.32384014129639) - 0.033159706112226*std::sin(0.374799847602844*x_49 - 4.23487997055054) - 0.000157192617888592*std::sin(0.56063985824585*x_49 - 4.21432018280029) + 0.0491690286546604*std::sin(0.27727997303009*x_50 + 5.07631969451904) + 0.00132724155420175*std::sin(0.322959840297699*x_50 + 4.94575977325439) - 0.000462993926355102*std::sin(0.398319840431213*x_50 - 1.00463974475861) + 0.000245519316570597*std::sin(0.917439818382263*x_50 - 4.02711963653564) + 0.00602356207212181*std::sin(0.210559993982315*x_51 + 5.01375961303711) + 0.000457872323234088*std::sin(0.274559944868088*x_51 - 4.30599975585938) + 0.0841533535936855*std::sin(0.325199842453003*x_51 - 4.27367973327637) - 0.000241152751436814*std::sin(0.350959837436676*x_51 - 1.05951988697052) - 0.0602841167697563*std::sin(0.226319998502731*x_52 + 8.22552013397217) - 0.00313685313721755*std::sin(0.363839834928513*x_53 - 4.24128007888794) - 0.000759067815894968*std::sin(0.366159826517105*x_53 - 7.44087982177734) - 0.00104620963125242*std::sin(0.488159865140915*x_54 + 2.25639986991882) - 7.89286344977251e-5*std::sin(0.683279812335968*x_54 + 8.4498405456543) - 0.0919002620115177*std::sin(0.238079980015755*x_55 - 4.34976005554199) - 0.000352624714765162*std::sin(0.318879842758179*x_55 + 5.11352014541626) + 0.000300417162509271*std::sin(0.322879940271378*x_55 + 8.36727905273438) + 0.00110032122106712*std::sin(0.4129598736763*x_55 - 4.18151998519897) - 0.00559177843331125*std::sin(0.315759837627411*x_56 + 8.30768013000488) + 0.00180396836273756*std::sin(0.354159832000732*x_56 - 7.45271968841553) - 0.113395480254735*std::sin(0.304559946060181*x_57 - 4.27871990203857) - 0.000160297191286189*std::sin(0.538079857826233*x_57 + 2.13239979743958) + 0.00118956906619886*std::sin(0.313599914312363*x_58 + 5.13840007781982) + 0.00192037820224335*std::sin(0.465279877185822*x_58 + 2.05847978591919) - 0.0341544649053771*std::sin(0.498079836368561*x_58 - 1.10559988021851) + 0.00536140280510186*std::sin(0.337039858102798*x_59 + 5.13671970367432) + 0.0023544401985247*std::sin(0.369119822978973*x_59 - 7.42424011230469) + 0.000203379706256042*std::sin(0.464319854974747*x_6 - 6.90000009536743) - 0.141497728388365*std::sin(0.151360034942627*x_60 + 1.74399983882904) + 5.47594286249955e-5*std::sin(1.47391986846924*x_60 + 3.38039994239807) - 0.000652000464093441*std::sin(0.347919851541519*x_62 + 8.34496021270752) + 0.000791659405816102*std::sin(0.376559853553772*x_62 - 4.21199989318848) + 0.0881627310291978*std::sin(0.271359950304031*x_63 + 5.09839963912964) - 0.00148986695940207*std::sin(0.296799927949905*x_63 - 4.28799962997437) - 0.000337804427479464*std::sin(0.385599851608276*x_63 - 7.40111970901489) - 0.124059341817312*std::sin(0.211040005087852*x_64 + 5.00703954696655) - 0.0036515035665334*std::sin(0.241439983248711*x_64 - 4.3517599105835) + 0.00503599115713627*std::sin(0.278079956769943*x_64 - 4.28567981719971) + 0.00383146582116353*std::sin(0.521519839763641*x_65 + 8.33312034606934) - 0.00093744320947677*std::sin(0.199440002441406*x_66 + 5.00719976425171) + 0.00311476901952279*std::sin(0.186240002512932*x_67 - 4.4201602935791) + 0.000377950173470255*std::sin(0.296319931745529*x_67 - 7.49088001251221) + 0.000106811786229424*std::sin(0.319439828395844*x_68 - 7.65296030044556) - 0.00128986638083119*std::sin(0.473519861698151*x_68 + 2.26967978477478) - 0.0965748556441688*std::sin(0.298079937696457*x_69 - 7.49047994613647) + 0.000267618028887376*std::sin(0.418239861726761*x_7 - 7.17655992507935) - 2.74094967561401e-5*std::sin(0.734559834003448*x_70 + 5.98959970474243) - 0.0270224436021677*std::sin(0.271119952201843*x_71 + 5.07599973678589) + 0.00137279443299668*std::sin(0.402959853410721*x_72 - 7.19704008102417) + 0.000374464231346186*std::sin(0.498719841241837*x_72 + 8.48984050750732) - 0.000152015598854341*std::sin(0.578239858150482*x_72 - 7.01944017410278) - 0.00635596783923407*std::sin(0.275039941072464*x_73 + 5.07879972457886) + 0.000411712526341271*std::sin(0.411759853363037*x_73 + 5.19583988189697) + 0.000283886092715156*std::sin(0.305759936571121*x_75 + 5.14759969711304) - 0.00113676274874114*std::sin(0.391919851303101*x_75 + 8.38992023468018) - 0.025354636691997*std::sin(0.437039852142334*x_75 + 5.22632026672363) + 0.00329440536438205*std::sin(0.150800034403801*x_76 + 4.92391967773438) - 3.47687940593018e-5*std::sin(1.22431993484497*x_76 - 0.768399834632874) + 0.000285124406534237*std::sin(0.406159847974777*x_77 - 1.00543987751007) + 0.000381705137930271*std::sin(0.468479871749878*x_77 + 5.25504016876221) + 0.00176455739076707*std::sin(0.491839855909348*x_77 - 0.899999797344208) + 0.00746234687698865*std::sin(0.492559850215912*x_77 - 0.874159812927246) - 0.000191834504190825*std::sin(0.890239894390106*x_77 + 8.64192008972168) - 0.000468128149363148*std::sin(0.407439857721329*x_78 - 4.18200016021729) - 0.0510846185727224*std::sin(0.428879857063293*x_78 - 4.15312004089355) - 1.32538289904776e-5*std::sin(0.752559840679169*x_79 - 1.39367985725403) + 6.1056451214862e-5*std::sin(1.52543985843658*x_8 + 2.39687991142273) + 0.000150583620253005*std::sin(0.430959850549698*x_80 - 7.16616010665894) + 0.000259909728848838*std::sin(0.530399858951569*x_80 + 5.34944009780884) - 0.112629211725918*std::sin(0.207440003752708*x_81 - 7.58808040618896) + 0.003268188157422*std::sin(0.347279846668243*x_81 - 1.04183983802795) - 0.000295452944836929*std::sin(0.423119872808456*x_81 - 4.17736005783081) + 0.00515307065608574*std::sin(0.386639833450317*x_82 - 4.22040033340454) + 9.86557334839628e-5*std::sin(0.61303985118866*x_82 - 0.966639816761017) + 0.000568914617873126*std::sin(0.997999846935272*x_82 - 4.60471963882446) + 0.000110454160332323*std::sin(0.99999988079071*x_82 - 10.0) + 0.00572843846139694*std::sin(0.32575985789299*x_83 + 5.12007999420166) - 0.000185865760991769*std::sin(0.461679875850677*x_83 + 2.05015993118286) - 0.000130454582871745*std::sin(0.637919843196869*x_83 + 2.00751972198486) - 0.000304706553738729*std::sin(0.36303985118866*x_84 + 5.15488004684448) + 0.000349894932752763*std::sin(0.632639825344086*x_84 + 5.43271970748901) + 0.00628741447638439*std::sin(0.1564000248909*x_85 - 7.65104007720947) + 0.00138522371236692*std::sin(0.5065598487854*x_85 + 8.51416015625) + 0.0649352232116052*std::sin(0.155040040612221*x_86 - 1.27311992645264) - 0.000404048140873821*std::sin(0.186640009284019*x_86 + 8.16335964202881) + 0.00538836933950998*std::sin(0.249119967222214*x_86 - 7.53016042709351) - 0.00528856296832026*std::sin(0.301999926567078*x_86 - 7.48448038101196) - 0.000243037293659745*std::sin(0.489359855651855*x_86 - 4.12224006652832) + 0.00556848129279835*std::sin(0.211119994521141*x_87 + 5.01863956451416) - 0.00469941540337299*std::sin(0.32015985250473*x_87 + 5.12007999420166) + 0.0129228081180494*std::sin(0.399999856948853*x_87 + 8.40015983581543) + 5.22865084420397e-5*std::sin(0.5136798620224*x_87 + 5.15128040313721) - 0.0317990771253225*std::sin(0.279199928045273*x_88 + 5.0959997177124) - 0.000310809112259316*std::sin(0.531839847564697*x_88 + 2.15471982955933) + 0.0283314796026356*std::sin(0.501599848270416*x_89 + 8.48872089385986) + 0.00333601802856814*std::sin(0.392159849405289*x_9 - 7.39575958251953) - 0.000189207073538297*std::sin(0.53007984161377*x_9 - 4.06080007553101) + 0.000324658220530336*std::sin(0.60999983549118*x_9 + 5.19591999053955) - 0.00113282340120419*std::sin(0.238079980015755*x_90 - 7.55304002761841) - 0.00429722955490458*std::sin(0.406159847974777*x_90 - 4.18832015991211) + 0.00106104652321641*std::sin(0.196719989180565*x_91 - 7.39048004150391) - 0.0607861522598386*std::sin(0.326319843530655*x_92 - 4.21528005599976) + 0.0286490022739463*std::sin(0.353599846363068*x_92 - 7.40887975692749) + 0.000795380181902082*std::sin(0.373679846525192*x_92 + 5.19736003875732) + 0.00313700923164707*std::sin(0.375119835138321*x_92 + 1.9987998008728) - 0.00391044061889964*std::sin(0.356559842824936*x_93 + 1.99455988407135) + 0.0227613993319743*std::sin(0.392959833145142*x_94 + 5.19432020187378) - 0.000414593189236891*std::sin(0.406799852848053*x_94 - 7.39671945571899) - 0.000313083042310189*std::sin(0.45143985748291*x_94 + 2.01095986366272) + 0.00278738056340197*std::sin(0.3643998503685*x_95 - 4.23271989822388) + 0.0355577924226591*std::sin(0.346799850463867*x_96 + 5.1637601852417) + 0.00039540457810958*std::sin(0.422319859266281*x_96 - 1.19247984886169) + 0.00146264111784838*std::sin(0.440079867839813*x_96 - 4.17288017272949) - 0.000254578295437437*std::sin(0.403919845819473*x_97 - 4.20703983306885) + 0.0129529736486296*std::sin(0.437839865684509*x_97 + 5.22304010391235) + 0.00104071639791871*std::sin(0.487279862165451*x_98 + 8.24639987945557) + 0.000149667202572768*std::sin(0.600959837436676*x_98 - 7.4047999382019) - 7.28586689389353e-5*std::sin(0.687439858913422*x_98 + 2.02071976661682) + 0.000387369471202738*std::sin(0.33111983537674*x_99 + 5.1448802947998) - 0.00038010649963966*std::sin(0.446559846401215*x_99 - 7.37319993972778) - 0.00131909881882877*std::sin(0.511439859867096*x_99 + 5.16400003433228) - 0.00950638049531656*std::sin(0.531919836997986*x_99 - 1.00535976886749) + 0.358424110629432);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000224198571391276*x_1 + 0.00305558548391681*x_10 - 0.000298877943110246*x_100 - 0.00281014185762268*x_101 + 0.000547358002932374*x_102 + 0.000147383098838927*x_103 + 0.000124187610086857*x_104 + 0.000399371930692183*x_105 + 0.00013399476810144*x_106 - 0.000447854769351393*x_107 + 0.000339356220481486*x_109 - 0.0142990512050336*x_11 - 0.000901910870556837*x_111 + 0.000111906926178614*x_112 - 0.00184215885245139*x_113 + 0.0017262256013091*x_114 - 7.08351945472696e-6*x_115 + 0.00528517925856963*x_116 - 1.8203092578508e-5*x_117 + 0.000172287075451638*x_119 - 0.00562892901931241*x_12 + 0.000101847799277176*x_120 + 0.00565895568365758*x_13 - 0.000940556594587068*x_14 + 0.000132767168914269*x_16 + 0.000398799541983959*x_17 - 8.78538556345088e-5*x_18 + 8.25153644416621e-5*x_19 + 0.000704593844120262*x_2 - 0.00482035760260006*x_20 - 0.000169384135106197*x_21 + 0.000422017215427057*x_22 - 0.00109664711205426*x_23 + 0.00111647216211819*x_24 - 0.0015600383448574*x_25 - 0.000258400577368188*x_27 - 0.00053034103244408*x_28 - 0.000682632900239747*x_29 - 0.000107833200603786*x_3 - 1.41580575650396e-5*x_30 - 0.000167002778467029*x_31 + 6.74888107156467e-5*x_32 + 0.00725735565711111*x_33 - 0.000174881828628394*x_34 + 8.73910873726688e-5*x_35 + 3.62937853308985e-6*x_36 + 2.98247712571996e-5*x_37 + 0.0028737224444982*x_38 - 6.66312058735753e-5*x_39 - 0.00131700981045784*x_4 + 0.000913005345482117*x_40 - 0.00154412033383324*x_41 + 0.000393146699219962*x_42 - 0.000158768707015085*x_43 + 0.00122992020899571*x_44 - 0.00146123851016954*x_45 + 0.0001883036539638*x_46 + 0.0015253041303528*x_47 + 0.00152992718050939*x_48 + 0.000307238372424404*x_5 - 0.00351835934968491*x_50 + 0.000115342341182147*x_51 + 0.000439486012093239*x_52 + 0.000925397110641489*x_53 + 0.000666713421398398*x_54 - 0.00127462893456478*x_56 + 3.16275672474246e-5*x_57 - 4.79027141074307e-5*x_58 + 3.71925188820531e-5*x_59 + 1.71564325223607e-5*x_6 + 0.000758935157215677*x_60 + 0.00128401008483789*x_61 - 0.00351568027223928*x_62 - 0.000340939029397575*x_63 + 3.33224501322321e-5*x_64 - 0.00322450834586355*x_65 - 9.35931527101386e-6*x_66 + 5.11245255896043e-6*x_67 + 2.28819301849894e-5*x_68 + 2.36257991742866e-5*x_69 - 4.9565898502412e-5*x_7 - 0.00133098751217075*x_70 - 0.000481800386446783*x_71 - 0.000155445668355792*x_72 + 1.55646126515303e-5*x_73 - 0.000480421961269488*x_74 - 0.000107232918120221*x_75 + 3.3575737227357e-6*x_76 - 0.000174195550407801*x_78 + 0.000232809270387325*x_79 - 0.0127867108690098*x_8 - 1.84680821132411e-5*x_80 + 6.33931189820384e-5*x_82 - 8.26485447995445e-5*x_83 - 5.22556179124005e-5*x_84 - 1.94990831540021e-5*x_85 - 1.37779326610251e-5*x_88 + 0.00222457949002008*x_89 + 0.000337686747496608*x_9 - 0.000374429933242217*x_90 + 0.000447608252760376*x_91 + 2.50873913479602e-5*x_92 + 0.00417440469386557*x_93 - 0.0001146899455578*x_94 + 0.00106508696838596*x_95 + 4.44734624538565e-6*x_96 + 0.000131921270527276*x_97 - 8.31664000246936e-6*x_98 - 2.00371806589147e-5*x_99 + 0.00040786606132915*std::pow(-2.17063999176025*x_108 - 3.15591979026794, 2) + 1.46471638628041e-6*std::pow(-6.25112009048462*x_110 - 8.66423988342285, 2) - 2.17462521759553e-5*std::pow(-3.51968002319336*x_110 - 5.79135990142822, 2) + 4.49684638835806e-7*std::pow(-6.72800016403198*x_118 - 8.75936031341553, 2) + 3.93894241124151e-6*std::pow(-5.40447998046875*x_13 - 8.20039939880371, 2) + 3.97348183348656e-6*std::pow(-5.76688003540039*x_14 - 8.3450403213501, 2) - 4.74631406825888e-6*std::pow(-6.59999990463257*x_15 - 9.99973964691162, 2) - 6.11874456886707e-6*std::pow(-5.93840026855469*x_15 - 8.39935970306396, 2) - 0.000164794102986811*std::pow(-6.46104001998901*x_17 - 9.48311996459961, 2) + 7.81141232010494e-7*std::pow(-6.29008007049561*x_17 - 9.74312019348145, 2) - 2.47982936560275e-5*std::pow(-4.0065598487854*x_17 - 6.20688009262085, 2) + 8.39871714234705e-7*std::pow(-4.49232006072998*x_18 - 7.14559984207153, 2) - 1.57481924848686e-5*std::pow(-3.45199990272522*x_18 - 5.2752799987793, 2) - 4.62434856332135e-5*std::pow(-4.59431982040405*x_19 - 7.38895988464355, 2) - 0.000122925812790003*std::pow(-5.7294397354126*x_22 - 9.58975982666016, 2) - 3.07892863682167e-6*std::pow(-5.72079992294312*x_22 - 8.28072071075439, 2) + 4.56919818788212e-6*std::pow(-5.72383975982666*x_24 - 8.38159942626953, 2) - 3.4893459066662e-6*std::pow(-1.62839984893799*x_25 - 3.46207976341248, 2) - 3.25250641072819e-6*std::pow(-6.12911987304688*x_27 - 7.76647996902466, 2) - 1.36237878217593e-5*std::pow(-5.51200008392334*x_4 - 9.19999980926514, 2) + 2.05789056908488e-5*std::pow(-4.58247995376587*x_4 - 7.77960014343262, 2) + 1.30892679899375e-6*std::pow(-3.95839977264404*x_41 - 9.7038402557373, 2) - 0.000147131919568188*std::pow(-4.11559963226318*x_5 - 6.37784004211426, 2) + 2.98999651321733e-5*std::pow(-3.50720000267029*x_5 - 5.56712007522583, 2) - 6.30070275197844e-7*std::pow(-7.74287986755371*x_55 - 9.17280006408691, 2) - 0.000277461864195986*std::pow(-3.28671979904175*x_6 - 5.13399982452393, 2) - 2.59116132288195e-5*std::pow(-3.16847991943359*x_6 - 5.34823989868164, 2) + 1.44969673129538e-5*std::pow(-5.31584024429321*x_64 - 8.99736022949219, 2) + 8.62192157342692e-8*std::pow(-7.26232004165649*x_66 - 9.61312007904053, 2) - 2.86330144594609e-6*std::pow(-5.60232019424438*x_66 - 7.61072015762329, 2) - 5.99137479425525e-5*std::pow(-1.15495979785919*x_66 - 1.92279982566833, 2) - 1.1865442258217e-6*std::pow(-5.68575954437256*x_67 - 8.73624038696289, 2) + 4.03053514959985e-6*std::pow(-5.72591972351074*x_7 - 9.18144035339355, 2) - 8.5677809448812e-6*std::pow(-5.31304025650024*x_7 - 8.78575992584229, 2) + 2.62063881989568e-6*std::pow(-5.07807970046997*x_7 - 8.11320018768311, 2) - 1.56129555318965e-6*std::pow(-7.10591983795166*x_70 - 9.93296051025391, 2) - 8.58435342309684e-7*std::pow(-5.73503971099854*x_70 - 6.75536012649536, 2) + 1.61661509854713e-7*std::pow(-5.9539999961853*x_72 - 9.1340799331665, 2) - 5.37536878495034e-6*std::pow(-3.84744000434875*x_75 - 5.66079998016357, 2) + 3.18660211187673e-7*std::pow(-5.71463966369629*x_78 - 9.38111972808838, 2) + 3.55941521820513e-7*std::pow(-4.57719993591309*x_8 - 8.7577600479126, 2) + 4.11145039368285e-5*std::pow(-2.51511979103088*x_8 - 5.22399997711182, 2) + 2.75482226310276e-6*std::pow(-6.33008003234863*x_81 - 8.87975978851318, 2) - 2.1197718800048e-6*std::pow(-4.91448020935059*x_81 - 6.35383987426758, 2) + 2.69009873311641e-7*std::pow(-6.81415987014771*x_85 - 8.80992031097412, 2) - 6.88966441952724e-5*std::pow(-2.30607986450195*x_85 - 3.7727198600769, 2) + 1.51665577078482e-5*std::pow(-5.80800008773804*x_87 - 8.01583957672119, 2) - 1.70698790627639e-5*std::pow(-9.5959997177124*x_88 - 9.99096012115479, 2) + 1.99915967992915e-6*std::pow(-6.0*x_9 - 9.99997997283936, 2) + 8.6446668424992e-5*std::exp(0.57999986410141*x_106) - 0.00011890737431524*std::exp(0.719279825687408*x_15) + 0.000239827401374914*std::exp(0.612959861755371*x_2) - 6.58495249198379e-5*std::exp(0.513279855251312*x_76) + 0.000225745815187323*std::exp(0.612399816513062*x_76) - 4.85671471713744e-5*std::log(0.681119859218597*x_91 + 1.02415990829468) + 0.00512086980514746*std::sin(0.299839943647385*x_1 - 7.41623973846436) + 0.00568107564944123*std::sin(0.305919945240021*x_1 + 1.97895979881287) + 0.0688608304183365*std::sin(0.351679861545563*x_1 - 4.35207986831665) + 0.013587469714097*std::sin(0.212640002369881*x_10 + 5.01351976394653) + 0.0010434696465494*std::sin(0.308879911899567*x_10 - 4.25407981872559) + 0.000636319246415259*std::sin(0.41143986582756*x_100 - 0.988239824771881) + 0.00322666312054667*std::sin(0.513359844684601*x_100 - 7.22968006134033) - 0.00043587809511988*std::sin(0.303999930620193*x_101 - 4.3010401725769) + 0.000315933713833639*std::sin(0.353999853134155*x_101 + 1.96231985092163) - 0.0030548027354957*std::sin(0.363119840621948*x_102 + 5.16175985336304) - 0.00056065939393906*std::sin(0.371919840574265*x_102 - 7.40231990814209) + 0.00036213486016496*std::sin(0.411119878292084*x_102 - 1.00239980220795) - 0.0199066179099004*std::sin(0.388159841299057*x_103 - 7.40567970275879) + 0.00160580857149617*std::sin(0.437279850244522*x_103 + 2.00919985771179) - 0.00422134049090993*std::sin(0.136880040168762*x_104 - 7.68391990661621) + 0.000221945920578458*std::sin(0.332559853792191*x_104 + 5.15224027633667) + 0.00220793181188531*std::sin(0.34215983748436*x_104 - 7.4378399848938) + 0.00140051399034225*std::sin(0.345919847488403*x_105 + 8.34463977813721) + 0.00143865884403901*std::sin(0.376319825649261*x_105 + 5.18792009353638) + 0.0541269464686588*std::sin(0.364719837903976*x_106 + 1.98247981071472) + 3.40688403816785e-5*std::sin(0.700959861278534*x_106 - 0.957199811935425) - 0.000249893203332858*std::sin(0.385039836168289*x_107 + 5.18535995483398) - 0.00177746947400709*std::sin(0.296479940414429*x_108 + 5.10391998291016) + 0.000388017559982801*std::sin(0.367439836263657*x_108 - 4.22936010360718) - 0.000322849658259284*std::sin(0.708239853382111*x_108 - 4.02719974517822) + 4.47940213284682e-5*std::sin(0.85207986831665*x_108 + 8.40624046325684) - 0.000422066170778336*std::sin(0.397519826889038*x_109 + 5.19832038879395) + 8.23452147540984e-5*std::sin(0.327279835939407*x_11 - 1.06439983844757) - 0.000284219897521812*std::sin(0.597919821739197*x_110 - 7.19352006912231) + 6.48839954631771e-5*std::sin(0.609279870986938*x_110 + 2.20576000213623) - 0.000131672534538081*std::sin(0.816159844398499*x_110 + 5.6101598739624) + 0.00124515563110537*std::sin(0.339759826660156*x_111 - 1.04287981987) - 0.000739824356134247*std::sin(0.361119836568832*x_111 + 1.97559976577759) - 0.000313792279375131*std::sin(0.368559837341309*x_111 + 5.17408037185669) - 0.0149858170532623*std::sin(0.268239974975586*x_112 + 5.07903957366943) + 0.00189488305749705*std::sin(0.331439822912216*x_112 - 7.43304014205933) - 0.000504371580090964*std::sin(0.369279861450195*x_112 + 1.9748797416687) + 0.000158707851053924*std::sin(0.438159853219986*x_112 - 1.17311990261078) + 0.000328936738846444*std::sin(0.327199816703796*x_113 + 1.92543983459473) + 0.00116622607230531*std::sin(0.409679859876633*x_114 + 5.21720027923584) - 9.59885308051899e-5*std::sin(0.469839870929718*x_114 - 0.924239873886108) - 0.000348771122642019*std::sin(0.360399842262268*x_115 + 5.16368007659912) - 9.49030706105566e-5*std::sin(0.516719877719879*x_115 - 7.04375982284546) - 0.000253690453399137*std::sin(1.55183982849121*x_115 + 1.80663990974426) + 0.00121036650232718*std::sin(0.259839832782745*x_116 + 8.09823989868164) + 0.000303930041326035*std::sin(0.288879930973053*x_117 + 8.30072021484375) + 0.0168544168580788*std::sin(0.394879847764969*x_117 - 7.39591979980469) + 0.000633037087328564*std::sin(0.542399823665619*x_117 - 7.43400001525879) - 0.000111949538063382*std::sin(0.976639807224274*x_117 - 7.98496007919312) - 0.0459391531366676*std::sin(0.239919975399971*x_118 - 1.36119985580444) - 0.000983788895413326*std::sin(0.364959836006165*x_118 + 1.96375977993011) + 0.00282524018993717*std::sin(0.384399831295013*x_118 - 7.41703987121582) + 0.000126784510209972*std::sin(0.427439838647842*x_118 + 8.43224048614502) + 0.00197910148442828*std::sin(0.353999853134155*x_119 + 5.16960000991821) + 0.0120592897426389*std::sin(0.429279863834381*x_119 + 2.01151990890503) + 0.00344317963736357*std::sin(0.283679932355881*x_12 - 7.49535989761353) + 0.000580411125255958*std::sin(0.342879861593246*x_12 + 2.14535975456238) + 0.00255581646043523*std::sin(0.169520005583763*x_120 - 7.63551998138428) + 0.000258886691522886*std::sin(0.289919942617416*x_120 - 7.49015998840332) + 0.0101501399141623*std::sin(0.322559833526611*x_120 + 5.33591985702515) + 0.0504355986095244*std::sin(0.142560034990311*x_14 - 4.49032020568848) - 0.0031611814807857*std::sin(0.213919997215271*x_14 + 5.01495981216431) - 0.00162538061765919*std::sin(0.281919956207275*x_15 - 4.2772798538208) - 0.0109484179792293*std::sin(0.510799825191498*x_15 - 0.896399855613708) - 0.000418094547320659*std::sin(0.326799839735031*x_16 - 4.26232004165649) + 0.0210433072219061*std::sin(0.338079839944839*x_16 - 4.24959993362427) - 0.00619036578600485*std::sin(0.354879856109619*x_16 + 5.17128038406372) - 0.000863378724788876*std::sin(0.37271985411644*x_16 - 4.2260799407959) + 0.0156513880769434*std::sin(0.134800046682358*x_18 + 4.90247964859009) - 0.0790144663778297*std::sin(0.208719998598099*x_18 - 7.57600021362305) + 0.00122307596036748*std::sin(0.213279992341995*x_19 + 5.02807998657227) - 0.00097571167590435*std::sin(0.295359939336777*x_21 + 8.31112003326416) + 0.00210778727405432*std::sin(0.324959844350815*x_21 - 4.26024007797241) - 0.000499744578779888*std::sin(0.330719828605652*x_21 - 4.2402400970459) - 0.0126018252237431*std::sin(0.161600023508072*x_23 + 4.94087982177734) + 0.00316619640316051*std::sin(0.183360010385513*x_23 - 4.41607999801636) - 0.0020665478702661*std::sin(0.158160030841827*x_24 + 4.95127964019775) + 0.0015318818451784*std::sin(0.241919979453087*x_24 - 4.34632015228271) - 0.0601249296031222*std::sin(0.316399842500687*x_26 - 4.28280019760132) + 0.00192947199808161*std::sin(0.321759849786758*x_26 - 4.27472019195557) + 0.000785034247255421*std::sin(0.324319839477539*x_26 - 4.26200008392334) - 0.0077120778622205*std::sin(0.33095982670784*x_26 - 4.2707200050354) - 0.000324474332472327*std::sin(0.398319840431213*x_26 - 1.17639982700348) - 0.00812262960692978*std::sin(0.214399993419647*x_27 - 7.57800006866455) + 0.00111119271660676*std::sin(0.305119842290878*x_27 - 4.31576013565063) + 0.00154507449642494*std::sin(0.291999936103821*x_28 - 4.28151988983154) - 0.00379316410080664*std::sin(0.320719838142395*x_28 + 8.30399990081787) - 0.000175233746645059*std::sin(1.78887987136841*x_29 - 0.204079851508141) - 0.00207409648868249*std::sin(0.293919950723648*x_3 - 1.08967983722687) - 0.239876164814047*std::sin(0.317679852247238*x_3 + 8.32208061218262) + 0.000787814049709691*std::sin(0.343599855899811*x_3 - 1.05495977401733) + 0.0450009993093135*std::sin(0.2880799472332*x_30 - 4.29983997344971) - 0.0954233570641747*std::sin(0.276319950819016*x_32 - 7.44519996643066) - 0.00202532036727751*std::sin(0.251519978046417*x_33 + 2.01743984222412) + 0.000225128617550808*std::sin(0.341839849948883*x_34 + 1.98831987380981) + 0.000447107541970118*std::sin(0.345679849386215*x_34 + 5.20056009292603) - 0.0488132744236551*std::sin(0.355519831180573*x_34 + 1.9975198507309) - 0.000249429893799056*std::sin(0.231999978423119*x_35 - 1.14375984668732) - 0.0497629369804495*std::sin(0.321999847888947*x_35 + 1.98599982261658) - 0.000831609351386828*std::sin(0.323519825935364*x_35 + 5.18839979171753) - 0.00214564195878247*std::sin(0.323599845170975*x_35 + 1.97183978557587) + 0.00071008961409071*std::sin(0.325279831886292*x_36 + 5.12784004211426) + 0.0714996055438997*std::sin(0.343599855899811*x_36 - 7.43511962890625) + 0.0011548705241269*std::sin(0.356639832258224*x_36 + 5.1573600769043) - 0.00172895876602921*std::sin(0.36015984416008*x_36 - 4.23160028457642) + 0.0188957452080301*std::sin(0.436079859733582*x_37 + 2.03319978713989) - 0.000841959947329732*std::sin(0.3781598508358*x_38 + 5.18815994262695) - 0.000507253065423881*std::sin(0.451279848814011*x_38 + 8.45608043670654) - 0.000764190383314267*std::sin(0.371439844369888*x_39 + 5.17072010040283) + 0.0229015299324289*std::sin(0.401119858026505*x_39 - 7.40167951583862) - 0.000138566095258331*std::sin(0.409199863672256*x_39 + 1.98799991607666) + 0.0020135759310261*std::sin(0.33095982670784*x_40 - 7.4703197479248) + 0.00105674752102557*std::sin(0.373999834060669*x_40 - 4.22448015213013) - 0.00118225326471833*std::sin(0.372079849243164*x_42 - 7.41975975036621) - 0.000258608021445834*std::sin(0.386159837245941*x_42 + 1.99703979492188) + 0.000672535500736178*std::sin(0.475279837846756*x_42 + 2.04271984100342) - 0.00143550777715168*std::sin(0.244559973478317*x_43 + 8.25592041015625) - 0.0186111389686772*std::sin(0.446799874305725*x_43 + 2.02879977226257) + 0.00155238493883699*std::sin(0.451839864253998*x_43 + 2.04807996749878) - 0.0021061839226309*std::sin(0.365279853343964*x_44 - 4.22080039978027) + 0.000714408366609098*std::sin(0.370959848165512*x_44 + 8.3645601272583) + 0.00278103027407722*std::sin(0.270159959793091*x_45 - 7.5237603187561) + 0.00157187210455019*std::sin(0.366239845752716*x_45 - 7.4172797203064) - 0.000317788034368053*std::sin(0.380239844322205*x_45 + 5.16648006439209) + 0.000121094351331974*std::sin(0.703439831733704*x_46 + 2.05855989456177) + 0.00135553890789566*std::sin(0.339919835329056*x_47 + 5.1384801864624) - 0.000187138399185561*std::sin(0.462239861488342*x_48 + 5.23808002471924) - 0.000682370939794412*std::sin(0.476239860057831*x_48 - 7.34207963943481) + 0.000656881186742564*std::sin(0.163760021328926*x_49 - 7.27447986602783) + 0.00207259547309344*std::sin(0.238639980554581*x_49 - 4.35871982574463) - 0.000682087783624117*std::sin(0.326239824295044*x_49 + 8.32384014129639) + 0.000211865961266314*std::sin(0.374799847602844*x_49 - 4.23487997055054) + 0.00839732831026716*std::sin(0.56063985824585*x_49 - 4.21432018280029) - 0.000314153674498632*std::sin(0.27727997303009*x_50 + 5.07631969451904) - 0.00107312886624793*std::sin(0.322959840297699*x_50 + 4.94575977325439) - 0.000739216637518993*std::sin(0.398319840431213*x_50 - 1.00463974475861) + 0.000107281559749876*std::sin(0.917439818382263*x_50 - 4.02711963653564) + 0.0026320419239258*std::sin(0.210559993982315*x_51 + 5.01375961303711) - 0.0244598268928025*std::sin(0.274559944868088*x_51 - 4.30599975585938) - 0.000537677598606235*std::sin(0.325199842453003*x_51 - 4.27367973327637) - 0.000385024761445471*std::sin(0.350959837436676*x_51 - 1.05951988697052) + 0.000385170854810622*std::sin(0.226319998502731*x_52 + 8.22552013397217) - 0.00137067218159279*std::sin(0.363839834928513*x_53 - 4.24128007888794) + 0.000613737252347084*std::sin(0.366159826517105*x_53 - 7.44087982177734) - 0.000457149370704721*std::sin(0.488159865140915*x_54 + 2.25639986991882) - 0.00012601754899183*std::sin(0.683279812335968*x_54 + 8.4498405456543) + 0.000587174605402111*std::sin(0.238079980015755*x_55 - 4.34976005554199) - 0.000563001026831775*std::sin(0.318879842758179*x_55 + 5.11352014541626) - 0.016048473379438*std::sin(0.322879940271378*x_55 + 8.36727905273438) - 0.000889654532540961*std::sin(0.4129598736763*x_55 - 4.18151998519897) - 0.00244337073139764*std::sin(0.315759837627411*x_56 + 8.30768013000488) - 0.00145858191202882*std::sin(0.354159832000732*x_56 - 7.45271968841553) + 0.00072451312885933*std::sin(0.304559946060181*x_57 - 4.27871990203857) - 0.000255930680730861*std::sin(0.538079857826233*x_57 + 2.13239979743958) - 0.0635475261547554*std::sin(0.313599914312363*x_58 + 5.13840007781982) - 0.00155270400961797*std::sin(0.465279877185822*x_58 + 2.05847978591919) + 0.000218221733154816*std::sin(0.498079836368561*x_58 - 1.10559988021851) + 0.00234270632312264*std::sin(0.337039858102798*x_59 + 5.13671970367432) - 0.00190366081659563*std::sin(0.369119822978973*x_59 - 7.42424011230469) + 0.000324716273886679*std::sin(0.464319854974747*x_6 - 6.90000009536743) + 0.000904065679609496*std::sin(0.151360034942627*x_60 + 1.74399983882904) - 4.4275228853928e-5*std::sin(1.47391986846924*x_60 + 3.38039994239807) - 0.00104098469395108*std::sin(0.347919851541519*x_62 + 8.34496021270752) - 0.00064008888052702*std::sin(0.376559853553772*x_62 - 4.21199989318848) - 0.000563294550746262*std::sin(0.271359950304031*x_63 + 5.09839963912964) - 0.0023787233079925*std::sin(0.296799927949905*x_63 - 4.28799962997437) + 0.0180457245404319*std::sin(0.385599851608276*x_63 - 7.40111970901489) + 0.00079264730571602*std::sin(0.211040005087852*x_64 + 5.00703954696655) - 0.0015955526576146*std::sin(0.241439983248711*x_64 - 4.3517599105835) - 0.00407180400868517*std::sin(0.278079956769943*x_64 - 4.28567981719971) - 2.44802287002339e-5*std::sin(0.521519839763641*x_65 + 8.33312034606934) + 0.0500788046407254*std::sin(0.199440002441406*x_66 + 5.00719976425171) - 0.16639291602179*std::sin(0.186240002512932*x_67 - 4.4201602935791) + 0.000603435683448083*std::sin(0.296319931745529*x_67 - 7.49088001251221) - 0.00570595266127723*std::sin(0.319439828395844*x_68 - 7.65296030044556) - 0.000563617067436351*std::sin(0.473519861698151*x_68 + 2.26967978477478) + 0.000617041796328326*std::sin(0.298079937696457*x_69 - 7.49047994613647) - 0.0142963230748315*std::sin(0.418239861726761*x_7 - 7.17655992507935) - 4.37620341754152e-5*std::sin(0.734559834003448*x_70 + 5.98959970474243) + 0.000172653399585684*std::sin(0.271119952201843*x_71 + 5.07599973678589) + 0.000599853119685113*std::sin(0.402959853410721*x_72 - 7.19704008102417) + 0.000597870024226963*std::sin(0.498719841241837*x_72 + 8.48984050750732) + 0.00812076870407804*std::sin(0.578239858150482*x_72 - 7.01944017410278) + 0.00513905892987791*std::sin(0.275039941072464*x_73 + 5.07879972457886) - 0.0219939415703826*std::sin(0.411759853363037*x_73 + 5.19583988189697) + 0.000453252863482169*std::sin(0.305759936571121*x_75 + 5.14759969711304) + 0.000919118992234344*std::sin(0.391919851303101*x_75 + 8.38992023468018) + 0.000161997348743917*std::sin(0.437039852142334*x_75 + 5.22632026672363) + 0.00525985140940111*std::sin(0.150800034403801*x_76 + 4.92391967773438) + 0.00185737080143897*std::sin(1.22431993484497*x_76 - 0.768399834632874) + 0.000455229956755813*std::sin(0.406159847974777*x_77 - 1.00543987751007) - 0.0203909280471937*std::sin(0.468479871749878*x_77 + 5.25504016876221) + 0.00077103696684179*std::sin(0.491839855909348*x_77 - 0.899999797344208) - 4.76788693194404e-5*std::sin(0.492559850215912*x_77 - 0.874159812927246) + 0.000155106011665937*std::sin(0.890239894390106*x_77 + 8.64192008972168) + 0.0250076995617326*std::sin(0.407439857721329*x_78 - 4.18200016021729) + 0.00032639287523246*std::sin(0.428879857063293*x_78 - 4.15312004089355) + 0.00070802786349711*std::sin(0.752559840679169*x_79 - 1.39367985725403) - 4.93666281483581e-5*std::sin(1.52543985843658*x_8 + 2.39687991142273) + 0.000240421982001312*std::sin(0.430959850549698*x_80 - 7.16616010665894) - 0.0138845408486234*std::sin(0.530399858951569*x_80 + 5.34944009780884) + 0.00071961724052134*std::sin(0.207440003752708*x_81 - 7.58808040618896) + 0.00142806003202395*std::sin(0.347279846668243*x_81 - 1.04183983802795) + 0.0157832817555677*std::sin(0.423119872808456*x_81 - 4.17736005783081) + 0.00225167398316389*std::sin(0.386639833450317*x_82 - 4.22040033340454) - 0.00527025120443125*std::sin(0.61303985118866*x_82 - 0.966639816761017) - 3.63494302350606e-6*std::sin(0.997999846935272*x_82 - 4.60471963882446) - 8.93066883526573e-5*std::sin(0.99999988079071*x_82 - 10.0) - 0.00463167586336395*std::sin(0.32575985789299*x_83 + 5.12007999420166) - 0.00029675348865131*std::sin(0.461679875850677*x_83 + 2.05015993118286) + 0.00696896569741841*std::sin(0.637919843196869*x_83 + 2.00751972198486) + 0.0162776153511715*std::sin(0.36303985118866*x_84 + 5.15488004684448) + 0.000152889290580526*std::sin(0.632639825344086*x_84 + 5.43271970748901) - 0.00508363074326074*std::sin(0.1564000248909*x_85 - 7.65104007720947) + 0.000605284189207592*std::sin(0.5065598487854*x_85 + 8.51416015625) - 0.000414887979984146*std::sin(0.155040040612221*x_86 - 1.27311992645264) - 0.000645103728344525*std::sin(0.186640009284019*x_86 + 8.16335964202881) - 0.00435671612445194*std::sin(0.249119967222214*x_86 - 7.53016042709351) - 0.00231087839442437*std::sin(0.301999926567078*x_86 - 7.48448038101196) + 0.0129832047707617*std::sin(0.489359855651855*x_86 - 4.12224006652832) - 0.00450234397615547*std::sin(0.211119994521141*x_87 + 5.01863956451416) - 0.00205344582018449*std::sin(0.32015985250473*x_87 + 5.12007999420166) - 8.25671721855577e-5*std::sin(0.399999856948853*x_87 + 8.40015983581543) + 8.3480699762979e-5*std::sin(0.5136798620224*x_87 + 5.15128040313721) + 0.000203172549833128*std::sin(0.279199928045273*x_88 + 5.0959997177124) - 0.000496238187579117*std::sin(0.531839847564697*x_88 + 2.15471982955933) - 0.000181017170049532*std::sin(0.501599848270416*x_89 + 8.48872089385986) + 0.00145769881758198*std::sin(0.392159849405289*x_9 - 7.39575958251953) - 0.000302088232121898*std::sin(0.53007984161377*x_9 - 4.06080007553101) - 0.0173434459139331*std::sin(0.60999983549118*x_9 + 5.19591999053955) - 0.00180866715063283*std::sin(0.238079980015755*x_90 - 7.55304002761841) - 0.00187770761051653*std::sin(0.406159847974777*x_90 - 4.18832015991211) - 0.0566817712408765*std::sin(0.196719989180565*x_91 - 7.39048004150391) + 0.000388378489743698*std::sin(0.326319843530655*x_92 - 4.21528005599976) + 0.0125184025931537*std::sin(0.353599846363068*x_92 - 7.40887975692749) - 0.0424897085411829*std::sin(0.373679846525192*x_92 + 5.19736003875732) + 0.00500855256210346*std::sin(0.375119835138321*x_92 + 1.9987998008728) - 0.00170869720054875*std::sin(0.356559842824936*x_93 + 1.99455988407135) - 0.000145428482777088*std::sin(0.392959833145142*x_94 + 5.19432020187378) + 0.0221478283903277*std::sin(0.406799852848053*x_94 - 7.39671945571899) - 0.000499868746924447*std::sin(0.45143985748291*x_94 + 2.01095986366272) - 0.00225371073888964*std::sin(0.3643998503685*x_95 - 4.23271989822388) - 0.000227187956571096*std::sin(0.346799850463867*x_96 + 5.1637601852417) - 0.0211227607400881*std::sin(0.422319859266281*x_96 - 1.19247984886169) - 0.00118260492941561*std::sin(0.440079867839813*x_96 - 4.17288017272949) + 0.0135997323294881*std::sin(0.403919845819473*x_97 - 4.20703983306885) - 8.27599075829058e-5*std::sin(0.437839865684509*x_97 + 5.22304010391235) - 0.000841461604821305*std::sin(0.487279862165451*x_98 + 8.24639987945557) + 0.000238958828474698*std::sin(0.600959837436676*x_98 - 7.4047999382019) + 0.00389215582479148*std::sin(0.687439858913422*x_98 + 2.02071976661682) + 0.000618474545085883*std::sin(0.33111983537674*x_99 + 5.1448802947998) + 0.0203055277863167*std::sin(0.446559846401215*x_99 - 7.37319993972778) - 0.000576390406770613*std::sin(0.511439859867096*x_99 + 5.16400003433228) + 6.0738730162056e-5*std::sin(0.531919836997986*x_99 - 1.00535976886749) + 0.135188052993799);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
