
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00215246950402558*x_1 - 23.9361990924324*x_10 - 14.3103947727019*x_100 - 6.80535892953363*x_101 + 2.74520896122279*x_102 - 4.47108688757726*x_103 + 559.539032767306*x_104 - 70.9506091707899*x_105 + 110.617855411985*x_106 + 22.6097456210376*x_107 + 20.6967590480409*x_108 + 18.2157107513664*x_109 - 15.602158164868*x_110 - 91.039110505102*x_111 - 40.6001172490521*x_112 - 12.0686876898166*x_113 + 54.2578549042083*x_114 - 34.7650789203824*x_115 - 24.4616118326479*x_116 - 60.2088311726198*x_117 - 45.9154744106795*x_118 + 58.6821003120767*x_119 + 1.13448490298065*x_12 + 20.134325922123*x_120 - 85.9153350980361*x_13 + 28.6562044531428*x_14 + 0.00642478382407664*x_16 + 0.000921979724593511*x_17 - 61.6340660922687*x_18 - 0.00161065452632879*x_19 + 6.57075291244709*x_2 - 3.81754563988505*x_20 - 24.413386180641*x_21 - 2.31596874221897*x_22 + 10.7958915757047*x_24 - 37.7294327488065*x_25 + 121.210937365135*x_26 - 11.2195284390488*x_27 - 19.8416041375136*x_28 + 89.2530826261831*x_29 - 21.9013357947206*x_3 + 13.5681185634952*x_30 - 0.477211195827956*x_31 + 41.08628898796*x_32 - 0.115986348764807*x_33 + 119.822457613731*x_34 - 447.501376418438*x_35 + 226.067414323808*x_36 + 15.629771637821*x_37 + 1017.70648991875*x_38 - 321.02081932022*x_39 - 0.00700698278876377*x_4 - 3725.88789940156*x_40 - 55.131167820323*x_42 - 67.9655343424444*x_43 + 36.7635187125169*x_44 - 153.680120686415*x_45 + 0.821016529751715*x_46 + 361.631360061023*x_47 - 132.595131515263*x_48 - 12.6972188045403*x_49 + 17.056028320302*x_5 + 40.258043968201*x_52 - 21.1183432700075*x_53 + 4.51340788507213*x_54 + 0.00848210602997373*x_55 + 13.8396895043431*x_56 - 93.5421031340592*x_59 - 74.2335106902712*x_6 - 32.739443422496*x_61 + 12.5918175664338*x_62 - 15.7957682192285*x_63 - 19.9513726104573*x_64 - 16.1445628172873*x_65 - 0.639604942953072*x_66 - 7.70509256867806*x_67 + 33.0262911054979*x_68 - 27.7605568749494*x_69 - 3.31948501279342*x_7 - 10.1212330219209*x_70 - 45.0951222023569*x_71 - 0.821619810051381*x_72 - 67.5135553013053*x_73 + 39.6575988273869*x_74 + 22.4679176629268*x_75 + 3.1526173976286*x_76 + 8.16400764649473*x_77 - 31.1614014642746*x_78 + 54.6907654670919*x_79 - 23.0064237433456*x_8 + 9.56565546362254*x_80 + 13.765724637376*x_81 + 24.2917887490864*x_82 + 17.1253247781157*x_83 - 19.9620471466376*x_84 - 69.1019846589608*x_85 + 59.7783972381616*x_86 - 164.616847204507*x_87 + 185.508589595771*x_88 - 34.7476309611865*x_89 + 10.2136051192673*x_9 + 29.181327872817*x_90 + 44.2685361621846*x_91 + 11.2160146862357*x_92 + 2.20056705600928*x_93 - 23.7092473259245*x_94 - 28.615628088139*x_95 - 30.6152197024248*x_96 + 12.0938914738822*x_97 - 56.2176727706207*x_98 + 53.3000411631883*x_99 - 2.383006497594e-5*std::pow(-9.51239967346191*x_16 - 6.14495992660522, 2) + 0.40137341703269*std::pow(-9.43984031677246*x_18 - 3.81256008148193, 2) + 0.0868952477856816*std::exp(1.24503993988037*x_1) + 10.1890187092205*std::exp(1.2720799446106*x_1) + 0.000152588597754799*std::exp(1.29311990737915*x_1) + 0.453948846154653*std::exp(1.79351997375488*x_1) - 0.485284892764785*std::exp(0.504559814929962*x_10) + 0.000259456758577098*std::exp(0.782479882240295*x_10) - 0.991263187616303*std::exp(0.861839890480042*x_10) - 0.00107834755456317*std::exp(0.880719900131226*x_11) - 0.209864574469401*std::exp(0.926479816436768*x_11) - 14.1556597668767*std::exp(0.940879821777344*x_11) + 0.518444132302199*std::exp(0.993199825286865*x_11) + 7.89104027132111e-5*std::exp(1.04079973697662*x_11) - 0.0132828839827785*std::exp(0.265359848737717*x_12) + 8.4161843738862*std::exp(0.676719844341278*x_12) + 0.000637883372704235*std::exp(1.34455978870392*x_12) + 5.8389077095551e-6*std::exp(1.34767985343933*x_12) - 1.35037891595719*std::exp(0.278639853000641*x_13) - 1.12455145317258e-5*std::exp(1.14487981796265*x_13) + 1.07129125466508e-5*std::exp(1.15631985664368*x_13) + 0.264733118570762*std::exp(0.539919853210449*x_15) - 0.00160385925128734*std::exp(0.669359803199768*x_15) - 4.52935086821282*std::exp(0.951039850711823*x_15) + 1.22695383015612*std::exp(0.998479843139648*x_15) - 0.553290063108441*std::exp(0.589679837226868*x_16) + 34.5379816022209*std::exp(0.625999867916107*x_16) - 10.1845669310292*std::exp(0.720319867134094*x_16) - 0.722349108781384*std::exp(0.616719841957092*x_17) + 0.00344344875273732*std::exp(0.643679857254028*x_17) + 11.1495193007502*std::exp(0.665919840335846*x_17) + 53.964222604125*std::exp(0.673039853572845*x_17) + 21.7723912844763*std::exp(0.753759860992432*x_19) - 0.723036638158277*std::exp(0.75519984960556*x_19) - 34.4180593020194*std::exp(0.767119884490967*x_19) + 0.00147320819457272*std::exp(0.855199873447418*x_19) - 0.00275273001012192*std::exp(0.776719868183136*x_2) - 0.000242392553097474*std::exp(1.21783995628357*x_2) - 14.1177466307234*std::exp(0.494959861040115*x_20) + 0.00017415986337146*std::exp(0.889919877052307*x_20) - 0.0781916640953235*std::exp(0.89383989572525*x_20) - 0.00031785661302014*std::exp(0.938079833984375*x_20) - 0.0128486467574093*std::exp(0.26503986120224*x_21) - 5.6893368919186*std::exp(0.480719864368439*x_22) - 9.51920396982355e-6*std::exp(1.3155198097229*x_22) + 0.00080710231377966*std::exp(1.41879987716675*x_22) - 0.00905451413979972*std::exp(0.465999871492386*x_23) - 20.5052390796604*std::exp(0.545759856700897*x_23) + 0.196620485841866*std::exp(0.615919828414917*x_23) - 12.6646058554461*std::exp(0.85647988319397*x_23) - 0.00031361946546044*std::exp(0.997199833393097*x_23) - 1.03495459357236*std::exp(0.477999836206436*x_24) + 0.00360186047063119*std::exp(0.564399838447571*x_24) + 102.044320661902*std::exp(0.582319855690002*x_24) + 0.370492953070268*std::exp(0.562079846858978*x_25) + 0.00361472234788438*std::exp(0.609439849853516*x_25) - 0.000952359557685359*std::exp(0.693359851837158*x_25) + 0.45314346405349*std::exp(1.08727979660034*x_25) + 0.00278960657963324*std::exp(0.552559852600098*x_26) - 3.84312264498126*std::exp(0.812399864196777*x_26) - 0.0402484370858651*std::exp(0.856399893760681*x_26) + 7.57880627512936e-6*std::exp(1.24303984642029*x_26) - 0.0328977059635748*std::exp(0.956959843635559*x_27) + 1.06494955134069*std::exp(1.00351977348328*x_27) - 3.90769514557709e-5*std::exp(1.22839987277985*x_27) - 0.00247125184182201*std::exp(0.543519854545593*x_28) - 0.00301354106716593*std::exp(0.643999814987183*x_28) + 1.06569722168135*std::exp(1.05095982551575*x_28) + 2.21017980809642e-5*std::exp(1.24479985237122*x_29) - 0.00510068725817556*std::exp(0.55927985906601*x_3) - 0.871675665192342*std::exp(0.633279860019684*x_3) + 0.00116968311527193*std::exp(0.864879846572876*x_30) + 0.126586181559277*std::exp(0.897199809551239*x_30) - 0.000291709959267134*std::exp(1.05735981464386*x_30) - 0.000752788087580091*std::exp(0.693919837474823*x_32) - 3.31442191156275*std::exp(0.863999903202057*x_32) - 0.0143793378460436*std::exp(0.405439853668213*x_33) - 0.920659664965498*std::exp(0.462239861488342*x_33) - 27.6819252921242*std::exp(0.586719870567322*x_4) - 0.368059407571073*std::exp(0.692239880561829*x_4) - 0.000150671138037518*std::exp(1.09551990032196*x_4) - 0.212050417243493*std::exp(1.09767985343933*x_4) - 4.9162968304263*std::exp(0.733679831027985*x_41) + 0.189288330543004*std::exp(0.797679901123047*x_41) - 0.00203582247480976*std::exp(0.799919843673706*x_41) - 9.76311015681293*std::exp(0.818319857120514*x_41) + 0.000265262616494288*std::exp(0.826639890670776*x_41) - 1.0020414756379*std::exp(0.786239862442017*x_42) - 0.00387232119723592*std::exp(0.947999835014343*x_44) - 5.79718537109075e-5*std::exp(0.96455979347229*x_44) - 0.0014556236023617*std::exp(0.519359886646271*x_45) + 0.280966267645326*std::exp(0.539679825305939*x_45) - 13.2447162733818*std::exp(0.743519842624664*x_46) - 5.30077393763199*std::exp(0.768079876899719*x_46) + 0.00319001769972886*std::exp(0.579119861125946*x_47) + 0.00585186367001989*std::exp(0.714559853076935*x_49) + 0.384522858827617*std::exp(0.727199852466583*x_49) + 0.00239734850168001*std::exp(0.735519826412201*x_49) - 24.9911459668727*std::exp(0.736719846725464*x_49) + 0.00655665023188317*std::exp(0.365119844675064*x_50) + 0.432252472778019*std::exp(0.555359840393066*x_50) - 65.9319461789336*std::exp(0.55735981464386*x_50) - 29.4191865225631*std::exp(0.56335985660553*x_50) + 0.00143725897337617*std::exp(0.612239837646484*x_50) + 237.534453873324*std::exp(0.491039842367172*x_51) - 9.29682226621241*std::exp(0.49415984749794*x_51) + 0.0425704045151281*std::exp(0.496079862117767*x_51) - 58.4469328790695*std::exp(0.498559832572937*x_51) + 0.0264246394758582*std::exp(0.503359854221344*x_51) + 0.43010153602796*std::exp(0.533759832382202*x_52) - 0.000184950952390377*std::exp(0.626239836215973*x_52) + 1.59737776319855*std::exp(0.688319861888885*x_52) + 0.000189879271896348*std::exp(0.782239854335785*x_52) + 0.00069359616687513*std::exp(0.593119859695435*x_53) + 113.771111711741*std::exp(0.453199863433838*x_54) - 24.1019979686061*std::exp(0.465039849281311*x_54) + 0.00703081716645674*std::exp(0.507999837398529*x_54) + 0.00975921089109012*std::exp(0.515119850635529*x_54) + 0.342615378077228*std::exp(0.566639840602875*x_55) - 0.0902241993022919*std::exp(0.652239859104156*x_55) + 166.998012547801*std::exp(0.65311986207962*x_55) + 298.313665845027*std::exp(0.653519809246063*x_55) - 67.1336026418568*std::exp(0.507439851760864*x_56) - 0.00700142860266346*std::exp(0.561359822750092*x_56) + 0.00911310319860258*std::exp(0.582399845123291*x_56) - 124.523047902435*std::exp(0.614079833030701*x_57) - 80.6117710939114*std::exp(0.629199862480164*x_57) + 0.00983335920491808*std::exp(0.635999858379364*x_57) - 1.17102029776086*std::exp(0.639119863510132*x_57) - 0.00292264390794748*std::exp(0.647839844226837*x_57) + 0.00546973179752691*std::exp(0.57399982213974*x_58) + 0.00201200482314191*std::exp(0.582559823989868*x_58) - 0.537481699737754*std::exp(0.585679829120636*x_58) - 35.870094205097*std::exp(0.615999817848206*x_58) + 44.9854475804032*std::exp(0.616879820823669*x_58) + 17.2947216789425*std::exp(0.506879806518555*x_59) + 0.000222033666722481*std::exp(0.877119898796082*x_59) + 0.148924708014284*std::exp(0.79807984828949*x_60) - 0.00155076878243626*std::exp(0.803999841213226*x_60) - 0.00160608126950842*std::exp(0.806159913539886*x_60) + 3.82653684077593*std::exp(0.821119904518127*x_60) - 19.874704574552*std::exp(0.831999897956848*x_60) + 2.5121324084484*std::exp(1.11703991889954*x_61) + 0.150347569527863*std::exp(1.19711995124817*x_61) + 0.00014406908164213*std::exp(1.54751980304718*x_61) - 0.000166563859853574*std::exp(1.57471978664398*x_61) - 0.000729329919876139*std::exp(0.964639782905579*x_66) + 15.4837253238185*std::exp(1.03479981422424*x_66) + 0.235587002905678*std::exp(1.18119990825653*x_66) - 121.022421305888*std::exp(0.348559856414795*x_8) - 0.000559463395594944*std::exp(0.771119832992554*x_8) - 0.00383359133382664*std::exp(1.57039988040924*x_9) + 3.10115571742272*std::sin(0.272079944610596*x_100 + 1.9314398765564) - 198.200802391895*std::sin(0.228799998760223*x_101 + 1.96423983573914) - 0.0292891466784497*std::sin(0.229599997401237*x_102 + 1.99663984775543) + 0.0375990645290155*std::sin(0.211759999394417*x_108 + 1.99663984775543) - 0.0214206990569145*std::sin(0.303359925746918*x_112 + 1.9437597990036) - 305.482321105004*std::sin(0.268159955739975*x_120 + 1.97183978557587) - 0.0241735562006318*std::sin(0.377679854631424*x_15 + 2.02607989311218) - 221.07150136933*std::sin(0.240319982171059*x_30 + 1.82743990421295) + 2.56062538599252*std::sin(0.347679853439331*x_31 - 4.23023986816406) - 238.226291257578*std::sin(0.387039840221405*x_31 - 7.40623998641968) + 0.00619636008807969*std::sin(0.609119892120361*x_65 + 2.20607995986938) + 20.7232705431147*std::sin(0.436879843473434*x_91 - 4.40895986557007) + 182.622590735268*std::sin(0.307679921388626*x_92 + 8.2163200378418) - 0.0455679548287105*std::sin(0.223119989037514*x_93 + 1.9903998374939) - 82.9662156126267*std::sin(0.275119960308075*x_94 - 1.19951987266541) + 0.0344535192765001*std::sin(0.27007994055748*x_95 + 1.96999979019165) + 0.0218197389921026*std::sin(0.329999834299088*x_97 + 1.85111999511719) - 4.9429455975606*std::sin(0.268239974975586*x_98 + 1.96031987667084) + 414.346100534449);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00321519099870713*x_1 - 10.6514996551917*x_10 - 13.4314416883836*x_100 - 5.85761828219877*x_101 - 5.70717451647123*x_102 + 8.44767266592057*x_103 + 220.594893496455*x_104 - 38.2026453387754*x_105 + 35.8909001091478*x_106 + 7.23052055072383*x_107 + 13.0706491247307*x_108 + 0.310911530275302*x_109 - 12.5426935181355*x_110 - 47.938747987877*x_111 - 20.905735180537*x_112 - 16.3999875396992*x_113 + 34.1156667173415*x_114 - 10.082884136103*x_115 - 21.8290667008603*x_116 - 33.0636102113196*x_117 - 20.6037050188994*x_118 + 26.8498994600661*x_119 + 1.00447664747568*x_12 + 17.6489670528421*x_120 - 61.4212840854636*x_13 + 9.82418030452458*x_14 - 0.00421962730211876*x_16 - 0.00060553178510311*x_17 - 54.1991685110708*x_18 + 0.00105783509603997*x_19 + 5.97986113315658*x_2 - 3.38006740844445*x_20 - 11.3082007326695*x_21 - 1.0225192106625*x_22 + 9.55898412383323*x_24 - 16.7894627201057*x_25 + 53.9384338935064*x_26 - 9.94330382102726*x_27 - 17.7994667975697*x_28 + 66.7583664515859*x_29 - 8.85090771505349*x_3 + 6.03776426537934*x_30 - 0.422097901100172*x_31 + 18.1791602283298*x_32 + 16.9409809265709*x_33 - 26.6764337608479*x_34 - 274.730724218357*x_35 + 132.487974586449*x_36 - 133.47343339408*x_37 + 466.31501447544*x_38 - 241.932304846231*x_39 - 0.0104664841701104*x_4 - 1749.57809288646*x_40 - 24.3179469193377*x_42 - 47.2459753279447*x_43 + 17.2920241494966*x_44 - 81.5282220350996*x_45 + 1.0272993092545*x_46 + 229.741317873563*x_47 - 111.527223559792*x_48 - 11.2421591010519*x_49 + 7.16334279256783*x_5 + 17.9146856749355*x_52 - 3.73473777016391*x_53 + 5.77051695243699*x_54 - 0.0055708218616503*x_55 + 11.8977306792396*x_56 - 40.6374062738543*x_59 - 35.8685090231948*x_6 - 14.5689353051934*x_61 + 8.1596677712986*x_62 - 9.59765526325087*x_63 - 8.93651066097134*x_64 - 5.68709400985209*x_65 - 0.566042180951891*x_66 - 4.15521441455774*x_67 + 13.7858483154646*x_68 - 14.7840455021126*x_69 - 10.8295469013654*x_7 - 2.09434835745779*x_70 - 23.1099675638674*x_71 + 1.90174129974391*x_72 - 33.4228575208538*x_73 + 23.3478260143268*x_74 + 13.9648706945364*x_75 + 5.87648773437434*x_76 + 8.11703712940247*x_77 - 11.8215708278751*x_78 + 44.6582426984297*x_79 - 20.4441561912365*x_8 + 2.90826178725881*x_80 + 12.095315536261*x_81 + 7.38513253255954*x_82 + 18.8084448351326*x_83 - 14.4938980376939*x_84 - 43.8896737368049*x_85 - 7.00112561109397*x_86 - 114.335837660064*x_87 + 83.8634327373394*x_88 - 16.799306949504*x_89 + 8.97531148192699*x_9 + 12.2872717284982*x_90 + 20.0194980333542*x_91 + 10.1852875159856*x_92 - 1.87726037252192*x_93 - 10.2017990334731*x_94 - 18.5753198598673*x_95 - 17.5727478437484*x_96 + 6.8067977902823*x_97 - 20.7465526408589*x_98 + 19.1747489830408*x_99 - 3.55954917205359e-5*std::pow(-9.51239967346191*x_16 - 6.14495992660522, 2) + 0.178609735984566*std::pow(-9.43984031677246*x_18 - 3.81256008148193, 2) + 0.11109798032922*std::exp(1.24503993988037*x_1) + 4.53407690785725*std::exp(1.2720799446106*x_1) - 0.000100216136559381*std::exp(1.29311990737915*x_1) + 0.40192779464308*std::exp(1.79351997375488*x_1) - 0.620450172412459*std::exp(0.504559814929962*x_10) + 0.000387556261852108*std::exp(0.782479882240295*x_10) - 0.877667671774975*std::exp(0.861839890480042*x_10) - 0.00161075143895193*std::exp(0.880719900131226*x_11) - 0.268317669381725*std::exp(0.926479816436768*x_11) - 6.29921800088537*std::exp(0.940879821777344*x_11) + 0.459032132159837*std::exp(0.993199825286865*x_11) - 5.18262557663108e-5*std::exp(1.04079973697662*x_11) - 0.019840935696617*std::exp(0.265359848737717*x_12) + 3.74517196512498*std::exp(0.676719844341278*x_12) + 0.000815551554301555*std::exp(1.34455978870392*x_12) - 3.83483943747032e-6*std::exp(1.34767985343933*x_12) - 1.72649683457978*std::exp(0.278639853000641*x_13) + 7.38575513881405e-6*std::exp(1.14487981796265*x_13) + 1.60021128873187e-5*std::exp(1.15631985664368*x_13) + 0.338468622265829*std::exp(0.539919853210449*x_15) + 0.00105337213995063*std::exp(0.669359803199768*x_15) - 2.01554494747984*std::exp(0.951039850711823*x_15) + 1.08634893834607*std::exp(0.998479843139648*x_15) - 0.707396665686281*std::exp(0.589679837226868*x_16) + 15.3692783668084*std::exp(0.625999867916107*x_16) - 9.0174489056611*std::exp(0.720319867134094*x_16) - 0.923543336640871*std::exp(0.616719841957092*x_17) + 0.00514355507179291*std::exp(0.643679857254028*x_17) + 9.87182089312831*std::exp(0.665919840335846*x_17) + 24.0138861790892*std::exp(0.673039853572845*x_17) + 19.2773465274862*std::exp(0.753759860992432*x_19) - 0.924422361986171*std::exp(0.75519984960556*x_19) - 15.3159133718468*std::exp(0.767119884490967*x_19) + 0.00220056345400167*std::exp(0.855199873447418*x_19) - 0.00411181330739533*std::exp(0.776719868183136*x_2) + 0.000159196988239113*std::exp(1.21783995628357*x_2) - 6.28234679080685*std::exp(0.494959861040115*x_20) - 0.000114383570644278*std::exp(0.889919877052307*x_20) - 0.0999702075882983*std::exp(0.89383989572525*x_20) - 0.000474789407771208*std::exp(0.938079833984375*x_20) + 0.00843864978766598*std::exp(0.26503986120224*x_21) - 5.03735751136003*std::exp(0.480719864368439*x_22) + 6.25196023171683e-6*std::exp(1.3155198097229*x_22) + 0.00103190265595555*std::exp(1.41879987716675*x_22) - 0.0135249267436797*std::exp(0.465999871492386*x_23) - 18.1554058166044*std::exp(0.545759856700897*x_23) + 0.251384735356962*std::exp(0.615919828414917*x_23) - 5.63570433964634*std::exp(0.85647988319397*x_23) + 0.000205976931702127*std::exp(0.997199833393097*x_23) - 1.32321810465318*std::exp(0.477999836206436*x_24) + 0.00538017813591046*std::exp(0.564399838447571*x_24) + 45.4093579661811*std::exp(0.582319855690002*x_24) + 0.473685499048632*std::exp(0.562079846858978*x_25) + 0.00539939020460346*std::exp(0.609439849853516*x_25) + 0.000625484452252436*std::exp(0.693359851837158*x_25) + 0.401214706693838*std::exp(1.08727979660034*x_25) - 0.00183213947860452*std::exp(0.552559852600098*x_26) - 3.4027133724974*std::exp(0.812399864196777*x_26) - 0.0514587412498764*std::exp(0.856399893760681*x_26) + 1.13206294775229e-5*std::exp(1.24303984642029*x_26) - 0.0420606279762509*std::exp(0.956959843635559*x_27) + 0.4738987439877*std::exp(1.00351977348328*x_27) + 2.56647033988009e-5*std::exp(1.22839987277985*x_27) - 0.0036913631819195*std::exp(0.543519854545593*x_28) + 0.00197921369983168*std::exp(0.643999814987183*x_28) + 0.474231454616958*std::exp(1.05095982551575*x_28) - 1.45158737106234e-5*std::exp(1.24479985237122*x_29) + 0.00334999586032922*std::exp(0.55927985906601*x_3) - 1.11446147370277*std::exp(0.633279860019684*x_3) - 0.000768216790350622*std::exp(0.864879846572876*x_30) + 0.161843938157696*std::exp(0.897199809551239*x_30) - 0.000435733576487301*std::exp(1.05735981464386*x_30) - 0.00112445610894597*std::exp(0.693919837474823*x_32) - 2.93460001212841*std::exp(0.863999903202057*x_32) + 0.00944396702254417*std::exp(0.405439853668213*x_33) - 1.17708887372661*std::exp(0.462239861488342*x_33) - 12.3183578138363*std::exp(0.586719870567322*x_4) - 0.470574143745674*std::exp(0.692239880561829*x_4) + 9.8956799966073e-5*std::exp(1.09551990032196*x_4) - 0.187750133694108*std::exp(1.09767985343933*x_4) - 4.35290530993182*std::exp(0.733679831027985*x_41) + 0.242010371787934*std::exp(0.797679901123047*x_41) - 0.00304095276784755*std::exp(0.799919843673706*x_41) - 4.34454912432472*std::exp(0.818319857120514*x_41) - 0.000174217438195537*std::exp(0.826639890670776*x_41) - 0.887210803278111*std::exp(0.786239862442017*x_42) - 0.00495086987104288*std::exp(0.947999835014343*x_44) - 8.65938318201889e-5*std::exp(0.96455979347229*x_44) + 0.00095601490451963*std::exp(0.519359886646271*x_45) + 0.359223152835962*std::exp(0.539679825305939*x_45) - 5.89385140218824*std::exp(0.743519842624664*x_46) - 4.69332259945454*std::exp(0.768079876899719*x_46) + 0.00476499953876362*std::exp(0.579119861125946*x_47) + 0.00874105735868564*std::exp(0.714559853076935*x_49) + 0.491623122032287*std::exp(0.727199852466583*x_49) - 0.0015745147957311*std::exp(0.735519826412201*x_49) - 11.1209706315238*std::exp(0.736719846725464*x_49) + 0.00979381253383429*std::exp(0.365119844675064*x_50) + 0.552646755049152*std::exp(0.555359840393066*x_50) - 29.3394803946591*std::exp(0.55735981464386*x_50) - 26.0478440673882*std::exp(0.56335985660553*x_50) - 0.000943953504170218*std::exp(0.612239837646484*x_50) + 105.701982974366*std::exp(0.491039842367172*x_51) - 11.8862446862843*std::exp(0.49415984749794*x_51) + 0.0635883487094156*std::exp(0.496079862117767*x_51) - 51.7491057301496*std::exp(0.498559832572937*x_51) - 0.0173550010761649*std::exp(0.503359854221344*x_51) + 0.549896722857094*std::exp(0.533759832382202*x_52) - 0.000276265301884986*std::exp(0.626239836215973*x_52) + 1.41432350145364*std::exp(0.688319861888885*x_52) - 0.000124707660481544*std::exp(0.782239854335785*x_52) + 0.00103603983624578*std::exp(0.593119859695435*x_53) + 50.6277380692841*std::exp(0.453199863433838*x_54) - 21.339987912897*std::exp(0.465039849281311*x_54) + 0.0105020861038311*std::exp(0.507999837398529*x_54) - 0.00640959040035826*std::exp(0.515119850635529*x_54) + 0.438043247520195*std::exp(0.566639840602875*x_55) - 0.134769869175735*std::exp(0.652239859104156*x_55) + 147.860587072068*std::exp(0.65311986207962*x_55) + 132.748515063789*std::exp(0.653519809246063*x_55) - 29.8742132256811*std::exp(0.507439851760864*x_56) + 0.00459835227061198*std::exp(0.561359822750092*x_56) + 0.0136124425083088*std::exp(0.582399845123291*x_56) - 55.4123112444092*std::exp(0.614079833030701*x_57) - 71.3739260546781*std::exp(0.629199862480164*x_57) - 0.00645828904267865*std::exp(0.635999858379364*x_57) - 1.49718187497004*std::exp(0.639119863510132*x_57) - 0.00436561743043739*std::exp(0.647839844226837*x_57) + 0.00817025858339024*std::exp(0.57399982213974*x_58) - 0.00132143130667037*std::exp(0.582559823989868*x_58) - 0.68718523540041*std::exp(0.585679829120636*x_58) - 31.7594988501909*std::exp(0.615999817848206*x_58) + 20.0183633856075*std::exp(0.616879820823669*x_58) + 15.312803198568*std::exp(0.506879806518555*x_59) - 0.000145825812625901*std::exp(0.877119898796082*x_59) + 0.190404362760008*std::exp(0.79807984828949*x_60) + 0.00101850373068108*std::exp(0.803999841213226*x_60) - 0.0023990388859206*std::exp(0.806159913539886*x_60) + 3.38802824715101*std::exp(0.821119904518127*x_60) - 8.84417249920384*std::exp(0.831999897956848*x_60) + 2.22425025932347*std::exp(1.11703991889954*x_61) + 0.192223530602613*std::exp(1.19711995124817*x_61) + 0.000215199153168711*std::exp(1.54751980304718*x_61) + 0.000109394717367854*std::exp(1.57471978664398*x_61) + 0.000479004512280806*std::exp(0.964639782905579*x_66) + 6.89020242693235*std::exp(1.03479981422424*x_66) + 0.301204506363668*std::exp(1.18119990825653*x_66) - 53.8545449209387*std::exp(0.348559856414795*x_8) + 0.000367440692672298*std::exp(0.771119832992554*x_8) - 0.00170593444147232*std::exp(1.57039988040924*x_9) + 3.96491345236543*std::sin(0.272079944610596*x_100 + 1.9314398765564) - 88.1986486520662*std::sin(0.228799998760223*x_101 + 1.96423983573914) + 0.0192363332937368*std::sin(0.229599997401237*x_102 + 1.99663984775543) + 0.0561625489269011*std::sin(0.211759999394417*x_108 + 1.99663984775543) - 0.0319965689014414*std::sin(0.303359925746918*x_112 + 1.9437597990036) - 135.938541032162*std::sin(0.268159955739975*x_120 + 1.97183978557587) - 0.0361085721110819*std::sin(0.377679854631424*x_15 + 2.02607989311218) - 195.737431114735*std::sin(0.240319982171059*x_30 + 1.82743990421295) + 3.27383045693293*std::sin(0.347679853439331*x_31 - 4.23023986816406) - 106.009848137583*std::sin(0.387039840221405*x_31 - 7.40623998641968) + 0.00925563922865465*std::sin(0.609119892120361*x_65 + 2.20607995986938) + 18.3484515881958*std::sin(0.436879843473434*x_91 - 4.40895986557007) + 81.2664001447489*std::sin(0.307679921388626*x_92 + 8.2163200378418) - 0.0680658554840191*std::sin(0.223119989037514*x_93 + 1.9903998374939) - 73.4585589401516*std::sin(0.275119960308075*x_94 - 1.19951987266541) + 0.0514639788598228*std::sin(0.27007994055748*x_95 + 1.96999979019165) - 0.0143306247956776*std::sin(0.329999834299088*x_97 + 1.85111999511719) - 6.31969281128719*std::sin(0.268239974975586*x_98 + 1.96031987667084) + 296.545045308343);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00165524192270002*x_1 + 6.09928854001635*x_10 - 12.7218494946588*x_100 - 5.47731097570887*x_101 - 16.3417287697122*x_102 + 25.5101381671537*x_103 - 224.750997205498*x_104 + 2.94923895004802*x_105 - 55.8432611378718*x_106 - 13.1961295045478*x_107 + 3.51716489276171*x_108 - 23.8054102593776*x_109 - 8.2190291988192*x_110 + 6.51064702583713*x_111 + 2.82677595079034*x_112 - 22.0341769514662*x_113 + 7.98232532963873*x_114 + 21.4366503974871*x_115 - 19.3507609679228*x_116 + 0.777952282410822*x_117 + 10.7016552290741*x_118 - 13.2533020523589*x_119 + 0.868434440224077*x_12 + 15.6926999100321*x_120 - 31.8305803033455*x_13 - 15.0740151677563*x_14 + 0.0304626532429845*x_16 + 0.00437150095884991*x_17 - 47.7454758458142*x_18 - 0.00763680330316001*x_19 + 5.17829030872791*x_2 - 2.92228490841363*x_20 + 4.98955800904728*x_21 + 0.586191635316012*x_22 + 8.26343737185037*x_24 + 9.61417046200828*x_25 - 30.886831017227*x_26 - 8.56445780643169*x_27 - 14.8202559716156*x_28 + 40.1906633700996*x_29 + 7.65331621545798*x_3 - 3.45741229630092*x_30 - 0.366372459890778*x_31 - 10.5822642206912*x_32 + 39.3859565586548*x_33 - 204.543134800068*x_34 - 65.0014989529505*x_35 + 15.2505559971332*x_36 - 333.961508222752*x_37 - 225.627611212697*x_38 - 146.987403860763*x_39 + 0.00538834656746963*x_4 + 761.225427415522*x_40 + 14.1329479908575*x_42 - 20.5066491019515*x_43 - 7.22773590042325*x_44 + 8.69475100683004*x_45 + 0.175882625214576*x_46 + 62.128519660418*x_47 - 89.5170894995111*x_48 - 9.71956707044136*x_49 - 5.49461526523396*x_5 - 10.2585082514805*x_52 + 17.4851251946987*x_53 + 0.634270362222848*x_54 + 0.0402172994199462*x_55 + 11.1600161516889*x_56 + 24.3114414143957*x_59 + 12.3004545983143*x_6 + 8.34262714710732*x_61 + 2.29641261360273*x_62 - 1.97716517758408*x_63 + 5.72512907492927*x_64 + 8.68415889780788*x_65 - 0.490281142413721*x_66 - 0.0577226149662059*x_67 - 10.1238271895642*x_68 + 1.45967871362387*x_69 - 21.8987036035809*x_7 + 8.68145571417963*x_70 + 5.14295372578843*x_71 + 5.42930744295115*x_72 + 9.73838496868706*x_73 + 3.12113060677102*x_74 + 2.58981157491068*x_75 + 9.65410811745556*x_76 + 8.44917354579785*x_77 + 13.015087782132*x_78 + 31.8941992961129*x_79 - 17.4925424650706*x_8 - 5.28845938911676*x_80 + 10.8799126894922*x_81 - 14.2001608298457*x_82 + 19.8046560685763*x_83 - 8.47201605051226*x_84 - 11.3695660346143*x_85 - 85.1211763443605*x_86 - 54.4794646391149*x_87 - 43.6427163552353*x_88 + 6.3660887701158*x_89 + 7.93161278183458*x_9 - 9.07498752119088*x_90 - 11.1265352102016*x_91 + 8.18003540533283*x_92 - 6.08734872943214*x_93 + 6.18586295980145*x_94 - 5.60554917001228*x_95 - 1.57161404551832*x_96 - 0.596574307502889*x_97 + 24.2211223364113*x_98 - 23.2066881167606*x_99 + 1.83252410754586e-5*std::pow(-9.51239967346191*x_16 - 6.14495992660522, 2) - 0.10227751039785*std::pow(-9.43984031677246*x_18 - 3.81256008148193, 2) + 0.0122114113529953*std::exp(1.24503993988037*x_1) - 2.59635397550832*std::exp(1.2720799446106*x_1) + 0.000723487928857391*std::exp(1.29311990737915*x_1) + 0.347492338650721*std::exp(1.79351997375488*x_1) - 0.0681972098584829*std::exp(0.504559814929962*x_10) - 0.000199521388396668*std::exp(0.782479882240295*x_10) - 0.75879995334498*std::exp(0.861839890480042*x_10) + 0.000829245699516674*std::exp(0.880719900131226*x_11) - 0.0294923222221303*std::exp(0.926479816436768*x_11) + 3.60712886692552*std::exp(0.940879821777344*x_11) + 0.396862698340375*std::exp(0.993199825286865*x_11) + 0.000374148033760853*std::exp(1.04079973697662*x_11) + 0.0102144938088723*std::exp(0.265359848737717*x_12) - 2.14460237843867*std::exp(0.676719844341278*x_12) + 8.96419131980536e-5*std::exp(1.34455978870392*x_12) + 2.7684763525803e-5*std::exp(1.34767985343933*x_12) - 0.189769093769502*std::exp(0.278639853000641*x_13) - 5.33198032959714e-5*std::exp(1.14487981796265*x_13) - 8.23819428255402e-6*std::exp(1.15631985664368*x_13) + 0.0372030127309395*std::exp(0.539919853210449*x_15) - 0.00760458399229342*std::exp(0.669359803199768*x_15) + 1.15416395521135*std::exp(0.951039850711823*x_15) + 0.939218283004859*std::exp(0.998479843139648*x_15) - 0.077753993806497*std::exp(0.589679837226868*x_16) - 8.80092856810739*std::exp(0.625999867916107*x_16) - 7.79616252136573*std::exp(0.720319867134094*x_16) - 0.10151190465047*std::exp(0.616719841957092*x_17) - 0.00264800069108537*std::exp(0.643679857254028*x_17) + 8.53482186256976*std::exp(0.665919840335846*x_17) - 13.7511008559287*std::exp(0.673039853572845*x_17) + 16.6665015883392*std::exp(0.753759860992432*x_19) - 0.101608523329309*std::exp(0.75519984960556*x_19) + 8.77037010612338*std::exp(0.767119884490967*x_19) - 0.00113289222447121*std::exp(0.855199873447418*x_19) + 0.00211684026468517*std::exp(0.776719868183136*x_2) - 0.00114928696371372*std::exp(1.21783995628357*x_2) + 3.59746788537421*std::exp(0.494959861040115*x_20) + 0.000825766542813261*std::exp(0.889919877052307*x_20) - 0.0109882945152331*std::exp(0.89383989572525*x_20) + 0.000244430683126705*std::exp(0.938079833984375*x_20) - 0.060920940148334*std::exp(0.26503986120224*x_21) - 4.35511842070216*std::exp(0.480719864368439*x_22) - 4.51346251675093e-5*std::exp(1.3155198097229*x_22) + 0.000113422294183753*std::exp(1.41879987716675*x_22) + 0.00696289139792548*std::exp(0.465999871492386*x_23) - 15.6965119368446*std::exp(0.545759856700897*x_23) + 0.0276311270664959*std::exp(0.615919828414917*x_23) + 3.22718023191744*std::exp(0.85647988319397*x_23) - 0.0014870042772131*std::exp(0.997199833393097*x_23) - 0.145442433226673*std::exp(0.477999836206436*x_24) - 0.00276981877771307*std::exp(0.564399838447571*x_24) - 26.0028158932337*std::exp(0.582319855690002*x_24) + 0.052065469270375*std::exp(0.562079846858978*x_25) - 0.00277970951874065*std::exp(0.609439849853516*x_25) - 0.00451554476583197*std::exp(0.693359851837158*x_25) + 0.346875828415678*std::exp(1.08727979660034*x_25) + 0.0132267201895977*std::exp(0.552559852600098*x_26) - 2.9418637957527*std::exp(0.812399864196777*x_26) - 0.00565612313785977*std::exp(0.856399893760681*x_26) - 5.82807693542451e-6*std::exp(1.24303984642029*x_26) - 0.00462312301682964*std::exp(0.956959843635559*x_27) - 0.271369214273505*std::exp(1.00351977348328*x_27) - 0.000185280572013825*std::exp(1.22839987277985*x_27) + 0.00190038448511502*std::exp(0.543519854545593*x_28) - 0.0142884895548626*std::exp(0.643999814987183*x_28) - 0.271559734765883*std::exp(1.05095982551575*x_28) + 0.000104794095711638*std::exp(1.24479985237122*x_29) - 0.0241845440253458*std::exp(0.55927985906601*x_3) - 0.12249680374136*std::exp(0.633279860019684*x_3) + 0.00554596887932233*std::exp(0.864879846572876*x_30) + 0.0177891884080684*std::exp(0.897199809551239*x_30) + 0.000224323992950906*std::exp(1.05735981464386*x_30) + 0.00057889154719329*std::exp(0.693919837474823*x_32) - 2.53714979359537*std::exp(0.863999903202057*x_32) - 0.0681786025276425*std::exp(0.405439853668213*x_33) - 0.129380537733584*std::exp(0.462239861488342*x_33) + 7.05387622037545*std::exp(0.586719870567322*x_4) - 0.0517234825001641*std::exp(0.692239880561829*x_4) - 0.000714396430672496*std::exp(1.09551990032196*x_4) - 0.162322023778642*std::exp(1.09767985343933*x_4) - 3.76336562495403*std::exp(0.733679831027985*x_41) + 0.026600737410674*std::exp(0.797679901123047*x_41) + 0.00156554074340093*std::exp(0.799919843673706*x_41) + 2.48782445026113*std::exp(0.818319857120514*x_41) + 0.00125772373450302*std::exp(0.826639890670776*x_41) - 0.767050602163683*std::exp(0.786239862442017*x_42) - 0.00054417828633159*std::exp(0.947999835014343*x_44) + 4.45801635839513e-5*std::exp(0.96455979347229*x_44) - 0.00690173525915032*std::exp(0.519359886646271*x_45) + 0.0394842613142097*std::exp(0.539679825305939*x_45) + 3.37500329837998*std::exp(0.743519842624664*x_46) - 4.0576781896236*std::exp(0.768079876899719*x_46) - 0.00245311305032247*std::exp(0.579119861125946*x_47) - 0.00450006378925544*std::exp(0.714559853076935*x_49) + 0.054037095507857*std::exp(0.727199852466583*x_49) + 0.0113668565525257*std::exp(0.735519826412201*x_49) + 6.36821494153117*std::exp(0.736719846725464*x_49) - 0.0050420423220848*std::exp(0.365119844675064*x_50) + 0.0607445503402036*std::exp(0.555359840393066*x_50) + 16.8007023502434*std::exp(0.55735981464386*x_50) - 22.5200306433744*std::exp(0.56335985660553*x_50) + 0.00681466068356293*std::exp(0.612239837646484*x_50) - 60.5282550984131*std::exp(0.491039842367172*x_51) - 1.30648480626247*std::exp(0.49415984749794*x_51) - 0.0327365001399346*std::exp(0.496079862117767*x_51) - 44.7404185849397*std::exp(0.498559832572937*x_51) + 0.125290539178513*std::exp(0.503359854221344*x_51) + 0.06044227864965*std::exp(0.533759832382202*x_52) + 0.000142226670095583*std::exp(0.626239836215973*x_52) + 1.22277331321471*std::exp(0.688319861888885*x_52) + 0.000900298994673197*std::exp(0.782239854335785*x_52) - 0.000533373156130026*std::exp(0.593119859695435*x_53) - 28.9910232398992*std::exp(0.453199863433838*x_54) - 18.4497872639433*std::exp(0.465039849281311*x_54) - 0.00540667512501022*std::exp(0.507999837398529*x_54) + 0.0462726008284274*std::exp(0.515119850635529*x_54) + 0.048147826540319*std::exp(0.566639840602875*x_55) + 0.0693821105701578*std::exp(0.652239859104156*x_55) + 127.834954140378*std::exp(0.65311986207962*x_55) - 76.0159436712282*std::exp(0.653519809246063*x_55) + 17.1069070617808*std::exp(0.507439851760864*x_56) - 0.0331967732407094*std::exp(0.561359822750092*x_56) - 0.00700794619018183*std::exp(0.582399845123291*x_56) + 31.7308191976649*std::exp(0.614079833030701*x_57) - 61.7073335409617*std::exp(0.629199862480164*x_57) + 0.0466241697581443*std::exp(0.635999858379364*x_57) - 0.164563781369655*std::exp(0.639119863510132*x_57) + 0.00224750348960159*std::exp(0.647839844226837*x_57) - 0.00420620564438171*std::exp(0.57399982213974*x_58) + 0.00953977704602269*std::exp(0.582559823989868*x_58) - 0.0755324404666273*std::exp(0.585679829120636*x_58) - 27.4581222720068*std::exp(0.615999817848206*x_58) - 11.4631397780932*std::exp(0.616879820823669*x_58) + 13.2388997866989*std::exp(0.506879806518555*x_59) + 0.00105275675926845*std::exp(0.877119898796082*x_59) + 0.0209284272331265*std::exp(0.79807984828949*x_60) - 0.00735285932926941*std::exp(0.803999841213226*x_60) + 0.00123507117921147*std::exp(0.806159913539886*x_60) + 2.92916756369806*std::exp(0.821119904518127*x_60) + 5.06444925726703*std::exp(0.831999897956848*x_60) + 1.92300690486744*std::exp(1.11703991889954*x_61) + 0.0211283823248425*std::exp(1.19711995124817*x_61) - 0.000110788646832374*std::exp(1.54751980304718*x_61) - 0.000789750635113657*std::exp(1.57471978664398*x_61) - 0.00345806568085013*std::exp(0.964639782905579*x_66) - 3.94554499775284*std::exp(1.03479981422424*x_66) + 0.0331071016564219*std::exp(1.18119990825653*x_66) + 30.8387935728135*std::exp(0.348559856414795*x_8) - 0.00265265569843524*std::exp(0.771119832992554*x_8) + 0.000976871314511162*std::exp(1.57039988040924*x_9) + 0.435806204598707*std::sin(0.272079944610596*x_100 + 1.9314398765564) + 50.5052994724065*std::sin(0.228799998760223*x_101 + 1.96423983573914) - 0.138872395317791*std::sin(0.229599997401237*x_102 + 1.99663984775543) - 0.0289135561485707*std::sin(0.211759999394417*x_108 + 1.99663984775543) + 0.0164724466600965*std::sin(0.303359925746918*x_112 + 1.9437597990036) + 77.8426521222047*std::sin(0.268159955739975*x_120 + 1.97183978557587) + 0.0185893846900956*std::sin(0.377679854631424*x_15 + 2.02607989311218) - 169.227554317173*std::sin(0.240319982171059*x_30 + 1.82743990421295) + 0.35984533914212*std::sin(0.347679853439331*x_31 - 4.23023986816406) + 60.7045483013481*std::sin(0.387039840221405*x_31 - 7.40623998641968) - 0.00476498039426477*std::sin(0.609119892120361*x_65 + 2.20607995986938) + 15.8634123789913*std::sin(0.436879843473434*x_91 - 4.40895986557007) - 46.5356775764932*std::sin(0.307679921388626*x_92 + 8.2163200378418) + 0.0350416064074867*std::sin(0.223119989037514*x_93 + 1.9903998374939) - 63.5096322778398*std::sin(0.275119960308075*x_94 - 1.19951987266541) - 0.0264946422629263*std::sin(0.27007994055748*x_95 + 1.96999979019165) + 0.103456732704057*std::sin(0.329999834299088*x_97 + 1.85111999511719) - 0.694633406606567*std::sin(0.268239974975586*x_98 + 1.96031987667084) + 163.548300652365);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00282953615380151*x_1 - 36.0534928849268*x_10 + 4.23921229976933*x_100 + 1.1425297015195*x_101 + 28.7447194733034*x_102 - 45.1459586902659*x_103 + 973.20434500262*x_104 - 83.0430784659407*x_105 + 210.104240580278*x_106 + 45.7875542666651*x_107 + 17.3098164505154*x_108 + 57.7355749210829*x_109 - 4.28870111980037*x_110 - 110.90557423334*x_111 - 49.261347521037*x_112 + 21.3460537058286*x_113 + 47.3906949875456*x_114 - 72.2638844398219*x_115 + 3.50417481822017*x_116 - 67.7596117554692*x_117 - 67.5913496370168*x_118 + 85.7117296647676*x_119 - 0.11557642929441*x_12 - 2.54693311100921*x_120 - 44.7348193742107*x_13 + 55.4504983220971*x_14 + 0.0159430545809436*x_16 + 0.00228788601674551*x_17 + 7.40717595215384*x_18 - 0.00399682755520485*x_19 - 0.891789428805997*x_2 + 0.388915086103956*x_20 - 34.8201681419242*x_21 - 3.51011576994996*x_22 - 1.10028509363768*x_24 - 56.8292839151708*x_25 + 182.571808566752*x_26 + 1.16192857159546*x_27 + 1.39476156920358*x_28 + 35.1810791448563*x_29 - 36.2564662617036*x_3 + 20.43673614637*x_30 + 0.0477508862504872*x_31 + 61.9505789357358*x_32 - 62.2179457958439*x_33 + 453.699397109709*x_34 - 391.858322699621*x_35 + 225.48658539628*x_36 + 542.993475901153*x_37 + 1480.66273918449*x_38 - 123.239518191889*x_39 + 0.0092110532078583*x_4 - 5320.1625827156*x_40 - 83.1834651525866*x_42 - 42.7982479538342*x_43 + 51.9778462155783*x_44 - 183.486964690836*x_45 + 0.845524076006962*x_46 + 302.009435578358*x_47 - 5.40811106252402*x_48 + 1.29353789331442*x_49 + 27.5285202903232*x_5 + 60.6379593822729*x_52 - 50.8090225611677*x_53 + 4.33986812208672*x_54 + 0.0210482847516908*x_55 - 2.37286422167349*x_56 - 141.528764637966*x_59 - 101.39509394254*x_6 - 49.3132016552927*x_61 + 10.3082092780843*x_62 - 14.31763469135*x_63 - 31.0834388757622*x_64 - 31.5911255952237*x_65 + 0.0646296662016624*x_66 - 8.40238348032555*x_67 + 52.4262182374611*x_68 - 32.9401737234482*x_69 + 30.8324079883622*x_7 - 24.8924876831616*x_70 - 57.943895029581*x_71 - 9.45951754781272*x_72 - 89.9381699003092*x_73 + 38.8725474079216*x_74 + 20.774654380399*x_75 - 11.7742754520805*x_76 - 4.31380067391847*x_77 - 54.9531057429801*x_78 + 10.2489374589638*x_79 + 2.14636936228057*x_8 + 18.9057634825532*x_80 - 1.9661346087084*x_81 + 49.2191241826571*x_82 - 12.1877991586562*x_83 - 8.61075163279456*x_84 - 58.4953582202217*x_85 + 199.393673184735*x_86 - 96.0803589841459*x_87 + 273.643614060439*x_88 - 48.4341385332377*x_89 - 1.19944683317648*x_9 + 46.5381013444637*x_90 + 66.4704475140523*x_91 - 0.458026292955202*x_92 + 11.9304313746669*x_93 - 35.9372471972744*x_94 - 22.8091316115334*x_95 - 31.3226277913253*x_96 + 14.3254669535726*x_97 - 100.270058612171*x_98 + 95.3033762460476*x_99 + 3.13258934775877e-5*std::pow(-9.51239967346191*x_16 - 6.14495992660522, 2) + 0.604561537524694*std::pow(-9.43984031677246*x_18 - 3.81256008148193, 2) + 0.0835541403366604*std::exp(1.24503993988037*x_1) + 15.3470273698084*std::exp(1.2720799446106*x_1) + 0.000378647501464228*std::exp(1.29311990737915*x_1) - 0.04624635072977*std::exp(1.79351997375488*x_1) - 0.46662577144997*std::exp(0.504559814929962*x_10) - 0.000341069770033463*std::exp(0.782479882240295*x_10) + 0.10098561859632*std::exp(0.861839890480042*x_10) + 0.00141754546872487*std::exp(0.880719900131226*x_11) - 0.201795317393631*std::exp(0.926479816436768*x_11) - 21.3217095855713*std::exp(0.940879821777344*x_11) - 0.0528168523377423*std::exp(0.993199825286865*x_11) + 0.000195815593475127*std::exp(1.04079973697662*x_11) + 0.017461060603057*std::exp(0.265359848737717*x_12) + 12.6767273298359*std::exp(0.676719844341278*x_12) + 0.000613356865876089*std::exp(1.34455978870392*x_12) + 1.44892072411336e-5*std::exp(1.34767985343933*x_12) - 1.29845707707558*std::exp(0.278639853000641*x_13) - 2.79056629575962e-5*std::exp(1.14487981796265*x_13) - 1.40826958554215e-5*std::exp(1.15631985664368*x_13) + 0.254554175337399*std::exp(0.539919853210449*x_15) - 0.0039799651293482*std::exp(0.669359803199768*x_15) - 6.82225381321785*std::exp(0.951039850711823*x_15) - 0.124996764810156*std::exp(0.998479843139648*x_15) - 0.532016154598732*std::exp(0.589679837226868*x_16) + 52.0222176515931*std::exp(0.625999867916107*x_16) + 1.03755975659586*std::exp(0.720319867134094*x_16) - 0.694574908814824*std::exp(0.616719841957092*x_17) - 0.00452659734384658*std::exp(0.643679857254028*x_17) - 1.13586494253401*std::exp(0.665919840335846*x_17) + 81.2826460458329*std::exp(0.673039853572845*x_17) - 2.21807732764816*std::exp(0.753759860992432*x_19) - 0.695236002804499*std::exp(0.75519984960556*x_19) - 51.8415868297283*std::exp(0.767119884490967*x_19) - 0.00193661087454395*std::exp(0.855199873447418*x_19) + 0.00361861065660971*std::exp(0.776719868183136*x_2) - 0.00060149536698267*std::exp(1.21783995628357*x_2) - 21.2646036016855*std::exp(0.494959861040115*x_20) + 0.00043217644104001*std::exp(0.889919877052307*x_20) - 0.0751852079539636*std::exp(0.89383989572525*x_20) + 0.000417839498577487*std::exp(0.938079833984375*x_20) - 0.0318838239781681*std::exp(0.26503986120224*x_21) + 0.579605106505436*std::exp(0.480719864368439*x_22) - 2.36218357868007e-5*std::exp(1.3155198097229*x_22) + 0.000776069367543722*std::exp(1.41879987716675*x_22) + 0.0119026425534742*std::exp(0.465999871492386*x_23) + 2.08898532578866*std::exp(0.545759856700897*x_23) + 0.189060461713772*std::exp(0.615919828414917*x_23) - 19.0758362741525*std::exp(0.85647988319397*x_23) - 0.000778244434737966*std::exp(0.997199833393097*x_23) - 0.995160766060509*std::exp(0.477999836206436*x_24) - 0.00473483800980177*std::exp(0.564399838447571*x_24) + 153.702434633327*std::exp(0.582319855690002*x_24) + 0.356247562247907*std::exp(0.562079846858978*x_25) - 0.00475174563456746*std::exp(0.609439849853516*x_25) - 0.00236327335278758*std::exp(0.693359851837158*x_25) - 0.0461643018746241*std::exp(1.08727979660034*x_25) + 0.00692238854664405*std::exp(0.552559852600098*x_26) + 0.391520761078827*std::exp(0.812399864196777*x_26) - 0.0387008915481539*std::exp(0.856399893760681*x_26) - 9.9627457290477e-6*std::exp(1.24303984642029*x_26) - 0.0316327947831418*std::exp(0.956959843635559*x_27) + 1.60406123281534*std::exp(1.00351977348328*x_27) - 9.69691723449976e-5*std::exp(1.22839987277985*x_27) + 0.00324859256705216*std::exp(0.543519854545593*x_28) - 0.00747808035745802*std::exp(0.643999814987183*x_28) + 1.60518739790632*std::exp(1.05095982551575*x_28) + 5.48454520479449e-5*std::exp(1.24479985237122*x_29) - 0.0126573185315078*std::exp(0.55927985906601*x_3) - 0.83815988461378*std::exp(0.633279860019684*x_3) + 0.00290256018876536*std::exp(0.864879846572876*x_30) + 0.121718964479765*std::exp(0.897199809551239*x_30) + 0.000383468325393989*std::exp(1.05735981464386*x_30) + 0.000989580157105747*std::exp(0.693919837474823*x_32) + 0.33765901045235*std::exp(0.863999903202057*x_32) - 0.0356822228412095*std::exp(0.405439853668213*x_33) - 0.885260457954588*std::exp(0.462239861488342*x_33) - 41.6954053409255*std::exp(0.586719870567322*x_4) - 0.35390758615788*std::exp(0.692239880561829*x_4) - 0.000373889339047181*std::exp(1.09551990032196*x_4) + 0.0216027820123497*std::exp(1.09767985343933*x_4) + 0.500851118881562*std::exp(0.733679831027985*x_41) + 0.182010226534947*std::exp(0.797679901123047*x_41) + 0.00267619740229659*std::exp(0.799919843673706*x_41) - 14.7055102230277*std::exp(0.818319857120514*x_41) + 0.000658247263854073*std::exp(0.826639890670776*x_41) + 0.10208366409712*std::exp(0.786239862442017*x_42) - 0.00372343110799885*std::exp(0.947999835014343*x_44) + 7.62070987166727e-5*std::exp(0.96455979347229*x_44) - 0.00361211943891321*std::exp(0.519359886646271*x_45) + 0.270163162600171*std::exp(0.539679825305939*x_45) - 19.949617225552*std::exp(0.743519842624664*x_46) + 0.540019988453584*std::exp(0.768079876899719*x_46) - 0.00419344868569262*std::exp(0.579119861125946*x_47) - 0.00769258741667267*std::exp(0.714559853076935*x_49) + 0.369738020523035*std::exp(0.727199852466583*x_49) + 0.00594900296389676*std::exp(0.735519826412201*x_49) - 37.6424670620528*std::exp(0.736719846725464*x_49) - 0.00861906700385196*std::exp(0.365119844675064*x_50) + 0.415632438961918*std::exp(0.555359840393066*x_50) - 99.3088158369119*std::exp(0.55735981464386*x_50) + 2.99709984865446*std::exp(0.56335985660553*x_50) + 0.00356654774493996*std::exp(0.612239837646484*x_50) + 357.782026797877*std::exp(0.491039842367172*x_51) - 8.93936103654333*std::exp(0.49415984749794*x_51) - 0.0559610709616253*std::exp(0.496079862117767*x_51) + 5.9543214613303*std::exp(0.498559832572937*x_51) + 0.0655725516968522*std::exp(0.503359854221344*x_51) + 0.413564205362849*std::exp(0.533759832382202*x_52) + 0.000243127907498742*std::exp(0.626239836215973*x_52) - 0.16273395760466*std::exp(0.688319861888885*x_52) + 0.000471184039576364*std::exp(0.782239854335785*x_52) - 0.000911769215146103*std::exp(0.593119859695435*x_53) + 171.365704113737*std::exp(0.453199863433838*x_54) + 2.45540760987996*std::exp(0.465039849281311*x_54) - 0.00924238477063284*std::exp(0.507999837398529*x_54) + 0.0242174112256533*std::exp(0.515119850635529*x_54) + 0.329441875256148*std::exp(0.566639840602875*x_55) + 0.11860453000434*std::exp(0.652239859104156*x_55) - 17.0130373166077*std::exp(0.65311986207962*x_55) + 449.329628806007*std::exp(0.653519809246063*x_55) - 101.118789412571*std::exp(0.507439851760864*x_56) - 0.0173739944274134*std::exp(0.561359822750092*x_56) - 0.011979661001257*std::exp(0.582399845123291*x_56) - 187.560615881609*std::exp(0.614079833030701*x_57) + 8.21237958976307*std::exp(0.629199862480164*x_57) + 0.0244014097300098*std::exp(0.635999858379364*x_57) - 1.12599476714204*std::exp(0.639119863510132*x_57) + 0.00384197155256275*std::exp(0.647839844226837*x_57) - 0.00719025465575943*std::exp(0.57399982213974*x_58) + 0.00499277541327756*std::exp(0.582559823989868*x_58) - 0.516815620102012*std::exp(0.585679829120636*x_58) + 3.65429050292962*std::exp(0.615999817848206*x_58) + 67.7585266022489*std::exp(0.616879820823669*x_58) - 1.76191165879877*std::exp(0.506879806518555*x_59) + 0.000550974937724431*std::exp(0.877119898796082*x_59) + 0.14319857840456*std::exp(0.79807984828949*x_60) - 0.00384822151496406*std::exp(0.803999841213226*x_60) + 0.00211127962998703*std::exp(0.806159913539886*x_60) - 0.389831070874936*std::exp(0.821119904518127*x_60) - 29.9359186372366*std::exp(0.831999897956848*x_60) - 0.255925215858236*std::exp(1.11703991889954*x_61) + 0.144566731135749*std::exp(1.19711995124817*x_61) - 0.000189386504379736*std::exp(1.54751980304718*x_61) - 0.000413327013261776*std::exp(1.57471978664398*x_61) - 0.00180982692001651*std::exp(0.964639782905579*x_66) + 23.3220846003744*std::exp(1.03479981422424*x_66) + 0.226528722845966*std::exp(1.18119990825653*x_66) - 182.287859620982*std::exp(0.348559856414795*x_8) - 0.0013883043688699*std::exp(0.771119832992554*x_8) - 0.00577427844662372*std::exp(1.57039988040924*x_9) + 2.98191680928805*std::sin(0.272079944610596*x_100 + 1.9314398765564) - 298.536417081435*std::sin(0.228799998760223*x_101 + 1.96423983573914) - 0.0726808055975171*std::sin(0.229599997401237*x_102 + 1.99663984775543) - 0.0494259789674125*std::sin(0.211759999394417*x_108 + 1.99663984775543) + 0.0281586532621654*std::sin(0.303359925746918*x_112 + 1.9437597990036) - 460.127287699305*std::sin(0.268159955739975*x_120 + 1.97183978557587) + 0.0317774310426781*std::sin(0.377679854631424*x_15 + 2.02607989311218) + 22.5218111584313*std::sin(0.240319982171059*x_30 + 1.82743990421295) + 2.46216977686194*std::sin(0.347679853439331*x_31 - 4.23023986816406) - 358.824094495916*std::sin(0.387039840221405*x_31 - 7.40623998641968) - 0.00814544636214545*std::sin(0.609119892120361*x_65 + 2.20607995986938) - 2.11119743099488*std::sin(0.436879843473434*x_91 - 4.40895986557007) + 275.072014130583*std::sin(0.307679921388626*x_92 + 8.2163200378418) + 0.0599015109860986*std::sin(0.223119989037514*x_93 + 1.9903998374939) + 8.45224024346588*std::sin(0.275119960308075*x_94 - 1.19951987266541) - 0.0452909916894208*std::sin(0.27007994055748*x_95 + 1.96999979019165) + 0.0541455244594211*std::sin(0.329999834299088*x_97 + 1.85111999511719) - 4.75289018282896*std::sin(0.268239974975586*x_98 + 1.96031987667084) + 132.340086071518);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0031403049632227*x_1 - 43.7661105283103*x_10 - 9.29855652458038*x_100 - 5.15540652512177*x_101 + 21.1975872327635*x_102 - 33.2243508954116*x_103 + 1104.50971889361*x_104 - 114.091272129825*x_105 + 231.434016633725*x_106 + 48.8082242163705*x_107 + 28.749820011519*x_108 + 52.8394350325584*x_109 - 15.7965512635212*x_110 - 149.191939943066*x_111 - 66.6883365878618*x_112 + 3.87119927304697*x_113 + 76.4634761131046*x_114 - 76.5337319454048*x_115 - 18.4153217940309*x_116 - 95.100129874936*x_117 - 83.0589716576753*x_118 + 105.544634429531*x_119 + 0.882024415975388*x_12 + 15.4952798999109*x_120 - 101.753186961944*x_13 + 60.2086676331264*x_14 + 0.010295354763083*x_16 + 0.00147742065865133*x_17 - 47.5293012547814*x_18 - 0.00258098329895224*x_19 + 4.90847972871156*x_2 - 2.96801522403021*x_20 - 43.4113717598719*x_21 - 4.2599538783913*x_22 + 8.39330543512057*x_24 - 68.9863373247317*x_25 + 221.627997118049*x_26 - 8.68789861217289*x_27 - 15.6176500925767*x_28 + 98.386059415467*x_29 - 42.1818918386277*x_3 + 24.8086105697639*x_30 - 0.372733681103788*x_31 + 75.2284539920221*x_32 - 40.7659356011305*x_33 + 400.463423664966*x_34 - 634.746598426014*x_35 + 337.937449296356*x_36 + 367.230611215487*x_37 + 1827.11598058384*x_38 - 351.300881618632*x_39 + 0.0102227059605809*x_4 - 6614.55615358335*x_40 - 100.990288789118*x_42 - 84.9808720358365*x_43 + 65.0026577416381*x_44 - 249.642107318977*x_45 + 0.956639000714302*x_46 + 501.312171410385*x_47 - 115.851483922047*x_48 - 9.87166684295436*x_49 + 32.3345359263577*x_5 + 73.6097735609886*x_52 - 51.2832259953852*x_53 + 4.97555071559633*x_54 + 0.013592097898985*x_55 + 10.4656777485635*x_56 - 171.883200875992*x_59 - 128.931970151947*x_6 - 59.8623971583492*x_61 + 17.2670869816028*x_62 - 22.711685690793*x_63 - 36.9683789581352*x_64 - 34.0036055254394*x_65 - 0.49825003524141*x_66 - 12.0775600470565*x_67 + 62.2382504982339*x_68 - 44.9638215694603*x_69 + 17.0970281626428*x_7 - 24.6940270133906*x_70 - 75.7650486582713*x_71 - 6.87867444365827*x_72 - 115.671967959928*x_73 + 58.8806448058505*x_74 + 32.3317094986085*x_75 - 5.00386225039077*x_76 + 4.1029430633092*x_77 - 62.1395363518584*x_78 + 52.5543800343715*x_79 - 17.944919205917*x_8 + 20.4917982436545*x_80 + 10.4709167455423*x_81 + 52.6472434338407*x_82 + 6.06429550034303*x_83 - 22.6254340625061*x_84 - 96.2051555203425*x_85 + 182.826202549916*x_86 - 202.002356335479*x_87 + 335.536544413098*x_88 - 60.8421247170694*x_89 + 7.89682833580817*x_9 + 55.0425514052576*x_90 + 80.6645134211579*x_91 + 8.93019266581733*x_92 + 9.9287878669464*x_93 - 43.6463545356336*x_94 - 38.905995279442*x_95 - 46.3641705516414*x_96 + 19.370529189484*x_97 - 112.982529359209*x_98 + 107.508129704481*x_99 + 3.4766425809011e-5*std::pow(-9.51239967346191*x_16 - 6.14495992660522, 2) + 0.733890756453879*std::pow(-9.43984031677246*x_18 - 3.81256008148193, 2) + 0.0957927409423708*std::exp(1.24503993988037*x_1) + 18.6300993805565*std::exp(1.2720799446106*x_1) + 0.000244514646671835*std::exp(1.29311990737915*x_1) + 0.35293018431563*std::exp(1.79351997375488*x_1) - 0.534974825441756*std::exp(0.504559814929962*x_10) - 0.00037852956577435*std::exp(0.782479882240295*x_10) - 0.770674278554138*std::exp(0.861839890480042*x_10) + 0.00157323491521742*std::exp(0.880719900131226*x_11) - 0.231353305588258*std::exp(0.926479816436768*x_11) - 25.8828995981335*std::exp(0.940879821777344*x_11) + 0.403073131963498*std::exp(0.993199825286865*x_11) + 0.00012644948260917*std::exp(1.04079973697662*x_11) + 0.0193788141569577*std::exp(0.265359848737717*x_12) + 15.3885625068778*std::exp(0.676719844341278*x_12) + 0.00070319837079711*std::exp(1.34455978870392*x_12) + 9.35652123788142e-6*std::exp(1.34767985343933*x_12) - 1.48864870020707*std::exp(0.278639853000641*x_13) - 1.80203046153325e-5*std::exp(1.14487981796265*x_13) - 1.56294025898628e-5*std::exp(1.15631985664368*x_13) + 0.291840022237598*std::exp(0.539919853210449*x_15) - 0.00257009425284888*std::exp(0.669359803199768*x_15) - 8.2816863146844*std::exp(0.951039850711823*x_15) + 0.953915942494193*std::exp(0.998479843139648*x_15) - 0.60994327114478*std::exp(0.589679837226868*x_16) + 63.1509321963383*std::exp(0.625999867916107*x_16) - 7.91816327894888*std::exp(0.720319867134094*x_16) - 0.79631283425432*std::exp(0.616719841957092*x_17) - 0.00502375489576067*std::exp(0.643679857254028*x_17) + 8.66838176851286*std::exp(0.665919840335846*x_17) + 98.670819909235*std::exp(0.673039853572845*x_17) + 16.9273127007891*std::exp(0.753759860992432*x_19) - 0.797070762048638*std::exp(0.75519984960556*x_19) - 62.93166040634*std::exp(0.767119884490967*x_19) - 0.00214930943115563*std::exp(0.855199873447418*x_19) + 0.004016043756732*std::exp(0.776719868183136*x_2) - 0.000388420434741487*std::exp(1.21783995628357*x_2) - 25.8135773685329*std::exp(0.494959861040115*x_20) + 0.000279081386704389*std::exp(0.889919877052307*x_20) - 0.0861979683976506*std::exp(0.89383989572525*x_20) + 0.000463730936765198*std::exp(0.938079833984375*x_20) - 0.0205892338505376*std::exp(0.26503986120224*x_21) - 4.42327089254121*std::exp(0.480719864368439*x_22) - 1.52539890236021e-5*std::exp(1.3155198097229*x_22) + 0.000889744201530693*std::exp(1.41879987716675*x_22) + 0.0132099133760574*std::exp(0.465999871492386*x_23) - 15.942143854145*std::exp(0.545759856700897*x_23) + 0.216753110718633*std::exp(0.615919828414917*x_23) - 23.1565838120429*std::exp(0.85647988319397*x_23) - 0.000502557556166136*std::exp(0.997199833393097*x_23) - 1.14092703335993*std::exp(0.477999836206436*x_24) - 0.00525486669688231*std::exp(0.564399838447571*x_24) + 186.582819151389*std::exp(0.582319855690002*x_24) + 0.408428957610754*std::exp(0.562079846858978*x_25) - 0.00527363129117691*std::exp(0.609439849853516*x_25) - 0.00152610263268939*std::exp(0.693359851837158*x_25) + 0.352304026421815*std::exp(1.08727979660034*x_25) + 0.00447018766283272*std::exp(0.552559852600098*x_26) - 2.9879004978872*std::exp(0.812399864196777*x_26) - 0.0443696082967714*std::exp(0.856399893760681*x_26) - 1.10569570981523e-5*std::exp(1.24303984642029*x_26) - 0.036266211389828*std::exp(0.956959843635559*x_27) + 1.94720576563491*std::exp(1.00351977348328*x_27) - 6.2618617110398e-5*std::exp(1.22839987277985*x_27) + 0.00360538646876676*std::exp(0.543519854545593*x_28) - 0.00482903008554563*std::exp(0.643999814987183*x_28) + 1.94857284259765*std::exp(1.05095982551575*x_28) + 3.54168884706803e-5*std::exp(1.24479985237122*x_29) - 0.00817356448035846*std::exp(0.55927985906601*x_3) - 0.960929432959137*std::exp(0.633279860019684*x_3) + 0.00187435141194704*std::exp(0.864879846572876*x_30) + 0.139547761310254*std::exp(0.897199809551239*x_30) + 0.00042558476726144*std::exp(1.05735981464386*x_30) + 0.00109826604430935*std::exp(0.693919837474823*x_32) - 2.57685319845286*std::exp(0.863999903202057*x_32) - 0.0230420802375433*std::exp(0.405439853668213*x_33) - 1.01492906723332*std::exp(0.462239861488342*x_33) - 50.6149840289055*std::exp(0.586719870567322*x_4) - 0.4057462333017*std::exp(0.692239880561829*x_4) - 0.000241442025308397*std::exp(1.09551990032196*x_4) - 0.164862172193859*std::exp(1.09767985343933*x_4) - 3.82225786277597*std::exp(0.733679831027985*x_41) + 0.208670191675403*std::exp(0.797679901123047*x_41) + 0.00297012497037889*std::exp(0.799919843673706*x_41) - 17.8513473844294*std::exp(0.818319857120514*x_41) + 0.000425068425175351*std::exp(0.826639890670776*x_41) - 0.779054040305476*std::exp(0.786239862442017*x_42) - 0.00426882103158689*std::exp(0.947999835014343*x_44) + 8.45769473598172e-5*std::exp(0.96455979347229*x_44) - 0.00233255496187599*std::exp(0.519359886646271*x_45) + 0.309735337385486*std::exp(0.539679825305939*x_45) - 24.217286029427*std::exp(0.743519842624664*x_46) - 4.12117607230704*std::exp(0.768079876899719*x_46) - 0.00465401641997328*std::exp(0.579119861125946*x_47) - 0.00853746661343997*std::exp(0.714559853076935*x_49) + 0.423895432037231*std::exp(0.727199852466583*x_49) + 0.0038416161526008*std::exp(0.735519826412201*x_49) - 45.6950317085492*std::exp(0.736719846725464*x_49) - 0.00956570173319088*std::exp(0.365119844675064*x_50) + 0.476512239756187*std::exp(0.555359840393066*x_50) - 120.553190127669*std::exp(0.55735981464386*x_50) - 22.8724425885792*std::exp(0.56335985660553*x_50) + 0.00230312667671098*std::exp(0.612239837646484*x_50) + 434.319595267952*std::exp(0.491039842367172*x_51) - 10.248754789572*std::exp(0.49415984749794*x_51) - 0.062107292268363*std::exp(0.496079862117767*x_51) - 45.440553420122*std::exp(0.498559832572937*x_51) + 0.0423439986993845*std::exp(0.503359854221344*x_51) + 0.474141061445146*std::exp(0.533759832382202*x_52) + 0.000269830718929138*std::exp(0.626239836215973*x_52) + 1.24190827482638*std::exp(0.688319861888885*x_52) + 0.000304270854842302*std::exp(0.782239854335785*x_52) - 0.00101190910311932*std::exp(0.593119859695435*x_53) + 208.02465657542*std::exp(0.453199863433838*x_54) - 18.7385046960492*std::exp(0.465039849281311*x_54) - 0.0102574786783475*std::exp(0.507999837398529*x_54) + 0.015638586617497*std::exp(0.515119850635529*x_54) + 0.377696905082447*std::exp(0.566639840602875*x_55) + 0.131630901316786*std::exp(0.652239859104156*x_55) + 129.835420550358*std::exp(0.65311986207962*x_55) + 545.451274541447*std::exp(0.653519809246063*x_55) - 122.750357486414*std::exp(0.507439851760864*x_56) - 0.0112193955915982*std::exp(0.561359822750092*x_56) - 0.0132953907831961*std::exp(0.582399845123291*x_56) - 227.684021768731*std::exp(0.614079833030701*x_57) - 62.6729806038342*std::exp(0.629199862480164*x_57) + 0.0157574051204764*std::exp(0.635999858379364*x_57) - 1.29092495712001*std::exp(0.639119863510132*x_57) + 0.00426393644727382*std::exp(0.647839844226837*x_57) - 0.00797996249384571*std::exp(0.57399982213974*x_58) + 0.00322412457858176*std::exp(0.582559823989868*x_58) - 0.592516236920469*std::exp(0.585679829120636*x_58) - 27.887809532863*std::exp(0.615999817848206*x_58) + 82.2535891845313*std::exp(0.616879820823669*x_58) + 13.446072969546*std::exp(0.506879806518555*x_59) + 0.000355796464262298*std::exp(0.877119898796082*x_59) + 0.164173603715544*std::exp(0.79807984828949*x_60) - 0.00248501976220035*std::exp(0.803999841213226*x_60) + 0.00234316210870524*std::exp(0.806159913539886*x_60) + 2.97500558476032*std::exp(0.821119904518127*x_60) - 36.3398804094877*std::exp(0.831999897956848*x_60) + 1.95309969713395*std::exp(1.11703991889954*x_61) + 0.16574215674739*std::exp(1.19711995124817*x_61) - 0.000210186881292206*std::exp(1.54751980304718*x_61) - 0.000266909218248667*std::exp(1.57471978664398*x_61) - 0.0011687101807717*std::exp(0.964639782905579*x_66) + 28.3111995174702*std::exp(1.03479981422424*x_66) + 0.259709538942724*std::exp(1.18119990825653*x_66) - 221.283305149291*std::exp(0.348559856414795*x_8) - 0.000896508628511993*std::exp(0.771119832992554*x_8) - 0.00700952560514971*std::exp(1.57039988040924*x_9) + 3.41869335586355*std::sin(0.272079944610596*x_100 + 1.9314398765564) - 362.400026071748*std::sin(0.228799998760223*x_101 + 1.96423983573914) - 0.0469342103982697*std::sin(0.229599997401237*x_102 + 1.99663984775543) - 0.054854449148839*std::sin(0.211759999394417*x_108 + 1.99663984775543) + 0.031251326645197*std::sin(0.303359925746918*x_112 + 1.9437597990036) - 558.558793894363*std::sin(0.268159955739975*x_120 + 1.97183978557587) + 0.0352675558811006*std::sin(0.377679854631424*x_15 + 2.02607989311218) - 171.875766148835*std::sin(0.240319982171059*x_30 + 1.82743990421295) + 2.82281632772164*std::sin(0.347679853439331*x_31 - 4.23023986816406) - 435.58458452665*std::sin(0.387039840221405*x_31 - 7.40623998641968) - 0.00904006319351806*std::sin(0.609119892120361*x_65 + 2.20607995986938) + 16.1116560915597*std::sin(0.436879843473434*x_91 - 4.40895986557007) + 333.916063129207*std::sin(0.307679921388626*x_92 + 8.2163200378418) + 0.0664805120095244*std::sin(0.223119989037514*x_93 + 1.9903998374939) - 64.5034831923749*std::sin(0.275119960308075*x_94 - 1.19951987266541) - 0.0502653149706118*std::sin(0.27007994055748*x_95 + 1.96999979019165) + 0.0349649046431311*std::sin(0.329999834299088*x_97 + 1.85111999511719) - 5.4490702217363*std::sin(0.268239974975586*x_98 + 1.96031987667084) + 408.355562380377);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00998902071834907*x_1 - 29.735089026392*x_10 - 13.2674985110347*x_100 - 6.86630930998756*x_101 + 8.01740885446609*x_102 - 12.1862596647242*x_103 + 707.306920078558*x_104 - 83.820960937505*x_105 + 147.036574484419*x_106 + 29.6129874032549*x_107 + 23.2000819409407*x_108 + 27.1905921689355*x_109 - 15.5477142301828*x_110 - 108.110051195058*x_111 - 48.9437706138305*x_112 - 7.75014932462749*x_113 + 60.5958599684587*x_114 - 46.5392846594442*x_115 - 23.4786043168458*x_116 - 70.7795491262601*x_117 - 57.1172188552648*x_118 + 72.4248977035308*x_119 + 1.08967222559371*x_12 + 19.7175295213074*x_120 - 91.8935728654028*x_13 + 37.1159521142648*x_14 - 0.0160982608815158*x_16 - 0.00231015868243747*x_17 - 60.1137383353369*x_18 + 0.00403573683797239*x_19 + 6.12818897696769*x_2 - 3.66675082479266*x_20 - 30.1154296084248*x_21 - 2.85087412308092*x_22 + 10.370047573921*x_24 - 46.8700581525563*x_25 + 150.576440437193*x_26 - 10.8338047717899*x_27 - 18.5935896547076*x_28 + 93.7427778262081*x_29 - 27.7782258588059*x_3 + 16.8552363436187*x_30 - 0.455599611807774*x_31 + 51.2329876754257*x_32 - 11.0006308957476*x_33 + 204.401566557952*x_34 - 508.708300255323*x_35 + 260.346146113107*x_36 + 108.267235339689*x_37 + 1255.65704741384*x_38 - 334.868190471117*x_39 - 0.0325174856689839*x_4 - 4559.48433902935*x_40 - 68.7443714796387*x_42 - 73.0244964332845*x_43 + 45.0852795079494*x_44 - 182.474808899275*x_45 + 0.0345447127679752*x_46 + 403.258177302621*x_47 - 131.544885169209*x_48 - 12.1956728002662*x_49 + 21.3998732587678*x_5 + 50.0112703644462*x_52 - 30.2315887579829*x_53 + 0.779027763452804*x_54 - 0.0212531906806716*x_55 + 14.0064588221747*x_56 - 117.502420826583*x_59 - 90.4118663659672*x_6 - 40.671155257251*x_61 + 13.8610924991659*x_62 - 17.9987760948008*x_63 - 24.4958513357548*x_64 - 20.6180246985649*x_65 - 0.612730212659356*x_66 - 9.22416779993913*x_67 + 41.7372506141568*x_68 - 32.9436084069627*x_69 + 1.55265943213349*x_7 - 13.9202854003834*x_70 - 53.8373820745835*x_71 - 2.49275831013872*x_72 - 81.5915131501487*x_73 + 45.6433634301896*x_74 + 25.0736002587067*x_75 + 1.11774114950811*x_76 + 7.33416712522359*x_77 - 39.894947671422*x_78 + 54.4625873695134*x_79 - 21.9545697818666*x_8 + 12.8253336078651*x_80 + 13.4681624946071*x_81 + 32.3459333446635*x_82 + 13.486274863971*x_83 - 21.452090494639*x_84 - 76.9122012106743*x_85 + 98.8101813122107*x_86 - 178.504085158921*x_87 + 229.874258999878*x_88 - 42.1057135700518*x_89 + 9.91707185314379*x_9 + 36.6879359074468*x_90 + 54.5789994472623*x_91 + 10.2655859100487*x_92 + 4.97222927920322*x_93 - 29.8869138229008*x_94 - 31.5870298275281*x_95 - 35.5933262452503*x_96 + 13.8479437271679*x_97 - 72.5710940572693*x_98 + 69.5282471787345*x_99 - 0.000110588796876836*std::pow(-9.51239967346191*x_16 - 6.14495992660522, 2) + 0.498613258313764*std::pow(-9.43984031677246*x_18 - 3.81256008148193, 2) + 0.0149983808822266*std::exp(1.24503993988037*x_1) + 12.6574895148339*std::exp(1.2720799446106*x_1) - 0.000382333650666365*std::exp(1.29311990737915*x_1) + 0.436017657172363*std::exp(1.79351997375488*x_1) - 0.0837616307399042*std::exp(0.504559814929962*x_10) + 0.00120406766836661*std::exp(0.782479882240295*x_10) - 0.952107834102574*std::exp(0.861839890480042*x_10) - 0.00500431529643846*std::exp(0.880719900131226*x_11) - 0.0362232561824532*std::exp(0.926479816436768*x_11) - 17.5851198420761*std::exp(0.940879821777344*x_11) + 0.497965349743728*std::exp(0.993199825286865*x_11) - 0.000197721866435765*std::exp(1.04079973697662*x_11) - 0.0616422221338123*std::exp(0.265359848737717*x_12) + 10.4551545646856*std::exp(0.676719844341278*x_12) + 0.000110100586925697*std::exp(1.34455978870392*x_12) - 1.46302602772819e-5*std::exp(1.34767985343933*x_12) - 0.233079458692694*std::exp(0.278639853000641*x_13) + 2.81773257491067e-5*std::exp(1.14487981796265*x_13) + 4.97156894358883e-5*std::exp(1.15631985664368*x_13) + 0.0456937317706597*std::exp(0.539919853210449*x_15) + 0.0040187102556975*std::exp(0.669359803199768*x_15) - 5.62666658679574*std::exp(0.951039850711823*x_15) + 1.17848858745876*std::exp(0.998479843139648*x_15) - 0.0954995274922158*std::exp(0.589679837226868*x_16) + 42.905421264761*std::exp(0.625999867916107*x_16) - 9.78227183568962*std::exp(0.720319867134094*x_16) - 0.124679626786511*std::exp(0.616719841957092*x_17) + 0.0159801013995028*std::exp(0.643679857254028*x_17) + 10.7091081413498*std::exp(0.665919840335846*x_17) + 67.0380142858852*std::exp(0.673039853572845*x_17) + 20.9123717778174*std::exp(0.753759860992432*x_19) - 0.124798296422942*std::exp(0.75519984960556*x_19) - 42.756445656735*std::exp(0.767119884490967*x_19) + 0.00683675524810299*std::exp(0.855199873447418*x_19) - 0.0127746651238049*std::exp(0.776719868183136*x_2) + 0.000607350949440016*std::exp(1.21783995628357*x_2) - 17.5380215751055*std::exp(0.494959861040115*x_20) - 0.000436383696699063*std::exp(0.889919877052307*x_20) - 0.0134961161835829*std::exp(0.89383989572525*x_20) - 0.00147508537843828*std::exp(0.938079833984375*x_20) + 0.0321942143329538*std::exp(0.26503986120224*x_21) - 5.46460545828444*std::exp(0.480719864368439*x_22) + 2.38517953423288e-5*std::exp(1.3155198097229*x_22) + 0.000139308284646936*std::exp(1.41879987716675*x_22) - 0.0420195171954311*std::exp(0.465999871492386*x_23) - 19.695272670055*std::exp(0.545759856700897*x_23) + 0.0339372866877385*std::exp(0.615919828414917*x_23) - 15.7328316297769*std::exp(0.85647988319397*x_23) + 0.00078582067673371*std::exp(0.997199833393097*x_23) - 0.178636272820044*std::exp(0.477999836206436*x_24) + 0.0167152467426131*std::exp(0.564399838447571*x_24) + 126.766370313711*std::exp(0.582319855690002*x_24) + 0.063948197006516*std::exp(0.562079846858978*x_25) + 0.0167749351879632*std::exp(0.609439849853516*x_25) + 0.00238627991733672*std::exp(0.693359851837158*x_25) + 0.43524408803599*std::exp(1.08727979660034*x_25) - 0.00698977828754929*std::exp(0.552559852600098*x_26) - 3.6913175263803*std::exp(0.812399864196777*x_26) - 0.00694700118488656*std::exp(0.856399893760681*x_26) + 3.51711616638641e-5*std::exp(1.24303984642029*x_26) - 0.005678242904723*std::exp(0.956959843635559*x_27) + 1.32295250059003*std::exp(1.00351977348328*x_27) + 9.79131712777493e-5*std::exp(1.22839987277985*x_27) - 0.011468402131622*std::exp(0.543519854545593*x_28) + 0.00755087978129302*std::exp(0.643999814987183*x_28) + 1.32388130735421*std::exp(1.05095982551575*x_28) - 5.53793748086275e-5*std::exp(1.24479985237122*x_29) + 0.0127805380547469*std::exp(0.55927985906601*x_3) - 0.150453839139374*std::exp(0.633279860019684*x_3) - 0.00293081673313076*std::exp(0.864879846572876*x_30) + 0.0218491553201551*std::exp(0.897199809551239*x_30) - 0.00135374592830168*std::exp(1.05735981464386*x_30) - 0.00349348308503354*std::exp(0.693919837474823*x_32) - 3.18350071599918*std::exp(0.863999903202057*x_32) + 0.0360295907671775*std::exp(0.405439853668213*x_33) - 0.15890862469387*std::exp(0.462239861488342*x_33) - 34.3883635053492*std::exp(0.586719870567322*x_4) - 0.0635281597407132*std::exp(0.692239880561829*x_4) + 0.00037752916733995*std::exp(1.09551990032196*x_4) - 0.203674327872245*std::exp(1.09767985343933*x_4) - 4.72210083608431*std::exp(0.733679831027985*x_41) + 0.0326717346505178*std::exp(0.797679901123047*x_41) - 0.00944769384268765*std::exp(0.799919843673706*x_41) - 12.128397048697*std::exp(0.818319857120514*x_41) - 0.000664655328391885*std::exp(0.826639890670776*x_41) - 0.962460374771676*std::exp(0.786239862442017*x_42) - 0.00066837427470958*std::exp(0.947999835014343*x_44) - 0.000269031476040124*std::exp(0.96455979347229*x_44) + 0.00364728357214077*std::exp(0.519359886646271*x_45) + 0.0484956220804586*std::exp(0.539679825305939*x_45) - 16.4534841029952*std::exp(0.743519842624664*x_46) - 5.09139092006686*std::exp(0.768079876899719*x_46) + 0.0148039973783123*std::exp(0.579119861125946*x_47) + 0.0271568945954684*std::exp(0.714559853076935*x_49) + 0.0663698008991646*std::exp(0.727199852466583*x_49) - 0.00600691675560033*std::exp(0.735519826412201*x_49) - 31.0456950827971*std::exp(0.736719846725464*x_49) + 0.0304276157626207*std::exp(0.365119844675064*x_50) + 0.0746080756913073*std::exp(0.555359840393066*x_50) - 81.905131521374*std::exp(0.55735981464386*x_50) - 28.2571150739629*std::exp(0.56335985660553*x_50) - 0.00360126823582807*std::exp(0.612239837646484*x_50) + 295.081395482432*std::exp(0.491039842367172*x_51) - 1.60465945947846*std::exp(0.49415984749794*x_51) + 0.19755757370538*std::exp(0.496079862117767*x_51) - 56.1382520491313*std::exp(0.498559832572937*x_51) - 0.0662109032195342*std::exp(0.503359854221344*x_51) + 0.0742368175448256*std::exp(0.533759832382202*x_52) - 0.000858306652823973*std::exp(0.626239836215973*x_52) + 1.53428060414494*std::exp(0.688319861888885*x_52) - 0.000475771035832321*std::exp(0.782239854335785*x_52) + 0.00321878961264059*std::exp(0.593119859695435*x_53) + 141.334184839526*std::exp(0.453199863433838*x_54) - 23.1499579224935*std::exp(0.465039849281311*x_54) + 0.0326280944799978*std::exp(0.507999837398529*x_54) - 0.0244531687328917*std::exp(0.515119850635529*x_54) + 0.0591364437924657*std::exp(0.566639840602875*x_55) - 0.418705767696832*std::exp(0.652239859104156*x_55) + 160.401513959849*std::exp(0.65311986207962*x_55) + 370.585451388769*std::exp(0.653519809246063*x_55) - 83.3979106116821*std::exp(0.507439851760864*x_56) + 0.0175431309870074*std::exp(0.561359822750092*x_56) + 0.0422914129510531*std::exp(0.582399845123291*x_56) - 154.6909685968*std::exp(0.614079833030701*x_57) - 77.4275689223972*std::exp(0.629199862480164*x_57) - 0.0246389584703539*std::exp(0.635999858379364*x_57) - 0.202121622231335*std::exp(0.639119863510132*x_57) - 0.0135631889298522*std::exp(0.647839844226837*x_57) + 0.0253835253633678*std::exp(0.57399982213974*x_58) - 0.00504138028993707*std::exp(0.582559823989868*x_58) - 0.0927709564713587*std::exp(0.585679829120636*x_58) - 34.4532089250648*std::exp(0.615999817848206*x_58) + 55.8839714911688*std::exp(0.616879820823669*x_58) + 16.6115721887562*std::exp(0.506879806518555*x_59) - 0.000556338701698143*std::exp(0.877119898796082*x_59) + 0.0257048521120699*std::exp(0.79807984828949*x_60) + 0.00388568411173857*std::exp(0.803999841213226*x_60) - 0.0074533827524468*std::exp(0.806159913539886*x_60) + 3.67538686909769*std::exp(0.821119904518127*x_60) - 24.6897048618787*std::exp(0.831999897956848*x_60) + 2.41290201862365*std::exp(1.11703991889954*x_61) + 0.0259504422849176*std::exp(1.19711995124817*x_61) + 0.000668585101301235*std::exp(1.54751980304718*x_61) + 0.000417350768956095*std::exp(1.57471978664398*x_61) + 0.00182744566048469*std::exp(0.964639782905579*x_66) + 19.2349328752773*std::exp(1.03479981422424*x_66) + 0.0406630246247346*std::exp(1.18119990825653*x_66) - 150.342253013321*std::exp(0.348559856414795*x_8) + 0.00140181956974101*std::exp(0.771119832992554*x_8) - 0.00476234694398565*std::exp(1.57039988040924*x_9) + 0.535268795593041*std::sin(0.272079944610596*x_100 + 1.9314398765564) - 246.218468107907*std::sin(0.228799998760223*x_101 + 1.96423983573914) + 0.0733883562680693*std::sin(0.229599997401237*x_102 + 1.99663984775543) + 0.174486948069865*std::sin(0.211759999394417*x_108 + 1.99663984775543) - 0.0994075903425653*std::sin(0.303359925746918*x_112 + 1.9437597990036) - 379.490840747463*std::sin(0.268159955739975*x_120 + 1.97183978557587) - 0.112182845458524*std::sin(0.377679854631424*x_15 + 2.02607989311218) - 212.339075010653*std::sin(0.240319982171059*x_30 + 1.82743990421295) + 0.441971636130633*std::sin(0.347679853439331*x_31 - 4.23023986816406) - 295.940842764558*std::sin(0.387039840221405*x_31 - 7.40623998641968) + 0.0287556080039328*std::sin(0.609119892120361*x_65 + 2.20607995986938) + 19.9046917900516*std::sin(0.436879843473434*x_91 - 4.40895986557007) + 226.866157907007*std::sin(0.307679921388626*x_92 + 8.2163200378418) - 0.211468382722961*std::sin(0.223119989037514*x_93 + 1.9903998374939) - 79.6890117957267*std::sin(0.275119960308075*x_94 - 1.19951987266541) + 0.159889335123843*std::sin(0.27007994055748*x_95 + 1.96999979019165) - 0.0546726333958688*std::sin(0.329999834299088*x_97 + 1.85111999511719) - 0.853167263360462*std::sin(0.268239974975586*x_98 + 1.96031987667084) + 338.08065484034);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00620321546861895*x_1 + 28.8858131255894*x_10 - 1.06831770469789*x_100 + 0.80542431771787*x_101 - 21.3017383082633*x_102 + 32.5391787903069*x_103 - 750.106333164716*x_104 + 68.4259978966855*x_105 - 167.838155634319*x_106 - 34.7217293706159*x_107 - 14.9698914980246*x_108 - 42.2882733623569*x_109 + 4.35914915756607*x_110 + 90.5776075683495*x_111 + 41.5424097597489*x_112 - 14.0718547255083*x_113 - 39.7001341129525*x_114 + 55.9111036478179*x_115 + 1.08471918593058*x_116 + 56.3585523695851*x_117 + 54.9026932804579*x_118 - 68.9040714553259*x_119 - 0.0713357805544033*x_12 - 1.69052979825053*x_120 + 43.4499442782818*x_13 - 42.2529811841116*x_14 + 0.00876698914842777*x_16 + 0.00125809466309062*x_17 + 4.86349242229298*x_18 - 0.00219783126418577*x_19 - 0.0104968163440824*x_2 + 0.240045149395791*x_20 + 28.2922646823862*x_21 + 2.78197455478265*x_22 - 0.679086223358776*x_24 + 45.5313476839219*x_25 - 146.27565086943*x_26 + 0.749486214110901*x_27 + 0.719102153587667*x_28 - 37.504725057757*x_29 + 28.7532413225988*x_3 - 16.373814253826*x_30 + 0.0278534617970063*x_31 - 49.8976834052445*x_32 + 44.2599049463339*x_33 - 351.76896144842*x_34 + 343.216478470638*x_35 - 190.278085197481*x_36 - 384.399439071956*x_37 - 1192.38250969784*x_38 + 129.909107389905*x_39 + 0.0201934679874979*x_4 + 4259.18196649181*x_40 + 67.0390642477481*x_42 + 37.9939492436746*x_43 - 41.9581711679632*x_44 + 151.294577989915*x_45 + 0.757731446572574*x_46 - 257.977494122187*x_47 + 23.3514612364823*x_48 + 0.79839406581101*x_49 - 21.7034561855946*x_5 - 48.582840065327*x_52 + 40.1249030719786*x_53 + 3.76454672679872*x_54 + 0.0115743242974063*x_55 - 1.68243302820869*x_56 + 115.332010393395*x_59 + 82.2106027415176*x_6 + 39.5094988936697*x_61 - 8.588833187493*x_62 + 12.3850633373686*x_63 + 24.003273063447*x_64 + 23.4533776008962*x_65 + 0.0389847246342371*x_66 + 7.38310667793548*x_67 - 42.1777517998907*x_68 + 27.2012663536372*x_69 - 20.424728755849*x_7 + 18.5025749415771*x_70 + 46.5798154987191*x_71 + 6.88712229567366*x_72 + 72.7354912469178*x_73 - 33.0651656958994*x_74 - 16.8857966454792*x_75 + 7.8005930357997*x_76 + 1.79616138843149*x_77 + 42.9379851996676*x_78 - 13.2887364759601*x_79 + 1.28216568602141*x_8 - 15.0126548055885*x_80 - 1.05489506249979*x_81 - 38.2211258119648*x_82 + 8.26456371246773*x_83 + 9.50492789650357*x_84 + 49.369921733144*x_85 - 158.949632796982*x_86 + 91.7455891838752*x_87 - 220.463011644379*x_88 + 38.5145499596064*x_89 - 0.773851345117029*x_9 - 37.0286535212184*x_90 - 52.6354099457485*x_91 - 0.126269405671861*x_92 - 10.0071711956997*x_93 + 29.4507766269763*x_94 + 19.4105164707656*x_95 + 26.6783147063273*x_96 - 10.9763885564861*x_97 + 78.9359357958437*x_98 - 76.1186163158897*x_99 + 6.86760148752329e-5*std::pow(-9.51239967346191*x_16 - 6.14495992660522, 2) - 0.484371782731806*std::pow(-9.43984031677246*x_18 - 3.81256008148193, 2) + 0.0724776552342829*std::exp(1.24503993988037*x_1) - 12.2959641746053*std::exp(1.2720799446106*x_1) + 0.000208215967621664*std::exp(1.29311990737915*x_1) - 0.0285440513021664*std::exp(1.79351997375488*x_1) - 0.404766797316247*std::exp(0.504559814929962*x_10) - 0.000747730072474028*std::exp(0.782479882240295*x_10) + 0.062330078644212*std::exp(0.861839890480042*x_10) + 0.00310769663333365*std::exp(0.880719900131226*x_11) - 0.175044005994412*std::exp(0.926479816436768*x_11) + 17.082850697281*std::exp(0.940879821777344*x_11) - 0.0325994790714801*std::exp(0.993199825286865*x_11) + 0.000107677808814713*std::exp(1.04079973697662*x_11) + 0.0382800273061909*std::exp(0.265359848737717*x_12) - 10.1565326849905*std::exp(0.676719844341278*x_12) + 0.000532046255056046*std::exp(1.34455978870392*x_12) + 7.96752730208752e-6*std::exp(1.34767985343933*x_12) - 1.12632508681927*std::exp(0.278639853000641*x_13) - 1.53451550383169e-5*std::exp(1.14487981796265*x_13) - 3.08736103805707e-5*std::exp(1.15631985664368*x_13) + 0.22080880354*std::exp(0.539919853210449*x_15) - 0.00218855871834138*std::exp(0.669359803199768*x_15) + 5.46595679124264*std::exp(0.951039850711823*x_15) - 0.077150175333708*std::exp(0.998479843139648*x_15) - 0.461488602201052*std::exp(0.589679837226868*x_16) - 41.6799494204259*std::exp(0.625999867916107*x_16) + 0.640399911646883*std::exp(0.720319867134094*x_16) - 0.602497501292303*std::exp(0.616719841957092*x_17) - 0.00992369672528607*std::exp(0.643679857254028*x_17) - 0.701075580676078*std::exp(0.665919840335846*x_17) - 65.123263268746*std::exp(0.673039853572845*x_17) - 1.36903587058179*std::exp(0.753759860992432*x_19) - 0.603070956324789*std::exp(0.75519984960556*x_19) + 41.5352288787237*std::exp(0.767119884490967*x_19) - 0.00424564800754598*std::exp(0.855199873447418*x_19) + 0.00793311001516376*std::exp(0.776719868183136*x_2) - 0.00033075865910098*std::exp(1.21783995628357*x_2) + 17.0370976589176*std::exp(0.494959861040115*x_20) + 0.000237651207274462*std::exp(0.889919877052307*x_20) - 0.0652181634428751*std::exp(0.89383989572525*x_20) + 0.00091603298211742*std::exp(0.938079833984375*x_20) - 0.0175327216881696*std::exp(0.26503986120224*x_21) + 0.357742343644832*std::exp(0.480719864368439*x_22) - 1.29895044238485e-5*std::exp(1.3155198097229*x_22) + 0.000673188519827815*std::exp(1.41879987716675*x_22) + 0.0260942615297406*std::exp(0.465999871492386*x_23) + 1.2893580437775*std::exp(0.545759856700897*x_23) + 0.163997366346104*std::exp(0.615919828414917*x_23) + 15.2834678518295*std::exp(0.85647988319397*x_23) - 0.000427951900906572*std::exp(0.997199833393097*x_23) - 0.863235724939556*std::exp(0.477999836206436*x_24) - 0.0103802244563466*std::exp(0.564399838447571*x_24) - 123.14564796561*std::exp(0.582319855690002*x_24) + 0.30902104779754*std::exp(0.562079846858978*x_25) - 0.0104172911816977*std::exp(0.609439849853516*x_25) - 0.0012995497025659*std::exp(0.693359851837158*x_25) - 0.0284934093229916*std::exp(1.08727979660034*x_25) + 0.00380657953352106*std::exp(0.552559852600098*x_26) + 0.241653417269598*std::exp(0.812399864196777*x_26) - 0.033570447419896*std::exp(0.856399893760681*x_26) - 2.18414097071408e-5*std::exp(1.24303984642029*x_26) - 0.0274393439409661*std::exp(0.956959843635559*x_27) - 1.28516610919531*std::exp(1.00351977348328*x_27) - 5.33227605390472e-5*std::exp(1.22839987277985*x_27) + 0.00712191630282033*std::exp(0.543519854545593*x_28) - 0.00411215109451285*std::exp(0.643999814987183*x_28) - 1.28606838722477*std::exp(1.05095982551575*x_28) + 3.01591818872447e-5*std::exp(1.24479985237122*x_29) - 0.00696018279624773*std::exp(0.55927985906601*x_3) - 0.727047910534124*std::exp(0.633279860019684*x_3) + 0.00159610026725871*std::exp(0.864879846572876*x_30) + 0.10558309986187*std::exp(0.897199809551239*x_30) + 0.000840680775403256*std::exp(1.05735981464386*x_30) + 0.00216946474769354*std::exp(0.693919837474823*x_32) + 0.208409008816911*std::exp(0.863999903202057*x_32) - 0.0196214382163992*std::exp(0.405439853668213*x_33) - 0.767904522811832*std::exp(0.462239861488342*x_33) + 33.406157294425*std::exp(0.586719870567322*x_4) - 0.306991274292289*std::exp(0.692239880561829*x_4) - 0.000205599482928287*std::exp(1.09551990032196*x_4) + 0.0133336124537301*std::exp(1.09767985343933*x_4) + 0.309134013960151*std::exp(0.733679831027985*x_41) + 0.157881756604294*std::exp(0.797679901123047*x_41) + 0.00586704965783894*std::exp(0.799919843673706*x_41) + 11.7819837363004*std::exp(0.818319857120514*x_41) + 0.000361966183449481*std::exp(0.826639890670776*x_41) + 0.0630078114082541*std::exp(0.786239862442017*x_42) - 0.00322982864818894*std::exp(0.947999835014343*x_44) + 0.000167069451628218*std::exp(0.96455979347229*x_44) - 0.0019862826011791*std::exp(0.519359886646271*x_45) + 0.234348561029326*std::exp(0.539679825305939*x_45) + 15.9835369281379*std::exp(0.743519842624664*x_46) + 0.333309720905001*std::exp(0.768079876899719*x_46) - 0.00919333217177654*std::exp(0.579119861125946*x_47) - 0.0168645228981071*std::exp(0.714559853076935*x_49) + 0.320723122403031*std::exp(0.727199852466583*x_49) + 0.00327132069727636*std::exp(0.735519826412201*x_49) + 30.1589627284634*std::exp(0.736719846725464*x_49) - 0.0188956517454374*std::exp(0.365119844675064*x_50) + 0.360533475587071*std::exp(0.555359840393066*x_50) + 79.5657434061373*std::exp(0.55735981464386*x_50) + 1.84986210777141*std::exp(0.56335985660553*x_50) + 0.00196122300268683*std::exp(0.612239837646484*x_50) - 286.65323113184*std::exp(0.491039842367172*x_51) - 7.75430067990411*std::exp(0.49415984749794*x_51) - 0.122683917844009*std::exp(0.496079862117767*x_51) + 3.67511067532501*std::exp(0.498559832572937*x_51) + 0.0360579490111109*std::exp(0.503359854221344*x_51) + 0.358739420605076*std::exp(0.533759832382202*x_52) + 0.000533011318700737*std::exp(0.626239836215973*x_52) - 0.10044222649295*std::exp(0.688319861888885*x_52) + 0.000259101249444123*std::exp(0.782239854335785*x_52) - 0.00199887917728357*std::exp(0.593119859695435*x_53) - 137.297374127562*std::exp(0.453199863433838*x_54) + 1.51552024490932*std::exp(0.465039849281311*x_54) - 0.0202621564312197*std::exp(0.507999837398529*x_54) + 0.0133170077503272*std::exp(0.515119850635529*x_54) + 0.285768898564975*std::exp(0.566639840602875*x_55) + 0.260017690243236*std::exp(0.652239859104156*x_55) - 10.5007422706396*std::exp(0.65311986207962*x_55) - 360.000727519151*std::exp(0.653519809246063*x_55) + 81.0158854894878*std::exp(0.507439851760864*x_56) - 0.00955385430292886*std::exp(0.561359822750092*x_56) - 0.0262631097086245*std::exp(0.582399845123291*x_56) + 150.272659185071*std::exp(0.614079833030701*x_57) + 5.06882339090514*std::exp(0.629199862480164*x_57) + 0.0134181874134106*std::exp(0.635999858379364*x_57) - 0.976725512340894*std::exp(0.639119863510132*x_57) + 0.00842278595127046*std::exp(0.647839844226837*x_57) - 0.0157632546394546*std::exp(0.57399982213974*x_58) + 0.00274549695897426*std::exp(0.582559823989868*x_58) - 0.448303150298954*std::exp(0.585679829120636*x_58) + 2.25549159971874*std::exp(0.615999817848206*x_58) - 54.2878041166674*std::exp(0.616879820823669*x_58) - 1.08748249288917*std::exp(0.506879806518555*x_59) + 0.000302977781049524*std::exp(0.877119898796082*x_59) + 0.12421523522146*std::exp(0.79807984828949*x_60) - 0.00211611370275065*std::exp(0.803999841213226*x_60) + 0.00462857576204498*std::exp(0.806159913539886*x_60) - 0.240610511113684*std::exp(0.821119904518127*x_60) + 23.9845133671613*std::exp(0.831999897956848*x_60) - 0.157961490489518*std::exp(1.11703991889954*x_61) + 0.125402016649159*std::exp(1.19711995124817*x_61) - 0.000415193596992103*std::exp(1.54751980304718*x_61) - 0.000227286021108483*std::exp(1.57471978664398*x_61) - 0.000995212861359852*std::exp(0.964639782905579*x_66) - 18.6855414936878*std::exp(1.03479981422424*x_66) + 0.196498588926163*std::exp(1.18119990825653*x_66) + 146.04815234607*std::exp(0.348559856414795*x_8) - 0.000763420163608126*std::exp(0.771119832992554*x_8) + 0.00462632399115654*std::exp(1.57039988040924*x_9) + 2.58661435052867*std::sin(0.272079944610596*x_100 + 1.9314398765564) + 239.185934891192*std::sin(0.228799998760223*x_101 + 1.96423983573914) - 0.0399667347770384*std::sin(0.229599997401237*x_102 + 1.99663984775543) - 0.10835698171602*std::sin(0.211759999394417*x_108 + 1.99663984775543) + 0.0617324480044779*std::sin(0.303359925746918*x_112 + 1.9437597990036) + 368.651759652109*std::sin(0.268159955739975*x_120 + 1.97183978557587) + 0.0696659244067537*std::sin(0.377679854631424*x_15 + 2.02607989311218) + 13.9008532128382*std::sin(0.240319982171059*x_30 + 1.82743990421295) + 2.13576839515842*std::sin(0.347679853439331*x_31 - 4.23023986816406) + 287.488130736425*std::sin(0.387039840221405*x_31 - 7.40623998641968) - 0.0178573293027487*std::sin(0.609119892120361*x_65 + 2.20607995986938) - 1.30306774109481*std::sin(0.436879843473434*x_91 - 4.40895986557007) - 220.386368622759*std::sin(0.307679921388626*x_92 + 8.2163200378418) + 0.131322577039134*std::sin(0.223119989037514*x_93 + 1.9903998374939) + 5.21686955447534*std::sin(0.275119960308075*x_94 - 1.19951987266541) - 0.099291814970962*std::sin(0.27007994055748*x_95 + 1.96999979019165) + 0.0297742959457133*std::sin(0.329999834299088*x_97 + 1.85111999511719) - 4.1228158730315*std::sin(0.268239974975586*x_98 + 1.96031987667084) - 145.13550654012);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00341057701258123*x_1 + 8.98574851233495*x_10 - 37.1900190592547*x_100 - 16.2852414774098*x_101 - 41.6795347680654*x_102 + 65.1326450173576*x_103 - 425.545892354476*x_104 - 12.6695312522144*x_105 - 113.201566976866*x_106 - 27.8926058287831*x_107 + 15.1090146922383*x_108 - 56.8680039764997*x_109 - 25.8302373409748*x_110 - 9.13054245165369*x_111 - 4.42862964001877*x_112 - 60.7334571422045*x_113 + 36.2538869812578*x_114 + 45.8722198926466*x_115 - 57.4332100517496*x_116 - 15.2506390758121*x_117 + 14.626952563549*x_118 - 17.6115654680977*x_119 + 2.58604799216943*x_12 + 46.7174939659395*x_120 - 107.538341535196*x_13 - 31.0425474146332*x_14 + 0.00621982743940591*x_16 + 0.000892567741830098*x_17 - 142.252601514636*x_18 - 0.00155927319775665*x_19 + 15.3365974945524*x_2 - 8.70206047793333*x_20 + 5.93592375302001*x_21 + 0.860113113012*x_22 + 24.6093629238028*x_24 + 14.1638306440848*x_25 - 45.5032335227689*x_26 - 25.5144911780619*x_27 - 44.160269617256*x_28 + 130.293226623902*x_29 + 13.614549933119*x_3 - 5.09354420384943*x_30 - 1.09085125229756*x_31 - 15.5572915111298*x_32 + 102.451619798437*x_33 - 495.88826266774*x_34 - 298.201525043997*x_35 + 104.750996371704*x_36 - 863.798256016035*x_37 - 295.144773256137*x_38 - 474.506696893902*x_39 + 0.0111025286919122*x_4 + 917.939730363134*x_40 + 20.9045516145471*x_42 - 72.7937504390326*x_43 - 8.20145916482762*x_44 - 21.5805791098287*x_45 + 0.424978229863811*x_46 + 264.777385429006*x_47 - 271.22009912042*x_48 - 28.9431944923621*x_49 - 9.45943678559184*x_5 - 15.1130848063375*x_52 + 39.2648074096169*x_53 + 2.10400964325727*x_54 + 0.00821151921586454*x_55 + 33.1894164461569*x_56 + 36.1283657244217*x_59 + 10.6628770184927*x_6 + 12.2905619892337*x_61 + 9.55493134023482*x_62 - 9.72625123907719*x_63 + 9.23932729500059*x_64 + 18.1064123792579*x_65 - 1.45966406721431*x_66 - 2.41119545137987*x_67 - 16.7935971448491*x_68 - 4.22298856745374*x_69 - 58.0037767175291*x_7 + 19.7231846202333*x_70 + 0.484058628751302*x_71 + 13.8976313184848*x_72 + 5.97143032063918*x_73 + 19.5334669472947*x_74 + 13.1022137838901*x_75 + 26.081028885657*x_76 + 24.3491491314735*x_77 + 24.9337750354274*x_78 + 98.5321996109882*x_79 - 52.0994988043047*x_8 - 10.9969683675167*x_80 + 32.3415855426659*x_81 - 29.9851925072258*x_82 + 56.2251570883208*x_83 - 27.9268687818395*x_84 - 49.2835820859741*x_85 - 202.729553118837*x_86 - 189.061393576589*x_87 - 60.1709452221731*x_88 + 6.62080289682235*x_89 + 23.5753764651135*x_9 - 15.2167023279016*x_90 - 16.2937188771764*x_91 + 24.399937023556*x_92 - 15.0206934398491*x_93 + 9.24610404914466*x_94 - 22.7363956935682*x_95 - 12.9236278832604*x_96 + 1.82898674586157*x_97 + 46.8489058295724*x_98 - 44.8354727880663*x_99 + 3.77586170969009e-5*std::pow(-9.51239967346191*x_16 - 6.14495992660522, 2) - 0.15067772531164*std::pow(-9.43984031677246*x_18 - 3.81256008148193, 2) + 0.0405078477172427*std::exp(1.24503993988037*x_1) - 3.82501206386084*std::exp(1.2720799446106*x_1) + 0.000147720884195223*std::exp(1.29311990737915*x_1) + 1.03477225572732*std::exp(1.79351997375488*x_1) - 0.226224644460171*std::exp(0.504559814929962*x_10) - 0.000411107918094513*std::exp(0.782479882240295*x_10) - 2.25957539788464*std::exp(0.861839890480042*x_10) + 0.00170863623121631*std::exp(0.880719900131226*x_11) - 0.0978323031521551*std::exp(0.926479816436768*x_11) + 5.31411031085988*std::exp(0.940879821777344*x_11) + 1.18178867243595*std::exp(0.993199825286865*x_11) + 7.63930898672283e-5*std::exp(1.04079973697662*x_11) + 0.0210466623047261*std::exp(0.265359848737717*x_12) - 3.1594805820368*std::exp(0.676719844341278*x_12) + 0.000297361284780432*std::exp(1.34455978870392*x_12) + 5.65264130007814e-6*std::exp(1.34767985343933*x_12) - 0.629504430703544*std::exp(0.278639853000641*x_13) - 1.0886772500041e-5*std::exp(1.14487981796265*x_13) - 1.69745555981479e-5*std::exp(1.15631985664368*x_13) + 0.123410302934221*std::exp(0.539919853210449*x_15) - 0.00155269469810305*std::exp(0.669359803199768*x_15) + 1.70034251646772*std::exp(0.951039850711823*x_15) + 2.79683006853901*std::exp(0.998479843139648*x_15) - 0.257926528676674*std::exp(0.589679837226868*x_16) - 12.9657428315789*std::exp(0.625999867916107*x_16) - 23.2156274569239*std::exp(0.720319867134094*x_16) - 0.336736570098414*std::exp(0.616719841957092*x_17) - 0.00545612708478486*std::exp(0.643679857254028*x_17) + 25.415227585317*std::exp(0.665919840335846*x_17) - 20.2584574990384*std::exp(0.673039853572845*x_17) + 49.6299674134207*std::exp(0.753759860992432*x_19) - 0.337057074798153*std::exp(0.75519984960556*x_19) + 12.9207233593326*std::exp(0.767119884490967*x_19) - 0.00233429091272101*std::exp(0.855199873447418*x_19) + 0.00436168674018656*std::exp(0.776719868183136*x_2) - 0.00023466001256159*std::exp(1.21783995628357*x_2) + 5.2998775169762*std::exp(0.494959861040115*x_20) + 0.000168604007030022*std::exp(0.889919877052307*x_20) - 0.0364505091203971*std::exp(0.89383989572525*x_20) + 0.000503642191276561*std::exp(0.938079833984375*x_20) - 0.0124387633653112*std::exp(0.26503986120224*x_21) - 12.9687915700475*std::exp(0.480719864368439*x_22) - 9.21553279830695e-6*std::exp(1.3155198097229*x_22) + 0.000376245864439642*std::exp(1.41879987716675*x_22) + 0.0143468317332897*std::exp(0.465999871492386*x_23) - 46.7415055163715*std::exp(0.545759856700897*x_23) + 0.0916583231135564*std::exp(0.615919828414917*x_23) + 4.7543607057357*std::exp(0.85647988319397*x_23) - 0.000303614722333946*std::exp(0.997199833393097*x_23) - 0.482463473423666*std::exp(0.477999836206436*x_24) - 0.00570712964838072*std::exp(0.564399838447571*x_24) - 38.3079832042157*std::exp(0.582319855690002*x_24) + 0.17271223117169*std::exp(0.562079846858978*x_25) - 0.00572750922765761*std::exp(0.609439849853516*x_25) - 0.000921978430912139*std::exp(0.693359851837158*x_25) + 1.03293639457115*std::exp(1.08727979660034*x_25) + 0.00270061561980161*std::exp(0.552559852600098*x_26) - 8.76036302784033*std::exp(0.812399864196777*x_26) - 0.0187625629925403*std::exp(0.856399893760681*x_26) - 1.20085801059764e-5*std::exp(1.24303984642029*x_26) - 0.0153358819656729*std::exp(0.956959843635559*x_27) - 0.399787751650225*std::exp(1.00351977348328*x_27) - 3.78303615449455e-5*std::exp(1.22839987277985*x_27) + 0.00391568601007088*std::exp(0.543519854545593*x_28) - 0.00291740639569754*std::exp(0.643999814987183*x_28) - 0.400068431090946*std::exp(1.05095982551575*x_28) + 2.13967308361456e-5*std::exp(1.24479985237122*x_29) - 0.00493797074530955*std::exp(0.55927985906601*x_3) - 0.406347941967154*std::exp(0.633279860019684*x_3) + 0.00113236917147539*std::exp(0.864879846572876*x_30) + 0.0590105200960754*std::exp(0.897199809551239*x_30) + 0.000462212951011299*std::exp(1.05735981464386*x_30) + 0.00119278890690157*std::exp(0.693919837474823*x_32) - 7.55519452667891*std::exp(0.863999903202057*x_32) - 0.0139206240309826*std::exp(0.405439853668213*x_33) - 0.429182751165078*std::exp(0.462239861488342*x_33) + 10.3919426605283*std::exp(0.586719870567322*x_4) - 0.17157778834534*std::exp(0.692239880561829*x_4) - 0.000145864593168153*std::exp(1.09551990032196*x_4) - 0.483366992641753*std::exp(1.09767985343933*x_4) - 11.2066537984153*std::exp(0.733679831027985*x_41) + 0.0882403015547939*std::exp(0.797679901123047*x_41) + 0.00322575038638033*std::exp(0.799919843673706*x_41) + 3.66512371763706*std::exp(0.818319857120514*x_41) + 0.000256800500358765*std::exp(0.826639890670776*x_41) - 2.28414440715401*std::exp(0.786239862442017*x_42) - 0.00180515507311472*std::exp(0.947999835014343*x_44) + 9.1856108192645e-5*std::exp(0.96455979347229*x_44) - 0.00140918789975278*std::exp(0.519359886646271*x_45) + 0.130977689499543*std::exp(0.539679825305939*x_45) + 4.97213725618677*std::exp(0.743519842624664*x_46) - 12.0830658586482*std::exp(0.768079876899719*x_46) - 0.00505456686660364*std::exp(0.579119861125946*x_47) - 0.00927224830660915*std::exp(0.714559853076935*x_49) + 0.17925253458745*std::exp(0.727199852466583*x_49) + 0.00232087092746829*std::exp(0.735519826412201*x_49) + 9.3818097248649*std::exp(0.736719846725464*x_49) - 0.0103889790394588*std::exp(0.365119844675064*x_50) + 0.201502588333476*std::exp(0.555359840393066*x_50) + 24.751204873147*std::exp(0.55735981464386*x_50) - 67.0607674355541*std::exp(0.56335985660553*x_50) + 0.00139140911895542*std::exp(0.612239837646484*x_50) - 89.1717031421145*std::exp(0.491039842367172*x_51) - 4.33388787316465*std::exp(0.49415984749794*x_51) - 0.067452590052516*std::exp(0.496079862117767*x_51) - 133.229250581713*std::exp(0.498559832572937*x_51) + 0.0255816697010771*std::exp(0.503359854221344*x_51) + 0.200499888870143*std::exp(0.533759832382202*x_52) + 0.000293053846058174*std::exp(0.626239836215973*x_52) + 3.64120804640286*std::exp(0.688319861888885*x_52) + 0.000183821952279469*std::exp(0.782239854335785*x_52) - 0.00109899960874459*std::exp(0.593119859695435*x_53) - 42.7102832211366*std::exp(0.453199863433838*x_54) - 54.9402846086606*std::exp(0.465039849281311*x_54) - 0.0111402941424874*std::exp(0.507999837398529*x_54) + 0.00944788328283951*std::exp(0.515119850635529*x_54) + 0.1597165773089*std::exp(0.566639840602875*x_55) + 0.142959786209955*std::exp(0.652239859104156*x_55) + 380.670446923429*std::exp(0.65311986207962*x_55) - 111.988544062559*std::exp(0.653519809246063*x_55) + 25.202313129837*std::exp(0.507439851760864*x_56) - 0.00677807673072116*std::exp(0.561359822750092*x_56) - 0.0144396657998203*std::exp(0.582399845123291*x_56) + 46.7466175152382*std::exp(0.614079833030701*x_57) - 183.753797194591*std::exp(0.629199862480164*x_57) + 0.00951966619874161*std::exp(0.635999858379364*x_57) - 0.545893050589969*std::exp(0.639119863510132*x_57) + 0.00463091444954929*std::exp(0.647839844226837*x_57) - 0.00866676229267877*std::exp(0.57399982213974*x_58) + 0.00194782005898753*std::exp(0.582559823989868*x_58) - 0.250557163925474*std::exp(0.585679829120636*x_58) - 81.765552678846*std::exp(0.615999817848206*x_58) - 16.8877773811042*std::exp(0.616879820823669*x_58) + 39.4231603747673*std::exp(0.506879806518555*x_59) + 0.000214950592979814*std::exp(0.877119898796082*x_59) + 0.0694240427100948*std::exp(0.79807984828949*x_60) - 0.00150129786297633*std::exp(0.803999841213226*x_60) + 0.00254482762607241*std::exp(0.806159913539886*x_60) + 8.72255583838279*std::exp(0.821119904518127*x_60) + 7.46107028879406*std::exp(0.831999897956848*x_60) + 5.72638291956414*std::exp(1.11703991889954*x_61) + 0.0700873362616245*std::exp(1.19711995124817*x_61) - 0.000228276729195647*std::exp(1.54751980304718*x_61) - 0.000161250322858841*std::exp(1.57471978664398*x_61) - 0.000706063639219375*std::exp(0.964639782905579*x_66) - 5.81267321685431*std::exp(1.03479981422424*x_66) + 0.109823295071348*std::exp(1.18119990825653*x_66) + 45.4324635868773*std::exp(0.348559856414795*x_8) - 0.000541616009899718*std::exp(0.771119832992554*x_8) + 0.00143915066978232*std::exp(1.57039988040924*x_9) + 1.44566183709663*std::sin(0.272079944610596*x_100 + 1.9314398765564) + 74.4056402143848*std::sin(0.228799998760223*x_101 + 1.96423983573914) - 0.0283547965465729*std::sin(0.229599997401237*x_102 + 1.99663984775543) - 0.05957552705736*std::sin(0.211759999394417*x_108 + 1.99663984775543) + 0.033940989017638*std::sin(0.303359925746918*x_112 + 1.9437597990036) + 114.679695549626*std::sin(0.268159955739975*x_120 + 1.97183978557587) + 0.0383028772003617*std::sin(0.377679854631424*x_15 + 2.02607989311218) - 503.930471652818*std::sin(0.240319982171059*x_30 + 1.82743990421295) + 1.19368349639234*std::sin(0.347679853439331*x_31 - 4.23023986816406) + 89.431422592684*std::sin(0.387039840221405*x_31 - 7.40623998641968) - 0.0098181011338636*std::sin(0.609119892120361*x_65 + 2.20607995986938) + 47.2385062493158*std::sin(0.436879843473434*x_91 - 4.40895986557007) - 68.5574963233494*std::sin(0.307679921388626*x_92 + 8.2163200378418) + 0.0722021933218957*std::sin(0.223119989037514*x_93 + 1.9903998374939) - 189.120732007299*std::sin(0.275119960308075*x_94 - 1.19951987266541) - 0.054591426557818*std::sin(0.27007994055748*x_95 + 1.96999979019165) + 0.0211236696860006*std::sin(0.329999834299088*x_97 + 1.85111999511719) - 2.30424669522138*std::sin(0.268239974975586*x_98 + 1.96031987667084) + 446.29717744592);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0102914084404211*x_1 - 32.2547038486164*x_10 + 11.646272706442*x_100 + 4.19586057499239*x_101 + 33.4904467387901*x_102 - 52.0874309971293*x_103 + 901.988739192782*x_104 - 66.9249941253025*x_105 + 202.833326627992*x_106 + 44.1300070621806*x_107 + 11.1794665126308*x_108 + 60.3327850536856*x_109 + 2.41342746703355*x_110 - 90.8952432502668*x_111 - 40.8891219099104*x_112 + 31.4387072309657*x_113 + 31.2900609558314*x_114 - 70.6352619842204*x_115 + 15.3515344983517*x_116 - 53.628825973506*x_117 - 60.2826850639787*x_118 + 75.8610631447471*x_119 - 0.661257752047726*x_12 - 11.9614134935627*x_120 - 14.1297317121701*x_13 + 52.8310907013142*x_14 + 0.0135059573774583*x_16 + 0.0019381537502595*x_17 + 36.3577750502671*x_18 - 0.00338586199599227*x_19 - 4.20713640265029*x_2 + 2.22513463294015*x_20 - 30.6544596624623*x_21 - 3.09438116027957*x_22 - 6.2930702089253*x_24 - 50.8414502486092*x_25 + 163.335078018944*x_26 + 6.45579191695282*x_27 + 11.2523603822202*x_28 + 1.37167999004704*x_29 - 33.432594348826*x_3 + 18.2834136284489*x_30 + 0.282416891021566*x_31 + 55.5522693123143*x_32 - 74.60857822395*x_33 + 495.324499843303*x_34 - 265.915829526987*x_35 + 166.408622326942*x_36 + 642.635533330223*x_37 + 1309.09139954848*x_38 + 0.607737467150512*x_39 - 0.0335018552779978*x_4 - 4658.90313090478*x_40 - 74.6446850449827*x_42 - 19.2944746918347*x_43 + 45.4636772293766*x_44 - 149.429663158116*x_45 - 0.110548577554741*x_46 + 193.385413897621*x_47 + 53.9907850184205*x_48 + 7.40083393079022*x_49 + 25.1337721111539*x_5 + 54.2488235416251*x_52 - 51.7695953122693*x_53 - 0.235359983341846*x_54 + 0.0178307886535578*x_55 - 8.54731872192017*x_56 - 127.742811155401*x_59 - 87.5436187643794*x_6 - 44.1173021342242*x_61 + 6.36670625027038*x_62 - 9.9199376577153*x_63 - 27.7709120184606*x_64 - 29.9453384505354*x_65 + 0.375153534519005*x_66 - 6.69808891177968*x_67 + 47.8948181741946*x_68 - 26.7554577071031*x_69 + 38.0934707138562*x_7 - 24.9339116096417*x_70 - 48.4537090972291*x_71 - 11.0162126773208*x_72 - 76.7141612479681*x_73 + 28.4364080716342*x_74 + 14.1705372009778*x_75 - 15.5151278386221*x_76 - 8.84904327349997*x_77 - 51.4334885062436*x_78 - 13.5374693191576*x_79 + 13.3044032911717*x_8 + 18.4080643464953*x_80 - 8.44534209536973*x_81 + 47.8744193130934*x_82 - 23.3868834469369*x_83 - 1.4503611897779*x_84 - 37.6585379018009*x_85 + 215.773032507624*x_86 - 40.0032657808532*x_87 + 243.453693030919*x_88 - 41.839981222366*x_89 - 6.04345937460448*x_9 + 42.4069359311698*x_90 + 59.1129658897406*x_91 - 6.20003376181987*x_92 + 13.8550703815955*x_93 - 32.5380200573116*x_94 - 13.8908855930478*x_95 - 23.6237112493033*x_96 + 11.2637933068078*x_97 - 94.4730592101036*x_98 + 90.3824305487577*x_99 - 0.000113936541897812*std::pow(-9.51239967346191*x_16 - 6.14495992660522, 2) + 0.540861739137261*std::pow(-9.43984031677246*x_18 - 3.81256008148193, 2) - 0.00453131305481308*std::exp(1.24503993988037*x_1) + 13.7299834650541*std::exp(1.2720799446106*x_1) + 0.00032076644973477*std::exp(1.29311990737915*x_1) - 0.264593378690387*std::exp(1.79351997375488*x_1) + 0.0253060762921373*std::exp(0.504559814929962*x_10) + 0.00124051721529659*std::exp(0.782479882240295*x_10) + 0.577778043064891*std::exp(0.861839890480042*x_10) - 0.00515580597262061*std::exp(0.880719900131226*x_11) + 0.0109437755259234*std::exp(0.926479816436768*x_11) - 19.0751415894708*std::exp(0.940879821777344*x_11) - 0.302185776635526*std::exp(0.993199825286865*x_11) + 0.000165882707475511*std::exp(1.04079973697662*x_11) - 0.0635082560184213*std::exp(0.265359848737717*x_12) + 11.3410403484424*std::exp(0.676719844341278*x_12) - 3.32636056382726e-5*std::exp(1.34455978870392*x_12) + 1.22743489610715e-5*std::exp(1.34767985343933*x_12) + 0.0704180006012873*std::exp(0.278639853000641*x_13) - 2.36399300135059e-5*std::exp(1.14487981796265*x_13) + 5.12206832189268e-5*std::exp(1.15631985664368*x_13) - 0.013804997014103*std::exp(0.539919853210449*x_15) - 0.00337157720484738*std::exp(0.669359803199768*x_15) - 6.103425099388*std::exp(0.951039850711823*x_15) - 0.715155159371234*std::exp(0.998479843139648*x_15) + 0.0288523313984352*std::exp(0.589679837226868*x_16) + 46.5408818894114*std::exp(0.625999867916107*x_16) + 5.93628334471264*std::exp(0.720319867134094*x_16) + 0.0376682273215524*std::exp(0.616719841957092*x_17) + 0.0164638511680662*std::exp(0.643679857254028*x_17) - 6.49872558890508*std::exp(0.665919840335846*x_17) + 72.7182769218624*std::exp(0.673039853572845*x_17) - 12.6904840070154*std::exp(0.753759860992432*x_19) + 0.0377040798096973*std::exp(0.75519984960556*x_19) - 46.3792832854784*std::exp(0.767119884490967*x_19) + 0.00704371756244079*std::exp(0.855199873447418*x_19) - 0.0131613798975488*std::exp(0.776719868183136*x_2) - 0.000509549205138941*std::exp(1.21783995628357*x_2) - 19.0240525938227*std::exp(0.494959861040115*x_20) + 0.000366112814993732*std::exp(0.889919877052307*x_20) + 0.00407744862143176*std::exp(0.89383989572525*x_20) - 0.0015197391758449*std::exp(0.938079833984375*x_20) - 0.0270099788903836*std::exp(0.26503986120224*x_21) + 3.31614648542967*std::exp(0.480719864368439*x_22) - 2.00109399170712e-5*std::exp(1.3155198097229*x_22) - 4.20878396022279e-5*std::exp(1.41879987716675*x_22) - 0.043291532385464*std::exp(0.465999871492386*x_23) + 11.9518984019911*std::exp(0.545759856700897*x_23) - 0.0102531380834125*std::exp(0.615919828414917*x_23) - 17.0659053584174*std::exp(0.85647988319397*x_23) - 0.000659279946101332*std::exp(0.997199833393097*x_23) + 0.0539696172172718*std::exp(0.477999836206436*x_24) + 0.0172212508373974*std::exp(0.564399838447571*x_24) + 137.507533882797*std::exp(0.582319855690002*x_24) - 0.0193200387563678*std::exp(0.562079846858978*x_25) + 0.0172827461718844*std::exp(0.609439849853516*x_25) - 0.00200201718008186*std::exp(0.693359851837158*x_25) - 0.264123945244111*std::exp(1.08727979660034*x_25) + 0.0058642140492281*std::exp(0.552559852600098*x_26) + 2.24004271399932*std::exp(0.812399864196777*x_26) + 0.002098829027484*std::exp(0.856399893760681*x_26) + 3.62358633756772e-5*std::exp(1.24303984642029*x_26) + 0.00171551158785823*std::exp(0.956959843635559*x_27) + 1.43504886469514*std::exp(1.00351977348328*x_27) - 8.21462099354759e-5*std::exp(1.22839987277985*x_27) - 0.0118155737007046*std::exp(0.543519854545593*x_28) - 0.00633496135011402*std::exp(0.643999814987183*x_28) + 1.43605637108094*std::exp(1.05095982551575*x_28) + 4.64616321763314e-5*std::exp(1.24479985237122*x_29) - 0.0107224875717222*std::exp(0.55927985906601*x_3) + 0.0454551361771913*std::exp(0.633279860019684*x_3) + 0.0024588672136787*std::exp(0.864879846572876*x_30) - 0.00660107004324586*std::exp(0.897199809551239*x_30) - 0.00139472653681833*std::exp(1.05735981464386*x_30) - 0.00359923783537057*std::exp(0.693919837474823*x_32) + 1.93187866741943*std::exp(0.863999903202057*x_32) - 0.0302277445253418*std::exp(0.405439853668213*x_33) + 0.0480094972418666*std::exp(0.462239861488342*x_33) - 37.302157095637*std::exp(0.586719870567322*x_4) + 0.0191931370353763*std::exp(0.692239880561829*x_4) - 0.000316735632523839*std::exp(1.09551990032196*x_4) + 0.123597927005298*std::exp(1.09767985343933*x_4) + 2.86556425911515*std::exp(0.733679831027985*x_41) - 0.00987078931437974*std::exp(0.797679901123047*x_41) - 0.00973369451287109*std::exp(0.799919843673706*x_41) - 13.1560599549432*std::exp(0.818319857120514*x_41) + 0.000557625857975044*std::exp(0.826639890670776*x_41) + 0.584060388902514*std::exp(0.786239862442017*x_42) + 0.000201929334924526*std::exp(0.947999835014343*x_44) - 0.000277175599222891*std::exp(0.96455979347229*x_44) - 0.00305996137293302*std::exp(0.519359886646271*x_45) - 0.0146515045297236*std::exp(0.539679825305939*x_45) - 17.8476201312989*std::exp(0.743519842624664*x_46) + 3.08966461246202*std::exp(0.768079876899719*x_46) + 0.0152521441157162*std::exp(0.579119861125946*x_47) + 0.0279789883448776*std::exp(0.714559853076935*x_49) - 0.0200516540832828*std::exp(0.727199852466583*x_49) + 0.00503962274361148*std::exp(0.735519826412201*x_49) - 33.6762578115008*std::exp(0.736719846725464*x_49) + 0.0313487208116512*std::exp(0.365119844675064*x_50) - 0.0225406028843504*std::exp(0.555359840393066*x_50) - 88.8451142048053*std::exp(0.55735981464386*x_50) + 17.1475751646161*std::exp(0.56335985660553*x_50) + 0.00302135588781119*std::exp(0.612239837646484*x_50) + 320.084221762205*std::exp(0.491039842367172*x_51) + 0.484799953699042*std::exp(0.49415984749794*x_51) + 0.203538038294977*std::exp(0.496079862117767*x_51) + 34.0669914144791*std::exp(0.498559832572937*x_51) + 0.0555489591942707*std::exp(0.503359854221344*x_51) - 0.022428438318117*std::exp(0.533759832382202*x_52) - 0.000884289319283953*std::exp(0.626239836215973*x_52) - 0.93106433244596*std::exp(0.688319861888885*x_52) + 0.000399157609550148*std::exp(0.782239854335785*x_52) + 0.00331622883979201*std::exp(0.593119859695435*x_53) + 153.309707949542*std::exp(0.453199863433838*x_54) + 14.0483429569721*std::exp(0.465039849281311*x_54) + 0.0336158124399009*std::exp(0.507999837398529*x_54) + 0.0205154741298448*std::exp(0.515119850635529*x_54) - 0.0178663111622645*std::exp(0.566639840602875*x_55) - 0.431380832338522*std::exp(0.652239859104156*x_55) - 97.3382105691013*std::exp(0.65311986207962*x_55) + 401.985884641214*std::exp(0.653519809246063*x_55) - 90.4643793997627*std::exp(0.507439851760864*x_56) - 0.0147181600001118*std::exp(0.561359822750092*x_56) + 0.0435716589717651*std::exp(0.582399845123291*x_56) - 167.798238231851*std::exp(0.614079833030701*x_57) + 46.9862211494366*std::exp(0.629199862480164*x_57) + 0.0206713461394863*std::exp(0.635999858379364*x_57) + 0.0610650144618062*std::exp(0.639119863510132*x_57) - 0.0139737739031115*std::exp(0.647839844226837*x_57) + 0.0261519356639578*std::exp(0.57399982213974*x_58) + 0.00422956664826003*std::exp(0.582559823989868*x_58) + 0.0280279751172552*std::exp(0.585679829120636*x_58) + 20.9076187770189*std::exp(0.615999817848206*x_58) + 60.6191301708038*std::exp(0.616879820823669*x_58) - 10.0805826059579*std::exp(0.506879806518555*x_59) + 0.000466751461407433*std::exp(0.877119898796082*x_59) - 0.00776595372941149*std::exp(0.79807984828949*x_60) - 0.00325997226543061*std::exp(0.803999841213226*x_60) - 0.00767901161995962*std::exp(0.806159913539886*x_60) - 2.23037533845655*std::exp(0.821119904518127*x_60) - 26.7817120538304*std::exp(0.831999897956848*x_60) - 1.46424780523075*std::exp(1.11703991889954*x_61) - 0.00784015146882731*std::exp(1.19711995124817*x_61) + 0.00068882451530329*std::exp(1.54751980304718*x_61) - 0.00035014476026057*std::exp(1.57471978664398*x_61) - 0.0015331720228529*std::exp(0.964639782905579*x_66) + 20.8647465217709*std::exp(1.03479981422424*x_66) - 0.0122851190256539*std::exp(1.18119990825653*x_66) - 163.081047434623*std::exp(0.348559856414795*x_8) - 0.00117608451615714*std::exp(0.771119832992554*x_8) - 0.00516586995542392*std::exp(1.57039988040924*x_9) - 0.161715487848362*std::sin(0.272079944610596*x_100 + 1.9314398765564) - 267.081042567774*std::sin(0.228799998760223*x_101 + 1.96423983573914) - 0.0615706267312609*std::sin(0.229599997401237*x_102 + 1.99663984775543) + 0.179769018479552*std::sin(0.211759999394417*x_108 + 1.99663984775543) - 0.102416857782079*std::sin(0.303359925746918*x_112 + 1.9437597990036) - 411.645845133493*std::sin(0.268159955739975*x_120 + 1.97183978557587) - 0.115578845532029*std::sin(0.377679854631424*x_15 + 2.02607989311218) + 128.856050576984*std::sin(0.240319982171059*x_30 + 1.82743990421295) - 0.13352853620547*std::sin(0.347679853439331*x_31 - 4.23023986816406) - 321.016491700792*std::sin(0.387039840221405*x_31 - 7.40623998641968) + 0.0296260980195489*std::sin(0.609119892120361*x_65 + 2.20607995986938) - 12.0789825042305*std::sin(0.436879843473434*x_91 - 4.40895986557007) + 246.088973109011*std::sin(0.307679921388626*x_92 + 8.2163200378418) - 0.217869955444138*std::sin(0.223119989037514*x_93 + 1.9903998374939) + 48.3585573397872*std::sin(0.275119960308075*x_94 - 1.19951987266541) + 0.164729506467456*std::sin(0.27007994055748*x_95 + 1.96999979019165) + 0.0458686973576042*std::sin(0.329999834299088*x_97 + 1.85111999511719) + 0.257759020041*std::sin(0.268239974975586*x_98 + 1.96031987667084) + 82.7213365697327);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00794546063742026*x_1 - 76.4448825128942*x_10 - 0.670592274174252*x_100 - 2.43418656450166*x_101 + 52.1613622992555*x_102 - 81.192931217849*x_103 + 1999.38747013815*x_104 - 184.774633823705*x_105 + 432.072099815716*x_106 + 91.9394783341215*x_107 + 41.7820010416853*x_108 + 109.983210728825*x_109 - 15.624251057337*x_110 - 244.390144623003*x_111 - 109.756725929036*x_112 + 30.9276960224568*x_113 + 112.200989919724*x_114 - 145.551553510385*x_115 - 7.91428907512003*x_116 - 152.242013473986*x_117 - 144.393042808284*x_118 + 182.73010040394*x_119 + 0.437951658741407*x_12 + 7.58341039971793*x_120 - 126.552529873218*x_13 + 112.073265951114*x_14 - 0.031625575766683*x_16 - 0.00453838454863004*x_17 - 23.4644372589696*x_18 + 0.00792834096074556*x_19 + 1.93929649848332*x_2 - 1.47370885316859*x_20 - 74.7486761622821*x_21 - 7.39267758244206*x_22 + 4.16851633807724*x_24 - 120.496514206203*x_25 + 387.111450453153*x_26 - 4.38273799516135*x_27 - 7.92083414064495*x_28 + 112.125305017021*x_29 - 75.6496301228817*x_3 + 43.332509187787*x_30 - 0.181808344451149*x_31 + 131.641559682619*x_32 - 108.674206138483*x_33 + 870.992274372251*x_34 - 939.719168299851*x_35 + 520.719975217326*x_36 + 954.127570789729*x_37 + 3159.49542581994*x_38 - 394.98185873149*x_39 - 0.0258650381950044*x_4 - 11361.6710178575*x_40 - 176.645953534497*x_42 - 111.670888219394*x_43 + 111.507250246816*x_44 - 406.979500909279*x_45 + 0.573828911070053*x_46 + 726.104278740195*x_47 - 85.4729044581921*x_48 - 4.90157958227661*x_49 + 57.5033155893457*x_5 + 128.572141522105*x_52 - 101.598429768728*x_53 + 3.74355726239521*x_54 - 0.0417526089993427*x_55 + 4.94111845804735*x_56 - 301.570923486148*x_59 - 218.913771622548*x_6 - 104.55998200998*x_61 + 24.7178753621764*x_62 - 33.9694395267659*x_63 - 64.842354479155*x_64 - 63.2205810153937*x_65 - 0.245464323340906*x_66 - 19.3263185046614*x_67 + 110.506214148077*x_68 - 73.1966502511238*x_69 + 51.1047395007462*x_7 - 48.6780403314259*x_70 - 125.970063058151*x_71 - 17.019968584653*x_72 - 194.776715508524*x_73 + 90.2799492777423*x_74 + 48.1484188141145*x_75 - 18.6262155411435*x_76 - 2.78040983216644*x_77 - 113.201313968195*x_78 + 47.5051104037088*x_79 - 8.9679791805775*x_8 + 38.6195967612434*x_80 + 4.83229334371523*x_81 + 99.562752186976*x_82 - 13.2715725111834*x_83 - 26.9134323457467*x_84 - 139.729648386684*x_85 + 389.857641034403*x_86 - 261.409588686021*x_87 + 582.985660681112*x_88 - 103.620041790553*x_89 + 3.85058443944875*x_9 + 97.6875999436452*x_90 + 140.467537795476*x_91 + 4.61850948733361*x_92 + 23.1455572479999*x_93 - 76.6685998080924*x_94 - 55.3704300842473*x_95 - 72.1725065126765*x_96 + 31.1134353131762*x_97 - 206.771182861619*x_98 + 197.474724791757*x_99 - 8.79644719237094e-5*std::pow(-9.51239967346191*x_16 - 6.14495992660522, 2) + 1.28186654619136*std::pow(-9.43984031677246*x_18 - 3.81256008148193, 2) + 0.0720735515599253*std::exp(1.24503993988037*x_1) + 32.5406757588131*std::exp(1.2720799446106*x_1) - 0.000751107335524998*std::exp(1.29311990737915*x_1) + 0.175240454619403*std::exp(1.79351997375488*x_1) - 0.40250999486417*std::exp(0.504559814929962*x_10) + 0.000957738754733355*std::exp(0.782479882240295*x_10) - 0.38266296547911*std::exp(0.861839890480042*x_10) - 0.0039805293558009*std::exp(0.880719900131226*x_11) - 0.174068037252488*std::exp(0.926479816436768*x_11) - 45.20893991579*std::exp(0.940879821777344*x_11) + 0.200137936705863*std::exp(0.993199825286865*x_11) - 0.000388431266813057*std::exp(1.04079973697662*x_11) - 0.0490314179314535*std::exp(0.265359848737717*x_12) + 26.8787735750435*std::exp(0.676719844341278*x_12) + 0.000529079798071458*std::exp(1.34455978870392*x_12) - 2.87416391305187e-5*std::exp(1.34767985343933*x_12) - 1.12004519124823*std::exp(0.278639853000641*x_13) + 5.53553055786343e-5*std::exp(1.14487981796265*x_13) + 3.95448227221564e-5*std::exp(1.15631985664368*x_13) + 0.219577670323113*std::exp(0.539919853210449*x_15) + 0.00789489166633138*std::exp(0.669359803199768*x_15) - 14.4653908493694*std::exp(0.951039850711823*x_15) + 0.473647964555736*std::exp(0.998479843139648*x_15) - 0.458915543798144*std::exp(0.589679837226868*x_16) + 110.3039745785*std::exp(0.625999867916107*x_16) - 3.93160629047453*std::exp(0.720319867134094*x_16) - 0.599138239002753*std::exp(0.616719841957092*x_17) + 0.0127108823008547*std::exp(0.643679857254028*x_17) + 4.3041123412959*std::exp(0.665919840335846*x_17) + 172.345573254089*std::exp(0.673039853572845*x_17) + 8.40492002383748*std::exp(0.753759860992432*x_19) - 0.599708496701041*std::exp(0.75519984960556*x_19) - 109.920978649405*std::exp(0.767119884490967*x_19) + 0.00543808760068891*std::exp(0.855199873447418*x_19) - 0.010161216175172*std::exp(0.776719868183136*x_2) + 0.00119316139860404*std::exp(1.21783995628357*x_2) - 45.0878567078998*std::exp(0.494959861040115*x_20) - 0.000857290471615339*std::exp(0.889919877052307*x_20) - 0.0648545355164897*std::exp(0.89383989572525*x_20) - 0.00117331149285599*std::exp(0.938079833984375*x_20) + 0.0632466185092531*std::exp(0.26503986120224*x_21) - 2.1962870747844*std::exp(0.480719864368439*x_22) + 4.68576553903635e-5*std::exp(1.3155198097229*x_22) + 0.000669435115367938*std::exp(1.41879987716675*x_22) - 0.0334231381927578*std::exp(0.465999871492386*x_23) - 7.91575405210976*std::exp(0.545759856700897*x_23) + 0.163082988830562*std::exp(0.615919828414917*x_23) - 40.4469600573306*std::exp(0.85647988319397*x_23) + 0.00154377118957014*std::exp(0.997199833393097*x_23) - 0.858422700467984*std::exp(0.477999836206436*x_24) + 0.0132956311517341*std::exp(0.564399838447571*x_24) + 325.899014071134*std::exp(0.582319855690002*x_24) + 0.307298081726616*std::exp(0.562079846858978*x_25) + 0.0133431084977534*std::exp(0.609439849853516*x_25) + 0.00468792727870991*std::exp(0.693359851837158*x_25) + 0.174929548386805*std::exp(1.08727979660034*x_25) - 0.0137316548944131*std::exp(0.552559852600098*x_26) - 1.48358248989843*std::exp(0.812399864196777*x_26) - 0.0333832733024614*std::exp(0.856399893760681*x_26) + 2.7975823501822e-5*std::exp(1.24303984642029*x_26) - 0.0272863541722896*std::exp(0.956959843635559*x_27) + 3.40113008314636*std::exp(1.00351977348328*x_27) + 0.000192353723150069*std::exp(1.22839987277985*x_27) - 0.00912218927962836*std::exp(0.543519854545593*x_28) + 0.0148339576794032*std::exp(0.643999814987183*x_28) + 3.40351791840549*std::exp(1.05095982551575*x_28) - 0.000108794647248683*std::exp(1.24479985237122*x_29) + 0.0251077975170269*std::exp(0.55927985906601*x_3) - 0.72299420969169*std::exp(0.633279860019684*x_3) - 0.00575768819589173*std::exp(0.864879846572876*x_30) + 0.104994414722067*std::exp(0.897199809551239*x_30) - 0.0010767957430132*std::exp(1.05735981464386*x_30) - 0.00277878413933404*std::exp(0.693919837474823*x_32) - 1.2794851391359*std::exp(0.863999903202057*x_32) + 0.0707813447077561*std::exp(0.405439853668213*x_33) - 0.763623023386651*std::exp(0.462239861488342*x_33) - 88.4077830277745*std::exp(0.586719870567322*x_4) - 0.305279625349781*std::exp(0.692239880561829*x_4) + 0.000741668766192721*std::exp(1.09551990032196*x_4) - 0.0818590284671065*std::exp(1.09767985343933*x_4) - 1.89786602368481*std::exp(0.733679831027985*x_41) + 0.157001477051215*std::exp(0.797679901123047*x_41) - 0.00751487875118543*std::exp(0.799919843673706*x_41) - 31.1804513346241*std::exp(0.818319857120514*x_41) - 0.00130573778133529*std::exp(0.826639890670776*x_41) - 0.38682376929858*std::exp(0.786239862442017*x_42) - 0.0032118205376884*std::exp(0.947999835014343*x_44) - 0.000213992849086529*std::exp(0.96455979347229*x_44) + 0.00716521143509107*std::exp(0.519359886646271*x_45) + 0.233041936052479*std::exp(0.539679825305939*x_45) - 42.2996590809641*std::exp(0.743519842624664*x_46) - 2.04628790784249*std::exp(0.768079876899719*x_46) + 0.011775386372939*std::exp(0.579119861125946*x_47) + 0.0216011201825325*std::exp(0.714559853076935*x_49) + 0.318934910687357*std::exp(0.727199852466583*x_49) - 0.0118007903075123*std::exp(0.735519826412201*x_49) - 79.8142393254462*std::exp(0.736719846725464*x_49) + 0.0242027151759085*std::exp(0.365119844675064*x_50) + 0.358523298771297*std::exp(0.555359840393066*x_50) - 210.566899913007*std::exp(0.55735981464386*x_50) - 11.3568558757623*std::exp(0.56335985660553*x_50) - 0.00707481275689238*std::exp(0.612239837646484*x_50) + 758.613941698211*std::exp(0.491039842367172*x_51) - 7.71106609420051*std::exp(0.49415984749794*x_51) + 0.157141122214008*std::exp(0.496079862117767*x_51) - 22.5626018781608*std::exp(0.498559832572937*x_51) - 0.130073549668598*std::exp(0.503359854221344*x_51) + 0.356739246654432*std::exp(0.533759832382202*x_52) - 0.000682713743132162*std::exp(0.626239836215973*x_52) + 0.616644821972898*std::exp(0.688319861888885*x_52) - 0.000934668226092977*std::exp(0.782239854335785*x_52) + 0.00256028762863552*std::exp(0.593119859695435*x_53) + 363.350874366456*std::exp(0.453199863433838*x_54) - 9.3042313402324*std::exp(0.465039849281311*x_54) + 0.0259530185865606*std::exp(0.507999837398529*x_54) - 0.0480390736732012*std::exp(0.515119850635529*x_54) + 0.284175576298216*std::exp(0.566639840602875*x_55) - 0.333046680920875*std::exp(0.652239859104156*x_55) + 64.4671924762275*std::exp(0.65311986207962*x_55) + 952.72455098167*std::exp(0.653519809246063*x_55) - 214.404630949666*std::exp(0.507439851760864*x_56) + 0.0344640717589245*std::exp(0.561359822750092*x_56) + 0.0336394093453251*std::exp(0.582399845123291*x_56) - 397.689340056408*std::exp(0.614079833030701*x_57) - 31.1190204223135*std::exp(0.629199862480164*x_57) - 0.0484040638707157*std::exp(0.635999858379364*x_57) - 0.971279718501401*std::exp(0.639119863510132*x_57) - 0.0107884232897903*std::exp(0.647839844226837*x_57) + 0.0201905479326036*std::exp(0.57399982213974*x_58) - 0.00990396139691923*std::exp(0.582559823989868*x_58) - 0.445803608203169*std::exp(0.585679829120636*x_58) - 13.8471364537856*std::exp(0.615999817848206*x_58) + 143.670053550326*std::exp(0.616879820823669*x_58) + 6.6763797621845*std::exp(0.506879806518555*x_59) - 0.00109294611958332*std::exp(0.877119898796082*x_59) + 0.123522665452171*std::exp(0.79807984828949*x_60) + 0.00763355732557949*std::exp(0.803999841213226*x_60) - 0.00592856506608395*std::exp(0.806159913539886*x_60) + 1.47717977758009*std::exp(0.821119904518127*x_60) - 63.4738570827666*std::exp(0.831999897956848*x_60) + 0.969772759749798*std::exp(1.11703991889954*x_61) + 0.124702829906211*std::exp(1.19711995124817*x_61) + 0.00053180554480145*std::exp(1.54751980304718*x_61) + 0.000819899643945987*std::exp(1.57471978664398*x_61) + 0.00359007855696478*std::exp(0.964639782905579*x_66) + 49.4503837592274*std::exp(1.03479981422424*x_66) + 0.195402998822779*std::exp(1.18119990825653*x_66) - 386.509386590641*std::exp(0.348559856414795*x_8) + 0.00275392176461541*std::exp(0.771119832992554*x_8) - 0.0122433431663992*std::exp(1.57039988040924*x_9) + 2.57219252134813*std::sin(0.272079944610596*x_100 + 1.9314398765564) - 632.994033069613*std::sin(0.228799998760223*x_101 + 1.96423983573914) + 0.144173897952734*std::sin(0.229599997401237*x_102 + 1.99663984775543) + 0.138790299542179*std::sin(0.211759999394417*x_108 + 1.99663984775543) - 0.0790707235872258*std::sin(0.303359925746918*x_112 + 1.9437597990036) - 975.619090004406*std::sin(0.268159955739975*x_120 + 1.97183978557587) - 0.0892324090535891*std::sin(0.377679854631424*x_15 + 2.02607989311218) - 85.3414888737423*std::sin(0.240319982171059*x_30 + 1.82743990421295) + 2.12386028564149*std::sin(0.347679853439331*x_31 - 4.23023986816406) - 760.823463207721*std::sin(0.387039840221405*x_31 - 7.40623998641968) + 0.0228727678060214*std::sin(0.609119892120361*x_65 + 2.20607995986938) + 7.99992197785892*std::sin(0.436879843473434*x_91 - 4.40895986557007) + 583.241888247099*std::sin(0.307679921388626*x_92 + 8.2163200378418) - 0.16820604925744*std::sin(0.223119989037514*x_93 + 1.9903998374939) - 32.0279200292425*std::sin(0.275119960308075*x_94 - 1.19951987266541) + 0.127179075345812*std::sin(0.27007994055748*x_95 + 1.96999979019165) - 0.107406229936952*std::sin(0.329999834299088*x_97 + 1.85111999511719) - 4.09982885672135*std::sin(0.268239974975586*x_98 + 1.96031987667084) + 427.334110359945);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00325270552986102*x_1 - 30.1665296438394*x_10 - 17.7987613253836*x_100 - 8.83910913669535*x_101 + 3.89021701340993*x_102 - 5.84744187333626*x_103 + 697.52196562316*x_104 - 89.0678980908704*x_105 + 141.521174178029*x_106 + 28.131920461208*x_107 + 25.8879269191143*x_108 + 22.6069488790442*x_109 - 19.0893478234278*x_110 - 114.213550133063*x_111 - 51.5799809327217*x_112 - 14.6255481063423*x_113 + 67.3848001366446*x_114 - 43.9091825451077*x_115 - 30.6127245043021*x_116 - 75.6837005572595*x_117 - 58.1595769553111*x_118 + 73.9276275289933*x_119 + 1.41406036776019*x_12 + 25.470330242786*x_120 - 107.548623807101*x_13 + 35.7088957035324*x_14 + 0.00746451206568265*x_16 + 0.00107118448915783*x_17 - 77.6048451038032*x_18 - 0.00187130812096321*x_19 + 8.06331179456506*x_2 - 4.75831805015148*x_20 - 30.8618667573602*x_21 - 2.94013936185213*x_22 + 13.4563791463879*x_24 - 47.5499942961842*x_25 + 152.760827832208*x_26 - 13.9413505483441*x_27 - 24.2393784333154*x_28 + 111.772406042811*x_29 - 27.6313735895516*x_3 + 17.0997524558478*x_30 - 0.596964411415927*x_31 + 51.9005794068519*x_32 - 0.690969022146582*x_33 + 159.71931416701*x_34 - 563.683396593844*x_35 + 283.366735423007*x_36 + 22.0701555728007*x_37 + 1283.2685454886*x_38 - 401.031633898883*x_39 + 0.0105886060741059*x_4 - 4677.64645167792*x_40 - 69.6979826276764*x_42 - 84.3164083981227*x_43 + 46.3036792937414*x_44 - 193.287806228803*x_45 + 0.380280612479426*x_46 + 450.743962395776*x_47 - 166.339795066457*x_48 - 15.8262431215324*x_49 + 21.4008310738674*x_5 + 50.7367755515499*x_52 - 27.3485189956701*x_53 + 1.85811016400273*x_54 + 0.00985477247745966*x_55 + 18.0061240709071*x_56 - 118.88585217275*x_59 - 93.4872344284259*x_6 - 41.2611649468591*x_61 + 15.5695006514567*x_62 - 19.8689626521774*x_63 - 24.7283500958024*x_64 - 19.7975328587934*x_65 - 0.798431640407276*x_66 - 9.87075320926602*x_67 + 41.8702782393548*x_68 - 34.9140874704778*x_69 - 4.45411103608575*x_7 - 12.5655573037641*x_70 - 56.365139177928*x_71 - 1.11654725551808*x_72 - 84.7786368729176*x_73 + 49.8078190028258*x_74 + 27.7246892673733*x_75 + 3.89454301503672*x_76 + 10.2194293098202*x_77 - 39.1631052526372*x_78 + 67.6112897473658*x_79 - 28.5167675614127*x_8 + 12.2382671743608*x_80 + 17.46365566728*x_81 + 30.6736549296215*x_82 + 20.2886900978514*x_83 - 25.3030302540734*x_84 - 85.8957555734668*x_85 + 80.8727892392357*x_86 - 206.784627611884*x_87 + 234.030818584403*x_88 - 43.4332989177481*x_89 + 12.8694637425114*x_9 + 36.7908998571406*x_90 + 55.4655555079181*x_91 + 13.4429414835702*x_92 + 3.46512379959048*x_93 - 30.2278854852208*x_94 - 35.5386271663223*x_95 - 38.5773880983851*x_96 + 14.7550594558184*x_97 - 70.9850366233517*x_98 + 67.8260945276736*x_99 + 3.6010816403774e-5*std::pow(-9.51239967346191*x_16 - 6.14495992660522, 2) + 0.505846557980603*std::pow(-9.43984031677246*x_18 - 3.81256008148193, 2) + 0.035773621003352*std::exp(1.24503993988037*x_1) + 12.8411096115002*std::exp(1.2720799446106*x_1) + 0.00017728214056914*std::exp(1.29311990737915*x_1) + 0.565817200961653*std::exp(1.79351997375488*x_1) - 0.199785353915296*std::exp(0.504559814929962*x_10) - 0.000392078230053991*std::exp(0.782479882240295*x_10) - 1.23554397590054*std::exp(0.861839890480042*x_10) + 0.00162954552772053*std::exp(0.880719900131226*x_11) - 0.0863984618309035*std::exp(0.926479816436768*x_11) - 17.8402242529078*std::exp(0.940879821777344*x_11) + 0.646206307779193*std::exp(0.993199825286865*x_11) + 9.16805404336379e-5*std::exp(1.04079973697662*x_11) + 0.0200724377755331*std::exp(0.265359848737717*x_12) + 10.606825754267*std::exp(0.676719844341278*x_12) + 0.000262608124160518*std::exp(1.34455978870392*x_12) + 6.78382312025035e-6*std::exp(1.34767985343933*x_12) - 0.555933089338976*std::exp(0.278639853000641*x_13) - 1.30653857320936e-5*std::exp(1.14487981796265*x_13) - 1.61888239606829e-5*std::exp(1.15631985664368*x_13) + 0.108987113704352*std::exp(0.539919853210449*x_15) - 0.0018634131607707*std::exp(0.669359803199768*x_15) - 5.70829170379588*std::exp(0.951039850711823*x_15) + 1.529316767228*std::exp(0.998479843139648*x_15) - 0.227782180578851*std::exp(0.589679837226868*x_16) + 43.5278430799962*std::exp(0.625999867916107*x_16) - 12.6943888121665*std::exp(0.720319867134094*x_16) - 0.297381547416594*std::exp(0.616719841957092*x_17) - 0.00520356956457424*std::exp(0.643679857254028*x_17) + 13.8971380944301*std::exp(0.665919840335846*x_17) + 68.0105236171442*std::exp(0.673039853572845*x_17) + 27.1378451540933*std::exp(0.753759860992432*x_19) - 0.297664594142213*std::exp(0.75519984960556*x_19) - 43.3767063075849*std::exp(0.767119884490967*x_19) - 0.00222623941113282*std::exp(0.855199873447418*x_19) + 0.00415978953912815*std::exp(0.776719868183136*x_2) - 0.000281619146538016*std::exp(1.21783995628357*x_2) - 17.7924427392062*std::exp(0.494959861040115*x_20) + 0.000202344302484098*std::exp(0.889919877052307*x_20) - 0.0321904710354992*std::exp(0.89383989572525*x_20) + 0.000480329203707602*std::exp(0.938079833984375*x_20) - 0.0149279542120875*std::exp(0.26503986120224*x_21) - 7.09138199773405*std::exp(0.480719864368439*x_22) - 1.10597048607552e-5*std::exp(1.3155198097229*x_22) + 0.000332273317814737*std::exp(1.41879987716675*x_22) + 0.0136827342536795*std::exp(0.465999871492386*x_23) - 25.558423772599*std::exp(0.545759856700897*x_23) + 0.08094604620209*std::exp(0.615919828414917*x_23) - 15.9610652033705*std::exp(0.85647988319397*x_23) - 0.000364372770829973*std::exp(0.997199833393097*x_23) - 0.426077079352512*std::exp(0.477999836206436*x_24) - 0.00544295352324335*std::exp(0.564399838447571*x_24) + 128.605348978773*std::exp(0.582319855690002*x_24) + 0.15252703485279*std::exp(0.562079846858978*x_25) - 0.00546238975645715*std::exp(0.609439849853516*x_25) - 0.00110648071652936*std::exp(0.693359851837158*x_25) + 0.564813345461095*std::exp(1.08727979660034*x_25) + 0.00324105098978527*std::exp(0.552559852600098*x_26) - 4.79019809468758*std::exp(0.812399864196777*x_26) - 0.016569747724734*std::exp(0.856399893760681*x_26) - 1.145271746464e-5*std::exp(1.24303984642029*x_26) - 0.0135435492159856*std::exp(0.956959843635559*x_27) + 1.34214435263609*std::exp(1.00351977348328*x_27) - 4.54008078121786e-5*std::exp(1.22839987277985*x_27) + 0.00373443364309712*std::exp(0.543519854545593*x_28) - 0.00350122498627776*std::exp(0.643999814987183*x_28) + 1.34308663344562*std::exp(1.05095982551575*x_28) + 2.56785509000919e-5*std::exp(1.24479985237122*x_29) - 0.00592613582409478*std::exp(0.55927985906601*x_3) - 0.358857310141348*std::exp(0.633279860019684*x_3) + 0.00135897393064854*std::exp(0.864879846572876*x_30) + 0.0521138520087086*std::exp(0.897199809551239*x_30) + 0.000440817672840053*std::exp(1.05735981464386*x_30) + 0.00113757615181347*std::exp(0.693919837474823*x_32) - 4.13120761225045*std::exp(0.863999903202057*x_32) - 0.0167063583440872*std::exp(0.405439853668213*x_33) - 0.379023373162828*std::exp(0.462239861488342*x_33) - 34.8872297792376*std::exp(0.586719870567322*x_4) - 0.151525176447399*std::exp(0.692239880561829*x_4) - 0.000175054376711706*std::exp(1.09551990032196*x_4) - 0.264306814663844*std::exp(1.09767985343933*x_4) - 6.12783870969631*std::exp(0.733679831027985*x_41) + 0.077927495113472*std::exp(0.797679901123047*x_41) + 0.0030764343045254*std::exp(0.799919843673706*x_41) - 12.3043416888943*std::exp(0.818319857120514*x_41) + 0.000308190291784757*std::exp(0.826639890670776*x_41) - 1.24897839876823*std::exp(0.786239862442017*x_42) - 0.00159418327748863*std::exp(0.947999835014343*x_44) + 8.76042001009098e-5*std::exp(0.96455979347229*x_44) - 0.00169118841044943*std::exp(0.519359886646271*x_45) + 0.115670085874667*std::exp(0.539679825305939*x_45) - 16.6921720622424*std::exp(0.743519842624664*x_46) - 6.60706398469314*std::exp(0.768079876899719*x_46) - 0.00482059708295838*std::exp(0.579119861125946*x_47) - 0.00884304715298781*std::exp(0.714559853076935*x_49) + 0.158302960971489*std::exp(0.727199852466583*x_49) + 0.00278531345278509*std::exp(0.735519826412201*x_49) - 31.4960698214445*std::exp(0.736719846725464*x_49) - 0.00990808577158707*std::exp(0.365119844675064*x_50) + 0.177952609986925*std::exp(0.555359840393066*x_50) - 83.0933156513939*std::exp(0.55735981464386*x_50) - 36.6690694640392*std::exp(0.56335985660553*x_50) + 0.00166985181790439*std::exp(0.612239837646484*x_50) + 299.362092242987*std::exp(0.491039842367172*x_51) - 3.82737842128357*std::exp(0.49415984749794*x_51) - 0.0643302912844113*std::exp(0.496079862117767*x_51) - 72.8502346609384*std::exp(0.498559832572937*x_51) + 0.0307009614019513*std::exp(0.503359854221344*x_51) + 0.177067097855254*std::exp(0.533759832382202*x_52) + 0.000279488738153149*std::exp(0.626239836215973*x_52) + 1.99102569046617*std::exp(0.688319861888885*x_52) + 0.000220607596287028*std::exp(0.782239854335785*x_52) - 0.00104812824677229*std::exp(0.593119859695435*x_53) + 143.384496368685*std::exp(0.453199863433838*x_54) - 30.0415457461789*std::exp(0.465039849281311*x_54) - 0.0106246234076745*std::exp(0.507999837398529*x_54) + 0.0113385523066301*std::exp(0.515119850635529*x_54) + 0.141050206974317*std::exp(0.566639840602875*x_55) + 0.136342350704152*std::exp(0.652239859104156*x_55) + 208.151973127307*std::exp(0.65311986207962*x_55) + 375.961472939281*std::exp(0.653519809246063*x_55) - 84.6077502398593*std::exp(0.507439851760864*x_56) - 0.00813447576021876*std::exp(0.561359822750092*x_56) - 0.0137712711436104*std::exp(0.582399845123291*x_56) - 156.935044767976*std::exp(0.614079833030701*x_57) - 100.47723894727*std::exp(0.629199862480164*x_57) + 0.0114247001052758*std::exp(0.635999858379364*x_57) - 0.482093525098759*std::exp(0.639119863510132*x_57) + 0.00441655502362111*std::exp(0.647839844226837*x_57) - 0.00826558835393425*std::exp(0.57399982213974*x_58) + 0.00233760927834999*std::exp(0.582559823989868*x_58) - 0.221274087048799*std::exp(0.585679829120636*x_58) - 44.7096990625334*std::exp(0.615999817848206*x_58) + 56.6946709774515*std::exp(0.616879820823669*x_58) + 21.5567262582186*std::exp(0.506879806518555*x_59) + 0.000257965564230624*std::exp(0.877119898796082*x_59) + 0.0613103270696434*std::exp(0.79807984828949*x_60) - 0.00180173101610047*std::exp(0.803999841213226*x_60) + 0.00242703063479693*std::exp(0.806159913539886*x_60) + 4.76952498715431*std::exp(0.821119904518127*x_60) - 25.0478743067822*std::exp(0.831999897956848*x_60) + 3.13120683053588*std::exp(1.11703991889954*x_61) + 0.0618961002830716*std::exp(1.19711995124817*x_61) - 0.000217710075642394*std::exp(1.54751980304718*x_61) - 0.000193519031243415*std::exp(1.57471978664398*x_61) - 0.000847358002362237*std::exp(0.964639782905579*x_66) + 19.5139708495762*std::exp(1.03479981422424*x_66) + 0.0969880444561207*std::exp(1.18119990825653*x_66) - 152.523243090301*std::exp(0.348559856414795*x_8) - 0.000650001833692269*std::exp(0.771119832992554*x_8) - 0.00483143351958093*std::exp(1.57039988040924*x_9) + 1.27670467758007*std::sin(0.272079944610596*x_100 + 1.9314398765564) - 249.790318502253*std::sin(0.228799998760223*x_101 + 1.96423983573914) - 0.0340290342463402*std::sin(0.229599997401237*x_102 + 1.99663984775543) - 0.0568178480031448*std::sin(0.211759999394417*x_108 + 1.99663984775543) + 0.0323699017085292*std::sin(0.303359925746918*x_112 + 1.9437597990036) - 384.99605130129*std::sin(0.268159955739975*x_120 + 1.97183978557587) + 0.0365298833656632*std::sin(0.377679854631424*x_15 + 2.02607989311218) - 275.550999141806*std::sin(0.240319982171059*x_30 + 1.82743990421295) + 1.05417550929814*std::sin(0.347679853439331*x_31 - 4.23023986816406) - 300.234007383991*std::sin(0.387039840221405*x_31 - 7.40623998641968) - 0.00936363311341363*std::sin(0.609119892120361*x_65 + 2.20607995986938) + 25.8301855656254*std::sin(0.436879843473434*x_91 - 4.40895986557007) + 230.1572675537*std::sin(0.307679921388626*x_92 + 8.2163200378418) + 0.06886004116602*std::sin(0.223119989037514*x_93 + 1.9903998374939) - 103.411898256758*std::sin(0.275119960308075*x_94 - 1.19951987266541) - 0.0520644554843892*std::sin(0.27007994055748*x_95 + 1.96999979019165) + 0.0253508459485022*std::sin(0.329999834299088*x_97 + 1.85111999511719) - 2.03494514318489*std::sin(0.268239974975586*x_98 + 1.96031987667084) + 404.59637350079);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0044651409005448*x_1 + 48.6762865065334*x_10 - 1.94417263808171*x_100 + 1.18834507430876*x_101 - 35.8708591341942*x_102 + 54.9811237849748*x_103 - 1268.41980927988*x_104 + 115.217518023431*x_105 - 282.343131229102*x_106 - 58.7394498108416*x_107 - 25.1989215310755*x_108 - 71.6384729200428*x_109 + 7.43187745193039*x_110 + 152.666202075761*x_111 + 69.7704836745244*x_112 - 23.7549655755898*x_113 - 67.0049789592607*x_114 + 94.3441909832842*x_115 + 1.61306264387652*x_116 + 94.8548004860298*x_117 + 92.3759173111678*x_118 - 116.099256357801*x_119 - 0.112731868841431*x_12 - 2.5494871019108*x_120 + 72.8716694716648*x_13 - 71.5125635088485*x_14 + 0.0223153198940274*x_16 + 0.00320232914499164*x_17 + 7.32417597221235*x_18 - 0.00559431600781616*x_19 - 0.0181291662331674*x_2 + 0.379343130297292*x_20 + 47.6266270908281*x_21 + 4.74137484652697*x_22 - 1.07338680471984*x_24 + 76.7261786889269*x_25 - 246.49329082807*x_26 + 1.08093015556022*x_27 + 1.26155204388272*x_28 - 62.6385379023651*x_29 + 48.4693323679463*x_3 - 27.5919835929209*x_30 + 0.0492248236264974*x_31 - 84.0554951609817*x_32 + 74.8637255202099*x_33 - 591.449640524013*x_34 + 576.646014815559*x_35 - 320.095549821665*x_36 - 650.901406181895*x_37 - 2009.06623825654*x_38 + 217.828247056305*x_39 - 0.0145354744311168*x_4 + 7178.95328498496*x_40 + 112.895515137038*x_42 + 64.1259721815182*x_43 - 70.6940836005019*x_44 + 254.804248903945*x_45 + 0.912686430977757*x_46 - 434.750485660456*x_47 + 38.4072614318613*x_48 + 1.26170141282947*x_49 - 36.5787856567593*x_5 - 81.8683359417477*x_52 + 67.4929169764501*x_53 + 4.99045805391934*x_54 + 0.0294610549734918*x_55 - 2.46641755808028*x_56 + 193.948172687022*x_59 + 138.484336649539*x_6 + 66.5785887356047*x_61 - 14.5270501116488*x_62 + 20.8459319143642*x_63 + 40.5870630540363*x_64 + 39.7689374555607*x_65 + 0.0645074747628576*x_66 + 12.3661947995791*x_67 - 71.0277181956766*x_68 + 45.8079515252977*x_69 - 34.7242922266258*x_7 + 31.3569196205101*x_70 + 78.5866110290129*x_71 + 11.6084388481535*x_72 + 122.568766782132*x_73 - 55.603628627517*x_74 - 28.5702397411301*x_75 + 13.2431055033905*x_76 + 3.14243672383749*x_77 + 72.4738844546306*x_78 - 22.3742434902267*x_79 + 2.05832759377331*x_8 - 25.2697801192328*x_80 - 1.59057004487802*x_81 - 64.4554346807012*x_82 + 13.7264901078607*x_83 + 15.8054446541828*x_84 + 83.3169587615109*x_85 - 266.81905885979*x_86 + 153.791727854815*x_87 - 371.243298545119*x_88 + 65.0135485493968*x_89 - 1.20198544291087*x_9 - 62.4213561587642*x_90 - 88.8154214217034*x_91 - 0.34107614446345*x_92 - 16.6827668728266*x_93 + 49.4883631250158*x_94 + 32.75117620098*x_95 + 44.8375641830364*x_96 - 18.6104372696789*x_97 + 133.081924586086*x_98 - 128.100722821005*x_99 - 4.94337306929137e-5*std::pow(-9.51239967346191*x_16 - 6.14495992660522, 2) - 0.816228770818441*std::pow(-9.43984031677246*x_18 - 3.81256008148193, 2) + 0.0960797473221149*std::exp(1.24503993988037*x_1) - 20.7202815730963*std::exp(1.2720799446106*x_1) + 0.000529988784730633*std::exp(1.29311990737915*x_1) - 0.0451081381964395*std::exp(1.79351997375488*x_1) - 0.536577673281726*std::exp(0.504559814929962*x_10) + 0.000538224110715024*std::exp(0.782479882240295*x_10) + 0.0985001663399008*std::exp(0.861839890480042*x_10) - 0.00223695330497246*std::exp(0.880719900131226*x_11) - 0.232046467450269*std::exp(0.926479816436768*x_11) + 28.7868012213195*std::exp(0.940879821777344*x_11) - 0.0515169269954561*std::exp(0.993199825286865*x_11) + 0.000274080953963445*std::exp(1.04079973697662*x_11) - 0.027554373447695*std::exp(0.265359848737717*x_12) - 17.115064264256*std::exp(0.676719844341278*x_12) + 0.000705305236272082*std::exp(1.34455978870392*x_12) + 2.02803856033477e-5*std::exp(1.34767985343933*x_12) - 1.49310886775165*std::exp(0.278639853000641*x_13) - 3.90592525787372e-5*std::exp(1.14487981796265*x_13) + 2.22231552579718e-5*std::exp(1.15631985664368*x_13) + 0.29271440945549*std::exp(0.539919853210449*x_15) - 0.00557071385395851*std::exp(0.669359803199768*x_15) + 9.21084041663299*std::exp(0.951039850711823*x_15) - 0.121920351599435*std::exp(0.998479843139648*x_15) - 0.611770733313399*std::exp(0.589679837226868*x_16) - 70.2360771127866*std::exp(0.625999867916107*x_16) + 1.01202339533922*std::exp(0.720319867134094*x_16) - 0.798698681672973*std::exp(0.616719841957092*x_17) + 0.00714318313733223*std::exp(0.643679857254028*x_17) - 1.10790909967589*std::exp(0.665919840335846*x_17) - 109.741077049829*std::exp(0.673039853572845*x_17) - 2.16348613559979*std::exp(0.753759860992432*x_19) - 0.799458880308591*std::exp(0.75519984960556*x_19) + 69.992204380978*std::exp(0.767119884490967*x_19) + 0.00305606288604879*std::exp(0.855199873447418*x_19) - 0.00571033751389513*std::exp(0.776719868183136*x_2) - 0.000841906515520393*std::exp(1.21783995628357*x_2) + 28.709701465314*std::exp(0.494959861040115*x_20) + 0.000604912658581595*std::exp(0.889919877052307*x_20) - 0.0864562277042299*std::exp(0.89383989572525*x_20) - 0.000659370346780997*std::exp(0.938079833984375*x_20) - 0.0446274412412864*std::exp(0.26503986120224*x_21) + 0.56533989884696*std::exp(0.480719864368439*x_22) - 3.30632263340996e-5*std::exp(1.3155198097229*x_22) + 0.000892409980374345*std::exp(1.41879987716675*x_22) - 0.0187829287915897*std::exp(0.465999871492386*x_23) + 2.03757133869052*std::exp(0.545759856700897*x_23) + 0.217402528670282*std::exp(0.615919828414917*x_23) + 25.7546096268973*std::exp(0.85647988319397*x_23) - 0.00108930026104799*std::exp(0.997199833393097*x_23) - 1.14434538567114*std::exp(0.477999836206436*x_24) + 0.00747179668533866*std::exp(0.564399838447571*x_24) - 207.516260141571*std::exp(0.582319855690002*x_24) + 0.409652659066139*std::exp(0.562079846858978*x_25) + 0.00749847771105057*std::exp(0.609439849853516*x_25) - 0.00330784797836176*std::exp(0.693359851837158*x_25) - 0.0450281087230133*std::exp(1.08727979660034*x_25) + 0.00968919187128384*std::exp(0.552559852600098*x_26) + 0.381884674549038*std::exp(0.812399864196777*x_26) - 0.044502544890115*std::exp(0.856399893760681*x_26) + 1.57216805223474e-5*std::exp(1.24303984642029*x_26) - 0.0363748692477787*std::exp(0.956959843635559*x_27) - 2.16567023720873*std::exp(1.00351977348328*x_27) - 0.00013572669464007*std::exp(1.22839987277985*x_27) - 0.00512643159581554*std::exp(0.543519854545593*x_28) - 0.010466987647987*std::exp(0.643999814987183*x_28) - 2.16719069177107*std::exp(1.05095982551575*x_28) + 7.6766582022828e-5*std::exp(1.24479985237122*x_29) - 0.0177163109238054*std::exp(0.55927985906601*x_3) - 0.963808491174091*std::exp(0.633279860019684*x_3) + 0.00406268189041939*std::exp(0.864879846572876*x_30) + 0.13996586290523*std::exp(0.897199809551239*x_30) - 0.000605131021732913*std::exp(1.05735981464386*x_30) - 0.00156160394979367*std::exp(0.693919837474823*x_32) + 0.329348566241636*std::exp(0.863999903202057*x_32) - 0.0499440187693589*std::exp(0.405439853668213*x_33) - 1.01796991473823*std::exp(0.462239861488342*x_33) + 56.293672914662*std::exp(0.586719870567322*x_4) - 0.406961896997812*std::exp(0.692239880561829*x_4) - 0.000523328836606823*std::exp(1.09551990032196*x_4) + 0.0210710955797285*std::exp(1.09767985343933*x_4) + 0.488524199852323*std::exp(0.733679831027985*x_41) + 0.20929539224576*std::exp(0.797679901123047*x_41) - 0.00422316515124638*std::exp(0.799919843673706*x_41) + 19.8541584083318*std::exp(0.818319857120514*x_41) + 0.000921341527603458*std::exp(0.826639890670776*x_41) + 0.0995711868077748*std::exp(0.786239862442017*x_42) - 0.00428161092420295*std::exp(0.947999835014343*x_44) - 0.000120258379782321*std::exp(0.96455979347229*x_44) - 0.00505584424650525*std::exp(0.519359886646271*x_45) + 0.310663341083755*std::exp(0.539679825305939*x_45) + 26.9343160879559*std::exp(0.743519842624664*x_46) + 0.52672904745159*std::exp(0.768079876899719*x_46) + 0.00661745891306801*std::exp(0.579119861125946*x_47) + 0.0121392641189807*std::exp(0.714559853076935*x_49) + 0.425165472878971*std::exp(0.727199852466583*x_49) + 0.00832675467024689*std::exp(0.735519826412201*x_49) + 50.8217323027732*std::exp(0.736719846725464*x_49) + 0.013601292406789*std::exp(0.365119844675064*x_50) + 0.477939926776004*std::exp(0.555359840393066*x_50) + 134.078514180513*std::exp(0.55735981464386*x_50) + 2.92333539897247*std::exp(0.56335985660553*x_50) + 0.00499205804267822*std::exp(0.612239837646484*x_50) - 483.047573866264*std::exp(0.491039842367172*x_51) - 10.2794612708784*std::exp(0.49415984749794*x_51) + 0.0883091974115034*std::exp(0.496079862117767*x_51) + 5.80777404282442*std::exp(0.498559832572937*x_51) + 0.0917811865946896*std::exp(0.503359854221344*x_51) + 0.475561644134343*std::exp(0.533759832382202*x_52) - 0.000383667253156667*std::exp(0.626239836215973*x_52) - 0.158728758767968*std::exp(0.688319861888885*x_52) + 0.000659511169501642*std::exp(0.782239854335785*x_52) + 0.00143881463007173*std::exp(0.593119859695435*x_53) - 231.36373941665*std::exp(0.453199863433838*x_54) + 2.39497525852901*std::exp(0.465039849281311*x_54) + 0.0145849171082265*std::exp(0.507999837398529*x_54) + 0.033896846790678*std::exp(0.515119850635529*x_54) + 0.378828529674267*std::exp(0.566639840602875*x_55) - 0.187163516960462*std::exp(0.652239859104156*x_55) - 16.5943134173549*std::exp(0.65311986207962*x_55) - 606.647541810668*std::exp(0.653519809246063*x_55) + 136.522190159179*std::exp(0.507439851760864*x_56) - 0.0243181908157171*std::exp(0.561359822750092*x_56) + 0.0189044675182922*std::exp(0.582399845123291*x_56) + 253.228764075555*std::exp(0.614079833030701*x_57) + 8.01025697403159*std::exp(0.629199862480164*x_57) + 0.0341543874936777*std::exp(0.635999858379364*x_57) - 1.29479272094866*std::exp(0.639119863510132*x_57) - 0.00606281149474967*std::exp(0.647839844226837*x_57) + 0.011346559437182*std::exp(0.57399982213974*x_58) + 0.00698833337994691*std::exp(0.582559823989868*x_58) - 0.594291485633734*std::exp(0.585679829120636*x_58) + 3.56435131453464*std::exp(0.615999817848206*x_58) - 91.4819343411559*std::exp(0.616879820823669*x_58) - 1.7185475900448*std::exp(0.506879806518555*x_59) + 0.000771193620801415*std::exp(0.877119898796082*x_59) + 0.164665487246471*std::exp(0.79807984828949*x_60) - 0.00538631375145297*std::exp(0.803999841213226*x_60) - 0.00333169838302886*std::exp(0.806159913539886*x_60) - 0.380236570903593*std::exp(0.821119904518127*x_60) + 40.4169907543853*std::exp(0.831999897956848*x_60) - 0.24962639911511*std::exp(1.11703991889954*x_61) + 0.166238739848688*std::exp(1.19711995124817*x_61) + 0.000298860795816673*std::exp(1.54751980304718*x_61) - 0.000578529319770636*std::exp(1.57471978664398*x_61) - 0.00253319503285552*std::exp(0.964639782905579*x_66) - 31.4875414076599*std::exp(1.03479981422424*x_66) + 0.260487659433104*std::exp(1.18119990825653*x_66) + 246.109926547356*std::exp(0.348559856414795*x_8) - 0.00194319450794817*std::exp(0.771119832992554*x_8) + 0.0077959511254197*std::exp(1.57039988040924*x_9) + 3.42893616543209*std::sin(0.272079944610596*x_100 + 1.9314398765564) + 403.059072789539*std::sin(0.228799998760223*x_101 + 1.96423983573914) - 0.10173053217812*std::sin(0.229599997401237*x_102 + 1.99663984775543) + 0.0779965154148521*std::sin(0.211759999394417*x_108 + 1.99663984775543) - 0.0444356769275528*std::sin(0.303359925746918*x_112 + 1.9437597990036) + 621.225643954378*std::sin(0.268159955739975*x_120 + 1.97183978557587) - 0.0501462781708134*std::sin(0.377679854631424*x_15 + 2.02607989311218) + 21.9675056331452*std::sin(0.240319982171059*x_30 + 1.82743990421295) + 2.83127381924899*std::sin(0.347679853439331*x_31 - 4.23023986816406) + 484.454487114108*std::sin(0.387039840221405*x_31 - 7.40623998641968) + 0.0128538967971642*std::sin(0.609119892120361*x_65 + 2.20607995986938) - 2.05923676083661*std::sin(0.436879843473434*x_91 - 4.40895986557007) - 371.37938496656*std::sin(0.307679921388626*x_92 + 8.2163200378418) - 0.0945273967781313*std::sin(0.223119989037514*x_93 + 1.9903998374939) + 8.24421419107424*std::sin(0.275119960308075*x_94 - 1.19951987266541) + 0.0714713113479637*std::sin(0.27007994055748*x_95 + 1.96999979019165) + 0.0757869009986388*std::sin(0.329999834299088*x_97 + 1.85111999511719) - 5.46539628049531*std::sin(0.268239974975586*x_98 + 1.96031987667084) - 249.395917942703);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
