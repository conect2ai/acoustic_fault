
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (6.48843973121734e-5*x_1 + 0.00117840897234014*x_10 + 0.000186250231314401*x_100 + 0.000252543159050903*x_101 - 0.000109790169708075*x_102 + 0.000386630101454153*x_103 + 0.000143593138481168*x_104 + 0.000263242768931613*x_105 - 0.00125125269344474*x_106 + 0.00140692502474822*x_107 - 4.35738570227439e-5*x_108 + 6.6276007504728e-5*x_109 - 0.000811890446300314*x_11 + 1.33326852952399e-5*x_110 - 0.000847258405449911*x_111 + 1.61017455552922e-5*x_112 + 1.85012866653606e-5*x_113 + 0.000729204074954677*x_114 - 0.00205187333243764*x_115 - 0.000298511996023228*x_116 - 0.000338535241834738*x_117 - 0.000310014510824718*x_118 + 0.000598442963699206*x_119 + 0.00188477312180917*x_12 - 0.00103845805652551*x_120 - 0.000129381282503913*x_13 + 0.0014517072427093*x_14 + 2.76518957374894e-5*x_15 - 5.28204669519479e-5*x_16 + 1.39295567100681e-5*x_17 - 2.83400927245531e-5*x_18 - 9.12696299055065e-5*x_19 - 0.000140719453085707*x_2 - 0.000797317351586546*x_20 - 3.72598955726625e-5*x_22 - 3.72519510344199e-5*x_23 - 5.80514900238381e-5*x_24 + 0.000926319152209231*x_25 + 5.75572505553347e-6*x_26 - 0.000107899370208023*x_27 - 7.93222687808949e-6*x_28 - 4.49490479978071e-6*x_29 - 1.28109855038925e-5*x_3 + 1.36254458028131e-5*x_30 - 6.90546465477106e-7*x_31 + 0.000124880400497627*x_33 + 0.00141481279267753*x_34 + 0.000946861310388256*x_35 + 0.00153721304795422*x_36 + 0.000110307610038818*x_37 - 0.000355512056527806*x_38 - 0.000749275286844815*x_39 + 1.45887089700827e-5*x_4 + 0.000459113516252302*x_40 - 7.12552604829527e-5*x_41 + 0.00166646213316368*x_42 - 0.00173864324542013*x_43 + 2.96742012925405e-6*x_44 - 0.000543557258873397*x_45 + 0.00115964920949742*x_46 + 0.000372579553389922*x_47 + 0.0002444224119558*x_48 - 0.000348045747505946*x_49 + 0.000207677416206668*x_5 - 0.00142193882636362*x_50 + 0.000765762138990431*x_51 - 4.08025977819098e-5*x_52 - 4.76263343306167e-5*x_53 - 0.00188884239481954*x_54 + 0.0012300107985729*x_55 + 0.000218180027998641*x_56 + 0.00177585778810024*x_57 + 0.00127781545165764*x_58 + 6.19375615609606e-5*x_59 - 0.000115826320843554*x_6 - 0.00227917723989293*x_60 - 0.000688630530992582*x_61 + 1.53578403705507e-5*x_62 + 4.61401478758252e-5*x_63 - 0.000282206372449715*x_64 + 0.00030830925465951*x_65 - 0.000115387536893068*x_66 - 1.27846526963823e-5*x_67 + 2.79798083645996e-7*x_68 - 0.000136844466088103*x_69 - 0.000644175658550349*x_7 + 9.76140263715922e-6*x_70 + 9.25231194629581e-5*x_71 - 2.6506346559434e-5*x_72 + 8.35211130476016e-6*x_73 - 5.27921172850876e-5*x_74 - 4.9390163672135e-5*x_75 + 5.68940793201009e-5*x_76 + 9.20715443884404e-6*x_77 - 4.17161610890339e-5*x_78 + 1.90156414735301e-6*x_79 + 0.000163454670398147*x_8 + 1.24249674350583e-5*x_80 - 8.24233425910958e-5*x_81 - 6.86955019802563e-5*x_82 + 9.89432065210724e-5*x_83 + 0.000340795719088605*x_84 - 8.78194704643674e-5*x_85 + 6.16977349878841e-5*x_86 - 0.000439053544837277*x_87 + 0.000585909628357212*x_88 + 0.000491126724526413*x_89 - 0.000280559620100536*x_9 - 0.000302789150537515*x_90 - 2.03578183527561e-5*x_91 + 0.000116430694034604*x_92 + 0.000139180532995009*x_93 + 8.77720549053572e-6*x_94 + 0.000170987285188977*x_95 - 0.00112183918984307*x_96 + 1.5362329413503e-5*x_97 + 7.43307135905609e-6*x_98 + 7.51163984686168e-5*x_99 - 2.6746574372472e-7*std::pow(-9.68360042572021*x_27 - 4.91775989532471, 2) - 8.77263706725745e-8*std::pow(-4.46895980834961*x_62 - 9.54120063781738, 2) - 0.000419438036900906*std::exp(0.0198841172009193*x_10 + 0.00276854976643089*x_100 - 0.0742855085127541*x_103 + 0.0698029750068127*x_104 + 0.118784117889524*x_105 - 0.122634770885968*x_106 - 0.0788909454224073*x_107 - 0.0689846940687605*x_108 + 0.0212585627904477*x_11 - 0.0637461434864535*x_110 + 0.0932688524736384*x_111 - 0.0214130554960537*x_112 + 0.134776679280037*x_113 + 0.145416636647855*x_114 - 0.0249128709847246*x_115 + 0.0311292839477329*x_116 + 0.00214148512641064*x_117 + 0.087858076744365*x_118 + 0.143789372464254*x_119 - 0.0310353453880694*x_12 - 0.00532669113817707*x_14 - 0.0736870500497764*x_16 + 0.000275336048387541*x_19 - 0.011101151304865*x_23 - 0.0394365965436925*x_24 + 0.0965258892615462*x_27 - 0.00958130036383097*x_28 - 0.0806283628485286*x_29 - 0.0306091745673571*x_30 - 6.53641914236839e-5*x_32 - 0.0560255731324205*x_33 - 0.00400041697360611*x_34 - 0.122324249179773*x_35 + 0.116806210030078*x_36 - 0.0497783061057379*x_37 - 0.0523380779548082*x_38 + 0.0331025082623692*x_39 + 0.0516701848589995*x_4 - 0.145512140409562*x_40 - 0.174183753069978*x_42 + 0.0857198429194503*x_43 + 0.0266089527246149*x_44 - 0.108621699443544*x_45 + 0.119375169607574*x_46 - 0.173293575793841*x_49 + 0.0496491093961628*x_50 + 0.0600887753315858*x_51 - 0.00396482252415139*x_52 - 0.013872836429485*x_53 - 0.0177844217570785*x_54 - 0.0222842048921193*x_56 - 0.0821072946897121*x_58 - 0.0441896241820971*x_59 - 0.00986751069460263*x_6 + 0.00157976015878954*x_61 - 0.0460019562475289*x_62 + 0.0308040526400498*x_63 - 0.021099337698263*x_64 - 0.00363392811410721*x_65 - 0.0107788117231883*x_66 + 8.65681435503722e-5*x_67 + 0.0232021151126679*x_68 - 0.0113963250440752*x_69 + 0.00277256981075806*x_70 + 0.0112232705393205*x_71 + 0.00632495100234655*x_72 + 0.000421988134813923*x_73 + 0.0338759156808095*x_74 + 5.33572743782685e-5*x_75 + 0.0144648602006304*x_76 + 0.0386830772996391*x_77 + 0.000722872386670766*x_78 - 0.0258586757827148*x_79 - 0.0919286569676739*x_8 - 0.0084587080457195*x_80 + 0.0462363487522514*x_81 + 0.000151647135896698*x_82 - 0.0153643921235281*x_83 + 8.43150691849862e-5*x_84 - 0.0018224403801936*x_85 + 0.0252957152369003*x_86 - 0.0363667678618172*x_87 + 0.000610609753177756*x_88 - 0.000788769252621535*x_89 - 0.000750302962020607*x_9 + 0.00136389280397741*x_90 + 0.0459928114761716*x_91 + 0.0556884569846393*x_93 - 3.54072426981249e-5*x_95 - 0.0608813775556981*x_96 - 0.138819579219411*x_99 - 6.85067736748233e-5*std::pow(-6.70760011672974*x_18 - 7.31832027435303, 2) - 0.896166456582051*std::sin(0.190880000591278*x_1 - 4.41607999801636) + 0.43368099584481*std::sin(0.228079989552498*x_101 + 1.98055982589722) + 0.958360352819369*std::sin(0.234159991145134*x_102 + 1.95911991596222) + 0.492574564582839*std::sin(0.184880003333092*x_109 - 7.38399982452393) + 0.914641942407144*std::sin(0.240399971604347*x_120 - 1.03391981124878) - 0.393463277076776*std::sin(0.319999933242798*x_13 - 4.28240013122559) + 0.889431191504485*std::sin(0.324719846248627*x_15 + 8.26583957672119) + 0.426236791565074*std::sin(0.384079843759537*x_17 + 1.99359977245331) - 0.453637084331305*std::sin(0.404319852590561*x_2 - 7.38735961914063) - 0.547928883752121*std::sin(0.367359846830368*x_20 + 8.22056007385254) - 0.671141976051928*std::sin(0.347999840974808*x_21 - 1.16127991676331) - 3.22178562014733*std::sin(0.137040033936501*x_22 + 4.94816017150879) - 0.136316393390981*std::sin(0.375839829444885*x_25 - 4.37487983703613) + 0.821121626099796*std::sin(0.195199996232986*x_26 - 1.19399988651276) - 0.296804962493205*std::sin(0.409039855003357*x_3 - 1.17767977714539) + 0.45045124032363*std::sin(0.357599824666977*x_31 + 5.16951990127563) - 0.64233671763813*std::sin(0.267199963331223*x_41 + 1.93695986270905) - 0.719288524239374*std::sin(0.192159995436668*x_47 + 2.00471973419189) + 0.553325622561943*std::sin(0.242559969425201*x_48 + 1.78887987136841) + 0.897142848553699*std::sin(0.338559836149216*x_5 + 2.04775977134705) + 1.39934564069944*std::sin(0.185440003871918*x_55 - 4.38175964355469) - 0.901557568604005*std::sin(0.241599977016449*x_57 - 4.2422399520874) - 0.325333985298769*std::sin(0.489599853754044*x_60 - 7.72096014022827) - 0.241781000696228*std::sin(0.239919975399971*x_7 + 7.77871990203857) - 0.253510076075479*std::sin(0.351359844207764*x_92 - 4.59311962127686) + 0.853107534563236*std::sin(0.279999971389771*x_94 + 1.98743987083435) - 0.405083315406515*std::sin(0.294719934463501*x_97 - 4.42967987060547) + 0.942944757519683*std::sin(0.282159924507141*x_98 + 8.16495990753174)) + 0.00664092249216066*std::sin(0.368399828672409*x_1 + 8.37007999420166) - 0.0101001188143017*std::sin(0.240799978375435*x_100 + 8.18143939971924) - 0.000539599192165105*std::sin(0.236399978399277*x_102 - 1.20351994037628) + 0.00184385891211141*std::sin(0.255919963121414*x_108 + 1.94351983070374) - 0.000786626956693302*std::sin(0.382559835910797*x_11 + 1.82871985435486) - 0.0116298234211813*std::sin(0.211439996957779*x_110 - 7.40647983551025) - 0.000775125729867118*std::sin(0.245359972119331*x_110 + 4.95287990570068) + 0.000570926820451932*std::sin(0.268559962511063*x_112 + 1.97895979881287) - 0.000649118508601565*std::sin(0.270159959793091*x_112 - 4.40351963043213) + 0.0119336296894457*std::sin(0.268879950046539*x_113 - 4.22904014587402) + 0.0143653204479622*std::sin(0.235119983553886*x_117 - 4.23808002471924) + 0.00143831456850266*std::sin(0.241999968886375*x_118 + 1.97351980209351) - 0.000587617845697269*std::sin(0.271119952201843*x_12 + 5.15176010131836) + 0.00165180163104753*std::sin(0.279279947280884*x_120 + 1.94519984722137) + 0.00340266616782951*std::sin(0.185840010643005*x_13 - 4.40351963043213) + 0.000423162961303959*std::sin(0.352799862623215*x_13 - 4.33256006240845) - 0.000168670560183804*std::sin(0.295119941234589*x_14 - 1.21431994438171) + 0.00540509258949249*std::sin(0.370479851961136*x_15 + 1.83439981937408) - 0.00513939825792573*std::sin(0.477439850568771*x_17 + 1.95439982414246) + 0.000902183425886315*std::sin(0.334319829940796*x_18 + 1.80159986019135) - 0.0626051673914848*std::sin(0.107840068638325*x_19 - 1.46535992622375) - 0.00221467080625644*std::sin(0.260959982872009*x_20 + 5.02055978775024) + 0.00798168173506632*std::sin(0.293359935283661*x_21 - 4.38455963134766) - 0.000149915062834556*std::sin(0.396319836378098*x_21 - 4.40287971496582) - 0.00661261120301159*std::sin(0.273999959230423*x_22 - 7.55800008773804) - 0.00035750542047874*std::sin(0.342079848051071*x_22 - 1.16143989562988) - 0.000276503814054633*std::sin(0.276719957590103*x_23 - 1.14367985725403) + 0.00184301042575091*std::sin(0.313359916210175*x_23 - 7.38032007217407) - 0.00109135525498334*std::sin(0.365439832210541*x_24 + 2.03655982017517) + 0.000268995163016085*std::sin(0.333359837532043*x_25 - 1.14519989490509) + 0.0014761630242912*std::sin(0.261919975280762*x_26 - 7.38695955276489) + 0.00828571984455846*std::sin(0.36999985575676*x_26 + 8.22991943359375) - 0.0030365590470832*std::sin(0.375039845705032*x_27 - 1.17775988578796) - 0.00580707814302807*std::sin(0.309839934110641*x_28 + 1.97959983348846) + 0.0097622256967747*std::sin(0.360319852828979*x_29 + 8.21487998962402) + 0.000365550045184377*std::sin(0.320239931344986*x_3 + 2.06399965286255) - 0.00608579985693153*std::sin(0.37391984462738*x_31 + 5.17328023910522) - 0.00115590207913626*std::sin(0.398239821195602*x_31 + 5.2007999420166) - 0.000735327116193023*std::sin(0.292239934206009*x_32 + 2.03519988059998) - 0.000579793499678901*std::sin(0.321919858455658*x_32 - 1.19455993175507) - 0.00141549685693106*std::sin(0.336319833993912*x_32 - 4.41016006469727) - 0.00649572323517321*std::sin(0.238239988684654*x_33 + 1.99767982959747) + 0.00226367475384085*std::sin(0.240239977836609*x_35 + 1.95999991893768) + 0.00190882081131398*std::sin(0.271359950304031*x_36 + 8.15679931640625) + 0.00930484532372214*std::sin(0.22367998957634*x_37 + 1.97847986221313) + 0.000130059778772796*std::sin(0.260879963636398*x_38 + 1.78807997703552) - 0.0120119958329127*std::sin(0.261039972305298*x_38 - 1.20975983142853) + 0.0110510582173796*std::sin(0.221039995551109*x_4 - 4.39103984832764) - 0.000176175609220554*std::sin(0.295199930667877*x_4 - 1.13903987407684) + 0.00083880687512103*std::sin(0.235759988427162*x_40 + 1.95503973960876) + 0.000619851616069215*std::sin(0.236879989504814*x_41 + 4.97887992858887) + 0.0123786305978433*std::sin(0.252079963684082*x_41 + 1.95879983901978) + 0.000553949693349426*std::sin(0.259679973125458*x_42 + 1.94903981685638) - 0.000235689857216799*std::sin(0.145360037684441*x_44 + 4.98343992233276) - 0.0125152207855021*std::sin(0.225679993629456*x_44 - 1.18967986106873) - 0.00902151154038407*std::sin(0.294879943132401*x_53 - 4.42799949645996) - 0.00107312232186717*std::sin(0.170560017228127*x_55 - 1.18743991851807) - 0.000570714816917483*std::sin(0.105280071496964*x_57 + 5.14776039123535) + 0.00168242029205708*std::sin(0.234479993581772*x_57 + 5.18336009979248) + 0.00829594942218138*std::sin(0.358479857444763*x_6 + 2.01023983955383) - 0.000847722953229813*std::sin(0.146960034966469*x_60 - 1.22951984405518) + 0.000773461038616498*std::sin(0.346719831228256*x_7 + 5.02895975112915) + 5.29246593899508e-5*std::sin(0.839039862155914*x_75 + 5.40751981735229) - 0.00518215130371893*std::sin(0.315759927034378*x_8 + 1.9851998090744) + 0.000453005556709199*std::sin(0.329119831323624*x_9 + 8.27431964874268) - 0.000537952608900245*std::sin(0.343199849128723*x_91 - 7.38391971588135) - 0.000648815163163799*std::sin(0.275199949741364*x_92 - 7.39559984207153) - 0.00503172014715609*std::sin(0.287759929895401*x_94 + 8.18183994293213) + 0.000473440815567896*std::sin(0.271839946508408*x_95 + 1.97663974761963) - 0.000512575021397744*std::sin(0.286479949951172*x_96 - 1.20391988754272) + 0.00150306405659519*std::sin(0.275359958410263*x_97 - 1.19951987266541) + 0.00955040374479389*std::sin(0.247839972376823*x_98 + 1.98023986816406) + 0.000255249105037422*std::sin(0.282799929380417*x_98 - 4.41296005249023) - 0.100512683391571*std::sin(-0.0465223119511567*x_100 + 0.0800151475936139*x_103 + 0.0111868351201465*x_104 + 0.00110117838852658*x_105 - 0.000267800430100746*x_106 - 0.0308400413121807*x_107 - 0.000682403589562257*x_11 - 0.0150423189727593*x_111 - 0.0648132567640003*x_112 - 0.0113725265803611*x_113 - 0.00612083899364142*x_115 - 0.00231420731853241*x_116 + 0.0652775337287069*x_117 + 0.0578125258869784*x_119 + 0.000179871680824501*x_12 - 0.0179401385269204*x_120 + 0.000456287794376715*x_14 - 0.0106171812824324*x_16 + 0.0330097846375938*x_18 + 0.00508567360958749*x_19 + 0.00744064236831204*x_2 + 0.0285177167251271*x_21 - 0.0015044827348385*x_22 - 0.00389022810012481*x_24 - 0.0498371162455013*x_25 + 0.000103126542812947*x_26 + 0.00397696441445374*x_28 + 0.00728930396986057*x_31 - 0.0654490627960885*x_33 + 0.0525685774950714*x_35 + 0.0766641357792043*x_36 + 0.0139301618007116*x_37 + 0.0165480444039507*x_39 - 0.0112050460993101*x_4 + 0.0613111120438576*x_43 + 0.0236056007150907*x_44 - 0.00465462160537714*x_45 + 0.0424970429288482*x_47 - 0.0370963989382201*x_48 + 0.0292919055450785*x_49 - 0.00802026678947447*x_5 - 0.0918648560177063*x_50 + 0.0928769545129235*x_51 - 0.0021890372706732*x_52 + 0.0141890085789106*x_53 + 0.00510977359446196*x_54 - 0.0618187109293911*x_55 + 0.0088021949127591*x_56 - 0.0778735619289361*x_57 - 0.0501069550189012*x_58 - 0.0452302032265436*x_59 - 0.0495496683465217*x_6 - 0.0325118224697777*x_61 - 0.01449170700281*x_62 - 0.000590642492040267*x_63 + 0.00797643594190837*x_64 + 0.000243355589627415*x_65 - 0.0231734651911425*x_66 + 0.0250031947669182*x_67 + 0.000400460478825134*x_68 + 0.0201854312883189*x_69 - 0.00111608028819933*x_70 - 0.000923021160875053*x_71 + 3.65158836849318e-5*x_72 - 0.0208187462300998*x_73 + 0.000383249865889024*x_74 - 0.000102150999739021*x_75 + 0.00501226815278664*x_76 - 0.000374476378387123*x_77 - 0.00228382110371466*x_78 + 0.00811979529435175*x_79 - 0.000969681213425813*x_80 - 0.000324063196890214*x_81 + 0.0129937799539134*x_82 + 0.00686031226775676*x_83 - 0.000483493371524514*x_84 + 0.0160399657047619*x_85 - 0.000216919038378536*x_86 + 0.000584607876720605*x_87 + 0.000373199974302027*x_88 + 0.00045910988786374*x_89 - 0.00600392986754176*x_9 - 0.0147952290815724*x_90 + 0.0617907026375923*x_93 + 0.0243734515259194*x_94 + 0.00738347830167262*x_96 + 0.00280446348033609*x_98 + 0.0458375814091059*x_99 - 0.000846176723040742*std::pow(-2.61807990074158*x_13 - 4.83735990524292, 2) + 0.388875692531066*std::sin(0.404959857463837*x_1 + 8.39888000488281) - 0.202310347296773*std::sin(0.341039836406708*x_10 - 1.12095987796783) - 0.3552313671861*std::sin(0.23327998816967*x_101 + 1.97543978691101) + 0.27129033087369*std::sin(0.229759991168976*x_102 - 4.39823961257935) + 0.305420895930521*std::sin(0.272799968719482*x_108 + 1.93503975868225) - 0.432675132558963*std::sin(0.250639975070953*x_109 - 1.2137598991394) - 0.158985191413631*std::sin(0.241679981350899*x_110 + 8.17327976226807) - 0.181012184237321*std::sin(0.229999989271164*x_114 + 1.95623981952667) + 0.498716765618539*std::sin(0.235199987888336*x_118 - 7.41671991348267) + 0.372905214070805*std::sin(0.311599940061569*x_15 - 4.24927997589111) - 0.275560607538974*std::sin(0.353039860725403*x_17 + 5.22735977172852) - 0.357538151875644*std::sin(0.34623983502388*x_20 - 1.14527976512909) - 0.143365612846582*std::sin(0.339599847793579*x_23 - 4.39879989624023) - 0.402265847724514*std::sin(0.224879994988441*x_27 - 1.18111991882324) - 0.378107845037427*std::sin(0.326559841632843*x_29 - 1.16359984874725) + 0.292581556505404*std::sin(0.207359999418259*x_3 + 1.99087977409363) - 0.497221599996585*std::sin(0.213279992341995*x_30 - 1.19399988651276) - 0.277295884132496*std::sin(0.291759938001633*x_32 - 1.13471984863281) + 0.345687505862429*std::sin(0.237599983811378*x_34 - 1.19663989543915) - 0.171410824233032*std::sin(0.248799979686737*x_38 - 1.2339198589325) + 0.540905282944934*std::sin(0.235519990324974*x_40 - 1.21535992622375) + 0.198142632603524*std::sin(0.282239943742752*x_41 - 4.44271993637085) + 0.415931660709468*std::sin(0.266719967126846*x_42 + 1.95047974586487) - 0.249162215544239*std::sin(0.173040017485619*x_46 - 7.38007974624634) + 0.369814160172879*std::sin(0.400799870491028*x_60 + 8.19935989379883) + 0.457527837664038*std::sin(0.312239944934845*x_7 - 4.20567989349365) - 0.125014876939032*std::sin(0.398159831762314*x_8 + 7.99560022354126) + 0.513629316337628*std::sin(0.371119856834412*x_91 - 7.39224004745483) + 0.142754279516973*std::sin(0.198400005698204*x_92 - 1.00927984714508) + 0.174098287774335*std::sin(0.294079929590225*x_95 + 4.97615957260132) - 0.332556934420424*std::sin(0.276799947023392*x_97 - 1.19999980926514) - 6.75602227592013) - 0.0197602234803016 - 5.71068321814497e-7*std::exp(-4.22904014587402*x_21));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000160877150155496*x_1 + 0.00188082876363084*x_10 + 1.61783298528762e-5*x_100 + 0.000854733514193195*x_101 + 0.000283907255718237*x_102 - 0.00112048696595225*x_103 + 0.00126426308990308*x_104 + 0.00245492062187989*x_105 - 0.00279899641496523*x_106 + 0.00185487740032936*x_107 - 0.00099284800723632*x_108 + 0.000293192075289342*x_109 - 0.000758169856907148*x_11 - 0.000931262779932653*x_110 + 0.000538775584545898*x_111 + 0.00029213399197923*x_112 + 0.0019722658446664*x_113 + 0.00506403968907339*x_114 - 0.00124840505883448*x_115 - 0.000611196043151859*x_116 + 0.000333464073731113*x_117 + 0.00112183660871499*x_118 + 0.00253518908698775*x_119 + 0.00243022369102715*x_12 - 0.00121834912645695*x_120 - 0.000176379160495146*x_13 + 0.00124271678864301*x_14 - 4.0854274561608e-5*x_15 - 0.000867336146795972*x_16 - 5.23260128468352e-5*x_17 - 0.000409029949117667*x_18 + 3.58855938674938e-5*x_19 - 0.000457140120067805*x_2 - 0.000952980409802952*x_20 - 0.000254531971029084*x_21 + 0.000107794334333661*x_22 - 0.000210615888427322*x_23 - 0.000589890837260699*x_24 + 0.00160935588739799*x_25 - 6.73057472942357e-6*x_26 + 0.00149867947257043*x_27 - 0.000182832649502341*x_28 - 0.00116279758797161*x_29 - 0.000150687864456752*x_3 - 0.00158183908934597*x_30 - 6.43628652254623e-5*x_31 - 9.41100398193106e-7*x_32 - 0.000572600325040875*x_33 + 0.00315789465948852*x_34 - 0.000809061443515439*x_35 + 0.00311658116207588*x_36 - 0.00112700590242593*x_37 + 0.000146834105287054*x_38 + 0.000809532604658712*x_39 + 0.000806998283881062*x_4 - 0.00242333308883589*x_40 + 7.19287791270525e-5*x_41 - 0.00084988433653998*x_42 - 0.000382786177505513*x_43 + 0.000164905502016061*x_44 - 0.000379772651480971*x_45 + 0.00323396035295353*x_46 - 0.00074622266413928*x_47 + 0.000582879072943506*x_48 - 0.00318721039248806*x_49 + 1.98303542802048e-5*x_5 + 0.000662654708263793*x_50 + 0.00272843527658316*x_51 + 0.0002125487166891*x_52 - 0.000235182086469627*x_53 - 0.00260681496761959*x_54 + 0.00333550759270897*x_55 + 0.00158686858922212*x_56 + 0.00311599240619615*x_57 + 0.00177359930597454*x_58 - 0.000376901533197087*x_59 + 0.000415545453718117*x_6 - 0.00300271357161911*x_60 - 0.000229768266888923*x_61 - 0.000644759810504888*x_62 + 0.000378767811416226*x_63 - 0.000703829648480221*x_64 - 0.000197689548716366*x_65 + 0.000146282623417226*x_66 - 0.000248772290659662*x_67 + 0.00044175689519106*x_68 - 0.000965368166776708*x_69 - 0.000808485669841383*x_7 + 9.29914606180289e-5*x_70 - 0.000111216910189029*x_71 + 0.00021094843869985*x_72 + 0.000199517159293235*x_73 + 0.000400458855237062*x_74 + 0.000128539493401129*x_75 - 8.5608964942236e-7*x_76 + 0.000496485824732323*x_77 - 3.62583806312445e-5*x_78 - 0.000455098197560455*x_79 - 0.00171523511163325*x_8 - 8.46627867634691e-5*x_80 + 0.000844144263673562*x_81 + 0.000185060884329879*x_82 - 0.000381448521342485*x_83 + 0.000514629073479517*x_84 + 6.38258860618474e-5*x_85 + 0.000313274167834338*x_86 - 0.00116633488894626*x_87 + 0.000785008371303052*x_88 + 0.000305736997015445*x_89 - 0.000298825435362237*x_9 - 0.000305710392837752*x_90 + 0.000627882355206738*x_91 + 0.00021739253295204*x_92 + 0.000306870973979748*x_93 - 0.000235058626242216*x_94 + 0.000158525447114508*x_95 - 0.00269760065115716*x_96 + 3.1898788661009e-5*x_97 - 4.38563113941006e-5*x_98 - 0.00121553246992762*x_99 + 7.55246400791686e-6*std::pow(-2.61807990074158*x_13 - 4.83735990524292, 2) - 9.86346661376134e-7*std::pow(-6.70760011672974*x_18 - 7.31832027435303, 2) + 6.77396776026154e-7*std::pow(-9.68360042572021*x_27 - 4.91775989532471, 2) + 8.85555774683495e-8*std::pow(-4.46895980834961*x_62 - 9.54120063781738, 2) - 0.0129028232548607*std::sin(0.190880000591278*x_1 - 4.41607999801636) + 0.00905324411237929*std::sin(0.368399828672409*x_1 + 8.37007999420166) - 0.0034708703175391*std::sin(0.404959857463837*x_1 + 8.39888000488281) + 0.00180570036350961*std::sin(0.341039836406708*x_10 - 1.12095987796783) - 0.0137689968973209*std::sin(0.240799978375435*x_100 + 8.18143939971924) + 0.00624405119972844*std::sin(0.228079989552498*x_101 + 1.98055982589722) + 0.00317058132433045*std::sin(0.23327998816967*x_101 + 1.97543978691101) - 0.00242137416904665*std::sin(0.229759991168976*x_102 - 4.39823961257935) + 0.0137982783846385*std::sin(0.234159991145134*x_102 + 1.95911991596222) + 0.000544699589157568*std::sin(0.236399978399277*x_102 - 1.20351994037628) - 0.0046698469311153*std::sin(0.255919963121414*x_108 + 1.94351983070374) - 0.00272600304519357*std::sin(0.272799968719482*x_108 + 1.93503975868225) + 0.00709198888216858*std::sin(0.184880003333092*x_109 - 7.38399982452393) + 0.00386179775074584*std::sin(0.250639975070953*x_109 - 1.2137598991394) + 0.00199224976245083*std::sin(0.382559835910797*x_11 + 1.82871985435486) - 0.0158543682056384*std::sin(0.211439996957779*x_110 - 7.40647983551025) + 0.0014190061050467*std::sin(0.241679981350899*x_110 + 8.17327976226807) + 0.00196312119494193*std::sin(0.245359972119331*x_110 + 4.95287990570068) - 0.000576323332307825*std::sin(0.268559962511063*x_112 + 1.97895979881287) + 0.00164398916609733*std::sin(0.270159959793091*x_112 - 4.40351963043213) + 0.0162685323993502*std::sin(0.268879950046539*x_113 - 4.22904014587402) + 0.00161560578212805*std::sin(0.229999989271164*x_114 + 1.95623981952667) + 0.0195835372151199*std::sin(0.235119983553886*x_117 - 4.23808002471924) - 0.00445124560853392*std::sin(0.235199987888336*x_118 - 7.41671991348267) - 0.00364274556452329*std::sin(0.241999968886375*x_118 + 1.97351980209351) + 0.000593172124384911*std::sin(0.271119952201843*x_12 + 5.15176010131836) + 0.0131688295602719*std::sin(0.240399971604347*x_120 - 1.03391981124878) - 0.00418343330223983*std::sin(0.279279947280884*x_120 + 1.94519984722137) - 0.00861775814682747*std::sin(0.185840010643005*x_13 - 4.40351963043213) - 0.00566500462510348*std::sin(0.319999933242798*x_13 - 4.28240013122559) - 0.000427162780292747*std::sin(0.352799862623215*x_13 - 4.33256006240845) + 0.000170264867273899*std::sin(0.295119941234589*x_14 - 1.21431994438171) - 0.00332832744147546*std::sin(0.311599940061569*x_15 - 4.24927997589111) + 0.0128058502715134*std::sin(0.324719846248627*x_15 + 8.26583957672119) + 0.00736849778332031*std::sin(0.370479851961136*x_15 + 1.83439981937408) + 0.00245948808773555*std::sin(0.353039860725403*x_17 + 5.22735977172852) + 0.00613687105323998*std::sin(0.384079843759537*x_17 + 1.99359977245331) - 0.00700628972475785*std::sin(0.477439850568771*x_17 + 1.95439982414246) - 0.00228491370733671*std::sin(0.334319829940796*x_18 + 1.80159986019135) - 0.0853465559582334*std::sin(0.107840068638325*x_19 - 1.46535992622375) - 0.00653137492257974*std::sin(0.404319852590561*x_2 - 7.38735961914063) + 0.00560898320370101*std::sin(0.260959982872009*x_20 + 5.02055978775024) + 0.00319117029572072*std::sin(0.34623983502388*x_20 - 1.14527976512909) - 0.00788896916567353*std::sin(0.367359846830368*x_20 + 8.22056007385254) + 0.0108810354676138*std::sin(0.293359935283661*x_21 - 4.38455963134766) - 0.00966296632987523*std::sin(0.347999840974808*x_21 - 1.16127991676331) + 0.000151332089299215*std::sin(0.396319836378098*x_21 - 4.40287971496582) - 0.0463866172589853*std::sin(0.137040033936501*x_22 + 4.94816017150879) - 0.00901464871962998*std::sin(0.273999959230423*x_22 - 7.55800008773804) + 0.000360884631563327*std::sin(0.342079848051071*x_22 - 1.16143989562988) + 0.000279117382129022*std::sin(0.276719957590103*x_23 - 1.14367985725403) - 0.0046676980132124*std::sin(0.313359916210175*x_23 - 7.38032007217407) + 0.00127959515017836*std::sin(0.339599847793579*x_23 - 4.39879989624023) + 0.00276401949995432*std::sin(0.365439832210541*x_24 + 2.03655982017517) - 0.0002715377578538*std::sin(0.333359837532043*x_25 - 1.14519989490509) - 0.00196265584116163*std::sin(0.375839829444885*x_25 - 4.37487983703613) + 0.0118223429748951*std::sin(0.195199996232986*x_26 - 1.19399988651276) - 0.00373860240798924*std::sin(0.261919975280762*x_26 - 7.38695955276489) + 0.0112955157191072*std::sin(0.36999985575676*x_26 + 8.22991943359375) + 0.00359038278154962*std::sin(0.224879994988441*x_27 - 1.18111991882324) - 0.00413959210446286*std::sin(0.375039845705032*x_27 - 1.17775988578796) - 0.00791650498414271*std::sin(0.309839934110641*x_28 + 1.97959983348846) + 0.00337476299335485*std::sin(0.326559841632843*x_29 - 1.16359984874725) + 0.0133083637728602*std::sin(0.360319852828979*x_29 + 8.21487998962402) - 0.00261140683112476*std::sin(0.207359999418259*x_3 + 1.99087977409363) - 0.00036900529563346*std::sin(0.320239931344986*x_3 + 2.06399965286255) - 0.0042733377756867*std::sin(0.409039855003357*x_3 - 1.17767977714539) + 0.00443790066032369*std::sin(0.213279992341995*x_30 - 1.19399988651276) + 0.00648550578538243*std::sin(0.357599824666977*x_31 + 5.16951990127563) - 0.00829647263447555*std::sin(0.37391984462738*x_31 + 5.17328023910522) + 0.00292749393213777*std::sin(0.398239821195602*x_31 + 5.2007999420166) + 0.0024749761219245*std::sin(0.291759938001633*x_32 - 1.13471984863281) + 0.00186232528658482*std::sin(0.292239934206009*x_32 + 2.03519988059998) + 0.000585273821119239*std::sin(0.321919858455658*x_32 - 1.19455993175507) - 0.00192967748098701*std::sin(0.336319833993912*x_32 - 4.41016006469727) - 0.00885530108262774*std::sin(0.238239988684654*x_33 + 1.99767982959747) - 0.00308539856382558*std::sin(0.237599983811378*x_34 - 1.19663989543915) - 0.0057330929892906*std::sin(0.240239977836609*x_35 + 1.95999991893768) - 0.00483437260259588*std::sin(0.271359950304031*x_36 + 8.15679931640625) + 0.0126848395299039*std::sin(0.22367998957634*x_37 + 1.97847986221313) + 0.00152990982301578*std::sin(0.248799979686737*x_38 - 1.2339198589325) - 0.000131289129213131*std::sin(0.260879963636398*x_38 + 1.78807997703552) - 0.0163753651214291*std::sin(0.261039972305298*x_38 - 1.20975983142853) + 0.0150653659728984*std::sin(0.221039995551109*x_4 - 4.39103984832764) + 0.000177840855500498*std::sin(0.295199930667877*x_4 - 1.13903987407684) - 0.00482779491552736*std::sin(0.235519990324974*x_40 - 1.21535992622375) - 0.00084673544159267*std::sin(0.235759988427162*x_40 + 1.95503973960876) - 0.00156986640790919*std::sin(0.236879989504814*x_41 + 4.97887992858887) + 0.0168751803249523*std::sin(0.252079963684082*x_41 + 1.95879983901978) - 0.00924823404951144*std::sin(0.267199963331223*x_41 + 1.93695986270905) - 0.00176850185123794*std::sin(0.282239943742752*x_41 - 4.44271993637085) - 0.000559185734082916*std::sin(0.259679973125458*x_42 + 1.94903981685638) - 0.00371235560105344*std::sin(0.266719967126846*x_42 + 1.95047974586487) + 0.000237917643796833*std::sin(0.145360037684441*x_44 + 4.98343992233276) - 0.0170613870324829*std::sin(0.225679993629456*x_44 - 1.18967986106873) + 0.00222387193335745*std::sin(0.173040017485619*x_46 - 7.38007974624634) - 0.01035617058566*std::sin(0.192159995436668*x_47 + 2.00471973419189) + 0.00796667031873984*std::sin(0.242559969425201*x_48 + 1.78887987136841) + 0.0129168811488435*std::sin(0.338559836149216*x_5 + 2.04775977134705) - 0.0122985844713828*std::sin(0.294879943132401*x_53 - 4.42799949645996) + 0.00108326568372254*std::sin(0.170560017228127*x_55 - 1.18743991851807) + 0.0201474953026781*std::sin(0.185440003871918*x_55 - 4.38175964355469) + 0.000576109324874547*std::sin(0.105280071496964*x_57 + 5.14776039123535) - 0.00426097961514431*std::sin(0.234479993581772*x_57 + 5.18336009979248) - 0.0129804433945741*std::sin(0.241599977016449*x_57 - 4.2422399520874) + 0.0113094612008525*std::sin(0.358479857444763*x_6 + 2.01023983955383) + 0.00085573579621378*std::sin(0.146960034966469*x_60 - 1.22951984405518) - 0.00330073855528308*std::sin(0.400799870491028*x_60 + 8.19935989379883) - 0.00468409287167414*std::sin(0.489599853754044*x_60 - 7.72096014022827) - 0.00348111391076279*std::sin(0.239919975399971*x_7 + 7.77871990203857) - 0.00408361803449337*std::sin(0.312239944934845*x_7 - 4.20567989349365) - 0.00195890511676106*std::sin(0.346719831228256*x_7 + 5.02895975112915) + 7.21495939137005e-5*std::sin(0.839039862155914*x_75 + 5.40751981735229) - 0.0070645728564418*std::sin(0.315759927034378*x_8 + 1.9851998090744) + 0.00111580752912147*std::sin(0.398159831762314*x_8 + 7.99560022354126) - 0.000457287453740471*std::sin(0.329119831323624*x_9 + 8.27431964874268) + 0.00136244499145632*std::sin(0.343199849128723*x_91 - 7.38391971588135) - 0.00458434605848181*std::sin(0.371119856834412*x_91 - 7.39224004745483) - 0.00127413875691796*std::sin(0.198400005698204*x_92 - 1.00927984714508) + 0.000654947890853006*std::sin(0.275199949741364*x_92 - 7.39559984207153) - 0.0036499867640702*std::sin(0.351359844207764*x_92 - 4.59311962127686) + 0.0122828696108997*std::sin(0.279999971389771*x_94 + 1.98743987083435) - 0.00685949743445358*std::sin(0.287759929895401*x_94 + 8.18183994293213) - 0.000477915870658588*std::sin(0.271839946508408*x_95 + 1.97663974761963) - 0.00155389650465758*std::sin(0.294079929590225*x_95 + 4.97615957260132) + 0.00051741998064807*std::sin(0.286479949951172*x_96 - 1.20391988754272) - 0.0038067332732759*std::sin(0.275359958410263*x_97 - 1.19951987266541) + 0.00296820298810381*std::sin(0.276799947023392*x_97 - 1.19999980926514) - 0.00583230758504147*std::sin(0.294719934463501*x_97 - 4.42967987060547) + 0.0130195972886998*std::sin(0.247839972376823*x_98 + 1.98023986816406) + 0.0135763277636803*std::sin(0.282159924507141*x_98 + 8.16495990753174) - 0.000257661769449386*std::sin(0.282799929380417*x_98 - 4.41296005249023) - 0.170036123264726 + 1.44631545969471e-6*std::exp(-4.22904014587402*x_21));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (6.82106578654906e-5*x_1 + 0.00121060281478812*x_10 - 0.000426248658579577*x_100 + 0.000101425387254937*x_101 - 0.000108216935137778*x_102 + 0.00121322979955024*x_103 + 0.000570225596460757*x_104 + 0.000562835570033156*x_105 - 0.00169285254723281*x_106 + 0.000637379677920851*x_107 - 0.000325907655560313*x_108 + 0.000117408089099852*x_109 - 0.000764118338616735*x_11 - 0.000179580790025132*x_110 - 0.000889814834781575*x_111 - 0.000976438552586877*x_112 + 0.000289183075876251*x_113 + 0.00109165647894266*x_114 - 0.00242066645028264*x_115 - 0.000239644661927915*x_116 + 0.000633718485495423*x_117 - 0.00022624951837824*x_118 + 0.00191495323029042*x_119 + 0.00174918479463949*x_12 - 0.00130478753627508*x_120 - 0.000127190719434484*x_13 + 0.00141583351778058*x_14 + 6.3245759886404e-5*x_15 - 0.000528212832504044*x_16 - 7.29824200433248e-6*x_17 + 0.000500331846991812*x_18 - 0.000206659191342579*x_19 - 1.59794510898908e-5*x_2 - 0.000890042831452242*x_20 + 0.000404409204700901*x_21 - 5.80597152321357e-5*x_22 - 7.45454153592502e-5*x_23 - 0.000264664047813232*x_24 + 0.000203961107590644*x_25 + 1.79496052358495e-5*x_26 + 2.0679669008303e-5*x_27 - 2.05120739758462e-5*x_28 - 0.000296294718591859*x_29 - 1.25063179452327e-5*x_3 - 7.14932267640939e-5*x_30 + 0.000101391424763295*x_31 - 2.23299661933314e-7*x_32 - 0.0010381786887299*x_33 + 0.00120889901229804*x_34 + 0.0011549172001652*x_35 + 0.00297877890028268*x_36 + 0.000128064375002397*x_37 - 0.000529204637675561*x_38 - 0.000414237059421409*x_39 + 3.19982712405019e-5*x_4 - 4.51353508226301e-5*x_40 - 0.00020410939685449*x_41 + 0.0010435982966522*x_42 - 0.000691271884462592*x_43 + 0.000428577900958766*x_44 - 0.00106406917881449*x_45 + 0.00150613115375953*x_46 + 0.00101293752091755*x_47 - 0.000295445760872998*x_48 - 0.000519992756047199*x_49 + 4.63588670900217e-5*x_5 - 0.00260802083019898*x_50 + 0.00222267618658008*x_51 - 0.000309070844526777*x_52 + 7.05871994536867e-5*x_53 - 0.00190213512741347*x_54 + 0.000331806206096041*x_55 + 0.000302702996099637*x_56 + 0.000641467104618302*x_57 + 0.000247814429861554*x_58 - 0.000777705195047667*x_59 - 0.00107007409503499*x_6 - 0.00224065709977009*x_60 - 0.00113171760802093*x_61 - 0.000347475030755681*x_62 + 0.000145577634291966*x_63 - 0.000276687737533105*x_64 + 0.000340161190175512*x_65 - 0.000479615625247386*x_66 + 0.00033405496244541*x_67 + 7.3403336344035e-5*x_68 + 0.000151575843177613*x_69 - 0.000688527075467096*x_7 + 5.53039592180064e-5*x_70 + 0.000111691286108864*x_71 - 7.30270849115293e-6*x_72 - 0.000290359980162837*x_73 + 8.61066184077832e-5*x_74 - 4.77617761672712e-5*x_75 + 0.000193291163878763*x_76 + 0.000167249697031922*x_77 - 8.6270958798564e-5*x_78 + 6.76281057273553e-5*x_79 - 0.000125426387844953*x_8 - 3.33475684576171e-5*x_80 + 7.18526388902575e-5*x_81 + 0.00011851362060446*x_82 + 0.000124256977875178*x_83 + 0.000312151604575352*x_84 + 0.000112210486868466*x_85 + 0.000144117751598063*x_86 - 0.00050099412983625*x_87 + 0.000583930068032532*x_88 + 0.000483469665095969*x_89 - 0.000363541196388888*x_9 - 0.000453862453721767*x_90 + 0.000142310977036947*x_91 + 0.000114420749154016*x_92 + 0.00120656311233698*x_93 + 0.00036010488889034*x_94 + 0.000168020119493029*x_95 - 0.00120597684311892*x_96 + 6.41470888159667e-6*x_97 + 4.70963425034758e-5*x_98 + 0.000159852811132588*x_99 - 1.19996161999816e-5*std::pow(-2.61807990074158*x_13 - 4.83735990524292, 2) - 2.34035472152834e-7*std::pow(-6.70760011672974*x_18 - 7.31832027435303, 2) - 2.63623718075077e-7*std::pow(-9.68360042572021*x_27 - 4.91775989532471, 2) - 2.51290592229278e-7*std::pow(-4.46895980834961*x_62 - 9.54120063781738, 2) - 0.00306151827831285*std::sin(0.190880000591278*x_1 - 4.41607999801636) + 0.00652848459328741*std::sin(0.368399828672409*x_1 + 8.37007999420166) + 0.00551463888430569*std::sin(0.404959857463837*x_1 + 8.39888000488281) - 0.00286895923126141*std::sin(0.341039836406708*x_10 - 1.12095987796783) - 0.00992911303322376*std::sin(0.240799978375435*x_100 + 8.18143939971924) + 0.00148155767936204*std::sin(0.228079989552498*x_101 + 1.98055982589722) - 0.00503752933915519*std::sin(0.23327998816967*x_101 + 1.97543978691101) + 0.00384716308143299*std::sin(0.229759991168976*x_102 - 4.39823961257935) + 0.00327398745603263*std::sin(0.234159991145134*x_102 + 1.95911991596222) - 0.00154567206560615*std::sin(0.236399978399277*x_102 - 1.20351994037628) + 0.00181737270443486*std::sin(0.255919963121414*x_108 + 1.94351983070374) + 0.00433116798279537*std::sin(0.272799968719482*x_108 + 1.93503975868225) + 0.00168275215148524*std::sin(0.184880003333092*x_109 - 7.38399982452393) - 0.00613575791984262*std::sin(0.250639975070953*x_109 - 1.2137598991394) - 0.00077532741267608*std::sin(0.382559835910797*x_11 + 1.82871985435486) - 0.0114329181100159*std::sin(0.211439996957779*x_110 - 7.40647983551025) - 0.00225456601026394*std::sin(0.241679981350899*x_110 + 8.17327976226807) - 0.000763991395823529*std::sin(0.245359972119331*x_110 + 4.95287990570068) + 0.00163540948669151*std::sin(0.268559962511063*x_112 + 1.97895979881287) - 0.000639794211871169*std::sin(0.270159959793091*x_112 - 4.40351963043213) + 0.0117315806142161*std::sin(0.268879950046539*x_113 - 4.22904014587402) - 0.00256693038135443*std::sin(0.229999989271164*x_114 + 1.95623981952667) + 0.0141221002553283*std::sin(0.235119983553886*x_117 - 4.23808002471924) + 0.00707229307657344*std::sin(0.235199987888336*x_118 - 7.41671991348267) + 0.00141765382373779*std::sin(0.241999968886375*x_118 + 1.97351980209351) - 0.00168322062474109*std::sin(0.271119952201843*x_12 + 5.15176010131836) + 0.00312463494278828*std::sin(0.240399971604347*x_120 - 1.03391981124878) + 0.00162807424021897*std::sin(0.279279947280884*x_120 + 1.94519984722137) + 0.00335378839188737*std::sin(0.185840010643005*x_13 - 4.40351963043213) - 0.00134416436340377*std::sin(0.319999933242798*x_13 - 4.28240013122559) + 0.00121214260136731*std::sin(0.352799862623215*x_13 - 4.33256006240845) - 0.000483153749953125*std::sin(0.295119941234589*x_14 - 1.21431994438171) + 0.00528816182953095*std::sin(0.311599940061569*x_15 - 4.24927997589111) + 0.00303850900699634*std::sin(0.324719846248627*x_15 + 8.26583957672119) + 0.00531357860861177*std::sin(0.370479851961136*x_15 + 1.83439981937408) - 0.00390771979453545*std::sin(0.353039860725403*x_17 + 5.22735977172852) + 0.00145612650270672*std::sin(0.384079843759537*x_17 + 1.99359977245331) - 0.00505238276538292*std::sin(0.477439850568771*x_17 + 1.95439982414246) + 0.000889223964930052*std::sin(0.334319829940796*x_18 + 1.80159986019135) - 0.0615451951529268*std::sin(0.107840068638325*x_19 - 1.46535992622375) - 0.00154973243553183*std::sin(0.404319852590561*x_2 - 7.38735961914063) - 0.00218285805175315*std::sin(0.260959982872009*x_20 + 5.02055978775024) - 0.00507024180946642*std::sin(0.34623983502388*x_20 - 1.14527976512909) - 0.00187185570325917*std::sin(0.367359846830368*x_20 + 8.22056007385254) + 0.0078465433525863*std::sin(0.293359935283661*x_21 - 4.38455963134766) - 0.00229278100283131*std::sin(0.347999840974808*x_21 - 1.16127991676331) - 0.000429428969133934*std::sin(0.396319836378098*x_21 - 4.40287971496582) - 0.0110063878115967*std::sin(0.137040033936501*x_22 + 4.94816017150879) - 0.00650065264445139*std::sin(0.273999959230423*x_22 - 7.55800008773804) - 0.00102406777059757*std::sin(0.342079848051071*x_22 - 1.16143989562988) - 0.000792040143171739*std::sin(0.276719957590103*x_23 - 1.14367985725403) + 0.00181653640620101*std::sin(0.313359916210175*x_23 - 7.38032007217407) - 0.00203306506027737*std::sin(0.339599847793579*x_23 - 4.39879989624023) - 0.00107567842540461*std::sin(0.365439832210541*x_24 + 2.03655982017517) + 0.000770531748924333*std::sin(0.333359837532043*x_25 - 1.14519989490509) - 0.000465689300168492*std::sin(0.375839829444885*x_25 - 4.37487983703613) + 0.00280514724531237*std::sin(0.195199996232986*x_26 - 1.19399988651276) + 0.00145495860340573*std::sin(0.261919975280762*x_26 - 7.38695955276489) + 0.00814543377269506*std::sin(0.36999985575676*x_26 + 8.22991943359375) - 0.00570452442334791*std::sin(0.224879994988441*x_27 - 1.18111991882324) - 0.00298514686459476*std::sin(0.375039845705032*x_27 - 1.17775988578796) - 0.00570875811809696*std::sin(0.309839934110641*x_28 + 1.97959983348846) - 0.00536194024145093*std::sin(0.326559841632843*x_29 - 1.16359984874725) + 0.00959694080646504*std::sin(0.360319852828979*x_29 + 8.21487998962402) + 0.00414909355180765*std::sin(0.207359999418259*x_3 + 1.99087977409363) + 0.00104711145165998*std::sin(0.320239931344986*x_3 + 2.06399965286255) - 0.00101395651565955*std::sin(0.409039855003357*x_3 - 1.17767977714539) - 0.00705109016099999*std::sin(0.213279992341995*x_30 - 1.19399988651276) + 0.00153884883283759*std::sin(0.357599824666977*x_31 + 5.16951990127563) - 0.00598276077618872*std::sin(0.37391984462738*x_31 + 5.17328023910522) - 0.00113929806332971*std::sin(0.398239821195602*x_31 + 5.2007999420166) - 0.00393232771928223*std::sin(0.291759938001633*x_32 - 1.13471984863281) - 0.000724764471414858*std::sin(0.292239934206009*x_32 + 2.03519988059998) - 0.00166080792796943*std::sin(0.321919858455658*x_32 - 1.19455993175507) - 0.00139153098582763*std::sin(0.336319833993912*x_32 - 4.41016006469727) - 0.00638574371454378*std::sin(0.238239988684654*x_33 + 1.99767982959747) + 0.00490218802116388*std::sin(0.237599983811378*x_34 - 1.19663989543915) + 0.00223115807957225*std::sin(0.240239977836609*x_35 + 1.95999991893768) + 0.00188140145504237*std::sin(0.271359950304031*x_36 + 8.15679931640625) + 0.00914730437082368*std::sin(0.22367998957634*x_37 + 1.97847986221313) - 0.00243077367565434*std::sin(0.248799979686737*x_38 - 1.2339198589325) + 0.000372553869292146*std::sin(0.260879963636398*x_38 + 1.78807997703552) - 0.011808619935314*std::sin(0.261039972305298*x_38 - 1.20975983142853) + 0.0108639520182402*std::sin(0.221039995551109*x_4 - 4.39103984832764) - 0.000504651826331932*std::sin(0.295199930667877*x_4 - 1.13903987407684) + 0.00767056764756827*std::sin(0.235519990324974*x_40 - 1.21535992622375) + 0.00240274702805014*std::sin(0.235759988427162*x_40 + 1.95503973960876) + 0.000610947725145667*std::sin(0.236879989504814*x_41 + 4.97887992858887) + 0.012169047182739*std::sin(0.252079963684082*x_41 + 1.95879983901978) - 0.00219437537238436*std::sin(0.267199963331223*x_41 + 1.93695986270905) + 0.00280985694755606*std::sin(0.282239943742752*x_41 - 4.44271993637085) + 0.00158677881507894*std::sin(0.259679973125458*x_42 + 1.94903981685638) + 0.00589831906034866*std::sin(0.266719967126846*x_42 + 1.95047974586487) - 0.000675129306596964*std::sin(0.145360037684441*x_44 + 4.98343992233276) - 0.0123033247528775*std::sin(0.225679993629456*x_44 - 1.18967986106873) - 0.00353336469398957*std::sin(0.173040017485619*x_46 - 7.38007974624634) - 0.00245726109046561*std::sin(0.192159995436668*x_47 + 2.00471973419189) + 0.00189029224971569*std::sin(0.242559969425201*x_48 + 1.78887987136841) + 0.00306485386607787*std::sin(0.338559836149216*x_5 + 2.04775977134705) - 0.00886876773055058*std::sin(0.294879943132401*x_53 - 4.42799949645996) - 0.00307393936086728*std::sin(0.170560017228127*x_55 - 1.18743991851807) + 0.00478049833846518*std::sin(0.185440003871918*x_55 - 4.38175964355469) - 0.00163480220642541*std::sin(0.105280071496964*x_57 + 5.14776039123535) + 0.00165825307787276*std::sin(0.234479993581772*x_57 + 5.18336009979248) - 0.00307993560232048*std::sin(0.241599977016449*x_57 - 4.2422399520874) + 0.00815549015266124*std::sin(0.358479857444763*x_6 + 2.01023983955383) - 0.00242828697152598*std::sin(0.146960034966469*x_60 - 1.22951984405518) + 0.00524432765232116*std::sin(0.400799870491028*x_60 + 8.19935989379883) - 0.00111141845940911*std::sin(0.489599853754044*x_60 - 7.72096014022827) - 0.00082598154343272*std::sin(0.239919975399971*x_7 + 7.77871990203857) + 0.00648819366366758*std::sin(0.312239944934845*x_7 - 4.20567989349365) + 0.000762350617117351*std::sin(0.346719831228256*x_7 + 5.02895975112915) + 5.2028588473988e-5*std::sin(0.839039862155914*x_75 + 5.40751981735229) - 0.00509441195652413*std::sin(0.315759927034378*x_8 + 1.9851998090744) - 0.00177283361939523*std::sin(0.398159831762314*x_8 + 7.99560022354126) + 0.00129762617278998*std::sin(0.329119831323624*x_9 + 8.27431964874268) - 0.000530225160544038*std::sin(0.343199849128723*x_91 - 7.38391971588135) + 0.00728376767794133*std::sin(0.371119856834412*x_91 - 7.39224004745483) + 0.00202439575382422*std::sin(0.198400005698204*x_92 - 1.00927984714508) - 0.00185851922687299*std::sin(0.275199949741364*x_92 - 7.39559984207153) - 0.000866050861356355*std::sin(0.351359844207764*x_92 - 4.59311962127686) + 0.0029144187346546*std::sin(0.279999971389771*x_94 + 1.98743987083435) - 0.0049465277598436*std::sin(0.287759929895401*x_94 + 8.18183994293213) + 0.00135616259988244*std::sin(0.271839946508408*x_95 + 1.97663974761963) + 0.00246888454560499*std::sin(0.294079929590225*x_95 + 4.97615957260132) - 0.0014682618202652*std::sin(0.286479949951172*x_96 - 1.20391988754272) + 0.00148147321442574*std::sin(0.275359958410263*x_97 - 1.19951987266541) - 0.0047159836344203*std::sin(0.276799947023392*x_97 - 1.19999980926514) - 0.00138386118476982*std::sin(0.294719934463501*x_97 - 4.42967987060547) + 0.00938870522599271*std::sin(0.247839972376823*x_98 + 1.98023986816406) + 0.00322132410712638*std::sin(0.282159924507141*x_98 + 8.16495990753174) + 0.000731156416013676*std::sin(0.282799929380417*x_98 - 4.41296005249023) - 0.189649970233522 - 5.62865181069983e-7*std::exp(-4.22904014587402*x_21));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.16891909221592e-5*x_1 + 0.000194278450704577*x_10 + 0.000997831698293099*x_100 - 9.66542507042301e-7*x_101 + 2.58222786206728e-5*x_102 - 0.00168746829143289*x_103 - 0.000179331052125824*x_104 - 1.52270169118522e-5*x_105 - 0.000169965058778114*x_106 + 0.000972782794745602*x_107 - 3.3141045187958e-5*x_108 + 6.77481868358636e-5*x_109 - 0.000142747504676516*x_11 + 1.58362758621148e-5*x_110 + 9.23500630310213e-5*x_111 + 0.0014100384894286*x_112 + 0.000221389791301598*x_113 + 0.000251913563976149*x_114 - 0.000187899398637778*x_115 - 8.53606303410825e-5*x_116 - 0.00131361903001569*x_117 - 0.000173535899652553*x_118 - 0.00112290093863457*x_119 + 0.000357840860150507*x_12 + 0.000192013468169673*x_120 - 2.26278331750476e-5*x_13 + 0.000175911287129372*x_14 + 2.08017815683104e-5*x_15 + 0.000189531861015028*x_16 - 1.90629283436664e-5*x_17 - 0.000689317919079746*x_18 - 0.000232618441304401*x_19 - 0.000195620967470351*x_2 - 0.000196632646830426*x_20 - 0.000619175337573169*x_21 + 4.12225939336052e-5*x_22 - 6.51509180569764e-6*x_23 + 6.47808119309733e-5*x_24 + 0.00123386341767991*x_25 + 4.59744731179996e-6*x_26 - 0.000128160543365765*x_27 - 0.000111955992053521*x_28 - 1.13542919003744e-5*x_29 - 1.60747428142811e-5*x_3 - 0.000105372134594337*x_30 - 0.000159085244547215*x_31 + 0.00136085917150805*x_33 + 0.000268890711215878*x_34 - 0.0010314870538421*x_35 - 0.00140570418942186*x_36 - 0.000333931614944842*x_37 + 8.16490670516327e-5*x_38 - 0.000350707072687854*x_39 + 0.000239932907257635*x_4 - 1.87870772315465e-5*x_40 - 8.46354606478081e-5*x_41 + 0.000227710705053828*x_42 - 0.00159634403859633*x_43 - 0.000513205219306213*x_44 + 0.000140374206152224*x_45 + 0.000168032962167514*x_46 - 0.000919278008749697*x_47 + 0.000833215755042761*x_48 - 0.000693106908734921*x_49 + 0.000146015847234653*x_5 + 0.00180547607062728*x_50 - 0.00174587909311571*x_51 - 7.80281883341996e-5*x_52 - 0.000324512258309314*x_53 - 0.000451319388206103*x_54 + 0.00167227161393043*x_55 + 4.96380124316492e-5*x_56 + 0.00200137159495026*x_57 + 0.00137974899989969*x_58 + 0.000938044270881606*x_59 + 0.00093679633314225*x_6 - 0.00038777256914034*x_60 + 0.000627370739453908*x_61 + 0.000303547950161849*x_62 + 9.28392256093309e-6*x_63 - 0.000243705263159809*x_64 + 2.07116509220229e-5*x_65 + 0.000508741113568367*x_66 - 0.000551608596279432*x_67 - 4.99616922093373e-6*x_68 - 0.000481534261116121*x_69 - 0.000142410518145783*x_7 + 6.39235785190074e-5*x_70 - 9.26579261775749e-6*x_71 + 8.6176417296847e-6*x_72 + 0.000449880856236985*x_73 - 7.51199939038245e-6*x_74 + 1.52097389386326e-5*x_75 - 0.000112808166884824*x_76 + 2.27841102986608e-5*x_77 + 3.09502247175477e-5*x_78 - 0.000151217573890332*x_79 - 1.67804654843679e-5*x_8 + 2.24770402454372e-5*x_80 + 2.23250183091982e-5*x_81 - 0.000252356932765566*x_82 - 0.000167966628941214*x_83 + 6.38190104597609e-5*x_84 - 0.00034201320651525*x_85 + 1.29952630091381e-6*x_86 - 6.23464164835849e-5*x_87 + 9.2743357384462e-5*x_88 + 3.74850823694895e-5*x_89 + 8.55325369977969e-5*x_9 + 0.00029641596371641*x_90 - 7.60018764154655e-7*x_91 + 2.64551124111044e-5*x_92 - 0.00132896949182071*x_93 - 0.000526824625958382*x_94 + 2.22135164614077e-5*x_95 - 0.000379958092966502*x_96 - 1.99029355816447e-6*x_97 - 6.25975049918865e-5*x_98 - 0.00092856665785254*x_99 + 1.83721496073937e-5*std::pow(-2.61807990074158*x_13 - 4.83735990524292, 2) + 6.14278138881808e-8*std::pow(-9.68360042572021*x_27 - 4.91775989532471, 2) - 1.04199489869383e-7*std::pow(-4.46895980834961*x_62 - 9.54120063781738, 2) - 0.000153326498386802*std::exp(0.0223458915105004*x_10 + 0.00311131301917823*x_100 - 0.0834825050192127*x_103 + 0.078445006678008*x_104 + 0.133490312127464*x_105 - 0.137817699319647*x_106 - 0.088658122950936*x_107 - 0.0775254175968303*x_108 + 0.0238905018002279*x_11 - 0.0716383026798508*x_110 + 0.104816102099239*x_111 - 0.024064121639809*x_112 + 0.151462849615369*x_113 + 0.163420098238236*x_114 - 0.0279972355128752*x_115 + 0.0349832781041666*x_116 + 0.00240661397348382*x_117 + 0.0987354395175278*x_118 + 0.161591368879108*x_119 - 0.0348777093810655*x_12 - 0.0059861678082518*x_14 - 0.0828099537687794*x_16 + 0.000309424321131714*x_19 - 0.0124755411665294*x_23 - 0.0443190863845837*x_24 + 0.108476379795899*x_27 - 0.0107675234608749*x_28 - 0.0906106431921044*x_29 - 0.0343987760279601*x_30 - 7.345667476541e-5*x_32 - 0.0629618788895891*x_33 - 0.00449569285805828*x_34 - 0.137468733142865*x_35 + 0.131267527278715*x_36 - 0.0559411623144061*x_37 - 0.0588178494437855*x_38 + 0.0372007995568517*x_39 + 0.0580672671318455*x_4 - 0.163527425944887*x_40 - 0.195748758150227*x_42 + 0.0963324793763847*x_43 + 0.0299033024591502*x_44 - 0.122069724641303*x_45 + 0.134154539633025*x_46 - 0.194748371528248*x_49 + 0.0557959702685885*x_50 + 0.0675281301649325*x_51 - 0.00445569159987547*x_52 - 0.0155903777202569*x_53 - 0.0199862410357492*x_54 - 0.0250431246147573*x_56 - 0.0922726757651664*x_58 - 0.0496605676724373*x_59 - 0.011089168366504*x_6 + 0.00177534404792635*x_61 - 0.0516972774396313*x_62 + 0.0346177811880163*x_63 - 0.023711563675907*x_64 - 0.00408383045494436*x_65 - 0.0121132939896039*x_66 + 9.72858047704834e-5*x_67 + 0.0260746776878709*x_68 - 0.0128072592049261*x_69 + 0.00311583076937527*x_70 + 0.0126127795028816*x_71 + 0.00710801829819896*x_72 + 0.000474232825324244*x_73 + 0.0380699595045252*x_74 + 5.99632285660471e-5*x_75 + 0.0162556976249818*x_76 + 0.0434722768879109*x_77 + 0.000812368372468386*x_78 - 0.0290601366813023*x_79 - 0.103309982261153*x_8 - 0.00950594740509306*x_80 + 0.0519606891580635*x_81 + 0.000170421971082984*x_82 - 0.0172665970557282*x_83 + 9.47537861334338e-5*x_84 - 0.00204806955263161*x_85 + 0.0284274782054771*x_86 - 0.0408691942929279*x_87 + 0.000686206944059491*x_88 - 0.000886423670098085*x_89 - 0.000843195019417029*x_9 + 0.00153275100532109*x_90 + 0.0516870004901156*x_91 + 0.0625830257180534*x_93 - 3.97908740943087e-5*x_95 - 0.0684188613516394*x_96 - 0.156006285088023*x_99 - 7.69883277594659e-5*std::pow(-6.70760011672974*x_18 - 7.31832027435303, 2) - 1.00711729928882*std::sin(0.190880000591278*x_1 - 4.41607999801636) + 0.487373333469684*std::sin(0.228079989552498*x_101 + 1.98055982589722) + 1.07701117709548*std::sin(0.234159991145134*x_102 + 1.95911991596222) + 0.553558283215672*std::sin(0.184880003333092*x_109 - 7.38399982452393) + 1.0278801623156*std::sin(0.240399971604347*x_120 - 1.03391981124878) - 0.442176417191764*std::sin(0.319999933242798*x_13 - 4.28240013122559) + 0.999548167544269*std::sin(0.324719846248627*x_15 + 8.26583957672119) + 0.479007491549918*std::sin(0.384079843759537*x_17 + 1.99359977245331) - 0.509800106747431*std::sin(0.404319852590561*x_2 - 7.38735961914063) - 0.615765802830232*std::sin(0.367359846830368*x_20 + 8.22056007385254) - 0.754233423262356*std::sin(0.347999840974808*x_21 - 1.16127991676331) - 3.62066222052715*std::sin(0.137040033936501*x_22 + 4.94816017150879) - 0.153193189671842*std::sin(0.375839829444885*x_25 - 4.37487983703613) + 0.922781463634877*std::sin(0.195199996232986*x_26 - 1.19399988651276) - 0.333551217015794*std::sin(0.409039855003357*x_3 - 1.17767977714539) + 0.506219835928992*std::sin(0.357599824666977*x_31 + 5.16951990127563) - 0.721861899148784*std::sin(0.267199963331223*x_41 + 1.93695986270905) - 0.808340806131334*std::sin(0.192159995436668*x_47 + 2.00471973419189) + 0.621830690636727*std::sin(0.242559969425201*x_48 + 1.78887987136841) + 1.00821457450851*std::sin(0.338559836149216*x_5 + 2.04775977134705) + 1.57259311825599*std::sin(0.185440003871918*x_55 - 4.38175964355469) - 1.01317586367698*std::sin(0.241599977016449*x_57 - 4.2422399520874) - 0.365612305877423*std::sin(0.489599853754044*x_60 - 7.72096014022827) - 0.271714955019897*std::sin(0.239919975399971*x_7 + 7.77871990203857) - 0.284896161069673*std::sin(0.351359844207764*x_92 - 4.59311962127686) + 0.958727421565349*std::sin(0.279999971389771*x_94 + 1.98743987083435) - 0.455235086743972*std::sin(0.294719934463501*x_97 - 4.42967987060547) + 1.05968703759983*std::sin(0.282159924507141*x_98 + 8.16495990753174)) + 0.00116144842107658*std::sin(0.368399828672409*x_1 + 8.37007999420166) - 0.00844325092775636*std::sin(0.404959857463837*x_1 + 8.39888000488281) + 0.00439255283967571*std::sin(0.341039836406708*x_10 - 1.12095987796783) - 0.00176643637437484*std::sin(0.240799978375435*x_100 + 8.18143939971924) + 0.00771276690255613*std::sin(0.23327998816967*x_101 + 1.97543978691101) - 0.00589024303095937*std::sin(0.229759991168976*x_102 - 4.39823961257935) - 0.000640924275408478*std::sin(0.236399978399277*x_102 - 1.20351994037628) - 0.000423471882836017*std::sin(0.255919963121414*x_108 + 1.94351983070374) - 0.00663128427014126*std::sin(0.272799968719482*x_108 + 1.93503975868225) + 0.00939422233006689*std::sin(0.250639975070953*x_109 - 1.2137598991394) + 0.000180661544249624*std::sin(0.382559835910797*x_11 + 1.82871985435486) - 0.00203397044098549*std::sin(0.211439996957779*x_110 - 7.40647983551025) + 0.00345187907263046*std::sin(0.241679981350899*x_110 + 8.17327976226807) + 0.000178020102354577*std::sin(0.245359972119331*x_110 + 4.95287990570068) + 0.000678134556208633*std::sin(0.268559962511063*x_112 + 1.97895979881287) + 0.000149080515442715*std::sin(0.270159959793091*x_112 - 4.40351963043213) + 0.00208710391920412*std::sin(0.268879950046539*x_113 - 4.22904014587402) + 0.00393012811510422*std::sin(0.229999989271164*x_114 + 1.95623981952667) + 0.00251238871892275*std::sin(0.235119983553886*x_117 - 4.23808002471924) - 0.010828115191746*std::sin(0.235199987888336*x_118 - 7.41671991348267) - 0.000330332095603144*std::sin(0.241999968886375*x_118 + 1.97351980209351) - 0.000697959795787418*std::sin(0.271119952201843*x_12 + 5.15176010131836) - 0.000379362836373588*std::sin(0.279279947280884*x_120 + 1.94519984722137) - 0.000781477063829771*std::sin(0.185840010643005*x_13 - 4.40351963043213) + 0.000502623833192212*std::sin(0.352799862623215*x_13 - 4.33256006240845) - 0.000200343251321008*std::sin(0.295119941234589*x_14 - 1.21431994438171) - 0.00809650064311227*std::sin(0.311599940061569*x_15 - 4.24927997589111) + 0.000945310875296223*std::sin(0.370479851961136*x_15 + 1.83439981937408) + 0.00598295907906531*std::sin(0.353039860725403*x_17 + 5.22735977172852) - 0.000898842894040385*std::sin(0.477439850568771*x_17 + 1.95439982414246) - 0.000207200947704855*std::sin(0.334319829940796*x_18 + 1.80159986019135) - 0.0109491825727389*std::sin(0.107840068638325*x_19 - 1.46535992622375) + 0.000508634803903429*std::sin(0.260959982872009*x_20 + 5.02055978775024) + 0.00776285170431723*std::sin(0.34623983502388*x_20 - 1.14527976512909) + 0.00139593733546383*std::sin(0.293359935283661*x_21 - 4.38455963134766) - 0.000178065876330398*std::sin(0.396319836378098*x_21 - 4.40287971496582) - 0.00115649698516995*std::sin(0.273999959230423*x_22 - 7.55800008773804) - 0.000424637223149937*std::sin(0.342079848051071*x_22 - 1.16143989562988) - 0.000328425263128307*std::sin(0.276719957590103*x_23 - 1.14367985725403) - 0.00042327701428383*std::sin(0.313359916210175*x_23 - 7.38032007217407) + 0.0031127475101277*std::sin(0.339599847793579*x_23 - 4.39879989624023) + 0.000250647303671167*std::sin(0.365439832210541*x_24 + 2.03655982017517) + 0.000319506649468292*std::sin(0.333359837532043*x_25 - 1.14519989490509) - 0.000339024602784648*std::sin(0.261919975280762*x_26 - 7.38695955276489) + 0.00144911136100525*std::sin(0.36999985575676*x_26 + 8.22991943359375) + 0.00873397735378736*std::sin(0.224879994988441*x_27 - 1.18111991882324) - 0.000531071807403842*std::sin(0.375039845705032*x_27 - 1.17775988578796) - 0.00101561518723491*std::sin(0.309839934110641*x_28 + 1.97959983348846) + 0.00820945992439261*std::sin(0.326559841632843*x_29 - 1.16359984874725) + 0.00170734135733351*std::sin(0.360319852828979*x_29 + 8.21487998962402) - 0.00635251713042286*std::sin(0.207359999418259*x_3 + 1.99087977409363) + 0.000434192454764917*std::sin(0.320239931344986*x_3 + 2.06399965286255) + 0.0107956522253864*std::sin(0.213279992341995*x_30 - 1.19399988651276) - 0.00106436156169043*std::sin(0.37391984462738*x_31 + 5.17328023910522) + 0.00026547152095568*std::sin(0.398239821195602*x_31 + 5.2007999420166) + 0.00602063532365854*std::sin(0.291759938001633*x_32 - 1.13471984863281) + 0.000168879710019713*std::sin(0.292239934206009*x_32 + 2.03519988059998) - 0.000688666206443361*std::sin(0.321919858455658*x_32 - 1.19455993175507) - 0.000247559972498121*std::sin(0.336319833993912*x_32 - 4.41016006469727) - 0.0011360541406933*std::sin(0.238239988684654*x_33 + 1.99767982959747) - 0.0075055510299183*std::sin(0.237599983811378*x_34 - 1.19663989543915) - 0.000519889349364397*std::sin(0.240239977836609*x_35 + 1.95999991893768) - 0.000438391428787837*std::sin(0.271359950304031*x_36 + 8.15679931640625) + 0.00162734889954765*std::sin(0.22367998957634*x_37 + 1.97847986221313) + 0.00372166383379031*std::sin(0.248799979686737*x_38 - 1.2339198589325) + 0.000154482198417071*std::sin(0.260879963636398*x_38 + 1.78807997703552) - 0.00210080958038343*std::sin(0.261039972305298*x_38 - 1.20975983142853) + 0.00193274867052769*std::sin(0.221039995551109*x_4 - 4.39103984832764) - 0.000209257586601021*std::sin(0.295199930667877*x_4 - 1.13903987407684) - 0.0117441103153761*std::sin(0.235519990324974*x_40 - 1.21535992622375) + 0.000996316704047434*std::sin(0.235759988427162*x_40 + 1.95503973960876) - 0.00014235890241472*std::sin(0.236879989504814*x_41 + 4.97887992858887) + 0.00216493129981971*std::sin(0.252079963684082*x_41 + 1.95879983901978) - 0.00430206361233068*std::sin(0.282239943742752*x_41 - 4.44271993637085) + 0.000657969491018243*std::sin(0.259679973125458*x_42 + 1.94903981685638) - 0.00903068884895116*std::sin(0.266719967126846*x_42 + 1.95047974586487) - 0.000279947325998931*std::sin(0.145360037684441*x_44 + 4.98343992233276) - 0.0021888199173993*std::sin(0.225679993629456*x_44 - 1.18967986106873) + 0.00540979842134942*std::sin(0.173040017485619*x_46 - 7.38007974624634) - 0.00157779590812453*std::sin(0.294879943132401*x_53 - 4.42799949645996) - 0.00127463153495036*std::sin(0.170560017228127*x_55 - 1.18743991851807) - 0.000677882742985645*std::sin(0.105280071496964*x_57 + 5.14776039123535) - 0.000386394904794042*std::sin(0.234479993581772*x_57 + 5.18336009979248) + 0.00145090043877155*std::sin(0.358479857444763*x_6 + 2.01023983955383) - 0.00100690702920791*std::sin(0.146960034966469*x_60 - 1.22951984405518) - 0.00802938782481927*std::sin(0.400799870491028*x_60 + 8.19935989379883) - 0.00993382310601131*std::sin(0.312239944934845*x_7 - 4.20567989349365) - 0.000177637779209562*std::sin(0.346719831228256*x_7 + 5.02895975112915) + 9.25613303829944e-6*std::sin(0.839039862155914*x_75 + 5.40751981735229) - 0.00090632008679355*std::sin(0.315759927034378*x_8 + 1.9851998090744) + 0.00271431718662771*std::sin(0.398159831762314*x_8 + 7.99560022354126) + 0.000538070223983989*std::sin(0.329119831323624*x_9 + 8.27431964874268) + 0.000123549476953565*std::sin(0.343199849128723*x_91 - 7.38391971588135) - 0.0111518957985375*std::sin(0.371119856834412*x_91 - 7.39224004745483) - 0.00309947426934273*std::sin(0.198400005698204*x_92 - 1.00927984714508) - 0.000770648648779951*std::sin(0.275199949741364*x_92 - 7.39559984207153) - 0.000880010785717249*std::sin(0.287759929895401*x_94 + 8.18183994293213) + 0.000562342783444729*std::sin(0.271839946508408*x_95 + 1.97663974761963) - 0.00378001391705401*std::sin(0.294079929590225*x_95 + 4.97615957260132) - 0.000608825548577385*std::sin(0.286479949951172*x_96 - 1.20391988754272) - 0.000345202857924008*std::sin(0.275359958410263*x_97 - 1.19951987266541) + 0.00722046067421081*std::sin(0.276799947023392*x_97 - 1.19999980926514) + 0.00167029525839651*std::sin(0.247839972376823*x_98 + 1.98023986816406) + 0.000303179378453768*std::sin(0.282799929380417*x_98 - 4.41296005249023) + 0.138161697255983 + 1.3115503354314e-7*std::exp(-4.22904014587402*x_21));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (4.69686636008381e-6*x_1 + 0.000536515204777138*x_10 + 0.000185489188860574*x_100 - 0.000147378429358943*x_101 + 9.92844293770592e-7*x_102 - 0.0019020681453906*x_103 + 0.00168141952606051*x_104 + 0.0026859114245411*x_105 - 0.00301752923134107*x_106 - 0.00173832065060829*x_107 - 0.00168587402613378*x_108 + 7.23268520007629e-5*x_109 + 0.000408409189447526*x_11 - 0.00147270207989367*x_110 + 0.00196936613924923*x_111 - 0.000403219073936247*x_112 + 0.00316125997893011*x_113 + 0.00337885091704369*x_114 - 0.000968374021508603*x_115 + 0.000677237389029822*x_116 - 6.02182762157677e-6*x_117 + 0.00178776199819389*x_118 + 0.00336765314505165*x_119 - 0.000586665280755005*x_12 - 8.35278518533469e-5*x_120 - 9.54181803454057e-6*x_13 - 3.30018598012432e-5*x_14 + 4.38256179618008e-5*x_15 - 0.0018106273438513*x_16 - 2.58434953236516e-5*x_17 + 1.75145127779584e-5*x_18 - 0.000232897595909912*x_19 - 5.93589013981735e-6*x_2 - 0.000184007942749751*x_20 - 4.42430816651729e-5*x_21 + 2.6294336552227e-6*x_22 - 0.00026453298938251*x_23 - 0.000949100495733975*x_24 + 0.000143574081237271*x_25 + 1.30283859153155e-5*x_26 + 0.00202902374590675*x_27 - 0.000276546974763521*x_28 - 0.00192142292193168*x_29 - 3.73778366373674e-6*x_3 - 0.000722313468987179*x_30 - 1.28910875098831e-5*x_31 - 1.54140848650052e-6*x_32 - 0.00127171320014083*x_33 - 0.000164980102810978*x_34 - 0.00301834935552235*x_35 + 0.00272699178339387*x_36 - 0.00120632113373469*x_37 - 0.001231410662655*x_38 + 0.000701733225644303*x_39 + 0.00123574663650478*x_4 - 0.00341758961568796*x_40 - 0.000163270720612801*x_41 - 0.0039975427165518*x_42 + 0.00165227265005917*x_43 + 0.000590842476478499*x_44 - 0.00266510471888172*x_45 + 0.00284888870596973*x_46 - 4.39970492674346e-6*x_47 + 6.21473981671632e-5*x_48 - 0.00415820949883119*x_49 - 3.26781872634462e-5*x_5 + 0.00113875876562036*x_50 + 0.00130195041662019*x_51 - 0.000357079970893454*x_52 - 0.000393195551139618*x_53 - 0.000629471020610541*x_54 + 0.00020982641535161*x_55 - 0.000438652233197089*x_56 + 0.00025178374868685*x_57 - 0.0017684555311066*x_58 - 0.00102806358918244*x_59 - 0.000423568631394552*x_6 - 0.000165900185822293*x_60 + 4.66187150604119e-5*x_61 - 0.00106397805702554*x_62 + 0.00073189685237675*x_63 - 0.000578131530561355*x_64 - 2.0071387429826e-5*x_65 - 0.000222148144541765*x_66 - 4.78385293765163e-5*x_67 + 0.00053471106399636*x_68 - 0.00027282887536881*x_69 - 0.000112639676334412*x_7 + 0.00013127720307762*x_70 + 0.000258612643055227*x_71 + 0.000146479194326781*x_72 + 3.70163514145153e-5*x_73 + 0.000814423476572026*x_74 + 4.48246821887329e-6*x_75 + 0.000352606098909238*x_76 + 0.00094963909266977*x_77 - 1.21481599779139e-6*x_78 - 0.000575552771731347*x_79 - 0.00213546871719327*x_8 - 0.000200315221371949*x_80 + 0.0010904504413414*x_81 - 1.15846419995459e-5*x_82 - 0.000392235657826216*x_83 + 9.17364864201323e-6*x_84 - 9.40293731481963e-5*x_85 + 0.000598576235806568*x_86 - 0.000835557605656391*x_87 + 5.72913381879254e-5*x_88 + 5.51926017908307e-6*x_89 - 2.82133699418639e-5*x_9 + 9.08572803608771e-5*x_90 + 0.00108922534282238*x_91 + 9.81667680830323e-6*x_92 + 0.00122864973821566*x_93 - 3.07677655363826e-5*x_94 + 1.02225640981928e-5*x_95 - 0.0015346192405693*x_96 - 9.1069159939888e-6*x_97 - 4.40983169449998e-6*x_98 - 0.00342375891635531*x_99 + 1.31277921796851e-6*std::pow(-2.61807990074158*x_13 - 4.83735990524292, 2) - 1.61551638634485e-6*std::pow(-6.70760011672974*x_18 - 7.31832027435303, 2) + 2.12008059233588e-9*std::pow(-9.68360042572021*x_27 - 4.91775989532471, 2) - 2.01011794208284e-7*std::pow(-4.46895980834961*x_62 - 9.54120063781738, 2) - 0.0211332619803839*std::sin(0.190880000591278*x_1 - 4.41607999801636) + 0.000489765387816188*std::sin(0.368399828672409*x_1 + 8.37007999420166) - 0.000603311239398529*std::sin(0.404959857463837*x_1 + 8.39888000488281) + 0.000313869209917286*std::sin(0.341039836406708*x_10 - 1.12095987796783) - 0.000744879738306755*std::sin(0.240799978375435*x_100 + 8.18143939971924) + 0.0102269997206295*std::sin(0.228079989552498*x_101 + 1.98055982589722) + 0.000551114612012319*std::sin(0.23327998816967*x_101 + 1.97543978691101) - 0.000420886439805357*std::sin(0.229759991168976*x_102 - 4.39823961257935) + 0.0225999090447886*std::sin(0.234159991145134*x_102 + 1.95911991596222) - 0.00123641045376516*std::sin(0.236399978399277*x_102 - 1.20351994037628) - 1.46154398695493e-5*std::sin(0.255919963121414*x_108 + 1.94351983070374) - 0.000473837431346603*std::sin(0.272799968719482*x_108 + 1.93503975868225) + 0.0116158189605812*std::sin(0.184880003333092*x_109 - 7.38399982452393) + 0.000671262759526214*std::sin(0.250639975070953*x_109 - 1.2137598991394) + 6.23523790773798e-6*std::sin(0.382559835910797*x_11 + 1.82871985435486) - 0.000857694843575186*std::sin(0.211439996957779*x_110 - 7.40647983551025) + 0.000246653505786062*std::sin(0.241679981350899*x_110 + 8.17327976226807) + 6.14407285817806e-6*std::sin(0.245359972119331*x_110 + 4.95287990570068) + 0.00130819300582956*std::sin(0.268559962511063*x_112 + 1.97895979881287) + 5.14527031778911e-6*std::sin(0.270159959793091*x_112 - 4.40351963043213) + 0.000880100434812417*std::sin(0.268879950046539*x_113 - 4.22904014587402) + 0.000280826719992866*std::sin(0.229999989271164*x_114 + 1.95623981952667) + 0.00105943665938058*std::sin(0.235119983553886*x_117 - 4.23808002471924) - 0.000773721360715058*std::sin(0.235199987888336*x_118 - 7.41671991348267) - 1.14008723505724e-5*std::sin(0.241999968886375*x_118 + 1.97351980209351) - 0.00134643798172471*std::sin(0.271119952201843*x_12 + 5.15176010131836) + 0.021568948095713*std::sin(0.240399971604347*x_120 - 1.03391981124878) - 1.30930882273166e-5*std::sin(0.279279947280884*x_120 + 1.94519984722137) - 2.69714035306066e-5*std::sin(0.185840010643005*x_13 - 4.40351963043213) - 0.00927859155299968*std::sin(0.319999933242798*x_13 - 4.28240013122559) + 0.000969614329671474*std::sin(0.352799862623215*x_13 - 4.33256006240845) - 0.000386483239563248*std::sin(0.295119941234589*x_14 - 1.21431994438171) - 0.000578534249376511*std::sin(0.311599940061569*x_15 - 4.24927997589111) + 0.0209744319769329*std::sin(0.324719846248627*x_15 + 8.26583957672119) + 0.000398623424893174*std::sin(0.370479851961136*x_15 + 1.83439981937408) + 0.000427511451234431*std::sin(0.353039860725403*x_17 + 5.22735977172852) + 0.0100514516200242*std::sin(0.384079843759537*x_17 + 1.99359977245331) - 0.000379028573802235*std::sin(0.477439850568771*x_17 + 1.95439982414246) - 7.15120203923107e-6*std::sin(0.334319829940796*x_18 + 1.80159986019135) - 0.00461710615098777*std::sin(0.107840068638325*x_19 - 1.46535992622375) - 0.0106976011842206*std::sin(0.404319852590561*x_2 - 7.38735961914063) + 1.7554698891046e-5*std::sin(0.260959982872009*x_20 + 5.02055978775024) + 0.00055469341407376*std::sin(0.34623983502388*x_20 - 1.14527976512909) - 0.0129211761519359*std::sin(0.367359846830368*x_20 + 8.22056007385254) + 0.000588645847774122*std::sin(0.293359935283661*x_21 - 4.38455963134766) - 0.0158267686787039*std::sin(0.347999840974808*x_21 - 1.16127991676331) - 0.000343507836106603*std::sin(0.396319836378098*x_21 - 4.40287971496582) - 0.075975661725711*std::sin(0.137040033936501*x_22 + 4.94816017150879) - 0.000487677441521673*std::sin(0.273999959230423*x_22 - 7.55800008773804) - 0.000819169942386374*std::sin(0.342079848051071*x_22 - 1.16143989562988) - 0.000633566934804605*std::sin(0.276719957590103*x_23 - 1.14367985725403) - 1.4608714299984e-5*std::sin(0.313359916210175*x_23 - 7.38032007217407) + 0.000222420910421628*std::sin(0.339599847793579*x_23 - 4.39879989624023) + 8.65068200216064e-6*std::sin(0.365439832210541*x_24 + 2.03655982017517) + 0.000616361989407106*std::sin(0.333359837532043*x_25 - 1.14519989490509) - 0.00321459259336706*std::sin(0.375839829444885*x_25 - 4.37487983703613) + 0.0193635661262188*std::sin(0.195199996232986*x_26 - 1.19399988651276) - 1.17008800280032e-5*std::sin(0.261919975280762*x_26 - 7.38695955276489) + 0.000611068537209527*std::sin(0.36999985575676*x_26 + 8.22991943359375) + 0.000624085052934979*std::sin(0.224879994988441*x_27 - 1.18111991882324) - 0.00022394501984883*std::sin(0.375039845705032*x_27 - 1.17775988578796) - 0.000428269699301024*std::sin(0.309839934110641*x_28 + 1.97959983348846) + 0.000586605738021575*std::sin(0.326559841632843*x_29 - 1.16359984874725) + 0.000719960255517819*std::sin(0.360319852828979*x_29 + 8.21487998962402) - 0.000453918166835086*std::sin(0.207359999418259*x_3 + 1.99087977409363) + 0.000837602990891799*std::sin(0.320239931344986*x_3 + 2.06399965286255) - 0.00699920978226505*std::sin(0.409039855003357*x_3 - 1.17767977714539) + 0.000771401724281585*std::sin(0.213279992341995*x_30 - 1.19399988651276) + 0.0106224730921699*std::sin(0.357599824666977*x_31 + 5.16951990127563) - 0.000448825314648721*std::sin(0.37391984462738*x_31 + 5.17328023910522) + 9.16231563149144e-6*std::sin(0.398239821195602*x_31 + 5.2007999420166) + 0.00043020360168879*std::sin(0.291759938001633*x_32 - 1.13471984863281) + 5.82860715674915e-6*std::sin(0.292239934206009*x_32 + 2.03519988059998) - 0.001328509668726*std::sin(0.321919858455658*x_32 - 1.19455993175507) - 0.000104392329214173*std::sin(0.336319833993912*x_32 - 4.41016006469727) - 0.000479057000465933*std::sin(0.238239988684654*x_33 + 1.99767982959747) - 0.000536308032649245*std::sin(0.237599983811378*x_34 - 1.19663989543915) - 1.79431311320304e-5*std::sin(0.240239977836609*x_35 + 1.95999991893768) - 1.51303636120171e-5*std::sin(0.271359950304031*x_36 + 8.15679931640625) + 0.000686228635241866*std::sin(0.22367998957634*x_37 + 1.97847986221313) + 0.000265930935773499*std::sin(0.248799979686737*x_38 - 1.2339198589325) + 0.000298012436682568*std::sin(0.260879963636398*x_38 + 1.78807997703552) - 0.00088587990666924*std::sin(0.261039972305298*x_38 - 1.20975983142853) + 0.000815011140395536*std::sin(0.221039995551109*x_4 - 4.39103984832764) - 0.000403679931514962*std::sin(0.295199930667877*x_4 - 1.13903987407684) - 0.000839173656051157*std::sin(0.235519990324974*x_40 - 1.21535992622375) + 0.00192199989204653*std::sin(0.235759988427162*x_40 + 1.95503973960876) - 4.91328483063201e-6*std::sin(0.236879989504814*x_41 + 4.97887992858887) + 0.000912919074502485*std::sin(0.252079963684082*x_41 + 1.95879983901978) - 0.015147487426878*std::sin(0.267199963331223*x_41 + 1.93695986270905) - 0.000307403315634519*std::sin(0.282239943742752*x_41 - 4.44271993637085) + 0.00126929247052629*std::sin(0.259679973125458*x_42 + 1.94903981685638) - 0.00064528652869624*std::sin(0.266719967126846*x_42 + 1.95047974586487) - 0.000540047886543359*std::sin(0.145360037684441*x_44 + 4.98343992233276) - 0.000922992546419917*std::sin(0.225679993629456*x_44 - 1.18967986106873) + 0.000386556341675353*std::sin(0.173040017485619*x_46 - 7.38007974624634) - 0.0169621533037625*std::sin(0.192159995436668*x_47 + 2.00471973419189) + 0.0130484412311742*std::sin(0.242559969425201*x_48 + 1.78887987136841) + 0.0211562871083395*std::sin(0.338559836149216*x_5 + 2.04775977134705) - 0.000665332881610981*std::sin(0.294879943132401*x_53 - 4.42799949645996) - 0.00245889852355327*std::sin(0.170560017228127*x_55 - 1.18743991851807) + 0.0329991574766129*std::sin(0.185440003871918*x_55 - 4.38175964355469) - 0.00130770723159188*std::sin(0.105280071496964*x_57 + 5.14776039123535) - 1.33357885749038e-5*std::sin(0.234479993581772*x_57 + 5.18336009979248) - 0.0212603943695608*std::sin(0.241599977016449*x_57 - 4.2422399520874) + 0.000611822964483389*std::sin(0.358479857444763*x_6 + 2.01023983955383) - 0.0019424297450566*std::sin(0.146960034966469*x_60 - 1.22951984405518) - 0.000573738712926117*std::sin(0.400799870491028*x_60 + 8.19935989379883) - 0.0076719768877131*std::sin(0.489599853754044*x_60 - 7.72096014022827) - 0.00570164302855151*std::sin(0.239919975399971*x_7 + 7.77871990203857) - 0.000709819852724194*std::sin(0.312239944934845*x_7 - 4.20567989349365) - 6.13087759973665e-6*std::sin(0.346719831228256*x_7 + 5.02895975112915) + 3.9031725429347e-6*std::sin(0.839039862155914*x_75 + 5.40751981735229) - 0.000382181593895143*std::sin(0.315759927034378*x_8 + 1.9851998090744) + 0.000193951130908797*std::sin(0.398159831762314*x_8 + 7.99560022354126) + 0.00103799415206979*std::sin(0.329119831323624*x_9 + 8.27431964874268) + 4.26410825492362e-6*std::sin(0.343199849128723*x_91 - 7.38391971588135) - 0.00079685705582207*std::sin(0.371119856834412*x_91 - 7.39224004745483) - 0.000221472472975278*std::sin(0.198400005698204*x_92 - 1.00927984714508) - 0.00148666243749975*std::sin(0.275199949741364*x_92 - 7.39559984207153) - 0.00597823631203899*std::sin(0.351359844207764*x_92 - 4.59311962127686) + 0.0201178529869618*std::sin(0.279999971389771*x_94 + 1.98743987083435) - 0.000371087356035778*std::sin(0.287759929895401*x_94 + 8.18183994293213) + 0.00108481847657796*std::sin(0.271839946508408*x_95 + 1.97663974761963) - 0.000270100332295531*std::sin(0.294079929590225*x_95 + 4.97615957260132) - 0.0011744886278502*std::sin(0.286479949951172*x_96 - 1.20391988754272) - 1.19141124057548e-5*std::sin(0.275359958410263*x_97 - 1.19951987266541) + 0.000515936943679588*std::sin(0.276799947023392*x_97 - 1.19999980926514) - 0.0095526135412596*std::sin(0.294719934463501*x_97 - 4.42967987060547) + 0.000704338470956664*std::sin(0.247839972376823*x_98 + 1.98023986816406) + 0.0222363808055211*std::sin(0.282159924507141*x_98 + 8.16495990753174) + 0.000584864963411408*std::sin(0.282799929380417*x_98 - 4.41296005249023) - 0.064475446444293 + 4.52660160929924e-9*std::exp(-4.22904014587402*x_21));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (6.44811555382707e-5*x_1 + 0.000256393242339021*x_10 + 0.000374420111577286*x_100 - 1.42446818862092e-5*x_101 - 0.000118463466850363*x_102 - 0.00121222853744953*x_103 + 0.000724395258684062*x_104 + 0.00141912847589829*x_105 - 0.00162611616979239*x_106 - 0.00101234916379564*x_107 - 0.000807233850872357*x_108 - 0.000100198220500936*x_109 + 0.000273669484022539*x_11 - 0.000781029278330584*x_110 + 0.00126363113521995*x_111 + 1.55718184074126e-6*x_112 + 0.00171990926450755*x_113 + 0.00131570380077556*x_114 - 0.000585036962609572*x_115 + 0.000585565718340692*x_116 - 0.000633037004491983*x_117 + 0.00117174872978425*x_118 + 0.00144280320657339*x_119 - 0.000459243801424015*x_12 + 8.68927341161407e-5*x_120 + 0.00011309005632963*x_14 - 9.31724086047622e-6*x_15 - 0.000829056260634145*x_16 + 3.74676001219813e-5*x_17 - 0.000162834930649615*x_18 + 9.0108820899566e-5*x_19 + 1.02540912858095e-5*x_2 + 5.41163942064798e-5*x_20 - 0.000114232829839379*x_21 - 3.36347189256038e-5*x_22 - 0.000133787860988751*x_23 - 0.000450676438139817*x_24 + 0.000226479905409482*x_25 - 5.92988397134848e-6*x_26 + 0.00126672229391441*x_27 - 0.000100697523679799*x_28 - 0.000958816452940403*x_29 + 3.63995902775989e-5*x_3 - 6.82025925319576e-5*x_30 - 2.85367342581465e-5*x_31 - 7.87750307664176e-7*x_32 - 0.000235170047971102*x_33 - 0.000256659418965977*x_34 - 0.00163206215763825*x_35 + 0.00111010764309237*x_36 - 0.000529524508304103*x_37 - 0.00100918720068824*x_38 - 5.68801008732338e-5*x_39 + 0.000683126839541432*x_4 - 0.00149297068835982*x_40 + 6.82972961184798e-5*x_41 - 0.00193150054669519*x_42 + 0.00055481430076631*x_43 + 0.000229285587386873*x_44 - 0.00172696130669533*x_45 + 0.00149229556808625*x_46 + 3.16666497852836e-5*x_47 + 0.000179152924555476*x_48 - 0.00221675738735311*x_49 + 0.000161474679092222*x_5 + 0.00074023300801971*x_50 - 5.42906238352033e-5*x_51 + 6.90611776499645e-5*x_52 - 0.000235648790873712*x_53 - 0.000259970806840156*x_54 - 5.48142617874005e-5*x_55 - 0.000799981885432197*x_56 + 0.000311936521235463*x_57 - 0.000983903991471251*x_58 - 0.000249231822936547*x_59 + 0.000192644008222151*x_6 - 2.85181509507924e-5*x_60 + 4.00545313879966e-5*x_61 - 0.000460092734423308*x_62 + 0.000407125260497794*x_63 - 0.000267089866724744*x_64 + 7.01605184711606e-5*x_65 - 0.000105426841381512*x_66 - 8.94856034848853e-5*x_67 + 0.000257759171202515*x_68 - 0.00013237481797865*x_69 + 2.81512453842864e-5*x_7 - 1.47749475722852e-5*x_70 + 0.000254297441526615*x_71 + 3.6156417420135e-5*x_72 + 9.35957343807025e-5*x_73 + 0.000395587677521732*x_74 - 5.3873820861638e-5*x_75 + 0.000206073228314447*x_76 + 0.000461800515661547*x_77 + 3.37621781663465e-5*x_78 - 0.000373924948879106*x_79 - 0.000963536066279776*x_8 - 9.87238141973042e-5*x_80 + 0.000480107393163979*x_81 - 0.000158762387310309*x_82 - 0.000133390629456094*x_83 + 4.70373677582551e-6*x_84 - 0.000163449763206567*x_85 + 0.000343120582458598*x_86 - 0.000469759916439079*x_87 + 1.06384916236892e-5*x_88 + 8.67237946488582e-5*x_89 + 3.84269789496205e-6*x_9 + 4.60789366647116e-5*x_90 + 0.000551642031099652*x_91 - 1.6029490004404e-5*x_92 + 0.000457312016834831*x_93 - 9.4549564956965e-5*x_94 + 1.98090526553473e-5*x_95 - 0.000701608578330981*x_96 + 4.42586621169939e-6*x_97 - 3.32166896418064e-6*x_98 - 0.00207828580606363*x_99 + 3.38951265098963e-6*std::pow(-2.61807990074158*x_13 - 4.83735990524292, 2) - 8.25623798963848e-7*std::pow(-6.70760011672974*x_18 - 7.31832027435303, 2) - 2.84703182669621e-7*std::pow(-9.68360042572021*x_27 - 4.91775989532471, 2) + 8.40846538854174e-8*std::pow(-4.46895980834961*x_62 - 9.54120063781738, 2) - 1.31941498970887e-8*std::exp(0.101902658163051*x_10 + 0.0357969804585219*x_101 + 0.00012976467438486*x_102 + 0.0373063586103233*x_103 + 0.0154632390646468*x_104 + 0.033645622203404*x_105 - 0.092599335710026*x_106 + 0.140027884335831*x_107 - 0.00158895203355277*x_108 + 0.00928957701693015*x_109 - 0.0688657119501569*x_11 - 0.0655297435102508*x_111 + 0.00139213132889508*x_112 + 0.109073556895772*x_114 - 0.132139376231458*x_115 - 0.0403838915067817*x_116 - 0.0166186720731663*x_118 + 0.055122379340699*x_119 + 0.169817433053469*x_12 - 0.088427656683899*x_120 - 0.0111861000490796*x_13 + 0.110964025783374*x_14 + 0.000553020252651977*x_16 - 0.00521119940587947*x_18 - 0.0168807458031712*x_2 - 0.0640533333820943*x_20 - 0.00322074447887648*x_23 - 0.00420549952899429*x_24 + 0.0779073538987281*x_25 - 0.00406412904488319*x_3 - 0.0248985620213585*x_30 + 0.153889116884416*x_34 + 0.0866202666863591*x_35 + 0.133760569130866*x_36 - 0.0310078446720884*x_39 + 0.0185192318145219*x_40 + 0.130457499982005*x_42 - 0.118879712515679*x_43 - 0.00355058517942996*x_45 + 0.0995546035510559*x_46 + 0.0120169426714463*x_47 + 0.0195000482839771*x_48 - 0.0290992117980211*x_49 + 0.0113203397233452*x_5 - 0.097901438046876*x_50 + 0.103710748587182*x_51 + 0.00728782410616229*x_52 - 0.156297165037514*x_54 + 0.130910108823038*x_55 + 0.0556118501671336*x_56 + 0.153537841843743*x_57 + 0.127791465341046*x_58 + 0.00111129139830532*x_59 - 0.19473769021896*x_60 - 0.0507689791870175*x_61 - 0.00161739073348744*x_62 + 0.000980678164583592*x_63 - 0.0224354697452618*x_64 + 0.0133295319779744*x_65 - 0.00437479807248431*x_66 - 0.00116621088334808*x_67 + 0.00269622104784786*x_68 - 0.0221677018866071*x_69 - 0.0531550786369281*x_7 + 0.0005688263694041*x_70 - 0.000950699060146169*x_71 + 0.00123666493294889*x_72 + 0.000724698354100285*x_73 - 0.00513089602157735*x_74 - 0.000750672585598825*x_76 - 0.00146151382355162*x_77 - 0.00355661291245786*x_78 - 0.000822360474723977*x_79 + 0.00138240250603901*x_80 - 0.000731567744091774*x_81 + 0.00274377920269644*x_82 + 0.00368698177546252*x_83 + 0.0307450994801219*x_84 + 0.000643834297209313*x_85 + 0.00229392255451331*x_86 - 0.0396618248913423*x_87 + 0.0502209777043389*x_88 + 0.0347925799972604*x_89 - 0.0233499010457478*x_9 - 0.0280486606089353*x_90 - 0.00199914372855076*x_91 + 0.0113683882090732*x_92 + 0.00902170247482998*x_93 + 0.0131396635392887*x_95 - 0.102003289669152*x_96 + 0.00172742870716408*x_97 + 0.0322825920660258*x_99 + 0.574163603713277*std::sin(0.368399828672409*x_1 + 8.37007999420166) - 0.873240219743174*std::sin(0.240799978375435*x_100 + 8.18143939971924) - 1.00549604876988*std::sin(0.211439996957779*x_110 - 7.40647983551025) + 1.03176265585997*std::sin(0.268879950046539*x_113 - 4.22904014587402) + 1.24200277395715*std::sin(0.235119983553886*x_117 - 4.23808002471924) + 0.467315714533694*std::sin(0.370479851961136*x_15 + 1.83439981937408) - 0.444344204916071*std::sin(0.477439850568771*x_17 + 1.95439982414246) - 5.41274326917687*std::sin(0.107840068638325*x_19 - 1.46535992622375) + 0.690083516877049*std::sin(0.293359935283661*x_21 - 4.38455963134766) - 0.571715854650886*std::sin(0.273999959230423*x_22 - 7.55800008773804) + 0.716370168591212*std::sin(0.36999985575676*x_26 + 8.22991943359375) - 0.262536068960232*std::sin(0.375039845705032*x_27 - 1.17775988578796) - 0.502070746584003*std::sin(0.309839934110641*x_28 + 1.97959983348846) + 0.844026517842835*std::sin(0.360319852828979*x_29 + 8.21487998962402) - 0.526168582972979*std::sin(0.37391984462738*x_31 + 5.17328023910522) - 0.122381608485831*std::sin(0.336319833993912*x_32 - 4.41016006469727) - 0.561609906731146*std::sin(0.238239988684654*x_33 + 1.99767982959747) + 0.804482137740585*std::sin(0.22367998957634*x_37 + 1.97847986221313) - 1.03853806807044*std::sin(0.261039972305298*x_38 - 1.20975983142853) + 0.955456929127855*std::sin(0.221039995551109*x_4 - 4.39103984832764) + 1.07023672712384*std::sin(0.252079963684082*x_41 + 1.95879983901978) - 1.08204609765492*std::sin(0.225679993629456*x_44 - 1.18967986106873) - 0.779985549158631*std::sin(0.294879943132401*x_53 - 4.42799949645996) + 0.717254601613789*std::sin(0.358479857444763*x_6 + 2.01023983955383) + 0.00457578193338395*std::sin(0.839039862155914*x_75 + 5.40751981735229) - 0.448040565304453*std::sin(0.315759927034378*x_8 + 1.9851998090744) - 0.435034526600518*std::sin(0.287759929895401*x_94 + 8.18183994293213) + 0.825712728540452*std::sin(0.247839972376823*x_98 + 1.98023986816406)) - 0.0108003386336549*std::sin(0.190880000591278*x_1 - 4.41607999801636) - 0.00155771134280296*std::sin(0.404959857463837*x_1 + 8.39888000488281) + 0.000810390386448271*std::sin(0.341039836406708*x_10 - 1.12095987796783) + 0.00522659778181038*std::sin(0.228079989552498*x_101 + 1.98055982589722) + 0.00142294296252776*std::sin(0.23327998816967*x_101 + 1.97543978691101) - 0.00108670208426811*std::sin(0.229759991168976*x_102 - 4.39823961257935) + 0.0115498814617488*std::sin(0.234159991145134*x_102 + 1.95911991596222) + 0.00051719922940159*std::sin(0.236399978399277*x_102 - 1.20351994037628) + 0.00196269059865906*std::sin(0.255919963121414*x_108 + 1.94351983070374) - 0.00122341818493067*std::sin(0.272799968719482*x_108 + 1.93503975868225) + 0.0059363660185519*std::sin(0.184880003333092*x_109 - 7.38399982452393) + 0.00173315785656113*std::sin(0.250639975070953*x_109 - 1.2137598991394) - 0.00083732292227598*std::sin(0.382559835910797*x_11 + 1.82871985435486) + 0.000636843702908811*std::sin(0.241679981350899*x_110 + 8.17327976226807) - 0.000825080472695633*std::sin(0.245359972119331*x_110 + 4.95287990570068) - 0.00054722637815234*std::sin(0.268559962511063*x_112 + 1.97895979881287) - 0.000690952429103701*std::sin(0.270159959793091*x_112 - 4.40351963043213) + 0.000725076773857468*std::sin(0.229999989271164*x_114 + 1.95623981952667) - 0.0019976994643036*std::sin(0.235199987888336*x_118 - 7.41671991348267) + 0.00153101002629423*std::sin(0.241999968886375*x_118 + 1.97351980209351) + 0.000563224521811846*std::sin(0.271119952201843*x_12 + 5.15176010131836) + 0.0110229998389106*std::sin(0.240399971604347*x_120 - 1.03391981124878) + 0.00175825574875157*std::sin(0.279279947280884*x_120 + 1.94519984722137) + 0.00362195873779019*std::sin(0.185840010643005*x_13 - 4.40351963043213) - 0.00474190548097989*std::sin(0.319999933242798*x_13 - 4.28240013122559) - 0.000405596525486896*std::sin(0.352799862623215*x_13 - 4.33256006240845) + 0.000161668670035936*std::sin(0.295119941234589*x_14 - 1.21431994438171) - 0.0014937387265522*std::sin(0.311599940061569*x_15 - 4.24927997589111) + 0.0107191671692568*std::sin(0.324719846248627*x_15 + 8.26583957672119) + 0.00110380744345147*std::sin(0.353039860725403*x_17 + 5.22735977172852) + 0.00513688238743388*std::sin(0.384079843759537*x_17 + 1.99359977245331) + 0.000960326691278919*std::sin(0.334319829940796*x_18 + 1.80159986019135) - 0.00546710278160624*std::sin(0.404319852590561*x_2 - 7.38735961914063) - 0.00235740030975947*std::sin(0.260959982872009*x_20 + 5.02055978775024) + 0.00143218320239187*std::sin(0.34623983502388*x_20 - 1.14527976512909) - 0.00660348024434408*std::sin(0.367359846830368*x_20 + 8.22056007385254) - 0.00808840875418041*std::sin(0.347999840974808*x_21 - 1.16127991676331) + 0.000143691755101811*std::sin(0.396319836378098*x_21 - 4.40287971496582) - 0.0388280273682002*std::sin(0.137040033936501*x_22 + 4.94816017150879) + 0.000342664575231462*std::sin(0.342079848051071*x_22 - 1.16143989562988) + 0.000265025525671839*std::sin(0.276719957590103*x_23 - 1.14367985725403) + 0.00196178742966283*std::sin(0.313359916210175*x_23 - 7.38032007217407) + 0.000574276679124595*std::sin(0.339599847793579*x_23 - 4.39879989624023) - 0.00116169012969661*std::sin(0.365439832210541*x_24 + 2.03655982017517) - 0.000257828575440316*std::sin(0.333359837532043*x_25 - 1.14519989490509) - 0.00164284570029129*std::sin(0.375839829444885*x_25 - 4.37487983703613) + 0.00989592006725946*std::sin(0.195199996232986*x_26 - 1.19399988651276) + 0.00157129771200705*std::sin(0.261919975280762*x_26 - 7.38695955276489) + 0.00161134801135112*std::sin(0.224879994988441*x_27 - 1.18111991882324) + 0.00151457879813491*std::sin(0.326559841632843*x_29 - 1.16359984874725) - 0.00117198790774767*std::sin(0.207359999418259*x_3 + 1.99087977409363) - 0.000350375249670921*std::sin(0.320239931344986*x_3 + 2.06399965286255) - 0.00357700746276743*std::sin(0.409039855003357*x_3 - 1.17767977714539) + 0.00199171031020264*std::sin(0.213279992341995*x_30 - 1.19399988651276) + 0.00542870791214402*std::sin(0.357599824666977*x_31 + 5.16951990127563) - 0.00123039682092234*std::sin(0.398239821195602*x_31 + 5.2007999420166) + 0.00111075840512005*std::sin(0.291759938001633*x_32 - 1.13471984863281) - 0.000782716946731293*std::sin(0.292239934206009*x_32 + 2.03519988059998) + 0.000555724981801354*std::sin(0.321919858455658*x_32 - 1.19455993175507) - 0.00138471331402168*std::sin(0.237599983811378*x_34 - 1.19663989543915) + 0.00240956242834097*std::sin(0.240239977836609*x_35 + 1.95999991893768) + 0.00203183911539125*std::sin(0.271359950304031*x_36 + 8.15679931640625) + 0.000686616804072081*std::sin(0.248799979686737*x_38 - 1.2339198589325) - 0.000124660708048*std::sin(0.260879963636398*x_38 + 1.78807997703552) + 0.000168862167792768*std::sin(0.295199930667877*x_4 - 1.13903987407684) - 0.00216669313821423*std::sin(0.235519990324974*x_40 - 1.21535992622375) - 0.000803986135873624*std::sin(0.235759988427162*x_40 + 1.95503973960876) + 0.000659799365033613*std::sin(0.236879989504814*x_41 + 4.97887992858887) - 0.00774125612085658*std::sin(0.267199963331223*x_41 + 1.93695986270905) - 0.000793695857641428*std::sin(0.282239943742752*x_41 - 4.44271993637085) - 0.000530954009360167*std::sin(0.259679973125458*x_42 + 1.94903981685638) - 0.00166608887663055*std::sin(0.266719967126846*x_42 + 1.95047974586487) + 0.00022590584696984*std::sin(0.145360037684441*x_44 + 4.98343992233276) + 0.000998063948983311*std::sin(0.173040017485619*x_46 - 7.38007974624634) - 0.00866865701123888*std::sin(0.192159995436668*x_47 + 2.00471973419189) + 0.00666852017775753*std::sin(0.242559969425201*x_48 + 1.78887987136841) + 0.0108121058269653*std::sin(0.338559836149216*x_5 + 2.04775977134705) + 0.00102857462720872*std::sin(0.170560017228127*x_55 - 1.18743991851807) + 0.0168645084560793*std::sin(0.185440003871918*x_55 - 4.38175964355469) + 0.000547023175356191*std::sin(0.105280071496964*x_57 + 5.14776039123535) + 0.0017908476990967*std::sin(0.234479993581772*x_57 + 5.18336009979248) - 0.0108653107546503*std::sin(0.241599977016449*x_57 - 4.2422399520874) + 0.000812532087746984*std::sin(0.146960034966469*x_60 - 1.22951984405518) - 0.00148135695569201*std::sin(0.400799870491028*x_60 + 8.19935989379883) - 0.00392083098452982*std::sin(0.489599853754044*x_60 - 7.72096014022827) - 0.00291387460836537*std::sin(0.239919975399971*x_7 + 7.77871990203857) - 0.00183270982492805*std::sin(0.312239944934845*x_7 - 4.20567989349365) + 0.000823308496626423*std::sin(0.346719831228256*x_7 + 5.02895975112915) + 0.000500769514699067*std::sin(0.398159831762314*x_8 + 7.99560022354126) - 0.000434200288374315*std::sin(0.329119831323624*x_9 + 8.27431964874268) - 0.00057262218984184*std::sin(0.343199849128723*x_91 - 7.38391971588135) - 0.00205743436121643*std::sin(0.371119856834412*x_91 - 7.39224004745483) - 0.000571827873812114*std::sin(0.198400005698204*x_92 - 1.00927984714508) + 0.000621881402501633*std::sin(0.275199949741364*x_92 - 7.39559984207153) - 0.00305523002847194*std::sin(0.351359844207764*x_92 - 4.59311962127686) + 0.0102814049739673*std::sin(0.279999971389771*x_94 + 1.98743987083435) - 0.000453787234181132*std::sin(0.271839946508408*x_95 + 1.97663974761963) - 0.00069738192136293*std::sin(0.294079929590225*x_95 + 4.97615957260132) + 0.000491296892075963*std::sin(0.286479949951172*x_96 - 1.20391988754272) + 0.00159993244259867*std::sin(0.275359958410263*x_97 - 1.19951987266541) + 0.00133211645475396*std::sin(0.276799947023392*x_97 - 1.19999980926514) - 0.00488194681813937*std::sin(0.294719934463501*x_97 - 4.42967987060547) + 0.0113640971710591*std::sin(0.282159924507141*x_98 + 8.16495990753174) - 0.000244653146905391*std::sin(0.282799929380417*x_98 - 4.41296005249023) + 0.0701989717138876 - 6.07872120288127e-7*std::exp(-4.22904014587402*x_21));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000120224522706811*x_1 - 0.000169679692216812*x_10 + 0.000369895697647503*x_100 - 0.000448623389119247*x_101 - 0.000203139578570611*x_102 - 0.000508103527526586*x_103 + 0.000208472743250558*x_104 + 0.000137408218973176*x_105 - 0.000641862986194792*x_106 - 0.00107711493818829*x_107 - 0.000355775767831514*x_108 - 7.31928256769622e-5*x_109 + 0.000214787426268683*x_11 - 0.000233688163017284*x_110 + 0.000314810052262107*x_111 - 9.3922249347075e-5*x_112 + 0.000590646130061891*x_113 - 0.000674503082990249*x_114 - 0.00084713505199795*x_115 + 0.000527056841759156*x_116 - 0.000591985517428665*x_117 + 9.442958707061e-5*x_118 + 0.000411002499037832*x_119 - 0.000685960201902359*x_12 + 0.000171281204801632*x_120 + 2.7009763368293e-5*x_13 + 1.62081319429097e-5*x_14 + 6.70768822763811e-5*x_15 - 0.000455121525241667*x_16 + 1.56401400834893e-5*x_17 + 9.85913563009769e-5*x_18 - 0.000253126581138263*x_19 + 0.000147876860192931*x_2 + 2.59656822709743e-6*x_20 - 6.79055879785743e-5*x_22 - 3.91726183271126e-5*x_23 - 0.000181975209963965*x_24 - 0.000142145485475886*x_25 + 1.55020260762055e-5*x_26 + 0.000117622777221107*x_27 - 7.18302071317291e-5*x_28 - 0.000356798141391189*x_29 + 7.21344348775635e-5*x_3 + 0.000489106167174474*x_30 - 1.85986460634809e-6*x_31 - 2.76440493757365e-7*x_32 - 2.86974280336672e-5*x_33 - 0.00113146920644651*x_34 - 0.000874651464963952*x_35 + 0.00014437240732101*x_36 - 1.32665463408533e-5*x_37 - 0.000869265273380577*x_38 - 0.000508357861056486*x_39 + 0.000245113026936963*x_4 - 0.000213766688670869*x_40 - 0.000191913424532258*x_41 - 0.000764518307978565*x_42 - 7.96489962530426e-5*x_43 + 0.000117943578658117*x_44 - 0.00140893029759945*x_45 + 0.000260045544366515*x_46 + 0.000416819169176528*x_47 - 1.71790231150145e-5*x_48 - 0.000684102870080992*x_49 + 9.20136991768544e-5*x_5 - 0.000116758510966341*x_50 - 0.00081066159755005*x_51 - 0.000366196302615118*x_52 - 0.000162290829463685*x_53 + 0.000128116943871056*x_54 - 0.000833913778687922*x_55 - 0.000984331238810238*x_56 - 0.00037072981272138*x_57 - 0.00102855378866512*x_58 - 0.000121599240017001*x_59 - 0.000354579158396935*x_6 + 0.000421383135039832*x_60 - 5.50351012072469e-5*x_61 - 0.000128564808900993*x_62 + 0.000192843541895878*x_63 - 9.51025649631566e-5*x_64 + 0.000254511226719817*x_65 - 0.000153361233485171*x_66 + 6.43964711183365e-7*x_67 + 2.98530933430562e-5*x_68 + 0.000241046485583818*x_69 + 4.92431475071715e-5*x_7 + 4.02792060829859e-5*x_70 + 0.000236206527824955*x_71 - 5.21254711261883e-5*x_72 - 2.23613649496567e-6*x_73 + 0.000175399485200596*x_74 - 8.87743044234311e-5*x_75 + 0.000190239454982147*x_76 + 0.000229219742378996*x_77 + 3.47776338348391e-6*x_78 - 6.85360884672341e-5*x_79 - 7.81401444246972e-5*x_8 - 4.69540483568057e-5*x_80 + 6.23827175882776e-5*x_81 - 0.000188312172438334*x_82 + 2.04000948877949e-5*x_83 - 0.000108410889636414*x_84 - 0.000193288364274458*x_85 + 0.000165547388870173*x_86 - 5.97817587209902e-7*x_87 - 0.000109238557681682*x_88 + 7.27523448110587e-5*x_89 + 3.40915337287104e-5*x_9 + 0.000135575364222692*x_90 + 0.000206787947850013*x_91 - 5.48946727548645e-5*x_92 + 0.000278679768609494*x_93 + 1.86912314537104e-5*x_94 + 2.76995865866918e-6*x_95 + 9.44392064681325e-5*x_96 - 1.66075753300241e-5*x_97 + 1.3546658501473e-5*x_98 - 0.00124990078452152*x_99 - 2.89731211048535e-7*std::pow(-6.70760011672974*x_18 - 7.31832027435303, 2) - 4.87452214038934e-7*std::pow(-9.68360042572021*x_27 - 4.91775989532471, 2) - 2.36275442731528e-7*std::pow(-4.46895980834961*x_62 - 9.54120063781738, 2) - 0.00379009810035783*std::sin(0.190880000591278*x_1 - 4.41607999801636) - 0.00138636548957543*std::sin(0.368399828672409*x_1 + 8.37007999420166) + 0.00210851070484391*std::sin(0.240799978375435*x_100 + 8.18143939971924) + 0.00183413863176904*std::sin(0.228079989552498*x_101 + 1.98055982589722) + 0.00405313067232214*std::sin(0.234159991145134*x_102 + 1.95911991596222) - 0.00145331485902041*std::sin(0.236399978399277*x_102 - 1.20351994037628) + 0.00336040457580682*std::sin(0.255919963121414*x_108 + 1.94351983070374) + 0.0020832133447957*std::sin(0.184880003333092*x_109 - 7.38399982452393) - 0.00143361555884893*std::sin(0.382559835910797*x_11 + 1.82871985435486) + 0.00242785333814912*std::sin(0.211439996957779*x_110 - 7.40647983551025) - 0.00141265474942895*std::sin(0.245359972119331*x_110 + 4.95287990570068) + 0.00153769027756845*std::sin(0.268559962511063*x_112 + 1.97895979881287) - 0.00118300852208252*std::sin(0.270159959793091*x_112 - 4.40351963043213) - 0.00249127623253399*std::sin(0.268879950046539*x_113 - 4.22904014587402) - 0.00299891837907407*std::sin(0.235119983553886*x_117 - 4.23808002471924) + 0.00262130623210824*std::sin(0.241999968886375*x_118 + 1.97351980209351) - 0.00158264459802249*std::sin(0.271119952201843*x_12 + 5.15176010131836) + 0.00386823526250508*std::sin(0.240399971604347*x_120 - 1.03391981124878) + 0.00301038312792661*std::sin(0.279279947280884*x_120 + 1.94519984722137) + 0.00620130688156822*std::sin(0.185840010643005*x_13 - 4.40351963043213) - 0.00166404846784479*std::sin(0.319999933242798*x_13 - 4.28240013122559) + 0.00113971449249678*std::sin(0.352799862623215*x_13 - 4.33256006240845) - 0.000454284281655141*std::sin(0.295119941234589*x_14 - 1.21431994438171) + 0.00376161308489179*std::sin(0.324719846248627*x_15 + 8.26583957672119) - 0.00112837242760745*std::sin(0.370479851961136*x_15 + 1.83439981937408) + 0.00180265534616726*std::sin(0.384079843759537*x_17 + 1.99359977245331) + 0.0010729058184888*std::sin(0.477439850568771*x_17 + 1.95439982414246) + 0.00164421545089578*std::sin(0.334319829940796*x_18 + 1.80159986019135) + 0.0130695161166395*std::sin(0.107840068638325*x_19 - 1.46535992622375) - 0.00191853760978001*std::sin(0.404319852590561*x_2 - 7.38735961914063) - 0.00403620356328015*std::sin(0.260959982872009*x_20 + 5.02055978775024) - 0.00231731974142458*std::sin(0.367359846830368*x_20 + 8.22056007385254) - 0.00166626370347386*std::sin(0.293359935283661*x_21 - 4.38455963134766) - 0.00283841680284082*std::sin(0.347999840974808*x_21 - 1.16127991676331) - 0.000403769671215103*std::sin(0.396319836378098*x_21 - 4.40287971496582) - 0.0136256869122869*std::sin(0.137040033936501*x_22 + 4.94816017150879) + 0.00138045519709905*std::sin(0.273999959230423*x_22 - 7.55800008773804) - 0.000962877534485108*std::sin(0.342079848051071*x_22 - 1.16143989562988) - 0.000744714053275416*std::sin(0.276719957590103*x_23 - 1.14367985725403) + 0.00335885822243368*std::sin(0.313359916210175*x_23 - 7.38032007217407) - 0.00198897820683974*std::sin(0.365439832210541*x_24 + 2.03655982017517) + 0.000724490831513842*std::sin(0.333359837532043*x_25 - 1.14519989490509) - 0.000576513994519817*std::sin(0.375839829444885*x_25 - 4.37487983703613) + 0.00347271591386397*std::sin(0.195199996232986*x_26 - 1.19399988651276) + 0.00269028446204959*std::sin(0.261919975280762*x_26 - 7.38695955276489) - 0.00172973499726071*std::sin(0.36999985575676*x_26 + 8.22991943359375) + 0.000633915043415079*std::sin(0.375039845705032*x_27 - 1.17775988578796) + 0.00121229132583093*std::sin(0.309839934110641*x_28 + 1.97959983348846) - 0.00203797180639154*std::sin(0.360319852828979*x_29 + 8.21487998962402) + 0.000984544306396005*std::sin(0.320239931344986*x_3 + 2.06399965286255) - 0.0012552577886174*std::sin(0.409039855003357*x_3 - 1.17767977714539) + 0.00190506392837535*std::sin(0.357599824666977*x_31 + 5.16951990127563) + 0.00127047754405697*std::sin(0.37391984462738*x_31 + 5.17328023910522) - 0.00210661380347491*std::sin(0.398239821195602*x_31 + 5.2007999420166) - 0.0013401223866637*std::sin(0.292239934206009*x_32 + 2.03519988059998) - 0.00156157110774356*std::sin(0.321919858455658*x_32 - 1.19455993175507) + 0.000295500511467834*std::sin(0.336319833993912*x_32 - 4.41016006469727) + 0.00135605355034755*std::sin(0.238239988684654*x_33 + 1.99767982959747) + 0.00412551250585358*std::sin(0.240239977836609*x_35 + 1.95999991893768) + 0.00347879664035121*std::sin(0.271359950304031*x_36 + 8.15679931640625) - 0.00194248863134203*std::sin(0.22367998957634*x_37 + 1.97847986221313) + 0.000350292980041334*std::sin(0.260879963636398*x_38 + 1.78807997703552) + 0.00250763602546668*std::sin(0.261039972305298*x_38 - 1.20975983142853) - 0.00230702974683859*std::sin(0.221039995551109*x_4 - 4.39103984832764) - 0.000474497802062798*std::sin(0.295199930667877*x_4 - 1.13903987407684) + 0.00225917776223962*std::sin(0.235759988427162*x_40 + 1.95503973960876) + 0.00112967005950312*std::sin(0.236879989504814*x_41 + 4.97887992858887) - 0.00258417505840651*std::sin(0.252079963684082*x_41 + 1.95879983901978) - 0.00271659261003312*std::sin(0.267199963331223*x_41 + 1.93695986270905) + 0.00149196539243185*std::sin(0.259679973125458*x_42 + 1.94903981685638) - 0.000634788888840231*std::sin(0.145360037684441*x_44 + 4.98343992233276) + 0.00261268975988185*std::sin(0.225679993629456*x_44 - 1.18967986106873) - 0.00304203984572953*std::sin(0.192159995436668*x_47 + 2.00471973419189) + 0.0023401438154133*std::sin(0.242559969425201*x_48 + 1.78887987136841) + 0.00379422749097469*std::sin(0.338559836149216*x_5 + 2.04775977134705) + 0.0018833395929796*std::sin(0.294879943132401*x_53 - 4.42799949645996) - 0.00289026491989048*std::sin(0.170560017228127*x_55 - 1.18743991851807) + 0.00591816086800093*std::sin(0.185440003871918*x_55 - 4.38175964355469) - 0.00153711928359504*std::sin(0.105280071496964*x_57 + 5.14776039123535) + 0.00306618516781465*std::sin(0.234479993581772*x_57 + 5.18336009979248) - 0.00381289837734115*std::sin(0.241599977016449*x_57 - 4.2422399520874) - 0.00173187053391335*std::sin(0.358479857444763*x_6 + 2.01023983955383) - 0.00228319163955417*std::sin(0.146960034966469*x_60 - 1.22951984405518) - 0.00137591371625927*std::sin(0.489599853754044*x_60 - 7.72096014022827) - 0.00102254855078644*std::sin(0.239919975399971*x_7 + 7.77871990203857) + 0.00140962087516712*std::sin(0.346719831228256*x_7 + 5.02895975112915) - 1.10486037764145e-5*std::sin(0.839039862155914*x_75 + 5.40751981735229) + 0.0010818309862395*std::sin(0.315759927034378*x_8 + 1.9851998090744) + 0.00122009023798325*std::sin(0.329119831323624*x_9 + 8.27431964874268) - 0.000980410375566944*std::sin(0.343199849128723*x_91 - 7.38391971588135) - 0.00174746873434011*std::sin(0.275199949741364*x_92 - 7.39559984207153) - 0.00107215356109155*std::sin(0.351359844207764*x_92 - 4.59311962127686) + 0.0036079918216098*std::sin(0.279999971389771*x_94 + 1.98743987083435) + 0.00105042683052742*std::sin(0.287759929895401*x_94 + 8.18183994293213) + 0.00127512898855681*std::sin(0.271839946508408*x_95 + 1.97663974761963) - 0.0013805300411423*std::sin(0.286479949951172*x_96 - 1.20391988754272) + 0.00273931118066374*std::sin(0.275359958410263*x_97 - 1.19951987266541) - 0.00171319233489779*std::sin(0.294719934463501*x_97 - 4.42967987060547) - 0.00199375164804647*std::sin(0.247839972376823*x_98 + 1.98023986816406) + 0.00398793450476632*std::sin(0.282159924507141*x_98 + 8.16495990753174) + 0.000687468258827641*std::sin(0.282799929380417*x_98 - 4.41296005249023) + 0.122696235775948*std::sin(-0.0448579282926204*x_100 + 0.0771525232203885*x_103 + 0.0107866145639484*x_104 + 0.00106178259674131*x_105 - 0.000258219593703866*x_106 - 0.0297367070487746*x_107 - 0.000657989897822553*x_11 - 0.0145041645080578*x_111 - 0.0624944957031189*x_112 - 0.0109656627207899*x_113 - 0.00590185967016661*x_115 - 0.00223141416656106*x_116 + 0.0629421626809035*x_117 + 0.0557442231885654*x_119 + 0.000173436586057241*x_12 - 0.0172983115810147*x_120 + 0.000439963628257295*x_14 - 0.0102373406793955*x_16 + 0.0318288255704629*x_18 + 0.00490372839462626*x_19 + 0.00717444571884558*x_2 + 0.0274974660173398*x_21 - 0.00145065831439602*x_22 - 0.00375105118035728*x_24 - 0.0480541420469131*x_25 + 9.94370844558598e-5*x_26 + 0.00383468441364582*x_28 + 0.00702852160757649*x_31 - 0.0631075551191121*x_33 + 0.0506878824550838*x_35 + 0.0739213973073786*x_36 + 0.0134317959050912*x_37 + 0.0159560210600639*x_39 - 0.0108041740265632*x_4 + 0.0591176438198446*x_43 + 0.0227610860202626*x_44 - 0.00448809772013272*x_45 + 0.0409766674182512*x_47 - 0.0357692370325921*x_48 + 0.0282439574343354*x_49 - 0.00773333347894774*x_5 - 0.08857829611264*x_50 + 0.0895541857410658*x_51 - 0.00211072220617124*x_52 + 0.0136813821730182*x_53 + 0.00492696617770306*x_54 - 0.0596070828320884*x_55 + 0.00848728731772323*x_56 - 0.0750875549901018*x_57 - 0.0483143270600837*x_58 - 0.0436120460893496*x_59 - 0.0477769778927793*x_6 - 0.0313486785124279*x_61 - 0.0139732512488247*x_62 - 0.000569511648138505*x_63 + 0.00769107072512783*x_64 + 0.000234649292592681*x_65 - 0.0223444105900666*x_66 + 0.0241086797044478*x_67 + 0.00038613359245831*x_68 + 0.0194632766797505*x_69 - 0.00107615136559455*x_70 - 0.000889999127527774*x_71 + 3.52094903108016e-5*x_72 - 0.0200739341267596*x_73 + 0.000369538706938205*x_74 - 9.84964424408524e-5*x_75 + 0.00483294909369821*x_76 - 0.000361079099994129*x_77 - 0.00220211504989614*x_78 + 0.00782930124898343*x_79 - 0.000934989868608084*x_80 - 0.000312469502023902*x_81 + 0.0125289140839494*x_82 + 0.00661487752575816*x_83 - 0.00046619589784305*x_84 + 0.0154661193999928*x_85 - 0.000209158536211711*x_86 + 0.000563692927401514*x_87 + 0.00035984836058071*x_88 + 0.000442684758441215*x_89 - 0.00578913308854621*x_9 - 0.0142659145123927*x_90 + 0.0595800765657957*x_93 + 0.0235014661769442*x_94 + 0.00711932675560666*x_96 + 0.00270413090889094*x_98 + 0.0441976946914329*x_99 - 0.00081590387865714*std::pow(-2.61807990074158*x_13 - 4.83735990524292, 2) + 0.374963263833838*std::sin(0.404959857463837*x_1 + 8.39888000488281) - 0.195072486109929*std::sin(0.341039836406708*x_10 - 1.12095987796783) - 0.342522598903802*std::sin(0.23327998816967*x_101 + 1.97543978691101) + 0.261584639679771*std::sin(0.229759991168976*x_102 - 4.39823961257935) + 0.294494148594834*std::sin(0.272799968719482*x_108 + 1.93503975868225) - 0.417195733752596*std::sin(0.250639975070953*x_109 - 1.2137598991394) - 0.153297332331823*std::sin(0.241679981350899*x_110 + 8.17327976226807) - 0.174536286785001*std::sin(0.229999989271164*x_114 + 1.95623981952667) + 0.480874659323284*std::sin(0.235199987888336*x_118 - 7.41671991348267) + 0.359564145700556*std::sin(0.311599940061569*x_15 - 4.24927997589111) - 0.265702142796171*std::sin(0.353039860725403*x_17 + 5.22735977172852) - 0.344746855993577*std::sin(0.34623983502388*x_20 - 1.14527976512909) - 0.138236560286416*std::sin(0.339599847793579*x_23 - 4.39879989624023) - 0.387874372424601*std::sin(0.224879994988441*x_27 - 1.18111991882324) - 0.364580647182226*std::sin(0.326559841632843*x_29 - 1.16359984874725) + 0.282114149770589*std::sin(0.207359999418259*x_3 + 1.99087977409363) - 0.479432984792457*std::sin(0.213279992341995*x_30 - 1.19399988651276) - 0.267375338081086*std::sin(0.291759938001633*x_32 - 1.13471984863281) + 0.33332017905542*std::sin(0.237599983811378*x_34 - 1.19663989543915) - 0.165278425330561*std::sin(0.248799979686737*x_38 - 1.2339198589325) + 0.521553838960493*std::sin(0.235519990324974*x_40 - 1.21535992622375) + 0.191053875705309*std::sin(0.282239943742752*x_41 - 4.44271993637085) + 0.401051276865271*std::sin(0.266719967126846*x_42 + 1.95047974586487) - 0.240248180482698*std::sin(0.173040017485619*x_46 - 7.38007974624634) + 0.356583677441641*std::sin(0.400799870491028*x_60 + 8.19935989379883) + 0.441159307717957*std::sin(0.312239944934845*x_7 - 4.20567989349365) - 0.120542340869249*std::sin(0.398159831762314*x_8 + 7.99560022354126) + 0.495253698170693*std::sin(0.371119856834412*x_91 - 7.39224004745483) + 0.137647098036749*std::sin(0.198400005698204*x_92 - 1.00927984714508) + 0.167869742093824*std::sin(0.294079929590225*x_95 + 4.97615957260132) - 0.32065936733985*std::sin(0.276799947023392*x_97 - 1.19999980926514) - 0.0481254711459744) + 0.0222979975350271 - 1.04076325423743e-6*std::exp(-4.22904014587402*x_21));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.66089999754336e-5*x_1 + 0.001506155420406*x_10 - 6.42126740441141e-5*x_100 + 0.000920655800560207*x_101 - 4.48752518784203e-5*x_102 + 0.00181564384204632*x_103 - 0.000837442108177689*x_104 - 0.000889479006460036*x_105 + 0.000200621553684213*x_106 + 0.00355415653805935*x_107 + 0.00107767378847492*x_108 + 8.88611401051734e-6*x_109 - 0.00142405081065177*x_11 + 0.000861221517997845*x_110 - 0.00209729453328231*x_111 + 0.00033279484547394*x_112 - 0.00186419785872137*x_113 - 0.0001391168058033*x_114 - 0.00154813858139545*x_115 - 0.0010209132137407*x_116 - 0.000261813188393534*x_117 - 0.00103872361158243*x_118 - 0.0011823228057198*x_119 + 0.00333504075603755*x_12 - 0.00145256235153532*x_120 - 0.00019241048468156*x_13 + 0.0020567300736111*x_14 - 8.00442759619883e-5*x_15 + 0.00123549857299911*x_16 + 5.95001362706928e-5*x_17 - 0.000229070128112978*x_18 + 0.000441136780147784*x_19 - 0.00030985950383764*x_2 - 0.000855250425201893*x_20 - 1.57713802922269e-5*x_22 + 0.000104716751648201*x_23 + 0.000537556609028507*x_24 + 0.00135074943277423*x_25 - 2.51311795475731e-5*x_26 - 0.000921110984964533*x_27 + 0.000227524153112303*x_28 + 0.00120288689651708*x_29 - 5.54320996309189e-5*x_3 + 9.26808775402533e-5*x_30 + 3.01512790176853e-6*x_31 + 9.42773670206389e-7*x_32 + 0.00096733380768626*x_33 + 0.00297680662937355*x_34 + 0.00349446689531733*x_35 + 0.000659261644325913*x_36 + 0.000785433027406139*x_37 + 0.000604411611858675*x_38 - 0.00111396064120192*x_39 - 0.000739084466264725*x_4 + 0.00252099381487541*x_40 + 0.000311121314452746*x_41 + 0.00482299289666918*x_42 - 0.00306951328977963*x_43 - 0.000382535433378095*x_44 + 0.00152577272364398*x_45 + 0.000100439723356126*x_46 + 0.000194896441800616*x_47 + 0.000368174455667696*x_48 + 0.00199711645292994*x_49 + 0.00034004188703273*x_5 - 0.00232818610054651*x_50 + 0.00086457404002288*x_51 + 0.000700744346089941*x_52 + 0.000272449392592263*x_53 - 0.00232152820081556*x_54 + 0.0021314996412173*x_55 + 0.000994544745387747*x_56 + 0.00264098215074933*x_57 + 0.00334042249491364*x_58 + 0.000795409559899987*x_59 + 0.000652946617017209*x_6 - 0.00336099508683887*x_60 - 0.000941960086731449*x_61 + 0.000650103006819561*x_62 - 0.000421040712135452*x_63 + 1.13673484237088e-5*x_64 + 0.000230590746665665*x_65 + 5.42465317210342e-5*x_66 + 5.82346579353086e-9*x_67 - 0.000271441946174259*x_68 - 0.000264418662184006*x_69 - 0.000786072693210829*x_7 - 0.000161557741868954*x_70 - 0.000122219974425073*x_71 - 7.89044785172502e-5*x_72 + 1.85564955849286e-5*x_73 - 0.000616978276727303*x_74 - 2.72461119813523e-5*x_75 - 0.000236353472465376*x_76 - 0.000651796151160446*x_77 - 3.27376261514666e-5*x_78 + 0.000264434824433728*x_79 + 0.00132496377885901*x_8 + 0.000151678649153633*x_80 - 0.000710039772298857*x_81 - 1.3800835004292e-6*x_82 + 0.000354622123118662*x_83 + 0.000562826908386356*x_84 + 5.42631145277942e-5*x_85 - 0.000310595229489682*x_86 - 0.000267948162706739*x_87 + 0.000855770302990743*x_88 + 0.000656016908323206*x_89 - 0.000395256011599021*x_9 - 0.000617624329359306*x_90 - 0.000709831421741342*x_91 + 0.000189171827205947*x_92 - 0.000641326137257877*x_93 - 1.11066660275016e-5*x_94 + 0.000234570948065977*x_95 - 0.000851895535840458*x_96 + 4.98748294111407e-5*x_97 + 3.14627277777302e-6*x_98 + 0.00265818369590874*x_99 + 9.8810038102926e-7*std::pow(-6.70760011672974*x_18 - 7.31832027435303, 2) - 1.13212983949446e-7*std::pow(-9.68360042572021*x_27 - 4.91775989532471, 2) + 3.83039000500882e-7*std::pow(-4.46895980834961*x_62 - 9.54120063781738, 2) + 0.0129257644129838*std::sin(0.190880000591278*x_1 - 4.41607999801636) + 0.00987610487947253*std::sin(0.368399828672409*x_1 + 8.37007999420166) - 0.0150204783782567*std::sin(0.240799978375435*x_100 + 8.18143939971924) - 0.00625515309293991*std::sin(0.228079989552498*x_101 + 1.98055982589722) - 0.0138228116577057*std::sin(0.234159991145134*x_102 + 1.95911991596222) + 0.00235604794377549*std::sin(0.236399978399277*x_102 - 1.20351994037628) + 0.000780469179024132*std::sin(0.255919963121414*x_108 + 1.94351983070374) - 0.00710459840452967*std::sin(0.184880003333092*x_109 - 7.38399982452393) - 0.000332963705116489*std::sin(0.382559835910797*x_11 + 1.82871985435486) - 0.0172953917129612*std::sin(0.211439996957779*x_110 - 7.40647983551025) - 0.000328095462215776*std::sin(0.245359972119331*x_110 + 4.95287990570068) - 0.00249283353441432*std::sin(0.268559962511063*x_112 + 1.97895979881287) - 0.00027475908605041*std::sin(0.270159959793091*x_112 - 4.40351963043213) + 0.0177471998122067*std::sin(0.268879950046539*x_113 - 4.22904014587402) + 0.0213635095935514*std::sin(0.235119983553886*x_117 - 4.23808002471924) + 0.000608810241979019*std::sin(0.241999968886375*x_118 + 1.97351980209351) + 0.00256571143393636*std::sin(0.271119952201843*x_12 + 5.15176010131836) - 0.0131922436763356*std::sin(0.240399971604347*x_120 - 1.03391981124878) + 0.000699175112817143*std::sin(0.279279947280884*x_120 + 1.94519984722137) + 0.00144028160346502*std::sin(0.185840010643005*x_13 - 4.40351963043213) + 0.00567507697627079*std::sin(0.319999933242798*x_13 - 4.28240013122559) - 0.00184765329403437*std::sin(0.352799862623215*x_13 - 4.33256006240845) + 0.000736465013785486*std::sin(0.295119941234589*x_14 - 1.21431994438171) - 0.0128286190121353*std::sin(0.324719846248627*x_15 + 8.26583957672119) + 0.0080382298332953*std::sin(0.370479851961136*x_15 + 1.83439981937408) - 0.00614778238066289*std::sin(0.384079843759537*x_17 + 1.99359977245331) - 0.00764310022780267*std::sin(0.477439850568771*x_17 + 1.95439982414246) + 0.000381876483664563*std::sin(0.334319829940796*x_18 + 1.80159986019135) - 0.0931038119907454*std::sin(0.107840068638325*x_19 - 1.46535992622375) + 0.00654298767599818*std::sin(0.404319852590561*x_2 - 7.38735961914063) - 0.000937426553959265*std::sin(0.260959982872009*x_20 + 5.02055978775024) + 0.00790299571517231*std::sin(0.367359846830368*x_20 + 8.22056007385254) + 0.0118700264945327*std::sin(0.293359935283661*x_21 - 4.38455963134766) + 0.00968014703785933*std::sin(0.347999840974808*x_21 - 1.16127991676331) + 0.000654573025054226*std::sin(0.396319836378098*x_21 - 4.40287971496582) + 0.0464690924429288*std::sin(0.137040033936501*x_22 + 4.94816017150879) - 0.00983400150283482*std::sin(0.273999959230423*x_22 - 7.55800008773804) + 0.00156097326133469*std::sin(0.342079848051071*x_22 - 1.16143989562988) + 0.00120729654900997*std::sin(0.276719957590103*x_23 - 1.14367985725403) + 0.000780110031451157*std::sin(0.313359916210175*x_23 - 7.38032007217407) - 0.000461949194857406*std::sin(0.365439832210541*x_24 + 2.03655982017517) - 0.0011745115817662*std::sin(0.333359837532043*x_25 - 1.14519989490509) + 0.00196614543387355*std::sin(0.375839829444885*x_25 - 4.37487983703613) - 0.0118433630442408*std::sin(0.195199996232986*x_26 - 1.19399988651276) + 0.000624830748224145*std::sin(0.261919975280762*x_26 - 7.38695955276489) + 0.0123221793784499*std::sin(0.36999985575676*x_26 + 8.22991943359375) - 0.0045158448479268*std::sin(0.375039845705032*x_27 - 1.17775988578796) - 0.00863604609924882*std::sin(0.309839934110641*x_28 + 1.97959983348846) + 0.0145179777285822*std::sin(0.360319852828979*x_29 + 8.21487998962402) - 0.00159609844641903*std::sin(0.320239931344986*x_3 + 2.06399965286255) + 0.00428093574984237*std::sin(0.409039855003357*x_3 - 1.17767977714539) - 0.00649703698369401*std::sin(0.357599824666977*x_31 + 5.16951990127563) - 0.00905054948819009*std::sin(0.37391984462738*x_31 + 5.17328023910522) - 0.000489270594843245*std::sin(0.398239821195602*x_31 + 5.2007999420166) - 0.000311249492528784*std::sin(0.292239934206009*x_32 + 2.03519988059998) + 0.00253154805004767*std::sin(0.321919858455658*x_32 - 1.19455993175507) - 0.00210506829918844*std::sin(0.336319833993912*x_32 - 4.41016006469727) - 0.00966017055828111*std::sin(0.238239988684654*x_33 + 1.99767982959747) + 0.000958168960272963*std::sin(0.240239977836609*x_35 + 1.95999991893768) + 0.00080796627210726*std::sin(0.271359950304031*x_36 + 8.15679931640625) + 0.0138377805813618*std::sin(0.22367998957634*x_37 + 1.97847986221313) - 0.000567879045771032*std::sin(0.260879963636398*x_38 + 1.78807997703552) - 0.0178637426950357*std::sin(0.261039972305298*x_38 - 1.20975983142853) + 0.0164346760729154*std::sin(0.221039995551109*x_4 - 4.39103984832764) + 0.000769234253635566*std::sin(0.295199930667877*x_4 - 1.13903987407684) - 0.00366247622688981*std::sin(0.235759988427162*x_40 + 1.95503973960876) + 0.000262370986593736*std::sin(0.236879989504814*x_41 + 4.97887992858887) + 0.0184089867323195*std::sin(0.252079963684082*x_41 + 1.95879983901978) + 0.00926467736548181*std::sin(0.267199963331223*x_41 + 1.93695986270905) - 0.00241870643047893*std::sin(0.259679973125458*x_42 + 1.94903981685638) + 0.00102909087249795*std::sin(0.145360037684441*x_44 + 4.98343992233276) - 0.0186121180021722*std::sin(0.225679993629456*x_44 - 1.18967986106873) + 0.0103745838075002*std::sin(0.192159995436668*x_47 + 2.00471973419189) - 0.00798083502051767*std::sin(0.242559969425201*x_48 + 1.78887987136841) - 0.012939847301835*std::sin(0.338559836149216*x_5 + 2.04775977134705) - 0.0134164183137781*std::sin(0.294879943132401*x_53 - 4.42799949645996) + 0.00468556602116098*std::sin(0.170560017228127*x_55 - 1.18743991851807) - 0.0201833174531017*std::sin(0.185440003871918*x_55 - 4.38175964355469) + 0.00249190786495694*std::sin(0.105280071496964*x_57 + 5.14776039123535) + 0.000712135389259106*std::sin(0.234479993581772*x_57 + 5.18336009979248) + 0.013003522560935*std::sin(0.241599977016449*x_57 - 4.2422399520874) + 0.0123373923826065*std::sin(0.358479857444763*x_6 + 2.01023983955383) + 0.00370140643249381*std::sin(0.146960034966469*x_60 - 1.22951984405518) + 0.0046924211664287*std::sin(0.489599853754044*x_60 - 7.72096014022827) + 0.0034873033146703*std::sin(0.239919975399971*x_7 + 7.77871990203857) + 0.000327390831180741*std::sin(0.346719831228256*x_7 + 5.02895975112915) + 7.87073614339768e-5*std::sin(0.839039862155914*x_75 + 5.40751981735229) - 0.00770668078677906*std::sin(0.315759927034378*x_8 + 1.9851998090744) - 0.00197795479663544*std::sin(0.329119831323624*x_9 + 8.27431964874268) - 0.000227704749134784*std::sin(0.343199849128723*x_91 - 7.38391971588135) + 0.00283291682652241*std::sin(0.275199949741364*x_92 - 7.39559984207153) + 0.00365647642310435*std::sin(0.351359844207764*x_92 - 4.59311962127686) - 0.0123047084944048*std::sin(0.279999971389771*x_94 + 1.98743987083435) - 0.00748296580123169*std::sin(0.287759929895401*x_94 + 8.18183994293213) - 0.00206718111556555*std::sin(0.271839946508408*x_95 + 1.97663974761963) + 0.00223805250773118*std::sin(0.286479949951172*x_96 - 1.20391988754272) + 0.000636217425620824*std::sin(0.275359958410263*x_97 - 1.19951987266541) + 0.00584267740007252*std::sin(0.294719934463501*x_97 - 4.42967987060547) + 0.0142029648947467*std::sin(0.247839972376823*x_98 + 1.98023986816406) - 0.0136004664096035*std::sin(0.282159924507141*x_98 + 8.16495990753174) - 0.00111449227094088*std::sin(0.282799929380417*x_98 - 4.41296005249023) + 0.0971207842230797*std::sin(-0.0446193691012445*x_100 + 0.0767422179688395*x_103 + 0.0107292502106222*x_104 + 0.00105613592496362*x_105 - 0.000256846354684231*x_106 - 0.0295785641059828*x_107 - 0.000654490638183674*x_11 - 0.0144270298322419*x_111 - 0.0621621433870884*x_112 - 0.0109073461704912*x_113 - 0.00587047295829385*x_115 - 0.00221954727079791*x_116 + 0.0626074296246941*x_117 + 0.0554477695333498*x_119 + 0.000172514232009704*x_12 - 0.0172063173365186*x_120 + 0.000437623855303287*x_14 - 0.0101828974224893*x_16 + 0.0316595565208312*x_18 + 0.00487764985009522*x_19 + 0.0071362912602158*x_2 + 0.0273512315944036*x_21 - 0.00144294356055836*x_22 - 0.00373110269476163*x_24 - 0.0477985850538617*x_25 + 9.89082675585249e-5*x_26 + 0.00381429115769932*x_28 + 0.00699114318875309*x_31 - 0.0627719424884814*x_33 + 0.050418318952905*x_35 + 0.0735282755240454*x_36 + 0.01336036419855*x_37 + 0.0158711652580563*x_39 - 0.0107467162901638*x_4 + 0.0588032499581015*x_43 + 0.0226400401654382*x_44 - 0.0044642295433425*x_45 + 0.0407587491813498*x_47 - 0.0355790124594249*x_48 + 0.0280937530913519*x_49 - 0.00769220679629437*x_5 - 0.0881072273963977*x_50 + 0.0890779271409058*x_51 - 0.00209949716297622*x_52 + 0.0136086231403939*x_53 + 0.004900764052192*x_54 - 0.0592900860820838*x_55 + 0.00844215102907692*x_56 - 0.0746882314572809*x_57 - 0.0480573863757048*x_58 - 0.0433801126308658*x_59 - 0.0475228948879169*x_6 - 0.0311819629354658*x_61 - 0.0138989400256878*x_62 - 0.000566482925158414*x_63 + 0.00765016880025442*x_64 + 0.000233401402919028*x_65 - 0.022225580659104*x_66 + 0.0239804672043538*x_67 + 0.000384080093309195*x_68 + 0.0193597689226388*x_69 - 0.0010704282791894*x_70 - 0.00088526601834798*x_71 + 3.50222425297067e-5*x_72 - 0.0199671788289719*x_73 + 0.000367573461139642*x_74 - 9.79726279769115e-5*x_75 + 0.00480724696095073*x_76 - 0.000359158843277067*x_77 - 0.00219040396992399*x_78 + 0.00778766419961252*x_79 - 0.000930017493924509*x_80 - 0.000310807756273046*x_81 + 0.0124622839981107*x_82 + 0.00657969890976632*x_83 - 0.0004637166189141*x_84 + 0.0153838689466567*x_85 - 0.00020804620906761*x_86 + 0.000560695148991686*x_87 + 0.000357934649065589*x_88 + 0.00044033051423004*x_89 - 0.00575834586851763*x_9 - 0.0141900468751689*x_90 + 0.059263223437962*x_93 + 0.0233764829023991*x_94 + 0.00708146542543377*x_96 + 0.00268975005566045*x_98 + 0.0439626466919469*x_99 - 0.000811564815821619*std::pow(-2.61807990074158*x_13 - 4.83735990524292, 2) + 0.372969169669872*std::sin(0.404959857463837*x_1 + 8.39888000488281) - 0.194035070065155*std::sin(0.341039836406708*x_10 - 1.12095987796783) - 0.34070102761568*std::sin(0.23327998816967*x_101 + 1.97543978691101) + 0.260193504990909*std::sin(0.229759991168976*x_102 - 4.39823961257935) + 0.292927997668393*std::sin(0.272799968719482*x_108 + 1.93503975868225) - 0.414977042861651*std::sin(0.250639975070953*x_109 - 1.2137598991394) - 0.152482080958585*std::sin(0.241679981350899*x_110 + 8.17327976226807) - 0.173608084413068*std::sin(0.229999989271164*x_114 + 1.95623981952667) + 0.478317317193415*std::sin(0.235199987888336*x_118 - 7.41671991348267) + 0.357651945670128*std::sin(0.311599940061569*x_15 - 4.24927997589111) - 0.264289110791687*std::sin(0.353039860725403*x_17 + 5.22735977172852) - 0.342913455871781*std::sin(0.34623983502388*x_20 - 1.14527976512909) - 0.137501403686553*std::sin(0.339599847793579*x_23 - 4.39879989624023) - 0.385811615624121*std::sin(0.224879994988441*x_27 - 1.18111991882324) - 0.362641768868102*std::sin(0.326559841632843*x_29 - 1.16359984874725) + 0.280613836982937*std::sin(0.207359999418259*x_3 + 1.99087977409363) - 0.476883309639717*std::sin(0.213279992341995*x_30 - 1.19399988651276) - 0.265953407847697*std::sin(0.291759938001633*x_32 - 1.13471984863281) + 0.331547547206128*std::sin(0.237599983811378*x_34 - 1.19663989543915) - 0.164399457241764*std::sin(0.248799979686737*x_38 - 1.2339198589325) + 0.518780160665102*std::sin(0.235519990324974*x_40 - 1.21535992622375) + 0.190037831054291*std::sin(0.282239943742752*x_41 - 4.44271993637085) + 0.398918443897927*std::sin(0.266719967126846*x_42 + 1.95047974586487) - 0.238970515333037*std::sin(0.173040017485619*x_46 - 7.38007974624634) + 0.354687327855601*std::sin(0.400799870491028*x_60 + 8.19935989379883) + 0.438813176014534*std::sin(0.312239944934845*x_7 - 4.20567989349365) - 0.119901283993489*std::sin(0.398159831762314*x_8 + 7.99560022354126) + 0.492619886796462*std::sin(0.371119856834412*x_91 - 7.39224004745483) + 0.136915076259267*std::sin(0.198400005698204*x_92 - 1.00927984714508) + 0.166976993109316*std::sin(0.294079929590225*x_95 + 4.97615957260132) - 0.318954067021906*std::sin(0.276799947023392*x_97 - 1.19999980926514) - 0.135295441680809) - 0.108444096296827 - 2.41721978490684e-7*std::exp(-4.22904014587402*x_21));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000125952264703245*x_1 - 0.000433637753840117*x_10 + 0.000130730209234199*x_100 + 0.000123892659479319*x_101 + 0.000208405452180216*x_102 - 0.00261096421339191*x_103 + 0.00132428590078567*x_104 + 0.00264290804432885*x_105 - 0.00150820547058673*x_106 - 0.0022072074409725*x_107 - 0.00140910088794548*x_108 - 4.97120652121977e-5*x_109 + 0.00112490758168806*x_11 - 0.0014450376078097*x_110 + 0.00307352792038091*x_111 + 0.000154720998900594*x_112 + 0.00305689656376361*x_113 + 0.0033516822384883*x_114 + 0.00185099353966503*x_115 + 0.000756135006778619*x_116 + 1.28737474423915e-5*x_117 + 0.00248934624861096*x_118 + 0.00216646938176782*x_119 - 0.00200603807136879*x_12 + 0.000999048515077018*x_120 + 9.70465490829946e-5*x_13 - 0.00140075570076777*x_14 - 8.41138643516207e-5*x_15 - 0.00133889838411008*x_16 - 7.49886840510497e-6*x_17 - 0.000392406184365436*x_18 + 0.000296942960483018*x_19 - 4.41292826334857e-5*x_2 + 0.000756475115245407*x_20 - 0.000279960902286394*x_21 + 8.49200359499679e-5*x_22 - 0.000215449436905486*x_23 - 0.000756506240745545*x_24 - 0.000234128533495691*x_25 - 2.14796796889621e-5*x_26 + 0.00250000751674915*x_27 - 0.000201796381512146*x_28 - 0.00174468269646282*x_29 - 2.91225535268133e-5*x_3 - 0.00103977714274067*x_30 - 6.91041567259037e-5*x_31 - 1.43310227858921e-6*x_32 - 0.00078378177943139*x_33 - 0.000586351324122341*x_34 - 0.00375388374848936*x_35 + 0.000683075056481458*x_36 - 0.00142856086088783*x_37 - 0.000478172328615551*x_38 + 0.00158950968486844*x_39 + 0.00121539706218783*x_4 - 0.00381211285705098*x_40 + 0.00025338270551886*x_41 - 0.00524739893416114*x_42 + 0.00312124369701359*x_43 + 0.000346073097538813*x_44 - 0.00127761950804725*x_45 + 0.00177534900654523*x_46 - 0.000999902390301239*x_47 + 0.000168109356635262*x_48 - 0.00381188424622347*x_49 - 0.000124542448048146*x_5 + 0.00345291091528364*x_50 + 0.000368348259669813*x_51 + 0.000306390198550682*x_52 - 0.000321466900243344*x_53 + 0.0011190838117781*x_54 + 6.0895172595848e-6*x_55 - 0.00029338911403648*x_56 - 0.000567547136666636*x_57 - 0.00202498653702961*x_58 - 0.000585599493418996*x_59 + 0.000683675180488942*x_6 + 0.0017399148437501*x_60 + 0.000984175113994969*x_61 - 0.00091642454088575*x_62 + 0.000604238190466721*x_63 - 0.000267671442561552*x_64 - 0.000528547965509321*x_65 + 0.000151611017310081*x_66 - 0.000227426333742353*x_67 + 0.000550018582262112*x_68 - 0.000515061446625251*x_69 + 0.000565595205562949*x_7 + 1.44598392128893e-5*x_70 + 7.27390281082243e-5*x_71 + 0.000207329053790265*x_72 + 0.000211659320954014*x_73 + 0.000756155155285968*x_74 + 9.32149989533915e-5*x_75 + 0.000136113378715356*x_76 + 0.000787449828388569*x_77 + 8.38796970973693e-5*x_78 - 0.000695677804045767*x_79 - 0.00234777248092806*x_8 - 0.000178632290959422*x_80 + 0.0011627620515581*x_81 + 3.96892112836336e-5*x_82 - 0.00052620441938844*x_83 - 0.000217767499031239*x_84 - 3.65493284153187e-6*x_85 + 0.000470595851026329*x_86 - 0.000537478450100262*x_87 - 0.000435955198485103*x_88 - 0.000487644911506706*x_89 + 0.000264813516305936*x_9 + 0.000334222336473453*x_90 + 0.00101589933274977*x_91 - 7.02759917778888e-5*x_92 + 0.000467700658076708*x_93 - 0.000260979493433624*x_94 - 0.000150563103355928*x_95 - 0.000631474989489006*x_96 + 1.43340132370146e-6*x_97 - 4.15261430110359e-5*x_98 - 0.00313283214795383*x_99 + 8.30699039336133e-6*std::pow(-2.61807990074158*x_13 - 4.83735990524292, 2) - 1.5020030281689e-6*std::pow(-6.70760011672974*x_18 - 7.31832027435303, 2) + 5.03566318516683e-7*std::pow(-9.68360042572021*x_27 - 4.91775989532471, 2) + 3.11953742021408e-7*std::pow(-4.46895980834961*x_62 - 9.54120063781738, 2) - 0.019648345109913*std::sin(0.190880000591278*x_1 - 4.41607999801636) - 0.00498123529245694*std::sin(0.368399828672409*x_1 + 8.37007999420166) - 0.00381762645332394*std::sin(0.404959857463837*x_1 + 8.39888000488281) + 0.00198609825313166*std::sin(0.341039836406708*x_10 - 1.12095987796783) + 0.00757591559835224*std::sin(0.240799978375435*x_100 + 8.18143939971924) + 0.00950840528719277*std::sin(0.228079989552498*x_101 + 1.98055982589722) + 0.00348733718889294*std::sin(0.23327998816967*x_101 + 1.97543978691101) - 0.00266328074386306*std::sin(0.229759991168976*x_102 - 4.39823961257935) + 0.0210119390360477*std::sin(0.234159991145134*x_102 + 1.95911991596222) + 0.00191880714883214*std::sin(0.236399978399277*x_102 - 1.20351994037628) - 0.00347149220421943*std::sin(0.255919963121414*x_108 + 1.94351983070374) - 0.00299834346578272*std::sin(0.272799968719482*x_108 + 1.93503975868225) + 0.0107996399175677*std::sin(0.184880003333092*x_109 - 7.38399982452393) + 0.00424760936072285*std::sin(0.250639975070953*x_109 - 1.2137598991394) + 0.00148100775490606*std::sin(0.382559835910797*x_11 + 1.82871985435486) + 0.00872331922846802*std::sin(0.211439996957779*x_110 - 7.40647983551025) + 0.00156077143438057*std::sin(0.241679981350899*x_110 + 8.17327976226807) + 0.00145935402695334*std::sin(0.245359972119331*x_110 + 4.95287990570068) - 0.00203020775503305*std::sin(0.268559962511063*x_112 + 1.97895979881287) + 0.00122211619740715*std::sin(0.270159959793091*x_112 - 4.40351963043213) - 0.00895119878997991*std::sin(0.268879950046539*x_113 - 4.22904014587402) + 0.00177701233630883*std::sin(0.229999989271164*x_114 + 1.95623981952667) - 0.010775165842895*std::sin(0.235119983553886*x_117 - 4.23808002471924) - 0.00489594580918526*std::sin(0.235199987888336*x_118 - 7.41671991348267) - 0.0027079608851713*std::sin(0.241999968886375*x_118 + 1.97351980209351) + 0.00208956080638509*std::sin(0.271119952201843*x_12 + 5.15176010131836) + 0.0200534179832598*std::sin(0.240399971604347*x_120 - 1.03391981124878) - 0.00310989981252533*std::sin(0.279279947280884*x_120 + 1.94519984722137) - 0.00640630852913524*std::sin(0.185840010643005*x_13 - 4.40351963043213) - 0.00862663649068861*std::sin(0.319999933242798*x_13 - 4.28240013122559) - 0.00150476154720145*std::sin(0.352799862623215*x_13 - 4.33256006240845) + 0.000599790143086753*std::sin(0.295119941234589*x_14 - 1.21431994438171) - 0.0036608428790015*std::sin(0.311599940061569*x_15 - 4.24927997589111) + 0.0195006752081009*std::sin(0.324719846248627*x_15 + 8.26583957672119) - 0.00405426173811849*std::sin(0.370479851961136*x_15 + 1.83439981937408) + 0.0027052024208244*std::sin(0.353039860725403*x_17 + 5.22735977172852) + 0.00934519197600191*std::sin(0.384079843759537*x_17 + 1.99359977245331) + 0.00385496924781035*std::sin(0.477439850568771*x_17 + 1.95439982414246) - 0.00169856961894874*std::sin(0.334319829940796*x_18 + 1.80159986019135) + 0.04695899849287*std::sin(0.107840068638325*x_19 - 1.46535992622375) - 0.00994594020132255*std::sin(0.404319852590561*x_2 - 7.38735961914063) + 0.00416963162871708*std::sin(0.260959982872009*x_20 + 5.02055978775024) + 0.00350998309456941*std::sin(0.34623983502388*x_20 - 1.14527976512909) - 0.0120132769136572*std::sin(0.367359846830368*x_20 + 8.22056007385254) - 0.00598691443828848*std::sin(0.293359935283661*x_21 - 4.38455963134766) - 0.0147147096015079*std::sin(0.347999840974808*x_21 - 1.16127991676331) + 0.000533095857928099*std::sin(0.396319836378098*x_21 - 4.40287971496582) - 0.0706372742138157*std::sin(0.137040033936501*x_22 + 4.94816017150879) + 0.00495999950889663*std::sin(0.273999959230423*x_22 - 7.55800008773804) + 0.00127128425416721*std::sin(0.342079848051071*x_22 - 1.16143989562988) + 0.000983243679366079*std::sin(0.276719957590103*x_23 - 1.14367985725403) - 0.00346989473178457*std::sin(0.313359916210175*x_23 - 7.38032007217407) + 0.00140743267479076*std::sin(0.339599847793579*x_23 - 4.39879989624023) + 0.00205472947784827*std::sin(0.365439832210541*x_24 + 2.03655982017517) - 0.000956543021729728*std::sin(0.333359837532043*x_25 - 1.14519989490509) - 0.00298872103704925*std::sin(0.375839829444885*x_25 - 4.37487983703613) + 0.0180029959482696*std::sin(0.195199996232986*x_26 - 1.19399988651276) - 0.00277921938458718*std::sin(0.261919975280762*x_26 - 7.38695955276489) - 0.00621496789969265*std::sin(0.36999985575676*x_26 + 8.22991943359375) + 0.0039490787699959*std::sin(0.224879994988441*x_27 - 1.18111991882324) + 0.00227766776540694*std::sin(0.375039845705032*x_27 - 1.17775988578796) + 0.00435578379754518*std::sin(0.309839934110641*x_28 + 1.97959983348846) + 0.00371191755912816*std::sin(0.326559841632843*x_29 - 1.16359984874725) - 0.00732246811058366*std::sin(0.360319852828979*x_29 + 8.21487998962402) - 0.00287229855535517*std::sin(0.207359999418259*x_3 + 1.99087977409363) - 0.00129989082663614*std::sin(0.320239931344986*x_3 + 2.06399965286255) - 0.0065074142092344*std::sin(0.409039855003357*x_3 - 1.17767977714539) + 0.00488126763839675*std::sin(0.213279992341995*x_30 - 1.19399988651276) + 0.0098760909427731*std::sin(0.357599824666977*x_31 + 5.16951990127563) + 0.00456484789062998*std::sin(0.37391984462738*x_31 + 5.17328023910522) + 0.00217625385012111*std::sin(0.398239821195602*x_31 + 5.2007999420166) + 0.00272223778187806*std::sin(0.291759938001633*x_32 - 1.13471984863281) + 0.00138442390285282*std::sin(0.292239934206009*x_32 + 2.03519988059998) + 0.00206173754183434*std::sin(0.321919858455658*x_32 - 1.19455993175507) + 0.00106173847209182*std::sin(0.336319833993912*x_32 - 4.41016006469727) + 0.00487232396813442*std::sin(0.238239988684654*x_33 + 1.99767982959747) - 0.00339364427324949*std::sin(0.237599983811378*x_34 - 1.19663989543915) - 0.00426189292967555*std::sin(0.240239977836609*x_35 + 1.95999991893768) - 0.00359379805157669*std::sin(0.271359950304031*x_36 + 8.15679931640625) - 0.00697939540358911*std::sin(0.22367998957634*x_37 + 1.97847986221313) + 0.00168275495112312*std::sin(0.248799979686737*x_38 - 1.2339198589325) - 0.000462490746665919*std::sin(0.260879963636398*x_38 + 1.78807997703552) + 0.00900997981024216*std::sin(0.261039972305298*x_38 - 1.20975983142853) - 0.00828919796555217*std::sin(0.221039995551109*x_4 - 4.39103984832764) + 0.000626477992055296*std::sin(0.295199930667877*x_4 - 1.13903987407684) - 0.00531011414849048*std::sin(0.235519990324974*x_40 - 1.21535992622375) - 0.00298278546714225*std::sin(0.235759988427162*x_40 + 1.95503973960876) - 0.00116701448186893*std::sin(0.236879989504814*x_41 + 4.97887992858887) - 0.00928498588547787*std::sin(0.252079963684082*x_41 + 1.95879983901978) - 0.014083157668117*std::sin(0.267199963331223*x_41 + 1.93695986270905) - 0.00194518343595886*std::sin(0.282239943742752*x_41 - 4.44271993637085) - 0.00196983732949514*std::sin(0.259679973125458*x_42 + 1.94903981685638) - 0.00408323724315212*std::sin(0.266719967126846*x_42 + 1.95047974586487) + 0.000838109822070385*std::sin(0.145360037684441*x_44 + 4.98343992233276) + 0.00938743970332814*std::sin(0.225679993629456*x_44 - 1.18967986106873) + 0.00244604711351172*std::sin(0.173040017485619*x_46 - 7.38007974624634) - 0.015770317058906*std::sin(0.192159995436668*x_47 + 2.00471973419189) + 0.0121315997830578*std::sin(0.242559969425201*x_48 + 1.78887987136841) + 0.0196697523900903*std::sin(0.338559836149216*x_5 + 2.04775977134705) + 0.00676687188102504*std::sin(0.294879943132401*x_53 - 4.42799949645996) + 0.00381600790488217*std::sin(0.170560017228127*x_55 - 1.18743991851807) + 0.0306804900747783*std::sin(0.185440003871918*x_55 - 4.38175964355469) + 0.00202945387344208*std::sin(0.105280071496964*x_57 + 5.14776039123535) - 0.00316754654585189*std::sin(0.234479993581772*x_57 + 5.18336009979248) - 0.0197665446126455*std::sin(0.241599977016449*x_57 - 4.2422399520874) - 0.00622264091999102*std::sin(0.358479857444763*x_6 + 2.01023983955383) + 0.00301449091567347*std::sin(0.146960034966469*x_60 - 1.22951984405518) - 0.0036304977343807*std::sin(0.400799870491028*x_60 + 8.19935989379883) - 0.00713290970911086*std::sin(0.489599853754044*x_60 - 7.72096014022827) - 0.00530102026002874*std::sin(0.239919975399971*x_7 + 7.77871990203857) - 0.00449159052557341*std::sin(0.312239944934845*x_7 - 4.20567989349365) - 0.00145621985944139*std::sin(0.346719831228256*x_7 + 5.02895975112915) - 3.96978253406346e-5*std::sin(0.839039862155914*x_75 + 5.40751981735229) + 0.0038870375306154*std::sin(0.315759927034378*x_8 + 1.9851998090744) + 0.00122728190634687*std::sin(0.398159831762314*x_8 + 7.99560022354126) - 0.00161088139733228*std::sin(0.329119831323624*x_9 + 8.27431964874268) + 0.00101282059910876*std::sin(0.343199849128723*x_91 - 7.38391971588135) - 0.00504234361497555*std::sin(0.371119856834412*x_91 - 7.39224004745483) - 0.00140143116239043*std::sin(0.198400005698204*x_92 - 1.00927984714508) + 0.00230717760779831*std::sin(0.275199949741364*x_92 - 7.39559984207153) - 0.00555817887066303*std::sin(0.351359844207764*x_92 - 4.59311962127686) + 0.0187042832632855*std::sin(0.279999971389771*x_94 + 1.98743987083435) + 0.00377420185348765*std::sin(0.287759929895401*x_94 + 8.18183994293213) - 0.00168354889082679*std::sin(0.271839946508408*x_95 + 1.97663974761963) - 0.00170913801415502*std::sin(0.294079929590225*x_95 + 4.97615957260132) + 0.00182270957712968*std::sin(0.286479949951172*x_96 - 1.20391988754272) - 0.00282986681933144*std::sin(0.275359958410263*x_97 - 1.19951987266541) + 0.00326474031281423*std::sin(0.276799947023392*x_97 - 1.19999980926514) - 0.00888140447672091*std::sin(0.294719934463501*x_97 - 4.42967987060547) - 0.00716358431331461*std::sin(0.247839972376823*x_98 + 1.98023986816406) + 0.0206739539058319*std::sin(0.282159924507141*x_98 + 8.16495990753174) - 0.000907662232616815*std::sin(0.282799929380417*x_98 - 4.41296005249023) + 0.188240267734992 + 1.0751686119984e-6*std::exp(-4.22904014587402*x_21));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (5.0907824160735e-5*x_1 - 0.000176566949136753*x_10 - 1.6253322909078e-5*x_100 - 0.000236554231739945*x_101 - 7.81666532797021e-5*x_102 + 0.00141957042549025*x_103 - 0.00104077021327599*x_104 - 0.00207495046138233*x_105 + 0.00163875208360611*x_106 + 0.00118487515686534*x_107 + 0.00102500902120459*x_108 + 4.98137270100946e-5*x_109 - 0.00049717298765458*x_11 + 0.00105954099617355*x_110 - 0.00190578397674283*x_111 + 0.000131936863093352*x_112 - 0.00221428030611232*x_113 - 0.00267598284681012*x_114 - 0.000481071178098395*x_115 - 0.000475171425829538*x_116 - 1.63028514992854e-5*x_117 - 0.00178538152181036*x_118 - 0.00203111771318404*x_119 + 0.00070919909269571*x_12 - 0.000245652334620081*x_120 - 1.76647661166682e-5*x_13 + 0.000380412152775095*x_14 + 6.35580859311033e-5*x_15 + 0.00101233029022874*x_16 - 1.59476259916331e-5*x_17 + 0.000196087312260811*x_18 - 0.000284423557452693*x_19 + 5.6618782653192e-5*x_2 - 0.000270848207763311*x_20 + 9.35931313189233e-5*x_21 - 3.11761613472952e-5*x_22 + 0.000172450449476191*x_23 + 0.000583004485498835*x_24 - 2.27708257762792e-5*x_25 + 1.76378929404235e-5*x_26 - 0.00186800534518338*x_27 + 0.000116160115707685*x_28 + 0.00126618263340478*x_29 + 1.76628289834971e-5*x_3 + 0.000685754035626564*x_30 + 2.18474703313361e-5*x_31 + 1.04534503865342e-6*x_32 + 0.00071801483105323*x_33 - 0.00015511062463943*x_34 + 0.00210025985729024*x_35 - 0.00143494364573609*x_36 + 0.000909502735951833*x_37 + 0.000586670387445187*x_38 - 0.000829022884058988*x_39 - 0.000852842666354971*x_4 + 0.00252883651117886*x_40 - 0.00021416520318428*x_41 + 0.00310262279869782*x_42 - 0.00178916157449*x_43 - 0.000345985435739911*x_44 + 0.00125052435718638*x_45 - 0.00179725319855582*x_46 + 0.000376124385819803*x_47 - 8.95584319497767e-5*x_48 + 0.00281206566705633*x_49 - 8.62126833878827e-6*x_5 - 0.00154749568804152*x_50 - 0.000860781012116359*x_51 - 0.000294800142827443*x_52 + 0.000190437948296899*x_53 - 7.22582934563775e-5*x_54 - 0.000196239769252945*x_55 + 0.000223522482480549*x_56 - 1.31130026414903e-5*x_57 + 0.00118888514586051*x_58 + 0.000537812796054934*x_59 - 0.000355289948073485*x_6 - 0.000326390816368945*x_60 - 0.000282132710192356*x_61 + 0.00070956585984009*x_62 - 0.000464516030220716*x_63 + 0.000262905336948628*x_64 + 0.000244411951438716*x_65 + 4.30974999154917e-5*x_66 + 6.92300470097247e-5*x_67 - 0.000401628913744012*x_68 + 0.000344821341985803*x_69 - 0.000172217039254174*x_7 + 1.88979005167735e-5*x_70 - 0.000116980339998826*x_71 - 0.000131818579271977*x_72 - 7.98084493256293e-5*x_73 - 0.0005233858574299*x_74 - 3.32926058575861e-5*x_75 - 0.000149434255199787*x_76 - 0.000565464524491227*x_77 - 4.38733271559119e-5*x_78 + 0.000494611121411279*x_79 + 0.00161899171302412*x_8 + 0.000128209245371298*x_80 - 0.000794097103487157*x_81 - 2.43080800506943e-5*x_82 + 0.00029170940691318*x_83 + 1.5261022794978e-5*x_84 - 1.17802476962848e-5*x_85 - 0.000376828527076331*x_86 + 0.000591733805678565*x_87 + 7.49897491989969e-5*x_88 + 0.000127385585277861*x_89 - 5.19648415665907e-5*x_9 - 3.95387353997022e-5*x_90 - 0.00073039294281764*x_91 + 7.34804145680055e-6*x_92 - 0.000645174760319927*x_93 + 9.32948388424535e-5*x_94 + 3.47033590525939e-5*x_95 + 0.000877617900342945*x_96 - 1.11506312628249e-5*x_97 + 1.44384471396884e-5*x_98 + 0.00210243529061269*x_99 - 2.7770922168109e-6*std::pow(-2.61807990074158*x_13 - 4.83735990524292, 2) + 1.09560317989616e-6*std::pow(-6.70760011672974*x_18 - 7.31832027435303, 2) - 1.88350359102109e-7*std::pow(-9.68360042572021*x_27 - 4.91775989532471, 2) - 2.63670862647485e-7*std::pow(-4.46895980834961*x_62 - 9.54120063781738, 2) + 0.0143320545820478*std::sin(0.190880000591278*x_1 - 4.41607999801636) + 0.000906702579790795*std::sin(0.368399828672409*x_1 + 8.37007999420166) + 0.00127626254614306*std::sin(0.404959857463837*x_1 + 8.39888000488281) - 0.000663968265209686*std::sin(0.341039836406708*x_10 - 1.12095987796783) - 0.0013789957337902*std::sin(0.240799978375435*x_100 + 8.18143939971924) - 0.00693569778024335*std::sin(0.228079989552498*x_101 + 1.98055982589722) - 0.00116584424756401*std::sin(0.23327998816967*x_101 + 1.97543978691101) + 0.00089035569739857*std::sin(0.229759991168976*x_102 - 4.39823961257935) - 0.0153266982768622*std::sin(0.234159991145134*x_102 + 1.95911991596222) - 0.00162182230259001*std::sin(0.236399978399277*x_102 - 1.20351994037628) + 0.00129845221819227*std::sin(0.255919963121414*x_108 + 1.94351983070374) + 0.00100236980035578*std::sin(0.272799968719482*x_108 + 1.93503975868225) - 0.007877560573127*std::sin(0.184880003333092*x_109 - 7.38399982452393) - 0.00142000921358276*std::sin(0.250639975070953*x_109 - 1.2137598991394) - 0.000553945592094487*std::sin(0.382559835910797*x_11 + 1.82871985435486) - 0.00158785031913025*std::sin(0.211439996957779*x_110 - 7.40647983551025) - 0.000521778164821637*std::sin(0.241679981350899*x_110 + 8.17327976226807) - 0.000545846385920794*std::sin(0.245359972119331*x_110 + 4.95287990570068) + 0.00171598079463475*std::sin(0.268559962511063*x_112 + 1.97895979881287) - 0.000457111637895445*std::sin(0.270159959793091*x_112 - 4.40351963043213) + 0.00162932978640563*std::sin(0.268879950046539*x_113 - 4.22904014587402) - 0.000594069198910357*std::sin(0.229999989271164*x_114 + 1.95623981952667) + 0.00196133490867637*std::sin(0.235119983553886*x_117 - 4.23808002471924) + 0.00163675318698842*std::sin(0.235199987888336*x_118 - 7.41671991348267) + 0.00101286640190488*std::sin(0.241999968886375*x_118 + 1.97351980209351) - 0.00176614743200009*std::sin(0.271119952201843*x_12 + 5.15176010131836) - 0.0146275261089392*std::sin(0.240399971604347*x_120 - 1.03391981124878) + 0.0011632047754626*std::sin(0.279279947280884*x_120 + 1.94519984722137) + 0.00239617001299016*std::sin(0.185840010643005*x_13 - 4.40351963043213) + 0.00629251086299665*std::sin(0.319999933242798*x_13 - 4.28240013122559) + 0.00127186092610532*std::sin(0.352799862623215*x_13 - 4.33256006240845) - 0.000506957164258954*std::sin(0.295119941234589*x_14 - 1.21431994438171) + 0.0012238485642607*std::sin(0.311599940061569*x_15 - 4.24927997589111) - 0.0142243400095962*std::sin(0.324719846248627*x_15 + 8.26583957672119) + 0.000737971479216352*std::sin(0.370479851961136*x_15 + 1.83439981937408) - 0.000904370443689599*std::sin(0.353039860725403*x_17 + 5.22735977172852) - 0.00681664540858463*std::sin(0.384079843759537*x_17 + 1.99359977245331) - 0.000701695534699345*std::sin(0.477439850568771*x_17 + 1.95439982414246) + 0.000635320882125934*std::sin(0.334319829940796*x_18 + 1.80159986019135) - 0.00854764783794748*std::sin(0.107840068638325*x_19 - 1.46535992622375) + 0.00725484803110574*std::sin(0.404319852590561*x_2 - 7.38735961914063) - 0.00155957931599898*std::sin(0.260959982872009*x_20 + 5.02055978775024) - 0.00117341495192488*std::sin(0.34623983502388*x_20 - 1.14527976512909) + 0.00876282147288442*std::sin(0.367359846830368*x_20 + 8.22056007385254) + 0.00108975995861971*std::sin(0.293359935283661*x_21 - 4.38455963134766) + 0.0107333223224686*std::sin(0.347999840974808*x_21 - 1.16127991676331) - 0.000450585538172697*std::sin(0.396319836378098*x_21 - 4.40287971496582) + 0.0515248110665931*std::sin(0.137040033936501*x_22 + 4.94816017150879) - 0.000902837165168208*std::sin(0.273999959230423*x_22 - 7.55800008773804) - 0.00107452025994107*std::sin(0.342079848051071*x_22 - 1.16143989562988) - 0.000831061385740165*std::sin(0.276719957590103*x_23 - 1.14367985725403) + 0.00129785471098081*std::sin(0.313359916210175*x_23 - 7.38032007217407) - 0.0004705158115953*std::sin(0.339599847793579*x_23 - 4.39879989624023) - 0.000768536378982601*std::sin(0.365439832210541*x_24 + 2.03655982017517) + 0.000808493342841841*std::sin(0.333359837532043*x_25 - 1.14519989490509) + 0.00218005703757176*std::sin(0.375839829444885*x_25 - 4.37487983703613) - 0.0131318907077222*std::sin(0.195199996232986*x_26 - 1.19399988651276) + 0.00103951942348423*std::sin(0.261919975280762*x_26 - 7.38695955276489) + 0.00113127107978648*std::sin(0.36999985575676*x_26 + 8.22991943359375) - 0.00132020808938135*std::sin(0.224879994988441*x_27 - 1.18111991882324) - 0.0004145893774438*std::sin(0.375039845705032*x_27 - 1.17775988578796) - 0.000792855622023259*std::sin(0.309839934110641*x_28 + 1.97959983348846) - 0.00124092323149147*std::sin(0.326559841632843*x_29 - 1.16359984874725) + 0.0013328622995095*std::sin(0.360319852828979*x_29 + 8.21487998962402) + 0.000960231995550239*std::sin(0.207359999418259*x_3 + 1.99087977409363) + 0.00109869922824386*std::sin(0.320239931344986*x_3 + 2.06399965286255) + 0.00474669063033136*std::sin(0.409039855003357*x_3 - 1.17767977714539) - 0.0016318461590609*std::sin(0.213279992341995*x_30 - 1.19399988651276) - 0.00720389802078955*std::sin(0.357599824666977*x_31 + 5.16951990127563) - 0.000830910229246623*std::sin(0.37391984462738*x_31 + 5.17328023910522) - 0.000813990489624214*std::sin(0.398239821195602*x_31 + 5.2007999420166) - 0.000910065498860303*std::sin(0.291759938001633*x_32 - 1.13471984863281) - 0.000517820055995729*std::sin(0.292239934206009*x_32 + 2.03519988059998) - 0.00174263053453245*std::sin(0.321919858455658*x_32 - 1.19455993175507) - 0.000193261501452577*std::sin(0.336319833993912*x_32 - 4.41016006469727) - 0.000886878144096862*std::sin(0.238239988684654*x_33 + 1.99767982959747) + 0.0011345219690392*std::sin(0.237599983811378*x_34 - 1.19663989543915) + 0.00159408807587383*std::sin(0.240239977836609*x_35 + 1.95999991893768) + 0.00134419862620836*std::sin(0.271359950304031*x_36 + 8.15679931640625) + 0.00127041495658659*std::sin(0.22367998957634*x_37 + 1.97847986221313) - 0.00056255821377844*std::sin(0.248799979686737*x_38 - 1.2339198589325) + 0.000390908387088729*std::sin(0.260879963636398*x_38 + 1.78807997703552) - 0.00164002932167858*std::sin(0.261039972305298*x_38 - 1.20975983142853) + 0.00150882998663885*std::sin(0.221039995551109*x_4 - 4.39103984832764) - 0.000529514380960842*std::sin(0.295199930667877*x_4 - 1.13903987407684) + 0.00177521291994455*std::sin(0.235519990324974*x_40 - 1.21535992622375) + 0.00252112256168995*std::sin(0.235759988427162*x_40 + 1.95503973960876) + 0.000436501784680207*std::sin(0.236879989504814*x_41 + 4.97887992858887) + 0.001690086928524*std::sin(0.252079963684082*x_41 + 1.95879983901978) + 0.0102726506104173*std::sin(0.267199963331223*x_41 + 1.93695986270905) + 0.000650290120064167*std::sin(0.282239943742752*x_41 - 4.44271993637085) + 0.00166495424795244*std::sin(0.259679973125458*x_42 + 1.94903981685638) + 0.00136505832201423*std::sin(0.266719967126846*x_42 + 1.95047974586487) - 0.000708390732378082*std::sin(0.145360037684441*x_44 + 4.98343992233276) - 0.00170873594538432*std::sin(0.225679993629456*x_44 - 1.18967986106873) - 0.000817732786390943*std::sin(0.173040017485619*x_46 - 7.38007974624634) + 0.0115033120397711*std::sin(0.192159995436668*x_47 + 2.00471973419189) - 0.00884912949593007*std::sin(0.242559969425201*x_48 + 1.78887987136841) - 0.0143476696532529*std::sin(0.338559836149216*x_5 + 2.04775977134705) - 0.00123173065141697*std::sin(0.294879943132401*x_53 - 4.42799949645996) - 0.00322538235839099*std::sin(0.170560017228127*x_55 - 1.18743991851807) - 0.0223792108646267*std::sin(0.185440003871918*x_55 - 4.38175964355469) - 0.00171534359564448*std::sin(0.105280071496964*x_57 + 5.14776039123535) + 0.00118476654900437*std::sin(0.234479993581772*x_57 + 5.18336009979248) + 0.014418272617982*std::sin(0.241599977016449*x_57 - 4.2422399520874) + 0.00113266775087124*std::sin(0.358479857444763*x_6 + 2.01023983955383) - 0.00254792077513879*std::sin(0.146960034966469*x_60 - 1.22951984405518) + 0.00121370394377193*std::sin(0.400799870491028*x_60 + 8.19935989379883) + 0.00520294460973301*std::sin(0.489599853754044*x_60 - 7.72096014022827) + 0.00386671301233112*std::sin(0.239919975399971*x_7 + 7.77871990203857) + 0.00150157403572296*std::sin(0.312239944934845*x_7 - 4.20567989349365) + 0.000544674104227886*std::sin(0.346719831228256*x_7 + 5.02895975112915) + 7.22594266987216e-6*std::sin(0.839039862155914*x_75 + 5.40751981735229) - 0.00070753272026511*std::sin(0.315759927034378*x_8 + 1.9851998090744) - 0.000410289992952502*std::sin(0.398159831762314*x_8 + 7.99560022354126) + 0.00136155599514571*std::sin(0.329119831323624*x_9 + 8.27431964874268) - 0.000378828203026109*std::sin(0.343199849128723*x_91 - 7.38391971588135) + 0.00168569512477413*std::sin(0.371119856834412*x_91 - 7.39224004745483) + 0.000468509458802432*std::sin(0.198400005698204*x_92 - 1.00927984714508) - 0.00195008242628291*std::sin(0.275199949741364*x_92 - 7.39559984207153) + 0.0040542917230692*std::sin(0.351359844207764*x_92 - 4.59311962127686) - 0.0136434293650636*std::sin(0.279999971389771*x_94 + 1.98743987083435) - 0.000686993959588796*std::sin(0.287759929895401*x_94 + 8.18183994293213) + 0.00142297632167225*std::sin(0.271839946508408*x_95 + 1.97663974761963) + 0.000571378279233202*std::sin(0.294079929590225*x_95 + 4.97615957260132) - 0.00154059830615731*std::sin(0.286479949951172*x_96 - 1.20391988754272) + 0.00105846322923713*std::sin(0.275359958410263*x_97 - 1.19951987266541) - 0.00109142836133178*std::sin(0.276799947023392*x_97 - 1.19999980926514) + 0.0064783457850294*std::sin(0.294719934463501*x_97 - 4.42967987060547) + 0.00130394169238842*std::sin(0.247839972376823*x_98 + 1.98023986816406) - 0.0150801624334068*std::sin(0.282159924507141*x_98 + 8.16495990753174) + 0.000767178115305935*std::sin(0.282799929380417*x_98 - 4.41296005249023) + 0.0813705004798917 - 4.0214840969056e-7*std::exp(-4.22904014587402*x_21));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-8.23022272344646e-6*x_1 - 0.00108938305945125*x_10 + 1.9595390405715e-5*x_100 - 0.000395860288679555*x_101 + 2.65709619439159e-6*x_102 - 0.00267813358260533*x_103 + 0.00170389647047132*x_104 + 0.00300057266121432*x_105 - 0.00192654747255895*x_106 - 0.00450681627393953*x_107 - 0.00188691512802537*x_108 - 0.000218084080844574*x_109 + 0.00178047968317453*x_11 - 0.00185719286381874*x_110 + 0.00395978704515929*x_111 - 0.000635853108601111*x_112 + 0.00389300529533924*x_113 + 0.00254240609553412*x_114 + 0.00178015897265429*x_115 + 0.00157474738854012*x_116 + 3.20093625512092e-5*x_117 + 0.00307613615889321*x_118 + 0.00318938494688874*x_119 - 0.0036824101432795*x_12 + 0.00149499010008703*x_120 + 0.00018427406165761*x_13 - 0.00198768323669098*x_14 - 4.71261744853478e-5*x_15 - 0.0020215104294592*x_16 + 2.6237204731481e-5*x_17 + 7.89499301994323e-6*x_18 + 0.000254002395792347*x_19 + 0.00025441911262895*x_2 + 0.0011930024281272*x_20 + 1.60527476026275e-6*x_22 - 0.000264698604988697*x_23 - 0.00103657108482171*x_24 - 0.00128449237818087*x_25 - 1.40498714945095e-5*x_26 + 0.0030263085926974*x_27 - 0.000227505586373808*x_28 - 0.00228672966686432*x_29 + 6.54771102704022e-5*x_3 - 0.00050310416904513*x_30 + 1.68564151472344e-6*x_31 - 1.87096188072237e-6*x_32 - 0.00155576899971878*x_33 - 0.00242027280657953*x_34 - 0.00479402184402394*x_35 + 0.0011640732943751*x_36 - 0.0014191907747096*x_37 - 0.00148279034979415*x_38 + 0.00150629140700463*x_39 + 0.00147836087182001*x_4 - 0.00448071693297472*x_40 + 0.000173935906151532*x_41 - 0.00714165302962084*x_42 + 0.0046106946960905*x_43 + 0.000761517561926349*x_44 - 0.00291243382955716*x_45 + 0.00182983504092498*x_46 - 0.000263436935909572*x_47 - 0.000309648123944574*x_48 - 0.00447892128632675*x_49 - 0.000133298281264741*x_5 + 0.00314376479480035*x_50 + 9.57359096146613e-5*x_51 + 5.77981545076643e-5*x_52 - 0.000348720763684061*x_53 + 0.00214165216083372*x_54 - 0.00214430465962242*x_55 - 0.00158749704355666*x_56 - 0.00252930347579167*x_57 - 0.004425327220936*x_58 - 0.00122613532907199*x_59 + 2.74002454710163e-6*x_6 + 0.00320916286137633*x_60 + 0.000884441198184428*x_61 - 0.00129156756024876*x_62 + 0.000859895032559739*x_63 - 0.000182020602811999*x_64 - 0.000388490066768183*x_65 - 0.000232942075588528*x_66 + 3.21810945652494e-5*x_67 + 0.000636022176696284*x_68 - 1.52871240390215e-5*x_69 + 0.000947343527749819*x_7 + 3.41641789426452e-6*x_70 + 0.000338556884725247*x_71 + 0.000166597294446559*x_72 + 6.24497393663564e-6*x_73 + 0.0010324203227084*x_74 + 8.66177411501907e-7*x_75 + 0.000402266975370672*x_76 + 0.00109026569150714*x_77 + 9.88871511966705e-5*x_78 - 0.000776790088730173*x_79 - 0.00267349570125613*x_8 - 0.000261030906842343*x_80 + 0.00133905944002581*x_81 - 3.8473494710954e-5*x_82 - 0.000480034799712575*x_83 - 0.000482665287809808*x_84 - 3.00154411993222e-5*x_85 + 0.000684708026376063*x_86 - 0.000447805223482203*x_87 - 0.000810754865026041*x_88 - 0.000595233533078098*x_89 + 0.000363629742360413*x_9 + 0.000437761608965149*x_90 + 0.00134266618872965*x_91 - 0.000186628194370106*x_92 + 0.00143986479559853*x_93 - 7.79885823439639e-6*x_94 - 0.000218288583552942*x_95 - 6.47945845627792e-5*x_96 - 1.71852127926532e-5*x_97 - 3.20240345833906e-7*x_98 - 0.00437888094543241*x_99 - 1.96091406204449e-6*std::pow(-6.70760011672974*x_18 - 7.31832027435303, 2) + 1.15232745834966e-8*std::pow(-9.68360042572021*x_27 - 4.91775989532471, 2) + 2.14142305745552e-7*std::pow(-4.46895980834961*x_62 - 9.54120063781738, 2) + 0.00267671165056527*std::pow(0.11140002027726*x_100 - 0.191600302963768*x_103 - 0.0267874404120559*x_104 - 0.00263682714091107*x_105 + 0.000641261624633004*x_106 + 0.0738480329854513*x_107 + 0.00163404978227056*x_11 + 0.0360195907791883*x_111 + 0.155198609332342*x_112 + 0.0272320879707357*x_113 + 0.0146566574060502*x_115 + 0.00554148603966542*x_116 - 0.156310343919756*x_117 - 0.138435006472822*x_119 - 0.000430711803665125*x_12 + 0.0429585657259258*x_120 - 0.00109260411647639*x_14 + 0.0254233755921691*x_16 - 0.0790435927138938*x_18 - 0.0121779017308165*x_19 - 0.0178169930930355*x_2 - 0.0682871097372739*x_21 + 0.00360255972110237*x_22 + 0.00931534721860049*x_24 + 0.119337486196685*x_25 - 0.000246941703424961*x_26 - 0.00952304169399893*x_28 - 0.017454605671836*x_31 + 0.156721078915139*x_33 - 0.125878107800102*x_35 - 0.183576136313012*x_36 - 0.033356474387903*x_37 - 0.0396251261993284*x_39 + 0.0268310475193343*x_4 - 0.146812547323055*x_43 - 0.05652480042434*x_44 + 0.0111457259855525*x_45 - 0.101761310765631*x_47 + 0.0888291965857108*x_48 - 0.0701409438788695*x_49 + 0.0192049329774179*x_5 + 0.219975026905034*x_50 - 0.222398547752583*x_51 + 0.00524176005261084*x_52 - 0.0339762960418729*x_53 - 0.012235610359023*x_54 + 0.148028018432928*x_55 - 0.0210772992708369*x_56 + 0.186472168172852*x_57 + 0.119983628737062*x_58 + 0.108306000825402*x_59 + 0.118649177717764*x_6 + 0.0778511972101996*x_61 + 0.0347011226712048*x_62 + 0.00141432321031202*x_63 - 0.0190999778042365*x_64 - 0.000582727222317347*x_65 + 0.055490030136464*x_66 - 0.0598714098077348*x_67 - 0.000958922796188596*x_68 - 0.0483350323858543*x_69 + 0.00267251049060052*x_70 + 0.00221022068176181*x_71 - 8.7439123558913e-5*x_72 + 0.0498515369273816*x_73 - 0.000917711116251458*x_74 + 0.000244605716375761*x_75 - 0.0120021286655255*x_76 + 0.000896702558322519*x_77 + 0.0054687247170897*x_78 - 0.0194432589976969*x_79 + 0.00232195052884572*x_80 + 0.000775985654852781*x_81 - 0.0311142608704385*x_82 - 0.016427363423787*x_83 + 0.0011577492418756*x_84 - 0.0384085061514792*x_85 + 0.000519423568185155*x_86 - 0.00139987301983822*x_87 - 0.000893646144421359*x_88 - 0.00109936176153945*x_89 + 0.0143767126124258*x_9 + 0.0354279215836111*x_90 - 0.147960951166848*x_93 - 0.0583634578837121*x_94 - 0.0176801108549076*x_96 - 0.00671542912364889*x_98 - 0.109760398489998*x_99 + 0.00202621280309223*std::pow(-2.61807990074158*x_13 - 4.83735990524292, 2) - 0.93118244163739*std::sin(0.404959857463837*x_1 + 8.39888000488281) + 0.484442321241943*std::sin(0.341039836406708*x_10 - 1.12095987796783) + 0.850619409224493*std::sin(0.23327998816967*x_101 + 1.97543978691101) - 0.649618367893737*std::sin(0.229759991168976*x_102 - 4.39823961257935) - 0.731345725798846*std::sin(0.272799968719482*x_108 + 1.93503975868225) + 1.03606240788591*std::sin(0.250639975070953*x_109 - 1.2137598991394) + 0.380698052277737*std::sin(0.241679981350899*x_110 + 8.17327976226807) + 0.433442796558339*std::sin(0.229999989271164*x_114 + 1.95623981952667) - 1.19420242615723*std::sin(0.235199987888336*x_118 - 7.41671991348267) - 0.892940326194406*std::sin(0.311599940061569*x_15 - 4.24927997589111) + 0.659843760552675*std::sin(0.353039860725403*x_17 + 5.22735977172852) + 0.856143121405012*std::sin(0.34623983502388*x_20 - 1.14527976512909) + 0.343296184311278*std::sin(0.339599847793579*x_23 - 4.39879989624023) + 0.963245842992677*std::sin(0.224879994988441*x_27 - 1.18111991882324) + 0.90539828821025*std::sin(0.326559841632843*x_29 - 1.16359984874725) - 0.700601280557038*std::sin(0.207359999418259*x_3 + 1.99087977409363) + 1.19062217673243*std::sin(0.213279992341995*x_30 - 1.19399988651276) + 0.663998967798349*std::sin(0.291759938001633*x_32 - 1.13471984863281) - 0.827766152359345*std::sin(0.237599983811378*x_34 - 1.19663989543915) + 0.410451856205029*std::sin(0.248799979686737*x_38 - 1.2339198589325) - 1.29522495682085*std::sin(0.235519990324974*x_40 - 1.21535992622375) - 0.474462518393253*std::sin(0.282239943742752*x_41 - 4.44271993637085) - 0.995969320820421*std::sin(0.266719967126846*x_42 + 1.95047974586487) + 0.596631480677416*std::sin(0.173040017485619*x_46 - 7.38007974624634) - 0.885538641874234*std::sin(0.400799870491028*x_60 + 8.19935989379883) - 1.09557346261502*std::sin(0.312239944934845*x_7 - 4.20567989349365) + 0.299354422466983*std::sin(0.398159831762314*x_8 + 7.99560022354126) - 1.22991128031384*std::sin(0.371119856834412*x_91 - 7.39224004745483) - 0.341832315847775*std::sin(0.198400005698204*x_92 - 1.00927984714508) - 0.416887123078908*std::sin(0.294079929590225*x_95 + 4.97615957260132) + 0.796324337377598*std::sin(0.276799947023392*x_97 - 1.19999980926514) - 0.30397028580962, 2) - 0.0256515569538512*std::sin(0.190880000591278*x_1 - 4.41607999801636) - 0.00945847604151561*std::sin(0.368399828672409*x_1 + 8.37007999420166) + 0.0143853104646689*std::sin(0.240799978375435*x_100 + 8.18143939971924) + 0.012413533984685*std::sin(0.228079989552498*x_101 + 1.98055982589722) + 0.0274317734078325*std::sin(0.234159991145134*x_102 + 1.95911991596222) + 0.00131717537500724*std::sin(0.236399978399277*x_102 - 1.20351994037628) - 7.94393040454369e-5*std::sin(0.255919963121414*x_108 + 1.94351983070374) + 0.0140992830122272*std::sin(0.184880003333092*x_109 - 7.38399982452393) + 3.38903901880104e-5*std::sin(0.382559835910797*x_11 + 1.82871985435486) + 0.016564025001971*std::sin(0.211439996957779*x_110 - 7.40647983551025) + 3.33948807709181e-5*std::sin(0.245359972119331*x_110 + 4.95287990570068) - 0.00139364691376404*std::sin(0.268559962511063*x_112 + 1.97895979881287) + 2.79660890687523e-5*std::sin(0.270159959793091*x_112 - 4.40351963043213) - 0.0169967275840344*std::sin(0.268879950046539*x_113 - 4.22904014587402) - 0.0204601152093159*std::sin(0.235119983553886*x_117 - 4.23808002471924) - 6.1967164390808e-5*std::sin(0.241999968886375*x_118 + 1.97351980209351) + 0.00143439013161166*std::sin(0.271119952201843*x_12 + 5.15176010131836) + 0.0261803928340737*std::sin(0.240399971604347*x_120 - 1.03391981124878) - 7.11648657766745e-5*std::sin(0.279279947280884*x_120 + 1.94519984722137) - 0.00014659767647938*std::sin(0.185840010643005*x_13 - 4.40351963043213) - 0.0112623559909596*std::sin(0.319999933242798*x_13 - 4.28240013122559) - 0.0010329515691235*std::sin(0.352799862623215*x_13 - 4.33256006240845) + 0.000411729134492117*std::sin(0.295119941234589*x_14 - 1.21431994438171) + 0.0254587690688913*std::sin(0.324719846248627*x_15 + 8.26583957672119) - 0.00769831884353989*std::sin(0.370479851961136*x_15 + 1.83439981937408) + 0.0122004536705813*std::sin(0.384079843759537*x_17 + 1.99359977245331) + 0.0073198980032941*std::sin(0.477439850568771*x_17 + 1.95439982414246) - 3.8868930265206e-5*std::sin(0.334319829940796*x_18 + 1.80159986019135) + 0.0891667500330628*std::sin(0.107840068638325*x_19 - 1.46535992622375) - 0.012984750120513*std::sin(0.404319852590561*x_2 - 7.38735961914063) + 9.54150593535914e-5*std::sin(0.260959982872009*x_20 + 5.02055978775024) - 0.0156837257911145*std::sin(0.367359846830368*x_20 + 8.22056007385254) - 0.0113680810988603*std::sin(0.293359935283661*x_21 - 4.38455963134766) - 0.0192105344898501*std::sin(0.347999840974808*x_21 - 1.16127991676331) + 0.000365946487643966*std::sin(0.396319836378098*x_21 - 4.40287971496582) - 0.0922192710085454*std::sin(0.137040033936501*x_22 + 4.94816017150879) + 0.00941815308180076*std::sin(0.273999959230423*x_22 - 7.55800008773804) + 0.000872679839265072*std::sin(0.342079848051071*x_22 - 1.16143989562988) + 0.000674952854371411*std::sin(0.276719957590103*x_23 - 1.14367985725403) - 7.94027485554656e-5*std::sin(0.313359916210175*x_23 - 7.38032007217407) + 4.70190540896268e-5*std::sin(0.365439832210541*x_24 + 2.03655982017517) - 0.000656624045894485*std::sin(0.333359837532043*x_25 - 1.14519989490509) - 0.00390187303165612*std::sin(0.375839829444885*x_25 - 4.37487983703613) + 0.0235034998277793*std::sin(0.195199996232986*x_26 - 1.19399988651276) - 6.35977961963582e-5*std::sin(0.261919975280762*x_26 - 7.38695955276489) - 0.011801113885756*std::sin(0.36999985575676*x_26 + 8.22991943359375) + 0.00432488423549412*std::sin(0.375039845705032*x_27 - 1.17775988578796) + 0.00827085537466791*std::sin(0.309839934110641*x_28 + 1.97959983348846) - 0.0139040589577442*std::sin(0.360319852828979*x_29 + 8.21487998962402) - 0.000892316973117931*std::sin(0.320239931344986*x_3 + 2.06399965286255) - 0.00849564201344668*std::sin(0.409039855003357*x_3 - 1.17767977714539) + 0.0128935596297188*std::sin(0.357599824666977*x_31 + 5.16951990127563) + 0.00866783074312283*std::sin(0.37391984462738*x_31 + 5.17328023910522) + 4.97999364854388e-5*std::sin(0.398239821195602*x_31 + 5.2007999420166) + 3.16802299635941e-5*std::sin(0.292239934206009*x_32 + 2.03519988059998) + 0.00141529070364629*std::sin(0.321919858455658*x_32 - 1.19455993175507) + 0.00201605170425158*std::sin(0.336319833993912*x_32 - 4.41016006469727) + 0.00925167289103722*std::sin(0.238239988684654*x_33 + 1.99767982959747) - 9.75263052119456e-5*std::sin(0.240239977836609*x_35 + 1.95999991893768) - 8.22380691940204e-5*std::sin(0.271359950304031*x_36 + 8.15679931640625) - 0.0132526251689169*std::sin(0.22367998957634*x_37 + 1.97847986221313) - 0.000317479233412193*std::sin(0.260879963636398*x_38 + 1.78807997703552) + 0.0171083422416853*std::sin(0.261039972305298*x_38 - 1.20975983142853) - 0.0157397062691017*std::sin(0.221039995551109*x_4 - 4.39103984832764) + 0.000430049150390887*std::sin(0.295199930667877*x_4 - 1.13903987407684) - 0.00204754895177481*std::sin(0.235759988427162*x_40 + 1.95503973960876) - 2.67051782913219e-5*std::sin(0.236879989504814*x_41 + 4.97887992858887) - 0.0176305296552827*std::sin(0.252079963684082*x_41 + 1.95879983901978) - 0.0183860227918894*std::sin(0.267199963331223*x_41 + 1.93695986270905) - 0.00135220531399428*std::sin(0.259679973125458*x_42 + 1.94903981685638) + 0.000575324945946088*std::sin(0.145360037684441*x_44 + 4.98343992233276) + 0.0178250711544498*std::sin(0.225679993629456*x_44 - 1.18967986106873) - 0.020588664539118*std::sin(0.192159995436668*x_47 + 2.00471973419189) + 0.0158382001657449*std::sin(0.242559969425201*x_48 + 1.78887987136841) + 0.0256795048580447*std::sin(0.338559836149216*x_5 + 2.04775977134705) + 0.0128490809618254*std::sin(0.294879943132401*x_53 - 4.42799949645996) + 0.00261951892674729*std::sin(0.170560017228127*x_55 - 1.18743991851807) + 0.0400543829071988*std::sin(0.185440003871918*x_55 - 4.38175964355469) + 0.00139312940773541*std::sin(0.105280071496964*x_57 + 5.14776039123535) - 7.24840150377297e-5*std::sin(0.234479993581772*x_57 + 5.18336009979248) - 0.0258058702692627*std::sin(0.241599977016449*x_57 - 4.2422399520874) - 0.0118156835807006*std::sin(0.358479857444763*x_6 + 2.01023983955383) + 0.00206931332558606*std::sin(0.146960034966469*x_60 - 1.22951984405518) - 0.009312246839436*std::sin(0.489599853754044*x_60 - 7.72096014022827) - 0.00692065526908124*std::sin(0.239919975399971*x_7 + 7.77871990203857) - 3.33231605793508e-5*std::sin(0.346719831228256*x_7 + 5.02895975112915) - 7.53790792523398e-5*std::sin(0.839039862155914*x_75 + 5.40751981735229) + 0.00738078994410715*std::sin(0.315759927034378*x_8 + 1.9851998090744) - 0.00110579810478336*std::sin(0.329119831323624*x_9 + 8.27431964874268) + 2.31767086840322e-5*std::sin(0.343199849128723*x_91 - 7.38391971588135) + 0.00158377434262202*std::sin(0.275199949741364*x_92 - 7.39559984207153) - 0.00725638424319879*std::sin(0.351359844207764*x_92 - 4.59311962127686) + 0.024419053346486*std::sin(0.279999971389771*x_94 + 1.98743987083435) + 0.00716653514864361*std::sin(0.287759929895401*x_94 + 8.18183994293213) - 0.00115568109227*std::sin(0.271839946508408*x_95 + 1.97663974761963) + 0.00125120868569117*std::sin(0.286479949951172*x_96 - 1.20391988754272) - 6.47567781934604e-5*std::sin(0.275359958410263*x_97 - 1.19951987266541) - 0.0115949639264965*std::sin(0.294719934463501*x_97 - 4.42967987060547) - 0.0136023670075306*std::sin(0.247839972376823*x_98 + 1.98023986816406) + 0.0269905227697361*std::sin(0.282159924507141*x_98 + 8.16495990753174) - 0.000623069568171365*std::sin(0.282799929380417*x_98 - 4.41296005249023) + 0.0560049966826875 + 2.46034388799257e-8*std::exp(-4.22904014587402*x_21));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-6.93541628915998e-6*x_1 - 9.80498469083825e-5*x_10 + 7.66778056976176e-6*x_100 + 9.72305779878601e-5*x_101 + 5.33893487203225e-6*x_102 - 8.69774304857505e-5*x_103 - 5.59852394702525e-5*x_104 + 7.0791279921188e-5*x_105 + 0.000145636296934161*x_106 - 7.49484144751782e-5*x_107 + 4.45590847747929e-5*x_108 - 5.41576676717548e-5*x_109 + 0.000102525537518435*x_11 - 2.26556896175561e-5*x_110 + 0.000235559660394757*x_111 + 7.14239996665981e-5*x_112 + 3.66619528617596e-5*x_113 + 1.23462496724678e-5*x_114 + 0.00038003929083057*x_115 + 5.63489813211377e-5*x_116 - 8.69902256890573e-5*x_117 + 0.00021842311159298*x_118 - 0.000137463519353187*x_119 - 0.000182805927527507*x_12 + 0.000143961186012898*x_120 + 1.22858675583011e-5*x_13 - 0.000130674920677086*x_14 - 3.29693665097144e-5*x_15 + 7.9106312717212e-5*x_16 + 1.77804894908563e-5*x_17 - 8.56959542210627e-5*x_18 + 0.000165419442807814*x_19 - 7.18802441023368e-6*x_2 + 0.000166291261518768*x_20 - 3.20991887726904e-5*x_21 + 3.52860176247494e-6*x_22 + 3.53739372372786e-6*x_23 + 2.49871275814662e-5*x_24 - 3.0713126858555e-5*x_25 - 9.89654734685292e-6*x_26 + 0.000183349009387891*x_27 + 2.7844836682062e-5*x_28 + 1.46402924169965e-5*x_29 + 2.77944010376468e-6*x_3 - 4.11218884929163e-6*x_30 - 7.03133276468337e-6*x_31 + 0.000104171022109541*x_33 - 4.06365467644967e-6*x_34 - 6.08293822150079e-5*x_35 - 0.000216388041073697*x_36 - 1.3957474401782e-5*x_37 + 1.7510159277688e-5*x_38 + 5.60970670981185e-5*x_39 + 1.18937183526826e-5*x_4 - 3.24028619718572e-5*x_40 + 0.000121081164774529*x_41 - 0.000151043732453547*x_42 + 0.000205422202601998*x_43 - 2.67163272033964e-5*x_44 + 0.000114103599237374*x_45 - 7.31073521171421e-5*x_46 - 0.000110666317021511*x_47 + 2.79398376837433e-5*x_48 + 5.96444468487149e-7*x_49 + 3.16871044726617e-5*x_5 + 0.000292192429713369*x_50 - 0.000151968572049908*x_51 + 0.000197382547905382*x_52 + 1.82462537151362e-5*x_53 + 0.000219761055632968*x_54 - 6.02039338336386e-5*x_55 - 8.57180704393466e-5*x_56 - 8.09794813625415e-5*x_57 - 5.93488357845732e-5*x_58 + 8.79763166534681e-5*x_59 + 0.000254276735917206*x_6 + 0.000215203003762733*x_60 + 9.63261305365603e-5*x_61 + 1.64102763088697e-5*x_62 - 4.99900697731931e-6*x_63 + 5.21156500089835e-5*x_64 - 6.25865397637128e-5*x_65 + 3.45802327684611e-5*x_66 - 1.9657005894593e-5*x_67 + 8.41608522822305e-6*x_68 - 3.80548233236974e-5*x_69 + 0.000108289109515119*x_7 - 4.52400386854126e-5*x_70 + 1.18490356875376e-6*x_71 + 3.47868451152823e-6*x_72 + 2.68383817495587e-5*x_73 - 9.89456808694458e-6*x_74 + 6.28529349974592e-7*x_75 - 2.27111429812789e-5*x_76 - 2.67393845531378e-5*x_77 + 1.99790890720221e-5*x_78 - 4.29799923274502e-5*x_79 - 3.22162564528331e-5*x_8 + 2.29989678847135e-6*x_80 + 5.06454164022429e-6*x_81 - 1.40285246170956e-5*x_82 + 1.22213973015714e-6*x_83 - 1.82078470685389e-5*x_84 + 5.64539088380345e-6*x_85 - 4.03743959638897e-6*x_86 + 1.07748596182206e-6*x_87 - 5.63091852244737e-5*x_88 - 4.01260182977104e-5*x_89 + 3.2920112798917e-5*x_9 + 3.45365769572965e-6*x_90 - 2.50239981982891e-6*x_91 - 1.17443722970674e-5*x_92 - 8.39431083456286e-5*x_93 - 3.29728952289572e-5*x_94 - 1.53678319104928e-5*x_95 + 0.000100866478333408*x_96 + 5.94915477157465e-6*x_97 - 3.52277301739611e-6*x_98 + 5.80663848089969e-6*x_99 + 9.52446040114043e-7*std::pow(-2.61807990074158*x_13 - 4.83735990524292, 2) + 1.31735835338086e-8*std::pow(-9.68360042572021*x_27 - 4.91775989532471, 2) + 1.49069852113146e-7*std::pow(-4.46895980834961*x_62 - 9.54120063781738, 2) - 0.00229329660034497*std::exp(0.013847314750659*x_10 + 0.00192802021992003*x_100 - 0.0517324861543921*x_103 + 0.048610846319445*x_104 + 0.0827213524832563*x_105 - 0.0854029502378133*x_106 - 0.0549397160156867*x_107 - 0.0480409948350075*x_108 + 0.0148044797328175*x_11 - 0.0443928641175372*x_110 + 0.0649525017170762*x_111 - 0.0149120685736793*x_112 + 0.093858584727765*x_113 + 0.101268259349828*x_114 - 0.0173493428137757*x_115 + 0.021678457656997*x_116 + 0.00149133191479539*x_117 + 0.0611844332727295*x_118 + 0.100135031301275*x_119 - 0.0216130387706698*x_12 - 0.00370951186942682*x_14 - 0.0513157192133048*x_16 + 0.00019174423916837*x_19 - 0.00773085044007122*x_23 - 0.0274636766378552*x_24 + 0.0672207046803211*x_27 - 0.00667242505754479*x_28 - 0.0561496548683741*x_29 - 0.021316253078234*x_30 - 4.55196739649187e-5*x_32 - 0.0390162528922745*x_33 - 0.00278589350523651*x_34 - 0.0851867026790631*x_35 + 0.081343935904949*x_36 - 0.0346656512550095*x_37 - 0.0364482783701984*x_38 + 0.0230526126110404*x_39 + 0.0359831570965707*x_4 - 0.101334768244081*x_40 - 0.121301701696847*x_42 + 0.0596953655668355*x_43 + 0.0185304954622835*x_44 - 0.0756442363393785*x_45 + 0.0831329613613904*x_46 - 0.120681781546408*x_49 + 0.034575678565543*x_50 + 0.0418458700776334*x_51 - 0.00276110550283261*x_52 - 0.00966105412588325*x_53 - 0.0123850852034482*x_54 - 0.0155187376935741*x_56 - 0.0571795841578017*x_58 - 0.0307736887979388*x_59 - 0.00687174215545961*x_6 + 0.00110014620856784*x_61 - 0.0320357982639596*x_62 + 0.0214519663202809*x_63 - 0.0146935952542457*x_64 - 0.00253067037720865*x_65 - 0.00750637290360476*x_66 + 6.02861227888366e-5*x_67 + 0.0161579710881649*x_68 - 0.00793640966262416*x_69 + 0.00193081978192962*x_70 + 0.00781589437033614*x_71 + 0.00440470081859806*x_72 + 0.000293872866709002*x_73 + 0.0235912141413685*x_74 + 3.71580475556139e-5*x_75 + 0.0100733399425523*x_76 + 0.0269389252477053*x_77 + 0.00050340889472968*x_78 - 0.0180080020138858*x_79 - 0.0640191885198651*x_8 - 0.00589065089032942*x_80 + 0.0321990293873376*x_81 + 0.000105607183893508*x_82 - 0.0106997746763032*x_83 + 5.87170800408538e-5*x_84 - 0.00126914890431669*x_85 + 0.0176159558500392*x_86 - 0.0253258455458838*x_87 + 0.000425229109074237*x_88 - 0.000549299523651345*x_89 - 0.000522511568829959*x_9 + 0.000949816014057741*x_90 + 0.0320294298380432*x_91 + 0.0387814849436305*x_93 - 2.46576314723815e-5*x_95 - 0.0423978388856249*x_96 - 0.096674063403547*x_99 - 4.77081706993551e-5*std::pow(-6.70760011672974*x_18 - 7.31832027435303, 2) - 0.624091020379861*std::sin(0.190880000591278*x_1 - 4.41607999801636) + 0.302015784264473*std::sin(0.228079989552498*x_101 + 1.98055982589722) + 0.667402898300605*std::sin(0.234159991145134*x_102 + 1.95911991596222) + 0.34302931153675*std::sin(0.184880003333092*x_109 - 7.38399982452393) + 0.63695736314008*std::sin(0.240399971604347*x_120 - 1.03391981124878) - 0.274008133499434*std::sin(0.319999933242798*x_13 - 4.28240013122559) + 0.619400576518775*std::sin(0.324719846248627*x_15 + 8.26583957672119) + 0.296831634589227*std::sin(0.384079843759537*x_17 + 1.99359977245331) - 0.315913219874625*std::sin(0.404319852590561*x_2 - 7.38735961914063) - 0.381578102644763*std::sin(0.367359846830368*x_20 + 8.22056007385254) - 0.467383796366914*std::sin(0.347999840974808*x_21 - 1.16127991676331) - 2.24365402248105*std::sin(0.137040033936501*x_22 + 4.94816017150879) - 0.0949308428373326*std::sin(0.375839829444885*x_25 - 4.37487983703613) + 0.571829741812785*std::sin(0.195199996232986*x_26 - 1.19399988651276) - 0.206695207721414*std::sin(0.409039855003357*x_3 - 1.17767977714539) + 0.313694595619145*std::sin(0.357599824666977*x_31 + 5.16951990127563) - 0.447323791907099*std::sin(0.267199963331223*x_41 + 1.93695986270905) - 0.500913090133022*std::sin(0.192159995436668*x_47 + 2.00471973419189) + 0.385336395767439*std::sin(0.242559969425201*x_48 + 1.78887987136841) + 0.624770980511599*std::sin(0.338559836149216*x_5 + 2.04775977134705) + 0.974505397243981*std::sin(0.185440003871918*x_55 - 4.38175964355469) - 0.627845395003071*std::sin(0.241599977016449*x_57 - 4.2422399520874) - 0.226562841487882*std::sin(0.489599853754044*x_60 - 7.72096014022827) - 0.168376477745524*std::sin(0.239919975399971*x_7 + 7.77871990203857) - 0.176544615001483*std::sin(0.351359844207764*x_92 - 4.59311962127686) + 0.594104753451649*std::sin(0.279999971389771*x_94 + 1.98743987083435) - 0.282100337268941*std::sin(0.294719934463501*x_97 - 4.42967987060547) + 0.656667465692429*std::sin(0.282159924507141*x_98 + 8.16495990753174)) - 0.00063061281063713*std::sin(0.368399828672409*x_1 + 8.37007999420166) - 0.000437713663544*std::sin(0.404959857463837*x_1 + 8.39888000488281) + 0.000227718021437031*std::sin(0.341039836406708*x_10 - 1.12095987796783) + 0.000959093306807064*std::sin(0.240799978375435*x_100 + 8.18143939971924) + 0.000399844027598485*std::sin(0.23327998816967*x_101 + 1.97543978691101) - 0.000305361036679608*std::sin(0.229759991168976*x_102 - 4.39823961257935) + 0.000916918951048913*std::sin(0.236399978399277*x_102 - 1.20351994037628) - 9.08162259023977e-5*std::sin(0.255919963121414*x_108 + 1.94351983070374) - 0.000343777978023039*std::sin(0.272799968719482*x_108 + 1.93503975868225) + 0.000487013770812224*std::sin(0.250639975070953*x_109 - 1.2137598991394) + 3.8744011773748e-5*std::sin(0.382559835910797*x_11 + 1.82871985435486) + 0.00110435193958401*std::sin(0.211439996957779*x_110 - 7.40647983551025) + 0.000178951762528447*std::sin(0.241679981350899*x_110 + 8.17327976226807) + 3.81775378387085e-5*std::sin(0.245359972119331*x_110 + 4.95287990570068) - 0.000970152715080972*std::sin(0.268559962511063*x_112 + 1.97895979881287) + 3.1971260234376e-5*std::sin(0.270159959793091*x_112 - 4.40351963043213) - 0.0011332009624337*std::sin(0.268879950046539*x_113 - 4.22904014587402) + 0.000203745072861014*std::sin(0.229999989271164*x_114 + 1.95623981952667) - 0.00136411095206821*std::sin(0.235119983553886*x_117 - 4.23808002471924) - 0.000561349415102016*std::sin(0.235199987888336*x_118 - 7.41671991348267) - 7.08418089441947e-5*std::sin(0.241999968886375*x_118 + 1.97351980209351) + 0.00099851509512546*std::sin(0.271119952201843*x_12 + 5.15176010131836) - 8.13567616729331e-5*std::sin(0.279279947280884*x_120 + 1.94519984722137) - 0.000167592703182585*std::sin(0.185840010643005*x_13 - 4.40351963043213) - 0.000719063601716544*std::sin(0.352799862623215*x_13 - 4.33256006240845) + 0.00028661501974459*std::sin(0.295119941234589*x_14 - 1.21431994438171) - 0.000419737490772972*std::sin(0.311599940061569*x_15 - 4.24927997589111) - 0.000513260113129976*std::sin(0.370479851961136*x_15 + 1.83439981937408) + 0.000310167607209492*std::sin(0.353039860725403*x_17 + 5.22735977172852) + 0.000488030147052605*std::sin(0.477439850568771*x_17 + 1.95439982414246) - 4.44355548423546e-5*std::sin(0.334319829940796*x_18 + 1.80159986019135) + 0.00594490006708501*std::sin(0.107840068638325*x_19 - 1.46535992622375) + 0.00010907995341689*std::sin(0.260959982872009*x_20 + 5.02055978775024) + 0.00040244051587703*std::sin(0.34623983502388*x_20 - 1.14527976512909) - 0.00075792945309976*std::sin(0.293359935283661*x_21 - 4.38455963134766) + 0.000254744566256937*std::sin(0.396319836378098*x_21 - 4.40287971496582) + 0.000627924409794607*std::sin(0.273999959230423*x_22 - 7.55800008773804) + 0.000607494414186162*std::sin(0.342079848051071*x_22 - 1.16143989562988) + 0.00046985168033095*std::sin(0.276719957590103*x_23 - 1.14367985725403) - 9.07744351078395e-5*std::sin(0.313359916210175*x_23 - 7.38032007217407) + 0.000161370558331554*std::sin(0.339599847793579*x_23 - 4.39879989624023) + 5.37529009000159e-5*std::sin(0.365439832210541*x_24 + 2.03655982017517) - 0.00045709253514685*std::sin(0.333359837532043*x_25 - 1.14519989490509) - 7.27059721338895e-5*std::sin(0.261919975280762*x_26 - 7.38695955276489) - 0.000786800491271635*std::sin(0.36999985575676*x_26 + 8.22991943359375) + 0.000452785456401505*std::sin(0.224879994988441*x_27 - 1.18111991882324) + 0.000288347445344709*std::sin(0.375039845705032*x_27 - 1.17775988578796) + 0.000551432105055772*std::sin(0.309839934110641*x_28 + 1.97959983348846) + 0.000425593507757849*std::sin(0.326559841632843*x_29 - 1.16359984874725) - 0.000927007443918256*std::sin(0.360319852828979*x_29 + 8.21487998962402) - 0.000329326176572878*std::sin(0.207359999418259*x_3 + 1.99087977409363) - 0.000621164317614072*std::sin(0.320239931344986*x_3 + 2.06399965286255) + 0.000559666475194584*std::sin(0.213279992341995*x_30 - 1.19399988651276) + 0.000577899133333507*std::sin(0.37391984462738*x_31 + 5.17328023910522) + 5.69320481357673e-5*std::sin(0.398239821195602*x_31 + 5.2007999420166) + 0.000312120813052903*std::sin(0.291759938001633*x_32 - 1.13471984863281) + 3.62173228427085e-5*std::sin(0.292239934206009*x_32 + 2.03519988059998) + 0.000985219502307726*std::sin(0.321919858455658*x_32 - 1.19455993175507) + 0.000134413622874087*std::sin(0.336319833993912*x_32 - 4.41016006469727) + 0.000616824890109618*std::sin(0.238239988684654*x_33 + 1.99767982959747) - 0.000389101575486989*std::sin(0.237599983811378*x_34 - 1.19663989543915) - 0.000111493561933628*std::sin(0.240239977836609*x_35 + 1.95999991893768) - 9.4015816974295e-5*std::sin(0.271359950304031*x_36 + 8.15679931640625) - 0.000883575236582391*std::sin(0.22367998957634*x_37 + 1.97847986221313) + 0.000192937900946697*std::sin(0.248799979686737*x_38 - 1.2339198589325) - 0.000221005289958841*std::sin(0.260879963636398*x_38 + 1.78807997703552) + 0.00114064250298004*std::sin(0.261039972305298*x_38 - 1.20975983142853) - 0.00104939319668358*std::sin(0.221039995551109*x_4 - 4.39103984832764) + 0.000299368044193598*std::sin(0.295199930667877*x_4 - 1.13903987407684) - 0.000608836287727644*std::sin(0.235519990324974*x_40 - 1.21535992622375) - 0.00142535039198735*std::sin(0.235759988427162*x_40 + 1.95503973960876) - 3.05297677718993e-5*std::sin(0.236879989504814*x_41 + 4.97887992858887) - 0.00117545763293572*std::sin(0.252079963684082*x_41 + 1.95879983901978) - 0.000223026893392707*std::sin(0.282239943742752*x_41 - 4.44271993637085) - 0.000941304173792032*std::sin(0.259679973125458*x_42 + 1.94903981685638) - 0.000468167526255288*std::sin(0.266719967126846*x_42 + 1.95047974586487) + 0.000400498184189222*std::sin(0.145360037684441*x_44 + 4.98343992233276) + 0.00118842804815238*std::sin(0.225679993629456*x_44 - 1.18967986106873) + 0.000280453904106891*std::sin(0.173040017485619*x_46 - 7.38007974624634) + 0.000856670252572987*std::sin(0.294879943132401*x_53 - 4.42799949645996) + 0.00182351309638831*std::sin(0.170560017228127*x_55 - 1.18743991851807) + 0.00096979246610127*std::sin(0.105280071496964*x_57 + 5.14776039123535) - 8.28648332595427e-5*std::sin(0.234479993581772*x_57 + 5.18336009979248) - 0.000787771877807773*std::sin(0.358479857444763*x_6 + 2.01023983955383) + 0.00144050112072394*std::sin(0.146960034966469*x_60 - 1.22951984405518) - 0.000416258238786131*std::sin(0.400799870491028*x_60 + 8.19935989379883) - 0.000514987667894136*std::sin(0.312239944934845*x_7 - 4.20567989349365) - 3.80955462201085e-5*std::sin(0.346719831228256*x_7 + 5.02895975112915) - 5.02565242243189e-6*std::sin(0.839039862155914*x_75 + 5.40751981735229) + 0.000492089917122617*std::sin(0.315759927034378*x_8 + 1.9851998090744) + 0.000140715197255777*std::sin(0.398159831762314*x_8 + 7.99560022354126) - 0.000769773909798653*std::sin(0.329119831323624*x_9 + 8.27431964874268) + 2.64959674158177e-5*std::sin(0.343199849128723*x_91 - 7.38391971588135) - 0.000578134797509317*std::sin(0.371119856834412*x_91 - 7.39224004745483) - 0.000160682449106707*std::sin(0.198400005698204*x_92 - 1.00927984714508) + 0.00110250520658813*std::sin(0.275199949741364*x_92 - 7.39559984207153) + 0.000477805182650943*std::sin(0.287759929895401*x_94 + 8.18183994293213) - 0.000804498713670109*std::sin(0.271839946508408*x_95 + 1.97663974761963) - 0.000195962876626324*std::sin(0.294079929590225*x_95 + 4.97615957260132) + 0.000870997877272743*std::sin(0.286479949951172*x_96 - 1.20391988754272) - 7.40309380576272e-5*std::sin(0.275359958410263*x_97 - 1.19951987266541) + 0.000374321966885335*std::sin(0.276799947023392*x_97 - 1.19999980926514) - 0.000906893124461743*std::sin(0.247839972376823*x_98 + 1.98023986816406) - 0.000433734418148414*std::sin(0.282799929380417*x_98 - 4.41296005249023) + 0.17099205940197 + 2.81270271705447e-8*std::exp(-4.22904014587402*x_21));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
