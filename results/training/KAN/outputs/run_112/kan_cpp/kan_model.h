
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.067349066922766*x_1 + 0.621083666299571*x_10 + 62.9228714744669*x_100 + 25.0021959072344*x_101 + 46.9706460907457*x_102 - 95.8495283152528*x_103 + 312.559401546736*x_104 + 58.0212563959181*x_105 + 78.8432819000619*x_106 + 23.6947667587726*x_107 - 38.8351417807352*x_108 + 63.5982223075801*x_109 + 0.634431064379823*x_110 + 63.0275816700665*x_111 + 23.5574027522399*x_112 + 82.0043062062583*x_113 - 88.1500260293677*x_114 - 50.0001289409731*x_115 + 86.24930502202*x_116 + 49.7310671166828*x_117 - 2.04079277272618*x_118 - 22.0208481567379*x_119 - 2.49387731226565*x_12 - 87.7204829664642*x_120 + 185.608102507271*x_13 + 31.3861406938531*x_14 + 209.67538107583*x_18 - 0.0810002976033456*x_19 - 35.8252404136794*x_2 + 2.52053718035015*x_20 - 2.78134384089219*x_21 - 0.787019889545855*x_22 - 45.4552748224353*x_24 + 4.21370261599294*x_25 - 10.0211090620408*x_26 + 37.4066959642114*x_27 - 0.0290481834073598*x_28 - 190.612930540636*x_29 - 14.4929410629257*x_3 - 0.419169531078506*x_30 - 12.3842498334954*x_31 - 4.36016711993753*x_32 - 160.215586017435*x_33 + 474.647082060885*x_34 + 642.748326440202*x_35 - 320.01994119627*x_36 + 1064.1544385333*x_37 - 232.082297997626*x_38 + 804.38736681182*x_39 + 19.8245170624546*x_4 + 901.763275860316*x_40 - 0.0709526542293001*x_42 + 91.6628826186549*x_43 - 39.405918690561*x_44 + 106.101393949336*x_45 + 0.523869983578388*x_46 - 662.494560615566*x_47 + 413.188232133329*x_48 + 3.97955231565739*x_5 - 3.71203923727484*x_52 - 44.7833527970033*x_53 + 0.152390441446197*x_54 - 86.4622230303607*x_56 - 204.024814798855*x_59 + 28.1084374094342*x_6 + 3.82162782630755*x_61 - 6.08524429642732*x_62 + 34.3420562674786*x_63 + 11.3878138882541*x_64 - 16.2504896527362*x_65 + 16.2504286866869*x_66 + 27.5926607099514*x_67 + 11.7206019953291*x_68 + 26.311689596501*x_69 + 78.6758646792425*x_7 - 28.025027057565*x_70 + 31.404109624522*x_71 - 12.6425220496663*x_72 + 34.2672118287537*x_73 - 63.1613579350119*x_74 - 44.1723461129622*x_75 - 46.3693995511069*x_76 - 42.5168260413065*x_77 - 17.0085846113094*x_78 - 186.66894991636*x_79 + 84.0249196991249*x_8 + 20.0369656655058*x_80 - 55.5569438270315*x_81 + 36.3065936061346*x_82 - 82.6839698136563*x_83 + 37.5297686027557*x_84 + 106.911228677653*x_85 + 212.875894441769*x_86 + 370.106776633626*x_87 - 32.5903997032169*x_88 + 24.4136269839658*x_89 - 44.199522449226*x_9 + 16.1060576216981*x_90 - 3.73292220165456*x_91 - 47.6218401444791*x_92 + 12.1748504788884*x_93 + 42.1176606155771*x_94 + 41.9045588025098*x_95 + 31.3506762860456*x_96 - 12.6360604008131*x_97 - 36.4445389717329*x_98 + 18.3902643599573*x_99 + 0.00045822011721819*std::pow(-9.59200000762939*x_16 - 6.19047975540161, 2) - 0.0307518475350334*std::pow(-9.63535976409912*x_18 - 5.02335977554321, 2) + 0.260500575516564*std::pow(-7.45879983901978*x_28 - 6.84511995315552, 2) + 0.0671695488695411*std::exp(0.779199838638306*x_1) - 1.30623864889746*std::exp(1.14455986022949*x_1) + 0.0050169957805086*std::exp(1.20367991924286*x_1) - 2.04170238632535*std::exp(1.76095998287201*x_1) - 0.0205279322672667*std::exp(0.533119857311249*x_10) - 0.0137138365884512*std::exp(0.675439834594727*x_10) + 2.34465186271621*std::exp(0.918319821357727*x_10) + 0.0194543578840258*std::exp(0.870079874992371*x_11) - 0.0100654086893684*std::exp(0.924879848957062*x_11) + 1.41948537848482*std::exp(0.94023984670639*x_11) + 0.00938198741604931*std::exp(0.976159811019897*x_11) - 1.82130833222546*std::exp(0.993999779224396*x_11) + 0.230274082329875*std::exp(0.283759832382202*x_12) - 0.690766944275236*std::exp(0.713359832763672*x_12) + 0.00044966874065719*std::exp(1.27959990501404*x_12) - 0.0549485343773217*std::exp(0.310159832239151*x_13) - 0.000745892772284631*std::exp(1.05879986286163*x_13) - 2.04039050446245e-5*std::exp(1.53175985813141*x_13) - 0.36816597967121*std::exp(0.278959840536118*x_15) + 0.0124607647355116*std::exp(0.582399845123291*x_15) - 0.0454374549229653*std::exp(0.681759834289551*x_15) + 0.359770290872096*std::exp(0.954799830913544*x_15) - 3.72031794503425*std::exp(1.00311982631683*x_15) - 0.0264854198090831*std::exp(0.590239822864532*x_16) - 3.21239613664403*std::exp(0.650239825248718*x_16) + 32.6541437499442*std::exp(0.729439854621887*x_16) + 0.0235591083135472*std::exp(0.863999843597412*x_16) - 0.0352421647500329*std::exp(0.61847984790802*x_17) - 0.100282831493039*std::exp(0.625439822673798*x_17) - 52.4792982849293*std::exp(0.647039830684662*x_17) - 5.11915488609729*std::exp(0.67199981212616*x_17) + 0.00355858708370208*std::exp(1.05343985557556*x_17) - 77.1790678577402*std::exp(0.750399827957153*x_19) - 0.0357453677065874*std::exp(0.754719853401184*x_19) + 4.244987087801*std::exp(0.763839840888977*x_19) - 0.0571058406833772*std::exp(0.82999986410141*x_19) + 0.0535128415857738*std::exp(0.768799841403961*x_2) + 1.83339658204133*std::exp(0.44191986322403*x_20) + 0.0143698128764867*std::exp(0.842719852924347*x_20) - 0.00368815246792948*std::exp(0.891919851303101*x_20) + 0.00555121222003548*std::exp(0.933999836444855*x_20) + 7.89275046963174*std::exp(0.636719882488251*x_22) + 6.55208297413236e-5*std::exp(1.36591982841492*x_22) - 8.83559594780609e-5*std::exp(1.53999984264374*x_22) + 0.176201725404825*std::exp(0.463439851999283*x_23) + 71.5390085126656*std::exp(0.544079840183258*x_23) + 0.0129399327018696*std::exp(0.579119861125946*x_23) + 1.40008266658682*std::exp(0.848079860210419*x_23) - 0.00347625811853891*std::exp(1.14591991901398*x_23) - 0.0499101547023477*std::exp(0.482319831848145*x_24) - 0.127148107252431*std::exp(0.533679842948914*x_24) - 8.57591977945529*std::exp(0.572719871997833*x_24) + 0.0212645161815938*std::exp(0.535999834537506*x_25) - 0.0917626597956843*std::exp(0.614799857139587*x_25) - 0.0182922490522465*std::exp(0.786159873008728*x_25) - 1.67911111452107*std::exp(1.07983982563019*x_25) + 0.226167469856247*std::exp(0.489839851856232*x_26) + 11.1354371859175*std::exp(0.850239872932434*x_26) - 0.00166438216196501*std::exp(0.868559896945953*x_26) - 0.000514075594160785*std::exp(1.1283198595047*x_26) - 0.00147403873162834*std::exp(0.954079806804657*x_27) - 0.164485894550721*std::exp(0.98039984703064*x_27) + 0.038089028134274*std::exp(0.568239867687225*x_28) - 0.0964908818112372*std::exp(0.650319814682007*x_28) - 0.153605599432588*std::exp(1.03335976600647*x_28) + 0.00231212741898192*std::exp(1.16567981243134*x_29) - 0.000493595917657232*std::exp(1.36007988452911*x_29) - 0.187905132237421*std::exp(0.599999845027924*x_3) - 0.041126116560411*std::exp(0.637119889259338*x_3) + 0.0685234633879895*std::exp(0.828319907188416*x_30) + 0.00605662616369328*std::exp(0.892719864845276*x_30) + 0.00366709604501116*std::exp(1.10247993469238*x_30) + 10.9790029467498*std::exp(0.882719874382019*x_32) - 0.550066885466857*std::exp(0.415839850902557*x_33) - 0.053135161208857*std::exp(0.467359870672226*x_33) + 2.8621978104239*std::exp(0.612639844417572*x_4) - 0.017488634055346*std::exp(0.691119849681854*x_4) - 0.00253107521079208*std::exp(1.22247993946075*x_4) + 17.0644156665662*std::exp(0.737679839134216*x_41) + 0.0115762539161137*std::exp(0.798239827156067*x_41) + 0.0516886482023107*std::exp(0.799759864807129*x_41) + 0.00772665031806265*std::exp(0.821119904518127*x_41) + 0.787144417192166*std::exp(0.822159886360168*x_41) + 2.72942938723082*std::exp(0.807039856910706*x_42) - 0.000638052657861223*std::exp(0.848479866981506*x_43) - 0.000253802485316517*std::exp(0.914319813251495*x_44) + 0.00113142986165097*std::exp(0.967199802398682*x_44) + 0.0124966047169829*std::exp(0.543519854545593*x_45) - 0.0502006446356334*std::exp(0.547439873218536*x_45) + 1.17584270299126*std::exp(0.731919825077057*x_46) + 15.9459502465613*std::exp(0.767999827861786*x_46) - 0.0895106611960261*std::exp(0.570559859275818*x_47) + 10.1160475132976*std::exp(0.685039818286896*x_49) - 0.110834604222202*std::exp(0.712159812450409*x_49) + 2.79567784143316*std::exp(0.735519826412201*x_49) + 0.0709677582774111*std::exp(0.737599849700928*x_49) + 0.00732168528329759*std::exp(0.799999833106995*x_49) - 0.148322061337355*std::exp(0.508159816265106*x_50) + 0.0129240597229261*std::exp(0.55079984664917*x_50) + 2.55982206698362*std::exp(0.554719865322113*x_50) + 107.355550361976*std::exp(0.564399838447571*x_50) + 0.114035921556752*std::exp(0.585679829120636*x_50) - 23.6597059012731*std::exp(0.487999856472015*x_51) - 0.602429192807725*std::exp(0.494799852371216*x_51) - 1.16951108079191*std::exp(0.495199859142303*x_51) + 0.921990772958076*std::exp(0.502639830112457*x_51) + 216.543517727912*std::exp(0.503999829292297*x_51) + 0.020579784640761*std::exp(0.507519841194153*x_52) - 5.96422938546728*std::exp(0.658879816532135*x_52) + 0.00209607825883609*std::exp(0.705439865589142*x_52) + 0.0128980237604664*std::exp(0.773359835147858*x_52) - 0.0313157318580004*std::exp(0.525039851665497*x_53) + 75.3801300331873*std::exp(0.453999847173691*x_54) - 10.4878827376023*std::exp(0.459519863128662*x_54) + 0.453445231785164*std::exp(0.508879840373993*x_54) - 0.177793259104816*std::exp(0.512559831142426*x_54) + 1.5986254224085*std::exp(0.651999831199646*x_55) - 613.90471730831*std::exp(0.652239859104156*x_55) - 30.0321454836781*std::exp(0.653599858283997*x_55) + 0.0456690869102532*std::exp(0.711279809474945*x_55) + 7.54082359060828*std::exp(0.469519853591919*x_56) - 0.230555269925132*std::exp(0.561119854450226*x_56) - 0.209526676800466*std::exp(0.585519850254059*x_56) + 11.7217808033946*std::exp(0.610479831695557*x_57) + 275.338179191952*std::exp(0.631999850273132*x_57) + 0.442662243451386*std::exp(0.635999858379364*x_57) - 0.0662517380673645*std::exp(0.638479828834534*x_57) + 0.0307414968621575*std::exp(0.672319829463959*x_57) - 0.210336601968631*std::exp(0.59175980091095*x_58) - 0.0376779740775956*std::exp(0.593759834766388*x_58) + 127.352846224838*std::exp(0.61847984790802*x_58) - 4.07352328189324*std::exp(0.626239836215973*x_58) - 0.0234928541794202*std::exp(0.706959843635559*x_58) + 0.0192875433213637*std::exp(0.621359825134277*x_59) + 0.0253988886380948*std::exp(0.799279868602753*x_60) + 0.00678067271967167*std::exp(0.800079882144928*x_60) - 13.5551901133526*std::exp(0.807039856910706*x_60) - 0.0678355179050219*std::exp(0.808319866657257*x_60) + 1.87983432583288*std::exp(0.832079887390137*x_60) + 0.0119419988954188*std::exp(1.13375985622406*x_61) - 4.55652883258114*std::exp(1.2727198600769*x_61) - 0.0215898775867643*std::exp(1.33911991119385*x_61) - 0.0421976829071148*std::exp(0.915039837360382*x_66) - 2.17908935696505*std::exp(0.965039789676666*x_66) + 0.0164578840877105*std::exp(1.11287987232208*x_66) + 12.0861870910343*std::exp(0.34607982635498*x_8) - 0.00585465262473875*std::exp(0.950719833374023*x_8) - 1.01428090819645*std::log(8.08096027374268 - 1.18407988548279*x_5) + 1.01105109198596*std::log(9.57600021362305 - 1.22015988826752*x_21) + 0.193312584091867*std::sin(0.275039941072464*x_100 + 1.92927980422974) + 17.8755439612743*std::sin(0.226159989833832*x_101 + 1.98423981666565) + 1.47263899721136*std::sin(0.225599989295006*x_102 - 7.41752004623413) + 322.712951518533*std::sin(0.223199993371964*x_110 - 1.21599984169006) + 28.1545043652253*std::sin(0.268159955739975*x_120 + 1.97151982784271) - 0.264149208302795*std::sin(0.303919941186905*x_120 + 1.93567979335785) + 1986.92730046141*std::sin(0.152400031685829*x_30 + 1.75583982467651) + 23.1888291761141*std::sin(0.390159845352173*x_31 - 7.40823984146118) - 0.194785261543844*std::sin(0.44327986240387*x_31 - 7.37296009063721) - 34.1931619404155*std::sin(0.297759920358658*x_42 - 4.28904008865356) - 0.317916565313017*std::sin(0.238159984350204*x_55 - 4.43512010574341) + 0.43930121411357*std::sin(0.299839943647385*x_91 - 1.14311993122101) - 49.3740229202376*std::sin(0.467279851436615*x_91 + 1.77087986469269) - 18.5659592233062*std::sin(0.308479934930801*x_92 + 8.217360496521) - 0.699418143223536*std::sin(0.270239949226379*x_95 + 1.96583986282349) + 1.00359104480352*std::sin(0.334639847278595*x_97 + 1.84383988380432) - 0.243529278544688*std::sin(0.268479973077774*x_98 + 1.9592798948288) - 2563.60334569896);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00441521762182725*x_1 + 0.111559029905335*x_10 - 16.0671295931585*x_100 - 6.12471420228488*x_101 - 12.9079182197667*x_102 + 25.2154501396736*x_103 - 99.8992120441226*x_104 - 12.6100140603706*x_105 - 27.4198167061169*x_106 - 6.99811679034442*x_107 + 9.47251138372862*x_108 - 17.0702372292581*x_109 - 0.208146683813854*x_110 - 13.2810546003587*x_111 - 4.09058821530598*x_112 - 21.6535390161848*x_113 + 21.6775018708321*x_114 + 14.549891812932*x_115 - 21.7212820716842*x_116 - 10.6386400505187*x_117 + 2.75855704245295*x_118 + 3.3547607905816*x_119 + 1.36688489640211*x_12 + 21.925891331722*x_120 - 45.6372078463393*x_13 - 9.24133569674774*x_14 - 52.387561231367*x_18 - 0.028327954189841*x_19 + 9.42357744311387*x_2 - 0.641890521151129*x_20 + 1.20840723765632*x_21 - 0.0899985523697977*x_22 + 11.5901257303788*x_24 + 0.711354814817813*x_25 - 1.691757779498*x_26 - 9.69459796143426*x_27 - 0.399777419414572*x_28 + 46.712652793034*x_29 + 5.24084717366997*x_3 - 0.0707639554404946*x_30 + 2.80970620865959*x_31 - 1.03799878268854*x_32 + 42.8154238496257*x_33 - 142.485593986313*x_34 - 151.983604678937*x_35 + 73.7865140665064*x_36 - 289.885180485628*x_37 + 15.3387449653397*x_38 - 203.671402536991*x_39 - 5.02778607337944*x_4 - 113.413330524515*x_40 + 0.0477620026236919*x_42 - 22.062426505243*x_43 + 8.16361791239106*x_44 - 21.1263467594933*x_45 + 0.367199423239058*x_46 + 163.052032488853*x_47 - 104.32123845959*x_48 - 2.12811196246292*x_5 - 0.62666429619544*x_52 + 12.9345168366304*x_53 + 2.09728286862071*x_54 + 21.1673324765269*x_56 + 57.3648407065299*x_59 - 4.35657623800164*x_6 + 0.645765894171208*x_61 + 1.55530868995412*x_62 - 8.11043210798589*x_63 - 2.40386430203536*x_64 + 4.53880226679366*x_65 - 4.13731850666051*x_66 - 6.47643076566904*x_67 - 4.89062154000336*x_68 - 5.7368641995572*x_69 - 20.6417591570715*x_7 + 7.41576703039773*x_70 - 7.18008854092981*x_71 + 3.17403168064549*x_72 - 6.63391117891128*x_73 + 14.5778787212461*x_74 + 10.9187320644459*x_75 + 11.6587593347753*x_76 + 10.143877030863*x_77 + 5.42337341970558*x_78 + 47.7606911048448*x_79 - 21.5297423347338*x_8 - 5.37223811210789*x_80 + 14.0167749283769*x_81 - 10.5175170693435*x_82 + 22.2031462547545*x_83 - 9.18899435206191*x_84 - 26.3762830801437*x_85 - 65.1836445104331*x_86 - 91.0056868600849*x_87 + 0.849956926269715*x_88 - 5.0921781893298*x_89 + 11.6207449112899*x_9 - 5.64694135133945*x_90 - 0.327951063383492*x_91 + 12.5290842759586*x_92 - 3.98495945288706*x_93 - 9.48013001741531*x_94 - 10.1461267090944*x_95 - 6.86467241908591*x_96 + 3.17750365101514*x_97 + 12.1449074821952*x_98 - 8.50937503811045*x_99 - 3.00396372014713e-5*std::pow(-9.59200000762939*x_16 - 6.19047975540161, 2) - 0.00519150894169935*std::pow(-9.63535976409912*x_18 - 5.02335977554321, 2) - 0.066340164105521*std::pow(-7.45879983901978*x_28 - 6.84511995315552, 2) + 0.0234909742263719*std::exp(0.779199838638306*x_1) - 0.220518445859844*std::exp(1.14455986022949*x_1) + 0.0690467144956595*std::exp(1.20367991924286*x_1) + 0.519948453453014*std::exp(1.76095998287201*x_1) - 0.282516936520228*std::exp(0.533119857311249*x_10) + 0.000899041007318268*std::exp(0.675439834594727*x_10) - 0.597098831871942*std::exp(0.918319821357727*x_10) - 0.00127537362691879*std::exp(0.870079874992371*x_11) - 0.138525809161931*std::exp(0.924879848957062*x_11) + 0.239636692612375*std::exp(0.94023984670639*x_11) + 0.00328113004020039*std::exp(0.976159811019897*x_11) + 0.463821983529197*std::exp(0.993999779224396*x_11) - 0.0150961287603123*std::exp(0.283759832382202*x_12) - 0.116614872122717*std::exp(0.713359832763672*x_12) + 0.000157261094870523*std::exp(1.27959990501404*x_12) - 0.756232600363328*std::exp(0.310159832239151*x_13) + 4.88986568434767e-5*std::exp(1.05879986286163*x_13) - 7.13578720696101e-6*std::exp(1.53175985813141*x_13) + 0.024135938261264*std::exp(0.278959840536118*x_15) + 0.171492044787654*std::exp(0.582399845123291*x_15) - 0.0158906841041972*std::exp(0.681759834289551*x_15) + 0.0607362103981708*std::exp(0.954799830913544*x_15) + 0.94743169956104*std::exp(1.00311982631683*x_15) - 0.36450722700629*std::exp(0.590239822864532*x_16) - 0.542314839739914*std::exp(0.650239825248718*x_16) - 8.31584057271624*std::exp(0.729439854621887*x_16) + 0.00823924554361267*std::exp(0.863999843597412*x_16) - 0.485022470450998*std::exp(0.61847984790802*x_17) + 0.00657426368330467*std::exp(0.625439822673798*x_17) + 13.3645971931583*std::exp(0.647039830684662*x_17) - 0.86421273827017*std::exp(0.67199981212616*x_17) + 0.00124453236432934*std::exp(1.05343985557556*x_17) + 19.6547436298008*std::exp(0.750399827957153*x_19) - 0.491947832240134*std::exp(0.754719853401184*x_19) + 0.71663624107823*std::exp(0.763839840888977*x_19) + 0.00374370018197353*std::exp(0.82999986410141*x_19) - 0.00350815314835033*std::exp(0.768799841403961*x_2) + 0.309512940271485*std::exp(0.44191986322403*x_20) + 0.0050255050033901*std::exp(0.842719852924347*x_20) - 0.0507584262795161*std::exp(0.891919851303101*x_20) - 0.000363922042817766*std::exp(0.933999836444855*x_20) - 2.01000078545318*std::exp(0.636719882488251*x_22) + 0.000901734468712124*std::exp(1.36591982841492*x_22) - 3.09004244002996e-5*std::exp(1.53999984264374*x_22) - 0.0115512953415658*std::exp(0.463439851999283*x_23) - 18.2184225707199*std::exp(0.544079840183258*x_23) + 0.178086623538771*std::exp(0.579119861125946*x_23) + 0.236361138120993*std::exp(0.848079860210419*x_23) - 0.00121573973982493*std::exp(1.14591991901398*x_23) - 0.686891588698495*std::exp(0.482319831848145*x_24) + 0.00833547648650718*std::exp(0.533679842948914*x_24) - 1.4477817688065*std::exp(0.572719871997833*x_24) + 0.292654218164401*std::exp(0.535999834537506*x_25) + 0.006015704909769*std::exp(0.614799857139587*x_25) - 0.00639728505342919*std::exp(0.786159873008728*x_25) + 0.427609446420011*std::exp(1.07983982563019*x_25) + 0.0790967677266333*std::exp(0.489839851856232*x_26) - 2.83579692227405*std::exp(0.850239872932434*x_26) - 0.0229061623681925*std::exp(0.868559896945953*x_26) + 3.37013670121504e-5*std::exp(1.1283198595047*x_26) - 0.0202865491443504*std::exp(0.954079806804657*x_27) - 0.0277684126578301*std::exp(0.98039984703064*x_27) - 0.0024970108109972*std::exp(0.568239867687225*x_28) - 0.0337454226782148*std::exp(0.650319814682007*x_28) - 0.0259316075901097*std::exp(1.03335976600647*x_28) + 0.000808612332842709*std::exp(1.16567981243134*x_29) + 3.23587763465439e-5*std::exp(1.36007988452911*x_29) - 0.0657154126040867*std::exp(0.599999845027924*x_3) - 0.566000720888397*std::exp(0.637119889259338*x_3) + 0.02396447407255*std::exp(0.828319907188416*x_30) + 0.0833546918967265*std::exp(0.892719864845276*x_30) - 0.000240404623532999*std::exp(1.10247993469238*x_30) - 2.79595872584192*std::exp(0.882719874382019*x_32) - 0.192372991135899*std::exp(0.415839850902557*x_33) - 0.731275940060062*std::exp(0.467359870672226*x_33) + 0.483194562824234*std::exp(0.612639844417572*x_4) - 0.240688407040304*std::exp(0.691119849681854*x_4) - 0.000885184187513386*std::exp(1.22247993946075*x_4) - 4.3456953346072*std::exp(0.737679839134216*x_41) + 0.159318909970088*std::exp(0.798239827156067*x_41) - 0.003388564100717*std::exp(0.799759864807129*x_41) + 0.00270221471682541*std::exp(0.821119904518127*x_41) + 0.13288526081584*std::exp(0.822159886360168*x_41) - 0.695087882643894*std::exp(0.807039856910706*x_42) - 0.00878123913751319*std::exp(0.848479866981506*x_43) - 0.00349297238997515*std::exp(0.914319813251495*x_44) - 7.4173396771059e-5*std::exp(0.967199802398682*x_44) + 0.171985294747679*std::exp(0.543519854545593*x_45) - 0.017556497983533*std::exp(0.547439873218536*x_45) + 0.198505078423557*std::exp(0.731919825077057*x_46) - 4.0608622613507*std::exp(0.767999827861786*x_46) + 0.00586807014130303*std::exp(0.570559859275818*x_47) - 2.57619489247056*std::exp(0.685039818286896*x_49) + 0.00726600857338228*std::exp(0.712159812450409*x_49) + 0.471964700507066*std::exp(0.735519826412201*x_49) + 0.0248193088781339*std::exp(0.737599849700928*x_49) + 0.100765146214987*std::exp(0.799999833106995*x_49) + 0.00972358206051202*std::exp(0.508159816265106*x_50) + 0.177868170685061*std::exp(0.55079984664917*x_50) + 0.432147666404927*std::exp(0.554719865322113*x_50) - 27.3396126458813*std::exp(0.564399838447571*x_50) + 0.0398813888027314*std::exp(0.585679829120636*x_50) - 3.99421773291849*std::exp(0.487999856472015*x_51) - 8.29096899807017*std::exp(0.494799852371216*x_51) + 0.0766698956461593*std::exp(0.495199859142303*x_51) + 0.322444647150699*std::exp(0.502639830112457*x_51) - 55.1458762560126*std::exp(0.503999829292297*x_51) + 0.283230558015086*std::exp(0.507519841194153*x_52) + 1.51887555492065*std::exp(0.658879816532135*x_52) - 0.000137413064322851*std::exp(0.705439865589142*x_52) + 0.00451078128151078*std::exp(0.773359835147858*x_52) + 0.00205297233439655*std::exp(0.525039851665497*x_53) - 19.1966186131485*std::exp(0.453999847173691*x_54) - 1.77055823880915*std::exp(0.459519863128662*x_54) + 0.158581834063303*std::exp(0.508879840373993*x_54) + 0.011655631867059*std::exp(0.512559831142426*x_54) - 0.104801439102538*std::exp(0.651999831199646*x_55) + 156.339538254867*std::exp(0.652239859104156*x_55) - 5.07000926169755*std::exp(0.653599858283997*x_55) + 0.0159716919587229*std::exp(0.711279809474945*x_55) + 1.27303743470442*std::exp(0.469519853591919*x_56) - 0.080631297882982*std::exp(0.561119854450226*x_56) + 0.0137359865239589*std::exp(0.585519850254059*x_56) + 1.97886418967629*std::exp(0.610479831695557*x_57) - 70.1187702019032*std::exp(0.631999850273132*x_57) + 0.154810736813208*std::exp(0.635999858379364*x_57) - 0.911793639721737*std::exp(0.638479828834534*x_57) - 0.00201532708423113*std::exp(0.672319829463959*x_57) + 0.0137890829666898*std::exp(0.59175980091095*x_58) - 0.518545446862399*std::exp(0.593759834766388*x_58) - 32.4322074955405*std::exp(0.61847984790802*x_58) - 0.687689821500224*std::exp(0.626239836215973*x_58) - 0.00821607471422105*std::exp(0.706959843635559*x_58) - 0.00126443772787378*std::exp(0.621359825134277*x_59) - 0.00166508053954697*std::exp(0.799279868602753*x_60) + 0.0933194273717757*std::exp(0.800079882144928*x_60) + 3.45202130482114*std::exp(0.807039856910706*x_60) - 0.0237238812759402*std::exp(0.808319866657257*x_60) + 0.317352533058602*std::exp(0.832079887390137*x_60) + 0.164352497851987*std::exp(1.13375985622406*x_61) + 1.16038465521835*std::exp(1.2727198600769*x_61) - 0.00755055328607672*std::exp(1.33911991119385*x_61) - 0.0147576498319039*std::exp(0.915039837360382*x_66) - 0.367872592648559*std::exp(0.965039789676666*x_66) + 0.226502646907072*std::exp(1.11287987232208*x_66) + 2.04038304634133*std::exp(0.34607982635498*x_8) - 0.00204752743209898*std::exp(0.950719833374023*x_8) - 0.35472095724538*std::log(8.08096027374268 - 1.18407988548279*x_5) + 0.353591404782494*std::log(9.57600021362305 - 1.22015988826752*x_21) + 2.66047638590125*std::sin(0.275039941072464*x_100 + 1.92927980422974) + 3.01773889217465*std::sin(0.226159989833832*x_101 + 1.98423981666565) + 0.515020947891598*std::sin(0.225599989295006*x_102 - 7.41752004623413) - 82.1834275040027*std::sin(0.223199993371964*x_110 - 1.21599984169006) + 4.75302698462802*std::sin(0.268159955739975*x_120 + 1.97151982784271) - 0.0923799898702504*std::sin(0.303919941186905*x_120 + 1.93567979335785) - 505.999201410473*std::sin(0.152400031685829*x_30 + 1.75583982467651) + 3.91472459917047*std::sin(0.390159845352173*x_31 - 7.40823984146118) - 0.0681215764526066*std::sin(0.44327986240387*x_31 - 7.37296009063721) - 5.77246962987871*std::sin(0.297759920358658*x_42 - 4.28904008865356) - 4.3753463783825*std::sin(0.238159984350204*x_55 - 4.43512010574341) + 0.1536352956367*std::sin(0.299839943647385*x_91 - 1.14311993122101) + 12.5737948048028*std::sin(0.467279851436615*x_91 + 1.77087986469269) - 3.13429439350643*std::sin(0.308479934930801*x_92 + 8.217360496521) + 0.0458519093446028*std::sin(0.270239949226379*x_95 + 1.96583986282349) + 0.350982428259061*std::sin(0.334639847278595*x_97 + 1.84383988380432) - 3.35158674686076*std::sin(0.268479973077774*x_98 + 1.9592798948288) + 535.538111181605);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0900043183873256*x_1 + 0.714147313095954*x_10 + 60.6883927903518*x_100 + 25.4153233285*x_101 + 46.1351998303499*x_102 - 96.1676074145541*x_103 + 337.390382323684*x_104 + 52.1310561660505*x_105 + 82.6454794294553*x_106 + 24.4315976841687*x_107 - 37.8503493238072*x_108 + 66.6108363692962*x_109 + 1.57314743602473*x_110 + 55.8294978122847*x_111 + 22.7750917107969*x_112 + 79.7317704358224*x_113 - 83.5773074798009*x_114 - 53.9278087635549*x_115 + 85.7730571055798*x_116 + 44.4962471802347*x_117 - 5.44491511837459*x_118 - 18.3383757580508*x_119 - 0.00161143826489329*x_12 - 86.7415470505154*x_120 + 179.420520275147*x_13 + 32.0438245898219*x_14 + 210.935399393529*x_18 - 0.923518367190027*x_19 - 35.0375309607426*x_2 + 2.46148412469509*x_20 - 2.66379067900637*x_21 - 0.0570079229250874*x_22 - 44.1437348648128*x_24 + 2.1023788902812*x_25 - 4.99991814070523*x_26 + 32.1725604927126*x_27 - 1.38258970874355*x_28 - 184.254852878375*x_29 - 15.8549910368442*x_3 - 0.209139859619841*x_30 - 13.144859481202*x_31 - 8.54747590870683*x_32 - 158.441505408566*x_33 + 439.84685982671*x_34 + 616.356928244203*x_35 - 308.825672828343*x_36 + 1016.50615479942*x_37 - 150.280828647502*x_38 + 770.36078064501*x_39 + 19.1055492294644*x_4 + 379.005240267856*x_40 - 0.305540300783105*x_42 + 90.8934882006079*x_43 - 37.6176281548191*x_44 + 97.3917354297698*x_45 + 1.91259154024361*x_46 - 623.070019096776*x_47 + 403.336209758358*x_48 + 5.95186725013086*x_5 - 1.85207966568925*x_52 - 41.9770570040862*x_53 + 7.25324035240757*x_54 - 87.2685161484001*x_56 - 198.633158555066*x_59 + 24.1547248715832*x_6 + 1.91146321583362*x_61 - 5.64890013339917*x_62 + 34.592457524552*x_63 + 9.38817587383054*x_64 - 19.4674962154317*x_65 + 15.8564490304363*x_66 + 27.1302126846302*x_67 + 11.9197575404759*x_68 + 25.786277871456*x_69 + 78.0071021131434*x_7 - 28.1618544246714*x_70 + 28.3695702041386*x_71 - 13.3213972126942*x_72 + 29.5365769049547*x_73 - 60.8550678448869*x_74 - 41.036359496831*x_75 - 47.0576442214408*x_76 - 41.2136177172545*x_77 - 18.4552733612241*x_78 - 178.674601054087*x_79 + 81.5881615638769*x_8 + 19.9359839798478*x_80 - 55.4566364301856*x_81 + 38.2306541458172*x_82 - 77.3569675551623*x_83 + 40.3347095825808*x_84 + 101.157644126298*x_85 + 175.139447568007*x_86 + 352.032655236401*x_87 - 21.5943142616861*x_88 + 22.5867841641416*x_89 - 41.8098494927584*x_9 + 17.2375934597663*x_90 - 0.849641136768165*x_91 - 45.0960632232153*x_92 + 9.42866320698917*x_93 + 39.5729793590918*x_94 + 38.7588993074917*x_95 + 29.6562255079796*x_96 - 10.5438635005016*x_97 - 38.4170682328074*x_98 + 14.8672546930888*x_99 - 0.000612358733475529*std::pow(-9.59200000762939*x_16 - 6.19047975540161, 2) - 0.0153432838020927*std::pow(-9.63535976409912*x_18 - 5.02335977554321, 2) + 0.254397370571173*std::pow(-7.45879983901978*x_28 - 6.84511995315552, 2) + 0.765828199800678*std::exp(0.779199838638306*x_1) - 0.651732884681593*std::exp(1.14455986022949*x_1) + 0.238791067849824*std::exp(1.20367991924286*x_1) - 1.99386783518653*std::exp(1.76095998287201*x_1) - 0.977056206802818*std::exp(0.533119857311249*x_10) + 0.01832697275575*std::exp(0.675439834594727*x_10) + 2.28971958160561*std::exp(0.918319821357727*x_10) - 0.0259985223406704*std::exp(0.870079874992371*x_11) - 0.479077478720845*std::exp(0.924879848957062*x_11) + 0.70823604956423*std::exp(0.94023984670639*x_11) + 0.106967973647412*std::exp(0.976159811019897*x_11) - 1.77863734004712*std::exp(0.993999779224396*x_11) - 0.307734951192938*std::exp(0.283759832382202*x_12) - 0.344650293126129*std::exp(0.713359832763672*x_12) + 0.00512686191823289*std::exp(1.27959990501404*x_12) - 2.61535384417111*std::exp(0.310159832239151*x_13) + 0.000996800306624853*std::exp(1.05879986286163*x_13) - 0.000232633479489015*std::exp(1.53175985813141*x_13) + 0.492011687284536*std::exp(0.278959840536118*x_15) + 0.593087865247639*std::exp(0.582399845123291*x_15) - 0.51805148155399*std::exp(0.681759834289551*x_15) + 0.179503285782208*std::exp(0.954799830913544*x_15) - 3.63315551617768*std::exp(1.00311982631683*x_15) - 1.26061132106846*std::exp(0.590239822864532*x_16) - 1.60278843582078*std::exp(0.650239825248718*x_16) + 31.8890977179845*std::exp(0.729439854621887*x_16) + 0.268607275355016*std::exp(0.863999843597412*x_16) - 1.67740108267475*std::exp(0.61847984790802*x_17) + 0.134016524755014*std::exp(0.625439822673798*x_17) - 51.2497735048473*std::exp(0.647039830684662*x_17) - 2.55414397963504*std::exp(0.67199981212616*x_17) + 0.0405729439308668*std::exp(1.05343985557556*x_17) - 75.3708581534201*std::exp(0.750399827957153*x_19) - 1.70135174490326*std::exp(0.754719853401184*x_19) + 2.11798792089319*std::exp(0.763839840888977*x_19) + 0.0763154190768035*std::exp(0.82999986410141*x_19) - 0.0715137870791855*std::exp(0.768799841403961*x_2) + 0.914752326604117*std::exp(0.44191986322403*x_20) + 0.163836263781468*std::exp(0.842719852924347*x_20) - 0.175542875605242*std::exp(0.891919851303101*x_20) - 0.0074185596759737*std::exp(0.933999836444855*x_20) + 7.70783312884095*std::exp(0.636719882488251*x_22) + 0.00311855731693502*std::exp(1.36591982841492*x_22) - 0.00100738335343248*std::exp(1.53999984264374*x_22) - 0.235473435911422*std::exp(0.463439851999283*x_23) + 69.8629383939065*std::exp(0.544079840183258*x_23) + 0.61589454784653*std::exp(0.579119861125946*x_23) + 0.698555287624898*std::exp(0.848079860210419*x_23) - 0.0396342768675399*std::exp(1.14591991901398*x_23) - 2.37554497937316*std::exp(0.482319831848145*x_24) + 0.16991889049654*std::exp(0.533679842948914*x_24) - 4.27885742117639*std::exp(0.572719871997833*x_24) + 1.01211496849174*std::exp(0.535999834537506*x_25) + 0.122630290599124*std::exp(0.614799857139587*x_25) - 0.208557603821276*std::exp(0.786159873008728*x_25) - 1.6397716265461*std::exp(1.07983982563019*x_25) + 2.57863018597741*std::exp(0.489839851856232*x_26) + 10.8745477227468*std::exp(0.850239872932434*x_26) - 0.0792186422220856*std::exp(0.868559896945953*x_26) + 0.000687003184543907*std::exp(1.1283198595047*x_26) - 0.0701589752467062*std::exp(0.954079806804657*x_27) - 0.082068362190521*std::exp(0.98039984703064*x_27) - 0.0509016259897459*std::exp(0.568239867687225*x_28) - 1.10013301500955*std::exp(0.650319814682007*x_28) - 0.076639762960577*std::exp(1.03335976600647*x_28) + 0.0263615344868224*std::exp(1.16567981243134*x_29) + 0.000659634441238092*std::exp(1.36007988452911*x_29) - 2.14238522629035*std::exp(0.599999845027924*x_3) - 1.95745615894884*std::exp(0.637119889259338*x_3) + 0.781264747102211*std::exp(0.828319907188416*x_30) + 0.288273758334492*std::exp(0.892719864845276*x_30) - 0.00490065408583291*std::exp(1.10247993469238*x_30) + 10.7217785435131*std::exp(0.882719874382019*x_32) - 6.27154327752338*std::exp(0.415839850902557*x_33) - 2.52904376255012*std::exp(0.467359870672226*x_33) + 1.42806097269546*std::exp(0.612639844417572*x_4) - 0.832396474706127*std::exp(0.691119849681854*x_4) - 0.0288578500952236*std::exp(1.22247993946075*x_4) + 16.6646176013224*std::exp(0.737679839134216*x_41) + 0.550988311584599*std::exp(0.798239827156067*x_41) - 0.0690759614405089*std::exp(0.799759864807129*x_41) + 0.0880947810899251*std::exp(0.821119904518127*x_41) + 0.392736734677594*std::exp(0.822159886360168*x_41) + 2.66548224661046*std::exp(0.807039856910706*x_42) - 0.0303690260428432*std::exp(0.848479866981506*x_43) - 0.0120800911826811*std::exp(0.914319813251495*x_44) - 0.00151202649351834*std::exp(0.967199802398682*x_44) + 0.594793720269583*std::exp(0.543519854545593*x_45) - 0.572358605308038*std::exp(0.547439873218536*x_45) + 0.586673313792335*std::exp(0.731919825077057*x_46) + 15.5723564369861*std::exp(0.767999827861786*x_46) + 0.119620752260547*std::exp(0.570559859275818*x_47) + 9.87904108408519*std::exp(0.685039818286896*x_49) + 0.148117761129312*std::exp(0.712159812450409*x_49) + 1.39487159239664*std::exp(0.735519826412201*x_49) + 0.809133178354941*std::exp(0.737599849700928*x_49) + 0.348486050965292*std::exp(0.799999833106995*x_49) + 0.198215456314795*std::exp(0.508159816265106*x_50) + 0.615139050780619*std::exp(0.55079984664917*x_50) + 1.27719404214153*std::exp(0.554719865322113*x_50) + 104.840343151454*std::exp(0.564399838447571*x_50) + 1.30017137212039*std::exp(0.585679829120636*x_50) - 11.8047405738377*std::exp(0.487999856472015*x_51) - 28.6734764285333*std::exp(0.494799852371216*x_51) + 1.5629176836824*std::exp(0.495199859142303*x_51) + 10.5120035160382*std::exp(0.502639830112457*x_51) + 211.470172052308*std::exp(0.503999829292297*x_51) + 0.979524194454982*std::exp(0.507519841194153*x_52) - 5.82449489847565*std::exp(0.658879816532135*x_52) - 0.00280116865151791*std::exp(0.705439865589142*x_52) + 0.147055778752499*std::exp(0.773359835147858*x_52) + 0.0418498908665182*std::exp(0.525039851665497*x_53) + 73.6140672078347*std::exp(0.453999847173691*x_54) - 5.2328095455981*std::exp(0.459519863128662*x_54) + 5.16991927756869*std::exp(0.508879840373993*x_54) + 0.237600338516062*std::exp(0.512559831142426*x_54) - 2.13637987985088*std::exp(0.651999831199646*x_55) - 599.521692244948*std::exp(0.652239859104156*x_55) - 14.9841966671063*std::exp(0.653599858283997*x_55) + 0.520692414995206*std::exp(0.711279809474945*x_55) + 3.76240797631454*std::exp(0.469519853591919*x_56) - 2.62865733495181*std::exp(0.561119854450226*x_56) + 0.280008418691436*std::exp(0.585519850254059*x_56) + 5.84844892091487*std::exp(0.610479831695557*x_57) + 268.887347620594*std::exp(0.631999850273132*x_57) + 5.04697790483196*std::exp(0.635999858379364*x_57) - 3.1533459409067*std::exp(0.638479828834534*x_57) - 0.0410824915281687*std::exp(0.672319829463959*x_57) + 0.281090790965265*std::exp(0.59175980091095*x_58) - 1.79333690081257*std::exp(0.593759834766388*x_58) + 124.369127208679*std::exp(0.61847984790802*x_58) - 2.03243800936892*std::exp(0.626239836215973*x_58) - 0.26785188418265*std::exp(0.706959843635559*x_58) - 0.0257755937732011*std::exp(0.621359825134277*x_59) - 0.0339427072135809*std::exp(0.799279868602753*x_60) + 0.322735786575931*std::exp(0.800079882144928*x_60) - 13.2376088443996*std::exp(0.807039856910706*x_60) - 0.77342119210372*std::exp(0.808319866657257*x_60) + 0.937921909547414*std::exp(0.832079887390137*x_60) + 0.568396465386183*std::exp(1.13375985622406*x_61) - 4.44977502119442*std::exp(1.2727198600769*x_61) - 0.246155249878213*std::exp(1.33911991119385*x_61) - 0.481113481933325*std::exp(0.915039837360382*x_66) - 1.08723179626671*std::exp(0.965039789676666*x_66) + 0.783336460262007*std::exp(1.11287987232208*x_66) + 6.03026528444078*std::exp(0.34607982635498*x_8) - 0.0667513502103504*std::exp(0.950719833374023*x_8) - 11.564242057438*std::log(8.08096027374268 - 1.18407988548279*x_5) + 11.5274175681301*std::log(9.57600021362305 - 1.22015988826752*x_21) + 9.20098808204027*std::sin(0.275039941072464*x_100 + 1.92927980422974) + 8.91879890475394*std::sin(0.226159989833832*x_101 + 1.98423981666565) + 16.7901748808984*std::sin(0.225599989295006*x_102 - 7.41752004623413) + 315.152187870529*std::sin(0.223199993371964*x_110 - 1.21599984169006) + 14.0473690333819*std::sin(0.268159955739975*x_120 + 1.97151982784271) - 3.01167591680873*std::sin(0.303919941186905*x_120 + 1.93567979335785) + 1940.37606155431*std::sin(0.152400031685829*x_30 + 1.75583982467651) + 11.5698019991168*std::sin(0.390159845352173*x_31 - 7.40823984146118) - 2.22082846626755*std::sin(0.44327986240387*x_31 - 7.37296009063721) - 17.0602883987711*std::sin(0.297759920358658*x_42 - 4.28904008865356) - 15.131692239643*std::sin(0.238159984350204*x_55 - 4.43512010574341) + 5.00865739962421*std::sin(0.299839943647385*x_91 - 1.14311993122101) - 48.2172508852312*std::sin(0.467279851436615*x_91 + 1.77087986469269) - 9.26327373003339*std::sin(0.308479934930801*x_92 + 8.217360496521) + 0.934692284909504*std::sin(0.270239949226379*x_95 + 1.96583986282349) + 11.4423624412116*std::sin(0.334639847278595*x_97 + 1.84383988380432) - 11.5911232579287*std::sin(0.268479973077774*x_98 + 1.9592798948288) - 2399.73283519888);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0237658363484194*x_10 - 116.001526579751*x_100 - 46.0464342742705*x_101 - 88.3020935159119*x_102 + 178.513821063234*x_103 - 676.293232608688*x_104 - 100.014963286322*x_105 - 158.15381956013*x_106 - 49.1108395302284*x_107 + 69.8589176794142*x_108 - 119.845533050889*x_109 + 2.2463793416959*x_110 - 106.987813512433*x_111 - 39.2996585601399*x_112 - 152.193648410959*x_113 + 156.425177013321*x_114 + 95.5666450568199*x_115 - 157.156522823614*x_116 - 86.4239342007256*x_117 + 8.15267946925223*x_118 + 34.4557516903677*x_119 + 3.74748357428969*x_12 + 161.342634923849*x_120 - 335.818760146719*x_13 - 64.6921107444456*x_14 - 379.847523640091*x_18 - 0.733621725494835*x_19 + 65.839350592789*x_2 - 4.62845432173863*x_20 + 6.08078294757197*x_21 + 0.322822724191881*x_22 + 83.7270351839652*x_24 - 2.25164189854924*x_25 + 5.35489831398685*x_26 - 72.1354443100744*x_27 + 0.516286354264398*x_28 + 344.558990064817*x_29 + 31.3507653751805*x_3 + 0.22398820343642*x_30 + 23.0670441027299*x_31 - 2.3352315430896*x_32 + 300.221216247175*x_33 - 933.399400323383*x_34 - 1157.33288505137*x_35 + 554.967623269372*x_36 - 2059.91619499086*x_37 + 325.399983750135*x_38 - 1482.8982082337*x_39 - 36.2016417662482*x_4 - 1494.03857644305*x_40 - 0.526013471756598*x_42 - 162.373835244466*x_43 + 65.5932757304218*x_44 - 176.96704774344*x_45 + 0.498243792027218*x_46 + 1194.69707786365*x_47 - 760.794246634336*x_48 - 11.4102226986767*x_5 + 1.98357213059689*x_52 + 86.8468928252261*x_53 - 2.70850346597114*x_54 + 159.738429211672*x_56 + 392.841116997652*x_59 - 43.5322756153152*x_6 - 2.04350213711598*x_61 + 9.3036168440751*x_62 - 61.0090184400957*x_63 - 17.5791368737768*x_64 + 32.216578275234*x_65 - 29.8300887301166*x_66 - 49.0495101661796*x_67 - 26.2262240022453*x_68 - 44.7228977395993*x_69 - 150.210451999732*x_7 + 54.3281660265363*x_70 - 53.2979464972088*x_71 + 23.091053696336*x_72 - 56.1409620438258*x_73 + 111.089899567922*x_74 + 77.6084741897283*x_75 + 83.3340954523038*x_76 + 76.5589945611452*x_77 + 35.8111233835284*x_78 + 341.975975225589*x_79 - 154.123825110629*x_8 - 36.8477958057068*x_80 + 102.514602207992*x_81 - 70.4869566039168*x_82 + 151.782719408879*x_83 - 66.8329979129628*x_84 - 191.435880591995*x_85 - 429.510212457103*x_86 - 679.239064823291*x_87 + 38.3129183201602*x_88 - 39.5985358927126*x_89 + 84.8822659103381*x_9 - 33.9864867752306*x_90 + 1.61938983605239*x_91 + 87.144457334349*x_92 - 24.2564070436377*x_93 - 75.8116366813179*x_94 - 74.2778994886628*x_95 - 54.1591212289471*x_96 + 21.4853111603419*x_97 + 76.0634558156231*x_98 - 45.5916568062522*x_99 + 0.0164326139450073*std::pow(-9.63535976409912*x_18 - 5.02335977554321, 2) - 0.478356369413897*std::pow(-7.45879983901978*x_28 - 6.84511995315552, 2) + 0.60835628757427*std::exp(0.779199838638306*x_1) + 0.698004092694804*std::exp(1.14455986022949*x_1) - 0.0891693096451045*std::exp(1.20367991924286*x_1) + 3.74917152873692*std::exp(1.76095998287201*x_1) + 0.364852120431338*std::exp(0.533119857311249*x_10) - 4.30547667836973*std::exp(0.918319821357727*x_10) + 0.17889700996237*std::exp(0.924879848957062*x_11) - 0.758518823906439*std::exp(0.94023984670639*x_11) + 0.0849728951668523*std::exp(0.976159811019897*x_11) + 3.34446263567374*std::exp(0.993999779224396*x_11) + 0.369119497887593*std::exp(0.713359832763672*x_12) + 0.00407266105412916*std::exp(1.27959990501404*x_12) + 0.976624874884658*std::exp(0.310159832239151*x_13) - 0.000184798679369938*std::exp(1.53175985813141*x_13) - 0.221470744191656*std::exp(0.582399845123291*x_15) - 0.41152816803111*std::exp(0.681759834289551*x_15) - 0.192247515927264*std::exp(0.954799830913544*x_15) + 6.8316078831035*std::exp(1.00311982631683*x_15) + 0.470737210745133*std::exp(0.590239822864532*x_16) + 1.71658192216798*std::exp(0.650239825248718*x_16) - 59.962699197759*std::exp(0.729439854621887*x_16) + 0.213375434455074*std::exp(0.863999843597412*x_16) + 0.626374754662619*std::exp(0.61847984790802*x_17) + 96.3675667402567*std::exp(0.647039830684662*x_17) + 2.73548104295527*std::exp(0.67199981212616*x_17) + 0.0322302124055569*std::exp(1.05343985557556*x_17) + 141.723674206739*std::exp(0.750399827957153*x_19) + 0.635318405845597*std::exp(0.754719853401184*x_19) - 2.26835912658276*std::exp(0.763839840888977*x_19) - 0.979697177753598*std::exp(0.44191986322403*x_20) + 0.130147755371341*std::exp(0.842719852924347*x_20) + 0.0655511831819442*std::exp(0.891919851303101*x_20) - 14.4934323152879*std::exp(0.636719882488251*x_22) - 0.00116453100839881*std::exp(1.36591982841492*x_22) - 0.000800242139448256*std::exp(1.53999984264374*x_22) - 131.366851361957*std::exp(0.544079840183258*x_23) - 0.229987210745242*std::exp(0.579119861125946*x_23) - 0.74815075500447*std::exp(0.848079860210419*x_23) - 0.0314845569046725*std::exp(1.14591991901398*x_23) + 0.887075499720183*std::exp(0.482319831848145*x_24) + 4.5826443044957*std::exp(0.572719871997833*x_24) - 0.377943755746523*std::exp(0.535999834537506*x_25) - 0.165673358122773*std::exp(0.786159873008728*x_25) + 3.08334634191144*std::exp(1.07983982563019*x_25) + 2.04840444289785*std::exp(0.489839851856232*x_26) - 20.4479675084377*std::exp(0.850239872932434*x_26) + 0.0295818084887847*std::exp(0.868559896945953*x_26) + 0.0261987495784021*std::exp(0.954079806804657*x_27) + 0.087894985869448*std::exp(0.98039984703064*x_27) - 0.873920334904476*std::exp(0.650319814682007*x_28) + 0.0820809713104741*std::exp(1.03335976600647*x_28) + 0.0209409959823083*std::exp(1.16567981243134*x_29) - 1.70186149211948*std::exp(0.599999845027924*x_3) + 0.730952861535831*std::exp(0.637119889259338*x_3) + 0.620618725300864*std::exp(0.828319907188416*x_30) - 0.107647125375947*std::exp(0.892719864845276*x_30) - 20.1607078179286*std::exp(0.882719874382019*x_32) - 4.98196956793771*std::exp(0.415839850902557*x_33) + 0.94439498260746*std::exp(0.467359870672226*x_33) - 1.52944929891966*std::exp(0.612639844417572*x_4) + 0.310833314113926*std::exp(0.691119849681854*x_4) - 0.0229240116201967*std::exp(1.22247993946075*x_4) - 31.3353316331126*std::exp(0.737679839134216*x_41) - 0.205749937838626*std::exp(0.798239827156067*x_41) + 0.0699804655828599*std::exp(0.821119904518127*x_41) - 0.420619942003514*std::exp(0.822159886360168*x_41) - 5.01204240972709*std::exp(0.807039856910706*x_42) + 0.0113403952300996*std::exp(0.848479866981506*x_43) + 0.00451094507390463*std::exp(0.914319813251495*x_44) - 0.222107744210254*std::exp(0.543519854545593*x_45) - 0.454668496638033*std::exp(0.547439873218536*x_45) - 0.628325474633578*std::exp(0.731919825077057*x_46) - 29.2814971777854*std::exp(0.767999827861786*x_46) - 18.5760655295437*std::exp(0.685039818286896*x_49) - 1.49390356564905*std::exp(0.735519826412201*x_49) + 0.642756765375443*std::exp(0.737599849700928*x_49) - 0.130131586852597*std::exp(0.799999833106995*x_49) - 0.229705093191965*std::exp(0.55079984664917*x_50) - 1.36787123917454*std::exp(0.554719865322113*x_50) - 197.136652023712*std::exp(0.564399838447571*x_50) + 1.03282619960896*std::exp(0.585679829120636*x_50) + 12.642844066039*std::exp(0.487999856472015*x_51) + 10.7072434546231*std::exp(0.494799852371216*x_51) + 8.35049353843217*std::exp(0.502639830112457*x_51) - 397.638165501295*std::exp(0.503999829292297*x_51) - 0.365773715854222*std::exp(0.507519841194153*x_52) + 10.9520952478756*std::exp(0.658879816532135*x_52) + 0.116817724460261*std::exp(0.773359835147858*x_52) - 138.420290462392*std::exp(0.453999847173691*x_54) + 5.6043243558354*std::exp(0.459519863128662*x_54) + 4.10686482892499*std::exp(0.508879840373993*x_54) + 1127.31125893039*std::exp(0.652239859104156*x_55) + 16.0480326299537*std::exp(0.653599858283997*x_55) + 0.413626064745343*std::exp(0.711279809474945*x_55) - 4.02952839665004*std::exp(0.469519853591919*x_56) - 2.08814485809268*std::exp(0.561119854450226*x_56) - 6.26367240117013*std::exp(0.610479831695557*x_57) - 505.602613345937*std::exp(0.631999850273132*x_57) + 4.00920303333314*std::exp(0.635999858379364*x_57) + 1.17752176894522*std::exp(0.638479828834534*x_57) + 0.669667483153584*std::exp(0.593759834766388*x_58) - 233.857622133223*std::exp(0.61847984790802*x_58) + 2.17673541113562*std::exp(0.626239836215973*x_58) - 0.212775369101766*std::exp(0.706959843635559*x_58) - 0.120515928614399*std::exp(0.800079882144928*x_60) + 24.8913520305302*std::exp(0.807039856910706*x_60) - 0.614387985819727*std::exp(0.808319866657257*x_60) - 1.00451173614181*std::exp(0.832079887390137*x_60) - 0.212250486919714*std::exp(1.13375985622406*x_61) + 8.36713924781585*std::exp(1.2727198600769*x_61) - 0.195540062407994*std::exp(1.33911991119385*x_61) - 0.382185471685511*std::exp(0.915039837360382*x_66) + 1.16442220630443*std::exp(0.965039789676666*x_66) - 0.292513333980027*std::exp(1.11287987232208*x_66) - 6.45839721687737*std::exp(0.34607982635498*x_8) - 0.053025735556758*std::exp(0.950719833374023*x_8) - 88.2319694454765*std::exp(0.00402373318210461*x_1 - 0.00672232779727884*x_100 + 0.00121738251129629*x_101 + 0.00820787417705404*x_102 - 0.0069053412890596*x_103 - 0.0962306610792203*x_104 - 0.00591483248127971*x_105 + 0.00677208051683372*x_106 + 0.000169080662255795*x_107 - 0.00568862876926882*x_108 - 0.0059359328061071*x_109 + 0.0029132470392008*x_110 + 0.00725680801406065*x_111 + 0.00610445232143174*x_112 + 0.00726082477334427*x_113 + 0.0027381222914661*x_114 + 0.00670548522660167*x_115 + 0.00107288570455919*x_116 - 0.00220279527506841*x_117 - 0.00266776220629731*x_118 + 0.00178455126426275*x_119 + 0.00606379396969995*x_120 - 0.0108793760084372*x_14 - 0.0240056570880872*x_18 + 0.00153859867318029*x_21 + 0.0109268014079362*x_22 - 0.0155629576828539*x_27 + 0.00132615049153853*x_3 + 0.00190379522023722*x_31 - 0.00207418229979572*x_32 + 0.0083153566513553*x_33 + 0.0447859017271443*x_34 + 0.0391946386085004*x_35 + 0.0478329301446495*x_36 - 0.0216421531931424*x_37 - 0.103073537514649*x_38 + 0.0258724446806389*x_39 - 0.00657392465353708*x_4 - 0.367975057234009*x_40 + 0.00158177419713961*x_42 + 0.00579910637671907*x_43 + 0.0120551302745912*x_45 - 0.0234344659272464*x_46 + 0.0250696791774038*x_48 + 0.0072492102388331*x_5 + 0.0012060010180836*x_6 + 0.000153178323853274*x_61 - 0.00144666905653802*x_62 + 0.0052197851428717*x_63 - 0.00470020797835833*x_64 - 0.00356671283208695*x_65 - 0.000342311247891602*x_66 - 0.00111370793913857*x_67 - 0.0056570621639764*x_68 - 0.000672369723564567*x_69 + 0.0102601349443383*x_7 + 0.00537308761881717*x_70 - 0.00257157646845831*x_71 - 0.00641862704105578*x_72 - 0.0058244899498407*x_73 + 0.00372360004320206*x_74 - 0.00117469488130578*x_75 + 0.0019314059747921*x_76 + 0.00284782231162227*x_77 + 0.00221134269572813*x_78 - 0.00719989554250295*x_79 - 0.000618426594765406*x_8 - 0.00335501752882857*x_80 - 0.00479589739608099*x_81 + 0.00195941468638464*x_82 - 0.00195670597657244*x_83 - 0.00245635432565887*x_84 + 0.00371611342550299*x_85 - 0.0315317453800767*x_86 + 0.00708207385930279*x_87 + 0.0166826994063374*x_88 + 0.000723836050296972*x_89 - 0.00293112395707432*x_9 - 0.00328890630567346*x_90 - 0.00200211088932607*x_91 - 0.00049310187938762*x_92 + 0.00913590274403031*x_93 - 0.00157851590200295*x_94 - 0.00261907857195834*x_96 + 0.00501723943280031*x_97 - 0.000158603312630368*x_98 + 0.0106862571539845*x_99 - 2.73761103843214e-5*std::pow(-9.59200000762939*x_16 - 6.19047975540161, 2) + 0.000819325669325027*std::exp(0.675439834594727*x_10) - 0.0011622899756616*std::exp(0.870079874992371*x_11) - 0.0137575991529617*std::exp(0.283759832382202*x_12) + 4.45629558843843e-5*std::exp(1.05879986286163*x_13) + 0.0219958751711279*std::exp(0.278959840536118*x_15) + 0.00599134294075194*std::exp(0.625439822673798*x_17) + 0.00341175723062634*std::exp(0.82999986410141*x_19) - 0.00319709546391058*std::exp(0.768799841403961*x_2) - 0.000331654139117864*std::exp(0.933999836444855*x_20) - 0.0105270757510053*std::exp(0.463439851999283*x_23) + 0.00759639415316774*std::exp(0.533679842948914*x_24) + 0.00548230994085623*std::exp(0.614799857139587*x_25) + 3.07131653168558e-5*std::exp(1.1283198595047*x_26) - 0.00227560816178416*std::exp(0.568239867687225*x_28) + 2.94896182408344e-5*std::exp(1.36007988452911*x_29) - 0.000219088648328225*std::exp(1.10247993469238*x_30) - 0.00308811002754168*std::exp(0.799759864807129*x_41) - 6.75966585070851e-5*std::exp(0.967199802398682*x_44) + 0.00534776551573614*std::exp(0.570559859275818*x_47) + 0.00662175283357273*std::exp(0.712159812450409*x_49) + 0.00886142046371143*std::exp(0.508159816265106*x_50) + 0.0698718001248318*std::exp(0.495199859142303*x_51) - 0.000125229049602703*std::exp(0.705439865589142*x_52) + 0.00187094127886622*std::exp(0.525039851665497*x_53) + 0.0106221610617852*std::exp(0.512559831142426*x_54) - 0.0955090018585949*std::exp(0.651999831199646*x_55) + 0.0125180567526639*std::exp(0.585519850254059*x_56) - 0.00183663392298632*std::exp(0.672319829463959*x_57) + 0.0125664452890322*std::exp(0.59175980091095*x_58) - 0.00115232373081649*std::exp(0.621359825134277*x_59) - 0.00151744271555952*std::exp(0.799279868602753*x_60) + 0.0417863545798172*std::sin(0.270239949226379*x_95 + 1.96583986282349)) - 9.18636760634342*std::log(8.08096027374268 - 1.18407988548279*x_5) + 9.15711507997649*std::log(9.57600021362305 - 1.22015988826752*x_21) - 3.43583100790162*std::sin(0.275039941072464*x_100 + 1.92927980422974) - 9.5520086277089*std::sin(0.226159989833832*x_101 + 1.98423981666565) + 13.3377283063285*std::sin(0.225599989295006*x_102 - 7.41752004623413) - 592.596755477927*std::sin(0.223199993371964*x_110 - 1.21599984169006) - 15.044692860151*std::sin(0.268159955739975*x_120 + 1.97151982784271) - 2.39240599994027*std::sin(0.303919941186905*x_120 + 1.93567979335785) - 3648.58821464539*std::sin(0.152400031685829*x_30 + 1.75583982467651) - 12.3912255110428*std::sin(0.390159845352173*x_31 - 7.40823984146118) - 1.76417499568366*std::sin(0.44327986240387*x_31 - 7.37296009063721) + 18.2715210553074*std::sin(0.297759920358658*x_42 - 4.28904008865356) + 5.65047328997966*std::sin(0.238159984350204*x_55 - 4.43512010574341) + 3.97876210638344*std::sin(0.299839943647385*x_91 - 1.14311993122101) + 90.6653595703156*std::sin(0.467279851436615*x_91 + 1.77087986469269) + 9.92094020002454*std::sin(0.308479934930801*x_92 + 8.217360496521) + 9.08954924567482*std::sin(0.334639847278595*x_97 + 1.84383988380432) + 4.32835477569383*std::sin(0.268479973077774*x_98 + 1.9592798948288) + 4653.26612374454);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0667138675732616*x_1 - 0.0487087733681262*x_10 - 43.8642995650629*x_100 - 17.6214816058891*x_101 - 33.6367072176032*x_102 + 68.1659588165924*x_103 - 255.928447968016*x_104 - 37.5335715070714*x_105 - 60.6454302135967*x_106 - 18.6032246506794*x_107 + 26.6540040768442*x_108 - 45.9434212090444*x_109 + 0.517695638869733*x_110 - 40.2731064258451*x_111 - 15.0734636778633*x_112 - 57.8294746903729*x_113 + 59.2933818938372*x_114 + 36.8043809720738*x_115 - 59.9721426560646*x_116 - 32.4046386246287*x_117 + 3.48741493573403*x_118 + 12.8271577425227*x_119 + 1.18378858938837*x_12 + 61.3259868941652*x_120 - 127.50407085066*x_13 - 24.336935669911*x_14 - 145.021023037431*x_18 - 0.126035031751753*x_19 + 25.0339628639015*x_2 - 1.75844174066465*x_20 + 2.26191161284237*x_21 - 0.0710961150540537*x_22 + 31.7649788339593*x_24 - 0.767731154867927*x_25 + 1.82583308182632*x_26 - 26.4686526761284*x_27 + 0.329661773458954*x_28 + 130.829375496977*x_29 + 11.9651868130886*x_3 + 0.0763721452384736*x_30 + 8.84292510598364*x_31 + 0.10504463614086*x_32 + 114.022437225327*x_33 - 350.150832969054*x_34 - 439.217793178277*x_35 + 210.956938434223*x_36 - 775.069559185644*x_37 + 117.554047751138*x_38 - 561.360730617539*x_39 - 13.6447265718456*x_4 - 498.584332325803*x_40 - 0.154679868496227*x_42 - 62.1728194890153*x_43 + 25.0429747353715*x_44 - 67.1415879187163*x_45 + 0.259609926894471*x_46 + 451.522838509786*x_47 - 289.188885910673*x_48 - 4.555692825889*x_5 + 0.676328737517353*x_52 + 32.6155742846838*x_53 - 1.72944732828345*x_54 + 60.9670121907221*x_56 + 148.551216027733*x_59 - 16.3722788563094*x_6 - 0.699302484933194*x_61 + 3.60807850741863*x_62 - 23.4528428267887*x_63 - 6.52938655767385*x_64 + 12.6628146689279*x_65 - 11.3273677285609*x_66 - 18.6959581363014*x_67 - 9.82163702519501*x_68 - 17.1218298513837*x_69 - 57.1009063865269*x_7 + 20.5480191682543*x_70 - 20.086837556296*x_71 + 8.98744567767954*x_72 - 20.962251629068*x_73 + 42.2114464896174*x_74 + 29.3801528913259*x_75 + 31.9518100693005*x_76 + 29.0479869438554*x_77 + 13.6506111597914*x_78 + 129.590668739784*x_79 - 58.5006533989893*x_8 - 14.0165145059401*x_80 + 39.1354715740872*x_81 - 27.0483463619848*x_82 + 57.307714461753*x_83 - 25.9293440296691*x_84 - 72.5476330562902*x_85 - 157.122575261227*x_86 - 256.752414026925*x_87 + 13.665859011229*x_88 - 15.0885542640125*x_89 + 31.9417458406504*x_9 - 12.9319721083978*x_90 + 0.464708337057028*x_91 + 32.9651039470051*x_92 - 8.96123395843407*x_93 - 28.585936816424*x_94 - 28.0393609066052*x_95 - 20.5258062174199*x_96 + 7.94502968840829*x_97 + 28.9708535487161*x_98 - 16.6670608396053*x_99 + 0.000453898437146206*std::pow(-9.59200000762939*x_16 - 6.19047975540161, 2) + 0.00560294676059625*std::pow(-9.63535976409912*x_18 - 5.02335977554321, 2) - 0.181737087247352*std::pow(-7.45879983901978*x_28 - 6.84511995315552, 2) + 0.104514631118761*std::exp(0.779199838638306*x_1) + 0.237994988693537*std::exp(1.14455986022949*x_1) - 0.0569368384674792*std::exp(1.20367991924286*x_1) + 1.42438474072831*std::exp(1.76095998287201*x_1) + 0.232967220764581*std::exp(0.533119857311249*x_10) - 0.0135844952259319*std::exp(0.675439834594727*x_10) - 1.63573611802646*std::exp(0.918319821357727*x_10) + 0.0192708750825917*std::exp(0.870079874992371*x_11) + 0.114230223370376*std::exp(0.924879848957062*x_11) - 0.258628396034893*std::exp(0.94023984670639*x_11) + 0.0145982066345825*std::exp(0.976159811019897*x_11) + 1.2706277927472*std::exp(0.993999779224396*x_11) + 0.228102263862495*std::exp(0.283759832382202*x_12) + 0.125856841880629*std::exp(0.713359832763672*x_12) + 0.000699676614572818*std::exp(1.27959990501404*x_12) + 0.62359945328659*std::exp(0.310159832239151*x_13) - 0.000738857921983014*std::exp(1.05879986286163*x_13) - 3.17481157014019e-5*std::exp(1.53175985813141*x_13) - 0.364693640684465*std::exp(0.278959840536118*x_15) - 0.141414619418947*std::exp(0.582399845123291*x_15) - 0.0706998769557388*std::exp(0.681759834289551*x_15) - 0.0655496806656625*std::exp(0.954799830913544*x_15) + 2.595463544078*std::exp(1.00311982631683*x_15) + 0.300577504025779*std::exp(0.590239822864532*x_16) + 0.585294412215615*std::exp(0.650239825248718*x_16) - 22.7810205789501*std::exp(0.729439854621887*x_16) + 0.0366575562336978*std::exp(0.863999843597412*x_16) + 0.399955975528744*std::exp(0.61847984790802*x_17) - 0.099337018993455*std::exp(0.625439822673798*x_17) + 36.6119529378221*std::exp(0.647039830684662*x_17) + 0.932703384841302*std::exp(0.67199981212616*x_17) + 0.00553709862008265*std::exp(1.05343985557556*x_17) + 53.8436391594059*std::exp(0.750399827957153*x_19) + 0.405666720904495*std::exp(0.754719853401184*x_19) - 0.773431145080686*std::exp(0.763839840888977*x_19) - 0.0565672498088134*std::exp(0.82999986410141*x_19) + 0.053008137902137*std::exp(0.768799841403961*x_2) - 0.33404248081466*std::exp(0.44191986322403*x_20) + 0.0223591749134504*std::exp(0.842719852924347*x_20) + 0.0418560729362718*std::exp(0.891919851303101*x_20) + 0.0054988562401795*std::exp(0.933999836444855*x_20) - 5.50634284733024*std::exp(0.636719882488251*x_22) - 0.000743582227780699*std::exp(1.36591982841492*x_22) - 0.000137480311650288*std::exp(1.53999984264374*x_22) + 0.174539887661965*std::exp(0.463439851999283*x_23) - 49.9088764233026*std::exp(0.544079840183258*x_23) - 0.146852596705136*std::exp(0.579119861125946*x_23) - 0.25509324707671*std::exp(0.848079860210419*x_23) - 0.00540899620508608*std::exp(1.14591991901398*x_23) + 0.566419933461931*std::exp(0.482319831848145*x_24) - 0.125948916250868*std::exp(0.533679842948914*x_24) + 1.56252146778147*std::exp(0.572719871997833*x_24) - 0.241326557942165*std::exp(0.535999834537506*x_25) - 0.0908972048684786*std::exp(0.614799857139587*x_25) - 0.0284624162913647*std::exp(0.786159873008728*x_25) + 1.17142452569481*std::exp(1.07983982563019*x_25) + 0.351912586594846*std::exp(0.489839851856232*x_26) - 7.76858905352333*std::exp(0.850239872932434*x_26) + 0.018888725932783*std::exp(0.868559896945953*x_26) - 0.000509227115957197*std::exp(1.1283198595047*x_26) + 0.016728558051333*std::exp(0.954079806804657*x_27) + 0.0299691167819045*std::exp(0.98039984703064*x_27) + 0.0377297933742454*std::exp(0.568239867687225*x_28) - 0.150138107052234*std::exp(0.650319814682007*x_28) + 0.027986741114328*std::exp(1.03335976600647*x_28) + 0.00359762940739428*std::exp(1.16567981243134*x_29) - 0.000488940592496254*std::exp(1.36007988452911*x_29) - 0.292377065376146*std::exp(0.599999845027924*x_3) + 0.466731717114871*std::exp(0.637119889259338*x_3) + 0.106621298185065*std::exp(0.828319907188416*x_30) - 0.068735386798582*std::exp(0.892719864845276*x_30) + 0.00363251001243802*std::exp(1.10247993469238*x_30) - 7.65945339071056*std::exp(0.882719874382019*x_32) - 0.85589435380716*std::exp(0.415839850902557*x_33) + 0.603019859503542*std::exp(0.467359870672226*x_33) - 0.52148873110244*std::exp(0.612639844417572*x_4) + 0.198474859415797*std::exp(0.691119849681854*x_4) - 0.00393830830252502*std::exp(1.22247993946075*x_4) - 11.9049149610137*std::exp(0.737679839134216*x_41) - 0.131376490656221*std::exp(0.798239827156067*x_41) + 0.0512011493071512*std::exp(0.799759864807129*x_41) + 0.0120225313608168*std::exp(0.821119904518127*x_41) - 0.143416692522422*std::exp(0.822159886360168*x_41) - 1.90417447523494*std::exp(0.807039856910706*x_42) + 0.00724112650354022*std::exp(0.848479866981506*x_43) + 0.00288035145759009*std::exp(0.914319813251495*x_44) + 0.00112075883761207*std::exp(0.967199802398682*x_44) - 0.141821359891729*std::exp(0.543519854545593*x_45) - 0.0781113159805129*std::exp(0.547439873218536*x_45) - 0.214237016367559*std::exp(0.731919825077057*x_46) - 11.1246224521949*std::exp(0.767999827861786*x_46) - 0.0886664458807548*std::exp(0.570559859275818*x_47) - 7.05741630657408*std::exp(0.685039818286896*x_49) - 0.109789273206922*std::exp(0.712159812450409*x_49) - 0.509368878974954*std::exp(0.735519826412201*x_49) + 0.110424577840993*std::exp(0.737599849700928*x_49) - 0.0830922788303748*std::exp(0.799999833106995*x_49) - 0.146923169248966*std::exp(0.508159816265106*x_50) - 0.146672457578527*std::exp(0.55079984664917*x_50) - 0.466396262584525*std::exp(0.554719865322113*x_50) - 74.8961302059823*std::exp(0.564399838447571*x_50) + 0.177437878865917*std::exp(0.585679829120636*x_50) + 4.31076774769963*std::exp(0.487999856472015*x_51) + 6.83684323041431*std::exp(0.494799852371216*x_51) - 1.15848089564311*std::exp(0.495199859142303*x_51) + 1.43460135064732*std::exp(0.502639830112457*x_51) - 151.070638120966*std::exp(0.503999829292297*x_51) - 0.233555682533927*std::exp(0.507519841194153*x_52) + 4.16091854707233*std::exp(0.658879816532135*x_52) + 0.00207630920178219*std::exp(0.705439865589142*x_52) + 0.0200690970562324*std::exp(0.773359835147858*x_52) - 0.0310203791023599*std::exp(0.525039851665497*x_53) - 52.5886180535023*std::exp(0.453999847173691*x_54) + 1.9108786404855*std::exp(0.459519863128662*x_54) + 0.705552768035305*std::exp(0.508879840373993*x_54) - 0.176116410891623*std::exp(0.512559831142426*x_54) + 1.58354806685168*std::exp(0.651999831199646*x_55) + 428.287941206208*std::exp(0.652239859104156*x_55) + 5.47181797971107*std::exp(0.653599858283997*x_55) + 0.0710602922348964*std::exp(0.711279809474945*x_55) - 1.37392828385654*std::exp(0.469519853591919*x_56) - 0.358739925967232*std::exp(0.561119854450226*x_56) - 0.207550536448587*std::exp(0.585519850254059*x_56) - 2.13569326870453*std::exp(0.610479831695557*x_57) - 192.088476561362*std::exp(0.631999850273132*x_57) + 0.688774628729181*std::exp(0.635999858379364*x_57) + 0.751877153890863*std::exp(0.638479828834534*x_57) + 0.0304515599751027*std::exp(0.672319829463959*x_57) - 0.208352822848117*std::exp(0.59175980091095*x_58) + 0.427599467428783*std::exp(0.593759834766388*x_58) - 88.8471562094123*std::exp(0.61847984790802*x_58) + 0.742190661894238*std::exp(0.626239836215973*x_58) - 0.0365544659717426*std::exp(0.706959843635559*x_58) + 0.0191056338231175*std::exp(0.621359825134277*x_59) + 0.0251593402927621*std::exp(0.799279868602753*x_60) - 0.0769524401118095*std::exp(0.800079882144928*x_60) + 9.45671910090719*std::exp(0.807039856910706*x_60) - 0.105550867169936*std::exp(0.808319866657257*x_60) - 0.342503377541265*std::exp(0.832079887390137*x_60) - 0.135527254124648*std::exp(1.13375985622406*x_61) + 3.17884241272711*std::exp(1.2727198600769*x_61) - 0.0335934680201954*std::exp(1.33911991119385*x_61) - 0.0656588489475987*std::exp(0.915039837360382*x_66) + 0.397027256321686*std::exp(0.965039789676666*x_66) - 0.18677709306813*std::exp(1.11287987232208*x_66) - 2.20208762197211*std::exp(0.34607982635498*x_8) - 0.00910973602921619*std::exp(0.950719833374023*x_8) - 1.57820317026165*std::log(8.08096027374268 - 1.18407988548279*x_5) + 1.57317763331072*std::log(9.57600021362305 - 1.22015988826752*x_21) - 2.19386418799297*std::sin(0.275039941072464*x_100 + 1.92927980422974) - 3.25690093961404*std::sin(0.226159989833832*x_101 + 1.98423981666565) + 2.29140025733358*std::sin(0.225599989295006*x_102 - 7.41752004623413) - 225.139279288252*std::sin(0.223199993371964*x_110 - 1.21599984169006) - 5.12971420171164*std::sin(0.268159955739975*x_120 + 1.97151982784271) - 0.411011500459821*std::sin(0.303919941186905*x_120 + 1.93567979335785) - 1386.17114162629*std::sin(0.152400031685829*x_30 + 1.75583982467651) - 4.22497461872212*std::sin(0.390159845352173*x_31 - 7.40823984146118) - 0.303082425001335*std::sin(0.44327986240387*x_31 - 7.37296009063721) + 6.229949784654*std::sin(0.297759920358658*x_42 - 4.28904008865356) + 3.60796877599288*std::sin(0.238159984350204*x_55 - 4.43512010574341) + 0.683544926470745*std::sin(0.299839943647385*x_91 - 1.14311993122101) + 34.4455711601199*std::sin(0.467279851436615*x_91 + 1.77087986469269) + 3.38269370544577*std::sin(0.308479934930801*x_92 + 8.217360496521) - 0.692821616056847*std::sin(0.270239949226379*x_95 + 1.96583986282349) + 1.56156993171791*std::sin(0.334639847278595*x_97 + 1.84383988380432) + 2.7637629771327*std::sin(0.268479973077774*x_98 + 1.9592798948288) + 1619.05244745265);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0026583116964372*x_1 - 0.285600768826619*x_10 - 61.4509262063853*x_100 - 24.7061261758414*x_101 - 47.6042833715686*x_102 + 96.6637495934327*x_103 - 354.51260592817*x_104 - 51.2312079189501*x_105 - 91.7354937074879*x_106 - 25.3134565833092*x_107 + 37.4103842783557*x_108 - 66.3267162390022*x_109 - 1.34249708914482*x_110 - 54.4567498272841*x_111 - 20.0385957445818*x_112 - 81.3878668148548*x_113 + 84.1085508000298*x_114 + 54.8035375805289*x_115 - 85.1891578215176*x_116 - 43.4783957659804*x_117 + 7.34284519476388*x_118 + 16.4676278482251*x_119 + 2.26267698245516*x_12 + 86.1101613575201*x_120 - 178.737583637253*x_13 - 33.4301708537948*x_14 - 208.162649893026*x_18 + 0.516188059770519*x_19 + 35.6721725019902*x_2 - 2.47414618539912*x_20 + 3.47621974595769*x_21 + 0.0582195527315552*x_22 + 44.4911460535717*x_24 - 0.355722335056528*x_25 + 0.845985737549559*x_26 - 34.5308310665843*x_27 + 0.131617134629804*x_28 + 183.319716947752*x_29 + 17.4979708241311*x_3 + 0.0353864470202199*x_30 + 12.2119045838086*x_31 + 3.67278904105457*x_32 + 161.458733153256*x_33 - 484.068846776605*x_34 - 606.288167842122*x_35 + 301.471759208947*x_36 - 1057.89096459129*x_37 + 117.371695147156*x_38 - 778.576653740108*x_39 - 19.3559770862071*x_4 - 424.175338300231*x_40 + 0.292937633988997*x_42 - 88.8880256372119*x_43 + 35.4638340351387*x_44 - 91.7713183668038*x_45 - 0.806655089687752*x_46 + 628.50814289736*x_47 - 403.711265343692*x_48 - 6.62829432383417*x_5 + 0.313371726873445*x_52 + 45.2215181266289*x_53 - 0.690480122865017*x_54 + 85.0864821412982*x_56 + 207.844940625297*x_59 - 21.5459151054804*x_6 - 0.322738482354422*x_61 + 5.87282525164095*x_62 - 33.3234451828062*x_63 - 9.57683706132219*x_64 + 18.509847207213*x_65 - 15.9459382850951*x_66 - 26.3852047002464*x_67 - 14.6907090227106*x_68 - 24.4873248522419*x_69 - 78.5368535771419*x_7 + 28.3490634954119*x_70 - 28.4086756733898*x_71 + 12.8319284652198*x_72 - 28.3833454170998*x_73 + 59.3508772532872*x_74 + 41.7601821634963*x_75 + 46.3767049966975*x_76 + 40.5561288016717*x_77 + 19.3331307118643*x_78 + 181.486112542656*x_79 - 82.4348515934237*x_8 - 20.3398890781891*x_80 + 54.9404200415248*x_81 - 39.0788926915505*x_82 + 81.0443897048827*x_83 - 38.45351139354*x_84 - 101.88938366609*x_85 - 206.649679844834*x_86 - 352.704588476441*x_87 + 15.2821343813734*x_88 - 21.650097297854*x_89 + 43.0235126200962*x_9 - 18.9967148428374*x_90 + 0.215208224227269*x_91 + 46.5902493330369*x_92 - 11.7953275209137*x_93 - 38.5431403008823*x_94 - 39.1666847025207*x_95 - 28.5999591514588*x_96 + 11.4340112795443*x_97 + 41.596531384429*x_98 - 21.8309194848356*x_99 - 1.80862475576805e-5*std::pow(-9.59200000762939*x_16 - 6.19047975540161, 2) + 0.00259608235544327*std::pow(-9.63535976409912*x_18 - 5.02335977554321, 2) - 0.255706009906605*std::pow(-7.45879983901978*x_28 - 6.84511995315552, 2) - 0.428049280465821*std::exp(0.779199838638306*x_1) + 0.110273150402997*std::exp(1.14455986022949*x_1) - 0.0227319760351367*std::exp(1.20367991924286*x_1) + 2.00412444229265*std::exp(1.76095998287201*x_1) + 0.0930119307979785*std::exp(0.533119857311249*x_10) + 0.000541294094659315*std::exp(0.675439834594727*x_10) - 2.30149807249516*std::exp(0.918319821357727*x_10) - 0.000767876222681559*std::exp(0.870079874992371*x_11) + 0.0456063028794064*std::exp(0.924879848957062*x_11) - 0.119833481246809*std::exp(0.94023984670639*x_11) - 0.0597882973812912*std::exp(0.976159811019897*x_11) + 1.78778678519047*std::exp(0.993999779224396*x_11) - 0.00908906855600293*std::exp(0.283759832382202*x_12) + 0.0583148012070962*std::exp(0.713359832763672*x_12) - 0.002865589900866*std::exp(1.27959990501404*x_12) + 0.248971460467231*std::exp(0.310159832239151*x_13) + 2.94408753001143e-5*std::exp(1.05879986286163*x_13) + 0.000130027326668632*std::exp(1.53175985813141*x_13) + 0.0145317518817682*std::exp(0.278959840536118*x_15) - 0.0564596459194972*std::exp(0.582399845123291*x_15) + 0.289557845977928*std::exp(0.681759834289551*x_15) - 0.0303719411681431*std::exp(0.954799830913544*x_15) + 3.65184474323037*std::exp(1.00311982631683*x_15) + 0.120005269033648*std::exp(0.590239822864532*x_16) + 0.271191671314542*std::exp(0.650239825248718*x_16) - 32.0531376510683*std::exp(0.729439854621887*x_16) - 0.150134391725878*std::exp(0.863999843597412*x_16) + 0.159682024775965*std::exp(0.61847984790802*x_17) + 0.00395822891229503*std::exp(0.625439822673798*x_17) + 51.5134062200356*std::exp(0.647039830684662*x_17) + 0.432160950961997*std::exp(0.67199981212616*x_17) - 0.0226776964605218*std::exp(1.05343985557556*x_17) + 75.7585715543227*std::exp(0.750399827957153*x_19) + 0.161962034177936*std::exp(0.754719853401184*x_19) - 0.358363381750316*std::exp(0.763839840888977*x_19) + 0.00225400486093722*std::exp(0.82999986410141*x_19) - 0.00211218683786943*std::exp(0.768799841403961*x_2) - 0.154776018310613*std::exp(0.44191986322403*x_20) - 0.091574056484364*std::exp(0.842719852924347*x_20) + 0.0167109954209298*std::exp(0.891919851303101*x_20) - 0.000219109975062434*std::exp(0.933999836444855*x_20) - 7.74748280603966*std::exp(0.636719882488251*x_22) - 0.000296874463651841*std::exp(1.36591982841492*x_22) + 0.000563063255834989*std::exp(1.53999984264374*x_22) - 0.00695479728194616*std::exp(0.463439851999283*x_23) - 70.2223186385445*std::exp(0.544079840183258*x_23) - 0.0586307529334539*std::exp(0.579119861125946*x_23) - 0.118195497124107*std::exp(0.848079860210419*x_23) + 0.022153041242604*std::exp(1.14591991901398*x_23) + 0.22614259414201*std::exp(0.482319831848145*x_24) + 0.00501861890791445*std::exp(0.533679842948914*x_24) + 0.723982323201143*std::exp(0.572719871997833*x_24) - 0.0963493878381865*std::exp(0.535999834537506*x_25) + 0.00362193216590204*std::exp(0.614799857139587*x_25) + 0.116570442658821*std::exp(0.786159873008728*x_25) + 1.64820673594525*std::exp(1.07983982563019*x_25) - 1.44129035204287*std::exp(0.489839851856232*x_26) - 10.9304872195783*std::exp(0.850239872932434*x_26) + 0.00754130501087687*std::exp(0.868559896945953*x_26) + 2.02908997444265e-5*std::exp(1.1283198595047*x_26) + 0.00667886013626304*std::exp(0.954079806804657*x_27) + 0.013885960122427*std::exp(0.98039984703064*x_27) - 0.00150339883864137*std::exp(0.568239867687225*x_28) + 0.614904420618224*std::exp(0.650319814682007*x_28) + 0.0129674415798899*std::exp(1.03335976600647*x_28) - 0.0147344219917681*std::exp(1.16567981243134*x_29) + 1.9482553525598e-5*std::exp(1.36007988452911*x_29) + 1.1974571513988*std::exp(0.599999845027924*x_3) + 0.18634217307927*std::exp(0.637119889259338*x_3) - 0.436677329115659*std::exp(0.828319907188416*x_30) - 0.0274425347020922*std::exp(0.892719864845276*x_30) - 0.000144742678017957*std::exp(1.10247993469238*x_30) - 10.77693218412*std::exp(0.882719874382019*x_32) + 3.5053940140267*std::exp(0.415839850902557*x_33) + 0.240755078151653*std::exp(0.467359870672226*x_33) - 0.241627798946545*std::exp(0.612639844417572*x_4) + 0.0792408898922971*std::exp(0.691119849681854*x_4) + 0.0161297037276324*std::exp(1.22247993946075*x_4) - 16.7503416559935*std::exp(0.737679839134216*x_41) - 0.0524519330114079*std::exp(0.798239827156067*x_41) - 0.00204018473257843*std::exp(0.799759864807129*x_41) - 0.0492393824987784*std::exp(0.821119904518127*x_41) - 0.0664510231565845*std::exp(0.822159886360168*x_41) - 2.67919368909895*std::exp(0.807039856910706*x_42) + 0.00289101254260697*std::exp(0.848479866981506*x_43) + 0.00114997744990894*std::exp(0.914319813251495*x_44) - 4.46582762367626e-5*std::exp(0.967199802398682*x_44) - 0.0566220366480425*std::exp(0.543519854545593*x_45) + 0.319912075886331*std::exp(0.547439873218536*x_45) - 0.0992650763676798*std::exp(0.731919825077057*x_46) - 15.6524618175294*std::exp(0.767999827861786*x_46) + 0.00353304430907847*std::exp(0.570559859275818*x_47) - 9.92985961939456*std::exp(0.685039818286896*x_49) + 0.00437471427943826*std::exp(0.712159812450409*x_49) - 0.236012158533891*std::exp(0.735519826412201*x_49) - 0.452254010607079*std::exp(0.737599849700928*x_49) - 0.0331745095428128*std::exp(0.799999833106995*x_49) + 0.00585436871671767*std::exp(0.508159816265106*x_50) - 0.058558832566618*std::exp(0.55079984664917*x_50) - 0.216101126724167*std::exp(0.554719865322113*x_50) - 105.379649814412*std::exp(0.564399838447571*x_50) - 0.72671314592913*std::exp(0.585679829120636*x_50) + 1.99736113270261*std::exp(0.487999856472015*x_51) + 2.72960284857638*std::exp(0.494799852371216*x_51) + 0.0461613668493324*std::exp(0.495199859142303*x_51) - 5.87554172393427*std::exp(0.502639830112457*x_51) - 212.557990628408*std::exp(0.503999829292297*x_51) - 0.0932468735731383*std::exp(0.507519841194153*x_52) + 5.85445654122398*std::exp(0.658879816532135*x_52) - 8.27335790487125e-5*std::exp(0.705439865589142*x_52) - 0.0821948320781754*std::exp(0.773359835147858*x_52) + 0.00123605240702264*std::exp(0.525039851665497*x_53) - 73.9927435431011*std::exp(0.453999847173691*x_54) + 0.885390944073492*std::exp(0.459519863128662*x_54) - 2.88965622760513*std::exp(0.508879840373993*x_54) + 0.00701761615744461*std::exp(0.512559831142426*x_54) - 0.0630987904180433*std::exp(0.651999831199646*x_55) + 602.605677221503*std::exp(0.652239859104156*x_55) + 2.53532484178262*std::exp(0.653599858283997*x_55) - 0.29103395988907*std::exp(0.711279809474945*x_55) - 0.636599119671957*std::exp(0.469519853591919*x_56) + 1.46925234812479*std::exp(0.561119854450226*x_56) + 0.00827015489751376*std::exp(0.585519850254059*x_56) - 0.989557075665086*std::exp(0.610479831695557*x_57) - 270.270524495049*std::exp(0.631999850273132*x_57) - 2.82093981555197*std::exp(0.635999858379364*x_57) + 0.300186204637551*std::exp(0.638479828834534*x_57) - 0.00121338697636859*std::exp(0.672319829463959*x_57) + 0.00830212317333622*std::exp(0.59175980091095*x_58) + 0.170718661377383*std::exp(0.593759834766388*x_58) - 125.008891415413*std::exp(0.61847984790802*x_58) + 0.343888343767405*std::exp(0.626239836215973*x_58) + 0.149712176080273*std::exp(0.706959843635559*x_58) - 0.000761291942849304*std::exp(0.621359825134277*x_59) - 0.00100251073738826*std::exp(0.799279868602753*x_60) - 0.0307231850512053*std::exp(0.800079882144928*x_60) + 13.3057041065556*std::exp(0.807039856910706*x_60) + 0.43229328048142*std::exp(0.808319866657257*x_60) - 0.158696309836073*std::exp(0.832079887390137*x_60) - 0.0541091211910029*std::exp(1.13375985622406*x_61) + 4.47266500080971*std::exp(1.2727198600769*x_61) + 0.137585136745653*std::exp(1.33911991119385*x_61) + 0.268911852315657*std::exp(0.915039837360382*x_66) + 0.18395953036989*std::exp(0.965039789676666*x_66) - 0.0745705683318249*std::exp(1.11287987232208*x_66) - 1.02032038939693*std::exp(0.34607982635498*x_8) + 0.0373097614257339*std::exp(0.950719833374023*x_8) + 6.46367617842657*std::log(8.08096027374268 - 1.18407988548279*x_5) - 6.44309362981332*std::log(9.57600021362305 - 1.22015988826752*x_21) - 0.875898091431362*std::sin(0.275039941072464*x_100 + 1.92927980422974) - 1.50906004001702*std::sin(0.226159989833832*x_101 + 1.98423981666565) - 9.38464041743885*std::sin(0.225599989295006*x_102 - 7.41752004623413) - 316.773354586085*std::sin(0.223199993371964*x_110 - 1.21599984169006) - 2.37681368332566*std::sin(0.268159955739975*x_120 + 1.97151982784271) + 1.68333538712957*std::sin(0.303919941186905*x_120 + 1.93567979335785) - 1950.35750292684*std::sin(0.152400031685829*x_30 + 1.75583982467651) - 1.9576095452124*std::sin(0.390159845352173*x_31 - 7.40823984146118) + 1.24130193595803*std::sin(0.44327986240387*x_31 - 7.37296009063721) + 2.88659939176661*std::sin(0.297759920358658*x_42 - 4.28904008865356) + 1.4404779393966*std::sin(0.238159984350204*x_55 - 4.43512010574341) - 2.79952108915154*std::sin(0.299839943647385*x_91 - 1.14311993122101) + 48.4652840744624*std::sin(0.467279851436615*x_91 + 1.77087986469269) + 1.56734515207891*std::sin(0.308479934930801*x_92 + 8.217360496521) + 0.0276064913113596*std::sin(0.270239949226379*x_95 + 1.96583986282349) - 6.39555322076745*std::sin(0.334639847278595*x_97 + 1.84383988380432) + 1.10342961523694*std::sin(0.268479973077774*x_98 + 1.9592798948288) + 2342.03211187061);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0532791004690636*x_1 - 0.145828359677849*x_10 - 10.5805201679654*x_100 - 4.50180130640807*x_101 - 7.34402725056771*x_102 + 15.7129474518516*x_103 - 49.6439053763659*x_104 - 10.9581766291197*x_105 - 7.34445615439855*x_106 - 4.1061597032135*x_107 + 6.77277472231468*x_108 - 10.0607224463916*x_109 + 0.786291077138314*x_110 - 12.2470704150517*x_111 - 5.43303065330496*x_112 - 13.3605032613332*x_113 + 14.5265068512084*x_114 + 6.74793583257367*x_115 - 14.4421902025095*x_116 - 9.82077298484711*x_117 - 1.45790830074032*x_118 + 5.13640961694725*x_119 - 0.558156280197716*x_12 + 15.1798361790625*x_120 - 32.0777717276706*x_13 - 5.24233323853288*x_14 - 34.5813593376001*x_18 - 0.183171802429013*x_19 + 5.6672456155737*x_2 - 0.423841313725726*x_20 + 0.0730035497162851*x_21 + 0.0929105626942912*x_22 + 7.70100436146504*x_24 - 1.65718836205895*x_25 + 3.94115741569109*x_26 - 6.91541679063546*x_27 + 0.548787759903668*x_28 + 33.0561418405548*x_29 + 1.5895273325592*x_3 + 0.16485332068678*x_30 + 2.50353156213814*x_31 + 0.662198039159165*x_32 + 25.7227660651817*x_33 - 70.2274727959973*x_34 - 117.944874926942*x_35 + 54.7913231018018*x_36 - 182.404866581183*x_37 + 73.3352610006908*x_38 - 139.241163882128*x_39 - 3.22804517023748*x_4 - 274.118322246639*x_40 - 0.218644646452423*x_42 - 15.548706728033*x_43 + 7.31272456599916*x_44 - 21.1886117466748*x_45 + 0.0608791676865646*x_46 + 114.201693155726*x_47 - 71.454837907545*x_48 - 0.305158622303962*x_5 + 1.45989140291251*x_52 + 6.86778649832277*x_53 - 2.87900994768577*x_54 + 15.6764972070053*x_56 + 32.1481007995511*x_59 - 6.3690519573126*x_6 - 1.50602761990625*x_61 + 0.596345028201052*x_62 - 6.07520065280094*x_63 - 1.72954690113597*x_64 + 2.69358484324937*x_65 - 2.72709723694767*x_66 - 4.89438971227282*x_67 - 0.678333670806895*x_68 - 4.71526137386703*x_69 - 13.9742495799328*x_7 + 4.95239180607972*x_70 - 5.29478413125267*x_71 + 2.19523996444563*x_72 - 6.78361255156825*x_73 + 11.2619668466121*x_74 + 7.10008476603282*x_75 + 7.42328572439029*x_76 + 7.59186194656951*x_77 + 2.51473690351521*x_78 + 31.2041575324302*x_79 - 13.9408808026812*x_8 - 2.9860254306932*x_80 + 9.63319355567182*x_81 - 5.36843850231455*x_82 + 12.6846175816761*x_83 - 6.03668768713794*x_84 - 18.0437923838711*x_85 - 32.9369079452833*x_86 - 66.6845253421487*x_87 + 9.6252571240353*x_88 - 4.28142098974364*x_89 + 8.00060613900535*x_9 - 1.76843639711873*x_90 + 1.08580434228831*x_91 + 7.51959542482106*x_92 - 1.68052513137463*x_93 - 8.28960711541736*x_94 - 7.14675162566323*x_95 - 5.82164120444062*x_96 + 1.77308163067865*x_97 + 4.71005657858189*x_98 - 1.59402933221565*x_99 + 0.000362492856659927*std::pow(-9.59200000762939*x_16 - 6.19047975540161, 2) + 0.0120942573530096*std::pow(-9.63535976409912*x_18 - 5.02335977554321, 2) - 0.0438045139797977*std::pow(-7.45879983901978*x_28 - 6.84511995315552, 2) + 0.151895334940959*std::exp(0.779199838638306*x_1) + 0.513724788932307*std::exp(1.14455986022949*x_1) - 0.0947827214260113*std::exp(1.20367991924286*x_1) + 0.343322775955588*std::exp(1.76095998287201*x_1) + 0.387820395045882*std::exp(0.533119857311249*x_10) - 0.0108488641461108*std::exp(0.675439834594727*x_10) - 0.39426529133169*std::exp(0.918319821357727*x_10) + 0.0153901269256302*std::exp(0.870079874992371*x_11) + 0.190158985492837*std::exp(0.924879848957062*x_11) - 0.55826309156456*std::exp(0.94023984670639*x_11) + 0.021216163350159*std::exp(0.976159811019897*x_11) + 0.306262380197388*std::exp(0.993999779224396*x_11) + 0.182167274595569*std::exp(0.283759832382202*x_12) + 0.271668659435805*std::exp(0.713359832763672*x_12) + 0.00101686828516985*std::exp(1.27959990501404*x_12) + 1.03810564220274*std::exp(0.310159832239151*x_13) - 0.000590067506046884*std::exp(1.05879986286163*x_13) - 4.61408189129905e-5*std::exp(1.53175985813141*x_13) - 0.291252026441408*std::exp(0.278959840536118*x_15) - 0.235412833566572*std::exp(0.582399845123291*x_15) - 0.102750986876409*std::exp(0.681759834289551*x_15) - 0.141492457674854*std::exp(0.954799830913544*x_15) + 0.625590631073992*std::exp(1.00311982631683*x_15) + 0.500371193726777*std::exp(0.590239822864532*x_16) + 1.26338898995015*std::exp(0.650239825248718*x_16) - 5.49096251920489*std::exp(0.729439854621887*x_16) + 0.0532759071398096*std::exp(0.863999843597412*x_16) + 0.665806476642748*std::exp(0.61847984790802*x_17) - 0.0793326366431617*std::exp(0.625439822673798*x_17) + 8.82466440165691*std::exp(0.647039830684662*x_17) + 2.0132896585106*std::exp(0.67199981212616*x_17) + 0.00804728907805139*std::exp(1.05343985557556*x_17) + 12.9780579187518*std::exp(0.750399827957153*x_19) + 0.675313151102621*std::exp(0.754719853401184*x_19) - 1.66949209284354*std::exp(0.763839840888977*x_19) - 0.0451757977082162*std::exp(0.82999986410141*x_19) + 0.0423334159403144*std::exp(0.768799841403961*x_2) - 0.721048388005807*std::exp(0.44191986322403*x_20) + 0.0324954920294636*std::exp(0.842719852924347*x_20) + 0.0696777799380525*std::exp(0.891919851303101*x_20) + 0.00439150246781499*std::exp(0.933999836444855*x_20) - 1.32720665818281*std::exp(0.636719882488251*x_22) - 0.00123784089615946*std::exp(1.36591982841492*x_22) - 0.000199805690001228*std::exp(1.53999984264374*x_22) + 0.139391232270995*std::exp(0.463439851999283*x_23) - 12.0296528799595*std::exp(0.544079840183258*x_23) - 0.244465431148579*std::exp(0.579119861125946*x_23) - 0.550632285292729*std::exp(0.848079860210419*x_23) - 0.00786111266404732*std::exp(1.14591991901398*x_23) + 0.942918929264514*std::exp(0.482319831848145*x_24) - 0.100585458570973*std::exp(0.533679842948914*x_24) + 3.37278534999687*std::exp(0.572719871997833*x_24) - 0.401736178716618*std::exp(0.535999834537506*x_25) - 0.0725924232353415*std::exp(0.614799857139587*x_25) - 0.0413655792450076*std::exp(0.786159873008728*x_25) + 0.282351185381528*std::exp(1.07983982563019*x_25) + 0.511448776487793*std::exp(0.489839851856232*x_26) - 1.87248113718915*std::exp(0.850239872932434*x_26) + 0.0314440509232319*std::exp(0.868559896945953*x_26) - 0.000406679505469549*std::exp(1.1283198595047*x_26) + 0.027848020724649*std::exp(0.954079806804657*x_27) + 0.0646899259425021*std::exp(0.98039984703064*x_27) + 0.0301318080480933*std::exp(0.568239867687225*x_28) - 0.218201775330257*std::exp(0.650319814682007*x_28) + 0.0604108630639064*std::exp(1.03335976600647*x_28) + 0.00522858013256197*std::exp(1.16567981243134*x_29) - 0.000390478260346762*std::exp(1.36007988452911*x_29) - 0.424923398752659*std::exp(0.599999845027924*x_3) + 0.77696801428921*std::exp(0.637119889259338*x_3) + 0.154957039280533*std::exp(0.828319907188416*x_30) - 0.1144237578762*std::exp(0.892719864845276*x_30) + 0.00290099904184139*std::exp(1.10247993469238*x_30) - 1.8461759138592*std::exp(0.882719874382019*x_32) - 1.24390583551777*std::exp(0.415839850902557*x_33) + 1.00384680456613*std::exp(0.467359870672226*x_33) - 1.12566104768345*std::exp(0.612639844417572*x_4) + 0.330400981445768*std::exp(0.691119849681854*x_4) - 0.00572370253149575*std::exp(1.22247993946075*x_4) - 2.8694694172591*std::exp(0.737679839134216*x_41) - 0.218702366533891*std::exp(0.798239827156067*x_41) + 0.0408903167706706*std::exp(0.799759864807129*x_41) + 0.0174728304385857*std::exp(0.821119904518127*x_41) - 0.309572527135531*std::exp(0.822159886360168*x_41) - 0.458967614611741*std::exp(0.807039856910706*x_42) + 0.0120542990209682*std::exp(0.848479866981506*x_43) + 0.00479491937315244*std::exp(0.914319813251495*x_44) + 0.000895061624858589*std::exp(0.967199802398682*x_44) - 0.236089934191792*std::exp(0.543519854545593*x_45) - 0.113522330572617*std::exp(0.547439873218536*x_45) - 0.462441947282481*std::exp(0.731919825077057*x_46) - 2.68139369408894*std::exp(0.767999827861786*x_46) - 0.0708108921001741*std::exp(0.570559859275818*x_47) - 1.70106551142098*std::exp(0.685039818286896*x_49) - 0.0876800271127064*std::exp(0.712159812450409*x_49) - 1.09949970491626*std::exp(0.735519826412201*x_49) + 0.160484499225877*std::exp(0.737599849700928*x_49) - 0.13832366757649*std::exp(0.799999833106995*x_49) - 0.117335938994283*std::exp(0.508159816265106*x_50) - 0.244165553650726*std::exp(0.55079984664917*x_50) - 1.00674103631476*std::exp(0.554719865322113*x_50) - 18.0523889335554*std::exp(0.564399838447571*x_50) + 0.257877636394525*std::exp(0.585679829120636*x_50) + 9.30502051106138*std::exp(0.487999856472015*x_51) + 11.3812888945669*std::exp(0.494799852371216*x_51) - 0.925187255298595*std::exp(0.495199859142303*x_51) + 2.08496408905384*std::exp(0.502639830112457*x_51) - 36.412908227697*std::exp(0.503999829292297*x_51) - 0.388800007006347*std::exp(0.507519841194153*x_52) + 1.00291590134245*std::exp(0.658879816532135*x_52) + 0.00165818428147811*std::exp(0.705439865589142*x_52) + 0.0291672293791584*std::exp(0.773359835147858*x_52) - 0.0247735284267267*std::exp(0.525039851665497*x_53) - 12.6755572546816*std::exp(0.453999847173691*x_54) + 4.12473275864956*std::exp(0.459519863128662*x_54) + 1.02540833634541*std::exp(0.508879840373993*x_54) - 0.140650276943417*std::exp(0.512559831142426*x_54) + 1.26465485543513*std::exp(0.651999831199646*x_55) + 103.231241306358*std::exp(0.652239859104156*x_55) + 11.8112089339947*std::exp(0.653599858283997*x_55) + 0.103274792959437*std::exp(0.711279809474945*x_55) - 2.96569697331402*std::exp(0.469519853591919*x_56) - 0.521371224566337*std::exp(0.561119854450226*x_56) - 0.165754232007444*std::exp(0.585519850254059*x_56) - 4.61000704137589*std::exp(0.610479831695557*x_57) - 46.2995334872841*std::exp(0.631999850273132*x_57) + 1.00102398879226*std::exp(0.635999858379364*x_57) + 1.25164945476424*std::exp(0.638479828834534*x_57) + 0.0243192574852829*std::exp(0.672319829463959*x_57) - 0.166394954832254*std::exp(0.59175980091095*x_58) + 0.711824581309732*std::exp(0.593759834766388*x_58) - 21.4150372672333*std::exp(0.61847984790802*x_58) + 1.60205785517659*std::exp(0.626239836215973*x_58) - 0.0531260818981068*std::exp(0.706959843635559*x_58) + 0.0152581617737749*std::exp(0.621359825134277*x_59) + 0.0200927793268978*std::exp(0.799279868602753*x_60) - 0.128102681681834*std::exp(0.800079882144928*x_60) + 2.27937505950506*std::exp(0.807039856910706*x_60) - 0.153401338649591*std::exp(0.808319866657257*x_60) - 0.739311681736964*std::exp(0.832079887390137*x_60) - 0.225612140032431*std::exp(1.13375985622406*x_61) + 0.766203800319284*std::exp(1.2727198600769*x_61) - 0.0488227439750299*std::exp(1.33911991119385*x_61) - 0.0954246572558878*std::exp(0.915039837360382*x_66) + 0.857004362040877*std::exp(0.965039789676666*x_66) - 0.310927716703983*std::exp(1.11287987232208*x_66) - 4.75332276960161*std::exp(0.34607982635498*x_8) - 0.0132395473300687*std::exp(0.950719833374023*x_8) - 2.29366641383805*std::log(8.08096027374268 - 1.18407988548279*x_5) + 2.2863625979967*std::log(9.57600021362305 - 1.22015988826752*x_21) - 3.65212442021715*std::sin(0.275039941072464*x_100 + 1.92927980422974) - 7.03019318583697*std::sin(0.226159989833832*x_101 + 1.98423981666565) + 3.33018454780735*std::sin(0.225599989295006*x_102 - 7.41752004623413) - 54.265845548416*std::sin(0.223199993371964*x_110 - 1.21599984169006) - 11.0727598090343*std::sin(0.268159955739975*x_120 + 1.97151982784271) - 0.597339615120394*std::sin(0.303919941186905*x_120 + 1.93567979335785) - 334.112063043674*std::sin(0.152400031685829*x_30 + 1.75583982467651) - 9.11983149797436*std::sin(0.390159845352173*x_31 - 7.40823984146118) - 0.440481930304895*std::sin(0.44327986240387*x_31 - 7.37296009063721) + 13.4476765907935*std::sin(0.297759920358658*x_42 - 4.28904008865356) + 6.00618349408365*std::sin(0.238159984350204*x_55 - 4.43512010574341) + 0.993423451262885*std::sin(0.299839943647385*x_91 - 1.14311993122101) + 8.30249634942123*std::sin(0.467279851436615*x_91 + 1.77087986469269) + 7.30172353372733*std::sin(0.308479934930801*x_92 + 8.217360496521) - 0.553301942036204*std::sin(0.270239949226379*x_95 + 1.96583986282349) + 2.26949265641569*std::sin(0.334639847278595*x_97 + 1.84383988380432) + 4.60083459847732*std::sin(0.268479973077774*x_98 + 1.9592798948288) + 543.523407692732);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0807385396370186*x_1 + 0.919038763190312*x_10 + 41.9831576027899*x_100 + 17.2397679637597*x_101 + 30.3445779285355*x_102 - 63.8869086716373*x_103 + 181.967220889451*x_104 + 40.8431139920688*x_105 + 45.8413652573997*x_106 + 14.3016952494196*x_107 - 26.6533280832616*x_108 + 42.7630948058703*x_109 + 1.39705545077965*x_110 + 44.673188081156*x_111 + 18.0653475614093*x_112 + 53.9424790507514*x_113 - 60.3137301646862*x_114 - 32.9207910441627*x_115 + 58.8493256884336*x_116 + 34.8985718389819*x_117 + 0.366443647505514*x_118 - 16.9660167006107*x_119 - 0.561616890549105*x_12 - 59.5816396906808*x_120 + 126.53101300916*x_13 + 19.0740541016996*x_14 + 144.894299730886*x_18 - 0.539449735490226*x_19 - 23.8342215318059*x_2 + 1.69322864435207*x_20 - 1.2614365927823*x_21 - 0.914503093124152*x_22 - 30.3939869245973*x_24 + 4.84927177689963*x_25 - 11.5326319335747*x_26 + 23.1090708174785*x_27 - 0.639193775577717*x_28 - 130.133384621689*x_29 - 7.98947964439474*x_3 - 0.482394502421777*x_30 - 8.85074146558891*x_31 - 8.16028172714973*x_32 - 105.39347107599*x_33 + 280.65553490938*x_34 + 442.251961486667*x_35 - 227.707883261427*x_36 + 670.077451829562*x_37 - 188.763636234463*x_38 + 535.205013851777*x_39 + 13.3755656022202*x_4 + 587.847957012013*x_40 - 0.257498271471362*x_42 + 64.2459547671245*x_43 - 29.1841602014476*x_44 + 77.8802466415859*x_45 + 1.74367259576607*x_46 - 447.225478674576*x_47 + 277.49392902246*x_48 + 1.42297311398647*x_5 - 4.27194055881876*x_52 - 27.3387150538826*x_53 + 3.3532913319898*x_54 - 59.3788768413641*x_56 - 128.59939572715*x_59 + 21.8808008868873*x_6 + 4.39793582301326*x_61 - 4.39481314327762*x_62 + 24.279944624638*x_63 + 8.31488298430105*x_64 - 11.1059070672181*x_65 + 10.9196177666612*x_66 + 19.3939532397275*x_67 + 5.53798039970635*x_68 + 19.2630561752625*x_69 + 51.3408086045171*x_7 - 18.2675237815815*x_70 + 22.0516007558445*x_71 - 8.77530312162208*x_72 + 25.0630068580536*x_73 - 44.4932235969664*x_74 - 30.0724520268673*x_75 - 32.218280446093*x_76 - 29.3742080624818*x_77 - 10.1268268241505*x_78 - 124.246436235788*x_79 + 56.2478522127503*x_8 + 13.3832525427*x_80 - 37.6193550587206*x_81 + 23.3486546496618*x_82 - 53.6263300377495*x_83 + 27.0848017151083*x_84 + 72.5634289821182*x_85 + 116.445088117005*x_86 + 248.389498950998*x_87 - 29.6569530395927*x_88 + 18.0623772878215*x_89 - 28.1465546174533*x_9 + 9.11353813738483*x_90 - 3.81866106467307*x_91 - 31.3184265874408*x_92 + 6.23083511019051*x_93 + 29.164713564067*x_94 + 28.5116802157562*x_95 + 22.4385982005152*x_96 - 8.42253285894359*x_97 - 21.046582173868*x_98 + 5.69279142102483*x_99 + 0.000549317530099209*std::pow(-9.59200000762939*x_16 - 6.19047975540161, 2) - 0.0353902683528647*std::pow(-9.63535976409912*x_18 - 5.02335977554321, 2) + 0.174997234626616*std::pow(-7.45879983901978*x_28 - 6.84511995315552, 2) + 0.447339040013294*std::exp(0.779199838638306*x_1) - 1.50326370682932*std::exp(1.14455986022949*x_1) + 0.1103970058998*std::exp(1.20367991924286*x_1) - 1.3715603922525*std::exp(1.76095998287201*x_1) - 0.451709022444184*std::exp(0.533119857311249*x_10) - 0.016440244676916*std::exp(0.675439834594727*x_10) + 1.57507364935319*std::exp(0.918319821357727*x_10) + 0.0233220223664482*std::exp(0.870079874992371*x_11) - 0.221485333270791*std::exp(0.924879848957062*x_11) + 1.63359188127852*std::exp(0.94023984670639*x_11) + 0.0624826177151155*std::exp(0.976159811019897*x_11) - 1.22350563299084*std::exp(0.993999779224396*x_11) + 0.276054204951191*std::exp(0.283759832382202*x_12) - 0.794958010224876*std::exp(0.713359832763672*x_12) + 0.00299472582673233*std::exp(1.27959990501404*x_12) - 1.20912074461095*std::exp(0.310159832239151*x_13) - 0.00089418155160382*std::exp(1.05879986286163*x_13) - 0.000135886922702316*std::exp(1.53175985813141*x_13) - 0.441359990581218*std::exp(0.278959840536118*x_15) + 0.274194194734372*std::exp(0.582399845123291*x_15) - 0.302606580034717*std::exp(0.681759834289551*x_15) + 0.414035843695133*std::exp(0.954799830913544*x_15) - 2.49920888282788*std::exp(1.00311982631683*x_15) - 0.582801177206813*std::exp(0.590239822864532*x_16) - 3.69693434522988*std::exp(0.650239825248718*x_16) + 21.9361697915976*std::exp(0.729439854621887*x_16) + 0.156900099433754*std::exp(0.863999843597412*x_16) - 0.77548988279928*std::exp(0.61847984790802*x_17) - 0.120219770449058*std::exp(0.625439822673798*x_17) - 35.2541719218736*std::exp(0.647039830684662*x_17) - 5.89129693597984*std::exp(0.67199981212616*x_17) + 0.0236996519497076*std::exp(1.05343985557556*x_17) - 51.8468084739633*std::exp(0.750399827957153*x_19) - 0.786562664638039*std::exp(0.754719853401184*x_19) + 4.88527500731704*std::exp(0.763839840888977*x_19) - 0.0684588872895221*std::exp(0.82999986410141*x_19) + 0.0641515744593341*std::exp(0.768799841403961*x_2) + 2.10993492217824*std::exp(0.44191986322403*x_20) + 0.0957007811653348*std::exp(0.842719852924347*x_20) - 0.0811563349013015*std::exp(0.891919851303101*x_20) + 0.00665483262559251*std::exp(0.933999836444855*x_20) + 5.30213610102239*std::exp(0.636719882488251*x_22) + 0.00144175991847843*std::exp(1.36591982841492*x_22) - 0.000588437331463044*std::exp(1.53999984264374*x_22) + 0.211231879530311*std::exp(0.463439851999283*x_23) + 48.057969287866*std::exp(0.544079840183258*x_23) + 0.284738096129411*std::exp(0.579119861125946*x_23) + 1.61126258284982*std::exp(0.848079860210419*x_23) - 0.023151353489152*std::exp(1.14591991901398*x_23) - 1.09825319457941*std::exp(0.482319831848145*x_24) - 0.152426053785493*std::exp(0.533679842948914*x_24) - 9.86945912832723*std::exp(0.572719871997833*x_24) + 0.4679172598622*std::exp(0.535999834537506*x_25) - 0.110005728121049*std::exp(0.614799857139587*x_25) - 0.121823613057295*std::exp(0.786159873008728*x_25) - 1.12798139155481*std::exp(1.07983982563019*x_25) + 1.50624115466715*std::exp(0.489839851856232*x_26) + 7.48048525432165*std::exp(0.850239872932434*x_26) - 0.0366240705379556*std::exp(0.868559896945953*x_26) - 0.000616277472458112*std::exp(1.1283198595047*x_26) - 0.0324356387111832*std::exp(0.954079806804657*x_27) - 0.18929594203338*std::exp(0.98039984703064*x_27) + 0.0456613973773566*std::exp(0.568239867687225*x_28) - 0.642614684271736*std::exp(0.650319814682007*x_28) - 0.176774529667816*std::exp(1.03335976600647*x_28) + 0.0153984190366478*std::exp(1.16567981243134*x_29) - 0.00059172629085033*std::exp(1.36007988452911*x_29) - 1.251419771062*std::exp(0.599999845027924*x_3) - 0.904963912904724*std::exp(0.637119889259338*x_3) + 0.456355906005935*std::exp(0.828319907188416*x_30) + 0.133273660887621*std::exp(0.892719864845276*x_30) + 0.00439614077686362*std::exp(1.10247993469238*x_30) + 7.37539696727662*std::exp(0.882719874382019*x_32) - 3.66336229182907*std::exp(0.415839850902557*x_33) - 1.16921818596115*std::exp(0.467359870672226*x_33) + 3.29391424285928*std::exp(0.612639844417572*x_4) - 0.384830468562154*std::exp(0.691119849681854*x_4) - 0.0168565782270812*std::exp(1.22247993946075*x_4) + 11.463412494374*std::exp(0.737679839134216*x_41) + 0.254730884335172*std::exp(0.798239827156067*x_41) + 0.0619647184786087*std::exp(0.799759864807129*x_41) + 0.0514583229152507*std::exp(0.821119904518127*x_41) + 0.905872472382488*std::exp(0.822159886360168*x_41) + 1.83355677401811*std::exp(0.807039856910706*x_42) - 0.014040096128434*std::exp(0.848479866981506*x_43) - 0.00558482320789015*std::exp(0.914319813251495*x_44) + 0.0013563661518306*std::exp(0.967199802398682*x_44) + 0.274982839337444*std::exp(0.543519854545593*x_45) - 0.334328703367785*std::exp(0.547439873218536*x_45) + 1.35319963303705*std::exp(0.731919825077057*x_46) + 10.7120577031678*std::exp(0.767999827861786*x_46) - 0.107306016209531*std::exp(0.570559859275818*x_47) + 6.79568686813125*std::exp(0.685039818286896*x_49) - 0.132869310519321*std::exp(0.712159812450409*x_49) + 3.21736080811931*std::exp(0.735519826412201*x_49) + 0.472634540413126*std::exp(0.737599849700928*x_49) + 0.161110785972146*std::exp(0.799999833106995*x_49) - 0.177809540287518*std::exp(0.508159816265106*x_50) + 0.284388817511942*std::exp(0.55079984664917*x_50) + 2.94592998950483*std::exp(0.554719865322113*x_50) + 72.1185525134076*std::exp(0.564399838447571*x_50) + 0.759461996317818*std::exp(0.585679829120636*x_50) - 27.2283914012648*std::exp(0.487999856472015*x_51) - 13.2562158834154*std::exp(0.494799852371216*x_51) - 1.40201818773129*std::exp(0.495199859142303*x_51) + 6.1403191508289*std::exp(0.502639830112457*x_51) + 145.468073164755*std::exp(0.503999829292297*x_51) + 0.452850013394347*std::exp(0.507519841194153*x_52) - 4.00660784363301*std::exp(0.658879816532135*x_52) + 0.0025127934998328*std::exp(0.705439865589142*x_52) + 0.085898888174491*std::exp(0.773359835147858*x_52) - 0.0375415217077751*std::exp(0.525039851665497*x_53) + 50.6383307424354*std::exp(0.453999847173691*x_54) - 12.0698108988175*std::exp(0.459519863128662*x_54) + 3.01987668667167*std::exp(0.508879840373993*x_54) - 0.213139821430496*std::exp(0.512559831142426*x_54) + 1.91644350737463*std::exp(0.651999831199646*x_55) - 412.404570086479*std::exp(0.652239859104156*x_55) - 34.5620108407735*std::exp(0.653599858283997*x_55) + 0.304149214049291*std::exp(0.711279809474945*x_55) + 8.67823535380147*std::exp(0.469519853591919*x_56) - 1.53546323972831*std::exp(0.561119854450226*x_56) - 0.251182067886212*std::exp(0.585519850254059*x_56) + 13.4898226109178*std::exp(0.610479831695557*x_57) + 184.964735107296*std::exp(0.631999850273132*x_57) + 2.94806361466377*std::exp(0.635999858379364*x_57) - 1.45784326682319*std::exp(0.638479828834534*x_57) + 0.0368531247174204*std::exp(0.672319829463959*x_57) - 0.252153011928657*std::exp(0.59175980091095*x_58) - 0.829088902704868*std::exp(0.593759834766388*x_58) + 85.5521945277171*std::exp(0.61847984790802*x_58) - 4.68794864840588*std::exp(0.626239836215973*x_58) - 0.156458856917523*std::exp(0.706959843635559*x_58) + 0.0231220438842671*std::exp(0.621359825134277*x_59) + 0.0304483680433864*std::exp(0.799279868602753*x_60) + 0.149206018698768*std::exp(0.800079882144928*x_60) - 9.10600976589368*std::exp(0.807039856910706*x_60) - 0.451774293100808*std::exp(0.808319866657257*x_60) + 2.16337705155313*std::exp(0.832079887390137*x_60) + 0.262778957804766*std::exp(1.13375985622406*x_61) - 3.06095272003513*std::exp(1.2727198600769*x_61) - 0.143785320524123*std::exp(1.33911991119385*x_61) - 0.281030188234806*std::exp(0.915039837360382*x_66) - 2.50776988341948*std::exp(0.965039789676666*x_66) + 0.362149223602698*std::exp(1.11287987232208*x_66) + 13.9091937168115*std::exp(0.34607982635498*x_8) - 0.0389911013076577*std::exp(0.950719833374023*x_8) - 6.75495749804213*std::log(8.08096027374268 - 1.18407988548279*x_5) + 6.73344741040069*std::log(9.57600021362305 - 1.22015988826752*x_21) + 4.25376687965481*std::sin(0.275039941072464*x_100 + 1.92927980422974) + 20.5717818099296*std::sin(0.226159989833832*x_101 + 1.98423981666565) + 9.80755307108211*std::sin(0.225599989295006*x_102 - 7.41752004623413) + 216.789824674862*std::sin(0.223199993371964*x_110 - 1.21599984169006) + 32.4011578066033*std::sin(0.268159955739975*x_120 + 1.97151982784271) - 1.75919379020911*std::sin(0.303919941186905*x_120 + 1.93567979335785) + 1334.76397238426*std::sin(0.152400031685829*x_30 + 1.75583982467651) + 26.6864905074889*std::sin(0.390159845352173*x_31 - 7.40823984146118) - 1.29724039202642*std::sin(0.44327986240387*x_31 - 7.37296009063721) - 39.3506496000175*std::sin(0.297759920358658*x_42 - 4.28904008865356) - 6.99562815517203*std::sin(0.238159984350204*x_55 - 4.43512010574341) + 2.92567966743263*std::sin(0.299839943647385*x_91 - 1.14311993122101) - 33.1681319947155*std::sin(0.467279851436615*x_91 + 1.77087986469269) - 21.3663350923099*std::sin(0.308479934930801*x_92 + 8.217360496521) - 0.838467436293685*std::sin(0.270239949226379*x_95 + 1.96583986282349) + 6.68376462406059*std::sin(0.334639847278595*x_97 + 1.84383988380432) - 5.35876536008297*std::sin(0.268479973077774*x_98 + 1.9592798948288) - 1932.9129121725);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0739840374087776*x_1 + 0.0564406450871391*x_10 - 86.6619979775246*x_100 - 34.3113399550297*x_101 - 66.3455020970131*x_102 + 133.974446904111*x_103 - 514.995869779335*x_104 - 73.1951926278802*x_105 - 123.357256877134*x_106 - 36.8900341758169*x_107 + 51.9088814201038*x_108 - 90.7406800295733*x_109 + 1.01388153243386*x_110 - 77.7114759920789*x_111 - 28.1167726219014*x_112 - 113.91165831429*x_113 + 116.672248216004*x_114 + 73.4422952155826*x_115 - 117.632193867436*x_116 - 62.9042521439777*x_117 + 7.90534662167961*x_118 + 24.1889057695737*x_119 + 3.15762655497981*x_12 + 120.464877971326*x_120 - 249.933175843924*x_13 - 48.8275273282846*x_14 - 285.318621097388*x_18 - 0.310708919870752*x_19 + 49.4559557270129*x_2 - 3.45811870456309*x_20 + 4.8588830655945*x_21 + 0.289661251735451*x_22 + 62.4867676227508*x_24 - 0.619026041117251*x_25 + 1.47217970407661*x_26 - 53.1258666926926*x_27 + 0.186699768642333*x_28 + 256.348858303767*x_29 + 24.3739916038038*x_3 + 0.061579299496758*x_30 + 17.1041222742822*x_31 - 1.3503502393929*x_32 + 225.677065361793*x_33 - 701.757680711815*x_34 - 855.120061985876*x_35 + 413.387969837222*x_36 - 1535.90952083576*x_37 + 204.841778510988*x_38 - 1102.82144807998*x_39 - 27.1686888217331*x_4 - 962.072175136223*x_40 - 0.188645486852695*x_42 - 121.211824658865*x_43 + 48.2615271723832*x_44 - 128.463426546793*x_45 - 0.191411826436826*x_46 + 886.937776140025*x_47 - 566.703433691998*x_48 - 9.05559504162616*x_5 + 0.545327746861098*x_52 + 65.2194184217737*x_53 - 0.979450582582712*x_54 + 118.931259972975*x_56 + 295.344367222856*x_59 - 30.7226139243963*x_6 - 0.558987351306344*x_61 + 7.16229981183407*x_62 - 45.4012118991929*x_63 - 13.0263863389161*x_64 + 24.5857748643207*x_65 - 22.2936454236061*x_66 - 36.4704373018109*x_67 - 20.7538132039447*x_68 - 33.1538931708388*x_69 - 111.837413847804*x_7 + 40.6513542087294*x_70 - 39.4460452319055*x_71 + 17.2499578797189*x_72 - 40.6194879398573*x_73 + 82.3767920880041*x_74 + 57.8515719984476*x_75 + 62.7583087773707*x_76 + 56.8468786813291*x_77 + 27.3730372259071*x_78 + 255.04275263848*x_79 - 115.229246399321*x_8 - 27.8992909035935*x_80 + 76.4949985040797*x_81 - 53.6190721402549*x_82 + 113.796897256115*x_83 - 50.6164239862974*x_84 - 142.399304983138*x_85 - 319.725117335497*x_86 - 502.927428930022*x_87 + 24.0461971130561*x_88 - 29.1756057772208*x_89 + 62.8661642487635*x_9 - 26.4019661838194*x_90 + 0.373242481830448*x_91 + 65.2578931598203*x_92 - 17.977320748823*x_93 - 55.553977136633*x_94 - 55.078836795793*x_95 - 39.9047420917292*x_96 + 16.0923898247678*x_97 + 58.4122599017409*x_98 - 34.8260298801039*x_99 - 0.000503362197023482*std::pow(-9.59200000762939*x_16 - 6.19047975540161, 2) + 0.00451768816441908*std::pow(-9.63535976409912*x_18 - 5.02335977554321, 2) - 0.357400763522217*std::pow(-7.45879983901978*x_28 - 6.84511995315552, 2) + 0.257655571583959*std::exp(0.779199838638306*x_1) + 0.191896726767653*std::exp(1.14455986022949*x_1) - 0.0322454570864214*std::exp(1.20367991924286*x_1) + 2.80116844391161*std::exp(1.76095998287201*x_1) + 0.131938033826692*std::exp(0.533119857311249*x_10) + 0.0150648709111495*std::exp(0.675439834594727*x_10) - 3.21680811747488*std::exp(0.918319821357727*x_10) - 0.0213709262387566*std::exp(0.870079874992371*x_11) + 0.0646928397291613*std::exp(0.924879848957062*x_11) - 0.20853356165483*std::exp(0.94023984670639*x_11) + 0.035988351432443*std::exp(0.976159811019897*x_11) + 2.4987929000002*std::exp(0.993999779224396*x_11) - 0.252959797362932*std::exp(0.283759832382202*x_12) + 0.101479094710294*std::exp(0.713359832763672*x_12) + 0.00172488364664312*std::exp(1.27959990501404*x_12) + 0.353167649474494*std::exp(0.310159832239151*x_13) + 0.000819375253274505*std::exp(1.05879986286163*x_13) - 7.82673087030587e-5*std::exp(1.53175985813141*x_13) + 0.404436272945998*std::exp(0.278959840536118*x_15) - 0.0800883780097979*std::exp(0.582399845123291*x_15) - 0.174293465067558*std::exp(0.681759834289551*x_15) - 0.0528530841319648*std::exp(0.954799830913544*x_15) + 5.10419015951887*std::exp(1.00311982631683*x_15) + 0.170228261141385*std::exp(0.590239822864532*x_16) + 0.471926247338769*std::exp(0.650239825248718*x_16) - 44.8007298458049*std::exp(0.729439854621887*x_16) + 0.0903703481815103*std::exp(0.863999843597412*x_16) + 0.226509999369498*std::exp(0.61847984790802*x_17) + 0.11016230952609*std::exp(0.625439822673798*x_17) + 72.0003832580834*std::exp(0.647039830684662*x_17) + 0.752044097981533*std::exp(0.67199981212616*x_17) + 0.0136503788474651*std::exp(1.05343985557556*x_17) + 105.887895739161*std::exp(0.750399827957153*x_19) + 0.229744207658925*std::exp(0.754719853401184*x_19) - 0.623621975974705*std::exp(0.763839840888977*x_19) + 0.0627316880013154*std::exp(0.82999986410141*x_19) - 0.0587847204813105*std::exp(0.768799841403961*x_2) - 0.269340371499261*std::exp(0.44191986322403*x_20) + 0.0551211436217437*std::exp(0.842719852924347*x_20) + 0.0237046565984441*std::exp(0.891919851303101*x_20) - 0.00609809625161026*std::exp(0.933999836444855*x_20) - 10.8286710635591*std::exp(0.636719882488251*x_22) - 0.00042111837364878*std::exp(1.36591982841492*x_22) - 0.00033892449220382*std::exp(1.53999984264374*x_22) - 0.193560440247691*std::exp(0.463439851999283*x_23) - 98.1498647876243*std::exp(0.544079840183258*x_23) - 0.0831681075476242*std::exp(0.579119861125946*x_23) - 0.205683150738888*std::exp(0.848079860210419*x_23) - 0.0133345732936979*std::exp(1.14591991901398*x_23) + 0.320784752876164*std::exp(0.482319831848145*x_24) + 0.139674248704985*std::exp(0.533679842948914*x_24) + 1.25987003683324*std::exp(0.572719871997833*x_24) - 0.136672238525899*std::exp(0.535999834537506*x_25) + 0.10080276335288*std::exp(0.614799857139587*x_25) - 0.0701672106547363*std::exp(0.786159873008728*x_25) + 2.303701606718*std::exp(1.07983982563019*x_25) + 0.86755545779665*std::exp(0.489839851856232*x_26) - 15.2775622261439*std::exp(0.850239872932434*x_26) + 0.0106973906152274*std::exp(0.868559896945953*x_26) + 0.00056472034026762*std::exp(1.1283198595047*x_26) + 0.00947400690451174*std::exp(0.954079806804657*x_27) + 0.024164271046776*std::exp(0.98039984703064*x_27) - 0.041841412377423*std::exp(0.568239867687225*x_28) - 0.370129228558632*std::exp(0.650319814682007*x_28) + 0.0225658701564041*std::exp(1.03335976600647*x_28) + 0.0088690860924164*std::exp(1.16567981243134*x_29) + 0.000542223084970881*std::exp(1.36007988452911*x_29) - 0.720785014415163*std::exp(0.599999845027924*x_3) + 0.26432759458001*std::exp(0.637119889259338*x_3) + 0.262849050250969*std::exp(0.828319907188416*x_30) - 0.0389274154482287*std::exp(0.892719864845276*x_30) - 0.00402836421307533*std::exp(1.10247993469238*x_30) - 15.062938068755*std::exp(0.882719874382019*x_32) - 2.11000073946662*std::exp(0.415839850902557*x_33) + 0.341512657275265*std::exp(0.467359870672226*x_33) - 0.420479360066007*std::exp(0.612639844417572*x_4) + 0.112403721988903*std::exp(0.691119849681854*x_4) - 0.00970894759804388*std::exp(1.22247993946075*x_4) - 23.411983548203*std::exp(0.737679839134216*x_41) - 0.0744034109663372*std::exp(0.798239827156067*x_41) - 0.0567808145967977*std::exp(0.799759864807129*x_41) + 0.0296386463454807*std::exp(0.821119904518127*x_41) - 0.115637703171701*std::exp(0.822159886360168*x_41) - 3.74471398015872*std::exp(0.807039856910706*x_42) + 0.00410092025149271*std::exp(0.848479866981506*x_43) + 0.00163125055446453*std::exp(0.914319813251495*x_44) - 0.00124289397068837*std::exp(0.967199802398682*x_44) - 0.0803187303232284*std::exp(0.543519854545593*x_45) - 0.192564577329514*std::exp(0.547439873218536*x_45) - 0.172740537181399*std::exp(0.731919825077057*x_46) - 21.8774748651023*std::exp(0.767999827861786*x_46) + 0.0983289065311854*std::exp(0.570559859275818*x_47) - 13.8789831765639*std::exp(0.685039818286896*x_49) + 0.121753602234252*std::exp(0.712159812450409*x_49) - 0.410707053661826*std::exp(0.735519826412201*x_49) + 0.272225117344658*std::exp(0.737599849700928*x_49) - 0.0470582593511613*std::exp(0.799999833106995*x_49) + 0.162934179134418*std::exp(0.508159816265106*x_50) - 0.0830660880356001*std::exp(0.55079984664917*x_50) - 0.376057986169973*std::exp(0.554719865322113*x_50) - 147.289331670894*std::exp(0.564399838447571*x_50) + 0.437430220156387*std::exp(0.585679829120636*x_50) + 3.47579680219371*std::exp(0.487999856472015*x_51) + 3.87195954195515*std::exp(0.494799852371216*x_51) + 1.28472680476053*std::exp(0.495199859142303*x_51) + 3.53666302066489*std::exp(0.502639830112457*x_51) - 297.092697082435*std::exp(0.503999829292297*x_51) - 0.132271301694055*std::exp(0.507519841194153*x_52) + 8.18278474802106*std::exp(0.658879816532135*x_52) - 0.0023025758098667*std::exp(0.705439865589142*x_52) + 0.0494755099630189*std::exp(0.773359835147858*x_52) + 0.0344008370587*std::exp(0.525039851665497*x_53) - 103.419794658197*std::exp(0.453999847173691*x_54) + 1.54075242664699*std::exp(0.459519863128662*x_54) + 1.7393698832866*std::exp(0.508879840373993*x_54) + 0.195308765713468*std::exp(0.512559831142426*x_54) - 1.75611583735414*std::exp(0.651999831199646*x_55) + 842.263070861928*std::exp(0.652239859104156*x_55) + 4.41195827499985*std::exp(0.653599858283997*x_55) + 0.17518198185956*std::exp(0.711279809474945*x_55) - 1.10780626908523*std::exp(0.469519853591919*x_56) - 0.884386613488054*std::exp(0.561119854450226*x_56) + 0.230168437408633*std::exp(0.585519850254059*x_56) - 1.72202175303718*std::exp(0.610479831695557*x_57) - 377.757612530739*std::exp(0.631999850273132*x_57) + 1.6980074345389*std::exp(0.635999858379364*x_57) + 0.42581609995603*std::exp(0.638479828834534*x_57) - 0.0337700306443722*std::exp(0.672319829463959*x_57) + 0.231058153282627*std::exp(0.59175980091095*x_58) + 0.24216554076895*std::exp(0.593759834766388*x_58) - 174.725159002923*std::exp(0.61847984790802*x_58) + 0.598432594891396*std::exp(0.626239836215973*x_58) - 0.0901162040479617*std::exp(0.706959843635559*x_58) - 0.0211876777483436*std::exp(0.621359825134277*x_59) - 0.0279010892503841*std::exp(0.799279868602753*x_60) - 0.0435810394835684*std::exp(0.800079882144928*x_60) + 18.5974072671213*std::exp(0.807039856910706*x_60) - 0.260210161206517*std::exp(0.808319866657257*x_60) - 0.276162441141431*std::exp(0.832079887390137*x_60) - 0.0767541432672448*std::exp(1.13375985622406*x_61) + 6.25145215340204*std::exp(1.2727198600769*x_61) - 0.0828165789954854*std::exp(1.33911991119385*x_61) - 0.161866028459834*std::exp(0.915039837360382*x_66) + 0.320125357865328*std::exp(0.965039789676666*x_66) - 0.105778840226525*std::exp(1.11287987232208*x_66) - 1.77555590154108*std::exp(0.34607982635498*x_8) - 0.0224578532064048*std::exp(0.950719833374023*x_8) - 3.89067861175647*std::log(8.08096027374268 - 1.18407988548279*x_5) + 3.87828936460757*std::log(9.57600021362305 - 1.22015988826752*x_21) - 1.24246718700003*std::sin(0.275039941072464*x_100 + 1.92927980422974) - 2.62605793991409*std::sin(0.226159989833832*x_101 + 1.98423981666565) + 5.64889371670887*std::sin(0.225599989295006*x_102 - 7.41752004623413) - 442.75470425553*std::sin(0.223199993371964*x_110 - 1.21599984169006) - 4.13611803326487*std::sin(0.268159955739975*x_120 + 1.97151982784271) - 1.01324955123481*std::sin(0.303919941186905*x_120 + 1.93567979335785) - 2726.01829320293*std::sin(0.152400031685829*x_30 + 1.75583982467651) - 3.40662130938055*std::sin(0.390159845352173*x_31 - 7.40823984146118) - 0.747176492084023*std::sin(0.44327986240387*x_31 - 7.37296009063721) + 5.02324430512016*std::sin(0.297759920358658*x_42 - 4.28904008865356) + 2.04332740395969*std::sin(0.238159984350204*x_55 - 4.43512010574341) + 1.68511486715204*std::sin(0.299839943647385*x_91 - 1.14311993122101) + 67.7400172911876*std::sin(0.467279851436615*x_91 + 1.77087986469269) + 2.72748536973801*std::sin(0.308479934930801*x_92 + 8.217360496521) + 0.768322122888034*std::sin(0.270239949226379*x_95 + 1.96583986282349) + 3.84967338082944*std::sin(0.334639847278595*x_97 + 1.84383988380432) + 1.56522214571283*std::sin(0.268479973077774*x_98 + 1.9592798948288) + 3221.81082765831);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.125159349647754*x_10 - 23.9429540926231*x_100 - 9.45633415774384*x_101 - 19.8551254974463*x_102 + 39.2655026192423*x_103 - 163.842020575877*x_104 - 16.5813301071226*x_105 - 47.056581914877*x_106 - 10.8903386680075*x_107 + 14.1201593112061*x_108 - 27.9467559550696*x_109 - 1.32376339484717*x_110 - 16.8288025197178*x_111 - 5.22268206169086*x_112 - 32.73175029306*x_113 + 31.9888654741321*x_114 + 25.0162272579891*x_115 - 33.462884266936*x_116 - 13.587922952398*x_117 + 6.59385509951024*x_118 + 3.00571999126273*x_119 + 1.69328602387338*x_12 + 33.2676557472626*x_120 - 67.665723939906*x_13 - 14.4217010384056*x_14 - 82.179155329584*x_18 + 0.444438222672277*x_19 + 14.4596228988367*x_2 - 0.968402492708111*x_20 + 2.03231947764019*x_21 - 0.33993645551398*x_22 + 17.3434413769443*x_24 + 2.37100770398259*x_25 - 5.63877638122061*x_26 - 12.4336687108992*x_27 - 0.397874421285343*x_28 + 69.19077894619*x_29 + 9.03489342587534*x_3 - 0.235862441665858*x_30 + 4.4062084405926*x_31 + 0.447805529142142*x_32 + 66.0647765343508*x_33 - 209.769359780318*x_34 - 218.858508457571*x_35 + 110.064425013134*x_36 - 423.698550780975*x_37 - 27.7114457948712*x_38 - 298.36391393487*x_39 - 7.5743990735533*x_4 + 105.811001356311*x_40 + 0.332116889093125*x_42 - 33.871573613724*x_43 + 11.6789924315458*x_44 - 27.5783647419665*x_45 - 0.226076761383536*x_46 + 234.930508225203*x_47 - 155.952638648538*x_48 - 4.16968275788162*x_5 - 2.08872681134625*x_52 + 19.1093599180657*x_53 + 2.08729949992197*x_54 + 32.3638136934223*x_56 + 87.2517783476492*x_59 - 4.3686343926625*x_6 + 2.15183387435127*x_61 + 2.52730480236436*x_62 - 12.5060254035513*x_63 - 3.12083043702638*x_64 + 8.28100769292497*x_65 - 6.24129142817115*x_66 - 9.72598255777861*x_67 - 8.29739814822548*x_68 - 8.59023252839984*x_69 - 30.9993084439716*x_7 + 11.3207836498231*x_70 - 9.98532844848246*x_71 + 5.1244843800823*x_72 - 7.92963742554021*x_73 + 21.373084013517*x_74 + 15.8880118945816*x_75 + 18.594336227073*x_76 + 14.9446850816715*x_77 + 9.06245509261741*x_78 + 70.6805301826603*x_79 - 32.4129738793944*x_8 - 8.5053826759825*x_80 + 21.4294815588059*x_81 - 17.3738674249009*x_82 + 32.8641080346697*x_83 - 15.5952012705979*x_84 - 38.5136747316985*x_85 - 86.0048421357219*x_86 - 130.658710907474*x_87 - 4.97058271470871*x_88 - 7.16839109003588*x_89 + 16.5335224506136*x_9 - 9.64014812633649*x_90 - 1.81972011785677*x_91 + 18.6343321657558*x_92 - 5.16059649445878*x_93 - 12.9503358056233*x_94 - 14.4161544964304*x_95 - 9.70300547230701*x_96 + 4.33239542392147*x_97 + 20.1676299864641*x_98 - 12.2159388074598*x_99 - 0.0173037525573172*std::pow(-9.63535976409912*x_18 - 5.02335977554321, 2) - 0.100085572491771*std::pow(-7.45879983901978*x_28 - 6.84511995315552, 2) - 0.368550681918044*std::exp(0.779199838638306*x_1) - 0.735007232836214*std::exp(1.14455986022949*x_1) + 0.0687180421841842*std::exp(1.20367991924286*x_1) + 0.78443186464359*std::exp(1.76095998287201*x_1) - 0.281172115188246*std::exp(0.533119857311249*x_10) - 0.900826508764957*std::exp(0.918319821357727*x_10) - 0.137866406347057*std::exp(0.924879848957062*x_11) + 0.798730018417557*std::exp(0.94023984670639*x_11) - 0.0514777591650528*std::exp(0.976159811019897*x_11) + 0.699755410341604*std::exp(0.993999779224396*x_11) - 0.388687550069822*std::exp(0.713359832763672*x_12) - 0.00246727458789865*std::exp(1.27959990501404*x_12) - 0.752632824203233*std::exp(0.310159832239151*x_13) + 0.000111953604639994*std::exp(1.53175985813141*x_13) + 0.170675717940364*std::exp(0.582399845123291*x_15) + 0.249309475473832*std::exp(0.681759834289551*x_15) + 0.202439091948302*std::exp(0.954799830913544*x_15) + 1.42936402594045*std::exp(1.00311982631683*x_15) - 0.362772120075791*std::exp(0.590239822864532*x_16) - 1.80758270868911*std::exp(0.650239825248718*x_16) - 12.5458788909045*std::exp(0.729439854621887*x_16) - 0.129265799465212*std::exp(0.863999843597412*x_16) - 0.482713693593982*std::exp(0.61847984790802*x_17) + 20.1627984982305*std::exp(0.647039830684662*x_17) - 2.88049650840312*std::exp(0.67199981212616*x_17) - 0.0195255099734319*std::exp(1.05343985557556*x_17) + 29.6525686194961*std::exp(0.750399827957153*x_19) - 0.489606089662972*std::exp(0.754719853401184*x_19) + 2.3886111588136*std::exp(0.763839840888977*x_19) + 1.03163365254503*std::exp(0.44191986322403*x_20) - 0.0788453164238146*std::exp(0.842719852924347*x_20) - 0.0505168088555156*std::exp(0.891919851303101*x_20) - 3.0324326451922*std::exp(0.636719882488251*x_22) + 0.00089744208269009*std::exp(1.36591982841492*x_22) + 0.000484797794018367*std::exp(1.53999984264374*x_22) - 27.4856307257122*std::exp(0.544079840183258*x_23) + 0.177238905546266*std::exp(0.579119861125946*x_23) + 0.787812309319219*std::exp(0.848079860210419*x_23) + 0.0190737815226211*std::exp(1.14591991901398*x_23) - 0.683621885746812*std::exp(0.482319831848145*x_24) - 4.82558303679284*std::exp(0.572719871997833*x_24) + 0.291261141910887*std::exp(0.535999834537506*x_25) + 0.100367219602947*std::exp(0.786159873008728*x_25) + 0.645122556220421*std::exp(1.07983982563019*x_25) - 1.24095183972564*std::exp(0.489839851856232*x_26) - 4.27828845862892*std::exp(0.850239872932434*x_26) - 0.0227971257342618*std::exp(0.868559896945953*x_26) - 0.0201899822468834*std::exp(0.954079806804657*x_27) - 0.0925545437630096*std::exp(0.98039984703064*x_27) + 0.529433067348332*std::exp(0.650319814682007*x_28) - 0.0864323121065123*std::exp(1.03335976600647*x_28) - 0.0126863459899402*std::exp(1.16567981243134*x_29) + 1.031011310743*std::exp(0.599999845027924*x_3) - 0.563306475889343*std::exp(0.637119889259338*x_3) - 0.375979436873687*std::exp(0.828319907188416*x_30) + 0.0829579115508677*std::exp(0.892719864845276*x_30) - 4.21818567247049*std::exp(0.882719874382019*x_32) + 3.01814630515219*std::exp(0.415839850902557*x_33) - 0.727794961199571*std::exp(0.467359870672226*x_33) + 1.61052966412011*std::exp(0.612639844417572*x_4) - 0.23954269553665*std::exp(0.691119849681854*x_4) + 0.0138876843841105*std::exp(1.22247993946075*x_4) - 6.55623047219416*std::exp(0.737679839134216*x_41) + 0.158560528998827*std::exp(0.798239827156067*x_41) - 0.0423951372547563*std::exp(0.821119904518127*x_41) + 0.442918176101452*std::exp(0.822159886360168*x_41) - 1.04865988205653*std::exp(0.807039856910706*x_42) - 0.00873943917373467*std::exp(0.848479866981506*x_43) - 0.00347634533801883*std::exp(0.914319813251495*x_44) + 0.171166619959496*std::exp(0.543519854545593*x_45) + 0.275444485255101*std::exp(0.547439873218536*x_45) + 0.661634757251853*std::exp(0.731919825077057*x_46) - 6.12651068500577*std::exp(0.767999827861786*x_46) - 3.88663404952043*std::exp(0.685039818286896*x_49) + 1.57309955257235*std::exp(0.735519826412201*x_49) - 0.389390968787572*std::exp(0.737599849700928*x_49) + 0.100285489597514*std::exp(0.799999833106995*x_49) + 0.177021492559621*std::exp(0.55079984664917*x_50) + 1.44038590160748*std::exp(0.554719865322113*x_50) - 41.2465181577468*std::exp(0.564399838447571*x_50) - 0.625700445517682*std::exp(0.585679829120636*x_50) - 13.313076426648*std::exp(0.487999856472015*x_51) - 8.25150279080933*std::exp(0.494799852371216*x_51) - 5.05884487561193*std::exp(0.502639830112457*x_51) - 83.1970597308792*std::exp(0.503999829292297*x_51) + 0.281882339741947*std::exp(0.507519841194153*x_52) + 2.29148558053292*std::exp(0.658879816532135*x_52) - 0.0707697987007117*std::exp(0.773359835147858*x_52) - 28.9614080656645*std::exp(0.453999847173691*x_54) - 5.90142519192973*std::exp(0.459519863128662*x_54) - 2.48799570935765*std::exp(0.508879840373993*x_54) + 235.865141431497*std::exp(0.652239859104156*x_55) - 16.8987835161089*std::exp(0.653599858283997*x_55) - 0.250580410418398*std::exp(0.711279809474945*x_55) + 4.24314491484176*std::exp(0.469519853591919*x_56) + 1.2650271347771*std::exp(0.561119854450226*x_56) + 6.59572711271996*std::exp(0.610479831695557*x_57) - 105.786251099918*std::exp(0.631999850273132*x_57) - 2.42883083821572*std::exp(0.635999858379364*x_57) - 0.907453370596047*std::exp(0.638479828834534*x_57) - 0.516077095806594*std::exp(0.593759834766388*x_58) - 48.9295752901661*std::exp(0.61847984790802*x_58) - 2.29213021513749*std::exp(0.626239836215973*x_58) + 0.128902271546336*std::exp(0.706959843635559*x_58) + 0.0928752134490153*std::exp(0.800079882144928*x_60) + 5.20796915722522*std::exp(0.807039856910706*x_60) + 0.372204768424408*std::exp(0.808319866657257*x_60) + 1.05776369975516*std::exp(0.832079887390137*x_60) + 0.163570156277006*std::exp(1.13375985622406*x_61) + 1.75064026587974*std::exp(1.2727198600769*x_61) + 0.118460883555781*std::exp(1.33911991119385*x_61) + 0.231533262803121*std::exp(0.915039837360382*x_66) - 1.22615146911907*std::exp(0.965039789676666*x_66) + 0.225424461665993*std::exp(1.11287987232208*x_66) + 6.80077483300618*std::exp(0.34607982635498*x_8) + 0.0321237265033826*std::exp(0.950719833374023*x_8) + 442.218366445728*std::exp(0.00408552233630874*x_1 - 0.00682555704486516*x_100 + 0.00123607685118205*x_101 + 0.00833391573603953*x_102 - 0.00701138092400346*x_103 - 0.0977083960301943*x_104 - 0.00600566168881833*x_105 + 0.00687607377592914*x_106 + 0.000171677094633449*x_107 - 0.00577598435283427*x_108 - 0.00602708603394367*x_109 + 0.00295798337294691*x_110 + 0.00736824483382912*x_111 + 0.00619819336457502*x_112 + 0.00737232327517453*x_113 + 0.00278016937879525*x_114 + 0.00680845583671139*x_115 + 0.00108936112607502*x_116 - 0.00223662178661164*x_117 - 0.00270872883178779*x_118 + 0.00181195514723967*x_119 + 0.00615691065604542*x_120 - 0.0110464416192535*x_14 - 0.024374292179048*x_18 + 0.00156222566492473*x_21 + 0.0110945952915256*x_22 - 0.0158019451973379*x_27 + 0.00134651509165267*x_3 + 0.00193303023436776*x_31 - 0.00210603380787771*x_32 + 0.00844304873011391*x_33 + 0.0454736419084011*x_34 + 0.0397965183702418*x_35 + 0.0485674610300193*x_36 - 0.0219744939027372*x_37 - 0.104656352879291*x_38 + 0.0262697464900929*x_39 - 0.00667487499635561*x_4 - 0.373625746910906*x_40 + 0.00160606419982117*x_42 + 0.0058881584738489*x_43 + 0.0122402509746417*x_45 - 0.0237943297063136*x_46 + 0.0254546535786465*x_48 + 0.00736053038582932*x_5 + 0.00122452058175848*x_6 + 0.000155530557126443*x_61 - 0.00146888436092608*x_62 + 0.0052999410812773*x_63 - 0.00477238519847271*x_64 - 0.00362148390144211*x_65 - 0.000347567839599981*x_66 - 0.00113081023406604*x_67 - 0.00574393300520089*x_68 - 0.000682694751256834*x_69 + 0.0104176913804982*x_7 + 0.0054555976969973*x_70 - 0.00261106604884698*x_71 - 0.00651719260643235*x_72 - 0.00591393184158236*x_73 + 0.00378078030015528*x_74 - 0.00119273370244*x_75 + 0.00196106498452415*x_76 + 0.00289155397174859*x_77 + 0.00224530046296583*x_78 - 0.00731045840435173*x_79 - 0.000627923262287458*x_8 - 0.00340653776788626*x_80 - 0.00486954403971819*x_81 + 0.00198950380281644*x_82 - 0.00198675349758012*x_83 - 0.00249407453456416*x_84 + 0.00377317871663851*x_85 - 0.0320159524060993*x_86 + 0.00719082743066873*x_87 + 0.0169388818716022*x_88 + 0.00073495140395144*x_89 - 0.00297613481191444*x_9 - 0.00333941132916458*x_90 - 0.00203285565615716*x_91 - 0.000500674038545523*x_92 + 0.00927619527285788*x_93 - 0.0016027558697315*x_94 - 0.00265929760300026*x_96 + 0.00509428504367012*x_97 - 0.000161038852985029*x_98 + 0.0108503571977173*x_99 - 2.77965027486982e-5*std::pow(-9.59200000762939*x_16 - 6.19047975540161, 2) + 0.000831907378358441*std::exp(0.675439834594727*x_10) - 0.00118013830488369*std::exp(0.870079874992371*x_11) - 0.0139688632644395*std::exp(0.283759832382202*x_12) + 4.5247272470081e-5*std::exp(1.05879986286163*x_13) + 0.0223336476976086*std::exp(0.278959840536118*x_15) + 0.00608334705635842*std::exp(0.625439822673798*x_17) + 0.0034641487745209*std::exp(0.82999986410141*x_19) - 0.00324619062397325*std::exp(0.768799841403961*x_2) - 0.000336747078390163*std::exp(0.933999836444855*x_20) - 0.0106887313771264*std::exp(0.463439851999283*x_23) + 0.00771304571739496*std::exp(0.533679842948914*x_24) + 0.00556649725621725*std::exp(0.614799857139587*x_25) + 3.11848020835033e-5*std::exp(1.1283198595047*x_26) - 0.00231055280081789*std::exp(0.568239867687225*x_28) + 2.99424660034564e-5*std::exp(1.36007988452911*x_29) - 0.000222453012132499*std::exp(1.10247993469238*x_30) - 0.00313553158808146*std::exp(0.799759864807129*x_41) - 6.86346846800815e-5*std::exp(0.967199802398682*x_44) + 0.00542988674324918*std::exp(0.570559859275818*x_47) + 0.00672343763433313*std::exp(0.712159812450409*x_49) + 0.00899749799438248*std::exp(0.508159816265106*x_50) + 0.0709447637725296*std::exp(0.495199859142303*x_51) - 0.00012715208890639*std::exp(0.705439865589142*x_52) + 0.00189967178209663*std::exp(0.525039851665497*x_53) + 0.0107852768346567*std::exp(0.512559831142426*x_54) - 0.0969756548836935*std::exp(0.651999831199646*x_55) + 0.0127102862331042*std::exp(0.585519850254059*x_56) - 0.00186483759642786*std::exp(0.672319829463959*x_57) + 0.0127594178323448*std::exp(0.59175980091095*x_58) - 0.00117001901663046*std::exp(0.621359825134277*x_59) - 0.00154074483269906*std::exp(0.799279868602753*x_60) + 0.0424280331876941*std::sin(0.270239949226379*x_95 + 1.96583986282349)) + 5.56522898640111*std::log(8.08096027374268 - 1.18407988548279*x_5) - 5.54750739995487*std::log(9.57600021362305 - 1.22015988826752*x_21) + 2.64781213489718*std::sin(0.275039941072464*x_100 + 1.92927980422974) + 10.058387197093*std::sin(0.226159989833832*x_101 + 1.98423981666565) - 8.0801809119707*std::sin(0.225599989295006*x_102 - 7.41752004623413) - 123.98786620411*std::sin(0.223199993371964*x_110 - 1.21599984169006) + 15.8422539118912*std::sin(0.268159955739975*x_120 + 1.97151982784271) + 1.44935275711301*std::sin(0.303919941186905*x_120 + 1.93567979335785) - 763.387013529127*std::sin(0.152400031685829*x_30 + 1.75583982467651) + 13.0481188715656*std::sin(0.390159845352173*x_31 - 7.40823984146118) + 1.06876169600302*std::sin(0.44327986240387*x_31 - 7.37296009063721) - 19.2401452529048*std::sin(0.297759920358658*x_42 - 4.28904008865356) - 4.35451909908048*std::sin(0.238159984350204*x_55 - 4.43512010574341) - 2.41038930220355*std::sin(0.299839943647385*x_91 - 1.14311993122101) + 18.9697367861653*std::sin(0.467279851436615*x_91 + 1.77087986469269) - 10.4468768591332*std::sin(0.308479934930801*x_92 + 8.217360496521) - 5.50657507984106*std::sin(0.334639847278595*x_97 + 1.84383988380432) - 3.33563271094107*std::sin(0.268479973077774*x_98 + 1.9592798948288) + 303.491939183052);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0127977642372839*x_1 - 0.125692047214518*x_10 - 15.5182774284586*x_100 - 6.9375923781182*x_101 - 11.1697229763235*x_102 + 24.5726854765069*x_103 - 102.39470583435*x_104 - 13.1019091641683*x_105 - 17.1878730836859*x_106 - 7.15608109857175*x_107 + 9.53392199215728*x_108 - 17.6458573212405*x_109 + 0.769811711904837*x_110 - 13.6487123846992*x_111 - 6.66939642429557*x_112 - 19.6977418454988*x_113 + 19.9627979442894*x_114 + 13.5771556917115*x_115 - 21.87665567335*x_116 - 11.5735462545351*x_117 + 0.577775895655298*x_118 + 4.95477472412124*x_119 - 1.56843843047666*x_12 + 22.9007073529395*x_120 - 45.6074749325501*x_13 - 9.42680707398301*x_14 - 54.293244492107*x_18 + 0.106907359387908*x_19 + 8.5508432965339*x_2 - 0.625447024874676*x_20 + 0.405848373113495*x_21 + 0.0446436545392502*x_22 + 11.2539397169923*x_24 - 0.553783374166727*x_25 + 1.31701833162282*x_26 - 8.78192661061989*x_27 + 1.22423649583176*x_28 + 46.9200796357865*x_29 + 4.01491289064533*x_3 + 0.0550891077095719*x_30 + 4.06961412306434*x_31 + 1.81616045386756*x_32 + 40.2573712396372*x_33 - 102.259387270043*x_34 - 161.027400861158*x_35 + 76.824050188716*x_36 - 268.9044343631*x_37 + 45.1440185277091*x_38 - 196.692281346567*x_39 - 4.871050252207*x_4 - 118.493720611312*x_40 - 0.133765403355351*x_42 - 22.7217138751339*x_43 + 9.40126169297961*x_44 - 24.7815273204191*x_45 - 1.15500505871025*x_46 + 154.276749748817*x_47 - 103.950100899864*x_48 - 1.74731890619133*x_5 + 0.487852561321045*x_52 + 10.1125550048104*x_53 - 6.42249938380237*x_54 + 23.9998595107086*x_56 + 49.9942834362419*x_59 - 6.31791394919931*x_6 - 0.503079329156009*x_61 + 0.703117504830724*x_62 - 8.93964846231711*x_63 - 1.65307363923144*x_64 + 5.74888394135954*x_65 - 4.02987687590268*x_66 - 7.05882372169341*x_67 - 2.44166850324322*x_68 - 6.52072704010376*x_69 - 21.1012150135078*x_7 + 8.01225807989923*x_70 - 6.40076393379369*x_71 + 3.44343858954322*x_72 - 7.26457937426473*x_73 + 15.5698327391194*x_74 + 9.2832697141677*x_75 + 11.7910092639314*x_76 + 10.7969305141062*x_77 + 5.23092767514444*x_78 + 44.2030572090094*x_79 - 20.446225028517*x_8 - 4.8485303522431*x_80 + 14.5342619217677*x_81 - 9.83254475958306*x_82 + 17.6729822047126*x_83 - 10.5477365394406*x_84 - 24.5231257472592*x_85 - 40.041646672784*x_86 - 91.9379201316282*x_87 + 6.03761698231374*x_88 - 5.11621184160529*x_89 + 11.2377836801321*x_9 - 4.25831455389715*x_90 - 0.457021947966025*x_91 + 10.6337352143328*x_92 - 1.45885995812527*x_93 - 10.8833481709113*x_94 - 9.25356066784926*x_95 - 7.64165787454226*x_96 + 1.93807383971058*x_97 + 9.78805466056005*x_98 - 2.52377527814967*x_99 + 8.7071629895985e-5*std::pow(-9.59200000762939*x_16 - 6.19047975540161, 2) + 0.00404154337450758*std::pow(-9.63535976409912*x_18 - 5.02335977554321, 2) - 0.0646407088160237*std::pow(-7.45879983901978*x_28 - 6.84511995315552, 2) - 0.0886529965122389*std::exp(0.779199838638306*x_1) + 0.171671641873323*std::exp(1.14455986022949*x_1) - 0.211441426398333*std::exp(1.20367991924286*x_1) + 0.506628782611062*std::exp(1.76095998287201*x_1) + 0.865150275083395*std::exp(0.533119857311249*x_10) - 0.00260592247920677*std::exp(0.675439834594727*x_10) - 0.581802777334553*std::exp(0.918319821357727*x_10) + 0.00369674439399469*std::exp(0.870079874992371*x_11) + 0.424206928542898*std::exp(0.924879848957062*x_11) - 0.186555026331022*std::exp(0.94023984670639*x_11) - 0.0123827137694244*std::exp(0.976159811019897*x_11) + 0.451940120800609*std::exp(0.993999779224396*x_11) + 0.0437570043694025*std::exp(0.283759832382202*x_12) + 0.0907836371061598*std::exp(0.713359832763672*x_12) - 0.000593490383187935*std::exp(1.27959990501404*x_12) + 2.31580750623253*std::exp(0.310159832239151*x_13) - 0.000141735591629497*std::exp(1.05879986286163*x_13) + 2.69298715444761e-5*std::exp(1.53175985813141*x_13) - 0.0699594162666584*std::exp(0.278959840536118*x_15) - 0.525159275582157*std::exp(0.582399845123291*x_15) + 0.0599701293309903*std::exp(0.681759834289551*x_15) - 0.04728259769636*std::exp(0.954799830913544*x_15) + 0.923161066001929*std::exp(1.00311982631683*x_15) + 1.11622875286204*std::exp(0.590239822864532*x_16) + 0.422187262328118*std::exp(0.650239825248718*x_16) - 8.10281126477784*std::exp(0.729439854621887*x_16) - 0.0310942321677472*std::exp(0.863999843597412*x_16) + 1.48528201141054*std::exp(0.61847984790802*x_17) - 0.0190558844113897*std::exp(0.625439822673798*x_17) + 13.0222324176388*std::exp(0.647039830684662*x_17) + 0.672781903247107*std::exp(0.67199981212616*x_17) - 0.00469676235183109*std::exp(1.05343985557556*x_17) + 19.1512423425226*std::exp(0.750399827957153*x_19) + 1.50648951397913*std::exp(0.754719853401184*x_19) - 0.557894917371303*std::exp(0.763839840888977*x_19) - 0.0108513320084427*std::exp(0.82999986410141*x_19) + 0.0101685852762774*std::exp(0.768799841403961*x_2) - 0.240953061455986*std::exp(0.44191986322403*x_20) - 0.0189658408052577*std::exp(0.842719852924347*x_20) + 0.155437288112387*std::exp(0.891919851303101*x_20) + 0.00105484913851314*std::exp(0.933999836444855*x_20) - 1.95851001040326*std::exp(0.636719882488251*x_22) - 0.00276137718774469*std::exp(1.36591982841492*x_22) + 0.000116615649491075*std::exp(1.53999984264374*x_22) + 0.0334820992029416*std::exp(0.463439851999283*x_23) - 17.751715937995*std::exp(0.544079840183258*x_23) - 0.545353822821907*std::exp(0.579119861125946*x_23) - 0.184005036395311*std::exp(0.848079860210419*x_23) + 0.00458810136505503*std::exp(1.14591991901398*x_23) + 2.10346485500852*std::exp(0.482319831848145*x_24) - 0.024160861823068*std::exp(0.533679842948914*x_24) + 1.1270851848976*std::exp(0.572719871997833*x_24) - 0.896193624593968*std::exp(0.535999834537506*x_25) - 0.0174368694253475*std::exp(0.614799857139587*x_25) + 0.0241428254130373*std::exp(0.786159873008728*x_25) + 0.416655250792735*std::exp(1.07983982563019*x_25) - 0.298504668466515*std::exp(0.489839851856232*x_26) - 2.76315148727282*std::exp(0.850239872932434*x_26) + 0.0701454324049975*std::exp(0.868559896945953*x_26) - 9.7685366031218e-5*std::exp(1.1283198595047*x_26) + 0.0621234032511566*std::exp(0.954079806804657*x_27) + 0.0216174614082645*std::exp(0.98039984703064*x_27) + 0.00723773059319014*std::exp(0.568239867687225*x_28) + 0.127352438011587*std::exp(0.650319814682007*x_28) + 0.0201875250573743*std::exp(1.03335976600647*x_28) - 0.00305163615746429*std::exp(1.16567981243134*x_29) - 9.37937891538593e-5*std::exp(1.36007988452911*x_29) + 0.248004539456269*std::exp(0.599999845027924*x_3) + 1.733261323747*std::exp(0.637119889259338*x_3) - 0.0904399458233768*std::exp(0.828319907188416*x_30) - 0.25525667774888*std::exp(0.892719864845276*x_30) + 0.000696826738124642*std::exp(1.10247993469238*x_30) - 2.72433383751197*std::exp(0.882719874382019*x_32) + 0.725999779654684*std::exp(0.415839850902557*x_33) + 2.23938284372389*std::exp(0.467359870672226*x_33) - 0.376162654424927*std::exp(0.612639844417572*x_4) + 0.737058967597131*std::exp(0.691119849681854*x_4) + 0.00334061201260078*std::exp(1.22247993946075*x_4) - 4.23437039258272*std::exp(0.737679839134216*x_41) - 0.487881542552191*std::exp(0.798239827156067*x_41) + 0.00982194948885738*std::exp(0.799759864807129*x_41) - 0.0101979351540519*std::exp(0.821119904518127*x_41) - 0.103449989483052*std::exp(0.822159886360168*x_41) - 0.677281614077152*std::exp(0.807039856910706*x_42) + 0.0268907469724338*std::exp(0.848479866981506*x_43) + 0.0106965127870461*std::exp(0.914319813251495*x_44) + 0.000214995890544956*std::exp(0.967199802398682*x_44) - 0.526669752595876*std::exp(0.543519854545593*x_45) + 0.0662567733250485*std::exp(0.547439873218536*x_45) - 0.154534431803603*std::exp(0.731919825077057*x_46) - 3.95683397105291*std::exp(0.767999827861786*x_46) - 0.0170089414902186*std::exp(0.570559859275818*x_47) - 2.51019975821341*std::exp(0.685039818286896*x_49) - 0.0210609470773372*std::exp(0.712159812450409*x_49) - 0.367420306842698*std::exp(0.735519826412201*x_49) - 0.0936660217752586*std::exp(0.737599849700928*x_49) - 0.308572629451801*std::exp(0.799999833106995*x_49) - 0.0281843663010243*std::exp(0.508159816265106*x_50) - 0.544684855683838*std::exp(0.55079984664917*x_50) - 0.336423101179528*std::exp(0.554719865322113*x_50) - 26.6392458326496*std::exp(0.564399838447571*x_50) - 0.150509067370334*std::exp(0.585679829120636*x_50) + 3.10946285484647*std::exp(0.487999856472015*x_51) + 25.3893950491521*std::exp(0.494799852371216*x_51) - 0.222232137262271*std::exp(0.495199859142303*x_51) - 1.21687946629092*std::exp(0.502639830112457*x_51) - 53.7331882959983*std::exp(0.503999829292297*x_51) - 0.86733559480329*std::exp(0.507519841194153*x_52) + 1.4799660778233*std::exp(0.658879816532135*x_52) + 0.000398299733094196*std::exp(0.705439865589142*x_52) - 0.0170233159920762*std::exp(0.773359835147858*x_52) - 0.00595065932682163*std::exp(0.525039851665497*x_53) - 18.7048532477405*std::exp(0.453999847173691*x_54) + 1.3783637858662*std::exp(0.459519863128662*x_54) - 0.598474743816098*std::exp(0.508879840373993*x_54) - 0.0337845246707142*std::exp(0.512559831142426*x_54) + 0.303773046821481*std::exp(0.651999831199646*x_55) + 152.334542807129*std::exp(0.652239859104156*x_55) + 3.94695695806672*std::exp(0.653599858283997*x_55) - 0.060275846283192*std::exp(0.711279809474945*x_55) - 0.991048280472695*std::exp(0.469519853591919*x_56) + 0.304295858533293*std::exp(0.561119854450226*x_56) - 0.0398145532467286*std::exp(0.585519850254059*x_56) - 1.54052810938983*std::exp(0.610479831695557*x_57) - 68.3225172604253*std::exp(0.631999850273132*x_57) - 0.584242934264979*std::exp(0.635999858379364*x_57) + 2.79218133942943*std::exp(0.638479828834534*x_57) + 0.00584154238683458*std::exp(0.672319829463959*x_57) - 0.0399684563641082*std::exp(0.59175980091095*x_58) + 1.58793926311786*std::exp(0.593759834766388*x_58) - 31.6013821980526*std::exp(0.61847984790802*x_58) + 0.535360388089935*std::exp(0.626239836215973*x_58) + 0.0310067873713992*std::exp(0.706959843635559*x_58) + 0.00366504605663326*std::exp(0.621359825134277*x_59) + 0.00482633247246208*std::exp(0.799279868602753*x_60) - 0.285771639943915*std::exp(0.800079882144928*x_60) + 3.36358987048516*std::exp(0.807039856910706*x_60) + 0.0895319684805397*std::exp(0.808319866657257*x_60) - 0.247056114468784*std::exp(0.832079887390137*x_60) - 0.503295874854953*std::exp(1.13375985622406*x_61) + 1.13065874382287*std::exp(1.2727198600769*x_61) + 0.0284951644697887*std::exp(1.33911991119385*x_61) + 0.0556941515694084*std::exp(0.915039837360382*x_66) + 0.286385529944795*std::exp(0.965039789676666*x_66) - 0.69361798160635*std::exp(1.11287987232208*x_66) - 1.58841999021948*std::exp(0.34607982635498*x_8) + 0.00772719941486307*std::exp(0.950719833374023*x_8) + 1.33868759475241*std::log(8.08096027374268 - 1.18407988548279*x_5) - 1.33442475705196*std::log(9.57600021362305 - 1.22015988826752*x_21) - 8.14716422125206*std::sin(0.275039941072464*x_100 + 1.92927980422974) - 2.34928279285021*std::sin(0.226159989833832*x_101 + 1.98423981666565) - 1.94364651960267*std::sin(0.225599989295006*x_102 - 7.41752004623413) - 80.0781107254892*std::sin(0.223199993371964*x_110 - 1.21599984169006) - 3.70018908458071*std::sin(0.268159955739975*x_120 + 1.97151982784271) + 0.348634451719496*std::sin(0.303919941186905*x_120 + 1.93567979335785) - 493.036872617456*std::sin(0.152400031685829*x_30 + 1.75583982467651) - 3.04757815973642*std::sin(0.390159845352173*x_31 - 7.40823984146118) + 0.257085203085419*std::sin(0.44327986240387*x_31 - 7.37296009063721) + 4.49381608491383*std::sin(0.297759920358658*x_42 - 4.28904008865356) + 13.3986024677559*std::sin(0.238159984350204*x_55 - 4.43512010574341) - 0.579806916349455*std::sin(0.299839943647385*x_91 - 1.14311993122101) + 12.2516882441967*std::sin(0.467279851436615*x_91 + 1.77087986469269) + 2.44002021032554*std::sin(0.308479934930801*x_92 + 8.217360496521) - 0.132904417376984*std::sin(0.270239949226379*x_95 + 1.96583986282349) - 1.32457869513884*std::sin(0.334639847278595*x_97 + 1.84383988380432) + 10.2635482025512*std::sin(0.268479973077774*x_98 + 1.9592798948288) + 683.900466088124);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0372726590426498*x_1 + 0.420812596915978*x_10 - 91.52530419174*x_100 - 35.7202123472713*x_101 - 70.141104089116*x_102 + 140.229847197702*x_103 - 550.720928283751*x_104 - 77.7701915782693*x_105 - 128.697689052247*x_106 - 39.7102826058634*x_107 + 54.3887545999262*x_108 - 93.6533829244614*x_109 + 2.73121225930763*x_110 - 82.8734648142539*x_111 - 29.1672606093176*x_112 - 120.373066081053*x_113 + 122.317929320541*x_114 + 75.0067414371661*x_115 - 122.558563092182*x_116 - 67.306087335339*x_117 + 7.22349969218705*x_118 + 25.8390047414764*x_119 + 4.01695242874998*x_12 + 126.226677356254*x_120 - 262.633238363676*x_13 - 52.3814771843424*x_14 - 294.820764134397*x_18 - 1.06341679655951*x_19 + 51.8736698586948*x_2 - 3.63604778153167*x_20 + 5.25070961664487*x_21 + 0.169486329185979*x_22 + 65.9170032946715*x_24 - 0.476167429833865*x_25 + 1.13243059157662*x_26 - 58.9789160556121*x_27 - 0.191435783932315*x_28 + 269.326664842178*x_29 + 25.7669106408956*x_3 + 0.047368050493351*x_30 + 17.6430460472168*x_31 - 6.43894096496101*x_32 + 237.404782604831*x_33 - 764.554849332072*x_34 - 902.41326622316*x_35 + 427.103227261067*x_36 - 1656.36858461075*x_37 + 239.386032541364*x_38 - 1170.60607362931*x_39 - 28.5003896704998*x_4 - 1256.54184552537*x_40 - 0.599284809269456*x_42 - 125.248939555829*x_43 + 49.5477938836321*x_44 - 134.613802204989*x_45 + 1.34187490026239*x_46 + 939.666583817185*x_47 - 597.558543606842*x_48 - 9.5952175967488*x_5 + 0.419477201914286*x_52 + 70.5244172632439*x_53 + 1.0042963173612*x_54 + 124.239719544605*x_56 + 315.153955561694*x_59 - 32.3127026025475*x_6 - 0.430732016908838*x_61 + 7.05204879094194*x_62 - 46.8164245086883*x_63 - 13.5287067352766*x_64 + 24.7139081808476*x_65 - 23.4372636671514*x_66 - 37.8724246717255*x_67 - 22.3635824912709*x_68 - 33.9089313620337*x_69 - 118.976181618765*x_7 + 43.1164395821407*x_70 - 41.4102263626677*x_71 + 17.732292641114*x_72 - 43.0841283531328*x_73 + 85.8389666378873*x_74 + 60.849665179893*x_75 + 64.4317635451031*x_76 + 59.6090557706994*x_77 + 28.9512208038218*x_78 + 269.847910749403*x_79 - 121.279047689181*x_8 - 28.9835865178443*x_80 + 80.1259714061503*x_81 - 55.8055413542874*x_82 + 121.005094592617*x_83 - 50.6410844977853*x_84 - 150.122104562881*x_85 - 362.054016103131*x_86 - 535.045559804517*x_87 + 25.6537760794574*x_88 - 29.9475194764009*x_89 + 68.0443904409259*x_9 - 27.8462188194925*x_90 + 0.559989748239855*x_91 + 69.1016027019379*x_92 - 20.7088515611881*x_93 - 59.1512453918994*x_94 - 58.3146820273416*x_95 - 41.645659797612*x_96 + 17.169436266493*x_97 + 62.0325445945857*x_98 - 41.1325719887773*x_99 - 0.000253590479807871*std::pow(-9.59200000762939*x_16 - 6.19047975540161, 2) + 0.00347509768435549*std::pow(-9.63535976409912*x_18 - 5.02335977554321, 2) - 0.375789949491299*std::pow(-7.45879983901978*x_28 - 6.84511995315552, 2) + 0.881839062307895*std::exp(0.779199838638306*x_1) + 0.147610867894292*std::exp(1.14455986022949*x_1) + 0.033063427986462*std::exp(1.20367991924286*x_1) + 2.94529574497882*std::exp(1.76095998287201*x_1) - 0.135284907527057*std::exp(0.533119857311249*x_10) + 0.00758958035623761*std::exp(0.675439834594727*x_10) - 3.38232114580792*std::exp(0.918319821357727*x_10) - 0.0107665284975146*std::exp(0.870079874992371*x_11) - 0.0663339037772727*std::exp(0.924879848957062*x_11) - 0.160408259898188*std::exp(0.94023984670639*x_11) + 0.123171930209361*std::exp(0.976159811019897*x_11) + 2.62736220377974*std::exp(0.993999779224396*x_11) - 0.12743943976066*std::exp(0.283759832382202*x_12) + 0.0780597850501662*std::exp(0.713359832763672*x_12) + 0.00590350042964368*std::exp(1.27959990501404*x_12) - 0.362126457511597*std::exp(0.310159832239151*x_13) + 0.000412795726117835*std::exp(1.05879986286163*x_13) - 0.000267873773083061*std::exp(1.53175985813141*x_13) + 0.203752266488335*std::exp(0.278959840536118*x_15) + 0.0821199808637407*std::exp(0.582399845123291*x_15) - 0.596528089249896*std::exp(0.681759834289551*x_15) - 0.0406556680305212*std::exp(0.954799830913544*x_15) + 5.36681383480131*std::exp(1.00311982631683*x_15) - 0.174546443501306*std::exp(0.590239822864532*x_16) + 0.363015274544612*std::exp(0.650239825248718*x_16) - 47.1058423043403*std::exp(0.729439854621887*x_16) + 0.30929703018222*std::exp(0.863999843597412*x_16) - 0.232255881263989*std::exp(0.61847984790802*x_17) + 0.0554990285219236*std::exp(0.625439822673798*x_17) + 75.7049876482075*std::exp(0.647039830684662*x_17) + 0.57848762648382*std::exp(0.67199981212616*x_17) + 0.046719103371198*std::exp(1.05343985557556*x_17) + 111.336099563441*std::exp(0.750399827957153*x_19) - 0.235572131754224*std::exp(0.754719853401184*x_19) - 0.479702716467055*std::exp(0.763839840888977*x_19) + 0.0316038013054626*std::exp(0.82999986410141*x_19) - 0.0296153456901963*std::exp(0.768799841403961*x_2) - 0.207182095628525*std::exp(0.44191986322403*x_20) + 0.188654867061153*std::exp(0.842719852924347*x_20) - 0.0243059729091732*std::exp(0.891919851303101*x_20) - 0.00307217976142194*std::exp(0.933999836444855*x_20) - 11.3858339638937*std::exp(0.636719882488251*x_22) + 0.00043180088852813*std::exp(1.36591982841492*x_22) - 0.00115998600209119*std::exp(1.53999984264374*x_22) - 0.0975144442798606*std::exp(0.463439851999283*x_23) - 103.199927072418*std::exp(0.544079840183258*x_23) + 0.0852778339380139*std::exp(0.579119861125946*x_23) - 0.158215665807373*std::exp(0.848079860210419*x_23) - 0.0456382430905777*std::exp(1.14591991901398*x_23) - 0.328922103583464*std::exp(0.482319831848145*x_24) + 0.0703669444295769*std::exp(0.533679842948914*x_24) + 0.969117674404832*std::exp(0.572719871997833*x_24) + 0.140139204854147*std::exp(0.535999834537506*x_25) + 0.0507837522876664*std::exp(0.614799857139587*x_25) - 0.240150782954718*std::exp(0.786159873008728*x_25) + 2.42223296307471*std::exp(1.07983982563019*x_25) + 2.9692518842124*std::exp(0.489839851856232*x_26) - 16.0636319876131*std::exp(0.850239872932434*x_26) - 0.0109687514523888*std::exp(0.868559896945953*x_26) + 0.000284502298528884*std::exp(1.1283198595047*x_26) - 0.00971433415228202*std::exp(0.954079806804657*x_27) + 0.0185876491033966*std::exp(0.98039984703064*x_27) - 0.0210794213458479*std::exp(0.568239867687225*x_28) - 1.26678577078055*std::exp(0.650319814682007*x_28) + 0.0173581266063481*std::exp(1.03335976600647*x_28) + 0.0303548901162259*std::exp(1.16567981243134*x_29) + 0.000273168333048767*std::exp(1.36007988452911*x_29) - 2.46692271131552*std::exp(0.599999845027924*x_3) - 0.271032795869751*std::exp(0.637119889259338*x_3) + 0.899614002433106*std::exp(0.828319907188416*x_30) + 0.0399148876668765*std::exp(0.892719864845276*x_30) - 0.00202946272023478*std::exp(1.10247993469238*x_30) - 15.8379648668438*std::exp(0.882719874382019*x_32) - 7.22158291443697*std::exp(0.415839850902557*x_33) - 0.350175812984238*std::exp(0.467359870672226*x_33) - 0.323441281758444*std::exp(0.612639844417572*x_4) - 0.115255068564539*std::exp(0.691119849681854*x_4) - 0.0332293580659698*std::exp(1.22247993946075*x_4) - 24.616590150411*std::exp(0.737679839134216*x_41) + 0.0762908031925077*std::exp(0.798239827156067*x_41) - 0.0286057914214245*std::exp(0.799759864807129*x_41) + 0.101439747414339*std::exp(0.821119904518127*x_41) - 0.0889508748481403*std::exp(0.822159886360168*x_41) - 3.93738911913582*std::exp(0.807039856910706*x_42) - 0.00420494834512829*std::exp(0.848479866981506*x_43) - 0.0016726305070157*std::exp(0.914319813251495*x_44) - 0.000626161599422751*std::exp(0.967199802398682*x_44) + 0.082356176527093*std::exp(0.543519854545593*x_45) - 0.659061883513901*std::exp(0.547439873218536*x_45) - 0.132875536979564*std::exp(0.731919825077057*x_46) - 23.0031270597521*std::exp(0.767999827861786*x_46) + 0.0495374399064444*std::exp(0.570559859275818*x_47) - 14.5930924587611*std::exp(0.685039818286896*x_49) + 0.0613386436079151*std::exp(0.712159812450409*x_49) - 0.315924224777078*std::exp(0.735519826412201*x_49) + 0.931704060347265*std::exp(0.737599849700928*x_49) + 0.0482519867854678*std::exp(0.799999833106995*x_49) + 0.0820851404974917*std::exp(0.508159816265106*x_50) + 0.085173226495794*std::exp(0.55079984664917*x_50) - 0.289271456851583*std::exp(0.554719865322113*x_50) - 154.867745563089*std::exp(0.564399838447571*x_50) + 1.49712677585994*std::exp(0.585679829120636*x_50) + 2.67365364296825*std::exp(0.487999856472015*x_51) - 3.97017958650175*std::exp(0.494799852371216*x_51) + 0.647236699076267*std::exp(0.495199859142303*x_51) + 12.1044058262325*std::exp(0.502639830112457*x_51) - 312.378878350947*std::exp(0.503999829292297*x_51) + 0.135626629404444*std::exp(0.507519841194153*x_52) + 8.6038100110714*std::exp(0.658879816532135*x_52) - 0.00116002216271091*std::exp(0.705439865589142*x_52) + 0.169332403893997*std::exp(0.773359835147858*x_52) + 0.0173309096851012*std::exp(0.525039851665497*x_53) - 108.741008351507*std::exp(0.453999847173691*x_54) + 1.18517812543499*std::exp(0.459519863128662*x_54) + 5.9530802980685*std::exp(0.508879840373993*x_54) + 0.0983952388574997*std::exp(0.512559831142426*x_54) - 0.884719314295394*std::exp(0.651999831199646*x_55) + 885.599666151568*std::exp(0.652239859104156*x_55) + 3.39376810149899*std::exp(0.653599858283997*x_55) + 0.599569082347337*std::exp(0.711279809474945*x_55) - 0.852147129306701*std::exp(0.469519853591919*x_56) - 3.02685735519532*std::exp(0.561119854450226*x_56) + 0.115957306337727*std::exp(0.585519850254059*x_56) - 1.32461418065998*std::exp(0.610479831695557*x_57) - 397.194210593946*std::exp(0.631999850273132*x_57) + 5.81151525138933*std::exp(0.635999858379364*x_57) - 0.436617782115453*std::exp(0.638479828834534*x_57) - 0.017013113668195*std::exp(0.672319829463959*x_57) + 0.116405539194133*std::exp(0.59175980091095*x_58) - 0.248308556971534*std::exp(0.593759834766388*x_58) - 183.715216580633*std::exp(0.61847984790802*x_58) + 0.460326531859543*std::exp(0.626239836215973*x_58) - 0.308427209191966*std::exp(0.706959843635559*x_58) - 0.01067420914401*std::exp(0.621359825134277*x_59) - 0.0140563805784506*std::exp(0.799279868602753*x_60) + 0.0446865602394237*std::exp(0.800079882144928*x_60) + 19.5542915709138*std::exp(0.807039856910706*x_60) - 0.890582272879624*std::exp(0.808319866657257*x_60) - 0.212429770446529*std::exp(0.832079887390137*x_60) + 0.0787011665481333*std::exp(1.13375985622406*x_61) + 6.57310540084561*std::exp(1.2727198600769*x_61) - 0.283443877871389*std::exp(1.33911991119385*x_61) - 0.553994566773844*std::exp(0.915039837360382*x_66) + 0.246246940765626*std::exp(0.965039789676666*x_66) + 0.108462133346341*std::exp(1.11287987232208*x_66) - 1.36579373726707*std::exp(0.34607982635498*x_8) - 0.0768631242524131*std::exp(0.950719833374023*x_8) - 13.3160418679893*std::log(8.08096027374268 - 1.18407988548279*x_5) + 13.2736390508434*std::log(9.57600021362305 - 1.22015988826752*x_21) + 1.27398486716494*std::sin(0.275039941072464*x_100 + 1.92927980422974) - 2.02001721540961*std::sin(0.226159989833832*x_101 + 1.98423981666565) + 19.3336208784302*std::sin(0.225599989295006*x_102 - 7.41752004623413) - 465.535569396953*std::sin(0.223199993371964*x_110 - 1.21599984169006) - 3.18158617339362*std::sin(0.268159955739975*x_120 + 1.97151982784271) - 3.46789719567013*std::sin(0.303919941186905*x_120 + 1.93567979335785) - 2866.27892626595*std::sin(0.152400031685829*x_30 + 1.75583982467651) - 2.62044244597097*std::sin(0.390159845352173*x_31 - 7.40823984146118) - 2.55724886175486*std::sin(0.44327986240387*x_31 - 7.37296009063721) + 3.86398175734195*std::sin(0.297759920358658*x_42 - 4.28904008865356) - 2.09516051493762*std::sin(0.238159984350204*x_55 - 4.43512010574341) + 5.76738979559082*std::sin(0.299839943647385*x_91 - 1.14311993122101) + 71.2254149250376*std::sin(0.467279851436615*x_91 + 1.77087986469269) + 2.09803725877765*std::sin(0.308479934930801*x_92 + 8.217360496521) + 0.387075503369771*std::sin(0.270239949226379*x_95 + 1.96583986282349) + 13.1756994171425*std::sin(0.334639847278595*x_97 + 1.84383988380432) - 1.60492715482034*std::sin(0.268479973077774*x_98 + 1.9592798948288) + 3305.92186979941);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
