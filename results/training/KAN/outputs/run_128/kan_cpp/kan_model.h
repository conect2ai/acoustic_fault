
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (9.93341225686408e-5*x_1 + 0.000146865466829946*x_10 + 0.00221411799809777*x_100 - 0.00187729318159317*x_101 - 7.44796324896382e-5*x_102 + 0.000217829607613439*x_103 - 0.000181397914562711*x_104 + 2.76294987600135e-5*x_105 - 0.000240552709091631*x_106 - 7.51433474881788e-5*x_107 - 0.00115459644794387*x_108 + 0.000149323242373116*x_109 + 0.000225329594941362*x_11 + 5.21664694734971e-5*x_110 - 8.80857705921441e-5*x_111 - 0.000153353870067*x_112 + 6.09080810175168e-5*x_113 + 0.0017401900438317*x_114 - 0.000728369562926613*x_115 - 0.000413407432009244*x_116 + 2.54946858946607e-7*x_117 + 0.0012563864465425*x_118 - 0.00101304404776466*x_119 - 0.000136170055875603*x_12 + 0.000550870140573898*x_120 + 0.000374219933609388*x_13 - 0.000395241739596282*x_14 - 0.000412406016337287*x_15 - 3.16605536142773e-5*x_16 - 0.000190167592205941*x_17 - 9.96489018936369e-7*x_18 - 2.03190457103449e-6*x_19 + 9.18230412699221e-5*x_2 + 3.91274930896506e-5*x_20 - 0.000235038988892301*x_21 - 9.80759777712666e-5*x_22 + 7.43367503468416e-6*x_23 - 0.000527067633287403*x_24 + 1.33556898372667e-5*x_25 - 7.00152977833462e-6*x_26 - 2.56872037001936e-5*x_27 - 7.59915089758847e-5*x_28 - 0.000212275019621274*x_29 - 4.6592856995507e-6*x_3 - 0.000101174439113859*x_30 - 1.95982667628774e-5*x_31 - 0.000200991139314776*x_32 - 1.05006210653692e-5*x_33 + 0.000170993432009786*x_34 + 9.59203811511865e-5*x_35 - 0.000468393990199067*x_36 - 0.000242347697825342*x_37 + 0.00013543885536443*x_38 - 0.00114071340400244*x_39 + 0.000447742107456328*x_4 - 0.00037611114745984*x_40 - 0.00147714989045926*x_41 - 0.00224687585824133*x_42 - 0.000387823250767177*x_43 + 9.25099701745868e-5*x_44 + 9.34982150601362e-5*x_45 - 0.00103492089041067*x_46 + 0.000831227345004591*x_47 + 0.000882654717494972*x_48 + 0.000152212033191792*x_49 + 4.97447704130343e-6*x_5 - 0.00196240825183191*x_50 + 0.000660895255512226*x_51 - 4.37712780881902e-5*x_52 + 0.000472064333683016*x_53 - 0.00239149973829033*x_54 + 0.00251885889056358*x_55 + 0.00163789696112334*x_56 - 0.00169474973056995*x_57 - 0.00091093821679252*x_58 + 0.000170304994064492*x_59 - 2.40422015582823e-5*x_6 + 3.90746818860946e-5*x_60 - 3.53106305326078e-5*x_61 - 4.71518632294722e-5*x_62 + 1.08618735135967e-5*x_63 - 2.7779382336472e-6*x_64 + 1.30585220466873e-6*x_65 - 1.06606930504602e-5*x_66 - 1.49996673378839e-5*x_67 + 4.77615318210022e-6*x_68 + 2.19723922702662e-5*x_69 - 1.61007099153842e-5*x_7 - 1.27578352878704e-5*x_70 - 2.42361967737772e-5*x_71 - 1.75343567699221e-5*x_72 + 3.58298701476577e-5*x_73 + 2.99754864655614e-5*x_74 - 5.11996480138891e-6*x_75 + 1.32165257657864e-5*x_76 - 7.41026515856408e-5*x_77 + 0.000138434834645732*x_78 - 5.58545742071581e-6*x_79 + 2.59342550183886e-5*x_8 + 3.80707160482675e-7*x_80 - 4.91893115952091e-6*x_81 + 3.90361779775665e-5*x_82 + 1.94153193055427e-5*x_83 + 6.63722345541748e-6*x_84 + 5.4530001284047e-7*x_85 + 1.68040793844543e-5*x_86 + 5.16383070703513e-7*x_87 + 2.91726475681714e-5*x_88 - 1.31213030631982e-5*x_89 - 0.000624481601270036*x_9 - 4.457123023202e-5*x_90 + 7.02066581830819e-7*x_91 + 7.0629120196385e-5*x_92 + 0.000524076785469021*x_93 - 6.31199581240226e-5*x_94 - 8.07443791273791e-5*x_95 + 0.000404621152851551*x_96 - 0.000277996961991597*x_97 - 0.000613523127847241*x_98 - 0.000104960334547336*x_99 + 8.80326339127624e-8*std::pow(5.50623989105225 - 9.58327960968018*x_6, 2) - 1.64822417882512e-7*std::pow(-7.36751985549927*x_11 - 5.58879995346069, 2) + 2.26960153895946e-7*std::pow(-5.96751976013184*x_12 - 7.36407995223999, 2) + 3.3193900918696e-8*std::pow(-6.45391988754272*x_17 - 1.20223987102509, 2) - 2.7977168746412e-6*std::pow(-7.15599966049194*x_19 - 8.56088066101074, 2) + 2.12113509355125e-7*std::pow(-5.99191999435425*x_26 - 0.821199893951416, 2) + 1.93527622498553e-5*std::pow(-3.90079998970032*x_27 - 7.59823989868164, 2) - 1.34227368950594e-7*std::pow(-8.39199924468994*x_30 - 6.94776010513306, 2) + 3.93196263142911e-8*std::pow(-6.28359985351563*x_32 - 4.66207981109619, 2) - 1.67208886495301e-5*std::pow(-3.47567987442017*x_43 - 8.39967918395996, 2) - 1.45874290720173e-6*std::pow(-2.60359978675842*x_52 - 6.60096025466919, 2) - 1.28420429075757e-6*std::pow(-2.68167996406555*x_58 - 5.57872009277344, 2) + 0.000256375360161894*std::exp(0.198239862918854*x_13) + 0.000264379617358026*std::exp(0.311599850654602*x_18) - 7.39327892064458e-5*std::exp(0.619279801845551*x_18) - 6.36116294046096e-5*std::exp(0.370399862527847*x_19) + 8.74352019816599e-5*std::exp(0.318559855222702*x_26) + 0.000122874491642723*std::exp(0.265839844942093*x_27) - 3.59369891439221e-5*std::exp(0.417679876089096*x_27) - 1.89217614333049e-5*std::exp(0.427119851112366*x_30) - 0.000360109612960462*std::exp(0.188799858093262*x_43) - 0.000584837808587499*std::exp(0.285439848899841*x_49) - 0.000558540852897312*std::exp(0.19327986240387*x_56) - 0.000345889712229446*std::exp(0.225839853286743*x_60) + 1.81652130640554e-5*std::exp(0.243999853730202*x_8) + 0.00133504563503251*std::sin(0.143360033631325*x_1 + 4.91999959945679) - 1.29854332607018e-5*std::sin(0.596159815788269*x_10 + 4.99143981933594) + 0.000613979372537595*std::sin(0.249439969658852*x_100 - 7.61488008499146) - 0.000615321512221422*std::sin(0.276079952716827*x_100 + 1.78791987895966) + 0.000118906335515843*std::sin(0.227279990911484*x_102 - 1.39095985889435) - 0.0127972384031779*std::sin(0.237599983811378*x_102 + 8.17735958099365) - 0.000696533381472584*std::sin(0.254479974508286*x_102 + 1.77367985248566) + 0.00032468376556094*std::sin(0.291839927434921*x_102 + 1.5759197473526) + 0.000548204809611977*std::sin(0.256239980459213*x_103 + 1.96455979347229) + 0.0115105140166979*std::sin(0.215120002627373*x_104 - 4.39056015014648) - 0.00113046484202648*std::sin(0.31183984875679*x_105 + 4.43111991882324) - 2.91534699190274e-5*std::sin(1.16343986988068*x_106 - 5.78295993804932) + 0.00743742763100511*std::sin(0.259199976921082*x_107 - 7.43327951431274) - 0.000637681787218329*std::sin(0.278879970312119*x_107 + 1.76543986797333) - 0.0126259893505191*std::sin(0.238079980015755*x_109 - 1.21103978157043) + 0.000476000802949638*std::sin(0.239439979195595*x_109 + 8.19032001495361) - 0.00092105473263722*std::sin(0.25927996635437*x_109 - 4.41807985305786) + 0.000780593186250603*std::sin(0.277599930763245*x_109 + 4.95183992385864) - 0.000458680435825317*std::sin(0.287199944257736*x_112 + 4.56680011749268) - 0.000461448269368344*std::sin(0.286159932613373*x_113 - 1.19527995586395) - 9.70460838079755e-5*std::sin(0.295519918203354*x_114 + 7.73567962646484) - 0.000822479615372582*std::sin(0.253679990768433*x_116 + 5.15799999237061) - 0.000583698165593767*std::sin(0.247519969940186*x_117 - 7.43887996673584) + 0.00938762531819648*std::sin(0.26063996553421*x_117 - 1.22167980670929) - 0.000633029536966291*std::sin(0.29615992307663*x_117 + 4.76168012619019) - 0.000267173405592068*std::sin(0.23039998114109*x_118 - 4.41991996765137) + 0.000424093317838723*std::sin(0.284399926662445*x_118 + 1.75903987884521) - 0.000584816364122942*std::sin(0.22087998688221*x_119 - 4.40064001083374) + 0.000109835544031896*std::sin(0.309679925441742*x_119 + 7.73167991638184) - 0.000894571737878008*std::sin(0.23879998922348*x_12 + 5.00543975830078) + 0.00101734038691776*std::sin(0.266959965229034*x_120 - 1.2157598733902) + 0.000298720605501237*std::sin(0.308479934930801*x_120 + 4.75375986099243) + 0.00124193349132182*std::sin(0.218639984726906*x_13 - 4.38479995727539) - 0.000824039480589197*std::sin(0.269839972257614*x_14 - 7.42647981643677) - 0.00107270236874504*std::sin(0.297919929027557*x_14 + 1.96719980239868) - 0.00737588006001255*std::sin(0.352399855852127*x_14 + 8.24512004852295) - 0.000331834889819847*std::sin(0.508959829807281*x_15 + 1.68047988414764) - 0.000259768186142277*std::sin(0.314959913492203*x_16 + 1.78967988491058) - 0.000594472534714053*std::sin(0.398079842329025*x_16 + 1.80543982982635) - 3.31395185537514e-5*std::sin(0.547359883785248*x_16 - 7.54184007644653) + 0.000376106075434889*std::sin(0.447759836912155*x_18 - 1.21223986148834) - 0.00211500789353515*std::sin(0.479279845952988*x_18 - 1.2247998714447) + 0.00252899074829689*std::sin(0.156000033020973*x_19 - 1.41391980648041) - 0.0119621455593646*std::sin(0.338479846715927*x_19 - 4.35743999481201) - 0.000460420399259828*std::sin(0.34895983338356*x_19 - 4.37375974655151) + 0.000718119714231082*std::sin(0.351359844207764*x_19 - 4.35784006118774) - 0.000238726154111521*std::sin(0.363359838724136*x_19 - 7.79911994934082) + 0.000356091059230776*std::sin(0.403119832277298*x_2 + 5.21200037002563) - 0.000964142373419253*std::sin(0.488319844007492*x_2 - 4.37152004241943) - 0.000388627473858663*std::sin(0.255759954452515*x_20 - 1.35999977588654) - 0.000835666474214071*std::sin(0.262479960918427*x_20 + 8.19607925415039) - 0.00283198771264394*std::sin(0.284639924764633*x_20 + 4.99671983718872) - 0.000857464997997793*std::sin(0.355199843645096*x_20 - 7.57775974273682) - 6.72739941353776e-5*std::sin(0.398719847202301*x_20 + 1.37599992752075) + 0.000297264225441235*std::sin(0.309199929237366*x_21 - 7.78527975082397) + 0.000347451845800255*std::sin(0.313199937343597*x_22 - 4.34143972396851) + 5.35787951430117e-5*std::sin(0.748719871044159*x_22 + 7.81496000289917) + 0.0187037484426159*std::sin(0.188480004668236*x_23 - 7.60056018829346) + 0.000593731632189078*std::sin(0.220399990677834*x_23 - 4.39192008972168) + 5.34815970864017e-5*std::sin(0.638799846172333*x_23 - 1.57759976387024) + 0.000973351853039016*std::sin(0.319439917802811*x_24 + 5.02647972106934) - 0.00519694391192966*std::sin(0.345359832048416*x_24 - 1.18375980854034) - 0.000484065788819085*std::sin(0.352239847183228*x_24 + 1.8154399394989) - 0.000753686919176756*std::sin(0.411519855260849*x_24 - 1.18431985378265) - 0.000154045913716191*std::sin(0.5065598487854*x_24 + 4.93807983398438) - 0.000309292206552069*std::sin(0.261679977178574*x_25 + 2.00943970680237) - 0.000239696369692338*std::sin(0.323359847068787*x_25 - 1.16343986988068) - 0.00771762302949359*std::sin(0.291839927434921*x_26 - 1.17271983623505) - 0.00241147670805589*std::sin(0.338559836149216*x_26 - 7.57192039489746) + 0.000174677784945163*std::sin(0.355599850416183*x_26 - 4.35775947570801) - 0.000521633475547782*std::sin(0.408239871263504*x_27 + 1.97231984138489) + 0.000455045249108812*std::sin(0.319119930267334*x_28 - 1.18535983562469) - 0.000138824170993624*std::sin(0.39047983288765*x_28 - 1.36959993839264) - 0.000615793380360742*std::sin(0.475599855184555*x_28 + 4.95831966400146) + 0.0126362043013058*std::sin(0.233119979500771*x_29 + 5.00799989700317) - 0.000400634429645332*std::sin(0.301359921693802*x_3 - 4.32032012939453) + 0.00710474506069765*std::sin(0.326879858970642*x_3 + 1.99583983421326) - 0.000629200689007133*std::sin(0.440799862146378*x_3 - 1.1911199092865) - 0.00491325470240271*std::sin(0.325839847326279*x_30 - 1.13759982585907) - 5.83556273724394e-6*std::sin(0.729919850826263*x_31 - 4.79967975616455) - 0.000744990358915291*std::sin(0.321119844913483*x_32 + 2.00159978866577) - 0.0160280172283401*std::sin(0.251759976148605*x_33 + 1.96623980998993) + 0.000303563493672929*std::sin(0.276319950819016*x_33 - 7.61472034454346) + 0.00103294190607914*std::sin(0.239119976758957*x_34 + 7.97983980178833) + 0.0010830617522269*std::sin(0.285279929637909*x_34 + 1.77127993106842) + 0.011163338623395*std::sin(0.248959973454475*x_35 + 1.96167981624603) - 0.000312653782917522*std::sin(0.279199957847595*x_35 - 1.43975985050201) + 0.00065954521879242*std::sin(0.202879995107651*x_36 - 4.39247989654541) + 0.00471730956918164*std::sin(0.186400011181831*x_38 + 5.01095962524414) - 0.000945988041223258*std::sin(0.253519982099533*x_38 - 7.62184000015259) + 0.0031501330510308*std::sin(0.239039987325668*x_4 + 5.00807952880859) - 0.000303732419834493*std::sin(0.333759844303131*x_4 + 8.01072025299072) + 0.000464348493398285*std::sin(0.427439838647842*x_4 - 1.18679988384247) + 0.000155101595286877*std::sin(0.216559991240501*x_40 - 7.80495977401733) + 0.000831436580420779*std::sin(0.228479996323586*x_40 - 1.21911990642548) + 0.00124781776574645*std::sin(0.27991995215416*x_41 - 1.22039985656738) + 0.00155529892055538*std::sin(0.224399983882904*x_42 - 1.21111989021301) - 0.00143751912232867*std::sin(0.229999989271164*x_42 + 1.96623980998993) - 0.000239072088453702*std::sin(0.328639835119247*x_42 - 1.31815981864929) + 0.000720188769247067*std::sin(0.304079920053482*x_43 + 1.91623985767365) - 0.0230418665822355*std::sin(0.118240058422089*x_44 + 8.16224002838135) + 0.000890368176470891*std::sin(0.257839977741241*x_44 - 7.44911956787109) - 0.00026490574947837*std::sin(0.336479842662811*x_44 - 1.34127986431122) - 0.00159478431745681*std::sin(0.181120008230209*x_45 + 1.99287974834442) - 0.000741313016462948*std::sin(0.183680012822151*x_45 - 1.18559980392456) - 9.02630029511156e-5*std::sin(0.380719840526581*x_48 - 1.99863982200623) - 0.000456882868967325*std::sin(0.261119961738586*x_49 + 1.94247984886169) + 0.000464178713401505*std::sin(0.328159838914871*x_49 - 7.46968030929565) - 0.00911194842607483*std::sin(0.412159860134125*x_49 + 4.97711944580078) - 0.000326060828827109*std::sin(0.311839938163757*x_5 - 7.56879997253418) - 0.000346774680184892*std::sin(0.373759835958481*x_5 - 7.38263988494873) - 0.000617852045006778*std::sin(0.416639864444733*x_5 + 1.96631979942322) - 0.00560159640481267*std::sin(0.451359868049622*x_5 - 1.2176798582077) - 0.00150999807558604*std::sin(0.12352005392313*x_50 + 1.63047981262207) - 0.000674689286136465*std::sin(0.247359976172447*x_52 + 1.96775984764099) - 0.000485811281550896*std::sin(0.202079996466637*x_53 - 1.19311988353729) - 0.00108613660922589*std::sin(0.240319982171059*x_53 - 1.19671988487244) - 0.000179765012627596*std::sin(0.277839958667755*x_55 + 4.72816038131714) + 0.00172207810909435*std::sin(0.195280000567436*x_56 - 1.18679988384247) - 0.00408222577233816*std::sin(0.131920039653778*x_57 - 7.61880016326904) - 0.000607441725770448*std::sin(0.449039846658707*x_57 - 1.30199992656708) - 0.000217546463243547*std::sin(0.452639847993851*x_57 - 7.50471973419189) + 0.00176048839216152*std::sin(0.106800064444542*x_58 - 7.62919998168945) - 0.00103783980107691*std::sin(0.239759981632233*x_58 - 7.61368036270142) - 0.000120952562788388*std::sin(0.548639833927155*x_58 + 1.6451997756958) + 0.0135080421657045*std::sin(0.148400038480759*x_59 - 1.5810399055481) - 0.000459245650933022*std::sin(0.250479966402054*x_59 - 7.6255202293396) + 0.000324818908446652*std::sin(0.448639839887619*x_59 + 1.88055980205536) + 8.99573448999138e-5*std::sin(0.363759845495224*x_6 - 1.77367985248566) - 0.00145043955180181*std::sin(0.197039991617203*x_60 + 5.00575971603394) + 0.000240654658872235*std::sin(0.523919880390167*x_60 + 8.08559989929199) + 4.61486628839442e-5*std::sin(0.801759898662567*x_63 + 8.58879947662354) - 0.00061975531945443*std::sin(0.430479854345322*x_7 - 4.4236798286438) + 0.000140261947925046*std::sin(0.463679850101471*x_7 + 4.96807956695557) + 0.00564262464352004*std::sin(0.172400012612343*x_8 + 7.81128025054932) - 0.000127261932647157*std::sin(0.174160018563271*x_8 + 8.00144004821777) - 1.57809731791466e-5*std::sin(0.703439831733704*x_8 + 4.0403995513916) - 0.00162748081747827*std::sin(0.171280011534691*x_9 - 1.4197598695755) - 4.38600900147566e-5*std::sin(0.263279944658279*x_9 + 4.32567977905273) + 6.18624943008773e-5*std::sin(0.433199852705002*x_9 + 7.36879968643188) + 0.000356770906468329*std::sin(0.318399846553802*x_91 - 1.21383988857269) + 0.000196212469517812*std::sin(0.347679853439331*x_91 - 7.39775943756104) - 0.00052409055002103*std::sin(0.325039833784103*x_92 - 1.18871986865997) - 0.000292200791426489*std::sin(0.27007994055748*x_94 - 4.40319967269897) + 0.000254083241707295*std::sin(0.282559931278229*x_94 + 8.19808006286621) + 0.00447398597040025*std::sin(0.316559940576553*x_94 + 4.78975963592529) - 0.000267706292472299*std::sin(0.346959829330444*x_94 + 4.61783981323242) + 0.00509386171591153*std::sin(0.324079841375351*x_95 - 1.36367988586426) + 0.000392490934054587*std::sin(0.258719980716705*x_96 + 8.19823932647705) + 0.00730733440458833*std::sin(0.260559976100922*x_97 + 1.97991979122162) + 0.00032831683510589*std::sin(0.279599964618683*x_97 - 4.40623998641968) - 0.000266209419032671*std::sin(0.276239961385727*x_98 + 4.97775983810425) + 0.000185398022154213*std::sin(0.313599914312363*x_98 + 4.77895975112915) - 0.0577045083045959*std::sin(-0.00601958467778038*x_1 + 0.000940495208147394*x_100 + 0.000621471763052778*x_101 - 0.000895779836186148*x_102 + 0.00151427577561666*x_103 + 0.00362143591555416*x_104 + 0.00599834123814815*x_105 + 0.0014838350043454*x_106 - 0.0117631229140767*x_107 - 0.00170106487032485*x_108 + 0.00239458909342697*x_109 + 0.00696199569281945*x_11 + 0.000679609084702713*x_111 - 0.000607387437897444*x_112 - 0.00172149896634203*x_113 + 0.00082244153300667*x_114 + 0.0150055411489209*x_115 - 0.000609657559541277*x_116 - 0.000120187635341916*x_117 - 0.00171814032411267*x_118 + 0.00815692551255981*x_119 + 0.0182370022440892*x_120 - 0.00873794673095188*x_13 - 0.00155193363586161*x_15 - 0.00430388938251714*x_16 + 0.00328830400398864*x_18 - 0.000541567175176568*x_2 - 0.00365852479287628*x_20 - 0.000166637448399699*x_22 - 0.00116771567471836*x_23 - 0.00289630767655205*x_24 - 0.00568489423252915*x_25 - 0.000303643719431218*x_26 + 0.00832950613650203*x_27 - 0.0111138880419042*x_28 - 0.00102068116828093*x_29 + 0.00243569724298196*x_3 - 0.000686845704497212*x_31 - 0.00175201557426937*x_32 + 0.00251107228054283*x_33 + 8.1679936951482e-5*x_34 + 0.00113555681314009*x_35 + 0.00030089650777399*x_36 + 9.31948800424492e-5*x_38 + 0.00141229992816537*x_39 + 0.00114527249056704*x_40 + 6.81018362602614e-5*x_42 + 0.0162625674553973*x_43 - 0.000442782366596032*x_44 + 0.00173703198583*x_45 + 0.00134465582799857*x_46 + 0.0390138078660584*x_47 + 0.034302911970797*x_48 - 0.00373248729745865*x_49 + 0.00153091271615301*x_50 + 0.00130200538833581*x_51 + 0.000540839609550462*x_54 + 0.0182663461282248*x_57 + 0.0040413540843963*x_58 - 0.00240733854144897*x_59 + 0.00402928412325291*x_6 - 0.000775166956091262*x_60 + 0.000126445511123208*x_61 - 0.0020237126793453*x_64 - 0.000761440865732182*x_65 - 0.000307422584702089*x_66 + 0.000241601669135554*x_67 - 0.000159202294305231*x_68 + 0.000252972193625295*x_69 - 0.000338130962903416*x_7 + 0.000435473003642004*x_70 - 0.000203455162448878*x_71 - 4.068763524763e-5*x_72 - 6.91854209524063e-5*x_73 + 0.00041809248446618*x_74 - 0.000331226049350401*x_75 - 0.000217413573914319*x_76 - 0.00190847235744538*x_77 + 5.48866627909807e-5*x_78 - 0.000296306895856063*x_79 + 0.000185959685201743*x_80 + 0.000475470764868925*x_81 - 0.000941602947614209*x_82 + 0.00311366027034366*x_83 - 0.000772008717536423*x_84 - 0.000268152414474289*x_85 - 4.59301593840507e-5*x_86 - 1.30592666736124e-6*x_87 - 7.56899944458655e-5*x_88 - 0.000418921382095418*x_89 - 0.000733582710182245*x_9 - 0.00140559133522099*x_90 - 0.000172697150661241*x_91 - 0.000493507683655957*x_92 + 0.0118062320675437*x_93 - 0.000682055105389665*x_95 + 0.000196491741370622*x_96 + 0.000761478961926902*x_97 + 0.000422897170472761*x_98 + 0.00165228381946581*x_99 - 0.000427221555028104*std::pow(0.586719870567322 - 2.74799990653992*x_8, 2) + 2.13836012871105e-5*std::pow(5.90783977508545 - 6.72600030899048*x_41, 2) - 0.0732043319160501*std::exp(0.208159849047661*x_14) + 0.167484427949225*std::sin(0.184320002794266*x_10 + 1.76455986499786) + 0.0598616733373798*std::sin(0.312159925699234*x_110 + 1.51447987556458) + 0.217683707574824*std::sin(0.377759844064713*x_12 - 7.57472038269043) - 0.472894245377876*std::sin(0.129280045628548*x_17 - 1.43207991123199) + 0.268983527464545*std::sin(0.30839991569519*x_19 + 5.02143955230713) + 0.166740522975255*std::sin(0.229599997401237*x_21 - 4.40079975128174) - 0.106479263168264*std::sin(0.286239951848984*x_30 - 4.36639976501465) + 0.137546063991136*std::sin(0.202880010008812*x_37 - 8.00967979431152) + 0.0730022393803291*std::sin(0.442959845066071*x_4 + 1.78983998298645) + 0.154754977307579*std::sin(0.168400019407272*x_5 - 4.60983991622925) + 0.194700808508657*std::sin(0.341359823942184*x_52 - 1.33279979228973) + 0.202072076533788*std::sin(0.266879975795746*x_53 - 7.61999988555908) - 0.0831228949959653*std::sin(0.233519986271858*x_55 + 7.96848011016846) - 0.0879308600040245*std::sin(0.267359972000122*x_56 - 4.42799949645996) + 0.00513371067264595*std::sin(1.41615986824036*x_62 + 3.77920007705688) + 0.00472272699070028*std::sin(1.67223989963531*x_63 - 9.78384017944336) - 0.00738446458133968*std::sin(0.450159847736359*x_94 - 2.01663970947266) + 6.20486011941753) - 0.00974322482943535*std::sin(-0.000242785710162328*x_1 + 0.000431692790177706*x_10 + 0.00246420606679167*x_100 + 0.00166202890242987*x_101 - 0.0157945320598995*x_102 + 0.00575133791211456*x_103 - 0.000591471057882882*x_104 + 0.00595780747059787*x_105 + 0.000311475784945912*x_106 + 0.00238777337971648*x_107 + 0.00363407342837822*x_108 + 0.00166296950637747*x_109 - 0.00851230817588018*x_110 - 0.00101296984036022*x_111 + 0.00463145486282227*x_112 - 0.00237672993807081*x_114 + 0.0278409614651594*x_115 - 0.00270531429923458*x_116 + 0.00108932802984084*x_117 + 0.000200391268704018*x_118 + 0.011319566474588*x_119 + 0.00348529942990756*x_12 + 0.0208605165508932*x_120 + 0.0109886781307208*x_14 - 0.000628745902351415*x_15 + 0.00440101655449617*x_16 - 0.00109842609536734*x_17 - 0.000657630247218804*x_18 + 0.00609624106075572*x_19 - 8.46055293207092e-5*x_2 + 7.15459929247935e-5*x_20 + 0.00191932457114398*x_22 + 0.00652190052626861*x_23 - 0.0011127609532804*x_24 + 0.000608585541717355*x_25 + 0.0024613995806822*x_26 - 0.00112751933998959*x_27 - 0.000641353607433357*x_28 + 0.00876693253503688*x_3 + 0.00204862355248005*x_30 + 0.000760700319893103*x_31 + 0.00160835422685374*x_32 + 0.00205603281733481*x_33 + 0.00170988125735468*x_35 + 0.00074931632171275*x_36 + 0.0118387709079985*x_37 + 0.000778739169957695*x_39 - 0.00718593905585502*x_40 + 0.00454816566398082*x_41 + 0.00224514146952733*x_42 + 0.00800615286337799*x_43 + 0.00196472631211581*x_45 + 0.0568847168433634*x_47 + 0.00137383853369108*x_48 - 0.000648530413926131*x_5 + 0.00711836509588677*x_50 + 0.00450630004406752*x_51 + 0.000460188216002361*x_52 + 0.0214690569341872*x_53 + 0.000584134180031717*x_54 - 0.0156064747704027*x_55 + 0.0323300460495878*x_56 + 0.00169751951059312*x_57 + 0.008655573174812*x_58 + 0.00322847778103541*x_59 - 0.000386509245528586*x_6 - 0.000763338481721121*x_60 + 0.00229216791173309*x_61 - 0.000179348872675238*x_62 + 0.000523258669932346*x_63 + 0.000985817630765797*x_64 + 0.00242799697962679*x_65 - 0.00050183095705095*x_66 + 0.000225189127613659*x_67 - 0.00059664387383282*x_68 + 0.000979098535770456*x_69 - 0.000680548109008682*x_7 - 0.0014563571931289*x_70 - 0.000165483600371628*x_71 + 2.49215448471006e-5*x_72 - 0.000420151644336575*x_73 + 0.000618301387027608*x_74 - 0.000334048542541779*x_75 - 1.22157595651064e-5*x_76 + 0.000739599514758864*x_77 - 1.35618600417209e-5*x_78 + 0.000740770398120136*x_79 - 0.000376466225905664*x_8 + 0.000686543251362486*x_80 - 0.00107714843645565*x_81 - 0.000196567926830596*x_82 + 0.00233927194456268*x_83 + 0.000739699839945513*x_84 + 0.000639825560677938*x_85 - 0.00426687030030723*x_86 + 0.000681259739740776*x_87 - 0.000329823957996609*x_88 + 0.000901232716739027*x_89 - 0.00168053122029596*x_9 + 0.00189344841403796*x_90 - 0.000123929640315954*x_91 + 0.00177629464791683*x_92 + 0.00543881177678908*x_93 + 0.0105452695971253*x_94 + 0.000548412188109226*x_95 + 0.0008578390771982*x_96 + 0.000882166265710197*x_97 + 0.00049868795396705*x_98 + 0.0305612317418321*x_99 + 0.0336676184060942*std::sin(0.386879861354828*x_11 - 2.18583989143372) + 0.0176741179358495*std::sin(0.233039990067482*x_113 + 5.00207996368408) - 0.127120465456468*std::sin(0.456879854202271*x_13 - 4.82416009902954) - 0.345714431154258*std::sin(0.275599956512451*x_21 + 8.02600002288818) + 0.0376835213462068*std::sin(0.551679849624634*x_29 - 1.37071990966797) - 0.267424776602287*std::sin(0.257119953632355*x_34 - 1.4139199256897) + 0.403525275003876*std::sin(0.251359969377518*x_38 + 4.96871948242188) - 0.214895079937661*std::sin(0.404239863157272*x_4 - 4.41328001022339) + 0.00937901653731743*std::sin(0.342239856719971*x_44 - 1.53007984161377) - 0.540814376816904*std::sin(0.198080003261566*x_46 - 4.59815979003906) + 0.0311284262946301*std::sin(0.453679859638214*x_49 + 7.36191987991333) + 1.30225660799128) + 0.117929999073683);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-2.72058048441079e-5*x_1 - 0.00030751484086185*x_10 - 0.00205525747525863*x_100 + 0.00130421121747474*x_101 + 0.000428712352043384*x_102 - 0.000193846493035447*x_103 + 0.000304150931085357*x_104 - 0.000623587313778097*x_105 + 0.0013644042256771*x_106 + 0.000154223072325952*x_107 + 0.00122630148245183*x_108 + 4.10307154934281e-5*x_109 - 0.000972511711461154*x_11 - 0.00101666371366536*x_110 - 0.000350012840763039*x_111 + 0.000617924618681061*x_112 + 5.51049298709641e-5*x_113 - 0.0012508625364722*x_114 + 0.0010498896288219*x_115 + 0.000632534741479835*x_116 - 0.00229185538553915*x_117 - 0.000402393207778582*x_118 + 0.00148857927364699*x_119 + 0.00013686671906032*x_12 - 0.000460405933472642*x_120 - 0.000483607613692788*x_13 + 0.000415510758970561*x_14 + 0.000334399672051941*x_15 + 0.000733993857095305*x_16 + 0.000331723895564021*x_17 - 0.000290544696943558*x_18 + 8.56820705492374e-5*x_19 - 2.8673977983286e-5*x_2 + 4.67231064396987e-5*x_20 + 0.000427233286473475*x_21 + 0.000151364363533126*x_22 + 0.000117944953233373*x_23 + 3.43505520576522e-5*x_24 + 0.000542325907980879*x_25 - 4.25082248778892e-5*x_26 - 7.86821082022533e-5*x_27 + 0.00015633834722656*x_28 + 0.000286019942763401*x_29 + 0.000209517742817238*x_3 + 4.68611856936502e-5*x_30 + 3.80061008366723e-5*x_31 + 0.000160140564101833*x_32 + 8.21534801040809e-5*x_33 - 7.17032648984516e-5*x_34 - 0.000290540202548819*x_35 + 0.000356276502260034*x_36 - 0.000117982464934844*x_37 + 0.000249690277735581*x_38 + 0.000653510649402348*x_39 - 0.00035642554100762*x_4 + 4.73009071814886e-5*x_40 + 0.000752491951727177*x_41 + 0.000563514787366854*x_42 + 0.000530127422163023*x_43 - 7.32280723973221e-7*x_44 - 0.000667872610575456*x_45 + 0.00160575671883498*x_46 - 0.00169872335465496*x_47 - 0.00147697155684579*x_48 - 0.00034504601058103*x_49 - 1.25431791803156e-5*x_5 + 0.000660862824869031*x_50 - 0.000786480772886031*x_51 - 2.70082920730871e-5*x_52 - 0.000211917501223218*x_53 + 0.00196674201030371*x_54 - 0.00417607911333782*x_55 - 0.00096334543778337*x_56 + 0.00158913481500812*x_57 + 0.00179284371297073*x_58 - 0.000175624027169974*x_59 - 2.71983197650388e-5*x_6 - 9.75489185978419e-5*x_60 + 5.90008334341213e-5*x_61 + 4.68330155917442e-6*x_62 + 2.72347575427534e-5*x_63 + 1.04721591660774e-5*x_64 + 2.2688354513428e-5*x_65 + 3.12510958121859e-5*x_66 + 6.60139277908966e-5*x_67 - 2.75035630410506e-5*x_68 + 3.03116648800762e-5*x_69 + 2.60850926866774e-5*x_7 - 5.11183460927651e-6*x_70 + 2.0620236029773e-5*x_71 - 2.61584047077912e-5*x_72 - 3.41236420428346e-5*x_73 + 6.30294605170869e-6*x_74 + 8.27406804441055e-6*x_75 - 2.5491598515525e-5*x_76 + 8.80187322197664e-5*x_77 - 0.000169831096019618*x_78 - 6.57624749473475e-6*x_79 + 6.07677853450086e-5*x_8 - 9.14264911226393e-7*x_80 - 8.17347763458026e-6*x_81 - 5.1033379864722e-5*x_82 + 0.000117840494971682*x_83 - 2.33376284631876e-5*x_84 + 2.30879858685852e-5*x_85 + 2.59120036965644e-5*x_86 - 7.01909387048089e-6*x_87 - 3.98187100045414e-5*x_88 + 3.39934708341596e-5*x_89 + 8.6325360093937e-5*x_9 + 9.17332381737834e-5*x_90 - 5.91332660850647e-5*x_91 - 2.27147736372712e-5*x_92 - 0.000246962800549833*x_93 + 8.51778659443109e-5*x_94 + 0.00047158865388121*x_95 - 0.00035082830271915*x_96 + 0.000164236339353764*x_97 + 0.000465485518259754*x_98 - 0.00160193974007626*x_99 + 2.80153480330284e-6*std::pow(0.586719870567322 - 2.74799990653992*x_8, 2) + 6.42675789515011e-7*std::pow(5.50623989105225 - 9.58327960968018*x_6, 2) - 1.4022443980349e-7*std::pow(5.90783977508545 - 6.72600030899048*x_41, 2) + 1.44750831791448e-7*std::pow(-7.36751985549927*x_11 - 5.58879995346069, 2) + 1.44912368810709e-8*std::pow(-6.45391988754272*x_17 - 1.20223987102509, 2) + 1.85216106202982e-7*std::pow(-7.15599966049194*x_19 - 8.56088066101074, 2) - 1.83518103998387e-6*std::pow(-5.99191999435425*x_26 - 0.821199893951416, 2) - 1.84747310343888e-5*std::pow(-3.90079998970032*x_27 - 7.59823989868164, 2) - 7.52722801196198e-8*std::pow(-6.28359985351563*x_32 - 4.66207981109619, 2) + 1.59622650486673e-5*std::pow(-3.47567987442017*x_43 - 8.39967918395996, 2) + 2.79257243839798e-6*std::pow(-2.60359978675842*x_52 - 6.60096025466919, 2) + 1.1110783905416e-5*std::pow(-2.68167996406555*x_58 - 5.57872009277344, 2) + 0.00187164951996687*std::exp(0.198239862918854*x_13) + 0.000480042453854783*std::exp(0.208159849047661*x_14) + 0.000115418421927752*std::exp(0.311599850654602*x_18) + 7.05784723429577e-5*std::exp(0.619279801845551*x_18) - 2.77704989344563e-5*std::exp(0.370399862527847*x_19) - 0.00106309559464621*std::exp(0.265839844942093*x_27) - 1.5688768359965e-5*std::exp(0.417679876089096*x_27) + 0.000163708845943245*std::exp(0.427119851112366*x_30) - 0.000157210618822496*std::exp(0.188799858093262*x_43) + 3.87177782886817e-5*std::exp(0.285439848899841*x_49) + 0.00049052340139811*std::exp(0.19327986240387*x_56) - 0.0025251424842345*std::exp(0.225839853286743*x_60) - 3.47749237304725e-5*std::exp(0.243999853730202*x_8) - 0.0115506572135533*std::sin(0.143360033631325*x_1 + 4.91999959945679) - 0.00109829068404602*std::sin(0.184320002794266*x_10 + 1.76455986499786) + 1.14041056417384e-5*std::sin(0.596159815788269*x_10 + 4.99143981933594) - 0.00531207704237138*std::sin(0.249439969658852*x_100 - 7.61488008499146) + 0.00117795252837194*std::sin(0.276079952716827*x_100 + 1.78791987895966) + 0.0122166300825315*std::sin(0.237599983811378*x_102 + 8.17735958099365) + 0.00133342202654185*std::sin(0.254479974508286*x_102 + 1.77367985248566) + 0.000141744996157762*std::sin(0.291839927434921*x_102 + 1.5759197473526) - 0.004743003289543*std::sin(0.256239980459213*x_103 + 1.96455979347229) - 0.0109882841415905*std::sin(0.215120002627373*x_104 - 4.39056015014648) + 7.48397016643674e-5*std::sin(0.31183984875679*x_105 + 4.43111991882324) + 2.5603246661472e-5*std::sin(1.16343986988068*x_106 - 5.78295993804932) - 0.0070999929258976*std::sin(0.259199976921082*x_107 - 7.43327951431274) + 0.00551714753578862*std::sin(0.278879970312119*x_107 + 1.76543986797333) + 0.012053150567467*std::sin(0.238079980015755*x_109 - 1.21103978157043) - 0.00411830274858996*std::sin(0.239439979195595*x_109 + 8.19032001495361) - 0.00672409254584791*std::sin(0.25927996635437*x_109 - 4.41807985305786) - 0.0014943435246628*std::sin(0.277599930763245*x_109 + 4.95183992385864) + 0.000463340037298662*std::sin(0.386879861354828*x_11 - 2.18583989143372) - 0.000392547050271336*std::sin(0.312159925699234*x_110 + 1.51447987556458) + 0.000402823690279227*std::sin(0.287199944257736*x_112 + 4.56680011749268) + 0.00024323450399257*std::sin(0.233039990067482*x_113 + 5.00207996368408) + 0.00399239594617406*std::sin(0.286159932613373*x_113 - 1.19527995586395) + 0.000839631259463574*std::sin(0.295519918203354*x_114 + 7.73567962646484) + 0.00157452961292515*std::sin(0.253679990768433*x_116 + 5.15799999237061) - 0.000254821161435163*std::sin(0.247519969940186*x_117 - 7.43887996673584) - 0.00896171050758375*std::sin(0.26063996553421*x_117 - 1.22167980670929) + 0.00121185222488244*std::sin(0.29615992307663*x_117 + 4.76168012619019) + 0.000185143552230669*std::sin(0.284399926662445*x_118 + 1.75903987884521) - 0.00426940898879003*std::sin(0.22087998688221*x_119 - 4.40064001083374) + 4.79501607968897e-5*std::sin(0.309679925441742*x_119 + 7.73167991638184) + 0.00171254054914999*std::sin(0.23879998922348*x_12 + 5.00543975830078) - 0.00142747592134659*std::sin(0.377759844064713*x_12 - 7.57472038269043) + 0.000444133413894782*std::sin(0.266959965229034*x_120 - 1.2157598733902) - 0.00109069450750706*std::sin(0.218639984726906*x_13 - 4.38479995727539) - 0.00174945553010549*std::sin(0.456879854202271*x_13 - 4.82416009902954) + 0.000723690392221425*std::sin(0.269839972257614*x_14 - 7.42647981643677) - 0.000468302419967004*std::sin(0.297919929027557*x_14 + 1.96719980239868) + 0.00704123775672706*std::sin(0.352399855852127*x_14 + 8.24512004852295) + 0.000635254480302735*std::sin(0.508959829807281*x_15 + 1.68047988414764) - 0.000113405240582424*std::sin(0.314959913492203*x_16 + 1.78967988491058) + 0.00113803988875024*std::sin(0.398079842329025*x_16 + 1.80543982982635) + 2.19392199532503e-6*std::sin(0.547359883785248*x_16 - 7.54184007644653) + 0.00310103661932648*std::sin(0.129280045628548*x_17 - 1.43207991123199) - 0.00325402536009748*std::sin(0.447759836912155*x_18 - 1.21223986148834) + 0.000140019002701762*std::sin(0.479279845952988*x_18 - 1.2247998714447) - 0.00484142190223567*std::sin(0.156000033020973*x_19 - 1.41391980648041) - 0.00176387802730955*std::sin(0.30839991569519*x_19 + 5.02143955230713) + 0.0114194252453611*std::sin(0.338479846715927*x_19 - 4.35743999481201) + 0.00398350293534957*std::sin(0.34895983338356*x_19 - 4.37375974655151) + 0.00524258032273696*std::sin(0.351359844207764*x_19 - 4.35784006118774) - 0.00308085780295117*std::sin(0.403119832277298*x_2 + 5.21200037002563) + 0.000920399413676005*std::sin(0.488319844007492*x_2 - 4.37152004241943) + 0.00723008767282355*std::sin(0.262479960918427*x_20 + 8.19607925415039) + 0.00270350095807031*std::sin(0.284639924764633*x_20 + 4.99671983718872) + 0.00164150455058115*std::sin(0.355199843645096*x_20 - 7.57775974273682) - 0.000491128861799443*std::sin(0.398719847202301*x_20 + 1.37599992752075) - 0.00109341247588822*std::sin(0.229599997401237*x_21 - 4.40079975128174) - 0.00475778641344898*std::sin(0.275599956512451*x_21 + 8.02600002288818) + 0.000129774632926941*std::sin(0.309199929237366*x_21 - 7.78527975082397) - 0.00300611234832989*std::sin(0.313199937343597*x_22 - 4.34143972396851) - 0.0178551628625925*std::sin(0.188480004668236*x_23 - 7.60056018829346) - 0.00513689598340402*std::sin(0.220399990677834*x_23 - 4.39192008972168) - 0.000102383520254085*std::sin(0.638799846172333*x_23 - 1.57759976387024) + 0.000424929637091049*std::sin(0.319439917802811*x_24 + 5.02647972106934) + 0.00496115953547782*std::sin(0.345359832048416*x_24 - 1.18375980854034) + 0.00418808005414841*std::sin(0.352239847183228*x_24 + 1.8154399394989) + 0.00144283499668323*std::sin(0.411519855260849*x_24 - 1.18431985378265) - 0.00112460089876695*std::sin(0.5065598487854*x_24 + 4.93807983398438) + 0.00267595965483194*std::sin(0.261679977178574*x_25 + 2.00943970680237) + 0.00736747591139167*std::sin(0.291839927434921*x_26 - 1.17271983623505) + 0.000159646006396762*std::sin(0.338559836149216*x_26 - 7.57192039489746) - 0.000334397764972861*std::sin(0.355599850416183*x_26 - 4.35775947570801) - 0.00380814694318182*std::sin(0.408239871263504*x_27 + 1.97231984138489) - 0.000871124592696634*std::sin(0.319119930267334*x_28 - 1.18535983562469) - 6.06055296608367e-5*std::sin(0.39047983288765*x_28 - 1.36959993839264) + 0.000540803885563811*std::sin(0.475599855184555*x_28 + 4.95831966400146) - 0.0120629020678409*std::sin(0.233119979500771*x_29 + 5.00799989700317) + 0.00051860764178484*std::sin(0.551679849624634*x_29 - 1.37071990966797) + 0.00346624178481209*std::sin(0.301359921693802*x_3 - 4.32032012939453) - 0.00678240410178515*std::sin(0.326879858970642*x_3 + 1.99583983421326) + 0.00120452239641934*std::sin(0.440799862146378*x_3 - 1.1911199092865) + 0.000698245109791593*std::sin(0.286239951848984*x_30 - 4.36639976501465) + 0.00469034125250077*std::sin(0.325839847326279*x_30 - 1.13759982585907) + 5.04885998331049e-5*std::sin(0.729919850826263*x_31 - 4.79967975616455) - 0.000325235403684505*std::sin(0.321119844913483*x_32 + 2.00159978866577) + 0.0153008290746892*std::sin(0.251759976148605*x_33 + 1.96623980998993) - 0.00262639550735604*std::sin(0.276319950819016*x_33 - 7.61472034454346) - 0.000907153298793238*std::sin(0.239119976758957*x_34 + 7.97983980178833) - 0.00368034960094062*std::sin(0.257119953632355*x_34 - 1.4139199256897) + 0.00790681291435295*std::sin(0.285279929637909*x_34 + 1.77127993106842) - 0.0106568600311601*std::sin(0.248959973454475*x_35 + 1.96167981624603) + 0.000274579730848954*std::sin(0.279199957847595*x_35 - 1.43975985050201) - 0.00570630736448479*std::sin(0.202879995107651*x_36 - 4.39247989654541) - 0.000901967798191127*std::sin(0.202880010008812*x_37 - 8.00967979431152) - 0.00450328611344517*std::sin(0.186400011181831*x_38 + 5.01095962524414) + 0.00555339001755483*std::sin(0.251359969377518*x_38 + 4.96871948242188) - 0.00690611633712322*std::sin(0.253519982099533*x_38 - 7.62184000015259) - 0.000208546970217661*std::sin(0.239039987325668*x_4 + 5.00807952880859) - 0.000132598408818033*std::sin(0.333759844303131*x_4 + 8.01072025299072) - 0.0029574261283534*std::sin(0.404239863157272*x_4 - 4.41328001022339) - 0.000888934436680933*std::sin(0.427439838647842*x_4 - 1.18679988384247) - 0.000478717218117853*std::sin(0.442959845066071*x_4 + 1.78983998298645) - 0.0013419206905166*std::sin(0.216559991240501*x_40 - 7.80495977401733) + 0.000362974646094666*std::sin(0.228479996323586*x_40 - 1.21911990642548) + 0.000544751364780264*std::sin(0.27991995215416*x_41 - 1.22039985656738) + 0.00067898633347874*std::sin(0.224399983882904*x_42 - 1.21111989021301) + 0.00275194227911331*std::sin(0.229999989271164*x_42 + 1.96623980998993) + 0.00206842348350869*std::sin(0.328639835119247*x_42 - 1.31815981864929) + 0.00525768530718245*std::sin(0.304079920053482*x_43 + 1.91623985767365) + 0.0219964613909446*std::sin(0.118240058422089*x_44 + 8.16224002838135) - 0.00770336034245106*std::sin(0.257839977741241*x_44 - 7.44911956787109) - 0.00193392500174184*std::sin(0.336479842662811*x_44 - 1.34127986431122) + 0.00012907577304128*std::sin(0.342239856719971*x_44 - 1.53007984161377) + 0.00305300591909122*std::sin(0.181120008230209*x_45 + 1.99287974834442) + 0.00641375269610183*std::sin(0.183680012822151*x_45 - 1.18559980392456) - 0.00744278821577232*std::sin(0.198080003261566*x_46 - 4.59815979003906) + 0.000172796709415954*std::sin(0.380719840526581*x_48 - 1.99863982200623) + 0.00395289664091361*std::sin(0.261119961738586*x_49 + 1.94247984886169) + 0.00020264336233116*std::sin(0.328159838914871*x_49 - 7.46968030929565) + 0.00869854102466501*std::sin(0.412159860134125*x_49 + 4.97711944580078) + 0.000428395202370235*std::sin(0.453679859638214*x_49 + 7.36191987991333) - 0.00101481643378927*std::sin(0.168400019407272*x_5 - 4.60983991622925) + 0.00282103979498597*std::sin(0.311839938163757*x_5 - 7.56879997253418) - 0.00253160312790927*std::sin(0.373759835958481*x_5 - 7.38263988494873) - 0.000269731489636532*std::sin(0.416639864444733*x_5 + 1.96631979942322) + 0.00534745302019546*std::sin(0.451359868049622*x_5 - 1.2176798582077) + 0.002890693752201*std::sin(0.12352005392313*x_50 + 1.63047981262207) - 0.000294544539687331*std::sin(0.247359976172447*x_52 + 1.96775984764099) - 0.00127676397608805*std::sin(0.341359823942184*x_52 - 1.33279979228973) + 0.00420318185118428*std::sin(0.202079996466637*x_53 - 1.19311988353729) + 0.00095387010847431*std::sin(0.240319982171059*x_53 - 1.19671988487244) - 0.00132510157439936*std::sin(0.266879975795746*x_53 - 7.61999988555908) + 0.000545084115119532*std::sin(0.233519986271858*x_55 + 7.96848011016846) + 0.000751795996129441*std::sin(0.195280000567436*x_56 - 1.18679988384247) + 0.000576612677160963*std::sin(0.267359972000122*x_56 - 4.42799949645996) + 0.00781488713526472*std::sin(0.131920039653778*x_57 - 7.61880016326904) - 0.00443458378265435*std::sin(0.449039846658707*x_57 - 1.30199992656708) + 0.00198680851139112*std::sin(0.239759981632233*x_58 - 7.61368036270142) - 5.28034425068708e-5*std::sin(0.548639833927155*x_58 + 1.6451997756958) - 0.0128951848108628*std::sin(0.148400038480759*x_59 - 1.5810399055481) + 0.00397333915152146*std::sin(0.250479966402054*x_59 - 7.6255202293396) + 0.00237131662608464*std::sin(0.448639839887619*x_59 + 1.88055980205536) - 0.000778300327355471*std::sin(0.363759845495224*x_6 - 1.77367985248566) + 0.00277667675087034*std::sin(0.197039991617203*x_60 + 5.00575971603394) - 0.00208211569592534*std::sin(0.523919880390167*x_60 + 8.08559989929199) - 3.36646616965728e-5*std::sin(1.41615986824036*x_62 + 3.77920007705688) - 4.40549066520944e-5*std::sin(0.801759898662567*x_63 + 8.58879947662354) - 3.0969607865582e-5*std::sin(1.67223989963531*x_63 - 9.78384017944336) - 0.000270562389293013*std::sin(0.430479854345322*x_7 - 4.4236798286438) - 0.00121352981356928*std::sin(0.463679850101471*x_7 + 4.96807956695557) - 0.000373556371879769*std::sin(0.172400012612343*x_8 + 7.81128025054932) - 5.55578814448452e-5*std::sin(0.174160018563271*x_8 + 8.00144004821777) + 0.000136535116782104*std::sin(0.703439831733704*x_8 + 4.0403995513916) - 0.0118813043845749*std::sin(0.171280011534691*x_9 - 1.4197598695755) + 0.000379472320512632*std::sin(0.263279944658279*x_9 + 4.32567977905273) - 5.43290628895439e-5*std::sin(0.433199852705002*x_9 + 7.36879968643188) + 0.000155753062304135*std::sin(0.318399846553802*x_91 - 1.21383988857269) - 0.00169760712065086*std::sin(0.347679853439331*x_91 - 7.39775943756104) + 0.00100330278761806*std::sin(0.325039833784103*x_92 - 1.18871986865997) - 0.000127564123775905*std::sin(0.27007994055748*x_94 - 4.40319967269897) - 0.00427100206097925*std::sin(0.316559940576553*x_94 + 4.78975963592529) + 0.000512488671069485*std::sin(0.346959829330444*x_94 + 4.61783981323242) + 4.84241356385198e-5*std::sin(0.450159847736359*x_94 - 2.01663970947266) - 0.00486275415947609*std::sin(0.324079841375351*x_95 - 1.36367988586426) - 0.00339578522241415*std::sin(0.258719980716705*x_96 + 8.19823932647705) - 0.00697580200491092*std::sin(0.260559976100922*x_97 + 1.97991979122162) - 0.00284055849495699*std::sin(0.279599964618683*x_97 - 4.40623998641968) + 0.00230321246373775*std::sin(0.276239961385727*x_98 + 4.97775983810425) + 0.00135348466774895*std::sin(0.313599914312363*x_98 + 4.77895975112915) + 0.00450676120817661*std::sin(0.000496094327348272*x_1 + 0.00299817397136207*x_10 - 0.00124795206160548*x_100 - 0.00264786980533328*x_101 - 0.0235710493270333*x_103 - 0.00316735523222472*x_104 + 0.0011068536001178*x_105 + 0.000417756128073899*x_106 + 0.00782041277301085*x_107 - 0.00404972404433512*x_108 - 0.00209009075409041*x_109 - 0.00083495163326004*x_11 + 0.0246796662003628*x_110 + 0.00551024058158733*x_111 + 0.000357219007689167*x_112 + 0.000989522670612935*x_113 + 4.50586653923778e-5*x_114 + 0.021866895357228*x_115 - 0.00481948648110853*x_116 + 0.00117588520941743*x_117 - 0.0040763129037812*x_119 + 0.0026716763742941*x_13 - 0.00253825729267028*x_14 + 0.00715627651588179*x_15 + 0.00156419207893779*x_16 + 0.000854470553261695*x_17 - 0.013089253893602*x_18 + 0.00121869915348014*x_2 + 0.00181069752740541*x_21 - 0.00544675203279953*x_23 - 0.00335127510841034*x_24 + 0.00251880264291794*x_27 + 0.000316140850285997*x_28 + 0.0129219081549519*x_29 + 0.00164298351634133*x_3 - 0.000112659174477657*x_31 - 0.000820757108033557*x_32 + 0.00931335921834471*x_33 + 0.00359115979289477*x_34 - 0.000542578950927529*x_35 - 0.0256497855744734*x_36 - 0.0218289719225388*x_37 + 0.0010821059212672*x_38 + 0.0048467841191681*x_39 - 0.000272659578030885*x_4 + 0.001355980592457*x_40 + 0.0571737335807972*x_41 - 0.0390964865888548*x_42 + 0.000866861523942309*x_43 + 0.00140752526183722*x_44 + 0.0207482044813726*x_45 - 0.0136194016531444*x_46 - 0.00336630925309036*x_47 + 0.0231763883459326*x_48 - 0.000112642176362407*x_49 - 0.0003928993963827*x_5 + 0.00200641394330792*x_50 + 0.00210792844866046*x_51 + 0.00341311691860899*x_52 - 0.00653535957956487*x_53 + 0.0116126044852125*x_54 - 0.010585158529571*x_56 + 0.000170464478520814*x_59 - 0.0116978188050057*x_6 + 0.00414848850834826*x_60 + 0.00019322646443136*x_61 - 7.32758726098197e-5*x_62 - 9.81680698892155e-5*x_63 + 0.00103396387113086*x_64 - 0.000476896867000454*x_65 + 0.000441516064814078*x_66 + 0.000424189913098126*x_67 + 0.000576933213929086*x_68 + 0.000586041583577938*x_69 - 0.000454915148106619*x_7 + 3.82838657671659e-5*x_70 - 0.000345459915493501*x_71 + 0.00063377245971561*x_72 + 0.00177632901326439*x_73 - 0.000819204681555197*x_74 - 0.000172503784610418*x_75 + 0.00057235191590775*x_76 + 0.00164357894798399*x_77 - 0.00077717828671097*x_78 + 0.000335229325693847*x_79 + 0.0462099926664437*x_8 + 0.000481388099109624*x_80 + 0.000217709207451342*x_81 - 0.00018467694488941*x_82 - 0.00307374388007569*x_83 - 0.0010825963314264*x_84 + 0.00013973318213091*x_85 - 0.00222013160276956*x_86 - 0.00142643282971719*x_87 + 0.0011532966016582*x_88 - 4.31577201416352e-5*x_89 + 0.00368795621453709*x_9 + 0.00212904109474032*x_90 + 4.37356462213769e-5*x_91 + 0.000214547323673461*x_92 + 0.000266437930495088*x_93 + 0.000611898979098265*x_95 + 0.00137938806944778*x_96 - 0.00106943212085017*x_97 + 0.000587960490487587*x_98 + 0.000947940804012879*x_99 + 0.000149946280572801*std::pow(-5.96751976013184*x_12 - 7.36407995223999, 2) - 8.86803008357238e-5*std::pow(-8.39199924468994*x_30 - 6.94776010513306, 2) + 0.0577660135632982*std::exp(0.318559855222702*x_26) + 0.0785581188639681*std::sin(0.227279990911484*x_102 - 1.39095985889435) - 0.17651406094334*std::sin(0.23039998114109*x_118 - 4.41991996765137) + 0.197356421188809*std::sin(0.308479934930801*x_120 + 4.75375986099243) - 0.157719750669904*std::sin(0.363359838724136*x_19 - 7.79911994934082) - 0.2567553961927*std::sin(0.255759954452515*x_20 - 1.35999977588654) + 0.0353980243287548*std::sin(0.748719871044159*x_22 + 7.81496000289917) - 0.158360745202205*std::sin(0.323359847068787*x_25 - 1.16343986988068) - 0.118765759354343*std::sin(0.277839958667755*x_55 + 4.72816038131714) - 0.143726916179713*std::sin(0.452639847993851*x_57 - 7.50471973419189) + 1.16310586622723*std::sin(0.106800064444542*x_58 - 7.62919998168945) + 0.167865752626145*std::sin(0.282559931278229*x_94 + 8.19808006286621) + 2.02851379778489) - 0.026919382524012);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.55996930543674e-5*x_1 + 0.00012473920507851*x_10 + 0.00359581242147605*x_100 - 0.00216629586548398*x_101 - 7.80453972504667e-5*x_102 + 9.45493503569731e-5*x_103 + 0.000616583186809408*x_104 + 0.000969585134051178*x_105 + 0.000854326610718966*x_106 + 1.37592274978997e-5*x_107 - 0.00136213234187675*x_108 - 0.000562999079489514*x_109 - 0.000385345283370582*x_11 + 0.000253016375763154*x_110 + 0.000900926975752906*x_111 + 0.00030232699238481*x_112 - 0.000419688468093161*x_113 + 0.00110520073250891*x_114 + 0.000249102545298671*x_115 - 0.00119669496590651*x_116 - 1.71659307755487e-5*x_117 + 0.000787538694743757*x_118 - 0.00139783514260398*x_119 + 0.000227225522732562*x_12 + 0.00147828094427708*x_120 + 0.00110801424663747*x_13 + 0.000103251727750689*x_14 - 0.000941693692340067*x_15 - 0.000168677399013447*x_16 + 0.000578929293685624*x_17 - 3.17376764305461e-5*x_18 + 6.63097978679484e-5*x_19 - 0.000626754271250663*x_2 - 0.000309419933541167*x_20 - 0.000167590394521672*x_21 - 0.00039960610084136*x_22 - 6.03476543464519e-5*x_23 + 5.29908180027678e-5*x_24 + 0.000132449823765348*x_25 - 3.33286001102186e-5*x_26 - 4.3119699788854e-5*x_27 - 0.000142310113507818*x_28 + 0.00071014658206974*x_29 - 5.02240357417591e-5*x_3 + 0.0003794319043724*x_30 - 6.46629926797268e-5*x_31 - 0.000340916972129753*x_32 - 0.00100125178863016*x_33 + 0.000496188417799887*x_34 - 0.000400729908510252*x_35 - 1.299911059082e-5*x_36 + 0.00290192821336988*x_37 - 0.000738345022257132*x_38 - 0.000644467219946306*x_39 + 0.000738329498022671*x_4 - 0.000504666857468851*x_40 - 0.00242011892690965*x_41 - 0.00301836139850401*x_42 + 0.000152387709885325*x_43 - 0.00127013461727516*x_44 + 0.00128148358151727*x_45 - 0.00306090979227529*x_46 + 0.00339911686656051*x_47 + 0.00204097569067594*x_48 - 0.00083851213068831*x_49 - 1.3122313556052e-5*x_5 - 0.00389695845020392*x_50 + 0.0011121279066707*x_51 - 3.08591963836202e-5*x_52 + 0.00131907569267192*x_53 - 0.00143603194618047*x_54 + 0.0026476749052093*x_55 + 0.00292383140110464*x_56 - 0.00379052973035955*x_57 - 0.00197643498364709*x_58 - 0.000611799693401322*x_59 - 9.40987649027013e-5*x_6 + 0.000546087918131107*x_60 - 3.37797444403587e-5*x_61 + 2.95027788270602e-5*x_62 - 3.85260386566121e-5*x_63 + 6.49036563466902e-5*x_64 + 3.26884283649237e-5*x_65 - 1.59491563398763e-5*x_66 - 3.37190502535387e-5*x_67 - 1.97178665064612e-5*x_68 + 4.8113378578557e-5*x_69 - 0.000339316668976808*x_7 + 6.41029654387981e-6*x_70 - 8.26705519897985e-6*x_71 + 5.38243589504411e-6*x_72 + 2.17114620808912e-5*x_73 + 1.46411345156557e-5*x_74 + 3.67092298124548e-5*x_75 + 9.94092915074863e-5*x_76 - 4.47706361002618e-5*x_77 + 0.000244629505612528*x_78 + 1.17705266467991e-5*x_79 - 0.000141428212318316*x_8 + 8.44890261196957e-6*x_80 - 1.10041053658358e-5*x_81 + 0.000107593532928416*x_82 - 4.09391020492073e-5*x_83 + 0.000134847297045596*x_84 + 5.73908949545526e-5*x_85 - 4.71334512193406e-5*x_86 + 3.15121112874307e-5*x_87 - 9.96504655847931e-6*x_88 - 4.34969459406778e-6*x_89 - 4.38196531862435e-5*x_9 - 2.61334931565524e-7*x_90 - 5.95118730831589e-5*x_91 + 0.000251685079917371*x_92 + 0.000509189874158308*x_93 + 0.000121226159898542*x_94 + 0.000308447725757614*x_95 + 0.000599506120579706*x_96 + 0.000356712973473845*x_97 - 0.000196897227498605*x_98 + 0.000429596260797111*x_99 - 4.81804842026521e-8*std::pow(5.50623989105225 - 9.58327960968018*x_6, 2) + 1.61732949752328e-7*std::pow(-7.36751985549927*x_11 - 5.58879995346069, 2) - 1.27141383314199e-7*std::pow(-5.96751976013184*x_12 - 7.36407995223999, 2) - 2.44107842689655e-7*std::pow(-6.45391988754272*x_17 - 1.20223987102509, 2) + 3.53627975305148e-7*std::pow(-7.15599966049194*x_19 - 8.56088066101074, 2) - 1.61228929763268e-7*std::pow(-5.99191999435425*x_26 - 0.821199893951416, 2) + 3.16126304907464e-5*std::pow(-3.90079998970032*x_27 - 7.59823989868164, 2) + 7.51931696998589e-8*std::pow(-8.39199924468994*x_30 - 6.94776010513306, 2) - 2.00417762067851e-7*std::pow(-6.28359985351563*x_32 - 4.66207981109619, 2) - 2.73134794676902e-5*std::pow(-3.47567987442017*x_43 - 8.39967918395996, 2) + 7.43542134802694e-6*std::pow(-2.60359978675842*x_52 - 6.60096025466919, 2) + 9.76132468062616e-7*std::pow(-2.68167996406555*x_58 - 5.57872009277344, 2) + 0.000947202381212264*std::pow(-0.0345496306478628*x_1 + 0.00539800730564003*x_100 + 0.00356696035040525*x_101 - 0.00514136176143075*x_102 + 0.00869124226122737*x_103 + 0.0207853664321966*x_104 + 0.0344277031342101*x_105 + 0.00851652631978702*x_106 - 0.0675148824547506*x_107 - 0.00976332523317022*x_108 + 0.0137438333639005*x_109 + 0.0399586337985724*x_11 + 0.00390064167517763*x_111 - 0.00348612284116024*x_112 - 0.00988060748897477*x_113 + 0.00472043383652842*x_114 + 0.0861248627800165*x_115 - 0.00349915228895747*x_116 - 0.000689821413233171*x_117 - 0.00986133043670054*x_118 + 0.0468169780419114*x_119 + 0.104671954193667*x_120 - 0.0501517709833771*x_13 - 0.00890738095386081*x_15 - 0.0247023335453859*x_16 + 0.0188733434077361*x_18 - 0.00310834498971716*x_2 - 0.0209982394261347*x_20 - 0.000956421846770129*x_22 - 0.006702147643534*x_23 - 0.0166234658741175*x_24 - 0.0326286623612164*x_25 - 0.00174277444648559*x_26 + 0.0478075109662493*x_27 - 0.0637885747046384*x_28 - 0.00585823761288764*x_29 + 0.0139797751206441*x_3 - 0.00394217652424485*x_31 - 0.0100557586977296*x_32 + 0.014412392958451*x_33 + 0.000468805042884618*x_34 + 0.00651757065873202*x_35 + 0.00172700672277218*x_36 + 0.000534895487993328*x_38 + 0.00810594808346625*x_39 + 0.00657333415149157*x_40 + 0.000390873027821722*x_42 + 0.0933396121237238*x_43 - 0.00254136589850587*x_44 + 0.00996975983334438*x_45 + 0.00771770224901578*x_46 + 0.223921204549949*x_47 + 0.196882841952843*x_48 - 0.021422749978257*x_49 + 0.00878673060160456*x_50 + 0.00747290846070736*x_51 + 0.00310416909968494*x_54 + 0.104840374510504*x_57 + 0.0231955024153941*x_58 - 0.013817009296079*x_59 + 0.0231262264234842*x_6 - 0.00444909964008621*x_60 + 0.000725738724552328*x_61 - 0.0116151743602614*x_64 - 0.00437031823280808*x_65 - 0.00176446338457107*x_66 + 0.00138668178609599*x_67 - 0.000913747502687555*x_68 + 0.00145194333525952*x_69 - 0.00194071526596198*x_7 + 0.00249941353736291*x_70 - 0.00116773848899516*x_71 - 0.000233528199201099*x_72 - 0.000397092302554657*x_73 + 0.00239965739966635*x_74 - 0.00190108425723265*x_75 - 0.00124785331192339*x_76 - 0.0109537482369476*x_77 + 0.000315024047077847*x_78 - 0.00170066447408404*x_79 + 0.00106732254516305*x_80 + 0.00272898217890599*x_81 - 0.00540436521760259*x_82 + 0.0178709691883535*x_83 - 0.00443097281217227*x_84 - 0.00153907077868958*x_85 - 0.000263617861905641*x_86 - 7.49541478784582e-6*x_87 - 0.00043442554458885*x_88 - 0.00240441488850785*x_89 - 0.00421042531057147*x_9 - 0.00806744386418834*x_90 - 0.000991201733785442*x_91 - 0.00283250574663944*x_92 + 0.0677623090480378*x_93 - 0.00391468070208976*x_95 + 0.00112777167414374*x_96 + 0.00437053688733777*x_97 + 0.00242723407410355*x_98 + 0.00948334457337234*x_99 - 0.00245205404045735*std::pow(0.586719870567322 - 2.74799990653992*x_8, 2) + 0.00012273197669565*std::pow(5.90783977508545 - 6.72600030899048*x_41, 2) - 0.420158991841888*std::exp(0.208159849047661*x_14) + 0.961283117467168*std::sin(0.184320002794266*x_10 + 1.76455986499786) + 0.34357830556046*std::sin(0.312159925699234*x_110 + 1.51447987556458) + 1.24940375413752*std::sin(0.377759844064713*x_12 - 7.57472038269043) - 2.71419414924318*std::sin(0.129280045628548*x_17 - 1.43207991123199) + 1.54384098267823*std::sin(0.30839991569519*x_19 + 5.02143955230713) + 0.957013447138806*std::sin(0.229599997401237*x_21 - 4.40079975128174) - 0.611141700140781*std::sin(0.286239951848984*x_30 - 4.36639976501465) + 0.78945076152884*std::sin(0.202880010008812*x_37 - 8.00967979431152) + 0.418999074199792*std::sin(0.442959845066071*x_4 + 1.78983998298645) + 0.888221960998607*std::sin(0.168400019407272*x_5 - 4.60983991622925) + 1.11749254822257*std::sin(0.341359823942184*x_52 - 1.33279979228973) + 1.15980021582874*std::sin(0.266879975795746*x_53 - 7.61999988555908) - 0.477086954369522*std::sin(0.233519986271858*x_55 + 7.96848011016846) - 0.50468244875794*std::sin(0.267359972000122*x_56 - 4.42799949645996) + 0.0294651237730092*std::sin(1.41615986824036*x_62 + 3.77920007705688) + 0.0271062676104015*std::sin(1.67223989963531*x_63 - 9.78384017944336) - 0.0423834097324445*std::sin(0.450159847736359*x_94 - 2.01663970947266) - 9.03025946860822, 2) - 0.000140314885982738*std::exp(0.198239862918854*x_13) - 0.00194424687241368*std::exp(0.311599850654602*x_18) - 0.00012076880375829*std::exp(0.619279801845551*x_18) + 0.000467799722062407*std::exp(0.370399862527847*x_19) - 4.89805471994933e-5*std::exp(0.318559855222702*x_26) - 9.33977418175379e-5*std::exp(0.265839844942093*x_27) + 0.000264280504848509*std::exp(0.417679876089096*x_27) + 1.43825603300921e-5*std::exp(0.427119851112366*x_30) + 0.00264824495821982*std::exp(0.188799858093262*x_43) + 7.39227803954325e-5*std::exp(0.285439848899841*x_49) + 0.000548071438684118*std::exp(0.19327986240387*x_56) + 0.000189306318296069*std::exp(0.225839853286743*x_60) - 9.25906904781658e-5*std::exp(0.243999853730202*x_8) - 0.0010147773217077*std::sin(0.143360033631325*x_1 + 4.91999959945679) + 1.27420314059603e-5*std::sin(0.596159815788269*x_10 + 4.99143981933594) - 0.000466689921975815*std::sin(0.249439969658852*x_100 - 7.61488008499146) + 0.00313638180195016*std::sin(0.276079952716827*x_100 + 1.78791987895966) - 6.66104411844808e-5*std::sin(0.227279990911484*x_102 - 1.39095985889435) - 0.0209042184117503*std::sin(0.237599983811378*x_102 + 8.17735958099365) + 0.00355033032115949*std::sin(0.254479974508286*x_102 + 1.77367985248566) - 0.00238772338814791*std::sin(0.291839927434921*x_102 + 1.5759197473526) - 0.000416694226659731*std::sin(0.256239980459213*x_103 + 1.96455979347229) + 0.0188023612169963*std::sin(0.215120002627373*x_104 - 4.39056015014648) + 0.0001428893669917*std::sin(0.31183984875679*x_105 + 4.43111991882324) + 2.8607010782241e-5*std::sin(1.16343986988068*x_106 - 5.78295993804932) + 0.0121489970509192*std::sin(0.259199976921082*x_107 - 7.43327951431274) + 0.000484706289548999*std::sin(0.278879970312119*x_107 + 1.76543986797333) - 0.0206244840279089*std::sin(0.238079980015755*x_109 - 1.21103978157043) - 0.00036181146716845*std::sin(0.239439979195595*x_109 + 8.19032001495361) + 0.000504095595271881*std::sin(0.25927996635437*x_109 - 4.41807985305786) - 0.00397879517529641*std::sin(0.277599930763245*x_109 + 4.95183992385864) + 0.000355196889804079*std::sin(0.386879861354828*x_11 - 2.18583989143372) + 0.000450082827522838*std::sin(0.287199944257736*x_112 + 4.56680011749268) + 0.000186463789779317*std::sin(0.233039990067482*x_113 + 5.00207996368408) + 0.000350749986823378*std::sin(0.286159932613373*x_113 - 1.19527995586395) + 7.37653923017248e-5*std::sin(0.295519918203354*x_114 + 7.73567962646484) + 0.00419229629859141*std::sin(0.253679990768433*x_116 + 5.15799999237061) + 0.00429251446926958*std::sin(0.247519969940186*x_117 - 7.43887996673584) + 0.0153346342262816*std::sin(0.26063996553421*x_117 - 1.22167980670929) + 0.00322664213814056*std::sin(0.29615992307663*x_117 + 4.76168012619019) + 0.000149668546608911*std::sin(0.23039998114109*x_118 - 4.41991996765137) - 0.00311878092214224*std::sin(0.284399926662445*x_118 + 1.75903987884521) + 0.000320071481912039*std::sin(0.22087998688221*x_119 - 4.40064001083374) - 0.000807730244479019*std::sin(0.309679925441742*x_119 + 7.73167991638184) + 0.00455976016357751*std::sin(0.23879998922348*x_12 + 5.00543975830078) - 0.00748151799753305*std::sin(0.266959965229034*x_120 - 1.2157598733902) - 0.000167341052409115*std::sin(0.308479934930801*x_120 + 4.75375986099243) - 0.00121865441320526*std::sin(0.218639984726906*x_13 - 4.38479995727539) - 0.00134113418466246*std::sin(0.456879854202271*x_13 - 4.82416009902954) + 0.000808593500934241*std::sin(0.269839972257614*x_14 - 7.42647981643677) + 0.00788864983732444*std::sin(0.297919929027557*x_14 + 1.96719980239868) - 0.0120484594328639*std::sin(0.352399855852127*x_14 + 8.24512004852295) + 0.00169140991987388*std::sin(0.508959829807281*x_15 + 1.68047988414764) + 0.00191033442179374*std::sin(0.314959913492203*x_16 + 1.78967988491058) + 0.00303011158005055*std::sin(0.398079842329025*x_16 + 1.80543982982635) + 4.1887944255451e-6*std::sin(0.547359883785248*x_16 - 7.54184007644653) - 0.000285880801294494*std::sin(0.447759836912155*x_18 - 1.21223986148834) + 0.000267334398960997*std::sin(0.479279845952988*x_18 - 1.2247998714447) - 0.0128906277494235*std::sin(0.156000033020973*x_19 - 1.41391980648041) - 0.0195400988532035*std::sin(0.338479846715927*x_19 - 4.35743999481201) + 0.000349968695721102*std::sin(0.34895983338356*x_19 - 4.37375974655151) - 0.000393028744106539*std::sin(0.351359844207764*x_19 - 4.35784006118774) + 0.000133732608768554*std::sin(0.363359838724136*x_19 - 7.79911994934082) - 0.000270667250532949*std::sin(0.403119832277298*x_2 + 5.21200037002563) - 0.00157492125402419*std::sin(0.488319844007492*x_2 - 4.37152004241943) + 0.000217706208654345*std::sin(0.255759954452515*x_20 - 1.35999977588654) + 0.000635195804766045*std::sin(0.262479960918427*x_20 + 8.19607925415039) - 0.00462603632278987*std::sin(0.284639924764633*x_20 + 4.99671983718872) + 0.00437062180033413*std::sin(0.355199843645096*x_20 - 7.57775974273682) + 3.68192279115594e-5*std::sin(0.398719847202301*x_20 + 1.37599992752075) - 0.00364732334866167*std::sin(0.275599956512451*x_21 + 8.02600002288818) - 0.00218608017656642*std::sin(0.309199929237366*x_21 - 7.78527975082397) - 0.000264100525294024*std::sin(0.313199937343597*x_22 - 4.34143972396851) - 3.00144409221441e-5*std::sin(0.748719871044159*x_22 + 7.81496000289917) + 0.030552470013045*std::sin(0.188480004668236*x_23 - 7.60056018829346) - 0.000451299475999786*std::sin(0.220399990677834*x_23 - 4.39192008972168) - 0.000272603353709274*std::sin(0.638799846172333*x_23 - 1.57759976387024) - 0.00715802645809266*std::sin(0.319439917802811*x_24 + 5.02647972106934) - 0.00848917924211027*std::sin(0.345359832048416*x_24 - 1.18375980854034) + 0.00036794171810928*std::sin(0.352239847183228*x_24 + 1.8154399394989) + 0.00384165008166208*std::sin(0.411519855260849*x_24 - 1.18431985378265) + 8.4309719957272e-5*std::sin(0.5065598487854*x_24 + 4.93807983398438) + 0.000235095122409303*std::sin(0.261679977178574*x_25 + 2.00943970680237) + 0.00013427611629153*std::sin(0.323359847068787*x_25 - 1.16343986988068) - 0.012606694690319*std::sin(0.291839927434921*x_26 - 1.17271983623505) + 0.000304807692835142*std::sin(0.338559836149216*x_26 - 7.57192039489746) - 0.000890357666724692*std::sin(0.355599850416183*x_26 - 4.35775947570801) + 0.000285491326467751*std::sin(0.408239871263504*x_27 + 1.97231984138489) - 0.00231943075290237*std::sin(0.319119930267334*x_28 - 1.18535983562469) + 0.00102091251574913*std::sin(0.39047983288765*x_28 - 1.36959993839264) + 0.000604250812014492*std::sin(0.475599855184555*x_28 + 4.95831966400146) + 0.0206411700937291*std::sin(0.233119979500771*x_29 + 5.00799989700317) + 0.000397565085168466*std::sin(0.551679849624634*x_29 - 1.37071990966797) + 0.000304524971155373*std::sin(0.301359921693802*x_3 - 4.32032012939453) + 0.0116055619055864*std::sin(0.326879858970642*x_3 + 1.99583983421326) + 0.00320712595217433*std::sin(0.440799862146378*x_3 - 1.1911199092865) - 0.00802577448163198*std::sin(0.325839847326279*x_30 - 1.13759982585907) + 4.43565116409932e-6*std::sin(0.729919850826263*x_31 - 4.79967975616455) + 0.00547865675037231*std::sin(0.321119844913483*x_32 + 2.00159978866577) - 0.0261816778192799*std::sin(0.251759976148605*x_33 + 1.96623980998993) - 0.000230740688553426*std::sin(0.276319950819016*x_33 - 7.61472034454346) - 0.00101358021280851*std::sin(0.239119976758957*x_34 + 7.97983980178833) - 0.00282135931802318*std::sin(0.257119953632355*x_34 - 1.4139199256897) - 0.000592762448700287*std::sin(0.285279929637909*x_34 + 1.77127993106842) + 0.0182352521251639*std::sin(0.248959973454475*x_35 + 1.96167981624603) + 0.000306793330738051*std::sin(0.279199957847595*x_35 - 1.43975985050201) - 0.000501324833480312*std::sin(0.202879995107651*x_36 - 4.39247989654541) + 0.0077056991862811*std::sin(0.186400011181831*x_38 + 5.01095962524414) + 0.00425723378796428*std::sin(0.251359969377518*x_38 + 4.96871948242188) + 0.000517741658408421*std::sin(0.253519982099533*x_38 - 7.62184000015259) - 0.0003981729469751*std::sin(0.239039987325668*x_4 + 5.00807952880859) + 0.00223364725773904*std::sin(0.333759844303131*x_4 + 8.01072025299072) - 0.00226716553298702*std::sin(0.404239863157272*x_4 - 4.41328001022339) - 0.00236685072036501*std::sin(0.427439838647842*x_4 - 1.18679988384247) - 0.000117893783798616*std::sin(0.216559991240501*x_40 - 7.80495977401733) - 0.00611438199074293*std::sin(0.228479996323586*x_40 - 1.21911990642548) - 0.00917644791470196*std::sin(0.27991995215416*x_41 - 1.22039985656738) - 0.0114376633576226*std::sin(0.224399983882904*x_42 - 1.21111989021301) + 0.00732724067934847*std::sin(0.229999989271164*x_42 + 1.96623980998993) + 0.000181720330189467*std::sin(0.328639835119247*x_42 - 1.31815981864929) - 0.000394161143173581*std::sin(0.304079920053482*x_43 + 1.91623985767365) - 0.0376387620886902*std::sin(0.118240058422089*x_44 + 8.16224002838135) - 0.000676774942926125*std::sin(0.257839977741241*x_44 - 7.44911956787109) + 0.000144983589728581*std::sin(0.336479842662811*x_44 - 1.34127986431122) + 9.89496038387185e-5*std::sin(0.342239856719971*x_44 - 1.53007984161377) + 0.0081288438839875*std::sin(0.181120008230209*x_45 + 1.99287974834442) + 0.000563477095953359*std::sin(0.183680012822151*x_45 - 1.18559980392456) - 0.00570564814801168*std::sin(0.198080003261566*x_46 - 4.59815979003906) + 0.00046008344291948*std::sin(0.380719840526581*x_48 - 1.99863982200623) + 0.000347279794741625*std::sin(0.261119961738586*x_49 + 1.94247984886169) - 0.00341356879471436*std::sin(0.328159838914871*x_49 - 7.46968030929565) - 0.0148843175421326*std::sin(0.412159860134125*x_49 + 4.97711944580078) + 0.000328408147882142*std::sin(0.453679859638214*x_49 + 7.36191987991333) + 0.000247841066933199*std::sin(0.311839938163757*x_5 - 7.56879997253418) + 0.000189790663506499*std::sin(0.373759835958481*x_5 - 7.38263988494873) + 0.00454368199077945*std::sin(0.416639864444733*x_5 + 1.96631979942322) - 0.00915017685937628*std::sin(0.451359868049622*x_5 - 1.2176798582077) + 0.00769667627603375*std::sin(0.12352005392313*x_50 + 1.63047981262207) + 0.00496166288282896*std::sin(0.247359976172447*x_52 + 1.96775984764099) + 0.00036926847907757*std::sin(0.202079996466637*x_53 - 1.19311988353729) + 0.00106577782258546*std::sin(0.240319982171059*x_53 - 1.19671988487244) + 0.000100703017620642*std::sin(0.277839958667755*x_55 + 4.72816038131714) - 0.0126641569842529*std::sin(0.195280000567436*x_56 - 1.18679988384247) + 0.0208076889390568*std::sin(0.131920039653778*x_57 - 7.61880016326904) + 0.00033245439982538*std::sin(0.449039846658707*x_57 - 1.30199992656708) + 0.000121867904110503*std::sin(0.452639847993851*x_57 - 7.50471973419189) - 0.000986212450272772*std::sin(0.106800064444542*x_58 - 7.62919998168945) + 0.00529001798374615*std::sin(0.239759981632233*x_58 - 7.61368036270142) + 0.000889484765360269*std::sin(0.548639833927155*x_58 + 1.6451997756958) + 0.0220653124409169*std::sin(0.148400038480759*x_59 - 1.5810399055481) + 0.000349075761480148*std::sin(0.250479966402054*x_59 - 7.6255202293396) - 0.000177774213851709*std::sin(0.448639839887619*x_59 + 1.88055980205536) - 6.83771933558267e-5*std::sin(0.363759845495224*x_6 - 1.77367985248566) + 0.00739309795732114*std::sin(0.197039991617203*x_60 + 5.00575971603394) - 0.000182923252792703*std::sin(0.523919880390167*x_60 + 8.08559989929199) + 7.53835865163416e-5*std::sin(0.801759898662567*x_63 + 8.58879947662354) + 0.0045576786650661*std::sin(0.430479854345322*x_7 - 4.4236798286438) - 0.000106614066304495*std::sin(0.463679850101471*x_7 + 4.96807956695557) - 0.000713220821656885*std::sin(0.172400012612343*x_8 + 7.81128025054932) + 0.000935883851407064*std::sin(0.174160018563271*x_8 + 8.00144004821777) + 1.19952256885103e-5*std::sin(0.703439831733704*x_8 + 4.0403995513916) + 0.000890724386303558*std::sin(0.171280011534691*x_9 - 1.4197598695755) + 3.33383545154615e-5*std::sin(0.263279944658279*x_9 + 4.32567977905273) - 6.07029299221257e-5*std::sin(0.433199852705002*x_9 + 7.36879968643188) - 0.00262369212120423*std::sin(0.318399846553802*x_91 - 1.21383988857269) - 0.000149142440586378*std::sin(0.347679853439331*x_91 - 7.39775943756104) + 0.00267136453221956*std::sin(0.325039833784103*x_92 - 1.18871986865997) + 0.00214884369878791*std::sin(0.27007994055748*x_94 - 4.40319967269897) - 0.000142335534555691*std::sin(0.282559931278229*x_94 + 8.19808006286621) + 0.00730823142851891*std::sin(0.316559940576553*x_94 + 4.78975963592529) + 0.00136453728221927*std::sin(0.346959829330444*x_94 + 4.61783981323242) + 0.0083207950429544*std::sin(0.324079841375351*x_95 - 1.36367988586426) - 0.000298335044438214*std::sin(0.258719980716705*x_96 + 8.19823932647705) + 0.0119364904824528*std::sin(0.260559976100922*x_97 + 1.97991979122162) - 0.000249555872741526*std::sin(0.279599964618683*x_97 - 4.40623998641968) + 0.000202347600838947*std::sin(0.276239961385727*x_98 + 4.97775983810425) - 0.000101468808560879*std::sin(0.313599914312363*x_98 + 4.77895975112915) + 0.0187198897696053);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000134392960736301*x_1 - 4.97647350866115e-5*x_10 - 0.00177057575721664*x_100 + 0.00108158272824532*x_101 + 5.9238558759181e-6*x_102 - 0.000568536782675109*x_103 - 2.88800259245269e-5*x_104 + 0.000801719387479706*x_105 + 0.000295607237897281*x_106 - 3.51777436727753e-6*x_107 + 0.00131750078951404*x_108 - 0.00052462806586763*x_109 - 4.0841605035249e-6*x_11 + 0.000656457532222027*x_110 - 0.000363731345678167*x_111 + 6.1791114855887e-6*x_112 - 0.000272016828851947*x_113 - 0.0021702624000075*x_114 + 0.000131271702170461*x_115 + 0.000467603966493658*x_116 - 0.000608703917433662*x_117 - 0.000217464090621483*x_118 + 0.000593136590068961*x_119 + 0.000405670345816769*x_12 - 0.000677303007669368*x_120 + 0.000167143883525554*x_13 + 3.7339780631666e-5*x_14 + 0.000619028715115971*x_15 + 0.000433747740161436*x_16 + 7.65379458900408e-5*x_17 - 0.000211624496371853*x_18 - 3.73094927997484e-5*x_19 - 0.000366547460119419*x_2 - 0.000284473037389431*x_20 + 8.48830100340741e-5*x_21 + 0.000153994591691987*x_22 - 0.000180879420062541*x_23 - 0.000132813153739064*x_24 + 0.000932676209697517*x_25 - 0.000137207356421767*x_26 + 1.19281406984687e-5*x_27 + 8.4332095513181e-5*x_28 - 2.52440856944632e-5*x_29 - 0.000122358410601442*x_3 + 0.000195596136188536*x_30 + 3.16669045338055e-5*x_31 + 0.000163967256098407*x_32 - 0.00106409079837372*x_33 + 0.000585028490675675*x_34 + 0.000470709325068852*x_35 + 0.000586180089486134*x_36 + 0.000140827340823837*x_37 + 8.60605198567929e-5*x_38 + 0.000338097912569246*x_39 - 0.000343899851496894*x_4 + 0.000152259628533594*x_40 + 0.00161544126152665*x_41 + 0.000423308192080501*x_42 - 0.000181691722121973*x_43 - 0.000990018220815454*x_44 - 0.000703923054840988*x_45 + 6.48593976742337e-5*x_46 - 0.00294364819942666*x_47 - 0.0004586389426315*x_48 - 2.61832157815435e-5*x_49 + 2.48841319437157e-6*x_5 + 0.000120478512583248*x_50 - 0.000693846620092154*x_51 + 9.2853902475796e-6*x_52 - 0.000703700703670434*x_53 + 0.00163002723703757*x_54 - 0.000673640735021862*x_55 - 0.00141909598083654*x_56 + 0.000694120926735241*x_57 + 0.00133866988373967*x_58 - 8.41914312148392e-5*x_59 - 6.78035459782353e-5*x_6 + 0.000388251948938933*x_60 + 1.68215475794516e-5*x_61 + 1.52830203050443e-5*x_62 + 1.80897469767151e-5*x_63 + 2.50990746907427e-5*x_64 - 2.68990316264639e-5*x_65 - 1.35008204297522e-5*x_66 + 4.64205713760723e-5*x_67 + 1.1014993111276e-5*x_68 + 2.60539117980325e-5*x_69 + 9.55826537473255e-5*x_7 + 4.07392284046933e-5*x_70 + 1.08883801518255e-5*x_71 - 3.75575308348573e-6*x_72 + 1.20810682143844e-6*x_73 + 2.25944613576755e-5*x_74 + 3.05877068165601e-5*x_75 - 2.17998064563047e-5*x_76 + 3.80232265162108e-5*x_77 - 0.000114645803009735*x_78 - 1.35482633314561e-5*x_79 + 0.00027174294597638*x_8 + 1.25409633858697e-5*x_80 + 4.94104183797922e-6*x_81 - 4.77572312644634e-5*x_82 + 7.49599168759277e-5*x_83 - 5.96515321171374e-5*x_84 - 8.34339283591284e-6*x_85 + 7.42718720399271e-5*x_86 + 2.10479437564138e-5*x_87 - 1.22015005645747e-5*x_88 + 1.76984143192054e-5*x_89 - 5.52904745138763e-5*x_9 + 4.21670892963047e-5*x_90 - 2.46086198231202e-5*x_91 + 0.000233163318390087*x_92 - 0.000249621352007451*x_93 - 6.64706017412302e-5*x_94 + 0.000139557259835401*x_95 - 0.000332392361323866*x_96 - 6.91178071600748e-5*x_97 + 0.00104309372826067*x_98 - 0.000333299452765308*x_99 + 4.36843854494232e-7*std::pow(5.50623989105225 - 9.58327960968018*x_6, 2) + 2.86709427748872e-8*std::pow(-7.36751985549927*x_11 - 5.58879995346069, 2) + 6.93618044107839e-7*std::pow(-5.96751976013184*x_12 - 7.36407995223999, 2) - 2.21533706799047e-7*std::pow(-6.45391988754272*x_17 - 1.20223987102509, 2) - 6.55126056193826e-7*std::pow(-7.15599966049194*x_19 - 8.56088066101074, 2) + 2.51236543534919e-7*std::pow(-5.99191999435425*x_26 - 0.821199893951416, 2) - 1.5239623363386e-5*std::pow(-3.90079998970032*x_27 - 7.59823989868164, 2) - 4.10215288979479e-7*std::pow(-8.39199924468994*x_30 - 6.94776010513306, 2) + 2.70696765367807e-9*std::pow(-6.28359985351563*x_32 - 4.66207981109619, 2) + 1.3167114959099e-5*std::pow(-3.47567987442017*x_43 - 8.39967918395996, 2) - 1.00427451503835e-7*std::pow(-2.60359978675842*x_52 - 6.60096025466919, 2) - 1.52106788569735e-6*std::pow(-2.68167996406555*x_58 - 5.57872009277344, 2) + 0.00127221003794404*std::exp(0.198239862918854*x_13) - 0.00176445054707171*std::exp(0.311599850654602*x_18) + 5.82194855268926e-5*std::exp(0.619279801845551*x_18) + 0.000424539438496464*std::exp(0.370399862527847*x_19) + 0.000267212692376377*std::exp(0.318559855222702*x_26) + 0.000145537937035608*std::exp(0.265839844942093*x_27) + 0.000239840880279489*std::exp(0.417679876089096*x_27) - 2.24117641283134e-5*std::exp(0.427119851112366*x_30) + 0.00240334565101291*std::exp(0.188799858093262*x_43) - 0.000136948270400701*std::exp(0.285439848899841*x_49) + 9.71584632514641e-5*std::exp(0.19327986240387*x_56) - 0.00171640661427837*std::exp(0.225839853286743*x_60) + 1.25058778009536e-6*std::exp(0.243999853730202*x_8) + 0.0015812866036995*std::sin(0.143360033631325*x_1 + 4.91999959945679) + 2.25882266931724e-6*std::sin(0.596159815788269*x_10 + 4.99143981933594) + 0.000727224097263076*std::sin(0.249439969658852*x_100 - 7.61488008499146) - 4.23619343907719e-5*std::sin(0.276079952716827*x_100 + 1.78791987895966) + 0.000363392333221373*std::sin(0.227279990911484*x_102 - 1.39095985889435) + 0.0100773776289919*std::sin(0.237599983811378*x_102 + 8.17735958099365) - 4.7952982011632e-5*std::sin(0.254479974508286*x_102 + 1.77367985248566) - 0.00216691609396458*std::sin(0.291839927434921*x_102 + 1.5759197473526) + 0.000649317820137248*std::sin(0.256239980459213*x_103 + 1.96455979347229) - 0.00906412718085054*std::sin(0.215120002627373*x_104 - 4.39056015014648) - 0.000264714768079441*std::sin(0.31183984875679*x_105 + 4.43111991882324) + 5.07126080587922e-6*std::sin(1.16343986988068*x_106 - 5.78295993804932) - 0.00585671411789321*std::sin(0.259199976921082*x_107 - 7.43327951431274) - 0.0007552982767716*std::sin(0.278879970312119*x_107 + 1.76543986797333) + 0.00994252498986143*std::sin(0.238079980015755*x_109 - 1.21103978157043) + 0.000563796227861635*std::sin(0.239439979195595*x_109 + 8.19032001495361) - 0.00457054482777513*std::sin(0.25927996635437*x_109 - 4.41807985305786) + 5.37400963318382e-5*std::sin(0.277599930763245*x_109 + 4.95183992385864) - 0.000208000569759578*std::sin(0.386879861354828*x_11 - 2.18583989143372) + 7.97876933032379e-5*std::sin(0.287199944257736*x_112 + 4.56680011749268) - 0.000109191762729176*std::sin(0.233039990067482*x_113 + 5.00207996368408) - 0.000546559568830555*std::sin(0.286159932613373*x_113 - 1.19527995586395) - 0.000114945637991854*std::sin(0.295519918203354*x_114 + 7.73567962646484) - 5.66237760457542e-5*std::sin(0.253679990768433*x_116 + 5.15799999237061) + 0.00389555956657568*std::sin(0.247519969940186*x_117 - 7.43887996673584) - 0.00739242658380567*std::sin(0.26063996553421*x_117 - 1.22167980670929) - 4.35810469482447e-5*std::sin(0.29615992307663*x_117 + 4.76168012619019) - 0.000816514669395941*std::sin(0.23039998114109*x_118 - 4.41991996765137) - 0.00283036829445383*std::sin(0.284399926662445*x_118 + 1.75903987884521) - 0.00290203102326728*std::sin(0.22087998688221*x_119 - 4.40064001083374) - 0.000733034519421941*std::sin(0.309679925441742*x_119 + 7.73167991638184) - 6.15869728510162e-5*std::sin(0.23879998922348*x_12 + 5.00543975830078) - 0.00678965655595268*std::sin(0.266959965229034*x_120 - 1.2157598733902) + 0.000912926778404769*std::sin(0.308479934930801*x_120 + 4.75375986099243) - 0.00021603495760683*std::sin(0.218639984726906*x_13 - 4.38479995727539) + 0.0007853578748612*std::sin(0.456879854202271*x_13 - 4.82416009902954) + 0.000143342083532967*std::sin(0.269839972257614*x_14 - 7.42647981643677) + 0.00715913843998854*std::sin(0.297919929027557*x_14 + 1.96719980239868) + 0.00580824755850761*std::sin(0.352399855852127*x_14 + 8.24512004852295) - 2.28452403368257e-5*std::sin(0.508959829807281*x_15 + 1.68047988414764) + 0.00173367418687903*std::sin(0.314959913492203*x_16 + 1.78967988491058) - 4.09265823028962e-5*std::sin(0.398079842329025*x_16 + 1.80543982982635) - 7.7600997767387e-6*std::sin(0.547359883785248*x_16 - 7.54184007644653) + 0.00044547653132524*std::sin(0.447759836912155*x_18 - 1.21223986148834) - 0.000495259828708791*std::sin(0.479279845952988*x_18 - 1.2247998714447) + 0.000174108881334983*std::sin(0.156000033020973*x_19 - 1.41391980648041) + 0.00941977122382518*std::sin(0.338479846715927*x_19 - 4.35743999481201) - 0.000545342114392827*std::sin(0.34895983338356*x_19 - 4.37375974655151) + 0.00356352150344468*std::sin(0.351359844207764*x_19 - 4.35784006118774) - 0.000729576382681404*std::sin(0.363359838724136*x_19 - 7.79911994934082) + 0.000421769868297484*std::sin(0.403119832277298*x_2 + 5.21200037002563) + 0.000759228395920606*std::sin(0.488319844007492*x_2 - 4.37152004241943) - 0.00118769318612641*std::sin(0.255759954452515*x_20 - 1.35999977588654) - 0.000989800023430158*std::sin(0.262479960918427*x_20 + 8.19607925415039) + 0.00223009126827636*std::sin(0.284639924764633*x_20 + 4.99671983718872) - 5.9032351813006e-5*std::sin(0.355199843645096*x_20 - 7.57775974273682) - 0.000333833370638933*std::sin(0.398719847202301*x_20 + 1.37599992752075) + 0.00213584453128938*std::sin(0.275599956512451*x_21 + 8.02600002288818) - 0.0019839200557369*std::sin(0.309199929237366*x_21 - 7.78527975082397) + 0.000411537205004405*std::sin(0.313199937343597*x_22 - 4.34143972396851) + 0.000163743363999429*std::sin(0.748719871044159*x_22 + 7.81496000289917) - 0.0147285476909693*std::sin(0.188480004668236*x_23 - 7.60056018829346) + 0.000703241785551674*std::sin(0.220399990677834*x_23 - 4.39192008972168) + 3.68195140571094e-6*std::sin(0.638799846172333*x_23 - 1.57759976387024) - 0.00649608024533218*std::sin(0.319439917802811*x_24 + 5.02647972106934) + 0.00409241155530871*std::sin(0.345359832048416*x_24 - 1.18375980854034) - 0.000573348750846418*std::sin(0.352239847183228*x_24 + 1.8154399394989) - 5.1887728914408e-5*std::sin(0.411519855260849*x_24 - 1.18431985378265) - 0.000764421189346134*std::sin(0.5065598487854*x_24 + 4.93807983398438) - 0.000366339254640937*std::sin(0.261679977178574*x_25 + 2.00943970680237) - 0.000732541480395598*std::sin(0.323359847068787*x_25 - 1.16343986988068) + 0.00607735819370984*std::sin(0.291839927434921*x_26 - 1.17271983623505) - 0.000564682309232786*std::sin(0.338559836149216*x_26 - 7.57192039489746) + 1.20257275560839e-5*std::sin(0.355599850416183*x_26 - 4.35775947570801) - 0.00258849892322125*std::sin(0.408239871263504*x_27 + 1.97231984138489) + 3.13276825280948e-5*std::sin(0.319119930267334*x_28 - 1.18535983562469) + 0.000926502530354921*std::sin(0.39047983288765*x_28 - 1.36959993839264) + 0.000107117569298505*std::sin(0.475599855184555*x_28 + 4.95831966400146) - 0.0099505689063141*std::sin(0.233119979500771*x_29 + 5.00799989700317) - 0.00023281105945823*std::sin(0.551679849624634*x_29 - 1.37071990966797) - 0.000474528989837511*std::sin(0.301359921693802*x_3 - 4.32032012939453) - 0.0055947382301314*std::sin(0.326879858970642*x_3 + 1.99583983421326) - 4.33174491334169e-5*std::sin(0.440799862146378*x_3 - 1.1911199092865) + 0.00386901622550354*std::sin(0.325839847326279*x_30 - 1.13759982585907) - 6.91189644706577e-6*std::sin(0.729919850826263*x_31 - 4.79967975616455) + 0.00497201206162246*std::sin(0.321119844913483*x_32 + 2.00159978866577) + 0.0126215029497193*std::sin(0.251759976148605*x_33 + 1.96623980998993) + 0.000359553915852123*std::sin(0.276319950819016*x_33 - 7.61472034454346) - 0.000179680765877904*std::sin(0.239119976758957*x_34 + 7.97983980178833) + 0.00165216634067097*std::sin(0.257119953632355*x_34 - 1.4139199256897) + 0.00537447136895771*std::sin(0.285279929637909*x_34 + 1.77127993106842) - 0.0087907387019004*std::sin(0.248959973454475*x_35 + 1.96167981624603) + 5.43862833317371e-5*std::sin(0.279199957847595*x_35 - 1.43975985050201) + 0.000781194284032932*std::sin(0.202879995107651*x_36 - 4.39247989654541) - 0.00371471628673382*std::sin(0.186400011181831*x_38 + 5.01095962524414) - 0.00249300339871986*std::sin(0.251359969377518*x_38 + 4.96871948242188) - 0.00469427124767087*std::sin(0.253519982099533*x_38 - 7.62184000015259) + 0.000737649424397993*std::sin(0.239039987325668*x_4 + 5.00807952880859) + 0.00202708831980279*std::sin(0.333759844303131*x_4 + 8.01072025299072) + 0.00132763471791853*std::sin(0.404239863157272*x_4 - 4.41328001022339) + 3.19681662693331e-5*std::sin(0.427439838647842*x_4 - 1.18679988384247) + 0.000183709132035466*std::sin(0.216559991240501*x_40 - 7.80495977401733) - 0.00554894792510501*std::sin(0.228479996323586*x_40 - 1.21911990642548) - 0.00832784600196897*std::sin(0.27991995215416*x_41 - 1.22039985656738) - 0.0103799531093113*std::sin(0.224399983882904*x_42 - 1.21111989021301) - 9.89662957268002e-5*std::sin(0.229999989271164*x_42 + 1.96623980998993) - 0.000283167466991566*std::sin(0.328639835119247*x_42 - 1.31815981864929) + 0.00357378876375679*std::sin(0.304079920053482*x_43 + 1.91623985767365) + 0.0181446639900351*std::sin(0.118240058422089*x_44 + 8.16224002838135) + 0.00105459111873692*std::sin(0.257839977741241*x_44 - 7.44911956787109) - 0.00131454034187472*std::sin(0.336479842662811*x_44 - 1.34127986431122) - 5.79441277970942e-5*std::sin(0.342239856719971*x_44 - 1.53007984161377) - 0.000109793250002978*std::sin(0.181120008230209*x_45 + 1.99287974834442) - 0.000878043649835525*std::sin(0.183680012822151*x_45 - 1.18559980392456) + 0.00334118372007344*std::sin(0.198080003261566*x_46 - 4.59815979003906) - 6.21417475739619e-6*std::sin(0.380719840526581*x_48 - 1.99863982200623) - 0.000541152108362375*std::sin(0.261119961738586*x_49 + 1.94247984886169) - 0.00309789534074104*std::sin(0.328159838914871*x_49 - 7.46968030929565) + 0.00717534067370753*std::sin(0.412159860134125*x_49 + 4.97711944580078) - 0.000192313288302866*std::sin(0.453679859638214*x_49 + 7.36191987991333) - 0.000386200746315994*std::sin(0.311839938163757*x_5 - 7.56879997253418) - 0.00172079808589041*std::sin(0.373759835958481*x_5 - 7.38263988494873) + 0.004123500100786*std::sin(0.416639864444733*x_5 + 1.96631979942322) + 0.00441106123978145*std::sin(0.451359868049622*x_5 - 1.2176798582077) - 0.000103956123973689*std::sin(0.12352005392313*x_50 + 1.63047981262207) + 0.00450282775927759*std::sin(0.247359976172447*x_52 + 1.96775984764099) - 0.00057541618899328*std::sin(0.202079996466637*x_53 - 1.19311988353729) + 0.000188934011337116*std::sin(0.240319982171059*x_53 - 1.19671988487244) - 0.000549383908661515*std::sin(0.277839958667755*x_55 + 4.72816038131714) - 0.011493025415711*std::sin(0.195280000567436*x_56 - 1.18679988384247) - 0.000281041661800178*std::sin(0.131920039653778*x_57 - 7.61880016326904) - 0.00301430473077917*std::sin(0.449039846658707*x_57 - 1.30199992656708) - 0.000664848651833161*std::sin(0.452639847993851*x_57 - 7.50471973419189) + 0.00538026827301795*std::sin(0.106800064444542*x_58 - 7.62919998168945) - 7.14502917387539e-5*std::sin(0.239759981632233*x_58 - 7.61368036270142) + 0.000807228702856797*std::sin(0.548639833927155*x_58 + 1.6451997756958) - 0.0106371107299483*std::sin(0.148400038480759*x_59 - 1.5810399055481) - 0.000543950690951447*std::sin(0.250479966402054*x_59 - 7.6255202293396) + 0.00161184708069803*std::sin(0.448639839887619*x_59 + 1.88055980205536) + 0.000106549424725205*std::sin(0.363759845495224*x_6 - 1.77367985248566) - 9.98558053161297e-5*std::sin(0.197039991617203*x_60 + 5.00575971603394) + 0.000285041932804996*std::sin(0.523919880390167*x_60 + 8.08559989929199) - 3.63404578630857e-5*std::sin(0.801759898662567*x_63 + 8.58879947662354) + 0.00413620241753018*std::sin(0.430479854345322*x_7 - 4.4236798286438) + 0.000166132402850238*std::sin(0.463679850101471*x_7 + 4.96807956695557) + 0.0013213025459431*std::sin(0.172400012612343*x_8 + 7.81128025054932) + 0.000849336983405172*std::sin(0.174160018563271*x_8 + 8.00144004821777) - 1.86916767687257e-5*std::sin(0.703439831733704*x_8 + 4.0403995513916) - 0.00807603909849119*std::sin(0.171280011534691*x_9 - 1.4197598695755) - 5.19498142666113e-5*std::sin(0.263279944658279*x_9 + 4.32567977905273) - 1.07610121050191e-5*std::sin(0.433199852705002*x_9 + 7.36879968643188) - 0.00238106336406725*std::sin(0.318399846553802*x_91 - 1.21383988857269) + 0.000232402654550276*std::sin(0.347679853439331*x_91 - 7.39775943756104) - 3.60811202824082e-5*std::sin(0.325039833784103*x_92 - 1.18871986865997) + 0.0019501270613803*std::sin(0.27007994055748*x_94 - 4.40319967269897) + 0.000776509524374009*std::sin(0.282559931278229*x_94 + 8.19808006286621) - 0.00352310746350861*std::sin(0.316559940576553*x_94 + 4.78975963592529) - 1.84302940372861e-5*std::sin(0.346959829330444*x_94 + 4.61783981323242) - 0.00401123793148667*std::sin(0.324079841375351*x_95 - 1.36367988586426) + 0.000464883476495477*std::sin(0.258719980716705*x_96 + 8.19823932647705) - 0.00575427025240654*std::sin(0.260559976100922*x_97 + 1.97991979122162) + 0.000388872859098424*std::sin(0.279599964618683*x_97 - 4.40623998641968) - 0.000315310111541423*std::sin(0.276239961385727*x_98 + 4.97775983810425) + 0.000919999584400848*std::sin(0.313599914312363*x_98 + 4.77895975112915) + 0.100855648517609*std::sin(-0.00720765338453345*x_1 + 0.00112611813488777*x_100 + 0.000744129918612759*x_101 - 0.00107257741417214*x_102 + 0.0018131441791205*x_103 + 0.00433618866264369*x_104 + 0.00718221718623068*x_105 + 0.00177669539738128*x_106 - 0.0140847778082242*x_107 - 0.00203679931859165*x_108 + 0.00286720249114759*x_109 + 0.00833606544379742*x_11 + 0.000813741641943873*x_111 - 0.000727265809324717*x_112 - 0.00206126643537826*x_113 + 0.000984764533812025*x_114 + 0.0179671431233452*x_115 - 0.000729983978571488*x_116 - 0.00014390873507417*x_117 - 0.00205724490726167*x_118 + 0.0097668352428041*x_119 + 0.0218363887185688*x_120 - 0.0104625310051193*x_13 - 0.00185823446663662*x_15 - 0.00515333607467346*x_16 + 0.00393730743106066*x_18 - 0.000648454784185034*x_2 - 0.00438059766865802*x_20 - 0.000199526218707663*x_22 - 0.00139818447377668*x_23 - 0.00346794387735868*x_24 - 0.00680690601580043*x_25 - 0.000363573036878972*x_26 + 0.00997347762510225*x_27 - 0.0133074052527648*x_28 - 0.00122213017523366*x_29 + 0.00291642404199073*x_3 - 0.000822406533285453*x_31 - 0.00209780602144371*x_32 + 0.00300667564133948*x_33 + 9.78008792184494e-5*x_34 + 0.00135967850701905*x_35 + 0.000360283615688115*x_36 + 0.000111588494641267*x_38 + 0.00169104164192453*x_39 + 0.00137131174071172*x_40 + 8.15429065108209e-5*x_42 + 0.0194722652201845*x_43 - 0.000530173092337727*x_44 + 0.00207986516377521*x_45 + 0.00161004681360844*x_46 + 0.0467138547526871*x_47 + 0.0410731824204249*x_48 - 0.00446915794731802*x_49 + 0.00183306470639669*x_50 + 0.00155897857514311*x_51 + 0.000647583620952322*x_54 + 0.0218715241236054*x_57 + 0.00483898491402862*x_58 - 0.00288246826231049*x_59 + 0.00482453273818208*x_6 - 0.000928159504969342*x_60 + 0.000151401710415395*x_61 - 0.00242312722943285*x_64 - 0.000911724334284192*x_65 - 0.000368097726291487*x_66 + 0.000289285919455811*x_67 - 0.000190623608902816*x_68 + 0.000302900612779241*x_69 - 0.000404866931797197*x_7 + 0.000521421100721287*x_70 - 0.000243610542707106*x_71 - 4.87180407950302e-5*x_72 - 8.28403553036913e-5*x_73 + 0.000500610236755043*x_74 - 0.000396599214636576*x_75 - 0.000260323887070042*x_76 - 0.00228514224531215*x_77 + 6.57194909627935e-5*x_78 - 0.000354788164814893*x_79 + 0.000222662031714345*x_80 + 0.000569313108976461*x_81 - 0.00112744450581609*x_82 + 0.00372819474882858*x_83 - 0.000924377933643837*x_84 - 0.00032107691164984*x_85 - 5.49952673576613e-5*x_86 - 1.56367378611733e-6*x_87 - 9.06287183992603e-5*x_88 - 0.000501602731606865*x_89 - 0.000878367891957277*x_9 - 0.00168300899262573*x_90 - 0.000206781907572028*x_91 - 0.000590909924321842*x_92 + 0.0141363952955631*x_93 - 0.000816670426939294*x_95 + 0.000235272770553507*x_96 + 0.000911769949419041*x_97 + 0.000506363210292367*x_98 + 0.00197839048722775*x_99 - 0.000511541086615195*std::pow(0.586719870567322 - 2.74799990653992*x_8, 2) + 2.56040232741418e-5*std::pow(5.90783977508545 - 6.72600030899048*x_41, 2) - 0.0876524675605666*std::exp(0.208159849047661*x_14) + 0.200540364258154*std::sin(0.184320002794266*x_10 + 1.76455986499786) + 0.0716764055212353*std::sin(0.312159925699234*x_110 + 1.51447987556458) + 0.260647336260748*std::sin(0.377759844064713*x_12 - 7.57472038269043) - 0.566228068990476*std::sin(0.129280045628548*x_17 - 1.43207991123199) + 0.322072059102332*std::sin(0.30839991569519*x_19 + 5.02143955230713) + 0.199649636825878*std::sin(0.229599997401237*x_21 - 4.40079975128174) - 0.127494779563489*std::sin(0.286239951848984*x_30 - 4.36639976501465) + 0.164693148567938*std::sin(0.202880010008812*x_37 - 8.00967979431152) + 0.0874104885824396*std::sin(0.442959845066071*x_4 + 1.78983998298645) + 0.185298537303019*std::sin(0.168400019407272*x_5 - 4.60983991622925) + 0.233128366247399*std::sin(0.341359823942184*x_52 - 1.33279979228973) + 0.241954480966868*std::sin(0.266879975795746*x_53 - 7.61999988555908) - 0.0995286298839479*std::sin(0.233519986271858*x_55 + 7.96848011016846) - 0.105285529590164*std::sin(0.267359972000122*x_56 - 4.42799949645996) + 0.00614693688777146*std::sin(1.41615986824036*x_62 + 3.77920007705688) + 0.00565483849814369*std::sin(1.67223989963531*x_63 - 9.78384017944336) - 0.00884191584331795*std::sin(0.450159847736359*x_94 - 2.01663970947266) + 8.89299289700712) - 0.141493122870052);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-4.09751850156679e-5*x_1 + 0.000111227316902602*x_10 + 0.00116926566331669*x_100 - 0.000694527952948116*x_101 - 6.36436002724371e-5*x_102 - 0.000366282198731389*x_103 - 9.84289617005339e-5*x_104 + 0.000947889849521557*x_105 + 0.000133949136395992*x_106 + 1.60031767349182e-5*x_107 - 0.000132700047779693*x_108 - 0.000576561592553816*x_109 + 0.000104485737064199*x_11 + 0.000727928949300135*x_110 + 1.19857511254076e-5*x_111 - 6.7456099713548e-5*x_112 - 0.000330084066862864*x_113 - 0.000342836510438548*x_114 - 0.000449371072760087*x_115 - 0.000483479460886279*x_116 - 0.000223825858165441*x_117 + 0.000814831302214632*x_118 - 0.000640003213550982*x_119 + 0.000318526112655127*x_12 + 0.000284361892019383*x_120 + 0.00071676998776079*x_13 + 8.92079566554594e-5*x_14 - 0.00013288647496968*x_15 + 0.000100897534975859*x_16 + 7.20120503403095e-6*x_17 - 0.000124326886392043*x_18 - 2.18174641960759e-5*x_19 - 0.000398120080409345*x_2 - 0.00031100422002578*x_20 - 0.000124238011723212*x_21 - 7.7929422190817e-5*x_22 - 0.000195152448961794*x_23 + 1.92520147517517e-5*x_24 + 0.00071683059708577*x_25 - 0.000107689308025175*x_26 + 4.55643357305634e-5*x_27 - 6.29653561748303e-5*x_28 + 1.85621749252308e-5*x_29 - 0.000116257298030019*x_3 + 0.00021953306291009*x_30 - 5.87073336395613e-6*x_31 - 0.000138195433849954*x_32 - 0.00120198517375502*x_33 + 0.000549411539879555*x_34 + 0.000453624746521088*x_35 + 3.44910378249112e-5*x_36 + 0.000602310358462519*x_37 + 0.000137176804820995*x_38 - 0.000660346125516584*x_39 + 0.000248743337850162*x_4 + 2.54003523400708e-5*x_40 - 0.000308442990564197*x_41 - 0.00184508379579655*x_42 - 2.62394801638741e-5*x_43 - 0.00101459715836705*x_44 + 0.000584383219509871*x_45 - 0.00182386491355541*x_46 + 0.000127307301547904*x_47 + 0.0011427372999118*x_48 - 5.6450025730081e-5*x_49 + 4.38790631556555e-7*x_5 - 0.00197569003211016*x_50 + 0.000239273723258802*x_51 + 3.38869932124145e-6*x_52 + 0.000282695838140444*x_53 - 0.000914499105042604*x_54 + 0.00208310752955684*x_55 + 0.000721225881791517*x_56 - 0.00172919454040976*x_57 - 0.000550416064183228*x_58 - 5.63639943233157e-5*x_59 - 0.000128038895438278*x_6 + 0.000497757925700198*x_60 - 2.47680793881294e-5*x_61 + 2.34471578245224e-5*x_62 + 7.22524778555755e-6*x_63 + 4.27293825503311e-5*x_64 - 1.09710498079589e-5*x_65 - 2.79697232838591e-5*x_66 + 1.60491697104795e-6*x_67 + 4.54150377671695e-6*x_68 + 2.03196257837765e-5*x_69 - 5.15382999386596e-5*x_7 + 3.49555038155308e-5*x_70 - 1.10832588268047e-5*x_71 + 1.49510156077065e-5*x_72 + 2.20895160559699e-5*x_73 + 1.05706511394861e-5*x_74 + 2.46624978178721e-5*x_75 + 2.85432325039033e-5*x_76 - 2.51283469479569e-5*x_77 + 7.23802710877592e-5*x_78 - 1.29206279003809e-5*x_79 + 0.000362871952053747*x_8 + 7.26414337919835e-6*x_80 + 6.04358820309008e-6*x_81 + 2.90516772425966e-5*x_82 + 1.18883676242025e-5*x_83 + 2.21824742867398e-5*x_84 + 8.13099803611586e-6*x_85 + 3.92762722898499e-5*x_86 + 1.60415047628133e-5*x_87 + 1.46146569463982e-5*x_88 + 1.38963123656343e-6*x_89 + 4.61411752956632e-5*x_9 + 2.29747746161646e-5*x_90 - 6.93486801412284e-6*x_91 + 0.000252874858588578*x_92 + 0.000475880772201045*x_93 - 2.79848304714451e-5*x_94 + 0.00015813293262521*x_95 + 0.000183127238227077*x_96 - 1.39754483380139e-5*x_97 + 0.000357224005331264*x_98 - 6.36217006135542e-5*x_99 - 1.14164531512138e-6*std::pow(0.586719870567322 - 2.74799990653992*x_8, 2) + 2.0618503763125e-7*std::pow(5.50623989105225 - 9.58327960968018*x_6, 2) + 5.71424544069348e-8*std::pow(5.90783977508545 - 6.72600030899048*x_41, 2) - 1.44171411619819e-7*std::pow(-7.36751985549927*x_11 - 5.58879995346069, 2) + 1.22746376252236e-6*std::pow(-5.96751976013184*x_12 - 7.36407995223999, 2) - 2.31816059262842e-7*std::pow(-6.45391988754272*x_17 - 1.20223987102509, 2) + 2.47394698153878e-7*std::pow(-7.15599966049194*x_19 - 8.56088066101074, 2) + 1.9828806906373e-7*std::pow(-5.99191999435425*x_26 - 0.821199893951416, 2) + 1.06494105309017e-5*std::pow(-3.90079998970032*x_27 - 7.59823989868164, 2) - 7.25939018357865e-7*std::pow(-8.39199924468994*x_30 - 6.94776010513306, 2) - 5.14389851155844e-9*std::pow(-6.28359985351563*x_32 - 4.66207981109619, 2) - 9.2011468632429e-6*std::pow(-3.47567987442017*x_43 - 8.39967918395996, 2) + 1.90836642472722e-7*std::pow(-2.60359978675842*x_52 - 6.60096025466919, 2) - 1.20050057100017e-6*std::pow(-2.68167996406555*x_58 - 5.57872009277344, 2) + 0.000600467814414014*std::exp(0.198239862918854*x_13) - 0.000195620706855606*std::exp(0.208159849047661*x_14) - 0.00184634644766432*std::exp(0.311599850654602*x_18) - 4.06836302636824e-5*std::exp(0.619279801845551*x_18) + 0.00044424417871174*std::exp(0.370399862527847*x_19) + 0.000472873939143145*std::exp(0.318559855222702*x_26) + 0.000114865600777136*std::exp(0.265839844942093*x_27) + 0.000250972949082444*std::exp(0.417679876089096*x_27) - 1.76884515715262e-5*std::exp(0.427119851112366*x_30) + 0.00251489547985435*std::exp(0.188799858093262*x_43) + 5.17156594492913e-5*std::exp(0.285439848899841*x_49) - 0.000488559895213666*std::exp(0.19327986240387*x_56) - 0.000810123248191844*std::exp(0.225839853286743*x_60) - 2.37642168049737e-6*std::exp(0.243999853730202*x_8) + 0.00124802810479813*std::sin(0.143360033631325*x_1 + 4.91999959945679) + 0.000447561248428673*std::sin(0.184320002794266*x_10 + 1.76455986499786) - 1.13584563783357e-5*std::sin(0.596159815788269*x_10 + 4.99143981933594) + 0.000573960539314886*std::sin(0.249439969658852*x_100 - 7.61488008499146) + 8.04980033519611e-5*std::sin(0.276079952716827*x_100 + 1.78791987895966) + 0.000643078599809805*std::sin(0.227279990911484*x_102 - 1.39095985889435) - 0.0070420461770661*std::sin(0.237599983811378*x_102 + 8.17735958099365) + 9.1122356951428e-5*std::sin(0.254479974508286*x_102 + 1.77367985248566) - 0.00226749218849914*std::sin(0.291839927434921*x_102 + 1.5759197473526) + 0.000512473125732963*std::sin(0.256239980459213*x_103 + 1.96455979347229) + 0.0063339893087578*std::sin(0.215120002627373*x_104 - 4.39056015014648) + 9.99640138363104e-5*std::sin(0.31183984875679*x_105 + 4.43111991882324) - 2.55007599441852e-5*std::sin(1.16343986988068*x_106 - 5.78295993804932) + 0.00409265711601649*std::sin(0.259199976921082*x_107 - 7.43327951431274) - 0.000596118043820277*std::sin(0.278879970312119*x_107 + 1.76543986797333) - 0.00694781149153405*std::sin(0.238079980015755*x_109 - 1.21103978157043) + 0.000444975335972812*std::sin(0.239439979195595*x_109 + 8.19032001495361) - 0.00215724210748299*std::sin(0.25927996635437*x_109 - 4.41807985305786) - 0.0001021192850815*std::sin(0.277599930763245*x_109 + 4.95183992385864) - 0.000110675389175946*std::sin(0.386879861354828*x_11 - 2.18583989143372) + 0.000159965708931635*std::sin(0.312159925699234*x_110 + 1.51447987556458) - 0.000401211235491445*std::sin(0.287199944257736*x_112 + 4.56680011749268) - 5.81000371721462e-5*std::sin(0.233039990067482*x_113 + 5.00207996368408) - 0.000431371328417647*std::sin(0.286159932613373*x_113 - 1.19527995586395) - 9.07206741663175e-5*std::sin(0.295519918203354*x_114 + 7.73567962646484) + 0.000107598979590619*std::sin(0.253679990768433*x_116 + 5.15799999237061) + 0.00407636959808738*std::sin(0.247519969940186*x_117 - 7.43887996673584) + 0.00516580913014157*std::sin(0.26063996553421*x_117 - 1.22167980670929) + 8.28146144356902e-5*std::sin(0.29615992307663*x_117 + 4.76168012619019) - 0.00144494823450069*std::sin(0.23039998114109*x_118 - 4.41991996765137) - 0.00296173811995999*std::sin(0.284399926662445*x_118 + 1.75903987884521) - 0.00136972368864427*std::sin(0.22087998688221*x_119 - 4.40064001083374) - 0.000767057871469502*std::sin(0.309679925441742*x_119 + 7.73167991638184) + 0.000117030263567903*std::sin(0.23879998922348*x_12 + 5.00543975830078) + 0.000581706568889534*std::sin(0.377759844064713*x_12 - 7.57472038269043) - 0.00710479434164302*std::sin(0.266959965229034*x_120 - 1.2157598733902) + 0.00161556428332178*std::sin(0.308479934930801*x_120 + 4.75375986099243) + 0.00108632858856268*std::sin(0.218639984726906*x_13 - 4.38479995727539) + 0.000417882453606379*std::sin(0.456879854202271*x_13 - 4.82416009902954) - 0.000720793546613858*std::sin(0.269839972257614*x_14 - 7.42647981643677) + 0.00749142550294028*std::sin(0.297919929027557*x_14 + 1.96719980239868) - 0.00405878880604515*std::sin(0.352399855852127*x_14 + 8.24512004852295) + 4.34115264011824e-5*std::sin(0.508959829807281*x_15 + 1.68047988414764) + 0.00181414162140377*std::sin(0.314959913492203*x_16 + 1.78967988491058) + 7.7770484440402e-5*std::sin(0.398079842329025*x_16 + 1.80543982982635) + 2.93043991115849e-6*std::sin(0.547359883785248*x_16 - 7.54184007644653) - 0.00126369443074565*std::sin(0.129280045628548*x_17 - 1.43207991123199) + 0.000351591691108476*std::sin(0.447759836912155*x_18 - 1.21223986148834) + 0.000187024549966766*std::sin(0.479279845952988*x_18 - 1.2247998714447) - 0.000330849322979992*std::sin(0.156000033020973*x_19 - 1.41391980648041) + 0.000718792814549163*std::sin(0.30839991569519*x_19 + 5.02143955230713) - 0.00658251247276236*std::sin(0.338479846715927*x_19 - 4.35743999481201) - 0.00043041045430979*std::sin(0.34895983338356*x_19 - 4.37375974655151) + 0.00168193922777781*std::sin(0.351359844207764*x_19 - 4.35784006118774) - 0.00129109757068883*std::sin(0.363359838724136*x_19 - 7.79911994934082) + 0.000332881242502639*std::sin(0.403119832277298*x_2 + 5.21200037002563) - 0.000530546896211489*std::sin(0.488319844007492*x_2 - 4.37152004241943) - 0.00210180568303991*std::sin(0.255759954452515*x_20 - 1.35999977588654) - 0.000781198199289518*std::sin(0.262479960918427*x_20 + 8.19607925415039) - 0.00155838217723365*std::sin(0.284639924764633*x_20 + 4.99671983718872) + 0.000112175860768829*std::sin(0.355199843645096*x_20 - 7.57775974273682) - 0.000157565329990614*std::sin(0.398719847202301*x_20 + 1.37599992752075) + 0.000445573343983231*std::sin(0.229599997401237*x_21 - 4.40079975128174) + 0.00113646527503746*std::sin(0.275599956512451*x_21 + 8.02600002288818) - 0.00207600250029051*std::sin(0.309199929237366*x_21 - 7.78527975082397) + 0.000324805128187358*std::sin(0.313199937343597*x_22 - 4.34143972396851) + 0.000289769055707493*std::sin(0.748719871044159*x_22 + 7.81496000289917) + 0.010292272134621*std::sin(0.188480004668236*x_23 - 7.60056018829346) + 0.000555032535394638*std::sin(0.220399990677834*x_23 - 4.39192008972168) - 6.99660534536976e-6*std::sin(0.638799846172333*x_23 - 1.57759976387024) - 0.00679759186485378*std::sin(0.319439917802811*x_24 + 5.02647972106934) - 0.0028597669164578*std::sin(0.345359832048416*x_24 - 1.18375980854034) - 0.000452514650559332*std::sin(0.352239847183228*x_24 + 1.8154399394989) + 9.85993353737772e-5*std::sin(0.411519855260849*x_24 - 1.18431985378265) - 0.000360797594082987*std::sin(0.5065598487854*x_24 + 4.93807983398438) - 0.000289132712952252*std::sin(0.261679977178574*x_25 + 2.00943970680237) - 0.00129634476693383*std::sin(0.323359847068787*x_25 - 1.16343986988068) - 0.00424684264203336*std::sin(0.291839927434921*x_26 - 1.17271983623505) + 0.000213240502533376*std::sin(0.338559836149216*x_26 - 7.57192039489746) - 2.28518142771661e-5*std::sin(0.355599850416183*x_26 - 4.35775947570801) - 0.00122174031384907*std::sin(0.408239871263504*x_27 + 1.97231984138489) - 5.95302346180184e-5*std::sin(0.319119930267334*x_28 - 1.18535983562469) + 0.000969505582636933*std::sin(0.39047983288765*x_28 - 1.36959993839264) - 0.000538639112648086*std::sin(0.475599855184555*x_28 + 4.95831966400146) + 0.00695343256014829*std::sin(0.233119979500771*x_29 + 5.00799989700317) - 0.000123876846298001*std::sin(0.551679849624634*x_29 - 1.37071990966797) - 0.000374521300865472*std::sin(0.301359921693802*x_3 - 4.32032012939453) + 0.00390958902362021*std::sin(0.326879858970642*x_3 + 1.99583983421326) + 8.2313714321313e-5*std::sin(0.440799862146378*x_3 - 1.1911199092865) - 0.000284539837756145*std::sin(0.286239951848984*x_30 - 4.36639976501465) - 0.00270365882106371*std::sin(0.325839847326279*x_30 - 1.13759982585907) - 5.45520401122156e-6*std::sin(0.729919850826263*x_31 - 4.79967975616455) + 0.00520278498196282*std::sin(0.321119844913483*x_32 + 2.00159978866577) - 0.00881987456143301*std::sin(0.251759976148605*x_33 + 1.96623980998993) + 0.00028377739438495*std::sin(0.276319950819016*x_33 - 7.61472034454346) + 0.000903522073234289*std::sin(0.239119976758957*x_34 + 7.97983980178833) + 0.000879104095476828*std::sin(0.257119953632355*x_34 - 1.4139199256897) + 0.00253668575179933*std::sin(0.285279929637909*x_34 + 1.77127993106842) + 0.00614294612630267*std::sin(0.248959973454475*x_35 + 1.96167981624603) - 0.000273480621207889*std::sin(0.279199957847595*x_35 - 1.43975985050201) + 0.000616556429112726*std::sin(0.202879995107651*x_36 - 4.39247989654541) + 0.000367558279119452*std::sin(0.202880010008812*x_37 - 8.00967979431152) + 0.00259583441138705*std::sin(0.186400011181831*x_38 + 5.01095962524414) - 0.00132650656529066*std::sin(0.251359969377518*x_38 + 4.96871948242188) - 0.00221563948741573*std::sin(0.253519982099533*x_38 - 7.62184000015259) - 0.000278557927847601*std::sin(0.239039987325668*x_4 + 5.00807952880859) + 0.00212117439311696*std::sin(0.333759844303131*x_4 + 8.01072025299072) + 0.000706423493257591*std::sin(0.404239863157272*x_4 - 4.41328001022339) - 6.07473098788759e-5*std::sin(0.427439838647842*x_4 - 1.18679988384247) + 0.000195080663887475*std::sin(0.442959845066071*x_4 + 1.78983998298645) + 0.000144992159771628*std::sin(0.216559991240501*x_40 - 7.80495977401733) - 0.00580649897317613*std::sin(0.228479996323586*x_40 - 1.21911990642548) - 0.00871437791665465*std::sin(0.27991995215416*x_41 - 1.22039985656738) - 0.0108617323291409*std::sin(0.224399983882904*x_42 - 1.21111989021301) + 0.000188060090260717*std::sin(0.229999989271164*x_42 + 1.96623980998993) - 0.000223489503005447*std::sin(0.328639835119247*x_42 - 1.31815981864929) + 0.00168678525097819*std::sin(0.304079920053482*x_43 + 1.91623985767365) - 0.0126794456245814*std::sin(0.118240058422089*x_44 + 8.16224002838135) + 0.000832334475088172*std::sin(0.257839977741241*x_44 - 7.44911956787109) - 0.000620447208009913*std::sin(0.336479842662811*x_44 - 1.34127986431122) - 3.08315929221576e-5*std::sin(0.342239856719971*x_44 - 1.53007984161377) + 0.000208633943040329*std::sin(0.181120008230209*x_45 + 1.99287974834442) - 0.000692994647314744*std::sin(0.183680012822151*x_45 - 1.18559980392456) + 0.001777816324998*std::sin(0.198080003261566*x_46 - 4.59815979003906) + 1.18084470797802e-5*std::sin(0.380719840526581*x_48 - 1.99863982200623) - 0.000427103498269661*std::sin(0.261119961738586*x_49 + 1.94247984886169) - 0.00324168227163162*std::sin(0.328159838914871*x_49 - 7.46968030929565) - 0.00501411004139218*std::sin(0.412159860134125*x_49 + 4.97711944580078) - 0.00010232831598119*std::sin(0.453679859638214*x_49 + 7.36191987991333) + 0.000413544899023859*std::sin(0.168400019407272*x_5 - 4.60983991622925) - 0.000304808365775525*std::sin(0.311839938163757*x_5 - 7.56879997253418) - 0.000812195969898397*std::sin(0.373759835958481*x_5 - 7.38263988494873) + 0.00431488985376493*std::sin(0.416639864444733*x_5 + 1.96631979942322) - 0.00308243851565528*std::sin(0.451359868049622*x_5 - 1.2176798582077) + 0.000197541980469943*std::sin(0.12352005392313*x_50 + 1.63047981262207) + 0.00471182377515996*std::sin(0.247359976172447*x_52 + 1.96775984764099) + 0.000520290381578781*std::sin(0.341359823942184*x_52 - 1.33279979228973) - 0.000454146373047955*std::sin(0.202079996466637*x_53 - 1.19311988353729) - 0.000950051881144468*std::sin(0.240319982171059*x_53 - 1.19671988487244) + 0.000539988295947456*std::sin(0.266879975795746*x_53 - 7.61999988555908) - 0.000222125645428231*std::sin(0.233519986271858*x_55 + 7.96848011016846) - 0.000972219285993746*std::sin(0.277839958667755*x_55 + 4.72816038131714) - 0.0120264672106741*std::sin(0.195280000567436*x_56 - 1.18679988384247) - 0.000234973758221503*std::sin(0.267359972000122*x_56 - 4.42799949645996) + 0.000534047676504587*std::sin(0.131920039653778*x_57 - 7.61880016326904) - 0.00142271552627728*std::sin(0.449039846658707*x_57 - 1.30199992656708) - 0.0011765519000255*std::sin(0.452639847993851*x_57 - 7.50471973419189) + 0.00952121184545123*std::sin(0.106800064444542*x_58 - 7.62919998168945) + 0.000135772974171306*std::sin(0.239759981632233*x_58 - 7.61368036270142) + 0.000844695732870405*std::sin(0.548639833927155*x_58 + 1.6451997756958) + 0.00743318626220368*std::sin(0.148400038480759*x_59 - 1.5810399055481) - 0.00042931227542403*std::sin(0.250479966402054*x_59 - 7.6255202293396) + 0.000760772407738957*std::sin(0.448639839887619*x_59 + 1.88055980205536) + 8.40939753084754e-5*std::sin(0.363759845495224*x_6 - 1.77367985248566) + 0.000189750375346448*std::sin(0.197039991617203*x_60 + 5.00575971603394) + 0.000224968922366346*std::sin(0.523919880390167*x_60 + 8.08559989929199) + 1.37185885628578e-5*std::sin(1.41615986824036*x_62 + 3.77920007705688) + 2.53946206829976e-5*std::sin(0.801759898662567*x_63 + 8.58879947662354) + 1.26203349996598e-5*std::sin(1.67223989963531*x_63 - 9.78384017944336) + 0.00432818174082668*std::sin(0.430479854345322*x_7 - 4.4236798286438) + 0.000131119752352082*std::sin(0.463679850101471*x_7 + 4.96807956695557) - 0.00049896236217909*std::sin(0.172400012612343*x_8 + 7.81128025054932) + 0.0008887584436881*std::sin(0.174160018563271*x_8 + 8.00144004821777) - 1.47523781448572e-5*std::sin(0.703439831733704*x_8 + 4.0403995513916) - 0.00381179318033839*std::sin(0.171280011534691*x_9 - 1.4197598695755) - 4.10013137985799e-5*std::sin(0.263279944658279*x_9 + 4.32567977905273) + 5.41115901845218e-5*std::sin(0.433199852705002*x_9 + 7.36879968643188) - 0.00249157897409212*std::sin(0.318399846553802*x_91 - 1.21383988857269) + 0.000183423450138552*std::sin(0.347679853439331*x_91 - 7.39775943756104) + 6.85629252584017e-5*std::sin(0.325039833784103*x_92 - 1.18871986865997) + 0.00204064102462331*std::sin(0.27007994055748*x_94 - 4.40319967269897) + 0.00137415298018743*std::sin(0.282559931278229*x_94 + 8.19808006286621) + 0.00246193864695689*std::sin(0.316559940576553*x_94 + 4.78975963592529) + 3.50220520504435e-5*std::sin(0.346959829330444*x_94 + 4.61783981323242) - 1.97331789436786e-5*std::sin(0.450159847736359*x_94 - 2.01663970947266) + 0.00280304299200447*std::sin(0.324079841375351*x_95 - 1.36367988586426) + 0.000366908593777522*std::sin(0.258719980716705*x_96 + 8.19823932647705) + 0.00402106960010969*std::sin(0.260559976100922*x_97 + 1.97991979122162) + 0.000306917326822726*std::sin(0.279599964618683*x_97 - 4.40623998641968) - 0.000248858037505712*std::sin(0.276239961385727*x_98 + 4.97775983810425) + 0.000434228722640592*std::sin(0.313599914312363*x_98 + 4.77895975112915) - 0.00240681760094636);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-6.97043762863422e-7*x_1 + 3.31788391776883e-5*x_10 + 0.000202055424010775*x_100 - 0.000334580009978946*x_101 - 0.00015816706994726*x_102 - 4.601348820618e-6*x_103 + 9.71362312623903e-5*x_104 + 4.16565526082632e-5*x_105 + 0.000713240378539252*x_106 - 7.32664613567969e-6*x_107 - 0.00014440099300309*x_108 + 3.6061946198792e-5*x_109 - 6.19797184743176e-5*x_11 - 0.00011455550605472*x_110 - 0.000569264300133883*x_111 + 0.00017374008956258*x_112 + 1.2440557301262e-5*x_113 + 0.000242633675731023*x_114 + 0.000553515167639278*x_115 + 9.55779075862865e-5*x_116 - 0.000992506396588528*x_117 + 0.000615042681860516*x_118 - 4.06256304113665e-6*x_119 + 6.09299035877014e-5*x_12 + 0.000183959505710393*x_120 - 3.63941060023224e-5*x_13 + 0.000312957694481837*x_14 + 0.000184638626814914*x_15 + 0.000483076461602328*x_16 + 0.000209446676280442*x_17 - 0.000138373180722638*x_18 + 3.4543723881271e-5*x_19 - 3.47029182548117e-5*x_2 - 8.277638928308e-6*x_20 - 6.43832635970399e-5*x_21 - 3.09991277804003e-5*x_22 + 4.59584013048985e-5*x_23 - 3.83783254072827e-5*x_24 + 0.000492283076467749*x_25 - 6.62639277603179e-5*x_26 + 1.27178892286608e-5*x_27 - 3.78477358619057e-5*x_28 + 0.000108678632300148*x_29 + 0.000142080797048514*x_3 + 3.31085198405929e-6*x_30 + 2.19864804770714e-6*x_31 - 2.92960797162102e-5*x_32 - 0.000242005449078214*x_33 - 1.83849681660599e-5*x_34 - 0.000214250445172637*x_35 - 7.701873848103e-5*x_36 + 5.88950223585299e-5*x_37 - 0.000203533499340573*x_38 - 0.000286330093839644*x_39 + 5.81247660022441e-5*x_4 - 3.61960584398922e-5*x_40 - 7.26278919760103e-6*x_41 - 0.00135800085101657*x_42 + 6.26871932120447e-5*x_43 - 3.25861962811322e-5*x_44 + 6.67223490261615e-6*x_45 - 7.90280817837576e-5*x_46 - 0.000852376710326466*x_47 - 5.98700358927262e-5*x_48 - 0.000302807878323442*x_49 - 2.80619297817849e-6*x_5 - 0.000121266606743957*x_50 + 4.01677558461908e-5*x_51 - 3.38225105027699e-5*x_52 + 0.000292562867500519*x_53 - 0.000444598286120181*x_54 - 0.000241364960359926*x_55 + 0.000418682146645714*x_56 - 2.91430318947676e-5*x_57 + 0.000455961883870482*x_58 - 8.17602394225128e-5*x_59 - 9.0664128007464e-7*x_6 - 1.54882255773152e-5*x_60 - 3.81661103298691e-6*x_61 - 1.59757609714042e-6*x_62 + 3.21489205431052e-5*x_63 - 1.02446900032107e-5*x_64 + 7.58777614489265e-6*x_65 + 2.13062533329268e-5*x_66 + 3.82199462040242e-5*x_67 - 5.77378597996623e-7*x_68 + 2.95373812080803e-5*x_69 - 4.03221075247514e-5*x_7 - 5.3145287341798e-6*x_70 - 7.8569393725058e-6*x_71 - 1.16557155858834e-5*x_72 - 1.52774491129994e-5*x_73 + 2.03971636598477e-5*x_74 + 5.99905538937258e-7*x_75 + 8.72984573337634e-6*x_76 - 5.09541481384415e-6*x_77 + 4.80785984084566e-6*x_78 - 1.1867224737978e-5*x_79 + 2.34738809498038e-5*x_8 + 5.52707394050593e-6*x_80 - 4.14995522605738e-6*x_81 - 1.15668993720742e-5*x_82 + 0.000115690722792227*x_83 + 8.66712846837911e-6*x_84 + 4.03605440644637e-6*x_85 + 4.32877963069867e-5*x_86 + 1.26182353134582e-5*x_87 - 3.24925716859301e-6*x_88 + 1.52879435098155e-5*x_89 - 3.98943595617586e-5*x_9 + 3.34089027301966e-5*x_90 - 4.66719254388242e-5*x_91 + 3.39585554878193e-5*x_92 - 5.17477995492706e-5*x_93 + 5.3719512800082e-5*x_94 + 1.72226004648987e-5*x_95 + 3.98022610269258e-5*x_96 + 7.42146647435654e-5*x_97 - 6.77970872110462e-5*x_98 - 0.000607448099356078*x_99 - 1.75615492709385e-6*std::pow(0.586719870567322 - 2.74799990653992*x_8, 2) + 5.73049541185557e-7*std::pow(5.50623989105225 - 9.58327960968018*x_6, 2) + 8.79003325496983e-8*std::pow(5.90783977508545 - 6.72600030899048*x_41, 2) - 1.653718870254e-7*std::pow(-7.36751985549927*x_11 - 5.58879995346069, 2) + 1.2252879910163e-8*std::pow(-5.96751976013184*x_12 - 7.36407995223999, 2) + 7.70880054588765e-9*std::pow(-6.45391988754272*x_17 - 1.20223987102509, 2) - 1.29175479433973e-7*std::pow(-7.15599966049194*x_19 - 8.56088066101074, 2) + 1.49294574153016e-6*std::pow(-3.90079998970032*x_27 - 7.59823989868164, 2) - 7.24652237045452e-9*std::pow(-8.39199924468994*x_30 - 6.94776010513306, 2) - 5.44516107059277e-8*std::pow(-6.28359985351563*x_32 - 4.66207981109619, 2) - 1.28991299441518e-6*std::pow(-3.47567987442017*x_43 - 8.39967918395996, 2) + 2.02013366729561e-6*std::pow(-2.60359978675842*x_52 - 6.60096025466919, 2) + 0.00166887864172785*std::exp(0.198239862918854*x_13) - 0.000300916811583929*std::exp(0.208159849047661*x_14) + 6.13983196371843e-5*std::exp(0.311599850654602*x_18) - 5.70345676654171e-6*std::exp(0.619279801845551*x_18) - 1.47728754351636e-5*std::exp(0.370399862527847*x_19) + 4.72035734648513e-6*std::exp(0.318559855222702*x_26) - 8.34584287664097e-6*std::exp(0.417679876089096*x_27) - 8.36302183274111e-5*std::exp(0.188799858093262*x_43) - 2.70029841118549e-5*std::exp(0.285439848899841*x_49) - 0.000560402862735853*std::exp(0.19327986240387*x_56) - 0.00225157344593722*std::exp(0.225839853286743*x_60) - 2.51560150202818e-5*std::exp(0.243999853730202*x_8) + 0.000688468547274443*std::sin(0.184320002794266*x_10 + 1.76455986499786) - 1.30287228506462e-5*std::sin(0.596159815788269*x_10 + 4.99143981933594) + 0.000852125276436969*std::sin(0.276079952716827*x_100 + 1.78791987895966) + 6.41938694798886e-6*std::sin(0.227279990911484*x_102 - 1.39095985889435) - 0.000987227679992475*std::sin(0.237599983811378*x_102 + 8.17735958099365) + 0.000964591174607464*std::sin(0.254479974508286*x_102 + 1.77367985248566) + 7.54030806842379e-5*std::sin(0.291839927434921*x_102 + 1.5759197473526) + 0.000887964863216403*std::sin(0.215120002627373*x_104 - 4.39056015014648) - 5.21955381817359e-5*std::sin(0.31183984875679*x_105 + 4.43111991882324) - 2.9250658956383e-5*std::sin(1.16343986988068*x_106 - 5.78295993804932) + 0.000573751476212696*std::sin(0.259199976921082*x_107 - 7.43327951431274) - 0.000974016876252562*std::sin(0.238079980015755*x_109 - 1.21103978157043) - 0.00599561740328693*std::sin(0.25927996635437*x_109 - 4.41807985305786) - 0.00108100102370426*std::sin(0.277599930763245*x_109 + 4.95183992385864) + 0.000202033080067807*std::sin(0.386879861354828*x_11 - 2.18583989143372) + 0.000246069916974593*std::sin(0.312159925699234*x_110 + 1.51447987556458) - 0.000460209540598626*std::sin(0.287199944257736*x_112 + 4.56680011749268) + 0.000106059075548242*std::sin(0.233039990067482*x_113 + 5.00207996368408) + 0.00113900725993297*std::sin(0.253679990768433*x_116 + 5.15799999237061) - 0.000135555406656905*std::sin(0.247519969940186*x_117 - 7.43887996673584) + 0.000724197148755182*std::sin(0.26063996553421*x_117 - 1.22167980670929) + 0.000876648156234229*std::sin(0.29615992307663*x_117 + 4.76168012619019) - 1.44238695546961e-5*std::sin(0.23039998114109*x_118 - 4.41991996765137) + 9.84895028779548e-5*std::sin(0.284399926662445*x_118 + 1.75903987884521) - 0.00380686950103708*std::sin(0.22087998688221*x_119 - 4.40064001083374) + 2.55077070894688e-5*std::sin(0.309679925441742*x_119 + 7.73167991638184) + 0.00123884371713253*std::sin(0.23879998922348*x_12 + 5.00543975830078) + 0.000894819821486853*std::sin(0.377759844064713*x_12 - 7.57472038269043) + 0.000236262503441047*std::sin(0.266959965229034*x_120 - 1.2157598733902) + 1.61270057455808e-5*std::sin(0.308479934930801*x_120 + 4.75375986099243) + 0.00124607372988747*std::sin(0.218639984726906*x_13 - 4.38479995727539) - 0.000762826133587595*std::sin(0.456879854202271*x_13 - 4.82416009902954) - 0.000826786584247316*std::sin(0.269839972257614*x_14 - 7.42647981643677) - 0.000249119518251596*std::sin(0.297919929027557*x_14 + 1.96719980239868) - 0.00056900346232049*std::sin(0.352399855852127*x_14 + 8.24512004852295) + 0.00045954008043427*std::sin(0.508959829807281*x_15 + 1.68047988414764) - 6.03273818296526e-5*std::sin(0.314959913492203*x_16 + 1.78967988491058) + 0.000823252662089786*std::sin(0.398079842329025*x_16 + 1.80543982982635) - 1.53010951043461e-6*std::sin(0.547359883785248*x_16 - 7.54184007644653) - 0.00194389901267986*std::sin(0.129280045628548*x_17 - 1.43207991123199) - 9.76536121758496e-5*std::sin(0.479279845952988*x_18 - 1.2247998714447) - 0.00350226165946812*std::sin(0.156000033020973*x_19 - 1.41391980648041) + 0.00110569502288542*std::sin(0.30839991569519*x_19 + 5.02143955230713) - 0.000922805439443189*std::sin(0.338479846715927*x_19 - 4.35743999481201) + 0.00467460934048874*std::sin(0.351359844207764*x_19 - 4.35784006118774) - 1.28880900348904e-5*std::sin(0.363359838724136*x_19 - 7.79911994934082) - 7.43776124586978e-5*std::sin(0.488319844007492*x_2 - 4.37152004241943) - 2.09808007495595e-5*std::sin(0.255759954452515*x_20 - 1.35999977588654) - 0.000218470311424878*std::sin(0.284639924764633*x_20 + 4.99671983718872) + 0.00118745661242373*std::sin(0.355199843645096*x_20 - 7.57775974273682) - 0.000437920913637563*std::sin(0.398719847202301*x_20 + 1.37599992752075) + 0.000685410620140495*std::sin(0.229599997401237*x_21 - 4.40079975128174) - 0.00207456763075768*std::sin(0.275599956512451*x_21 + 8.02600002288818) + 6.90352914219727e-5*std::sin(0.309199929237366*x_21 - 7.78527975082397) + 2.89255418340758e-6*std::sin(0.748719871044159*x_22 + 7.81496000289917) + 0.00144287834612672*std::sin(0.188480004668236*x_23 - 7.60056018829346) - 7.40637533328127e-5*std::sin(0.638799846172333*x_23 - 1.57759976387024) + 0.000226046806442739*std::sin(0.319439917802811*x_24 + 5.02647972106934) - 0.000400912034267588*std::sin(0.345359832048416*x_24 - 1.18375980854034) + 0.00104373999867457*std::sin(0.411519855260849*x_24 - 1.18431985378265) - 0.00100276381897254*std::sin(0.5065598487854*x_24 + 4.93807983398438) - 1.29404689868547e-5*std::sin(0.323359847068787*x_25 - 1.16343986988068) - 0.000595366815747643*std::sin(0.291839927434921*x_26 - 1.17271983623505) - 0.000111342095667536*std::sin(0.338559836149216*x_26 - 7.57192039489746) - 0.000241901758393638*std::sin(0.355599850416183*x_26 - 4.35775947570801) - 0.00339557969066229*std::sin(0.408239871263504*x_27 + 1.97231984138489) - 0.000630167401897438*std::sin(0.319119930267334*x_28 - 1.18535983562469) - 3.22398939419409e-5*std::sin(0.39047983288765*x_28 - 1.36959993839264) - 0.000617846253175312*std::sin(0.475599855184555*x_28 + 4.95831966400146) + 0.000974804896436977*std::sin(0.233119979500771*x_29 + 5.00799989700317) + 0.00022613176238201*std::sin(0.551679849624634*x_29 - 1.37071990966797) + 0.000548087076463996*std::sin(0.326879858970642*x_3 + 1.99583983421326) + 0.000871345793061757*std::sin(0.440799862146378*x_3 - 1.1911199092865) - 0.000437698146185457*std::sin(0.286239951848984*x_30 - 4.36639976501465) - 0.000379027168850792*std::sin(0.325839847326279*x_30 - 1.13759982585907) - 0.000173013171894255*std::sin(0.321119844913483*x_32 + 2.00159978866577) - 0.00123646225573826*std::sin(0.251759976148605*x_33 + 1.96623980998993) + 0.00103638542857491*std::sin(0.239119976758957*x_34 + 7.97983980178833) - 0.00160476605893886*std::sin(0.257119953632355*x_34 - 1.4139199256897) + 0.00705020414139028*std::sin(0.285279929637909*x_34 + 1.77127993106842) + 0.000861182431938435*std::sin(0.248959973454475*x_35 + 1.96167981624603) - 0.000313696078063579*std::sin(0.279199957847595*x_35 - 1.43975985050201) + 0.000565402646794145*std::sin(0.202880010008812*x_37 - 8.00967979431152) + 0.00036391121545669*std::sin(0.186400011181831*x_38 + 5.01095962524414) + 0.0024214796903925*std::sin(0.251359969377518*x_38 + 4.96871948242188) - 0.00615792109011772*std::sin(0.253519982099533*x_38 - 7.62184000015259) + 0.000145447150437585*std::sin(0.239039987325668*x_4 + 5.00807952880859) - 7.05374354631862e-5*std::sin(0.333759844303131*x_4 + 8.01072025299072) - 0.00128954517565057*std::sin(0.404239863157272*x_4 - 4.41328001022339) - 0.000643050958630743*std::sin(0.427439838647842*x_4 - 1.18679988384247) + 0.000300086081490472*std::sin(0.442959845066071*x_4 + 1.78983998298645) + 0.00019308904912133*std::sin(0.228479996323586*x_40 - 1.21911990642548) + 0.000289787521427971*std::sin(0.27991995215416*x_41 - 1.22039985656738) + 0.000361195546048127*std::sin(0.224399983882904*x_42 - 1.21111989021301) + 0.00199074200262473*std::sin(0.229999989271164*x_42 + 1.96623980998993) + 0.00468807788022109*std::sin(0.304079920053482*x_43 + 1.91623985767365) - 0.00177753729140716*std::sin(0.118240058422089*x_44 + 8.16224002838135) - 0.00172440731861357*std::sin(0.336479842662811*x_44 - 1.34127986431122) + 5.62817237674924e-5*std::sin(0.342239856719971*x_44 - 1.53007984161377) + 0.00220853001297508*std::sin(0.181120008230209*x_45 + 1.99287974834442) - 0.00324532590857371*std::sin(0.198080003261566*x_46 - 4.59815979003906) + 0.00012500032066825*std::sin(0.380719840526581*x_48 - 1.99863982200623) + 0.000107798752789659*std::sin(0.328159838914871*x_49 - 7.46968030929565) - 0.000702930383999967*std::sin(0.412159860134125*x_49 + 4.97711944580078) + 0.000186795863197423*std::sin(0.453679859638214*x_49 + 7.36191987991333) + 0.000636142331051448*std::sin(0.168400019407272*x_5 - 4.60983991622925) - 0.00225733415600907*std::sin(0.373759835958481*x_5 - 7.38263988494873) - 0.000143487148241243*std::sin(0.416639864444733*x_5 + 1.96631979942322) - 0.000432128467779748*std::sin(0.451359868049622*x_5 - 1.2176798582077) + 0.0020911141606813*std::sin(0.12352005392313*x_50 + 1.63047981262207) - 0.000156686770561032*std::sin(0.247359976172447*x_52 + 1.96775984764099) + 0.000800345348092609*std::sin(0.341359823942184*x_52 - 1.33279979228973) - 0.0010897574671128*std::sin(0.240319982171059*x_53 - 1.19671988487244) + 0.000830645993059863*std::sin(0.266879975795746*x_53 - 7.61999988555908) - 0.000341688474945667*std::sin(0.233519986271858*x_55 + 7.96848011016846) - 9.70495954450535e-6*std::sin(0.277839958667755*x_55 + 4.72816038131714) + 0.000399927586093706*std::sin(0.195280000567436*x_56 - 1.18679988384247) - 0.000361452298514079*std::sin(0.267359972000122*x_56 - 4.42799949645996) + 0.00565325231710739*std::sin(0.131920039653778*x_57 - 7.61880016326904) - 0.00395414957815154*std::sin(0.449039846658707*x_57 - 1.30199992656708) - 1.17446637361109e-5*std::sin(0.452639847993851*x_57 - 7.50471973419189) + 9.50433478392895e-5*std::sin(0.106800064444542*x_58 - 7.62919998168945) + 0.00143724786119896*std::sin(0.239759981632233*x_58 - 7.61368036270142) - 2.80894729526795e-5*std::sin(0.548639833927155*x_58 + 1.6451997756958) + 0.00104206178773519*std::sin(0.148400038480759*x_59 - 1.5810399055481) + 0.00211441278285736*std::sin(0.448639839887619*x_59 + 1.88055980205536) + 0.00200863480227143*std::sin(0.197039991617203*x_60 + 5.00575971603394) + 2.11028474240922e-5*std::sin(1.41615986824036*x_62 + 3.77920007705688) + 3.56008350851365e-6*std::sin(0.801759898662567*x_63 + 8.58879947662354) + 1.94134405823504e-5*std::sin(1.67223989963531*x_63 - 9.78384017944336) - 0.000143929156040717*std::sin(0.430479854345322*x_7 - 4.4236798286438) + 0.000260529844960146*std::sin(0.172400012612343*x_8 + 7.81128025054932) - 2.95547323065174e-5*std::sin(0.174160018563271*x_8 + 8.00144004821777) - 0.0105941069157197*std::sin(0.171280011534691*x_9 - 1.4197598695755) + 6.20687255414882e-5*std::sin(0.433199852705002*x_9 + 7.36879968643188) + 8.28548523198981e-5*std::sin(0.318399846553802*x_91 - 1.21383988857269) + 0.000725784481680805*std::sin(0.325039833784103*x_92 - 1.18871986865997) - 6.78593825406228e-5*std::sin(0.27007994055748*x_94 - 4.40319967269897) + 1.37171719105008e-5*std::sin(0.282559931278229*x_94 + 8.19808006286621) + 0.000345140306894674*std::sin(0.316559940576553*x_94 + 4.78975963592529) + 0.000370731875850273*std::sin(0.346959829330444*x_94 + 4.61783981323242) - 3.03548912873008e-5*std::sin(0.450159847736359*x_94 - 2.01663970947266) + 0.000392959881309475*std::sin(0.324079841375351*x_95 - 1.36367988586426) + 0.000563715589558722*std::sin(0.260559976100922*x_97 + 1.97991979122162) + 0.00120685076442748*std::sin(0.313599914312363*x_98 + 4.77895975112915) - 0.0288527719676495*std::sin(0.0239637000445939*x_10 - 0.0120742483653747*x_101 - 0.0697941243804885*x_102 - 0.00482505491056584*x_104 + 0.0596343128525717*x_105 - 0.0518058810557187*x_106 - 0.0252082770500263*x_108 + 0.0764688487720369*x_11 + 0.090297481304464*x_110 - 0.0374946597765034*x_111 - 0.031887111683074*x_112 + 0.0352782537047778*x_115 + 0.010071799097892*x_116 + 0.127516840932794*x_117 - 9.38661211996488e-5*x_118 - 0.0527487842687089*x_119 + 0.000566780444845522*x_12 + 0.00439516704009629*x_120 + 0.010419985705717*x_13 + 0.00687609693456874*x_14 + 0.0438415238032547*x_15 + 0.000137769296849512*x_16 + 0.00112329705461403*x_17 - 0.0278584934984363*x_21 + 0.000591943940033054*x_28 + 0.000407362012064213*x_29 + 0.00788385431954118*x_32 + 0.000318669187679926*x_34 - 0.00273984449487276*x_35 + 0.0240198711839353*x_37 - 0.0716304981085951*x_38 + 0.00467529691916993*x_39 - 0.00504301325654162*x_4 + 0.102543847333273*x_41 - 0.0542869779840848*x_43 - 0.0359027968150974*x_46 - 0.08431829075334*x_47 + 0.00210631982417557*x_48 + 0.120755454288165*x_50 + 0.019039638716406*x_51 + 0.00304531273998169*x_52 - 6.66219114666628e-5*x_54 + 0.154956178591893*x_55 - 0.00107744930966102*x_56 + 0.0112114277926459*x_57 - 0.000969615012299038*x_61 + 4.6378791708068e-5*x_62 + 0.000665501944262271*x_63 - 4.72620045204986e-5*x_64 + 0.000433431546099314*x_65 + 0.000422504010579331*x_66 + 0.000311510520126657*x_67 + 0.00277505019943136*x_68 + 0.000704838743280963*x_69 - 0.00142709003316839*x_70 - 0.000552420673591533*x_71 + 0.00105192343668765*x_72 + 0.000225687820140685*x_73 + 0.00135746412042836*x_74 - 3.28621881470058e-5*x_75 + 0.00087571859679005*x_76 - 0.00057217543086798*x_77 + 0.00353783911153165*x_78 + 0.00137220712615639*x_79 + 0.00201542730457936*x_80 - 0.00100615880737613*x_81 - 0.000770005751099391*x_82 + 0.000913433771174122*x_83 - 0.000130984452937295*x_84 - 0.00139599936807103*x_85 - 0.00223647575295863*x_86 + 0.00254948375684195*x_87 + 0.00127046201849424*x_88 + 0.000344446745021584*x_89 + 8.05227655630627e-5*x_90 + 0.00168598154225459*x_92 - 0.0544340331557358*x_93 + 0.00812328631954578*x_94 - 0.0481509084448848*x_95 + 0.135419260516475*x_99 + 0.000200141947695819*std::pow(-5.99191999435425*x_26 - 0.821199893951416, 2) - 0.00121172455621973*std::pow(-2.68167996406555*x_58 - 5.57872009277344, 2) + 0.115939527634401*std::exp(0.265839844942093*x_27) - 0.0178538283516725*std::exp(0.427119851112366*x_30) + 1.2596964449391*std::sin(0.143360033631325*x_1 + 4.91999959945679) + 0.579326738020246*std::sin(0.249439969658852*x_100 - 7.61488008499146) + 0.517264452724053*std::sin(0.256239980459213*x_103 + 1.96455979347229) - 0.601691402363024*std::sin(0.278879970312119*x_107 + 1.76543986797333) + 0.449135597712521*std::sin(0.239439979195595*x_109 + 8.19032001495361) - 0.435404400563769*std::sin(0.286159932613373*x_113 - 1.19527995586395) - 0.0915688599402764*std::sin(0.295519918203354*x_114 + 7.73567962646484) + 0.354878869840125*std::sin(0.447759836912155*x_18 - 1.21223986148834) - 0.434434542839373*std::sin(0.34895983338356*x_19 - 4.37375974655151) + 0.335993489373632*std::sin(0.403119832277298*x_2 + 5.21200037002563) - 0.788501950119951*std::sin(0.262479960918427*x_20 + 8.19607925415039) + 0.327841868065772*std::sin(0.313199937343597*x_22 - 4.34143972396851) + 0.560221768223123*std::sin(0.220399990677834*x_23 - 4.39192008972168) - 0.456745400524976*std::sin(0.352239847183228*x_24 + 1.8154399394989) - 0.291835936403421*std::sin(0.261679977178574*x_25 + 2.00943970680237) - 0.378022858171542*std::sin(0.301359921693802*x_3 - 4.32032012939453) - 0.00550620701002952*std::sin(0.729919850826263*x_31 - 4.79967975616455) + 0.286430548708376*std::sin(0.276319950819016*x_33 - 7.61472034454346) + 0.622320874723631*std::sin(0.202879995107651*x_36 - 4.39247989654541) + 0.146347752511475*std::sin(0.216559991240501*x_40 - 7.80495977401733) - 0.225579000452642*std::sin(0.328639835119247*x_42 - 1.31815981864929) + 0.840116320488164*std::sin(0.257839977741241*x_44 - 7.44911956787109) - 0.699473746006234*std::sin(0.183680012822151*x_45 - 1.18559980392456) - 0.431096668675078*std::sin(0.261119961738586*x_49 + 1.94247984886169) - 0.307658147504004*std::sin(0.311839938163757*x_5 - 7.56879997253418) - 0.458392378674061*std::sin(0.202079996466637*x_53 - 1.19311988353729) - 0.433326096616904*std::sin(0.250479966402054*x_59 - 7.6255202293396) + 0.0848802052851347*std::sin(0.363759845495224*x_6 - 1.77367985248566) + 0.227072251527946*std::sin(0.523919880390167*x_60 + 8.08559989929199) + 0.13234564611502*std::sin(0.463679850101471*x_7 + 4.96807956695557) - 0.0148903043385227*std::sin(0.703439831733704*x_8 + 4.0403995513916) - 0.04138465234183*std::sin(0.263279944658279*x_9 + 4.32567977905273) + 0.18513835319067*std::sin(0.347679853439331*x_91 - 7.39775943756104) + 0.370338976680264*std::sin(0.258719980716705*x_96 + 8.19823932647705) + 0.309786826115856*std::sin(0.279599964618683*x_97 - 4.40623998641968) - 0.251184716061481*std::sin(0.276239961385727*x_98 + 4.97775983810425) + 7.39988823355505) + 0.0546782383015196);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-4.20031933899502e-6*x_1 - 4.14935690224933e-5*x_10 - 0.000260226719275797*x_100 - 5.87096633339402e-5*x_101 + 0.000351906239361943*x_102 - 3.70965074519742e-5*x_103 - 0.000200740960273067*x_104 - 0.000390125766054227*x_105 + 1.97202848468664e-6*x_106 - 0.000110844970574483*x_107 + 0.00012152353764856*x_108 + 0.00017517978905183*x_109 + 7.16168179307062e-5*x_11 - 0.000284920825647471*x_110 - 0.000659673895330926*x_111 - 9.52820689793462e-5*x_112 + 0.000115689363273141*x_113 + 0.000285246549489549*x_114 - 0.000779023525908492*x_115 + 0.000265582681838196*x_116 - 0.00103793894199269*x_117 + 0.000791958213002287*x_118 + 0.000221078934191353*x_119 - 0.000110296327421035*x_12 - 0.000288034856516504*x_120 - 0.000240931071778515*x_13 - 3.85776107463823e-5*x_14 + 9.87140169193686e-5*x_15 + 0.000265139752685676*x_16 - 0.000309803512699004*x_17 - 0.000112688769362531*x_18 - 6.35737418180357e-5*x_19 + 0.000222146918946494*x_2 + 5.84523235607994e-5*x_20 + 0.000126826087191054*x_21 + 0.000158425230274302*x_22 - 3.37276054383374e-5*x_23 - 0.000145313546161167*x_24 + 0.000289023793073908*x_25 - 6.02068296096718e-5*x_26 + 8.03912360137568e-5*x_27 - 4.96503807535939e-5*x_28 - 0.000374048797164771*x_29 + 9.40313026616616e-6*x_3 - 0.000147668395103516*x_30 + 1.77334825750762e-5*x_31 - 2.57273176444614e-5*x_32 + 0.000303896074677066*x_33 - 7.03173587870019e-5*x_34 + 0.000348036248303999*x_35 + 3.65692175668687e-5*x_36 - 0.00129131615254186*x_37 + 0.000591898282003725*x_38 - 0.000639176661344273*x_39 - 2.37722173865236e-5*x_4 + 0.000214733292855705*x_40 - 0.000285211754313104*x_41 - 0.000604770834164718*x_42 + 0.0001223535078941*x_43 + 0.000365201133984897*x_44 - 0.000279044976802435*x_45 + 0.000565255697735849*x_46 - 0.00115859029480128*x_47 - 0.000209586801760729*x_48 + 0.000370404663219659*x_49 + 8.95166058343165e-6*x_5 - 1.77028411685023e-5*x_50 - 0.000254633218057215*x_51 - 3.43299211305128e-5*x_52 - 0.000262700949794855*x_53 - 0.000655070388551475*x_54 - 2.45452197991628e-6*x_55 - 0.000431953344534506*x_56 + 0.000515370783118069*x_57 + 0.000476281907269106*x_58 + 0.000218729063559446*x_59 + 6.64670108036563e-5*x_6 - 0.000118709375098493*x_60 - 2.42603627450124e-5*x_61 - 1.96861819862231e-5*x_62 + 3.31247738291758e-5*x_63 - 4.00163699174415e-5*x_64 - 3.44421461845091e-5*x_65 + 1.26726868622805e-6*x_66 + 2.7979371209477e-5*x_67 - 5.95498088714322e-7*x_68 - 7.2835311387091e-6*x_69 + 0.000124553239748306*x_7 + 1.8983573090495e-5*x_70 - 9.94070110754041e-7*x_71 - 1.45560302590403e-5*x_72 + 6.30122735116868e-6*x_73 + 1.36592650444712e-5*x_74 - 2.52553442689488e-6*x_75 - 3.71896127223596e-5*x_76 - 3.85301028357463e-5*x_77 - 3.5366405123121e-5*x_78 - 2.25327074668493e-5*x_79 + 1.41039991789676e-5*x_8 - 5.66785037061072e-6*x_80 + 1.76041520370633e-5*x_81 - 2.78240301131682e-5*x_82 + 0.000101278118999729*x_83 - 4.58590165765894e-5*x_84 - 9.8756673273066e-6*x_85 + 0.000112388504902892*x_86 - 1.57596226907436e-5*x_87 + 1.51512242599048e-5*x_88 - 1.08816370286054e-5*x_89 - 0.000131698245725053*x_9 - 1.11064632010522e-5*x_90 + 1.4521055149237e-5*x_91 - 7.60002159920005e-5*x_92 + 0.000341888934194348*x_93 - 0.00014459759833988*x_94 + 4.34333844570673e-5*x_95 - 3.75945064730854e-5*x_96 - 0.000202198211860531*x_97 - 0.000105900993663925*x_98 - 0.00119677255134112*x_99 - 2.96177784694194e-6*std::pow(0.586719870567322 - 2.74799990653992*x_8, 2) + 3.88995078271716e-7*std::pow(5.50623989105225 - 9.58327960968018*x_6, 2) + 1.48245040154486e-7*std::pow(5.90783977508545 - 6.72600030899048*x_41, 2) + 5.62746295992583e-8*std::pow(-7.36751985549927*x_11 - 5.58879995346069, 2) - 2.01988360038214e-8*std::pow(-5.96751976013184*x_12 - 7.36407995223999, 2) + 6.48611055954301e-8*std::pow(-6.45391988754272*x_17 - 1.20223987102509, 2) - 7.21140415666262e-7*std::pow(-7.15599966049194*x_19 - 8.56088066101074, 2) - 5.3506035266165e-7*std::pow(-5.99191999435425*x_26 - 0.821199893951416, 2) - 2.30655526808296e-6*std::pow(-3.90079998970032*x_27 - 7.59823989868164, 2) + 1.1945870524482e-8*std::pow(-8.39199924468994*x_30 - 6.94776010513306, 2) + 1.01036338782784e-7*std::pow(-6.28359985351563*x_32 - 4.66207981109619, 2) + 1.99287591629927e-6*std::pow(-3.47567987442017*x_43 - 8.39967918395996, 2) - 3.7484090360098e-6*std::pow(-2.60359978675842*x_52 - 6.60096025466919, 2) + 3.23942969399441e-6*std::pow(-2.68167996406555*x_58 - 5.57872009277344, 2) + 0.00113286117727596*std::exp(0.198239862918854*x_13) - 0.000507500068798914*std::exp(0.208159849047661*x_14) + 0.000516599550042038*std::exp(0.311599850654602*x_18) + 8.81166534402447e-6*std::exp(0.619279801845551*x_18) - 0.000124297551589843*std::exp(0.370399862527847*x_19) - 7.78149501342972e-6*std::exp(0.318559855222702*x_26) - 0.000309953236978434*std::exp(0.265839844942093*x_27) - 7.02211184324196e-5*std::exp(0.417679876089096*x_27) + 4.77305022969256e-5*std::exp(0.427119851112366*x_30) - 0.000703656605150689*std::exp(0.188799858093262*x_43) - 0.000150747984617358*std::exp(0.285439848899841*x_49) + 0.000190700270124996*std::exp(0.19327986240387*x_56) - 0.0015284036124082*std::exp(0.225839853286743*x_60) + 4.66776211587311e-5*std::exp(0.243999853730202*x_8) - 0.00336767794975257*std::sin(0.143360033631325*x_1 + 4.91999959945679) + 0.00116111105015553*std::sin(0.184320002794266*x_10 + 1.76455986499786) + 4.43356223212775e-6*std::sin(0.596159815788269*x_10 + 4.99143981933594) - 0.00154877461881476*std::sin(0.249439969658852*x_100 - 7.61488008499146) - 0.00158113996995293*std::sin(0.276079952716827*x_100 + 1.78791987895966) - 1.05823402463898e-5*std::sin(0.227279990911484*x_102 - 1.39095985889435) + 0.00152523641197443*std::sin(0.237599983811378*x_102 + 8.17735958099365) - 0.00178982328421579*std::sin(0.254479974508286*x_102 + 1.77367985248566) + 0.000634434261123815*std::sin(0.291839927434921*x_102 + 1.5759197473526) - 0.00138285703562007*std::sin(0.256239980459213*x_103 + 1.96455979347229) - 0.00137187841202131*std::sin(0.215120002627373*x_104 - 4.39056015014648) - 0.000291388987021648*std::sin(0.31183984875679*x_105 + 4.43111991882324) + 9.95374744712115e-6*std::sin(1.16343986988068*x_106 - 5.78295993804932) - 0.00088642839000458*std::sin(0.259199976921082*x_107 - 7.43327951431274) + 0.00160856440965158*std::sin(0.278879970312119*x_107 + 1.76543986797333) + 0.00150482612637981*std::sin(0.238079980015755*x_109 - 1.21103978157043) - 0.00120072105858687*std::sin(0.239439979195595*x_109 + 8.19032001495361) - 0.00406991977736119*std::sin(0.25927996635437*x_109 - 4.41807985305786) + 0.00200582469902272*std::sin(0.277599930763245*x_109 + 4.95183992385864) - 0.000354929076801662*std::sin(0.386879861354828*x_11 - 2.18583989143372) + 0.000415000076388616*std::sin(0.312159925699234*x_110 + 1.51447987556458) + 0.000156605345086585*std::sin(0.287199944257736*x_112 + 4.56680011749268) - 0.00018632319894416*std::sin(0.233039990067482*x_113 + 5.00207996368408) + 0.00116401201646221*std::sin(0.286159932613373*x_113 - 1.19527995586395) + 0.000244800588065292*std::sin(0.295519918203354*x_114 + 7.73567962646484) - 0.00211345673523135*std::sin(0.253679990768433*x_116 + 5.15799999237061) - 0.00114055014043596*std::sin(0.247519969940186*x_117 - 7.43887996673584) - 0.00111886232843257*std::sin(0.26063996553421*x_117 - 1.22167980670929) - 0.00162664279271618*std::sin(0.29615992307663*x_117 + 4.76168012619019) + 2.37777059607159e-5*std::sin(0.23039998114109*x_118 - 4.41991996765137) + 0.000828681194717934*std::sin(0.284399926662445*x_118 + 1.75903987884521) - 0.00258416313616175*std::sin(0.22087998688221*x_119 - 4.40064001083374) + 0.00021461939158744*std::sin(0.309679925441742*x_119 + 7.73167991638184) - 0.00229870580282945*std::sin(0.23879998922348*x_12 + 5.00543975830078) + 0.00150912512523599*std::sin(0.377759844064713*x_12 - 7.57472038269043) + 0.00198788995677224*std::sin(0.266959965229034*x_120 - 1.2157598733902) - 2.65853208940279e-5*std::sin(0.308479934930801*x_120 + 4.75375986099243) - 0.000424028163819726*std::sin(0.218639984726906*x_13 - 4.38479995727539) + 0.00134012299007448*std::sin(0.456879854202271*x_13 - 4.82416009902954) + 0.000281348357469051*std::sin(0.269839972257614*x_14 - 7.42647981643677) - 0.00209606764152423*std::sin(0.297919929027557*x_14 + 1.96719980239868) + 0.000879092854525056*std::sin(0.352399855852127*x_14 + 8.24512004852295) - 0.000852688224445311*std::sin(0.508959829807281*x_15 + 1.68047988414764) - 0.000507588782438574*std::sin(0.314959913492203*x_16 + 1.78967988491058) - 0.00152756610488434*std::sin(0.398079842329025*x_16 + 1.80543982982635) - 8.54205312962449e-6*std::sin(0.547359883785248*x_16 - 7.54184007644653) - 0.00327841065934602*std::sin(0.129280045628548*x_17 - 1.43207991123199) - 0.000948734712712058*std::sin(0.447759836912155*x_18 - 1.21223986148834) - 0.000545165125644449*std::sin(0.479279845952988*x_18 - 1.2247998714447) + 0.00649853495506341*std::sin(0.156000033020973*x_19 - 1.41391980648041) + 0.00186476886163757*std::sin(0.30839991569519*x_19 + 5.02143955230713) + 0.00142570603107233*std::sin(0.338479846715927*x_19 - 4.35743999481201) + 0.00116141919460741*std::sin(0.34895983338356*x_19 - 4.37375974655151) + 0.00317319864270566*std::sin(0.351359844207764*x_19 - 4.35784006118774) + 2.12459780007565e-5*std::sin(0.363359838724136*x_19 - 7.79911994934082) - 0.000898246454508891*std::sin(0.403119832277298*x_2 + 5.21200037002563) + 0.000114911124411133*std::sin(0.488319844007492*x_2 - 4.37152004241943) + 3.45867874880337e-5*std::sin(0.255759954452515*x_20 - 1.35999977588654) + 0.00210798453978667*std::sin(0.262479960918427*x_20 + 8.19607925415039) + 0.000337529913994265*std::sin(0.284639924764633*x_20 + 4.99671983718872) - 0.00220335573231519*std::sin(0.355199843645096*x_20 - 7.57775974273682) - 0.000297267631913354*std::sin(0.398719847202301*x_20 + 1.37599992752075) + 0.00115595381675706*std::sin(0.229599997401237*x_21 - 4.40079975128174) + 0.00364457332284548*std::sin(0.275599956512451*x_21 + 8.02600002288818) + 0.0005808562953572*std::sin(0.309199929237366*x_21 - 7.78527975082397) - 0.000876453874682614*std::sin(0.313199937343597*x_22 - 4.34143972396851) - 4.76836694811284e-6*std::sin(0.748719871044159*x_22 + 7.81496000289917) - 0.0022292026815726*std::sin(0.188480004668236*x_23 - 7.60056018829346) - 0.00149769930954089*std::sin(0.220399990677834*x_23 - 4.39192008972168) + 0.000137427164710924*std::sin(0.638799846172333*x_23 - 1.57759976387024) + 0.0019019360657883*std::sin(0.319439917802811*x_24 + 5.02647972106934) + 0.00061939676637544*std::sin(0.345359832048416*x_24 - 1.18375980854034) + 0.00122106513849313*std::sin(0.352239847183228*x_24 + 1.8154399394989) - 0.00193668592609229*std::sin(0.411519855260849*x_24 - 1.18431985378265) - 0.000680691916168832*std::sin(0.5065598487854*x_24 + 4.93807983398438) + 0.000780195460517242*std::sin(0.261679977178574*x_25 + 2.00943970680237) + 2.13323245469185e-5*std::sin(0.323359847068787*x_25 - 1.16343986988068) + 0.000919823424994019*std::sin(0.291839927434921*x_26 - 1.17271983623505) - 0.000621583024136407*std::sin(0.338559836149216*x_26 - 7.57192039489746) + 0.000448854821672891*std::sin(0.355599850416183*x_26 - 4.35775947570801) - 0.00230497311770697*std::sin(0.408239871263504*x_27 + 1.97231984138489) + 0.00116929152843306*std::sin(0.319119930267334*x_28 - 1.18535983562469) - 0.000271263363594122*std::sin(0.39047983288765*x_28 - 1.36959993839264) + 0.000210247761406932*std::sin(0.475599855184555*x_28 + 4.95831966400146) - 0.00150604359333601*std::sin(0.233119979500771*x_29 + 5.00799989700317) - 0.000397265327197123*std::sin(0.551679849624634*x_29 - 1.37071990966797) + 0.00101060795168656*std::sin(0.301359921693802*x_3 - 4.32032012939453) - 0.000846777681478577*std::sin(0.326879858970642*x_3 + 1.99583983421326) - 0.00161680412394408*std::sin(0.440799862146378*x_3 - 1.1911199092865) - 0.000738183546917989*std::sin(0.286239951848984*x_30 - 4.36639976501465) + 0.000585585322185473*std::sin(0.325839847326279*x_30 - 1.13759982585907) + 1.47203177471425e-5*std::sin(0.729919850826263*x_31 - 4.79967975616455) - 0.00145571617073684*std::sin(0.321119844913483*x_32 + 2.00159978866577) + 0.00191029616845672*std::sin(0.251759976148605*x_33 + 1.96623980998993) - 0.000765744673564875*std::sin(0.276319950819016*x_33 - 7.61472034454346) - 0.000352673039923429*std::sin(0.239119976758957*x_34 + 7.97983980178833) + 0.00281923205640703*std::sin(0.257119953632355*x_34 - 1.4139199256897) + 0.00478578990943411*std::sin(0.285279929637909*x_34 + 1.77127993106842) - 0.00133050037915793*std::sin(0.248959973454475*x_35 + 1.96167981624603) + 0.000106748075004167*std::sin(0.279199957847595*x_35 - 1.43975985050201) - 0.0016637153307032*std::sin(0.202879995107651*x_36 - 4.39247989654541) + 0.000953558827892491*std::sin(0.202880010008812*x_37 - 8.00967979431152) - 0.00056223163895146*std::sin(0.186400011181831*x_38 + 5.01095962524414) - 0.00425402389903936*std::sin(0.251359969377518*x_38 + 4.96871948242188) - 0.00418009408311478*std::sin(0.253519982099533*x_38 - 7.62184000015259) + 0.000811979324432435*std::sin(0.239039987325668*x_4 + 5.00807952880859) - 0.000593495190694642*std::sin(0.333759844303131*x_4 + 8.01072025299072) + 0.00226545612497756*std::sin(0.404239863157272*x_4 - 4.41328001022339) + 0.00119319729331233*std::sin(0.427439838647842*x_4 - 1.18679988384247) + 0.000506099031823401*std::sin(0.442959845066071*x_4 + 1.78983998298645) - 0.000391246717499918*std::sin(0.216559991240501*x_40 - 7.80495977401733) + 0.00162463266883469*std::sin(0.228479996323586*x_40 - 1.21911990642548) + 0.0024382443047647*std::sin(0.27991995215416*x_41 - 1.22039985656738) + 0.0030390645488064*std::sin(0.224399983882904*x_42 - 1.21111989021301) - 0.00369387205995752*std::sin(0.229999989271164*x_42 + 1.96623980998993) + 0.000603063880035252*std::sin(0.328639835119247*x_42 - 1.31815981864929) + 0.0031823413001739*std::sin(0.304079920053482*x_43 + 1.91623985767365) + 0.00274624046250129*std::sin(0.118240058422089*x_44 + 8.16224002838135) - 0.0022459706218128*std::sin(0.257839977741241*x_44 - 7.44911956787109) - 0.00117055492006615*std::sin(0.336479842662811*x_44 - 1.34127986431122) - 9.88749973563627e-5*std::sin(0.342239856719971*x_44 - 1.53007984161377) - 0.00409798321316886*std::sin(0.181120008230209*x_45 + 1.99287974834442) + 0.0018699761520482*std::sin(0.183680012822151*x_45 - 1.18559980392456) + 0.00570134617689336*std::sin(0.198080003261566*x_46 - 4.59815979003906) - 0.000231941251751054*std::sin(0.380719840526581*x_48 - 1.99863982200623) + 0.00115249570731228*std::sin(0.261119961738586*x_49 + 1.94247984886169) + 0.000907008327187253*std::sin(0.328159838914871*x_49 - 7.46968030929565) + 0.00108600583076043*std::sin(0.412159860134125*x_49 + 4.97711944580078) - 0.00032816053317991*std::sin(0.453679859638214*x_49 + 7.36191987991333) + 0.00107286221422849*std::sin(0.168400019407272*x_5 - 4.60983991622925) + 0.000822494628426966*std::sin(0.311839938163757*x_5 - 7.56879997253418) - 0.00153231407337927*std::sin(0.373759835958481*x_5 - 7.38263988494873) - 0.00120728705046431*std::sin(0.416639864444733*x_5 + 1.96631979942322) + 0.000667625196361407*std::sin(0.451359868049622*x_5 - 1.2176798582077) - 0.00388011513402436*std::sin(0.12352005392313*x_50 + 1.63047981262207) - 0.00131834740181305*std::sin(0.247359976172447*x_52 + 1.96775984764099) + 0.00134979271208516*std::sin(0.341359823942184*x_52 - 1.33279979228973) + 0.00122546817703363*std::sin(0.202079996466637*x_53 - 1.19311988353729) + 0.000370835085200303*std::sin(0.240319982171059*x_53 - 1.19671988487244) + 0.00140089513911338*std::sin(0.266879975795746*x_53 - 7.61999988555908) - 0.000576262002877022*std::sin(0.233519986271858*x_55 + 7.96848011016846) + 1.59985968768527e-5*std::sin(0.277839958667755*x_55 + 4.72816038131714) + 0.00336495220465747*std::sin(0.195280000567436*x_56 - 1.18679988384247) - 0.000609593945243097*std::sin(0.267359972000122*x_56 - 4.42799949645996) - 0.010489752441311*std::sin(0.131920039653778*x_57 - 7.61880016326904) - 0.002684139178384*std::sin(0.449039846658707*x_57 - 1.30199992656708) + 1.93610431559821e-5*std::sin(0.452639847993851*x_57 - 7.50471973419189) - 0.000156678675571417*std::sin(0.106800064444542*x_58 - 7.62919998168945) - 0.00266684970263189*std::sin(0.239759981632233*x_58 - 7.61368036270142) - 0.000236342120989969*std::sin(0.548639833927155*x_58 + 1.6451997756958) - 0.00160995342249014*std::sin(0.148400038480759*x_59 - 1.5810399055481) + 0.00115845586965965*std::sin(0.250479966402054*x_59 - 7.6255202293396) + 0.00143529678824049*std::sin(0.448639839887619*x_59 + 1.88055980205536) - 0.000226919109645529*std::sin(0.363759845495224*x_6 - 1.77367985248566) - 0.00372707260156573*std::sin(0.197039991617203*x_60 + 5.00575971603394) - 0.000607055943948703*std::sin(0.523919880390167*x_60 + 8.08559989929199) + 3.55902233019398e-5*std::sin(1.41615986824036*x_62 + 3.77920007705688) - 5.50021956120204e-6*std::sin(0.801759898662567*x_63 + 8.58879947662354) + 3.27410169584976e-5*std::sin(1.67223989963531*x_63 - 9.78384017944336) - 0.0012110060615329*std::sin(0.430479854345322*x_7 - 4.4236798286438) - 0.000353813425415245*std::sin(0.463679850101471*x_7 + 4.96807956695557) + 0.00145444477164924*std::sin(0.172400012612343*x_8 + 7.81128025054932) - 0.000248670672119065*std::sin(0.174160018563271*x_8 + 8.00144004821777) + 3.98078043225503e-5*std::sin(0.703439831733704*x_8 + 4.0403995513916) - 0.00719144707868265*std::sin(0.171280011534691*x_9 - 1.4197598695755) + 0.000110637909402447*std::sin(0.263279944658279*x_9 + 4.32567977905273) - 2.11214530013121e-5*std::sin(0.433199852705002*x_9 + 7.36879968643188) + 0.000697132750215146*std::sin(0.318399846553802*x_91 - 1.21383988857269) - 0.000494949677915352*std::sin(0.347679853439331*x_91 - 7.39775943756104) - 0.00134671143467949*std::sin(0.325039833784103*x_92 - 1.18871986865997) - 0.000570962311245167*std::sin(0.27007994055748*x_94 - 4.40319967269897) - 2.26127170010552e-5*std::sin(0.282559931278229*x_94 + 8.19808006286621) - 0.000533231162359426*std::sin(0.316559940576553*x_94 + 4.78975963592529) - 0.000687902358082266*std::sin(0.346959829330444*x_94 + 4.61783981323242) - 5.11939141439165e-5*std::sin(0.450159847736359*x_94 - 2.01663970947266) - 0.000607110934554561*std::sin(0.324079841375351*x_95 - 1.36367988586426) - 0.000990065829518435*std::sin(0.258719980716705*x_96 + 8.19823932647705) - 0.00087092325369073*std::sin(0.260559976100922*x_97 + 1.97991979122162) - 0.000828185447077796*std::sin(0.279599964618683*x_97 - 4.40623998641968) + 0.000671518311410335*std::sin(0.276239961385727*x_98 + 4.97775983810425) + 0.000819229357726215*std::sin(0.313599914312363*x_98 + 4.77895975112915) + 0.0543441886714435);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000170276590885558*x_1 - 0.000145448495310325*x_10 - 0.00255621828270743*x_100 + 0.00147884518085198*x_101 + 4.59603276490135e-5*x_102 - 0.000291631677053335*x_103 + 4.3272968860781e-5*x_104 - 0.000550861242149817*x_105 + 0.000348048656179064*x_106 + 0.000512988969048134*x_107 + 0.00111306688297269*x_108 + 4.69876502115938e-5*x_109 - 0.000561024023005538*x_11 - 8.05564479887064e-5*x_110 - 5.9497426692715e-5*x_111 + 0.000238732617638762*x_112 + 0.000176083688729884*x_113 - 0.00139389122244136*x_114 + 0.000633394726050594*x_115 + 0.00079327393466497*x_116 - 0.000203792536580554*x_117 - 0.00122891739042303*x_118 + 0.000740056730732092*x_119 + 2.71511186088128e-5*x_12 - 0.00145176541568553*x_120 - 0.000230906903456449*x_13 - 7.22132863931549e-5*x_14 + 0.000705030414301579*x_15 + 0.000403697410805218*x_16 + 0.000297854626208137*x_17 - 0.000221243932907586*x_18 + 6.65656389033739e-6*x_19 + 5.97782655486436e-5*x_2 + 0.000226129757156547*x_20 + 0.00014583816948505*x_21 + 9.96304742367084e-5*x_22 + 7.25895543181463e-5*x_23 - 2.22929149105269e-5*x_24 + 0.000170924822731461*x_25 + 1.76203715075966e-5*x_26 - 0.00036469886481137*x_27 + 0.000565822571421656*x_28 + 0.00031145178249415*x_29 - 4.94477109510913e-5*x_3 - 3.44454581868442e-5*x_30 + 4.2723245569217e-5*x_31 + 0.000324116633144478*x_32 + 0.000169312492558842*x_33 - 8.13915276818248e-5*x_34 - 0.000450767563586204*x_35 + 0.000107023765143967*x_36 - 0.000194005964778641*x_37 - 0.000331925574447339*x_38 + 0.00121889470278234*x_39 - 0.000511830693492437*x_4 - 5.51723339249528e-5*x_40 + 0.00206186467889982*x_41 + 0.00190024581982317*x_42 - 0.000751648213188472*x_43 + 0.000179169635365023*x_44 - 0.00102701860726878*x_45 + 0.00167984633356938*x_46 - 0.0038863530601885*x_47 - 0.00264131347711796*x_48 - 0.000122432007643509*x_49 - 2.78061797039448e-6*x_5 + 0.00196440043909475*x_50 - 0.000749166435444035*x_51 + 2.75190617990706e-5*x_52 - 0.000822149938972089*x_53 + 0.00248920707322375*x_54 - 0.00309193841950156*x_55 - 0.00181098011487574*x_56 + 0.00150832665496289*x_57 + 0.00140065976428486*x_58 - 5.02375446701597e-5*x_59 - 0.000189809474208546*x_6 - 0.000128471751864105*x_60 + 3.9089903273351e-5*x_61 - 7.50362632930203e-6*x_62 - 4.06189437417028e-6*x_63 + 6.62659583468771e-5*x_64 + 2.18998391885612e-5*x_65 + 4.43931979019997e-5*x_66 + 2.53057703054364e-5*x_67 + 1.44620639750951e-5*x_68 + 1.95602755919414e-6*x_69 + 7.01702478952551e-5*x_7 - 2.54218062323478e-5*x_70 + 2.28244431909437e-5*x_71 - 1.24893777492306e-5*x_72 - 1.36655867357047e-5*x_73 - 2.07527164576195e-5*x_74 + 8.64912061158787e-6*x_75 - 1.5623203479756e-5*x_76 + 0.000156280490440146*x_77 - 0.000165920338003229*x_78 + 1.73320801360517e-5*x_79 + 0.000196681547408948*x_8 - 4.49438321537343e-6*x_80 - 2.25570165650811e-5*x_81 - 2.48049005297691e-5*x_82 - 0.000123433102024041*x_83 - 3.26369951493268e-5*x_84 - 2.88594080846825e-6*x_85 - 2.03068246584338e-5*x_86 - 7.65066976851885e-6*x_87 - 2.26509291666396e-5*x_88 + 3.40521241168639e-5*x_89 - 2.28433727347834e-5*x_9 + 7.97533288728422e-5*x_90 - 2.93804154098044e-5*x_91 - 2.64103376955808e-5*x_92 - 0.00130255613066788*x_93 - 4.93223992396117e-6*x_94 + 1.38598913360966e-5*x_95 - 0.000433173861569853*x_96 + 2.56634937354823e-5*x_97 + 0.000434200607320219*x_98 - 0.000215166729291632*x_99 + 1.80088818182571e-5*std::pow(0.586719870567322 - 2.74799990653992*x_8, 2) + 1.06963971503086e-7*std::pow(5.50623989105225 - 9.58327960968018*x_6, 2) - 9.01393536669683e-7*std::pow(5.90783977508545 - 6.72600030899048*x_41, 2) + 2.33923218681931e-8*std::pow(-7.36751985549927*x_11 - 5.58879995346069, 2) + 4.2874700050959e-7*std::pow(-5.96751976013184*x_12 - 7.36407995223999, 2) + 5.55040730411597e-8*std::pow(-6.45391988754272*x_17 - 1.20223987102509, 2) - 7.06139157935361e-7*std::pow(-7.15599966049194*x_19 - 8.56088066101074, 2) - 4.14913103422553e-8*std::pow(-5.99191999435425*x_26 - 0.821199893951416, 2) - 2.2202788700703e-5*std::pow(-3.90079998970032*x_27 - 7.59823989868164, 2) - 2.53566896373564e-7*std::pow(-8.39199924468994*x_30 - 6.94776010513306, 2) - 6.39571798191599e-8*std::pow(-6.28359985351563*x_32 - 4.66207981109619, 2) + 1.91833265339823e-5*std::pow(-3.47567987442017*x_43 - 8.39967918395996, 2) + 2.37278659975248e-6*std::pow(-2.60359978675842*x_52 - 6.60096025466919, 2) + 2.51201910395393e-7*std::pow(-2.68167996406555*x_58 - 5.57872009277344, 2) + 0.00031150864741393*std::exp(0.198239862918854*x_13) + 0.003085818462446*std::exp(0.208159849047661*x_14) + 0.000442073549245571*std::exp(0.311599850654602*x_18) + 8.48206615475063e-5*std::exp(0.619279801845551*x_18) - 0.000106366062048225*std::exp(0.370399862527847*x_19) + 0.000165172520132206*std::exp(0.318559855222702*x_26) - 2.40353557932018e-5*std::exp(0.265839844942093*x_27) - 6.00908364223066e-5*std::exp(0.417679876089096*x_27) + 3.70126673326101e-6*std::exp(0.427119851112366*x_30) - 0.000602145264864713*std::exp(0.188799858093262*x_43) - 0.000147612105223371*std::exp(0.285439848899841*x_49) + 7.92705723855012e-5*std::exp(0.19327986240387*x_56) - 0.000420272979208877*std::exp(0.225839853286743*x_60) - 2.95474781246554e-5*std::exp(0.243999853730202*x_8) - 0.000261146934641807*std::sin(0.143360033631325*x_1 + 4.91999959945679) - 0.00706005404885899*std::sin(0.184320002794266*x_10 + 1.76455986499786) + 1.8429497536482e-6*std::sin(0.596159815788269*x_10 + 4.99143981933594) - 0.000120099887872064*std::sin(0.249439969658852*x_100 - 7.61488008499146) + 0.00100088002589788*std::sin(0.276079952716827*x_100 + 1.78791987895966) + 0.000224624163399968*std::sin(0.227279990911484*x_102 - 1.39095985889435) + 0.0146818514354665*std::sin(0.237599983811378*x_102 + 8.17735958099365) + 0.0011329789955989*std::sin(0.254479974508286*x_102 + 1.77367985248566) + 0.000542909117042733*std::sin(0.291839927434921*x_102 + 1.5759197473526) - 0.000107233791736698*std::sin(0.256239980459213*x_103 + 1.96455979347229) - 0.0132056347951639*std::sin(0.215120002627373*x_104 - 4.39056015014648) - 0.000285327475006378*std::sin(0.31183984875679*x_105 + 4.43111991882324) + 4.1375885676346e-6*std::sin(1.16343986988068*x_106 - 5.78295993804932) - 0.0085327165205686*std::sin(0.259199976921082*x_107 - 7.43327951431274) + 0.000124736293381402*std::sin(0.278879970312119*x_107 + 1.76543986797333) + 0.0144853830201421*std::sin(0.238079980015755*x_109 - 1.21103978157043) - 9.31100385750559e-5*std::sin(0.239439979195595*x_109 + 8.19032001495361) - 0.00111912671239872*std::sin(0.25927996635437*x_109 - 4.41807985305786) - 0.00126971040822164*std::sin(0.277599930763245*x_109 + 4.95183992385864) + 3.51694904913135e-5*std::sin(0.386879861354828*x_11 - 2.18583989143372) - 0.0025233787665631*std::sin(0.312159925699234*x_110 + 1.51447987556458) + 6.50979431518662e-5*std::sin(0.287199944257736*x_112 + 4.56680011749268) + 1.84625391433894e-5*std::sin(0.233039990067482*x_113 + 5.00207996368408) + 9.02634321098512e-5*std::sin(0.286159932613373*x_113 - 1.19527995586395) + 1.89830869001175e-5*std::sin(0.295519918203354*x_114 + 7.73567962646484) + 0.00133784274137057*std::sin(0.253679990768433*x_116 + 5.15799999237061) - 0.000976011397288347*std::sin(0.247519969940186*x_117 - 7.43887996673584) - 0.0107701142942964*std::sin(0.26063996553421*x_117 - 1.22167980670929) + 0.00102968384294836*std::sin(0.29615992307663*x_117 + 4.76168012619019) - 0.000504713247225099*std::sin(0.23039998114109*x_118 - 4.41991996765137) + 0.000709133480492204*std::sin(0.284399926662445*x_118 + 1.75903987884521) - 0.000710580589563798*std::sin(0.22087998688221*x_119 - 4.40064001083374) + 0.000183657837426037*std::sin(0.309679925441742*x_119 + 7.73167991638184) + 0.00145510755985509*std::sin(0.23879998922348*x_12 + 5.00543975830078) - 0.0091761291473628*std::sin(0.377759844064713*x_12 - 7.57472038269043) + 0.00170111175789529*std::sin(0.266959965229034*x_120 - 1.2157598733902) + 0.000564308586333538*std::sin(0.308479934930801*x_120 + 4.75375986099243) - 0.000176260658841914*std::sin(0.218639984726906*x_13 - 4.38479995727539) - 0.000132791156986421*std::sin(0.456879854202271*x_13 - 4.82416009902954) + 0.00011695130437767*std::sin(0.269839972257614*x_14 - 7.42647981643677) - 0.00179368344721169*std::sin(0.297919929027557*x_14 + 1.96719980239868) + 0.00846210501322165*std::sin(0.352399855852127*x_14 + 8.24512004852295) + 0.000539761582392387*std::sin(0.508959829807281*x_15 + 1.68047988414764) - 0.000434362698518801*std::sin(0.314959913492203*x_16 + 1.78967988491058) + 0.000966967145016825*std::sin(0.398079842329025*x_16 + 1.80543982982635) - 8.3643602174471e-6*std::sin(0.547359883785248*x_16 - 7.54184007644653) + 0.0199341453569304*std::sin(0.129280045628548*x_17 - 1.43207991123199) - 7.35697313429963e-5*std::sin(0.447759836912155*x_18 - 1.21223986148834) - 0.000533824529031048*std::sin(0.479279845952988*x_18 - 1.2247998714447) - 0.00411364835354571*std::sin(0.156000033020973*x_19 - 1.41391980648041) - 0.0113385958647341*std::sin(0.30839991569519*x_19 + 5.02143955230713) + 0.0137237768351963*std::sin(0.338479846715927*x_19 - 4.35743999481201) + 9.00623714711694e-5*std::sin(0.34895983338356*x_19 - 4.37375974655151) + 0.000872550703469089*std::sin(0.351359844207764*x_19 - 4.35784006118774) - 0.000450973973896009*std::sin(0.363359838724136*x_19 - 7.79911994934082) - 6.96546141429891e-5*std::sin(0.403119832277298*x_2 + 5.21200037002563) + 0.0011061288883752*std::sin(0.488319844007492*x_2 - 4.37152004241943) - 0.00073415029410366*std::sin(0.255759954452515*x_20 - 1.35999977588654) + 0.000163463878984644*std::sin(0.262479960918427*x_20 + 8.19607925415039) + 0.00324904651723765*std::sin(0.284639924764633*x_20 + 4.99671983718872) + 0.00139474985411161*std::sin(0.355199843645096*x_20 - 7.57775974273682) - 8.17412051845025e-5*std::sin(0.398719847202301*x_20 + 1.37599992752075) - 0.00702869585402408*std::sin(0.229599997401237*x_21 - 4.40079975128174) - 0.000361136337371244*std::sin(0.275599956512451*x_21 + 8.02600002288818) + 0.000497060448599491*std::sin(0.309199929237366*x_21 - 7.78527975082397) - 6.7964706288235e-5*std::sin(0.313199937343597*x_22 - 4.34143972396851) + 0.000101214893073327*std::sin(0.748719871044159*x_22 + 7.81496000289917) - 0.0214581964693753*std::sin(0.188480004668236*x_23 - 7.60056018829346) - 0.000116139247736111*std::sin(0.220399990677834*x_23 - 4.39192008972168) - 8.69929966915181e-5*std::sin(0.638799846172333*x_23 - 1.57759976387024) + 0.00162755779979439*std::sin(0.319439917802811*x_24 + 5.02647972106934) + 0.00596228311371117*std::sin(0.345359832048416*x_24 - 1.18375980854034) + 9.46876223538188e-5*std::sin(0.352239847183228*x_24 + 1.8154399394989) + 0.0012259447592872*std::sin(0.411519855260849*x_24 - 1.18431985378265) - 0.000187173346888996*std::sin(0.5065598487854*x_24 + 4.93807983398438) + 6.05003376140821e-5*std::sin(0.261679977178574*x_25 + 2.00943970680237) - 0.000452806793503252*std::sin(0.323359847068787*x_25 - 1.16343986988068) + 0.0088541755013193*std::sin(0.291839927434921*x_26 - 1.17271983623505) - 0.000608652772352352*std::sin(0.338559836149216*x_26 - 7.57192039489746) - 0.000284130332593975*std::sin(0.355599850416183*x_26 - 4.35775947570801) - 0.000633810278456972*std::sin(0.408239871263504*x_27 + 1.97231984138489) - 0.000740175163173633*std::sin(0.319119930267334*x_28 - 1.18535983562469) - 0.000232130202038672*std::sin(0.39047983288765*x_28 - 1.36959993839264) + 8.73961026828833e-5*std::sin(0.475599855184555*x_28 + 4.95831966400146) - 0.0144971022977821*std::sin(0.233119979500771*x_29 + 5.00799989700317) + 3.93645380459918e-5*std::sin(0.551679849624634*x_29 - 1.37071990966797) + 7.83676980534823e-5*std::sin(0.301359921693802*x_3 - 4.32032012939453) - 0.00815104073095368*std::sin(0.326879858970642*x_3 + 1.99583983421326) + 0.00102345585096627*std::sin(0.440799862146378*x_3 - 1.1911199092865) + 0.00448847312108636*std::sin(0.286239951848984*x_30 - 4.36639976501465) + 0.00563681579827182*std::sin(0.325839847326279*x_30 - 1.13759982585907) + 1.14148856095402e-6*std::sin(0.729919850826263*x_31 - 4.79967975616455) - 0.0012457107526312*std::sin(0.321119844913483*x_32 + 2.00159978866577) + 0.0183884179021898*std::sin(0.251759976148605*x_33 + 1.96623980998993) - 5.93797498464633e-5*std::sin(0.276319950819016*x_33 - 7.61472034454346) - 0.000146599654637828*std::sin(0.239119976758957*x_34 + 7.97983980178833) - 0.000279354275209241*std::sin(0.257119953632355*x_34 - 1.4139199256897) + 0.00131597319371454*std::sin(0.285279929637909*x_34 + 1.77127993106842) - 0.0128073318655837*std::sin(0.248959973454475*x_35 + 1.96167981624603) + 4.43731988480363e-5*std::sin(0.279199957847595*x_35 - 1.43975985050201) - 0.00012901297725385*std::sin(0.202879995107651*x_36 - 4.39247989654541) - 0.00579804736401902*std::sin(0.202880010008812*x_37 - 8.00967979431152) - 0.00541201438058939*std::sin(0.186400011181831*x_38 + 5.01095962524414) + 0.000421526053642232*std::sin(0.251359969377518*x_38 + 4.96871948242188) - 0.00114942190624374*std::sin(0.253519982099533*x_38 - 7.62184000015259) + 0.000795088423779307*std::sin(0.239039987325668*x_4 + 5.00807952880859) - 0.000507876023874212*std::sin(0.333759844303131*x_4 + 8.01072025299072) - 0.000224481291766381*std::sin(0.404239863157272*x_4 - 4.41328001022339) - 0.00075530779091448*std::sin(0.427439838647842*x_4 - 1.18679988384247) - 0.00307729955568833*std::sin(0.442959845066071*x_4 + 1.78983998298645) - 3.0339267141408e-5*std::sin(0.216559991240501*x_40 - 7.80495977401733) + 0.00139025891538932*std::sin(0.228479996323586*x_40 - 1.21911990642548) + 0.00208649681101622*std::sin(0.27991995215416*x_41 - 1.22039985656738) + 0.00260064115690365*std::sin(0.224399983882904*x_42 - 1.21111989021301) + 0.00233826405839568*std::sin(0.229999989271164*x_42 + 1.96623980998993) + 4.67646509001762e-5*std::sin(0.328639835119247*x_42 - 1.31815981864929) + 0.000875064706878183*std::sin(0.304079920053482*x_43 + 1.91623985767365) + 0.0264351769731987*std::sin(0.118240058422089*x_44 + 8.16224002838135) - 0.000174164023975351*std::sin(0.257839977741241*x_44 - 7.44911956787109) - 0.000321873489168659*std::sin(0.336479842662811*x_44 - 1.34127986431122) + 9.79740321838e-6*std::sin(0.342239856719971*x_44 - 1.53007984161377) + 0.00259407112745853*std::sin(0.181120008230209*x_45 + 1.99287974834442) + 0.000145007493960801*std::sin(0.183680012822151*x_45 - 1.18559980392456) - 0.000564939457659556*std::sin(0.198080003261566*x_46 - 4.59815979003906) + 0.000146821515154218*std::sin(0.380719840526581*x_48 - 1.99863982200623) + 8.93703987266818e-5*std::sin(0.261119961738586*x_49 + 1.94247984886169) + 0.000776160936188057*std::sin(0.328159838914871*x_49 - 7.46968030929565) + 0.0104538392475397*std::sin(0.412159860134125*x_49 + 4.97711944580078) + 3.25170280645803e-5*std::sin(0.453679859638214*x_49 + 7.36191987991333) - 0.00652346321087644*std::sin(0.168400019407272*x_5 - 4.60983991622925) + 6.37804309609935e-5*std::sin(0.311839938163757*x_5 - 7.56879997253418) - 0.00042134825871558*std::sin(0.373759835958481*x_5 - 7.38263988494873) - 0.00103312066631406*std::sin(0.416639864444733*x_5 + 1.96631979942322) + 0.00642652763243673*std::sin(0.451359868049622*x_5 - 1.2176798582077) + 0.002456158094558*std::sin(0.12352005392313*x_50 + 1.63047981262207) - 0.00112815916121248*std::sin(0.247359976172447*x_52 + 1.96775984764099) - 0.00820731961925669*std::sin(0.341359823942184*x_52 - 1.33279979228973) + 9.5029056432468e-5*std::sin(0.202079996466637*x_53 - 1.19311988353729) + 0.000154149280675827*std::sin(0.240319982171059*x_53 - 1.19671988487244) - 0.00851804433141819*std::sin(0.266879975795746*x_53 - 7.61999988555908) + 0.00350392056476472*std::sin(0.233519986271858*x_55 + 7.96848011016846) - 0.00033959137160255*std::sin(0.277839958667755*x_55 + 4.72816038131714) + 0.00287951540808269*std::sin(0.195280000567436*x_56 - 1.18679988384247) + 0.00370659309520565*std::sin(0.267359972000122*x_56 - 4.42799949645996) + 0.00664013553172924*std::sin(0.131920039653778*x_57 - 7.61880016326904) - 0.000738071514587229*std::sin(0.449039846658707*x_57 - 1.30199992656708) - 0.000410963739608243*std::sin(0.452639847993851*x_57 - 7.50471973419189) + 0.00332571204510752*std::sin(0.106800064444542*x_58 - 7.62919998168945) + 0.00168814693838613*std::sin(0.239759981632233*x_58 - 7.61368036270142) - 0.000202246789130497*std::sin(0.548639833927155*x_58 + 1.6451997756958) - 0.015497333253684*std::sin(0.148400038480759*x_59 - 1.5810399055481) + 8.98325801318542e-5*std::sin(0.250479966402054*x_59 - 7.6255202293396) + 0.000394670918300381*std::sin(0.448639839887619*x_59 + 1.88055980205536) - 1.75964658081192e-5*std::sin(0.363759845495224*x_6 - 1.77367985248566) + 0.00235928038811735*std::sin(0.197039991617203*x_60 + 5.00575971603394) - 4.70742159088994e-5*std::sin(0.523919880390167*x_60 + 8.08559989929199) - 0.0002164038487869*std::sin(1.41615986824036*x_62 + 3.77920007705688) - 5.29448456816469e-5*std::sin(0.801759898662567*x_63 + 8.58879947662354) - 0.000199079450075546*std::sin(1.67223989963531*x_63 - 9.78384017944336) - 0.00103630316312932*std::sin(0.430479854345322*x_7 - 4.4236798286438) - 2.74364986382077e-5*std::sin(0.463679850101471*x_7 + 4.96807956695557) + 0.00142418922030184*std::sin(0.172400012612343*x_8 + 7.81128025054932) - 0.000212796791263196*std::sin(0.174160018563271*x_8 + 8.00144004821777) + 3.08690030007729e-6*std::sin(0.703439831733704*x_8 + 4.0403995513916) - 0.00197746908214827*std::sin(0.171280011534691*x_9 - 1.4197598695755) + 8.57942811834182e-6*std::sin(0.263279944658279*x_9 + 4.32567977905273) - 8.7797970497369e-6*std::sin(0.433199852705002*x_9 + 7.36879968643188) + 0.000596562558286892*std::sin(0.318399846553802*x_91 - 1.21383988857269) - 3.83809239238687e-5*std::sin(0.347679853439331*x_91 - 7.39775943756104) + 0.000852484031289852*std::sin(0.325039833784103*x_92 - 1.18871986865997) - 0.000488593796485239*std::sin(0.27007994055748*x_94 - 4.40319967269897) + 0.000479984816240916*std::sin(0.282559931278229*x_94 + 8.19808006286621) - 0.00513285720499404*std::sin(0.316559940576553*x_94 + 4.78975963592529) + 0.000435450208745967*std::sin(0.346959829330444*x_94 + 4.61783981323242) + 0.000311280993131781*std::sin(0.450159847736359*x_94 - 2.01663970947266) - 0.00584402029482018*std::sin(0.324079841375351*x_95 - 1.36367988586426) - 7.67747570670566e-5*std::sin(0.258719980716705*x_96 + 8.19823932647705) - 0.00838346483338135*std::sin(0.260559976100922*x_97 + 1.97991979122162) - 6.42217260813823e-5*std::sin(0.279599964618683*x_97 - 4.40623998641968) + 5.20729568554902e-5*std::sin(0.276239961385727*x_98 + 4.97775983810425) + 0.000225267697636805*std::sin(0.313599914312363*x_98 + 4.77895975112915) + 0.00279923774536836);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.55607871993182e-5*x_1 + 0.000126390572609599*x_10 + 0.00224037653206346*x_100 - 0.00159938871255091*x_101 + 3.93102691092937e-5*x_102 + 0.000185439649701226*x_103 + 6.00261136845772e-5*x_104 - 0.000161032075677696*x_105 - 0.000125792478766478*x_106 - 0.000234548621210263*x_107 - 0.00136342807995667*x_108 + 0.000282961920627674*x_109 + 0.000225457173256792*x_11 - 4.40313748501153e-5*x_110 + 0.000211249972002602*x_111 - 8.1716310377494e-5*x_112 + 8.20005367085742e-5*x_113 + 0.00197868354755006*x_114 - 7.1883703465207e-5*x_115 - 0.00057613535934033*x_116 + 0.000177204518891486*x_117 + 0.000831794156455863*x_118 - 0.000769528132394145*x_119 - 0.000253094284121215*x_12 + 0.00105533631703212*x_120 + 3.48764706379005e-5*x_13 - 0.00019887887980903*x_14 - 0.000555835512754624*x_15 - 0.000308046525384538*x_16 - 8.82435336869775e-5*x_17 + 3.21250164889828e-5*x_18 - 3.41171425362661e-6*x_19 + 0.000163233267134485*x_2 + 3.92112032283704e-5*x_20 - 0.000110360771313915*x_21 - 0.000143464081773801*x_22 - 1.55471272611662e-5*x_23 - 0.000215597431919656*x_24 - 0.000519239496605065*x_25 + 3.69919325581417e-5*x_26 + 0.00019781418861317*x_27 - 0.000333876001250902*x_28 + 5.43238012710156e-5*x_29 + 8.89299085664181e-5*x_3 - 0.000105811434677957*x_30 - 4.67318314009841e-5*x_31 - 0.000261865450900039*x_32 + 0.000595312005461987*x_33 - 0.000134061698530645*x_34 - 0.000149565482901773*x_35 - 0.000641888614120731*x_36 - 0.000160564437516608*x_37 + 1.8284475545965e-6*x_38 - 0.000770366304375658*x_39 + 0.000448364039949728*x_4 - 0.00017687389458772*x_40 - 0.00130964480835283*x_41 - 0.00195079196530062*x_42 + 0.000318989218971144*x_43 + 0.000401659574845534*x_44 + 0.000773043458391029*x_45 - 0.000913347521515771*x_46 + 0.00276570535998112*x_47 + 0.00177249310117102*x_48 - 4.19404950750617e-5*x_49 - 1.47346160146276e-6*x_5 - 0.00132690265083829*x_50 + 0.000757594386681535*x_51 - 1.69070516161518e-6*x_52 + 0.000570326444426262*x_53 - 0.00193165685140099*x_54 + 0.00186156935312451*x_55 + 0.00150799066112316*x_56 - 0.00111001033335823*x_57 - 0.00119677118924978*x_58 - 8.28537506385302e-6*x_59 + 1.35998464699633e-5*x_6 - 9.14616458067852e-5*x_60 - 3.52254080698688e-5*x_61 - 2.3013947273533e-5*x_62 - 7.33877176993924e-6*x_63 - 4.73766886198111e-5*x_64 - 1.51171282527048e-5*x_65 - 2.33528107053702e-6*x_66 - 2.11816315103325e-5*x_67 - 3.18888252062426e-6*x_68 + 7.40997543084211e-6*x_69 - 8.94945345643851e-5*x_7 - 6.04820716812114e-6*x_70 - 2.15501990591727e-5*x_71 - 7.51082629025609e-7*x_72 + 3.34741257215201e-5*x_73 + 5.08816139197574e-6*x_74 - 1.81086209232062e-5*x_75 + 2.40542969773674e-5*x_76 - 9.11413987593705e-5*x_77 + 0.000138153806997347*x_78 - 1.87431283220952e-6*x_79 + 0.000237769677479256*x_8 + 1.66103644517466e-6*x_80 + 1.26684745765921e-5*x_81 + 2.9495865039296e-5*x_82 + 1.61711064123141e-5*x_83 + 1.80236174050063e-5*x_84 + 6.22805720607552e-6*x_85 - 2.35178408532071e-5*x_86 - 2.18169402704454e-5*x_87 + 2.85726562702131e-5*x_88 - 2.95973175974877e-5*x_89 - 0.000194877273644754*x_9 - 5.64722324200277e-5*x_90 + 6.56065734594683e-6*x_91 - 8.53131131995967e-5*x_92 + 0.000698055847839202*x_93 - 2.54554706907698e-5*x_94 - 7.31156521194316e-5*x_95 + 0.000418639414700902*x_96 - 4.42798444270483e-5*x_97 - 0.000783335902250542*x_98 - 4.7765989211941e-6*x_99 - 9.62171632198429e-6*std::pow(0.586719870567322 - 2.74799990653992*x_8, 2) - 1.31483707312183e-7*std::pow(5.50623989105225 - 9.58327960968018*x_6, 2) + 4.8159308233748e-7*std::pow(5.90783977508545 - 6.72600030899048*x_41, 2) + 9.05202236682552e-9*std::pow(-7.36751985549927*x_11 - 5.58879995346069, 2) + 9.64122027668938e-7*std::pow(-5.96751976013184*x_12 - 7.36407995223999, 2) + 9.4512038793717e-8*std::pow(-6.45391988754272*x_17 - 1.20223987102509, 2) - 6.86179532239563e-7*std::pow(-7.15599966049194*x_19 - 8.56088066101074, 2) - 9.43308709460676e-8*std::pow(-5.99191999435425*x_26 - 0.821199893951416, 2) + 1.94768516691377e-5*std::pow(-3.90079998970032*x_27 - 7.59823989868164, 2) - 5.70195080060814e-7*std::pow(-8.39199924468994*x_30 - 6.94776010513306, 2) + 7.30909141271819e-9*std::pow(-6.28359985351563*x_32 - 4.66207981109619, 2) - 1.68281025622325e-5*std::pow(-3.47567987442017*x_43 - 8.39967918395996, 2) - 2.71164460495305e-7*std::pow(-2.60359978675842*x_52 - 6.60096025466919, 2) + 5.71109825056091e-7*std::pow(-2.68167996406555*x_58 - 5.57872009277344, 2) - 0.000382916894784571*std::exp(0.198239862918854*x_13) - 0.0016486792554048*std::exp(0.208159849047661*x_14) + 0.000752760475884178*std::exp(0.311599850654602*x_18) - 7.44068443702573e-5*std::exp(0.619279801845551*x_18) - 0.000181119561715442*std::exp(0.370399862527847*x_19) + 0.000371422925025196*std::exp(0.318559855222702*x_26) - 5.4644599719048e-5*std::exp(0.265839844942093*x_27) - 0.00010232235495367*std::exp(0.417679876089096*x_27) + 8.41486353822489e-6*std::exp(0.427119851112366*x_30) - 0.00102532973733557*std::exp(0.188799858093262*x_43) - 0.000143439723143553*std::exp(0.285439848899841*x_49) + 3.06749795213914e-5*std::exp(0.19327986240387*x_56) + 0.000516613665452061*std::exp(0.225839853286743*x_60) + 3.37671578451462e-6*std::exp(0.243999853730202*x_8) - 0.000593719928015134*std::sin(0.143360033631325*x_1 + 4.91999959945679) + 0.00377201860512692*std::sin(0.184320002794266*x_10 + 1.76455986499786) + 7.13158038990668e-7*std::sin(0.596159815788269*x_10 + 4.99143981933594) - 0.000273048185994723*std::sin(0.249439969658852*x_100 - 7.61488008499146) - 0.000114381585040744*std::sin(0.276079952716827*x_100 + 1.78791987895966) + 0.000505111647715822*std::sin(0.227279990911484*x_102 - 1.39095985889435) - 0.012879293970304*std::sin(0.237599983811378*x_102 + 8.17735958099365) - 0.000129477989350637*std::sin(0.254479974508286*x_102 + 1.77367985248566) + 0.000924462741560512*std::sin(0.291839927434921*x_102 + 1.5759197473526) - 0.000243796999562827*std::sin(0.256239980459213*x_103 + 1.96455979347229) + 0.0115843191397875*std::sin(0.215120002627373*x_104 - 4.39056015014648) - 0.000277262450516721*std::sin(0.31183984875679*x_105 + 4.43111991882324) + 1.60110417725896e-6*std::sin(1.16343986988068*x_106 - 5.78295993804932) + 0.00748511622779411*std::sin(0.259199976921082*x_107 - 7.43327951431274) + 0.000283589096034616*std::sin(0.278879970312119*x_107 + 1.76543986797333) - 0.0127069468730755*std::sin(0.238079980015755*x_109 - 1.21103978157043) - 0.000211686518457868*std::sin(0.239439979195595*x_109 + 8.19032001495361) + 0.00137566815284185*std::sin(0.25927996635437*x_109 - 4.41807985305786) + 0.000145103793938574*std::sin(0.277599930763245*x_109 + 4.95183992385864) - 1.94581096270766e-5*std::sin(0.386879861354828*x_11 - 2.18583989143372) + 0.00134818113138901*std::sin(0.312159925699234*x_110 + 1.51447987556458) + 2.51906604553978e-5*std::sin(0.287199944257736*x_112 + 4.56680011749268) - 1.02147089886046e-5*std::sin(0.233039990067482*x_113 + 5.00207996368408) + 0.000205214732802307*std::sin(0.286159932613373*x_113 - 1.19527995586395) + 4.31582204987465e-5*std::sin(0.295519918203354*x_114 + 7.73567962646484) - 0.000152890026110714*std::sin(0.253679990768433*x_116 + 5.15799999237061) - 0.00166194698856102*std::sin(0.247519969940186*x_117 - 7.43887996673584) + 0.00944781853294983*std::sin(0.26063996553421*x_117 - 1.22167980670929) - 0.000117673314483043*std::sin(0.29615992307663*x_117 + 4.76168012619019) - 0.00113494708704126*std::sin(0.23039998114109*x_118 - 4.41991996765137) + 0.00120750869883913*std::sin(0.284399926662445*x_118 + 1.75903987884521) + 0.000873469533217818*std::sin(0.22087998688221*x_119 - 4.40064001083374) + 0.000312731583548974*std::sin(0.309679925441742*x_119 + 7.73167991638184) - 0.000166291168566067*std::sin(0.23879998922348*x_12 + 5.00543975830078) + 0.0049025870945696*std::sin(0.377759844064713*x_12 - 7.57472038269043) + 0.00289664400548447*std::sin(0.266959965229034*x_120 - 1.2157598733902) + 0.00126895893811556*std::sin(0.308479934930801*x_120 + 4.75375986099243) - 6.82068003004803e-5*std::sin(0.218639984726906*x_13 - 4.38479995727539) + 7.34689315668735e-5*std::sin(0.456879854202271*x_13 - 4.82416009902954) + 4.52561241684838e-5*std::sin(0.269839972257614*x_14 - 7.42647981643677) - 0.0030542745830708*std::sin(0.297919929027557*x_14 + 1.96719980239868) - 0.00742317401534188*std::sin(0.352399855852127*x_14 + 8.24512004852295) - 6.16845013794293e-5*std::sin(0.508959829807281*x_15 + 1.68047988414764) - 0.000739630480496622*std::sin(0.314959913492203*x_16 + 1.78967988491058) - 0.000110505986599269*std::sin(0.398079842329025*x_16 + 1.80543982982635) - 8.12793444039035e-6*std::sin(0.547359883785248*x_16 - 7.54184007644653) - 0.0106503387429163*std::sin(0.129280045628548*x_17 - 1.43207991123199) - 0.000167261452472986*std::sin(0.447759836912155*x_18 - 1.21223986148834) - 0.000518735523320263*std::sin(0.479279845952988*x_18 - 1.2247998714447) + 0.000470111908324576*std::sin(0.156000033020973*x_19 - 1.41391980648041) + 0.00605794152025001*std::sin(0.30839991569519*x_19 + 5.02143955230713) - 0.0120388465324179*std::sin(0.338479846715927*x_19 - 4.35743999481201) + 0.000204757619613946*std::sin(0.34895983338356*x_19 - 4.37375974655151) - 0.00107256863874635*std::sin(0.351359844207764*x_19 - 4.35784006118774) - 0.00101410375261346*std::sin(0.363359838724136*x_19 - 7.79911994934082) - 0.00015836039795612*std::sin(0.403119832277298*x_2 + 5.21200037002563) - 0.000970324429793355*std::sin(0.488319844007492*x_2 - 4.37152004241943) - 0.00165088145065434*std::sin(0.255759954452515*x_20 - 1.35999977588654) + 0.000371636613682467*std::sin(0.262479960918427*x_20 + 8.19607925415039) - 0.00285014634582198*std::sin(0.284639924764633*x_20 + 4.99671983718872) - 0.00015939342870342*std::sin(0.355199843645096*x_20 - 7.57775974273682) + 0.000100479035574274*std::sin(0.398719847202301*x_20 + 1.37599992752075) + 0.00375526466903495*std::sin(0.229599997401237*x_21 - 4.40079975128174) + 0.000199804726901749*std::sin(0.275599956512451*x_21 + 8.02600002288818) + 0.000846391874088596*std::sin(0.309199929237366*x_21 - 7.78527975082397) - 0.000154518377098196*std::sin(0.313199937343597*x_22 - 4.34143972396851) + 0.000227601610796501*std::sin(0.748719871044159*x_22 + 7.81496000289917) + 0.0188236764018749*std::sin(0.188480004668236*x_23 - 7.60056018829346) - 0.00026404363466948*std::sin(0.220399990677834*x_23 - 4.39192008972168) + 9.94164794136399e-6*std::sin(0.638799846172333*x_23 - 1.57759976387024) + 0.00277139671892392*std::sin(0.319439917802811*x_24 + 5.02647972106934) - 0.00523026658410167*std::sin(0.345359832048416*x_24 - 1.18375980854034) + 0.00021527316950874*std::sin(0.352239847183228*x_24 + 1.8154399394989) - 0.000140102211165487*std::sin(0.411519855260849*x_24 - 1.18431985378265) + 0.000230079766234973*std::sin(0.5065598487854*x_24 + 4.93807983398438) + 0.000137548067115522*std::sin(0.261679977178574*x_25 + 2.00943970680237) - 0.00101822520828308*std::sin(0.323359847068787*x_25 - 1.16343986988068) - 0.00776710823205055*std::sin(0.291839927434921*x_26 - 1.17271983623505) - 0.000591448682509235*std::sin(0.338559836149216*x_26 - 7.57192039489746) + 3.24707027409181e-5*std::sin(0.355599850416183*x_26 - 4.35775947570801) + 0.000779100887645007*std::sin(0.408239871263504*x_27 + 1.97231984138489) + 8.45879687684258e-5*std::sin(0.319119930267334*x_28 - 1.18535983562469) - 0.000395270066829207*std::sin(0.39047983288765*x_28 - 1.36959993839264) + 3.3819279707096e-5*std::sin(0.475599855184555*x_28 + 4.95831966400146) + 0.0127172273218669*std::sin(0.233119979500771*x_29 + 5.00799989700317) - 2.17790899446586e-5*std::sin(0.551679849624634*x_29 - 1.37071990966797) + 0.000178169673371217*std::sin(0.301359921693802*x_3 - 4.32032012939453) + 0.00715030050530806*std::sin(0.326879858970642*x_3 + 1.99583983421326) - 0.000116961573239237*std::sin(0.440799862146378*x_3 - 1.1911199092865) - 0.00239808420788026*std::sin(0.286239951848984*x_30 - 4.36639976501465) - 0.00494475836657925*std::sin(0.325839847326279*x_30 - 1.13759982585907) + 2.59518461194768e-6*std::sin(0.729919850826263*x_31 - 4.79967975616455) - 0.00212118960875398*std::sin(0.321119844913483*x_32 + 2.00159978866577) - 0.016130788467114*std::sin(0.251759976148605*x_33 + 1.96623980998993) - 0.000135000400647073*std::sin(0.276319950819016*x_33 - 7.61472034454346) - 5.67290139143857e-5*std::sin(0.239119976758957*x_34 + 7.97983980178833) + 0.000154557431338293*std::sin(0.257119953632355*x_34 - 1.4139199256897) - 0.001617638460891*std::sin(0.285279929637909*x_34 + 1.77127993106842) + 0.0112349176666936*std::sin(0.248959973454475*x_35 + 1.96167981624603) + 1.71708986702245e-5*std::sin(0.279199957847595*x_35 - 1.43975985050201) - 0.000293312175665536*std::sin(0.202879995107651*x_36 - 4.39247989654541) + 0.0030977585127725*std::sin(0.202880010008812*x_37 - 8.00967979431152) + 0.0047475568381481*std::sin(0.186400011181831*x_38 + 5.01095962524414) - 0.000233216348825563*std::sin(0.251359969377518*x_38 + 4.96871948242188) + 0.00141290802290753*std::sin(0.253519982099533*x_38 - 7.62184000015259) + 0.000772614571203142*std::sin(0.239039987325668*x_4 + 5.00807952880859) - 0.000864808577835414*std::sin(0.333759844303131*x_4 + 8.01072025299072) + 0.000124198034244962*std::sin(0.404239863157272*x_4 - 4.41328001022339) + 8.63173408230603e-5*std::sin(0.427439838647842*x_4 - 1.18679988384247) + 0.00164412780656845*std::sin(0.442959845066071*x_4 + 1.78983998298645) - 6.8976599430262e-5*std::sin(0.216559991240501*x_40 - 7.80495977401733) + 0.00236732544739822*std::sin(0.228479996323586*x_40 - 1.21911990642548) + 0.00355287561328152*std::sin(0.27991995215416*x_41 - 1.22039985656738) + 0.00442835785632426*std::sin(0.224399983882904*x_42 - 1.21111989021301) - 0.000267219189435985*std::sin(0.229999989271164*x_42 + 1.96623980998993) + 0.000106319858604462*std::sin(0.328639835119247*x_42 - 1.31815981864929) - 0.00107565893619678*std::sin(0.304079920053482*x_43 + 1.91623985767365) - 0.0231896104446598*std::sin(0.118240058422089*x_44 + 8.16224002838135) - 0.000395963490512737*std::sin(0.257839977741241*x_44 - 7.44911956787109) + 0.000395657706484673*std::sin(0.336479842662811*x_44 - 1.34127986431122) - 5.42057741584276e-6*std::sin(0.342239856719971*x_44 - 1.53007984161377) - 0.000296453080878456*std::sin(0.181120008230209*x_45 + 1.99287974834442) + 0.000329675854683684*std::sin(0.183680012822151*x_45 - 1.18559980392456) + 0.000312562216461904*std::sin(0.198080003261566*x_46 - 4.59815979003906) - 1.67789117445495e-5*std::sin(0.380719840526581*x_48 - 1.99863982200623) + 0.000203184413293875*std::sin(0.261119961738586*x_49 + 1.94247984886169) + 0.00132164269200163*std::sin(0.328159838914871*x_49 - 7.46968030929565) - 0.00917037400760811*std::sin(0.412159860134125*x_49 + 4.97711944580078) - 1.79905903664884e-5*std::sin(0.453679859638214*x_49 + 7.36191987991333) + 0.00348533090979151*std::sin(0.168400019407272*x_5 - 4.60983991622925) + 0.000145005389134187*std::sin(0.311839938163757*x_5 - 7.56879997253418) + 0.000517935435146579*std::sin(0.373759835958481*x_5 - 7.38263988494873) - 0.00175919234649424*std::sin(0.416639864444733*x_5 + 1.96631979942322) - 0.00563751369847616*std::sin(0.451359868049622*x_5 - 1.2176798582077) - 0.00028069223952608*std::sin(0.12352005392313*x_50 + 1.63047981262207) - 0.0019210233874356*std::sin(0.247359976172447*x_52 + 1.96775984764099) + 0.00438497525483714*std::sin(0.341359823942184*x_52 - 1.33279979228973) + 0.000216049422987938*std::sin(0.202079996466637*x_53 - 1.19311988353729) + 5.9650458999752e-5*std::sin(0.240319982171059*x_53 - 1.19671988487244) + 0.00455098806256279*std::sin(0.266879975795746*x_53 - 7.61999988555908) - 0.00187206124340017*std::sin(0.233519986271858*x_55 + 7.96848011016846) - 0.000763638046165184*std::sin(0.277839958667755*x_55 + 4.72816038131714) + 0.00490322344008884*std::sin(0.195280000567436*x_56 - 1.18679988384247) - 0.00198034434580714*std::sin(0.267359972000122*x_56 - 4.42799949645996) - 0.000758841426896498*std::sin(0.131920039653778*x_57 - 7.61880016326904) + 0.00090726230183634*std::sin(0.449039846658707*x_57 - 1.30199992656708) - 0.000924132864973002*std::sin(0.452639847993851*x_57 - 7.50471973419189) + 0.00747851818569247*std::sin(0.106800064444542*x_58 - 7.62919998168945) - 0.00019292314523018*std::sin(0.239759981632233*x_58 - 7.61368036270142) - 0.000344384751116039*std::sin(0.548639833927155*x_58 + 1.6451997756958) + 0.0135946553884757*std::sin(0.148400038480759*x_59 - 1.5810399055481) + 0.000204235186916722*std::sin(0.250479966402054*x_59 - 7.6255202293396) - 0.000485142752061524*std::sin(0.448639839887619*x_59 + 1.88055980205536) - 4.00057248508281e-5*std::sin(0.363759845495224*x_6 - 1.77367985248566) - 0.000269620956923699*std::sin(0.197039991617203*x_60 + 5.00575971603394) - 0.000107023657463703*std::sin(0.523919880390167*x_60 + 8.08559989929199) + 0.000115619418519492*std::sin(1.41615986824036*x_62 + 3.77920007705688) + 4.64445669365026e-5*std::sin(0.801759898662567*x_63 + 8.58879947662354) + 0.000106363405207182*std::sin(1.67223989963531*x_63 - 9.78384017944336) - 0.00176461148505442*std::sin(0.430479854345322*x_7 - 4.4236798286438) - 6.2377128871174e-5*std::sin(0.463679850101471*x_7 + 4.96807956695557) + 0.00138393329703549*std::sin(0.172400012612343*x_8 + 7.81128025054932) - 0.000362349238336644*std::sin(0.174160018563271*x_8 + 8.00144004821777) + 7.01809587183406e-6*std::sin(0.703439831733704*x_8 + 4.0403995513916) + 0.00243077143043975*std::sin(0.171280011534691*x_9 - 1.4197598695755) + 1.95054077575892e-5*std::sin(0.263279944658279*x_9 + 4.32567977905273) - 3.39747887012749e-6*std::sin(0.433199852705002*x_9 + 7.36879968643188) + 0.00101582353442564*std::sin(0.318399846553802*x_91 - 1.21383988857269) - 8.72593791709231e-5*std::sin(0.347679853439331*x_91 - 7.39775943756104) - 9.74227401864496e-5*std::sin(0.325039833784103*x_92 - 1.18871986865997) - 0.000831974904139711*std::sin(0.27007994055748*x_94 - 4.40319967269897) + 0.00107934034228688*std::sin(0.282559931278229*x_94 + 8.19808006286621) + 0.00450267305464058*std::sin(0.316559940576553*x_94 + 4.78975963592529) - 4.97636917451764e-5*std::sin(0.346959829330444*x_94 + 4.61783981323242) - 0.000166310015389361*std::sin(0.450159847736359*x_94 - 2.01663970947266) + 0.00512652342766471*std::sin(0.324079841375351*x_95 - 1.36367988586426) - 0.000174548107569228*std::sin(0.258719980716705*x_96 + 8.19823932647705) + 0.00735418884691863*std::sin(0.260559976100922*x_97 + 1.97991979122162) - 0.000146008677598859*std::sin(0.279599964618683*x_97 - 4.40623998641968) + 0.000118388340411434*std::sin(0.276239961385727*x_98 + 4.97775983810425) - 0.00027690662198451*std::sin(0.313599914312363*x_98 + 4.77895975112915) + 0.177345301090192);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000104672943446955*x_1 + 0.000201414689796041*x_10 + 0.00211212162484861*x_100 - 0.00166080827218357*x_101 + 2.78806349915081e-5*x_102 - 0.000272385433293169*x_103 - 0.000478263976113221*x_104 + 0.000302326292028289*x_105 - 0.000337508369268837*x_106 + 0.000112064954430885*x_107 - 0.000698905003063876*x_108 - 0.000116376883217709*x_109 + 0.000411279113250308*x_11 + 0.000339579019298144*x_110 - 0.00092714170238261*x_111 - 0.000273734065695576*x_112 - 2.56554104404394e-5*x_113 + 0.00126779239575448*x_114 - 0.00141261648204437*x_115 - 0.000474694883224541*x_116 - 0.00113981547544623*x_117 + 0.00250766537451305*x_118 - 0.000793280023972858*x_119 + 1.32093577668516e-5*x_12 + 0.00055536653709215*x_120 + 0.000590688989649999*x_13 + 0.000177191553692832*x_14 - 0.000210950684460712*x_15 + 0.000436304715056455*x_16 - 0.000653179107265817*x_17 - 0.000447467472645099*x_18 + 2.99030754738099e-5*x_19 + 0.000131310201111277*x_2 - 6.34577118904586e-5*x_20 + 3.36500259228229e-5*x_21 + 0.000189308709042143*x_22 - 7.15828485935667e-5*x_23 - 0.000238172387762107*x_24 + 0.000801560790464985*x_25 - 7.74125343998772e-5*x_26 + 5.98645981164949e-5*x_27 - 5.77905729079282e-5*x_28 - 0.000468807096701636*x_29 + 0.000108860501599228*x_3 - 3.31131224556981e-5*x_30 + 3.32344839135018e-5*x_31 - 0.000221567649230301*x_32 + 2.97396491277002e-5*x_33 + 0.000298024824612966*x_34 + 0.000987599850301783*x_35 - 0.000287485196098723*x_36 - 0.00128770071729173*x_37 + 0.000923266127393537*x_38 - 0.00209134723295635*x_39 + 0.000456073421560618*x_4 + 0.000105756507345915*x_40 - 0.00100808277779342*x_41 - 0.00367224934252229*x_42 + 6.79185924526882e-5*x_43 - 4.69954834111146e-5*x_44 + 0.000786698332689921*x_45 - 0.00156317303289862*x_46 + 0.000677300323906632*x_47 + 0.00109015977345152*x_48 + 0.000737929150195765*x_49 - 6.60606694388127e-6*x_5 - 0.00211856884275134*x_50 + 0.000432072330254346*x_51 - 4.12315503890211e-6*x_52 + 0.000715324189798758*x_53 - 0.00284752970415123*x_54 + 0.00325277100935821*x_55 + 0.0016597388410236*x_56 - 0.00192145999261195*x_57 - 0.000550542849658173*x_58 + 0.000432893702549728*x_59 - 0.000161367798439208*x_6 + 0.000230762595979942*x_60 - 2.96453685784488e-5*x_61 - 2.4568841264885e-5*x_62 + 6.15578936145923e-5*x_63 + 3.41530075071943e-5*x_64 + 7.66293588430616e-6*x_65 - 3.44467263020416e-5*x_66 + 2.68547864498709e-5*x_67 - 2.94734587982484e-6*x_68 + 2.55915523188692e-5*x_69 + 9.38543268378573e-5*x_7 + 7.6667876608029e-6*x_70 - 2.0229868129054e-5*x_71 + 2.0512729532975e-6*x_72 + 5.72789696738623e-5*x_73 + 3.50168078476582e-5*x_74 + 1.08422980086556e-5*x_75 - 1.10866200038311e-5*x_76 - 6.65852297810007e-5*x_77 + 0.000106183071420073*x_78 - 9.31372953972582e-6*x_79 + 0.000659278035405437*x_8 + 2.15848546850926e-5*x_80 + 9.25013001476251e-7*x_81 + 2.27892021746514e-5*x_82 + 0.000129642387073324*x_83 - 2.38263425540443e-6*x_84 + 2.34887505795741e-5*x_85 + 6.66486989171606e-5*x_86 - 9.38810619770682e-6*x_87 + 5.90554393262354e-5*x_88 - 6.13020140511347e-6*x_89 - 0.000215639498601824*x_9 + 6.29438170179127e-5*x_90 + 4.02598976919463e-5*x_91 + 8.26982175585452e-5*x_92 + 0.00114436742939568*x_93 + 3.07289834359798e-5*x_94 + 7.02246666566588e-5*x_95 + 0.00039427913231757*x_96 - 0.000351806142375054*x_97 - 0.000319301214305452*x_98 - 0.000647980415944845*x_99 + 5.83465795638108e-7*std::pow(5.50623989105225 - 9.58327960968018*x_6, 2) + 1.88824446368306e-7*std::pow(-7.36751985549927*x_11 - 5.58879995346069, 2) + 2.28190529773551e-6*std::pow(-5.96751976013184*x_12 - 7.36407995223999, 2) - 5.28242347575002e-8*std::pow(-6.45391988754272*x_17 - 1.20223987102509, 2) - 9.38220421276934e-7*std::pow(-7.15599966049194*x_19 - 8.56088066101074, 2) - 2.03873808965236e-7*std::pow(-5.99191999435425*x_26 - 0.821199893951416, 2) + 1.84892736056704e-5*std::pow(-3.90079998970032*x_27 - 7.59823989868164, 2) - 1.34955030234023e-6*std::pow(-8.39199924468994*x_30 - 6.94776010513306, 2) + 1.84858402862562e-7*std::pow(-6.28359985351563*x_32 - 4.66207981109619, 2) - 1.59748299069516e-5*std::pow(-3.47567987442017*x_43 - 8.39967918395996, 2) - 6.85817514787499e-6*std::pow(-2.60359978675842*x_52 - 6.60096025466919, 2) + 1.2343184601595e-6*std::pow(-2.68167996406555*x_58 - 5.57872009277344, 2) + 0.00169921365350833*std::exp(0.198239862918854*x_13) - 0.000420729428777457*std::exp(0.311599850654602*x_18) - 7.06340289008901e-5*std::exp(0.619279801845551*x_18) + 0.000101230513798503*std::exp(0.370399862527847*x_19) + 0.000879091977977759*std::exp(0.318559855222702*x_26) - 0.000118101344473672*std::exp(0.265839844942093*x_27) + 5.71895408034751e-5*std::exp(0.417679876089096*x_27) + 1.81867321297335e-5*std::exp(0.427119851112366*x_30) + 0.000573072588848447*std::exp(0.188799858093262*x_43) - 0.000196126627438673*std::exp(0.285439848899841*x_49) + 0.000639877564456033*std::exp(0.19327986240387*x_56) - 0.00229250003298757*std::exp(0.225839853286743*x_60) + 8.54024462958573e-5*std::exp(0.243999853730202*x_8) - 0.00128318483619447*std::sin(0.143360033631325*x_1 + 4.91999959945679) + 1.48764183768521e-5*std::sin(0.596159815788269*x_10 + 4.99143981933594) - 0.000590128906385476*std::sin(0.249439969658852*x_100 - 7.61488008499146) - 0.00289288995493037*std::sin(0.276079952716827*x_100 + 1.78791987895966) + 0.00119550939797263*std::sin(0.227279990911484*x_102 - 1.39095985889435) - 0.0122262465263902*std::sin(0.237599983811378*x_102 + 8.17735958099365) - 0.0032747017331821*std::sin(0.254479974508286*x_102 + 1.77367985248566) - 0.000516696470714598*std::sin(0.291839927434921*x_102 + 1.5759197473526) - 0.000526909403217393*std::sin(0.256239980459213*x_103 + 1.96455979347229) + 0.0109969336805253*std::sin(0.215120002627373*x_104 - 4.39056015014648) - 0.000379103836395478*std::sin(0.31183984875679*x_105 + 4.43111991882324) + 3.33989022118301e-5*std::sin(1.16343986988068*x_106 - 5.78295993804932) + 0.00710558175709801*std::sin(0.259199976921082*x_107 - 7.43327951431274) + 0.000612910583881294*std::sin(0.278879970312119*x_107 + 1.76543986797333) - 0.0120626383267729*std::sin(0.238079980015755*x_109 - 1.21103978157043) - 0.000457510212635161*std::sin(0.239439979195595*x_109 + 8.19032001495361) - 0.00610459903922642*std::sin(0.25927996635437*x_109 - 4.41807985305786) + 0.00366990287604127*std::sin(0.277599930763245*x_109 + 4.95183992385864) + 0.000152289569612648*std::sin(0.386879861354828*x_11 - 2.18583989143372) + 0.000525475117204177*std::sin(0.287199944257736*x_112 + 4.56680011749268) + 7.99457740452021e-5*std::sin(0.233039990067482*x_113 + 5.00207996368408) + 0.000443522982588698*std::sin(0.286159932613373*x_113 - 1.19527995586395) + 9.32762595425583e-5*std::sin(0.295519918203354*x_114 + 7.73567962646484) - 0.00386682891819673*std::sin(0.253679990768433*x_116 + 5.15799999237061) + 0.000928887779787308*std::sin(0.247519969940186*x_117 - 7.43887996673584) + 0.00896876480859737*std::sin(0.26063996553421*x_117 - 1.22167980670929) - 0.00297614296313603*std::sin(0.29615992307663*x_117 + 4.76168012619019) - 0.00268621781915996*std::sin(0.23039998114109*x_118 - 4.41991996765137) - 0.000674895217512143*std::sin(0.284399926662445*x_118 + 1.75903987884521) - 0.00387606652248207*std::sin(0.22087998688221*x_119 - 4.40064001083374) - 0.000174790500726919*std::sin(0.309679925441742*x_119 + 7.73167991638184) - 0.00420576486124972*std::sin(0.23879998922348*x_12 + 5.00543975830078) - 0.00161897896720422*std::sin(0.266959965229034*x_120 - 1.2157598733902) + 0.00300340002654627*std::sin(0.308479934930801*x_120 + 4.75375986099243) - 0.00142278827684873*std::sin(0.218639984726906*x_13 - 4.38479995727539) - 0.000575007140089858*std::sin(0.456879854202271*x_13 - 4.82416009902954) + 0.000944039049462282*std::sin(0.269839972257614*x_14 - 7.42647981643677) + 0.0017070811258462*std::sin(0.297919929027557*x_14 + 1.96719980239868) - 0.00704678033820214*std::sin(0.352399855852127*x_14 + 8.24512004852295) - 0.00156009793317583*std::sin(0.508959829807281*x_15 + 1.68047988414764) + 0.000413390872043632*std::sin(0.314959913492203*x_16 + 1.78967988491058) - 0.00279486998260096*std::sin(0.398079842329025*x_16 + 1.80543982982635) - 1.11134094161701e-5*std::sin(0.547359883785248*x_16 - 7.54184007644653) - 0.000361495966980118*std::sin(0.447759836912155*x_18 - 1.21223986148834) - 0.000709272483882444*std::sin(0.479279845952988*x_18 - 1.2247998714447) + 0.0118898686077909*std::sin(0.156000033020973*x_19 - 1.41391980648041) - 0.0114284141613739*std::sin(0.338479846715927*x_19 - 4.35743999481201) + 0.000442535040826846*std::sin(0.34895983338356*x_19 - 4.37375974655151) + 0.00475957916745355*std::sin(0.351359844207764*x_19 - 4.35784006118774) - 0.00240020314766288*std::sin(0.363359838724136*x_19 - 7.79911994934082) - 0.000342258448340031*std::sin(0.403119832277298*x_2 + 5.21200037002563) - 0.000921123915378144*std::sin(0.488319844007492*x_2 - 4.37152004241943) - 0.00390734266002579*std::sin(0.255759954452515*x_20 - 1.35999977588654) + 0.000803204414657692*std::sin(0.262479960918427*x_20 + 8.19607925415039) - 0.00270562904617723*std::sin(0.284639924764633*x_20 + 4.99671983718872) - 0.00403131018523465*std::sin(0.355199843645096*x_20 - 7.57775974273682) - 0.000445880950839766*std::sin(0.398719847202301*x_20 + 1.37599992752075) - 0.00156377862236413*std::sin(0.275599956512451*x_21 + 8.02600002288818) - 0.000473061459940369*std::sin(0.309199929237366*x_21 - 7.78527975082397) - 0.000333954831310175*std::sin(0.313199937343597*x_22 - 4.34143972396851) + 0.000538692516657249*std::sin(0.748719871044159*x_22 + 7.81496000289917) + 0.0178692177345249*std::sin(0.188480004668236*x_23 - 7.60056018829346) - 0.000570667703936177*std::sin(0.220399990677834*x_23 - 4.39192008972168) + 0.000251439892660881*std::sin(0.638799846172333*x_23 - 1.57759976387024) - 0.00154897632889002*std::sin(0.319439917802811*x_24 + 5.02647972106934) - 0.00496506476235501*std::sin(0.345359832048416*x_24 - 1.18375980854034) + 0.000465261908382659*std::sin(0.352239847183228*x_24 + 1.8154399394989) - 0.00354340499128246*std::sin(0.411519855260849*x_24 - 1.18431985378265) - 0.00102099093956777*std::sin(0.5065598487854*x_24 + 4.93807983398438) + 0.000297277530435189*std::sin(0.261679977178574*x_25 + 2.00943970680237) - 0.00240995789992142*std::sin(0.323359847068787*x_25 - 1.16343986988068) - 0.0073732752945279*std::sin(0.291839927434921*x_26 - 1.17271983623505) - 0.000808693943779379*std::sin(0.338559836149216*x_26 - 7.57192039489746) + 0.000821235076916198*std::sin(0.355599850416183*x_26 - 4.35775947570801) - 0.00345730074535274*std::sin(0.408239871263504*x_27 + 1.97231984138489) + 0.00213936259994104*std::sin(0.319119930267334*x_28 - 1.18535983562469) + 0.000220922530815057*std::sin(0.39047983288765*x_28 - 1.36959993839264) + 0.000705467409213525*std::sin(0.475599855184555*x_28 + 4.95831966400146) + 0.0120723975031389*std::sin(0.233119979500771*x_29 + 5.00799989700317) + 0.000170454802537029*std::sin(0.551679849624634*x_29 - 1.37071990966797) + 0.000385071499796179*std::sin(0.301359921693802*x_3 - 4.32032012939453) + 0.00678774293973237*std::sin(0.326879858970642*x_3 + 1.99583983421326) - 0.00295814190908542*std::sin(0.440799862146378*x_3 - 1.1911199092865) - 0.00469403330202901*std::sin(0.325839847326279*x_30 - 1.13759982585907) + 5.60887614520427e-6*std::sin(0.729919850826263*x_31 - 4.79967975616455) + 0.00118556555638962*std::sin(0.321119844913483*x_32 + 2.00159978866577) - 0.0153128732769605*std::sin(0.251759976148605*x_33 + 1.96623980998993) - 0.000291771353489226*std::sin(0.276319950819016*x_33 - 7.61472034454346) - 0.0011833625913985*std::sin(0.239119976758957*x_34 + 7.97983980178833) - 0.00120964909490446*std::sin(0.257119953632355*x_34 - 1.4139199256897) + 0.00717835487706179*std::sin(0.285279929637909*x_34 + 1.77127993106842) + 0.0106652486862563*std::sin(0.248959973454475*x_35 + 1.96167981624603) + 0.00035818354215893*std::sin(0.279199957847595*x_35 - 1.43975985050201) - 0.00063392471487942*std::sin(0.202879995107651*x_36 - 4.39247989654541) + 0.00450683092062989*std::sin(0.186400011181831*x_38 + 5.01095962524414) + 0.0018252758397381*std::sin(0.251359969377518*x_38 + 4.96871948242188) - 0.00626985290118015*std::sin(0.253519982099533*x_38 - 7.62184000015259) + 0.00105640395030879*std::sin(0.239039987325668*x_4 + 5.00807952880859) + 0.000483354839435701*std::sin(0.333759844303131*x_4 + 8.01072025299072) - 0.000972040220987479*std::sin(0.404239863157272*x_4 - 4.41328001022339) + 0.00218310113568005*std::sin(0.427439838647842*x_4 - 1.18679988384247) - 0.000149076563316763*std::sin(0.216559991240501*x_40 - 7.80495977401733) - 0.00132313466915795*std::sin(0.228479996323586*x_40 - 1.21911990642548) - 0.00198575692425605*std::sin(0.27991995215416*x_41 - 1.22039985656738) - 0.00247507743963983*std::sin(0.224399983882904*x_42 - 1.21111989021301) - 0.00675839304559936*std::sin(0.229999989271164*x_42 + 1.96623980998993) + 0.000229785162852252*std::sin(0.328639835119247*x_42 - 1.31815981864929) + 0.00477329252325655*std::sin(0.304079920053482*x_43 + 1.91623985767365) - 0.0220137761278751*std::sin(0.118240058422089*x_44 + 8.16224002838135) - 0.000855781190318449*std::sin(0.257839977741241*x_44 - 7.44911956787109) - 0.0017557516686559*std::sin(0.336479842662811*x_44 - 1.34127986431122) + 4.24243370775354e-5*std::sin(0.342239856719971*x_44 - 1.53007984161377) - 0.00749776408043267*std::sin(0.181120008230209*x_45 + 1.99287974834442) + 0.000712516184194463*std::sin(0.183680012822151*x_45 - 1.18559980392456) - 0.00244627902373012*std::sin(0.198080003261566*x_46 - 4.59815979003906) - 0.000424365034137095*std::sin(0.380719840526581*x_48 - 1.99863982200623) + 0.000439134928418848*std::sin(0.261119961738586*x_49 + 1.94247984886169) - 0.000738686464908528*std::sin(0.328159838914871*x_49 - 7.46968030929565) - 0.00870538816915995*std::sin(0.412159860134125*x_49 + 4.97711944580078) + 0.000140803979240484*std::sin(0.453679859638214*x_49 + 7.36191987991333) + 0.000313394763631252*std::sin(0.311839938163757*x_5 - 7.56879997253418) - 0.00229836545481227*std::sin(0.373759835958481*x_5 - 7.38263988494873) + 0.000983239708727847*std::sin(0.416639864444733*x_5 + 1.96631979942322) - 0.00535166232189391*std::sin(0.451359868049622*x_5 - 1.2176798582077) - 0.00709914764568664*std::sin(0.12352005392313*x_50 + 1.63047981262207) + 0.00107368957106121*std::sin(0.247359976172447*x_52 + 1.96775984764099) + 0.000466939596205737*std::sin(0.202079996466637*x_53 - 1.19311988353729) + 0.00124430369698628*std::sin(0.240319982171059*x_53 - 1.19671988487244) - 0.00180739538470029*std::sin(0.277839958667755*x_55 + 4.72816038131714) - 0.00274048713130659*std::sin(0.195280000567436*x_56 - 1.18679988384247) - 0.0191922916654104*std::sin(0.131920039653778*x_57 - 7.61880016326904) - 0.0040260236923237*std::sin(0.449039846658707*x_57 - 1.30199992656708) - 0.00218725806472031*std::sin(0.452639847993851*x_57 - 7.50471973419189) + 0.0177003219275091*std::sin(0.106800064444542*x_58 - 7.62919998168945) - 0.0048793293842812*std::sin(0.239759981632233*x_58 - 7.61368036270142) + 0.000192481943803611*std::sin(0.548639833927155*x_58 + 1.6451997756958) + 0.0129053353859349*std::sin(0.148400038480759*x_59 - 1.5810399055481) + 0.000441405926435738*std::sin(0.250479966402054*x_59 - 7.6255202293396) + 0.00215284621658528*std::sin(0.448639839887619*x_59 + 1.88055980205536) - 8.64628877477095e-5*std::sin(0.363759845495224*x_6 - 1.77367985248566) - 0.00681913751803181*std::sin(0.197039991617203*x_60 + 5.00575971603394) - 0.000231306257195385*std::sin(0.523919880390167*x_60 + 8.08559989929199) + 4.40895849171853e-5*std::sin(0.801759898662567*x_63 + 8.58879947662354) + 0.000986268548769183*std::sin(0.430479854345322*x_7 - 4.4236798286438) - 0.00013481337262912*std::sin(0.463679850101471*x_7 + 4.96807956695557) + 0.00189226641127864*std::sin(0.172400012612343*x_8 + 7.81128025054932) + 0.000202522572514526*std::sin(0.174160018563271*x_8 + 8.00144004821777) + 1.51679500329436e-5*std::sin(0.703439831733704*x_8 + 4.0403995513916) - 0.0107866747574169*std::sin(0.171280011534691*x_9 - 1.4197598695755) + 4.21563135702771e-5*std::sin(0.263279944658279*x_9 + 4.32567977905273) - 7.08711314115786e-5*std::sin(0.433199852705002*x_9 + 7.36879968643188) - 0.000567759425567073*std::sin(0.318399846553802*x_91 - 1.21383988857269) - 0.000188590456349004*std::sin(0.347679853439331*x_91 - 7.39775943756104) - 0.00246397412981101*std::sin(0.325039833784103*x_92 - 1.18871986865997) + 0.000465003593294047*std::sin(0.27007994055748*x_94 - 4.40319967269897) + 0.00255460654817631*std::sin(0.282559931278229*x_94 + 8.19808006286621) + 0.00427436402342408*std::sin(0.316559940576553*x_94 + 4.78975963592529) - 0.00125860193245785*std::sin(0.346959829330444*x_94 + 4.61783981323242) + 0.00486658192556685*std::sin(0.324079841375351*x_95 - 1.36367988586426) - 0.000377244344093441*std::sin(0.258719980716705*x_96 + 8.19823932647705) + 0.00698129307797251*std::sin(0.260559976100922*x_97 + 1.97991979122162) - 0.000315563133738855*std::sin(0.279599964618683*x_97 - 4.40623998641968) + 0.000255868324491053*std::sin(0.276239961385727*x_98 + 4.97775983810425) + 0.00122878754954823*std::sin(0.313599914312363*x_98 + 4.77895975112915) + 0.0781223177909851*std::sin(-0.00685844609609478*x_1 + 0.00107155826090859*x_100 + 0.000708077187264376*x_101 - 0.0010206115619785*x_102 + 0.00172529822863435*x_103 + 0.00412610243842408*x_104 + 0.00683424226918441*x_105 + 0.00169061537257982*x_106 - 0.0134023771981691*x_107 - 0.00193811738576378*x_108 + 0.0027282879299276*x_109 + 0.00793218714186319*x_11 + 0.000774316256577448*x_111 - 0.000692030135839999*x_112 - 0.00196139908268443*x_113 + 0.000937053172810537*x_114 + 0.0170966438087477*x_115 - 0.000694616611113497*x_116 - 0.000136936427101408*x_117 - 0.00195757239564218*x_118 + 0.00929363684246403*x_119 + 0.0207784263434542*x_120 - 0.00995562648466285*x_13 - 0.00176820391372881*x_15 - 0.00490365945718911*x_16 + 0.00374654680781808*x_18 - 0.000617037466400821*x_2 - 0.00416835984977297*x_20 - 0.000189859270799647*x_22 - 0.0013304431184734*x_23 - 0.00329992368919749*x_24 - 0.00647711474177284*x_25 - 0.000345958100701497*x_26 + 0.00949026750220159*x_27 - 0.0126626679635876*x_28 - 0.00116291856476301*x_29 + 0.00277512472065733*x_3 - 0.000782561338162845*x_31 - 0.00199616834363991*x_32 + 0.00286100367406928*x_33 + 9.30624743567395e-5*x_34 + 0.00129380274701049*x_35 + 0.000342828050361777*x_36 + 0.00010618208654203*x_38 + 0.00160911149976751*x_39 + 0.0013048723562089*x_40 + 7.759219249131e-5*x_42 + 0.0185288434746423*x_43 - 0.000504486464790447*x_44 + 0.00197909671176855*x_45 + 0.00153204083134991*x_46 + 0.0444505912908635*x_47 + 0.0390832067798979*x_48 - 0.00425262942615799*x_49 + 0.00174425361608718*x_50 + 0.00148344682411192*x_51 + 0.000616208510601522*x_54 + 0.0208118594552662*x_57 + 0.00460453845684331*x_58 - 0.00274281408192885*x_59 + 0.00459078648186246*x_6 - 0.000883190629986475*x_60 + 0.000144066371444657*x_61 - 0.00230572789789064*x_64 - 0.000867551735299045*x_65 - 0.000350263571120468*x_66 + 0.000275270157858086*x_67 - 0.000181387988094497*x_68 + 0.000288225225935303*x_69 - 0.000385251326566406*x_7 + 0.000496158502895993*x_70 - 0.000231807730818791*x_71 - 4.63576754976945e-5*x_72 - 7.8826780523448e-5*x_73 + 0.00047635591513117*x_74 - 0.00037738417626676*x_75 - 0.000247711321805095*x_76 - 0.00217442821890038*x_77 + 6.25354137032053e-5*x_78 - 0.000337598851401044*x_79 + 0.000211874164958701*x_80 + 0.000541730166727203*x_81 - 0.00107282036981283*x_82 + 0.00354756553297264*x_83 - 0.000879592273945912*x_84 - 0.000305520891997438*x_85 - 5.23307734972685e-5*x_86 - 1.48791455440616e-6*x_87 - 8.6237801228522e-5*x_88 - 0.000477300324091857*x_89 - 0.000835811396321652*x_9 - 0.00160146802840652*x_90 - 0.000196763425080021*x_91 - 0.000562280626910464*x_92 + 0.0134514938434409*x_93 - 0.000777103143369375*x_95 + 0.000223873919656384*x_96 + 0.000867595140402875*x_97 + 0.000481830159908626*x_98 + 0.00188253843377022*x_99 - 0.000486757170650925*std::pow(0.586719870567322 - 2.74799990653992*x_8, 2) + 2.43635208437849e-5*std::pow(5.90783977508545 - 6.72600030899048*x_41, 2) - 0.0834057482902606*std::exp(0.208159849047661*x_14) + 0.190824281493219*std::sin(0.184320002794266*x_10 + 1.76455986499786) + 0.0682037186588493*std::sin(0.312159925699234*x_110 + 1.51447987556458) + 0.248019100040386*std::sin(0.377759844064713*x_12 - 7.57472038269043) - 0.538794595422736*std::sin(0.129280045628548*x_17 - 1.43207991123199) + 0.306467825041587*std::sin(0.30839991569519*x_19 + 5.02143955230713) + 0.189976709370274*std::sin(0.229599997401237*x_21 - 4.40079975128174) - 0.121317719723598*std::sin(0.286239951848984*x_30 - 4.36639976501465) + 0.156713845906236*std::sin(0.202880010008812*x_37 - 8.00967979431152) + 0.0831754930755144*std::sin(0.442959845066071*x_4 + 1.78983998298645) + 0.176320913614553*std::sin(0.168400019407272*x_5 - 4.60983991622925) + 0.221833410692227*std::sin(0.341359823942184*x_52 - 1.33279979228973) + 0.230231904461547*std::sin(0.266879975795746*x_53 - 7.61999988555908) - 0.0947065163458065*std::sin(0.233519986271858*x_55 + 7.96848011016846) - 0.100184497071188*std::sin(0.267359972000122*x_56 - 4.42799949645996) + 0.00584912079586719*std::sin(1.41615986824036*x_62 + 3.77920007705688) + 0.00538086433302459*std::sin(1.67223989963531*x_63 - 9.78384017944336) - 0.00841352933643158*std::sin(0.450159847736359*x_94 - 2.01663970947266) - 9.81035867550431) + 0.0485699391040165);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-7.23354884816983e-6*x_1 - 2.37598680800691e-5*x_10 - 0.00208864193859499*x_100 + 0.00109838493013863*x_101 + 0.000324013556674763*x_102 - 0.000416427902075543*x_103 - 0.000780843111178434*x_104 - 0.000360271694107931*x_105 - 0.000821859049639967*x_106 - 5.38295460559791e-6*x_107 + 0.00104731689440319*x_108 + 0.000119847311801386*x_109 + 0.000502898283071361*x_11 + 0.000256041318747583*x_110 - 0.00119650371628951*x_111 - 0.000458241414495264*x_112 + 0.000183215681419644*x_113 - 0.000872048667852369*x_114 - 0.00151441141948792*x_115 + 0.000762142723783785*x_116 - 0.000724540752502817*x_117 + 0.000660462713174635*x_118 + 0.000637994614477027*x_119 - 5.59405685074817e-5*x_12 - 0.00133342608851848*x_120 - 0.000417878500351527*x_13 - 0.000116790637021092*x_14 + 0.000710176286891494*x_15 + 0.000356018455767025*x_16 - 0.000793402994413994*x_17 - 0.000188492853557*x_18 - 0.000136759376572552*x_19 + 0.000398318642935472*x_2 + 8.15161210127637e-5*x_20 + 0.000153068904977622*x_21 + 0.000410666764537766*x_22 - 0.00014415936997743*x_23 - 0.000123684195629953*x_24 + 0.000621953147393424*x_25 - 9.30882848986373e-5*x_26 + 8.21532756140869e-5*x_27 + 0.0001053160005738*x_28 - 0.000885870569604465*x_29 - 9.72898646464918e-5*x_3 - 0.00025697640173838*x_30 + 6.5994652956884e-5*x_31 + 0.000153699383555317*x_32 + 0.000227875467434695*x_33 - 1.69099043965571e-5*x_34 + 0.00104294678162971*x_35 + 9.12809018676198e-5*x_36 - 0.00295253822305395*x_37 + 0.00119681438060837*x_38 - 0.000580713817417119*x_39 - 0.000403049240003506*x_4 + 0.000617021621322864*x_40 + 0.00144933367639407*x_41 + 0.000600864112158088*x_42 - 0.000207136443928715*x_43 + 0.00054821089668194*x_44 - 0.000753164851270868*x_45 + 0.00138494642489111*x_46 - 0.00366280162989554*x_47 - 0.0010682831872456*x_48 + 0.00106862139422466*x_49 + 1.86976121519964e-5*x_5 + 0.00156363220083192*x_50 - 0.000885774811207822*x_51 + 9.80365063650085e-6*x_52 - 0.00109832807174518*x_53 - 0.000114197445063487*x_54 - 9.6829140246837e-5*x_55 - 0.00216373319610091*x_56 + 0.00187650146071721*x_57 + 0.00134154384937436*x_58 + 0.000661337725898315*x_59 - 1.53573819574299e-6*x_6 - 0.000129598400948601*x_60 - 1.85291190440442e-5*x_61 - 2.21036226522544e-5*x_62 + 5.79118102497413e-5*x_63 - 3.50882968226542e-5*x_64 - 6.2076970905998e-5*x_65 - 1.15559913748936e-5*x_66 + 4.18712687755969e-5*x_67 + 2.22718097789209e-5*x_68 - 3.66948343028044e-5*x_69 + 0.000348263289167085*x_7 + 3.68710894335186e-5*x_70 + 6.14324267468837e-7*x_71 - 9.58160162222756e-7*x_72 + 1.43470183167747e-5*x_73 + 2.62662046747268e-6*x_74 - 7.87666824396596e-6*x_75 - 8.80039679481017e-5*x_76 - 7.09335169321524e-6*x_77 - 0.000157867716272132*x_78 - 3.1822924841517e-5*x_79 + 0.000423333054765104*x_8 - 5.39226880170673e-6*x_80 + 2.65374736502321e-5*x_81 - 7.52590253073215e-5*x_82 + 8.17847844515035e-5*x_83 - 0.000124542448191396*x_84 - 4.5029838679239e-5*x_85 + 0.000157879426699801*x_86 - 2.83782325953458e-5*x_87 + 3.76640559886015e-5*x_88 - 7.77732181064955e-6*x_89 - 2.68124480450628e-5*x_9 + 1.15045413698089e-5*x_90 + 6.92237253986456e-5*x_91 - 7.91912316734447e-5*x_92 + 0.000180053230786038*x_93 - 0.000252853414200491*x_94 - 0.000126887865816515*x_95 - 0.000352200203119934*x_96 - 0.000494964632092983*x_97 + 0.000329384298841573*x_98 - 0.00118773015843597*x_99 + 4.07106888735235e-7*std::pow(5.50623989105225 - 9.58327960968018*x_6, 2) - 8.63392323769992e-8*std::pow(-7.36751985549927*x_11 - 5.58879995346069, 2) + 1.12663921714427e-6*std::pow(-5.96751976013184*x_12 - 7.36407995223999, 2) + 6.61240305998132e-8*std::pow(-6.45391988754272*x_17 - 1.20223987102509, 2) - 6.68010789684483e-7*std::pow(-7.15599966049194*x_19 - 8.56088066101074, 2) - 1.7952285017296e-5*std::pow(-3.90079998970032*x_27 - 7.59823989868164, 2) - 6.66309990004521e-7*std::pow(-8.39199924468994*x_30 - 6.94776010513306, 2) + 2.61618121015026e-7*std::pow(-6.28359985351563*x_32 - 4.66207981109619, 2) + 1.55108689345408e-5*std::pow(-3.47567987442017*x_43 - 8.39967918395996, 2) - 9.70593096118529e-6*std::pow(-2.60359978675842*x_52 - 6.60096025466919, 2) + 0.00118560777503617*std::exp(0.198239862918854*x_13) + 0.000526658374710718*std::exp(0.311599850654602*x_18) + 6.85825871688009e-5*std::exp(0.619279801845551*x_18) - 0.000126717776845724*std::exp(0.370399862527847*x_19) + 0.000434031814926557*std::exp(0.318559855222702*x_26) - 7.15884094381761e-5*std::exp(0.417679876089096*x_27) - 0.000717357659318455*std::exp(0.188799858093262*x_43) - 0.000139641709242641*std::exp(0.285439848899841*x_49) - 0.000292581489277285*std::exp(0.19327986240387*x_56) - 0.00159956686892724*std::exp(0.225839853286743*x_60) + 0.000120864549211865*std::exp(0.243999853730202*x_8) - 6.80218355133536e-6*std::sin(0.596159815788269*x_10 + 4.99143981933594) - 0.00409411972943862*std::sin(0.276079952716827*x_100 + 1.78791987895966) + 0.000590255771594523*std::sin(0.227279990911484*x_102 - 1.39095985889435) + 0.0118711565967723*std::sin(0.237599983811378*x_102 + 8.17735958099365) - 0.00463447320247976*std::sin(0.254479974508286*x_102 + 1.77367985248566) + 0.000646787471644282*std::sin(0.291839927434921*x_102 + 1.5759197473526) - 0.0106775469907344*std::sin(0.215120002627373*x_104 - 4.39056015014648) - 0.000269921062662747*std::sin(0.31183984875679*x_105 + 4.43111991882324) - 1.52715161339824e-5*std::sin(1.16343986988068*x_106 - 5.78295993804932) - 0.00689921257252642*std::sin(0.259199976921082*x_107 - 7.43327951431274) + 0.0117123001109341*std::sin(0.238079980015755*x_109 - 1.21103978157043) - 0.00425941733074105*std::sin(0.25927996635437*x_109 - 4.41807985305786) + 0.00519377577578326*std::sin(0.277599930763245*x_109 + 4.95183992385864) - 0.000749400727778324*std::sin(0.386879861354828*x_11 - 2.18583989143372) - 0.000240271422081275*std::sin(0.287199944257736*x_112 + 4.56680011749268) - 0.000393404626493214*std::sin(0.233039990067482*x_113 + 5.00207996368408) - 0.00547247244485456*std::sin(0.253679990768433*x_116 + 5.15799999237061) - 0.00116275804574202*std::sin(0.247519969940186*x_117 - 7.43887996673584) - 0.00870828273359826*std::sin(0.26063996553421*x_117 - 1.22167980670929) - 0.00421194231817864*std::sin(0.29615992307663*x_117 + 4.76168012619019) - 0.00132625939554138*std::sin(0.23039998114109*x_118 - 4.41991996765137) + 0.000844816630459645*std::sin(0.284399926662445*x_118 + 1.75903987884521) - 0.00270448309788704*std::sin(0.22087998688221*x_119 - 4.40064001083374) + 0.000218798293466664*std::sin(0.309679925441742*x_119 + 7.73167991638184) - 0.00595214652616697*std::sin(0.23879998922348*x_12 + 5.00543975830078) + 0.00202659660398897*std::sin(0.266959965229034*x_120 - 1.2157598733902) + 0.00148286094871557*std::sin(0.308479934930801*x_120 + 4.75375986099243) + 0.0006505643205674*std::sin(0.218639984726906*x_13 - 4.38479995727539) + 0.00282954880204275*std::sin(0.456879854202271*x_13 - 4.82416009902954) - 0.000431658127070597*std::sin(0.269839972257614*x_14 - 7.42647981643677) - 0.00213688064048652*std::sin(0.297919929027557*x_14 + 1.96719980239868) + 0.00684211893791676*std::sin(0.352399855852127*x_14 + 8.24512004852295) - 0.00220790552961953*std::sin(0.508959829807281*x_15 + 1.68047988414764) - 0.000517472156448333*std::sin(0.314959913492203*x_16 + 1.78967988491058) - 0.00395539841309234*std::sin(0.398079842329025*x_16 + 1.80543982982635) - 7.91272203399572e-6*std::sin(0.547359883785248*x_16 - 7.54184007644653) - 0.000505000382974967*std::sin(0.479279845952988*x_18 - 1.2247998714447) + 0.0168269607230052*std::sin(0.156000033020973*x_19 - 1.41391980648041) + 0.0110964958762773*std::sin(0.338479846715927*x_19 - 4.35743999481201) + 0.00332094439988883*std::sin(0.351359844207764*x_19 - 4.35784006118774) - 0.00118504610947424*std::sin(0.363359838724136*x_19 - 7.79911994934082) + 0.000894371483585196*std::sin(0.488319844007492*x_2 - 4.37152004241943) - 0.00192916221368802*std::sin(0.255759954452515*x_20 - 1.35999977588654) + 0.0026270487864462*std::sin(0.284639924764633*x_20 + 4.99671983718872) - 0.00570525212572536*std::sin(0.355199843645096*x_20 - 7.57775974273682) - 0.000311108565402989*std::sin(0.398719847202301*x_20 + 1.37599992752075) + 0.00769518779693589*std::sin(0.275599956512451*x_21 + 8.02600002288818) + 0.000592166277396908*std::sin(0.309199929237366*x_21 - 7.78527975082397) + 0.00026596726684954*std::sin(0.748719871044159*x_22 + 7.81496000289917) - 0.0173502375835862*std::sin(0.188480004668236*x_23 - 7.60056018829346) + 0.000355846589862979*std::sin(0.638799846172333*x_23 - 1.57759976387024) + 0.00193896908568784*std::sin(0.319439917802811*x_24 + 5.02647972106934) + 0.00482086314714893*std::sin(0.345359832048416*x_24 - 1.18375980854034) - 0.00501475151499496*std::sin(0.411519855260849*x_24 - 1.18431985378265) - 0.000712385281093846*std::sin(0.5065598487854*x_24 + 4.93807983398438) - 0.00118986229814732*std::sin(0.323359847068787*x_25 - 1.16343986988068) + 0.00715913141973065*std::sin(0.291839927434921*x_26 - 1.17271983623505) - 0.000575788234562065*std::sin(0.338559836149216*x_26 - 7.57192039489746) + 0.00116224079840278*std::sin(0.355599850416183*x_26 - 4.35775947570801) - 0.00241229384890207*std::sin(0.408239871263504*x_27 + 1.97231984138489) + 0.0030277012832493*std::sin(0.319119930267334*x_28 - 1.18535983562469) - 0.000276545192843118*std::sin(0.39047983288765*x_28 - 1.36959993839264) - 0.000322572186758493*std::sin(0.475599855184555*x_28 + 4.95831966400146) - 0.011721775849105*std::sin(0.233119979500771*x_29 + 5.00799989700317) - 0.000838789901366638*std::sin(0.551679849624634*x_29 - 1.37071990966797) - 0.0065906048272682*std::sin(0.326879858970642*x_3 + 1.99583983421326) - 0.00418646659262824*std::sin(0.440799862146378*x_3 - 1.1911199092865) + 0.00455770332117642*std::sin(0.325839847326279*x_30 - 1.13759982585907) - 0.00148406074387402*std::sin(0.321119844913483*x_32 + 2.00159978866577) + 0.0148681376761833*std::sin(0.251759976148605*x_33 + 1.96623980998993) + 0.000541087871459806*std::sin(0.239119976758957*x_34 + 7.97983980178833) + 0.0059525541662737*std::sin(0.257119953632355*x_34 - 1.4139199256897) + 0.00500861874352375*std::sin(0.285279929637909*x_34 + 1.77127993106842) - 0.0103554952065447*std::sin(0.248959973454475*x_35 + 1.96167981624603) - 0.000163778010076916*std::sin(0.279199957847595*x_35 - 1.43975985050201) - 0.00437593790526723*std::sin(0.186400011181831*x_38 + 5.01095962524414) - 0.00898198771048548*std::sin(0.251359969377518*x_38 + 4.96871948242188) - 0.00437472140870828*std::sin(0.253519982099533*x_38 - 7.62184000015259) + 0.000752157191495709*std::sin(0.239039987325668*x_4 + 5.00807952880859) - 0.000605051267474842*std::sin(0.333759844303131*x_4 + 8.01072025299072) + 0.00478330624277582*std::sin(0.404239863157272*x_4 - 4.41328001022339) + 0.00308960159916026*std::sin(0.427439838647842*x_4 - 1.18679988384247) + 0.00165626625265312*std::sin(0.228479996323586*x_40 - 1.21911990642548) + 0.00248571990159602*std::sin(0.27991995215416*x_41 - 1.22039985656738) + 0.00309823885015985*std::sin(0.224399983882904*x_42 - 1.21111989021301) - 0.00956471581649052*std::sin(0.229999989271164*x_42 + 1.96623980998993) + 0.0033305127441805*std::sin(0.304079920053482*x_43 + 1.91623985767365) + 0.0213744245330091*std::sin(0.118240058422089*x_44 + 8.16224002838135) - 0.00122505655783384*std::sin(0.336479842662811*x_44 - 1.34127986431122) - 0.000208765637477891*std::sin(0.342239856719971*x_44 - 1.53007984161377) - 0.0106110997399189*std::sin(0.181120008230209*x_45 + 1.99287974834442) + 0.0120378781383066*std::sin(0.198080003261566*x_46 - 4.59815979003906) - 0.000600576339166829*std::sin(0.380719840526581*x_48 - 1.99863982200623) + 0.000924668887935839*std::sin(0.328159838914871*x_49 - 7.46968030929565) + 0.00845255540764058*std::sin(0.412159860134125*x_49 + 4.97711944580078) - 0.000692881362691432*std::sin(0.453679859638214*x_49 + 7.36191987991333) - 0.00160365940296785*std::sin(0.373759835958481*x_5 - 7.38263988494873) - 0.00123079440497982*std::sin(0.416639864444733*x_5 + 1.96631979942322) + 0.00519623265726884*std::sin(0.451359868049622*x_5 - 1.2176798582077) - 0.0100469637252769*std::sin(0.12352005392313*x_50 + 1.63047981262207) - 0.00134401723711617*std::sin(0.247359976172447*x_52 + 1.96775984764099) - 0.000568952951314942*std::sin(0.240319982171059*x_53 - 1.19671988487244) - 0.000892360661640798*std::sin(0.277839958667755*x_55 + 4.72816038131714) + 0.00343047193699634*std::sin(0.195280000567436*x_56 - 1.18679988384247) - 0.0271616069690381*std::sin(0.131920039653778*x_57 - 7.61880016326904) - 0.00280911407593949*std::sin(0.449039846658707*x_57 - 1.30199992656708) - 0.00107990928290251*std::sin(0.452639847993851*x_57 - 7.50471973419189) + 0.00873913429247043*std::sin(0.106800064444542*x_58 - 7.62919998168945) - 0.00690539875689674*std::sin(0.239759981632233*x_58 - 7.61368036270142) - 0.000240943990961921*std::sin(0.548639833927155*x_58 + 1.6451997756958) - 0.0125305225090642*std::sin(0.148400038480759*x_59 - 1.5810399055481) + 0.001502124943247*std::sin(0.448639839887619*x_59 + 1.88055980205536) - 0.00965068353282767*std::sin(0.197039991617203*x_60 + 5.00575971603394) - 4.28090800973835e-5*std::sin(0.801759898662567*x_63 + 8.58879947662354) - 0.00123458582973958*std::sin(0.430479854345322*x_7 - 4.4236798286438) + 0.0013472893480311*std::sin(0.172400012612343*x_8 + 7.81128025054932) - 0.000253512594050443*std::sin(0.174160018563271*x_8 + 8.00144004821777) - 0.00752628454507484*std::sin(0.171280011534691*x_9 - 1.4197598695755) + 3.24055449463889e-5*std::sin(0.433199852705002*x_9 + 7.36879968643188) + 0.000710706776953339*std::sin(0.318399846553802*x_91 - 1.21383988857269) - 0.00348710295063001*std::sin(0.325039833784103*x_92 - 1.18871986865997) - 0.000582079645320995*std::sin(0.27007994055748*x_94 - 4.40319967269897) + 0.00126127930217136*std::sin(0.282559931278229*x_94 + 8.19808006286621) - 0.00415022260218225*std::sin(0.316559940576553*x_94 + 4.78975963592529) - 0.00178121777304497*std::sin(0.346959829330444*x_94 + 4.61783981323242) - 0.00472524057197158*std::sin(0.324079841375351*x_95 - 1.36367988586426) - 0.00677853364053203*std::sin(0.260559976100922*x_97 + 1.97991979122162) + 0.000857373097022895*std::sin(0.313599914312363*x_98 + 4.77895975112915) + 0.0522006899118423*std::sin(-0.00821483382988323*x_1 + 0.00128347922095867*x_100 + 0.000848112874346279*x_101 - 0.00122245684649836*x_102 + 0.00206650866051033*x_103 + 0.00494211741578459*x_104 + 0.00818584323735979*x_105 + 0.00202496661217434*x_106 - 0.0160529513632929*x_107 - 0.00232141684045935*x_108 + 0.0032678585893083*x_109 + 0.00950092752278767*x_11 + 0.000927451975336347*x_111 - 0.000828892214292407*x_112 - 0.00234930293430643*x_113 + 0.00112237320182286*x_114 + 0.0204778292297922*x_115 - 0.000831990214084078*x_116 - 0.000164018201518929*x_117 - 0.00234471944735756*x_118 + 0.0111316297112249*x_119 + 0.0248877540577503*x_120 - 0.011924540354769*x_13 - 0.00211789975821231*x_15 - 0.00587345107546753*x_16 + 0.00448749746383946*x_18 - 0.000739068322805822*x_2 - 0.00499273203131824*x_20 - 0.000227407540837855*x_22 - 0.00159356346688994*x_23 - 0.00395254615669987*x_24 - 0.00775808697119425*x_25 - 0.000414377873580292*x_26 + 0.011367147811531*x_27 - 0.0151669506046112*x_28 - 0.00139290775685386*x_29 + 0.00332395824330848*x_3 - 0.000937327678110542*x_31 - 0.00239094847575055*x_32 + 0.00342682138779905*x_33 + 0.000111467342883061*x_34 + 0.00154967676736417*x_35 + 0.000410628796448285*x_36 + 0.00012718160709169*x_38 + 0.00192734380341212*x_39 + 0.00156293560163255*x_40 + 9.29375195024667e-5*x_42 + 0.0221932735303952*x_43 - 0.000604258226952971*x_44 + 0.00237050060504293*x_45 + 0.00183503094925568*x_46 + 0.0532415383861395*x_47 + 0.0468126518364912*x_48 - 0.00509366751396522*x_49 + 0.00208921283517676*x_50 + 0.00177682655587049*x_51 + 0.000738075425282367*x_54 + 0.0249277992012279*x_57 + 0.00551517322674778*x_58 - 0.00328525756324583*x_59 + 0.00549870153801282*x_6 - 0.00105785832006173*x_60 + 0.000172558227521242*x_61 - 0.00276172930029774*x_64 - 0.00103912653747713*x_65 - 0.000419534832395127*x_66 + 0.000329710049980198*x_67 - 0.000217260901384292*x_68 + 0.000345227228364053*x_69 - 0.00046144207975727*x_7 + 0.000594283252717409*x_70 - 0.000277652104059397*x_71 - 5.55257846482237e-5*x_72 - 9.44162707225355e-5*x_73 + 0.000570564327816573*x_74 - 0.000452019051345177*x_75 - 0.000296700931653931*x_76 - 0.00260446262068701*x_77 + 7.49029772716807e-5*x_78 - 0.000404365424261066*x_79 + 0.000253776297661951*x_80 + 0.000648867576991365*x_81 - 0.00128499093582502*x_82 + 0.00424916386972631*x_83 - 0.00105354832089869*x_84 - 0.000365943440270785*x_85 - 6.26801760116039e-5*x_86 - 1.78217786452695e-6*x_87 - 0.0001032929612657*x_88 - 0.000571695511552772*x_89 - 0.00100110894475275*x_9 - 0.00191818869068917*x_90 - 0.000235677122511967*x_91 - 0.000673482280259099*x_92 + 0.0161117817562909*x_93 - 0.000930790021823498*x_95 + 0.000268149231335215*x_96 + 0.00103917852676309*x_97 + 0.000577121208276204*x_98 + 0.00225484609707681*x_99 - 0.000583022628796091*std::pow(0.586719870567322 - 2.74799990653992*x_8, 2) + 2.91818689595812e-5*std::pow(5.90783977508545 - 6.72600030899048*x_41, 2) - 0.0999008161705453*std::exp(0.208159849047661*x_14) + 0.228563400690172*std::sin(0.184320002794266*x_10 + 1.76455986499786) + 0.0816922969886109*std::sin(0.312159925699234*x_110 + 1.51447987556458) + 0.297069578869925*std::sin(0.377759844064713*x_12 - 7.57472038269043) - 0.64535144081065*std::sin(0.129280045628548*x_17 - 1.43207991123199) + 0.367077647275799*std::sin(0.30839991569519*x_19 + 5.02143955230713) + 0.227548205112154*std::sin(0.229599997401237*x_21 - 4.40079975128174) - 0.145310598667121*std::sin(0.286239951848984*x_30 - 4.36639976501465) + 0.187706979820792*std::sin(0.202880010008812*x_37 - 8.00967979431152) + 0.0996250236220435*std::sin(0.442959845066071*x_4 + 1.78983998298645) + 0.211191716867397*std::sin(0.168400019407272*x_5 - 4.60983991622925) + 0.265705173040658*std::sin(0.341359823942184*x_52 - 1.33279979228973) + 0.275764628166442*std::sin(0.266879975795746*x_53 - 7.61999988555908) - 0.113436525342222*std::sin(0.233519986271858*x_55 + 7.96848011016846) - 0.119997880604304*std::sin(0.267359972000122*x_56 - 4.42799949645996) + 0.00700589531735518*std::sin(1.41615986824036*x_62 + 3.77920007705688) + 0.00644503226206178*std::sin(1.67223989963531*x_63 - 9.78384017944336) - 0.0100774642613271*std::sin(0.450159847736359*x_94 - 2.01663970947266) + 2.22708029268429) - 0.039128378033638*std::sin(0.0253319046610219*x_10 - 0.0127636261460456*x_101 - 0.073779011647448*x_102 - 0.00510054084933448*x_104 + 0.0630391268834004*x_105 - 0.0547637317000957*x_106 - 0.0266475406432052*x_108 + 0.0808348286377565*x_11 + 0.0954530053071301*x_110 - 0.0396354129365808*x_111 - 0.0337077025487647*x_112 + 0.0372924614226417*x_115 + 0.0106468472747524*x_116 + 0.134797399866176*x_117 - 9.92253962745564e-5*x_118 - 0.0557604698603793*x_119 + 0.000599140707229699*x_12 + 0.00464610858180487*x_120 + 0.0110149135557212*x_13 + 0.00726868687482741*x_14 + 0.0463446504133871*x_15 + 0.000145635218539433*x_16 + 0.00118743156693403*x_17 - 0.0294490708859166*x_21 + 0.000625740909195274*x_28 + 0.000430620297905986*x_29 + 0.00833398204836309*x_32 + 0.000336863567215878*x_34 - 0.00289627559187381*x_35 + 0.0253912828849126*x_37 - 0.0757202329161099*x_38 + 0.00494223244315314*x_39 - 0.0053309435012646*x_4 + 0.108398576154222*x_41 - 0.0573864865637922*x_43 - 0.0379526627478909*x_46 - 0.0891324335795046*x_47 + 0.00222657990512084*x_48 + 0.12764997265171*x_50 + 0.020126704634375*x_51 + 0.00321918451026577*x_52 - 7.04256816129393e-5*x_54 + 0.163803383259743*x_55 - 0.00113896615041191*x_56 + 0.0118515429348862*x_57 - 0.00102497506661105*x_61 + 4.90267833287798e-5*x_62 + 0.00070349869896572*x_63 - 4.9960423072152e-5*x_64 + 0.000458178268899845*x_65 + 0.000446626827033312*x_66 + 0.000329296176386336*x_67 + 0.00293349136196536*x_68 + 0.00074508142786639*x_69 - 0.00150856956962587*x_70 - 0.00058396106653635*x_71 + 0.00111198288074372*x_72 + 0.000238573439507204*x_73 + 0.00143496837364257*x_74 - 3.47384508879427e-5*x_75 + 0.00092571764637715*x_76 - 0.000604843719340272*x_77 + 0.00373983161667776*x_78 + 0.00145055312953687*x_79 + 0.00213049788788116*x_80 - 0.00106360532534081*x_81 - 0.000813969138279578*x_82 + 0.000965586164176707*x_83 - 0.000138462994767464*x_84 - 0.00147570378668631*x_85 - 0.00236416707124558*x_86 + 0.00269504623004635*x_87 + 0.00134299889700072*x_88 + 0.000364112891141555*x_89 + 8.51202033279287e-5*x_90 + 0.00178224245876718*x_92 - 0.0575419378330553*x_93 + 0.00858708439005604*x_94 - 0.0509000788608431*x_95 + 0.143151007160238*x_99 + 0.000211569028500067*std::pow(-5.99191999435425*x_26 - 0.821199893951416, 2) - 0.00128090782627294*std::pow(-2.68167996406555*x_58 - 5.57872009277344, 2) + 0.122559081235918*std::exp(0.265839844942093*x_27) - 0.0188731905672826*std::exp(0.427119851112366*x_30) + 1.33161866429823*std::sin(0.143360033631325*x_1 + 4.91999959945679) + 0.612403329527588*std::sin(0.249439969658852*x_100 - 7.61488008499146) + 0.546797605401402*std::sin(0.256239980459213*x_103 + 1.96455979347229) - 0.636044901732745*std::sin(0.278879970312119*x_107 + 1.76543986797333) + 0.474778941480341*std::sin(0.239439979195595*x_109 + 8.19032001495361) - 0.460263763256336*std::sin(0.286159932613373*x_113 - 1.19527995586395) - 0.0967969731556062*std::sin(0.295519918203354*x_114 + 7.73567962646484) + 0.375140636891309*std::sin(0.447759836912155*x_18 - 1.21223986148834) - 0.459238531620009*std::sin(0.34895983338356*x_19 - 4.37375974655151) + 0.35517699786336*std::sin(0.403119832277298*x_2 + 5.21200037002563) - 0.833521375593023*std::sin(0.262479960918427*x_20 + 8.19607925415039) + 0.346559960702187*std::sin(0.313199937343597*x_22 - 4.34143972396851) + 0.592207563742178*std::sin(0.220399990677834*x_23 - 4.39192008972168) - 0.482823225083273*std::sin(0.352239847183228*x_24 + 1.8154399394989) - 0.308498274635152*std::sin(0.261679977178574*x_25 + 2.00943970680237) - 0.399606028495956*std::sin(0.301359921693802*x_3 - 4.32032012939453) - 0.00582058324725965*std::sin(0.729919850826263*x_31 - 4.79967975616455) + 0.302784266969727*std::sin(0.276319950819016*x_33 - 7.61472034454346) + 0.65785221137498*std::sin(0.202879995107651*x_36 - 4.39247989654541) + 0.154703460111614*std::sin(0.216559991240501*x_40 - 7.80495977401733) - 0.238458406771958*std::sin(0.328639835119247*x_42 - 1.31815981864929) + 0.888082662325587*std::sin(0.257839977741241*x_44 - 7.44911956787109) - 0.739410116707546*std::sin(0.183680012822151*x_45 - 1.18559980392456) - 0.455710081925552*std::sin(0.261119961738586*x_49 + 1.94247984886169) - 0.325223853004964*std::sin(0.311839938163757*x_5 - 7.56879997253418) - 0.484564237254755*std::sin(0.202079996466637*x_53 - 1.19311988353729) - 0.458066798791723*std::sin(0.250479966402054*x_59 - 7.6255202293396) + 0.0897264305549541*std::sin(0.363759845495224*x_6 - 1.77367985248566) + 0.240036914840585*std::sin(0.523919880390167*x_60 + 8.08559989929199) + 0.139901905108488*std::sin(0.463679850101471*x_7 + 4.96807956695557) - 0.0157404645015223*std::sin(0.703439831733704*x_8 + 4.0403995513916) - 0.0437475041667983*std::sin(0.263279944658279*x_9 + 4.32567977905273) + 0.195708805543269*std::sin(0.347679853439331*x_91 - 7.39775943756104) + 0.391483436700806*std::sin(0.258719980716705*x_96 + 8.19823932647705) + 0.327474068270096*std::sin(0.279599964618683*x_97 - 4.40623998641968) - 0.265526077681429*std::sin(0.276239961385727*x_98 + 4.97775983810425) - 5.38224148650326) - 0.0934897388116454);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.68852608793161e-5*x_1 + 1.46433776320405e-5*x_10 + 0.0011454816707483*x_100 - 0.000820510466061578*x_101 - 0.000258454157335441*x_102 + 0.000444299837403164*x_103 + 7.83463296590945e-5*x_104 + 0.000104626616853537*x_105 + 0.000107824375571788*x_106 - 7.40707779931826e-5*x_107 - 0.000457151956696789*x_108 + 8.33511799208793e-5*x_109 - 5.6013554663903e-5*x_11 - 0.000441410519435118*x_110 + 0.000105327286978765*x_111 + 0.000111252402383117*x_112 - 1.45694979782027e-5*x_113 + 0.000716913053352947*x_114 + 0.000172366566550628*x_115 - 0.000241605111351688*x_116 - 1.86255067997738e-5*x_117 + 0.000360290748079493*x_118 - 0.000216088224270325*x_119 + 1.60369953378156e-5*x_12 + 0.000688607694957825*x_120 + 0.000166051119012117*x_13 + 1.35320162053383e-5*x_14 - 0.000350605998867324*x_15 + 6.06120456790394e-6*x_16 + 4.17560175530219e-5*x_17 + 0.000139356723990474*x_18 + 0.000108795689797168*x_19 - 4.78100052806094e-5*x_2 - 2.25803688088123e-7*x_20 - 0.000116247414810809*x_21 - 7.33555638179465e-5*x_22 + 0.00016955038590124*x_23 - 0.000216954292522487*x_24 - 5.502120364634e-5*x_25 + 4.29180423096702e-5*x_26 - 6.68116319472148e-5*x_27 - 5.44738136699482e-5*x_28 - 6.40088174365383e-5*x_29 + 0.000123562645326692*x_3 + 2.96938102899097e-5*x_30 - 5.40376681901409e-6*x_31 - 6.77745090441039e-5*x_32 - 0.000135913984624879*x_33 + 6.10364806059639e-5*x_34 - 0.00010548979616329*x_35 + 5.83150415503369e-5*x_36 + 0.000721558368379638*x_37 - 9.94417888855716e-5*x_38 - 0.000356661288424647*x_39 + 0.000225980590444463*x_4 - 0.000383912421537049*x_40 - 0.00127740578572528*x_41 - 0.000545661760807755*x_42 - 1.67909730740338e-6*x_43 - 8.68420016021069e-5*x_44 - 0.000104396414399402*x_45 - 0.000405402002193259*x_46 + 0.00163111702119933*x_47 + 0.000264337943734472*x_48 - 0.000125343038437757*x_49 - 6.30727120361762e-6*x_5 - 0.00101491322117337*x_50 + 0.000397351924724017*x_51 - 4.85957356484996e-5*x_52 + 0.000682957759176533*x_53 - 0.000942902452936368*x_54 + 0.000553183781223274*x_55 + 0.00148575335355829*x_56 - 0.000869823198122583*x_57 - 0.000346221294712937*x_58 + 4.41442698833555e-6*x_59 + 9.39313121892823e-5*x_6 - 9.91554804085832e-6*x_60 + 2.30947200842088e-5*x_61 - 1.96247138555265e-5*x_62 + 3.89944980386143e-6*x_63 + 8.23441600929009e-6*x_64 + 4.8560259982034e-5*x_65 - 1.32124991946551e-5*x_66 - 1.08454201027033e-5*x_67 - 1.70413046402182e-5*x_68 + 2.54548084316283e-5*x_69 - 6.18118563750527e-5*x_7 - 3.11064602131371e-5*x_70 - 8.55233702120705e-6*x_71 - 1.55195088362179e-5*x_72 - 1.12422073004523e-5*x_73 + 2.9336310610081e-5*x_74 - 3.77588547591724e-6*x_75 + 1.13137006809947e-5*x_76 - 3.0429538772798e-5*x_77 + 7.67208953308226e-5*x_78 + 8.51120404510409e-6*x_79 - 0.000489670636940742*x_8 + 4.98729655304153e-6*x_80 - 2.34779656188902e-5*x_81 + 2.32297674563806e-5*x_82 + 6.11810636238055e-5*x_83 + 3.78170962064753e-5*x_84 + 1.48257175104467e-5*x_85 - 5.55718525388066e-5*x_86 + 2.67947263646792e-5*x_87 - 1.23402190784034e-5*x_88 + 1.05330767885597e-5*x_89 - 0.000344937272485127*x_9 - 1.27973480215943e-5*x_90 - 1.66544776779131e-5*x_91 + 7.39783349763585e-5*x_92 + 0.000265504714725364*x_93 + 0.000155264111814099*x_94 + 3.09910397449838e-5*x_95 + 0.000196820452205871*x_96 - 2.19439652722063e-5*x_97 - 0.00025941845661374*x_98 + 0.000442264440437792*x_99 - 4.87464115816342e-9*std::pow(5.50623989105225 - 9.58327960968018*x_6, 2) - 7.0759608155283e-8*std::pow(-7.36751985549927*x_11 - 5.58879995346069, 2) - 1.48992624656927e-6*std::pow(-5.96751976013184*x_12 - 7.36407995223999, 2) - 1.23368776674159e-6*std::pow(-7.15599966049194*x_19 - 8.56088066101074, 2) - 6.7504139602202e-8*std::pow(-5.99191999435425*x_26 - 0.821199893951416, 2) + 9.53992856926455e-6*std::pow(-3.90079998970032*x_27 - 7.59823989868164, 2) + 8.81162955586981e-7*std::pow(-8.39199924468994*x_30 - 6.94776010513306, 2) - 2.9286282827923e-8*std::pow(-6.28359985351563*x_32 - 4.66207981109619, 2) - 8.24254859702711e-6*std::pow(-3.47567987442017*x_43 - 8.39967918395996, 2) + 1.08650974991614e-6*std::pow(-2.60359978675842*x_52 - 6.60096025466919, 2) + 4.0869205353587e-7*std::pow(-2.68167996406555*x_58 - 5.57872009277344, 2) + 0.0054453699849546*std::pow(-0.0167428081266856*x_1 + 0.00261588326387416*x_100 + 0.00172855488242461*x_101 - 0.00249151240888412*x_102 + 0.00421179036746872*x_103 + 0.010072622933775*x_104 + 0.0166837218520085*x_105 + 0.00412712273342008*x_106 - 0.0327178236478642*x_107 - 0.00473132354795545*x_108 + 0.00666028436837024*x_109 + 0.0193640199952579*x_11 + 0.00189025740402502*x_111 - 0.00168938089181027*x_112 - 0.00478815872300014*x_113 + 0.00228753004063152*x_114 + 0.0417362508780434*x_115 - 0.00169569498375207*x_116 - 0.000334288597211285*x_117 - 0.00477881703160074*x_118 + 0.0226875849532551*x_119 + 0.0507242020376907*x_120 - 0.0243036311255067*x_13 - 0.00431653153522237*x_15 - 0.0119707916720484*x_16 + 0.00914605341531542*x_18 - 0.00150630912048833*x_2 - 0.0101757815385423*x_20 - 0.000463483608026157*x_22 - 0.00324787182751978*x_23 - 0.00805575904320331*x_24 - 0.0158119037193831*x_25 - 0.000844551377784523*x_26 + 0.0231675988458604*x_27 - 0.030912048752121*x_28 - 0.00283891163158289*x_29 + 0.00677462213372852*x_3 - 0.00191038526054514*x_31 - 0.00487303728830894*x_32 + 0.00698426945309951*x_33 + 0.0002271836987735*x_34 + 0.0031584255155566*x_35 + 0.000836910312807044*x_36 + 0.000259211237728706*x_38 + 0.00392815584136339*x_39 + 0.00318544859633169*x_40 + 0.000189417715442945*x_42 + 0.04523253033686*x_43 - 0.00123155011560211*x_44 + 0.00483136209646129*x_45 + 0.00374001126817123*x_46 + 0.108512585893824*x_47 + 0.0954097506815725*x_48 - 0.0103815000538682*x_49 + 0.00425806417506932*x_50 + 0.00362138379368313*x_51 + 0.00150428547727546*x_54 + 0.0508058188016492*x_57 + 0.0112405788154797*x_58 - 0.00669574554607265*x_59 + 0.0112070075552786*x_6 - 0.00215604104048728*x_60 + 0.000351694185652222*x_61 - 0.00562873269627511*x_64 - 0.00211786344028507*x_65 - 0.00085506187303519*x_66 + 0.00067198828589535*x_67 - 0.000442803550337873*x_68 + 0.000703614140505258*x_69 - 0.000940473826122972*x_7 + 0.00121121993203989*x_70 - 0.000565888002180453*x_71 - 0.000113168151383299*x_72 - 0.000192431586259741*x_73 + 0.00116287794280314*x_74 - 0.000921268573777871*x_75 - 0.000604711777810999*x_76 - 0.00530820450349963*x_77 + 0.000152661173986896*x_78 - 0.000824144815545838*x_79 + 0.000517226269799677*x_80 + 0.00132246927523648*x_81 - 0.00261896431852162*x_82 + 0.00866030121155641*x_83 - 0.00214725674971434*x_84 - 0.000745836243623697*x_85 - 0.000127749651671783*x_86 - 3.63229039702013e-6*x_87 - 0.000210523337065889*x_88 - 0.00116518342976044*x_89 - 0.00204037906584681*x_9 - 0.00390949663304917*x_90 - 0.000480337998769151*x_91 - 0.00137263696729713*x_92 + 0.0328377269839974*x_93 - 0.00189706073967485*x_95 + 0.000546520017633461*x_96 + 0.00211796940063162*x_97 + 0.00117624164482299*x_98 + 0.0045956444573754*x_99 - 0.00118826944154846*std::pow(0.586719870567322 - 2.74799990653992*x_8, 2) + 5.947611879756e-5*std::pow(5.90783977508545 - 6.72600030899048*x_41, 2) - 0.203609742020369*std::exp(0.208159849047661*x_14) + 0.465839387842212*std::sin(0.184320002794266*x_10 + 1.76455986499786) + 0.166498614851223*std::sin(0.312159925699234*x_110 + 1.51447987556458) + 0.605463124671036*std::sin(0.377759844064713*x_12 - 7.57472038269043) - 1.31530297161548*std::sin(0.129280045628548*x_17 - 1.43207991123199) + 0.748147892362326*std::sin(0.30839991569519*x_19 + 5.02143955230713) + 0.463770298542805*std::sin(0.229599997401237*x_21 - 4.40079975128174) - 0.296160278179601*std::sin(0.286239951848984*x_30 - 4.36639976501465) + 0.382569144094767*std::sin(0.202880010008812*x_37 - 8.00967979431152) + 0.203047644013525*std::sin(0.442959845066071*x_4 + 1.78983998298645) + 0.430433830638592*std::sin(0.168400019407272*x_5 - 4.60983991622925) + 0.541538736219422*std::sin(0.341359823942184*x_52 - 1.33279979228973) + 0.562041101881078*std::sin(0.266879975795746*x_53 - 7.61999988555908) - 0.231197126770089*std::sin(0.233519986271858*x_55 + 7.96848011016846) - 0.244569948969417*std::sin(0.267359972000122*x_56 - 4.42799949645996) + 0.0142788476898248*std::sin(1.41615986824036*x_62 + 3.77920007705688) + 0.0131357420939496*std::sin(1.67223989963531*x_63 - 9.78384017944336) - 0.0205390704212611*std::sin(0.450159847736359*x_94 - 2.01663970947266) - 4.44945446763681, 2) - 1.41963022919727e-5*std::exp(0.198239862918854*x_13) - 3.64451089126185e-5*std::exp(0.619279801845551*x_18) - 0.000573986226526292*std::exp(0.318559855222702*x_26) - 3.91042365128808e-5*std::exp(0.265839844942093*x_27) + 6.0217627307033e-6*std::exp(0.427119851112366*x_30) - 0.000257891445886528*std::exp(0.285439848899841*x_49) - 0.000239786143156226*std::exp(0.19327986240387*x_56) + 1.91529907998643e-5*std::exp(0.225839853286743*x_60) - 1.352992429712e-5*std::exp(0.243999853730202*x_8) - 0.000424872075317287*std::sin(0.143360033631325*x_1 + 4.91999959945679) - 5.57475239750945e-6*std::sin(0.596159815788269*x_10 + 4.99143981933594) - 0.000195396084872936*std::sin(0.249439969658852*x_100 - 7.61488008499146) + 0.000458307505086133*std::sin(0.276079952716827*x_100 + 1.78791987895966) - 0.000780584905003413*std::sin(0.227279990911484*x_102 - 1.39095985889435) - 0.00630838836719957*std::sin(0.237599983811378*x_102 + 8.17735958099365) + 0.000518796222676244*std::sin(0.254479974508286*x_102 + 1.77367985248566) - 0.000174463635584328*std::sin(0.256239980459213*x_103 + 1.96455979347229) + 0.00567409861688543*std::sin(0.215120002627373*x_104 - 4.39056015014648) - 0.000498492416791956*std::sin(0.31183984875679*x_105 + 4.43111991882324) - 1.25158223883578e-5*std::sin(1.16343986988068*x_106 - 5.78295993804932) + 0.00366627396248791*std::sin(0.259199976921082*x_107 - 7.43327951431274) + 0.000202939268305155*std::sin(0.278879970312119*x_107 + 1.76543986797333) - 0.00622397128457192*std::sin(0.238079980015755*x_109 - 1.21103978157043) - 0.000151485045675599*std::sin(0.239439979195595*x_109 + 8.19032001495361) + 5.10016695977069e-5*std::sin(0.25927996635437*x_109 - 4.41807985305786) - 0.000581406156898693*std::sin(0.277599930763245*x_109 + 4.95183992385864) + 0.000605661823337983*std::sin(0.386879861354828*x_11 - 2.18583989143372) - 0.000196915251726431*std::sin(0.287199944257736*x_112 + 4.56680011749268) + 0.000317947600742069*std::sin(0.233039990067482*x_113 + 5.00207996368408) + 0.000146853769424388*std::sin(0.286159932613373*x_113 - 1.19527995586395) + 3.08844656294509e-5*std::sin(0.295519918203354*x_114 + 7.73567962646484) + 0.00061260426137997*std::sin(0.253679990768433*x_116 + 5.15799999237061) + 0.00462762234219477*std::sin(0.26063996553421*x_117 - 1.22167980670929) + 0.000471496903603219*std::sin(0.29615992307663*x_117 + 4.76168012619019) + 0.00175391434374609*std::sin(0.23039998114109*x_118 - 4.41991996765137) + 3.23831037629318e-5*std::sin(0.22087998688221*x_119 - 4.40064001083374) + 0.000666300353822024*std::sin(0.23879998922348*x_12 + 5.00543975830078) - 0.00196101237546485*std::sin(0.308479934930801*x_120 + 4.75375986099243) + 0.000533172176029452*std::sin(0.218639984726906*x_13 - 4.38479995727539) - 0.00228682682461439*std::sin(0.456879854202271*x_13 - 4.82416009902954) - 0.000353766869216406*std::sin(0.269839972257614*x_14 - 7.42647981643677) - 0.00363593413692191*std::sin(0.352399855852127*x_14 + 8.24512004852295) + 0.000247159277602405*std::sin(0.508959829807281*x_15 + 1.68047988414764) + 0.000442778643059999*std::sin(0.398079842329025*x_16 + 1.80543982982635) - 1.46132794944493e-5*std::sin(0.547359883785248*x_16 - 7.54184007644653) - 0.000119694012411471*std::sin(0.447759836912155*x_18 - 1.21223986148834) - 0.000932638820056031*std::sin(0.479279845952988*x_18 - 1.2247998714447) - 0.00188365824567625*std::sin(0.156000033020973*x_19 - 1.41391980648041) - 0.0058967300222136*std::sin(0.338479846715927*x_19 - 4.35743999481201) + 0.000146526654534303*std::sin(0.34895983338356*x_19 - 4.37375974655151) - 3.97645254934476e-5*std::sin(0.351359844207764*x_19 - 4.35784006118774) + 0.00156716655610114*std::sin(0.363359838724136*x_19 - 7.79911994934082) - 0.000113324326425461*std::sin(0.403119832277298*x_2 + 5.21200037002563) - 0.000475273206701521*std::sin(0.488319844007492*x_2 - 4.37152004241943) + 0.00255122436031393*std::sin(0.255759954452515*x_20 - 1.35999977588654) + 0.000265946975785414*std::sin(0.262479960918427*x_20 + 8.19607925415039) - 0.00139602606278389*std::sin(0.284639924764633*x_20 + 4.99671983718872) + 0.000638662286505012*std::sin(0.355199843645096*x_20 - 7.57775974273682) + 3.72517061129093e-6*std::sin(0.398719847202301*x_20 + 1.37599992752075) - 0.00621921129678838*std::sin(0.275599956512451*x_21 + 8.02600002288818) - 0.00011057493685928*std::sin(0.313199937343597*x_22 - 4.34143972396851) - 0.000351728934673397*std::sin(0.748719871044159*x_22 + 7.81496000289917) + 0.00921999773553688*std::sin(0.188480004668236*x_23 - 7.60056018829346) - 0.000188952335508405*std::sin(0.220399990677834*x_23 - 4.39192008972168) - 3.98344878926813e-5*std::sin(0.638799846172333*x_23 - 1.57759976387024) - 0.00256182931708646*std::sin(0.345359832048416*x_24 - 1.18375980854034) + 0.000154051689986355*std::sin(0.352239847183228*x_24 + 1.8154399394989) + 0.000561365667676599*std::sin(0.411519855260849*x_24 - 1.18431985378265) + 8.53000208981559e-6*std::sin(0.5065598487854*x_24 + 4.93807983398438) + 9.84308088270262e-5*std::sin(0.261679977178574*x_25 + 2.00943970680237) + 0.00157353573427571*std::sin(0.323359847068787*x_25 - 1.16343986988068) - 0.00380439605857456*std::sin(0.291839927434921*x_26 - 1.17271983623505) - 0.00106337040087102*std::sin(0.338559836149216*x_26 - 7.57192039489746) - 0.000130104568460759*std::sin(0.355599850416183*x_26 - 4.35775947570801) + 2.88844704101534e-5*std::sin(0.408239871263504*x_27 + 1.97231984138489) - 0.000338929565565572*std::sin(0.319119930267334*x_28 - 1.18535983562469) - 0.000264365120101581*std::sin(0.475599855184555*x_28 + 4.95831966400146) + 0.00622900673633774*std::sin(0.233119979500771*x_29 + 5.00799989700317) + 0.000677905694814698*std::sin(0.551679849624634*x_29 - 1.37071990966797) + 0.000127500047264546*std::sin(0.301359921693802*x_3 - 4.32032012939453) + 0.00350227835731293*std::sin(0.326879858970642*x_3 + 1.99583983421326) + 0.00046864507781676*std::sin(0.440799862146378*x_3 - 1.1911199092865) - 0.00242198494966141*std::sin(0.325839847326279*x_30 - 1.13759982585907) + 1.85714074916749e-6*std::sin(0.729919850826263*x_31 - 4.79967975616455) - 0.00790099818781424*std::sin(0.251759976148605*x_33 + 1.96623980998993) - 9.66076725491434e-5*std::sin(0.276319950819016*x_33 - 7.61472034454346) + 0.000443450384118445*std::sin(0.239119976758957*x_34 + 7.97983980178833) - 0.00481082373719002*std::sin(0.257119953632355*x_34 - 1.4139199256897) - 5.99725029182894e-5*std::sin(0.285279929637909*x_34 + 1.77127993106842) + 0.0055029587862837*std::sin(0.248959973454475*x_35 + 1.96167981624603) - 0.00013422481875785*std::sin(0.279199957847595*x_35 - 1.43975985050201) - 0.000209897203901278*std::sin(0.202879995107651*x_36 - 4.39247989654541) + 0.00232539395400455*std::sin(0.186400011181831*x_38 + 5.01095962524414) + 0.00725919638490287*std::sin(0.251359969377518*x_38 + 4.96871948242188) + 5.23823045604542e-5*std::sin(0.253519982099533*x_38 - 7.62184000015259) + 0.00138909002690398*std::sin(0.239039987325668*x_4 + 5.00807952880859) - 0.00386584356432667*std::sin(0.404239863157272*x_4 - 4.41328001022339) - 0.000345858864468389*std::sin(0.427439838647842*x_4 - 1.18679988384247) - 4.93603626313139e-5*std::sin(0.216559991240501*x_40 - 7.80495977401733) + 0.00107070172159199*std::sin(0.229999989271164*x_42 + 1.96623980998993) + 7.60835822434559e-5*std::sin(0.328639835119247*x_42 - 1.31815981864929) - 3.98790955147129e-5*std::sin(0.304079920053482*x_43 + 1.91623985767365) - 0.0113584695796433*std::sin(0.118240058422089*x_44 + 8.16224002838135) - 0.000283355538572616*std::sin(0.257839977741241*x_44 - 7.44911956787109) + 1.46686565202746e-5*std::sin(0.336479842662811*x_44 - 1.34127986431122) + 0.000168723317123035*std::sin(0.342239856719971*x_44 - 1.53007984161377) + 0.00118783693917255*std::sin(0.181120008230209*x_45 + 1.99287974834442) + 0.000235919425897874*std::sin(0.183680012822151*x_45 - 1.18559980392456) - 0.00972895135020988*std::sin(0.198080003261566*x_46 - 4.59815979003906) + 6.72302379527759e-5*std::sin(0.380719840526581*x_48 - 1.99863982200623) + 0.000145400851941917*std::sin(0.261119961738586*x_49 + 1.94247984886169) - 0.00449172764018359*std::sin(0.412159860134125*x_49 + 4.97711944580078) + 0.000559983162451284*std::sin(0.453679859638214*x_49 + 7.36191987991333) + 0.000103767345016693*std::sin(0.311839938163757*x_5 - 7.56879997253418) + 1.92019942321999e-5*std::sin(0.373759835958481*x_5 - 7.38263988494873) - 0.00276130243764875*std::sin(0.451359868049622*x_5 - 1.2176798582077) + 0.00112468593566362*std::sin(0.12352005392313*x_50 + 1.63047981262207) + 0.000154607184944696*std::sin(0.202079996466637*x_53 - 1.19311988353729) - 0.000466287303992317*std::sin(0.240319982171059*x_53 - 1.19671988487244) + 0.00118010411048411*std::sin(0.277839958667755*x_55 + 4.72816038131714) + 0.00304054818783155*std::sin(0.131920039653778*x_57 - 7.61880016326904) + 3.36359405145229e-5*std::sin(0.449039846658707*x_57 - 1.30199992656708) + 0.00142812815320649*std::sin(0.452639847993851*x_57 - 7.50471973419189) - 0.01155708531756*std::sin(0.106800064444542*x_58 - 7.62919998168945) + 0.000773010142605718*std::sin(0.239759981632233*x_58 - 7.61368036270142) + 0.00665877850963617*std::sin(0.148400038480759*x_59 - 1.5810399055481) + 0.000146152796333138*std::sin(0.250479966402054*x_59 - 7.6255202293396) - 1.79862347596329e-5*std::sin(0.448639839887619*x_59 + 1.88055980205536) - 2.86285073818685e-5*std::sin(0.363759845495224*x_6 - 1.77367985248566) + 0.00108032519432756*std::sin(0.197039991617203*x_60 + 5.00575971603394) - 7.65872279319731e-5*std::sin(0.523919880390167*x_60 + 8.08559989929199) + 2.27489462122231e-5*std::sin(0.801759898662567*x_63 + 8.58879947662354) - 4.46377137523907e-5*std::sin(0.463679850101471*x_7 + 4.96807956695557) + 0.00248818494041434*std::sin(0.172400012612343*x_8 + 7.81128025054932) + 5.02222145012086e-6*std::sin(0.703439831733704*x_8 + 4.0403995513916) + 9.01186824066034e-5*std::sin(0.171280011534691*x_9 - 1.4197598695755) + 1.39582700240197e-5*std::sin(0.263279944658279*x_9 + 4.32567977905273) + 2.65580733038315e-5*std::sin(0.433199852705002*x_9 + 7.36879968643188) - 6.24437074955367e-5*std::sin(0.347679853439331*x_91 - 7.39775943756104) + 0.000390356305847673*std::sin(0.325039833784103*x_92 - 1.18871986865997) - 0.00166798129158241*std::sin(0.282559931278229*x_94 + 8.19808006286621) + 0.00220544778189632*std::sin(0.316559940576553*x_94 + 4.78975963592529) + 0.000199394626324535*std::sin(0.346959829330444*x_94 + 4.61783981323242) + 0.00251101503155555*std::sin(0.324079841375351*x_95 - 1.36367988586426) - 0.000124908417599472*std::sin(0.258719980716705*x_96 + 8.19823932647705) + 0.00360214461126981*std::sin(0.260559976100922*x_97 + 1.97991979122162) - 0.000104485308541267*std::sin(0.279599964618683*x_97 - 4.40623998641968) + 8.47199117134795e-5*std::sin(0.276239961385727*x_98 + 4.97775983810425) - 1.02660659946925e-5*std::sin(0.313599914312363*x_98 + 4.77895975112915) + 0.0486779473721981*std::sin(-0.00319132099920318*x_1 - 0.000577348900831879*x_10 - 0.00109086522491218*x_100 + 0.00724024941660911*x_101 - 0.00883870852428927*x_103 - 0.00101225679543573*x_104 + 0.0309029852754683*x_105 + 7.35696978948129e-5*x_106 - 0.000950725843555555*x_107 + 0.0201115700918849*x_108 - 0.0201961915273986*x_109 - 0.00134587060212967*x_11 + 0.015679666385279*x_110 + 0.00816915275637693*x_111 - 0.000599333305061985*x_112 - 0.0120142813419186*x_113 - 0.0436004008857457*x_114 - 0.0116205844405493*x_115 - 0.00626978184933988*x_116 + 0.0127737537343656*x_12 + 0.0178248971932207*x_13 - 0.00155074701741596*x_15 - 0.0148609279360752*x_2 - 0.0109665235480539*x_20 + 0.000354193295881643*x_22 - 0.00471892847763149*x_23 + 0.0190741465491427*x_25 - 0.00246166852872851*x_26 - 0.00189922914352538*x_29 - 0.00500076203654258*x_3 + 0.00867968059220811*x_30 + 0.000297159468344933*x_31 - 0.0399506609860751*x_33 + 0.019861695605006*x_34 + 0.0173795138488469*x_35 + 0.016391555817738*x_36 + 0.0286283445267436*x_37 + 0.00647150464367815*x_38 - 0.00188945020701794*x_39 - 0.0376957601543976*x_44 - 0.00107833609542347*x_45 - 0.0342843873450061*x_46 - 0.00270205357932318*x_47 + 0.0157867777534752*x_48 - 0.0441496296069605*x_50 - 0.00448720405453101*x_51 - 0.00144352119014892*x_53 + 0.0129395706894985*x_54 + 0.0257887536232951*x_55 - 0.0287266509505626*x_57 - 0.00253374241383402*x_59 - 0.00116828818095594*x_6 + 0.0158061301581233*x_60 + 0.000346561950734615*x_61 + 0.000810837804732403*x_62 - 0.00019907112720333*x_63 + 0.00148532556620411*x_64 - 3.09527631036602e-5*x_65 - 0.00130938168031531*x_66 - 7.71446244904284e-5*x_67 - 0.000141573964071359*x_68 + 0.000464591523694239*x_69 + 0.00109722992164492*x_70 + 0.000129730340845053*x_71 + 0.000283584785392432*x_72 + 0.000176585168868481*x_73 + 0.000441661084450299*x_74 + 0.000948465139232612*x_75 + 0.000205707823156373*x_76 + 1.5437645574983e-5*x_77 + 4.26653653541983e-5*x_78 - 0.000173612121141285*x_79 + 0.000206824640564658*x_80 - 2.20244519341276e-5*x_81 + 0.000274520097979222*x_82 + 0.000286620885916958*x_83 + 0.000122581098032587*x_84 + 0.00022665205129885*x_85 + 0.000448497113235336*x_86 + 0.000871552542229515*x_87 - 0.000333059928358264*x_88 + 0.000252812217859294*x_89 - 7.36995209446774e-5*x_9 + 0.000420144993923791*x_90 + 0.00874908464544209*x_92 + 0.00917660497947594*x_93 + 0.0074057148895062*x_95 - 0.00136547337680225*x_96 - 0.000594851922131671*x_97 + 0.0239513937391445*x_98 + 0.00785517452264392*x_99 - 8.53458779816993e-6*std::pow(-6.45391988754272*x_17 - 1.20223987102509, 2) - 0.067975471214285*std::exp(0.311599850654602*x_18) + 0.0163553852097121*std::exp(0.370399862527847*x_19) + 0.00923987180060341*std::exp(0.417679876089096*x_27) + 0.0925889101224922*std::exp(0.188799858093262*x_43) - 0.0834804595762204*std::sin(0.291839927434921*x_102 + 1.5759197473526) + 0.150076462965066*std::sin(0.247519969940186*x_117 - 7.43887996673584) - 0.109039960822235*std::sin(0.284399926662445*x_118 + 1.75903987884521) - 0.0282401606305933*std::sin(0.309679925441742*x_119 + 7.73167991638184) - 0.261571572260838*std::sin(0.266959965229034*x_120 - 1.2157598733902) + 0.275805864751586*std::sin(0.297919929027557*x_14 + 1.96719980239868) + 0.0667898116956152*std::sin(0.314959913492203*x_16 + 1.78967988491058) - 0.0764305357631003*std::sin(0.309199929237366*x_21 - 7.78527975082397) - 0.250261542583385*std::sin(0.319439917802811*x_24 + 5.02647972106934) + 0.0356935172746122*std::sin(0.39047983288765*x_28 - 1.36959993839264) + 0.191546803809718*std::sin(0.321119844913483*x_32 + 2.00159978866577) + 0.0780935934760247*std::sin(0.333759844303131*x_4 + 8.01072025299072) - 0.213773262491562*std::sin(0.228479996323586*x_40 - 1.21911990642548) - 0.320830332776016*std::sin(0.27991995215416*x_41 - 1.22039985656738) - 0.39988777523893*std::sin(0.224399983882904*x_42 - 1.21111989021301) - 0.11934644238621*std::sin(0.328159838914871*x_49 - 7.46968030929565) + 0.158857873839684*std::sin(0.416639864444733*x_5 + 1.96631979942322) + 0.173471474868838*std::sin(0.247359976172447*x_52 + 1.96775984764099) - 0.442768894604196*std::sin(0.195280000567436*x_56 - 1.18679988384247) + 0.0310984921314186*std::sin(0.548639833927155*x_58 + 1.6451997756958) + 0.159347230692236*std::sin(0.430479854345322*x_7 - 4.4236798286438) + 0.0327207139709875*std::sin(0.174160018563271*x_8 + 8.00144004821777) - 0.0917304848425222*std::sin(0.318399846553802*x_91 - 1.21383988857269) + 0.0751286603895207*std::sin(0.27007994055748*x_94 - 4.40319967269897) + 0.176984695220784) - 0.0222200391242073);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
