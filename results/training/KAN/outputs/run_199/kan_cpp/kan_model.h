
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00044594519825727*x_1 - 0.000308220905890793*x_10 - 5.45671325670693e-5*x_100 - 0.000217499514652437*x_101 - 7.52236728704252e-5*x_102 + 0.000247202215818074*x_103 - 5.95322757503438e-5*x_104 + 0.000343786754131288*x_105 + 9.95513171613749e-5*x_106 + 0.000264122811430833*x_107 + 0.00078250982364508*x_108 - 0.000556981337246405*x_109 + 0.000503488999093487*x_11 - 6.10470006825107e-5*x_110 + 0.000313192644602791*x_111 - 0.000712589609383565*x_112 - 0.000599265100725792*x_113 - 0.000194327178738458*x_114 - 0.000415743285393573*x_115 - 0.000461727551138723*x_116 - 0.00261210670339429*x_117 - 0.00263057821291591*x_118 - 0.000593019793907537*x_119 - 0.000452608508300359*x_12 - 0.00121407118136416*x_120 - 0.000902866104446897*x_13 - 0.000381011708767207*x_14 + 0.000452958017102791*x_15 + 0.000146893338562331*x_16 + 0.000482257728533006*x_17 + 0.000828082960167666*x_18 - 4.58266365349361e-5*x_19 + 0.000244566063286883*x_2 - 0.0001324527709086*x_20 - 0.00124442428224247*x_21 - 5.18285340980971e-5*x_22 - 0.000484489336208343*x_23 - 0.000182056332946164*x_24 - 7.70236716248243e-5*x_25 - 0.00116872871605534*x_26 - 0.000376345564069416*x_27 - 0.000360468668951858*x_28 - 2.38500421783706e-5*x_29 + 0.000204436424562322*x_3 + 7.26961780679315e-5*x_30 + 1.89358466022219e-5*x_31 + 0.000455543929190691*x_32 + 0.00193990440874654*x_33 + 0.000543753455336025*x_34 - 0.000208487673390495*x_35 + 9.63501123658044e-5*x_36 + 0.0011349967134478*x_37 + 4.04365803339595e-5*x_38 - 0.000253901554982781*x_39 + 0.000231536827602221*x_4 - 0.000393058279556478*x_40 - 0.000509851773565347*x_41 + 0.000167781516274895*x_42 + 0.000382937047668254*x_43 + 0.000219592523977884*x_44 - 8.09636346179844e-5*x_45 - 0.000254299295761623*x_46 - 0.000756446320612895*x_47 + 0.000296807578611824*x_48 - 0.000348018354329128*x_49 - 8.9480783920041e-5*x_5 - 0.000172451728830343*x_50 - 0.000107490690652852*x_51 + 0.000129741458835708*x_52 + 0.000302252445759009*x_53 - 0.000138752662916401*x_54 - 0.000289807191430615*x_55 + 4.89457769199094e-5*x_56 - 0.000194123560383349*x_57 - 0.0006832157746472*x_58 + 1.27298675559431e-5*x_59 - 0.000520772200123618*x_6 - 0.00126271429047348*x_60 - 0.000491649923783174*x_61 - 0.000247980186895854*x_62 - 1.86451106497877e-5*x_63 - 3.07568641729622e-6*x_64 + 0.000188518491857325*x_65 - 0.000152991727463228*x_66 - 0.00106412329197938*x_67 - 5.63114397428316e-5*x_68 - 7.37904608532528e-5*x_69 + 5.87893199607404e-5*x_7 - 0.000634134365974021*x_70 - 0.000286952857895917*x_71 - 0.000327071654500052*x_72 + 7.16233335754273e-5*x_73 - 9.41091435556433e-5*x_74 + 0.000198371368513927*x_75 - 0.000455542305811756*x_76 - 0.000567179973035012*x_77 - 0.00025521555799305*x_78 - 7.49184485686559e-5*x_79 + 0.000745231780867*x_8 - 0.000795444485890637*x_80 - 0.00116945856357139*x_81 - 0.000371446596278052*x_82 + 0.000219555490621623*x_83 + 0.000146439718495534*x_84 - 0.000166148112859688*x_85 - 0.000156609091281543*x_86 - 0.000403939617907458*x_87 + 2.93942192878139e-5*x_88 - 5.78891664307758e-5*x_89 + 0.000168064311898611*x_9 + 0.000130543822091558*x_90 - 0.00109772415465809*x_91 + 0.000170977417319743*x_92 + 0.000499226477291151*x_93 + 0.000100127774605137*x_94 + 0.000380936750884346*x_95 + 0.000207031260023225*x_96 - 0.000170862069602128*x_97 + 0.00035363225136752*x_98 + 0.000116074061212383*x_99 + 4.53631940050235e-8*std::pow(2.4696798324585 - 7.17983961105347*x_59, 2) + 6.05665085177536e-8*std::pow(5.30704021453857 - 8.17615985870361*x_15, 2) + 1.15535804882673e-5*std::pow(5.54383993148804 - 0.991999804973602*x_10, 2) + 1.26832427320692e-7*std::pow(-2.62831997871399*x_16 - 9.89848041534424, 2) - 6.60389915488553e-6*std::pow(-3.71199989318848*x_25 - 8.0, 2) - 1.11619199178122e-7*std::pow(-9.3261604309082*x_28 - 1.61375975608826, 2) - 1.63704537624039e-8*std::pow(-5.89263963699341*x_60 - 9.60136032104492, 2) + 1.24342261097681e-6*std::pow(-3.8724000453949*x_61 - 6.51895952224731, 2) + 1.87449679694319e-6*std::pow(-2.83240008354187*x_64 - 9.11664009094238, 2) + 1.62757707206668e-7*std::pow(-2.76160001754761*x_64 - 6.32287979125977, 2) + 1.7789399349268e-6*std::pow(-3.67159986495972*x_9 - 7.73672008514404, 2) - 0.000391351459697296*std::exp(0.208559840917587*x_13) - 1.04012044752596e-6*std::exp(0.541759848594666*x_13) - 0.000309620572642746*std::exp(0.173759862780571*x_14) + 0.00228958857824238*std::exp(0.318959832191467*x_18) + 7.64821976453774e-6*std::exp(0.403919875621796*x_18) - 7.90018623520229e-5*std::exp(0.45007985830307*x_18) + 0.000101860214379808*std::exp(0.356479853391647*x_19) + 1.21181899512827e-5*std::exp(0.250079840421677*x_20) - 0.00012055560691992*std::exp(0.326959848403931*x_22) + 1.03857424451314e-5*std::exp(0.548639833927155*x_22) + 2.24656228682704e-6*std::exp(0.521439850330353*x_26) + 2.99782719493891e-5*std::exp(0.310879856348038*x_28) + 9.08113178876931e-5*std::exp(0.321919828653336*x_30) - 0.000118183026845006*std::exp(0.319119840860367*x_59) - 5.62342122800217e-5*std::log(5.16136026382446 - 0.59639984369278*x_9) - 0.0572208227868639*std::sin(0.332799851894379*x_1 - 4.25031995773315) - 0.000620536181935077*std::sin(0.344959855079651*x_1 - 4.25184011459351) - 0.00195296339433142*std::sin(0.348479837179184*x_1 + 5.15775966644287) + 0.00015237947968113*std::sin(0.351919859647751*x_1 - 4.22544002532959) - 0.00117190463146192*std::sin(0.353119850158691*x_1 - 4.22032022476196) + 0.00650414402967661*std::sin(0.358719855546951*x_1 - 4.23680019378662) - 0.000126134164907844*std::sin(0.359119862318039*x_1 - 1.03623986244202) + 0.000130969044270431*std::sin(0.403519839048386*x_1 - 4.18416023254395) + 9.3577557321517e-6*std::sin(1.34607982635498*x_100 - 4.97455978393555) + 1.99003262892896e-5*std::sin(0.225759983062744*x_107 - 4.39264011383057) + 0.000329384613521236*std::sin(0.206160008907318*x_108 - 4.39903974533081) + 8.48556226262664e-5*std::sin(0.20584000647068*x_109 + 5.18096017837524) - 0.00334922543896075*std::sin(0.102400071918964*x_11 - 4.28399991989136) - 0.000162184089871496*std::sin(0.175360009074211*x_11 + 5.18400001525879) - 0.00176365534433006*std::sin(0.283119946718216*x_11 - 7.42775964736938) - 0.000268551561323823*std::sin(0.282959938049316*x_112 - 7.43111991882324) + 1.45384506713953e-5*std::sin(0.323279827833176*x_112 - 1.34607982635498) - 0.00419862759469093*std::sin(0.254479974508286*x_113 - 4.22528028488159) - 0.00139693222820078*std::sin(0.283679932355881*x_113 + 1.96335983276367) - 0.000462664737867587*std::sin(0.287439942359924*x_113 - 7.42911958694458) - 0.00768952760107523*std::sin(0.2880799472332*x_113 - 7.42679977416992) + 0.00416395165779893*std::sin(0.233999982476234*x_114 + 1.97791981697083) - 0.000392585526640457*std::sin(0.241119980812073*x_114 - 1.23959982395172) + 0.00156205364899075*std::sin(0.209199994802475*x_116 + 2.000159740448) + 0.00189920096746918*std::sin(0.227039992809296*x_116 + 5.1735200881958) - 0.000549808753787918*std::sin(0.233519986271858*x_116 + 1.79903984069824) + 0.00412516217665894*std::sin(0.251039981842041*x_116 + 5.16688013076782) - 0.00155345947872952*std::sin(0.262319952249527*x_116 - 1.23943984508514) - 2.4792667141898e-5*std::sin(1.02279984951019*x_116 + 8.39000034332275) + 0.000445804312686836*std::sin(0.218319997191429*x_118 - 4.21447992324829) - 0.00125679669403332*std::sin(0.226719990372658*x_119 + 5.18576002120972) - 0.00617090931626355*std::sin(0.235759988427162*x_119 + 5.17343997955322) + 0.0034376583073043*std::sin(0.276479959487915*x_12 - 7.43616008758545) - 0.00157316782932342*std::sin(0.298639953136444*x_12 + 5.12664031982422) + 3.94223107537791e-5*std::sin(0.539439857006073*x_12 + 7.83392000198364) + 0.000123192300307977*std::sin(0.179840013384819*x_13 + 1.59295988082886) + 0.000338300104883199*std::sin(0.232399985194206*x_13 - 7.40807962417603) - 9.02631365285065e-5*std::sin(0.295279920101166*x_13 - 4.40863990783691) + 0.00371684331442275*std::sin(0.305279940366745*x_13 + 5.13495969772339) - 0.00192188744139803*std::sin(0.121120058000088*x_14 - 1.25951981544495) + 0.00122303050868889*std::sin(0.243039980530739*x_14 - 1.1814398765564) + 0.000260247710858866*std::sin(0.303039938211441*x_14 - 7.43951988220215) - 0.00045254187725227*std::sin(0.442319840192795*x_14 - 1.44655990600586) - 1.21413478940629e-5*std::sin(0.53143984079361*x_14 - 1.31679975986481) - 0.00125482935193109*std::sin(0.244799971580505*x_15 - 1.17535984516144) + 0.00175332296936772*std::sin(0.267919957637787*x_15 + 1.98791980743408) + 0.00203913226797631*std::sin(0.270559966564178*x_15 + 1.77759981155396) - 0.00174347271636196*std::sin(0.29615992307663*x_15 + 5.17063999176025) - 0.00324419840300529*std::sin(0.316639930009842*x_15 + 5.14856004714966) + 0.00104712481313942*std::sin(0.297039926052094*x_16 + 2.00455975532532) + 0.0216142626513727*std::sin(0.314639925956726*x_16 + 1.9968798160553) - 0.00274380270252119*std::sin(0.387599855661392*x_16 - 1.18503987789154) + 0.0293162971454047*std::sin(0.344799846410751*x_17 + 1.99871981143951) - 0.00250710960474548*std::sin(0.380239844322205*x_17 - 1.1743198633194) - 8.12693828240649e-5*std::sin(0.383119851350784*x_17 + 1.99287974834442) - 0.000180089428282464*std::sin(0.428399860858917*x_17 - 1.20383989810944) - 8.28131002260433e-5*std::sin(0.606959879398346*x_17 + 5.00175952911377) + 0.00023997075096535*std::sin(0.314559936523438*x_18 - 1.15207993984222) + 0.0024574876127063*std::sin(0.374319821596146*x_18 + 2.02303981781006) - 0.00110111137127751*std::sin(0.431999862194061*x_18 - 7.42375993728638) + 0.000660425352991421*std::sin(0.51775985956192*x_18 + 2.0559196472168) + 0.00116071059138339*std::sin(0.524639844894409*x_18 + 2.05535984039307) - 0.00238293606939174*std::sin(0.222240000963211*x_19 + 8.1947193145752) - 0.000460436265605535*std::sin(0.25655996799469*x_19 + 8.21303939819336) + 0.0013085878360329*std::sin(0.257999986410141*x_19 + 8.2061595916748) - 0.00047198601122346*std::sin(0.39319983124733*x_19 - 1.2047199010849) - 0.00466380275877656*std::sin(0.365679860115051*x_2 + 5.18024015426636) - 0.000499905924759733*std::sin(0.377919852733612*x_2 + 5.17736005783081) - 0.0106455541228026*std::sin(0.388719856739044*x_2 + 5.18279981613159) - 0.00213120192554908*std::sin(0.399199843406677*x_2 + 5.20344018936157) + 3.1713836877945e-5*std::sin(0.409279853105545*x_2 - 1.17679977416992) - 5.0219477757283e-5*std::sin(0.337519854307175*x_20 - 7.79392004013062) - 0.00142380749253283*std::sin(0.415519863367081*x_20 + 7.59352016448975) + 0.000172118911588521*std::sin(0.317199915647507*x_21 - 1.19207990169525) - 0.000246179456456685*std::sin(0.340239852666855*x_21 + 2.04071974754333) - 0.00389464276718548*std::sin(0.317359924316406*x_22 + 8.25111961364746) + 0.0102571688059132*std::sin(0.399679869413376*x_22 + 2.00927972793579) - 6.14425940586572e-5*std::sin(0.482559859752655*x_22 + 4.98415994644165) - 0.00437996018779752*std::sin(0.275279939174652*x_23 - 1.15063989162445) + 0.0131938263637077*std::sin(0.319999933242798*x_23 - 1.16799986362457) - 0.000505065928958562*std::sin(0.354399859905243*x_23 - 1.39335989952087) + 6.76447683456582e-5*std::sin(0.366559833288193*x_23 - 7.36911964416504) + 0.0008995021072399*std::sin(0.370399862527847*x_23 + 1.99191975593567) - 2.2989533636669e-5*std::sin(0.832639873027802*x_23 - 7.78951978683472) + 0.000153738596620962*std::sin(0.386879861354828*x_24 - 1.19351994991302) - 0.00100291099751442*std::sin(0.442479848861694*x_24 - 1.21311986446381) + 2.19107931556919e-5*std::sin(0.827359914779663*x_24 + 1.80167984962463) + 4.04900185711571e-5*std::sin(0.261439979076385*x_25 - 7.37575960159302) + 0.000356592105040648*std::sin(0.324319839477539*x_25 - 1.13855993747711) - 0.0198035803186061*std::sin(0.338639855384827*x_25 - 1.14871978759766) - 0.00137666858590596*std::sin(0.152400031685829*x_26 + 8.14935970306396) - 0.000192788582220756*std::sin(0.284159928560257*x_26 + 1.98807990550995) - 0.000256475016574551*std::sin(0.304559946060181*x_26 - 1.17807984352112) + 0.000101834838372587*std::sin(0.783759832382202*x_26 - 1.39231991767883) - 0.00347574590951008*std::sin(0.285999923944473*x_27 - 7.39047956466675) + 0.000423656584173084*std::sin(0.367839843034744*x_27 + 5.23767995834351) - 8.1400472246849e-5*std::sin(0.463919848203659*x_27 + 4.5776801109314) - 0.000222310434239376*std::sin(0.0912800803780556*x_28 + 2.02471995353699) + 1.74082498582999e-5*std::sin(0.805839836597443*x_28 + 4.79120016098022) + 4.44343784164777e-5*std::sin(0.323039919137955*x_29 + 4.80983972549438) - 0.00157775780380854*std::sin(0.377759844064713*x_29 - 1.18191993236542) - 0.000924080717028145*std::sin(0.856159865856171*x_29 - 5.43487977981567) - 0.00187784713171045*std::sin(0.2743199467659*x_3 - 1.15183985233307) - 0.0144300367444363*std::sin(0.2882399559021*x_3 - 1.13159990310669) - 0.00236097099368908*std::sin(0.316159933805466*x_3 + 8.28087997436523) - 0.000374172096411518*std::sin(0.344079852104187*x_3 - 7.40455961227417) - 0.000484392549616472*std::sin(0.348319828510284*x_3 + 1.97527980804443) + 0.00687471520834839*std::sin(0.359439849853516*x_3 - 7.39336013793945) - 0.00239395568823945*std::sin(0.372479856014252*x_3 + 5.19831991195679) - 0.000816567620319435*std::sin(0.259519964456558*x_30 + 1.99079978466034) - 0.00336227038598768*std::sin(0.266159951686859*x_30 - 1.1651998758316) + 0.00452789621111859*std::sin(0.284959942102432*x_30 - 1.16359984874725) - 0.000754792648999818*std::sin(0.304079920053482*x_30 - 1.16567981243134) + 0.013600332097601*std::sin(0.308239936828613*x_30 + 2.00159978866577) + 0.134308659741408*std::sin(0.312719941139221*x_30 + 1.99159979820251) + 4.06926024838911e-5*std::sin(0.765519857406616*x_30 - 7.37951993942261) + 0.00283351647815104*std::sin(0.309599936008453*x_31 - 4.056960105896) - 0.00109501916652507*std::sin(0.340319842100143*x_31 - 1.01967978477478) - 0.00149442556461197*std::sin(0.350399851799011*x_31 + 5.15687990188599) - 0.00310364312920128*std::sin(0.375759840011597*x_31 - 7.39991998672485) - 0.000412075025001367*std::sin(0.376639842987061*x_31 - 4.22408008575439) + 0.00102459322631269*std::sin(0.386079847812653*x_31 - 7.39783954620361) + 0.000103320518359164*std::sin(0.396079838275909*x_31 + 8.38568019866943) - 0.0668556362441557*std::sin(0.405199855566025*x_31 + 5.19992017745972) - 0.000233230497119026*std::sin(0.613279819488525*x_31 + 5.1956000328064) - 0.000488618644020135*std::sin(0.302159935235977*x_32 - 1.14591991901398) + 0.0163597614653904*std::sin(0.30839991569519*x_32 - 1.14823985099792) + 3.80117768882613e-5*std::sin(0.213440001010895*x_33 + 1.971599817276) - 0.000227520289108706*std::sin(0.233039990067482*x_33 + 1.9968798160553) + 0.00252666398590815*std::sin(0.233519986271858*x_33 - 1.17975986003876) - 0.00130296402219943*std::sin(0.225599989295006*x_34 + 1.77711987495422) + 0.000821895095421699*std::sin(0.179120019078255*x_35 + 8.19151973724365) + 0.000144017598981488*std::sin(0.179520010948181*x_35 + 8.40520000457764) - 0.000493703021498048*std::sin(0.1893600076437*x_36 - 7.60423994064331) - 0.000141661700593929*std::sin(0.291999936103821*x_37 + 4.77928018569946) - 0.0279687894661655*std::sin(0.178640007972717*x_4 + 8.1755199432373) + 6.04179109607341e-5*std::sin(0.249199971556664*x_4 - 7.36111974716187) + 0.00570526251884154*std::sin(0.375919848680496*x_4 + 1.9793598651886) - 0.00022712332521477*std::sin(0.772719860076904*x_4 + 8.20959949493408) + 8.37584019121322e-5*std::sin(0.862319886684418*x_4 + 7.99488019943237) + 0.00029960412717061*std::sin(0.16312001645565*x_40 + 5.19856023788452) + 0.00010325032766694*std::sin(0.171840012073517*x_41 - 1.20207989215851) - 0.000366659026714506*std::sin(0.697999835014343*x_42 + 4.62016010284424) - 3.32402462060723e-5*std::sin(0.459839850664139*x_44 - 1.4592798948288) - 2.40227437750213e-5*std::sin(0.576399862766266*x_45 + 5.03351974487305) - 0.000124097098782201*std::sin(0.665839850902557*x_47 + 7.57984018325806) - 0.000535119901541444*std::sin(0.228719994425774*x_48 - 7.5971999168396) - 0.000196940545829125*std::sin(0.467279851436615*x_49 - 1.34599983692169) + 0.00683155729496183*std::sin(0.254319965839386*x_5 - 7.56360006332397) - 0.000291332384339529*std::sin(0.265679955482483*x_5 + 2.00615978240967) + 0.00719124711883658*std::sin(0.350159853696823*x_5 - 1.14927983283997) + 0.0219193337970919*std::sin(0.359199851751328*x_5 + 2.00079965591431) - 0.000149565509111596*std::sin(0.386959850788116*x_5 - 7.39559984207153) - 7.25350343606487e-5*std::sin(0.685359835624695*x_5 - 4.65687990188599) + 0.00117041717818338*std::sin(0.209279999136925*x_50 + 8.17591953277588) - 0.000184655683128184*std::sin(0.224399983882904*x_50 + 4.37063980102539) - 0.00610355368258446*std::sin(0.16872002184391*x_51 + 8.20335960388184) + 0.00131587330379756*std::sin(0.255279958248138*x_52 - 1.2079998254776) - 0.000119910065755164*std::sin(0.233999982476234*x_53 - 7.42159986495972) - 3.39477047012991e-5*std::sin(0.20024000108242*x_54 + 5.00152015686035) + 0.000486783242086048*std::sin(0.5655198097229*x_54 + 4.83576011657715) - 0.000190338066416856*std::sin(0.589199841022491*x_54 + 1.78703987598419) - 0.000269638148889182*std::sin(0.337999850511551*x_56 + 1.85591995716095) - 2.36301053864188e-5*std::sin(0.29351994395256*x_57 - 1.42783987522125) - 0.000245384827181971*std::sin(0.299759924411774*x_58 + 1.87479984760284) + 0.000276824210338042*std::sin(0.48447984457016*x_58 + 4.6911997795105) + 4.55844851638246e-5*std::sin(0.359359860420227*x_59 + 4.64055967330933) - 0.00286858215387012*std::sin(0.606719851493835*x_59 - 7.81207990646362) + 0.00149967815344238*std::sin(0.323439925909042*x_6 + 2.01247978210449) - 0.00488867892671441*std::sin(0.342959851026535*x_6 + 2.01183986663818) + 0.00904297491893398*std::sin(0.344479858875275*x_6 + 2.01703977584839) + 0.000263891739476627*std::sin(0.366239845752716*x_6 + 1.99223983287811) - 0.00119828646856993*std::sin(0.367599844932556*x_6 - 1.16799986362457) - 0.0550290378675627*std::sin(0.378479838371277*x_6 + 1.99007987976074) + 7.93210591487802e-5*std::sin(0.38351982831955*x_6 - 1.17855989933014) - 0.000499779993223046*std::sin(0.358639866113663*x_60 + 8.24847984313965) + 0.000186520886022824*std::sin(0.452159851789474*x_60 - 7.48456001281738) + 1.72808463385988e-5*std::sin(1.41623985767365*x_64 + 6.79663991928101) - 4.47725368443171e-6*std::sin(1.77119994163513*x_64 + 3.59479999542236) + 0.00416536919469924*std::sin(0.26079997420311*x_7 + 2.03239989280701) - 0.00877246192140421*std::sin(0.322959840297699*x_7 - 7.339439868927) - 0.0174872717949407*std::sin(0.330399841070175*x_7 - 1.15071988105774) + 0.000426505271332897*std::sin(0.354959845542908*x_7 + 2.00631976127625) + 0.087470411053568*std::sin(0.359199851751328*x_7 - 1.15143990516663) - 0.000242312154872357*std::sin(0.376479834318161*x_7 + 2.02695989608765) + 0.000952929559241004*std::sin(0.480159848928452*x_7 + 1.93423986434937) - 5.53091080463694e-6*std::sin(1.0732798576355*x_70 + 2.81663990020752) + 1.14142989114134e-5*std::sin(1.18463981151581*x_70 - 9.6071195602417) + 4.68595622483298e-5*std::sin(0.909999787807465*x_72 + 7.97391986846924) - 0.000815287667162059*std::sin(1.2240799665451*x_73 - 0.783519864082336) + 0.000406623855750349*std::sin(1.13831984996796*x_75 - 2.37199997901917) - 2.56326753389306e-6*std::sin(1.41495978832245*x_77 + 1.97983980178833) - 2.71136889130358e-5*std::sin(0.803119838237762*x_78 + 3.78615999221802) - 0.000561273742713364*std::sin(0.307679921388626*x_8 + 2.11904001235962) - 0.00428044533179009*std::sin(0.314959913492203*x_8 + 5.15392017364502) - 0.000144870339040377*std::sin(0.398239850997925*x_8 - 7.80751991271973) + 1.80394968907566e-5*std::sin(0.451759845018387*x_8 + 7.95944023132324) + 2.97079944696887e-5*std::sin(0.171200007200241*x_87 + 5.50552034378052) - 0.000224856185331706*std::sin(0.180960014462471*x_88 - 7.25880002975464) + 0.00126046360624241*std::sin(0.376639842987061*x_9 - 4.38687992095947) - 0.000590980030513892*std::sin(0.452639847993851*x_9 - 4.27943992614746) + 7.95609129281732e-7*std::sin(1.79071986675262*x_90 - 2.39239978790283) - 0.000900567594626848*std::sin(0.329519838094711*x_91 - 4.20544004440308) + 0.00183109329875402*std::sin(0.370879858732224*x_91 + 5.18943977355957) + 0.00098211711919664*std::sin(0.388959854841232*x_91 + 1.971599817276) + 8.69388506593159e-5*std::sin(0.417119860649109*x_91 + 8.21047973632813) - 0.00847871975361047*std::sin(0.227119997143745*x_92 + 2.01871991157532) + 0.000510795011206171*std::sin(0.239759981632233*x_92 + 5.19600009918213) - 0.0236371852472145*std::sin(0.253919988870621*x_92 + 2.02055978775024) - 0.000215897824709757*std::sin(0.285359919071198*x_92 + 1.99703979492188) + 0.00388946909357183*std::sin(0.303839921951294*x_92 + 1.98935985565186) - 0.00441654966992964*std::sin(0.321039855480194*x_92 - 1.1814398765564) + 0.000852954554001598*std::sin(0.327039837837219*x_92 + 8.22480010986328) - 0.00812259232504267*std::sin(0.275759935379028*x_94 + 1.97855985164642) - 0.000789643115219425*std::sin(0.285999953746796*x_94 - 1.19919991493225) - 0.00640670761114133*std::sin(0.287839949131012*x_94 + 1.97927987575531) - 0.000329611609751058*std::sin(0.310879945755005*x_94 + 1.79847991466522) - 0.00213449129663089*std::sin(0.253759980201721*x_95 - 7.40999984741211) + 6.74365391428787e-5*std::sin(0.262319982051849*x_96 - 1.20431983470917) - 0.000319562159306333*std::sin(0.30447992682457*x_96 - 4.41775989532471) + 9.6364882646753e-5*std::sin(0.273119956254959*x_97 + 1.96655988693237) + 0.000176696328854986*std::sin(0.27991995215416*x_97 + 1.97735977172852) - 3.03381554803023e-5*std::sin(0.261359959840775*x_98 - 4.42471981048584) - 0.169991552829742*std::sin(-0.00678598575784814*x_10 - 0.00242623956305077*x_100 - 0.0089106765034634*x_101 + 0.00341780103176486*x_102 + 0.00613141889756799*x_103 + 0.00737637768620217*x_104 + 0.00656393388757081*x_105 + 0.0068125983218886*x_106 - 0.00184255750800034*x_107 - 0.00298560541573748*x_108 - 0.00537682425041262*x_109 - 0.00330520103066411*x_11 + 0.00318700737320991*x_110 + 0.00154076003814085*x_111 - 0.000893235160468857*x_112 - 0.00282094349829131*x_113 + 0.00097536208835431*x_114 - 0.00312872674827405*x_115 - 0.00939539109573159*x_116 - 0.000385665404993986*x_117 - 0.00052542323784348*x_118 - 0.00225600590975066*x_119 + 0.012884675446739*x_12 - 0.00124872447743537*x_120 + 0.000468557261864298*x_18 + 0.00570034305753662*x_19 + 0.00152700165094954*x_2 + 0.0101270062921268*x_20 + 0.0159720503798577*x_21 + 0.00618697753149792*x_22 - 0.0462312906140448*x_23 + 0.00584005196800855*x_24 + 0.019815762313899*x_25 + 0.00481631083063926*x_26 - 0.00474281005529913*x_27 + 0.00496381179742067*x_28 + 0.00227193717187418*x_29 + 0.00161996951906929*x_30 + 0.0332050797034683*x_33 - 0.0065881587887304*x_34 - 0.000444660199010556*x_35 - 0.0154741391854383*x_36 + 0.0101004101865021*x_38 - 0.00281600408872587*x_39 + 0.00466316791940021*x_4 + 0.000539049363764472*x_40 - 0.00825121945189062*x_41 + 0.000970612261215878*x_42 + 0.00278693516503701*x_43 + 0.00515739339510498*x_44 - 0.00213599777360043*x_45 + 0.00935388101423777*x_46 - 0.000345015462434957*x_47 + 0.00351828320992679*x_48 + 0.000304536649870167*x_49 - 0.00148925689725556*x_50 + 0.0060786467168101*x_51 - 0.11288948434248*x_52 - 0.00562368521277923*x_53 + 0.00615687599814393*x_54 - 0.0063133784278917*x_55 - 0.00169613947823589*x_56 - 0.00711984529936668*x_58 - 0.00471518828855348*x_59 - 0.00325822236328112*x_60 - 0.00118232750433175*x_61 + 0.00489265132578606*x_62 + 0.00400610372012064*x_63 + 0.0101935523533992*x_64 + 0.00734682451607425*x_65 + 0.00473149815137724*x_66 - 0.00408256083139876*x_67 + 0.00125975517384145*x_68 - 0.00252016124727229*x_69 + 0.0114274575263658*x_7 + 0.00193703516364055*x_70 - 0.00210267023121317*x_71 - 0.00135715078224077*x_72 + 0.0024239609388589*x_73 + 0.00241632421701727*x_74 - 0.00874764847010984*x_76 - 0.00204746537078044*x_77 + 0.00526702459630563*x_78 - 5.03941976671486e-5*x_79 - 0.0057514851163653*x_80 + 0.00240588482583678*x_81 - 0.000402910298242176*x_82 + 0.00895448274289932*x_83 + 0.00824107964921089*x_84 + 0.00390140985295943*x_85 - 0.00522448744057505*x_86 + 0.000852351059700894*x_87 - 0.00189178758595741*x_89 - 0.0080110476838404*x_90 + 0.000500864397827405*x_91 + 0.00626918256059429*x_92 + 0.000953327965982475*x_93 - 0.0122005254323374*x_95 - 0.0102718066512609*x_96 - 0.00858564613653545*x_97 + 0.00827056739581189*x_98 - 0.00209081628290951*x_99 + 0.043375460179759*std::exp(0.253679871559143*x_13) + 0.0311309513063797*std::exp(0.370639860630035*x_5) + 0.0288517142195752*std::exp(0.324639827013016*x_6) + 2.4124352560208*std::sin(0.337039858102798*x_1 - 4.24552011489868) - 0.0556271215044208*std::sin(0.538719832897186*x_14 + 1.86799991130829) - 0.0621324555203011*std::sin(0.502879858016968*x_15 + 8.08672046661377) - 0.0823294635310705*std::sin(0.51095986366272*x_16 + 8.10847949981689) + 0.134311309388536*std::sin(0.27975994348526*x_17 - 7.37399959564209) - 0.302849586689316*std::sin(0.396399825811386*x_3 - 7.40655994415283) - 0.131112448205774*std::sin(0.293119937181473*x_31 - 1.07175981998444) + 0.571472852479545*std::sin(0.285679936408997*x_32 + 8.2425594329834) - 0.0146584294511102*std::sin(0.538559854030609*x_37 - 0.706639885902405) + 0.136314448059325*std::sin(0.169280022382736*x_57 + 1.61479985713959) - 0.00669243070520614*std::sin(1.22527992725372*x_75 + 3.99287986755371) + 0.204117980939771*std::sin(0.295279920101166*x_8 - 1.19455993175507) + 0.00575507610707379*std::sin(1.14111983776093*x_88 - 1.60359990596771) - 0.0963395770072082*std::sin(0.485359847545624*x_9 - 4.47983980178833) + 0.220338417952203*std::sin(0.257679969072342*x_94 - 7.39807987213135) - 6.60424272123325) + 0.116847073665507);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00222192591743057*x_1 + 0.00288524605142918*x_10 + 0.00251289155768025*x_100 + 0.00207567131087441*x_101 - 2.76881607995177e-5*x_102 - 0.00154204333424459*x_103 - 0.000943539504561187*x_104 + 0.000284248867234708*x_105 + 0.00179131318008529*x_106 - 0.0024742826794928*x_107 + 0.00890312699210451*x_108 + 0.00663699330311162*x_109 + 0.00630497885122993*x_11 + 0.000591145189766694*x_110 - 0.00143177740538349*x_111 - 0.00357084835506037*x_112 - 0.000289710117756819*x_113 + 0.000195184998010767*x_114 + 0.00399199459700824*x_115 + 0.00146573850853263*x_116 + 0.000212893890272548*x_117 - 0.000565462908589357*x_118 + 0.00689006770253732*x_119 - 0.000575393815285946*x_12 - 0.00989570023452174*x_120 - 0.000218013138561079*x_13 + 0.000290027006201516*x_14 + 0.00933636920049398*x_15 + 0.000310095664184286*x_16 + 0.00129474392546414*x_17 + 0.00254222761783593*x_18 - 0.00122879564113543*x_19 - 0.00168926292444056*x_2 - 0.00101954357044172*x_20 + 7.38079503549044e-5*x_21 + 0.000835794804312742*x_22 + 0.000951659923781073*x_23 - 0.000116258263422787*x_24 - 0.00116746334368755*x_25 + 0.00144289942524613*x_26 - 0.00279813983980877*x_27 - 0.00180788615257583*x_28 - 0.000611928645643902*x_29 - 0.00329359690357207*x_3 + 0.000658680996152947*x_30 + 0.000128828931203676*x_31 - 0.00127232006379883*x_32 + 0.00466811332304452*x_33 + 0.00399287864803641*x_34 + 0.000483915130876469*x_35 + 0.000873224320202832*x_36 - 0.00359373335857821*x_37 + 0.00102377520445945*x_38 + 9.13405377291048e-5*x_39 - 0.000240323604532434*x_4 - 0.000649420798623507*x_40 - 0.0020325476077694*x_41 + 0.0010841879935259*x_42 + 0.00229281264409778*x_43 - 0.000881361256744105*x_44 + 0.000663191709820025*x_45 + 0.00288027024522772*x_46 + 6.14066438882539e-5*x_47 + 0.0111666792024543*x_48 + 0.000431905700843682*x_49 + 0.00154640085531387*x_5 + 0.000547378943144179*x_50 - 0.00284815834203873*x_51 - 0.00150911451724242*x_52 - 0.000618528746726016*x_53 - 0.00105979404426311*x_54 - 0.000171183082330325*x_55 + 0.00120549976168642*x_56 - 0.000986856004238805*x_57 + 0.00365102177747919*x_58 + 0.0013036947795821*x_59 + 0.00226478333258875*x_6 - 0.000806729302808315*x_60 - 0.000250418281460101*x_61 - 0.000807489514173538*x_62 - 0.000420943394998537*x_63 + 0.00106634851122484*x_64 + 0.000250825634634135*x_65 - 0.00149299020383668*x_66 + 0.000213497425319127*x_67 + 0.000456918333095364*x_68 - 0.00116473341564865*x_69 + 0.00122128115274177*x_7 + 0.000379958259885528*x_70 - 2.39644777225263e-5*x_71 - 0.000261816004799111*x_72 - 0.000133095518803793*x_73 + 0.000712364771046105*x_74 + 6.76602720873884e-5*x_75 - 0.000230613771401293*x_76 - 0.00366461376928313*x_77 - 0.00199366651957086*x_78 - 0.000219237948892232*x_79 - 0.000150125521191202*x_8 - 0.00145535038285845*x_80 + 0.000273475295907114*x_81 + 0.000945899208567648*x_82 - 0.00168112689487513*x_83 + 0.00259662034806509*x_84 + 0.00105462162790891*x_85 + 0.00127136178726396*x_86 + 0.00034306987912449*x_87 - 0.000174443884776673*x_88 + 0.00175505163181398*x_89 - 0.000357554217864806*x_9 + 0.00095727903263232*x_90 - 0.00115092135018631*x_91 + 0.0108048092434449*x_92 + 0.00355528036001893*x_93 - 0.000524605175728558*x_94 - 0.00121111220105327*x_95 + 0.000128331030595829*x_96 - 0.00101207134611584*x_97 - 0.000763418022695309*x_98 + 0.00277073706635255*x_99 - 1.6786272913355e-7*std::pow(2.4696798324585 - 7.17983961105347*x_59, 2) + 1.05073298249136e-7*std::pow(5.30704021453857 - 8.17615985870361*x_15, 2) - 3.24875925544729e-7*std::pow(-2.62831997871399*x_16 - 9.89848041534424, 2) - 1.19333833064259e-6*std::pow(-3.71199989318848*x_25 - 8.0, 2) - 5.39167212259686e-7*std::pow(-9.3261604309082*x_28 - 1.61375975608826, 2) - 2.35888256749698e-6*std::pow(-5.89263963699341*x_60 - 9.60136032104492, 2) - 1.98002177735045e-5*std::pow(-3.8724000453949*x_61 - 6.51895952224731, 2) + 9.05460010320219e-6*std::pow(-2.83240008354187*x_64 - 9.11664009094238, 2) - 4.16897018257078e-7*std::pow(-2.76160001754761*x_64 - 6.32287979125977, 2) + 5.70681376703378e-9*std::pow(-3.67159986495972*x_9 - 7.73672008514404, 2) + 0.00220815077124945*std::exp(0.208559840917587*x_13) - 9.54950061574511e-6*std::exp(0.253679871559143*x_13) - 2.58348019506407e-6*std::exp(0.541759848594666*x_13) - 1.95905930940763e-5*std::exp(0.403919875621796*x_18) + 0.00125802286790782*std::exp(0.45007985830307*x_18) + 0.00584674009448507*std::exp(0.356479853391647*x_19) - 3.10402336335915e-5*std::exp(0.250079840421677*x_20) - 0.000165382196155806*std::exp(0.548639833927155*x_22) - 8.3132170233325e-6*std::exp(0.521439850330353*x_26) - 6.85376103070672e-6*std::exp(0.370639860630035*x_5) - 0.000570873233185883*std::exp(0.319119840860367*x_59) - 6.35196633219133e-6*std::exp(0.324639827013016*x_6) + 3.30515052691073e-6*std::exp(0.00497861456761313*x_1 - 0.0046269845480468*x_100 + 0.0132033941240856*x_101 - 9.03799643839443e-5*x_102 - 0.00251577037408603*x_103 - 0.00606775654807451*x_104 + 0.000770668699012976*x_105 + 0.00616631395221743*x_106 - 0.00282652409903977*x_107 + 0.046786633934964*x_108 + 0.00875336080169086*x_109 - 0.00860609058972896*x_11 - 0.000407865488424549*x_110 - 0.00450705150638007*x_111 + 0.0138756300158226*x_112 + 0.00312494856199231*x_114 + 0.00235345250228158*x_115 + 0.0237731200471189*x_116 - 0.00504603469474582*x_117 - 0.00167430413668972*x_118 + 0.00628058225220616*x_119 - 0.00738974599402521*x_12 + 0.00093102495028267*x_120 - 0.0055427737106075*x_13 - 0.00593555730600838*x_14 - 0.00907729748600097*x_19 - 0.00998783415474101*x_20 - 0.0930615926108781*x_21 - 0.0122473323646102*x_23 - 0.0102901795744565*x_24 - 0.0220793250449117*x_26 - 0.0180721847023765*x_28 - 0.0126759965172285*x_29 + 0.0093514555045969*x_32 + 0.0253686425817608*x_33 + 0.0282357975394176*x_34 - 0.00168040557334636*x_35 + 0.0203807961410155*x_36 + 0.01615206544799*x_37 + 0.00394742444885079*x_38 + 0.00159861808157996*x_39 - 0.0156465299268603*x_40 + 0.0013577498319336*x_41 + 0.00514706862850065*x_43 - 0.00679175506033998*x_44 - 0.00660194298248747*x_45 + 0.00219649641045003*x_46 - 0.00610977582788759*x_47 + 0.0196689326092496*x_48 + 0.00274897796876173*x_49 + 0.000219127734438132*x_50 + 0.00299838460607264*x_51 + 0.000708475025560478*x_52 + 0.000656998921619662*x_53 + 0.00236320138775911*x_54 - 0.0080662266940633*x_55 + 0.00877505392046957*x_56 - 0.00914928936231597*x_57 - 0.0204416329000474*x_58 - 0.00713764544418696*x_59 - 0.00699692262137829*x_60 - 0.00277837151935398*x_61 - 0.00307347152360238*x_62 - 0.00393720202036859*x_63 + 0.0027314753413671*x_64 + 0.00196429216480377*x_65 - 0.00070176419221549*x_66 + 0.000224874975002025*x_67 + 9.50775030335146e-5*x_68 - 0.00348427116717502*x_69 - 0.00456487375110078*x_70 - 0.00270034447705083*x_71 + 0.00478086126460107*x_72 - 0.00755956383659581*x_73 + 0.00105127743518227*x_74 + 0.00616281788279109*x_75 + 0.000566232194684186*x_76 - 0.00735140305713167*x_77 - 0.000903068762200095*x_78 - 0.00217153102241564*x_79 - 0.0115789055638001*x_8 - 0.0022002712316713*x_80 + 0.00128975387530482*x_81 + 0.00510693252024501*x_82 - 0.00524424576573267*x_83 + 0.00286226522793248*x_84 + 0.000228803009491717*x_85 + 0.00132678072797687*x_86 - 0.00219772547750277*x_87 + 0.0012879971196051*x_88 + 0.00141235523370372*x_89 - 0.0076169031057651*x_9 + 0.000284000681875151*x_90 - 0.0224911545063685*x_91 + 0.0190503276333653*x_93 - 0.00179714516187356*x_95 - 0.0015388288743087*x_96 - 0.00568031911334033*x_97 + 0.00935581525248187*x_98 + 0.0274694426804855*x_99 + 0.000803419615263076*std::pow(5.54383993148804 - 0.991999804973602*x_10, 2) - 0.291966613309622*std::sin(0.254479974508286*x_113 - 4.22528028488159) + 0.141798368382142*std::sin(0.270559966564178*x_15 + 1.77759981155396) + 1.50302519649173*std::sin(0.314639925956726*x_16 + 1.9968798160553) + 2.0386137611122*std::sin(0.344799846410751*x_17 + 1.99871981143951) + 0.0807141697509284*std::sin(0.524639844894409*x_18 + 2.05535984039307) - 0.740276748518767*std::sin(0.388719856739044*x_2 + 5.18279981613159) + 0.713268983939983*std::sin(0.399679869413376*x_22 + 2.00927972793579) - 1.37711291288127*std::sin(0.338639855384827*x_25 - 1.14871978759766) - 0.241698445274743*std::sin(0.285999923944473*x_27 - 7.39047956466675) - 1.00344430726217*std::sin(0.2882399559021*x_3 - 1.13159990310669) + 0.945747821846297*std::sin(0.308239936828613*x_30 + 2.00159978866577) + 0.197038720683125*std::sin(0.309599936008453*x_31 - 4.056960105896) + 0.396735870972407*std::sin(0.375919848680496*x_4 + 1.9793598651886) - 0.0254969491470503*std::sin(0.697999835014343*x_42 + 4.62016010284424) + 1.52423941166688*std::sin(0.359199851751328*x_5 + 2.00079965591431) + 0.628835661601315*std::sin(0.344479858875275*x_6 + 2.01703977584839) - 1.21604010044848*std::sin(0.330399841070175*x_7 - 1.15071988105774) - 0.589598156977118*std::sin(0.227119997143745*x_92 + 2.01871991157532) - 0.564833560241489*std::sin(0.275759935379028*x_94 + 1.97855985164642)) - 0.000448978041257296*std::exp(-0.00297578702992404*x_10 + 0.00718658969849011*x_100 - 0.0065591384938615*x_101 - 0.0145851390749701*x_102 + 0.008299842682832*x_103 + 0.00873566903309156*x_104 - 0.0165097644701116*x_105 - 0.000447754692331845*x_106 - 0.00539412076213413*x_107 - 0.0199028880783126*x_108 - 0.0218776340308818*x_109 + 0.00641073628388183*x_11 + 0.0189926517879051*x_110 - 0.00164240929070917*x_111 - 0.0397617115568512*x_112 - 0.0729779730430056*x_113 - 0.00355287493003953*x_114 - 0.00416847190223676*x_115 - 0.00167414839536816*x_117 - 0.00716060663019711*x_118 + 0.00465050623371411*x_12 - 0.00101667749983309*x_120 - 0.00109740674586097*x_13 + 0.00560413814854875*x_17 + 0.00505066013233576*x_2 - 0.0106030333499041*x_20 - 0.00460856019487494*x_21 + 0.00200975859221734*x_24 - 9.49477538692455e-5*x_29 + 0.00140515515882977*x_3 + 0.00189389873383513*x_32 - 0.0288244099999437*x_33 - 0.0304984124205294*x_34 + 0.00561442040853198*x_35 - 0.00382287662777158*x_36 + 0.00363064357106518*x_37 - 0.00143756818516505*x_38 - 0.00466268286628711*x_39 + 0.00562650170582125*x_4 + 0.00226549397992212*x_40 - 0.00231550320579301*x_41 - 0.00462360467373202*x_42 + 0.00290747709588644*x_43 - 0.00784046411879084*x_44 - 0.0136154307197572*x_45 - 0.00568126575050715*x_46 - 0.00555899114127408*x_47 - 0.0124260845713935*x_48 + 0.000517148543242165*x_49 + 0.0052610468963769*x_50 + 0.00274707680478301*x_51 - 0.00324597152053074*x_52 - 0.00133001232140549*x_53 + 0.00414199308348155*x_55 - 0.00343907056317338*x_56 + 0.0197210384358868*x_57 + 0.0118774448950522*x_59 + 0.00668978605341824*x_61 + 0.0164764312903057*x_62 + 0.00460314483455449*x_63 - 0.00152637796757967*x_64 - 0.0107380129605772*x_65 - 0.00218746831130445*x_66 - 0.00497916238857784*x_67 - 0.0132088927852533*x_68 + 0.000812884239503663*x_69 + 0.000723848159111992*x_70 - 0.000852934576120147*x_71 + 0.00398818672006971*x_72 + 0.00322075830329024*x_73 + 0.0104820038319428*x_74 + 0.000645570029497379*x_75 - 0.00205490212080816*x_76 + 0.00852058585275249*x_77 + 0.00750992731625242*x_78 - 0.00276191430616713*x_79 + 0.00364414288690791*x_8 + 0.00986569298315259*x_80 + 0.0116883020340394*x_81 - 0.000856435362653991*x_82 - 3.96289193769509e-5*x_83 + 0.00120362051859827*x_84 + 0.0122152568608151*x_85 + 0.00805211982413812*x_86 - 0.00126268352133941*x_87 + 0.00371426826609334*x_88 - 0.000462593512729221*x_89 + 0.00504009042635313*x_9 - 0.00385204656676914*x_90 + 0.025801158619175*x_91 - 0.00936932798171537*x_93 + 0.00702466898423568*x_95 + 0.0231755799688179*x_96 + 0.00386343626674554*x_97 - 0.00359399639086228*x_98 + 0.0375857220941461*x_99 - 0.092629566897444*std::exp(0.173759862780571*x_14) - 0.0360667689512212*std::exp(0.326959848403931*x_22) + 0.00896863642911024*std::exp(0.310879856348038*x_28) + 0.0271681334787435*std::exp(0.321919828653336*x_30) - 0.584270456705777*std::sin(0.348479837179184*x_1 + 5.15775966644287) + 0.467321508198157*std::sin(0.209199994802475*x_116 + 2.000159740448) - 0.37599741016167*std::sin(0.226719990372658*x_119 + 5.18576002120972) - 0.970570819744914*std::sin(0.316639930009842*x_15 + 5.14856004714966) + 0.313269616100698*std::sin(0.297039926052094*x_16 + 2.00455975532532) - 0.329420840988409*std::sin(0.431999862194061*x_18 - 7.42375993728638) + 0.391491829707494*std::sin(0.257999986410141*x_19 + 8.2061595916748) + 0.269105149912338*std::sin(0.370399862527847*x_23 + 1.99191975593567) + 0.106682097920785*std::sin(0.324319839477539*x_25 - 1.13855993747711) - 0.41185963124267*std::sin(0.152400031685829*x_26 + 8.14935970306396) + 0.12674586049062*std::sin(0.367839843034744*x_27 + 5.23767995834351) - 0.12328099121234*std::sin(0.376639842987061*x_31 - 4.22408008575439) - 0.0217003952946973*std::sin(0.685359835624695*x_5 - 4.65687990188599) - 0.0569436730440831*std::sin(0.589199841022491*x_54 + 1.78703987598419) - 0.0734120800535334*std::sin(0.299759924411774*x_58 + 1.87479984760284) + 0.448660554604722*std::sin(0.323439925909042*x_6 + 2.01247978210449) - 0.149519794247247*std::sin(0.358639866113663*x_60 + 8.24847984313965) + 1.24615861659213*std::sin(0.26079997420311*x_7 + 2.03239989280701) + 1.16361724456294*std::sin(0.303839921951294*x_92 + 1.98935985565186) - 0.236238500374848*std::sin(0.285999953746796*x_94 - 1.19919991493225)) + 0.000144041568451243*std::log(5.16136026382446 - 0.59639984369278*x_9) - 0.000531119482475628*std::sin(0.337039858102798*x_1 - 4.24552011489868) - 0.00154130508650531*std::sin(0.344959855079651*x_1 - 4.25184011459351) - 0.000390313625160393*std::sin(0.351919859647751*x_1 - 4.22544002532959) + 0.0186613679917691*std::sin(0.353119850158691*x_1 - 4.22032022476196) + 2.08652006526889e-5*std::sin(0.358719855546951*x_1 - 4.23680019378662) + 0.000466748993822334*std::sin(0.359119862318039*x_1 - 1.03623986244202) + 0.0188718406890325*std::sin(0.403519839048386*x_1 - 4.18416023254395) - 3.46275973334275e-5*std::sin(1.34607982635498*x_100 - 4.97455978393555) + 0.00286751567504588*std::sin(0.225759983062744*x_107 - 4.39264011383057) - 0.00185851073341389*std::sin(0.206160008907318*x_108 - 4.39903974533081) + 0.0122271778090168*std::sin(0.20584000647068*x_109 + 5.18096017837524) - 0.0161781535475094*std::sin(0.102400071918964*x_11 - 4.28399991989136) - 0.023369738424835*std::sin(0.175360009074211*x_11 + 5.18400001525879) + 0.0099512006721858*std::sin(0.283119946718216*x_11 - 7.42775964736938) + 0.000687883523832277*std::sin(0.282959938049316*x_112 - 7.43111991882324) + 0.00209490209281365*std::sin(0.323279827833176*x_112 - 1.34607982635498) - 0.08018341329467*std::sin(0.283679932355881*x_113 + 1.96335983276367) + 0.00118509625737581*std::sin(0.287439942359924*x_113 - 7.42911958694458) - 0.0371436203699109*std::sin(0.2880799472332*x_113 - 7.42679977416992) + 0.0201136204510558*std::sin(0.233999982476234*x_114 + 1.97791981697083) + 0.00625151807083552*std::sin(0.241119980812073*x_114 - 1.23959982395172) + 0.109013460374064*std::sin(0.227039992809296*x_116 + 5.1735200881958) + 0.00310222587301845*std::sin(0.233519986271858*x_116 + 1.79903984069824) + 1.32334610285608e-5*std::sin(0.251039981842041*x_116 + 5.16688013076782) - 0.00750385617055337*std::sin(0.262319952249527*x_116 - 1.23943984508514) - 4.3011350212281e-5*std::sin(1.02279984951019*x_116 + 8.39000034332275) - 0.00114190898775253*std::sin(0.218319997191429*x_118 - 4.21447992324829) - 0.0298080616744765*std::sin(0.235759988427162*x_119 + 5.17343997955322) + 0.19732036476491*std::sin(0.276479959487915*x_12 - 7.43616008758545) + 0.00887639912806826*std::sin(0.298639953136444*x_12 + 5.12664031982422) - 0.000145878984428377*std::sin(0.539439857006073*x_12 + 7.83392000198364) - 0.000455862868378422*std::sin(0.179840013384819*x_13 + 1.59295988082886) + 0.0487469823117591*std::sin(0.232399985194206*x_13 - 7.40807962417603) + 0.00143734700045384*std::sin(0.295279920101166*x_13 - 4.40863990783691) + 0.213345484924309*std::sin(0.305279940366745*x_13 + 5.13495969772339) + 0.0108440051284342*std::sin(0.121120058000088*x_14 - 1.25951981544495) + 0.0702015164160828*std::sin(0.243039980530739*x_14 - 1.1814398765564) + 0.0375001082612522*std::sin(0.303039938211441*x_14 - 7.43951988220215) - 0.00218596571365382*std::sin(0.442319840192795*x_14 - 1.44655990600586) - 3.01570187378818e-5*std::sin(0.53143984079361*x_14 - 1.31679975986481) + 1.2246814877747e-5*std::sin(0.538719832897186*x_14 + 1.86799991130829) + 0.00708021481099441*std::sin(0.244799971580505*x_15 - 1.17535984516144) + 0.00846928005706527*std::sin(0.267919957637787*x_15 + 1.98791980743408) - 5.59303543915979e-6*std::sin(0.29615992307663*x_15 + 5.17063999176025) + 1.36790231109928e-5*std::sin(0.502879858016968*x_15 + 8.08672046661377) - 0.0132537096216589*std::sin(0.387599855661392*x_16 - 1.18503987789154) + 1.81255774446124e-5*std::sin(0.51095986366272*x_16 + 8.10847949981689) - 2.95698518561395e-5*std::sin(0.27975994348526*x_17 - 7.37399959564209) - 0.0121103833961662*std::sin(0.380239844322205*x_17 - 1.1743198633194) + 0.00020816810433391*std::sin(0.383119851350784*x_17 + 1.99287974834442) - 0.000447311147872175*std::sin(0.428399860858917*x_17 - 1.20383989810944) - 2.65663236392621e-7*std::sin(0.606959879398346*x_17 + 5.00175952911377) + 0.0345783219803797*std::sin(0.314559936523438*x_18 - 1.15207993984222) + 7.88358497392683e-6*std::sin(0.374319821596146*x_18 + 2.02303981781006) + 0.00319012946786843*std::sin(0.51775985956192*x_18 + 2.0559196472168) + 0.0134454132955975*std::sin(0.222240000963211*x_19 + 8.1947193145752) - 0.066346058340463*std::sin(0.25655996799469*x_19 + 8.21303939819336) + 0.00751588858508103*std::sin(0.39319983124733*x_19 - 1.2047199010849) - 1.4961412281529e-5*std::sin(0.365679860115051*x_2 + 5.18024015426636) - 0.0720333955563505*std::sin(0.377919852733612*x_2 + 5.17736005783081) + 0.0120250354482632*std::sin(0.399199843406677*x_2 + 5.20344018936157) - 8.12336586624328e-5*std::sin(0.409279853105545*x_2 - 1.17679977416992) + 0.000185833003537308*std::sin(0.337519854307175*x_20 - 7.79392004013062) - 0.000257284979138205*std::sin(0.415519863367081*x_20 + 7.59352016448975) + 0.000298599047134376*std::sin(0.317199915647507*x_21 - 1.19207990169525) + 0.000630578318620695*std::sin(0.340239852666855*x_21 + 2.04071974754333) + 0.000227363212620983*std::sin(0.482559859752655*x_22 + 4.98415994644165) - 1.40508493895895e-5*std::sin(0.275279939174652*x_23 - 1.15063989162445) - 0.00243967875534903*std::sin(0.354399859905243*x_23 - 1.39335989952087) + 0.00974719865123107*std::sin(0.366559833288193*x_23 - 7.36911964416504) + 5.8886723023679e-5*std::sin(0.832639873027802*x_23 - 7.78951978683472) + 0.022152794344253*std::sin(0.386879861354828*x_24 - 1.19351994991302) - 3.21732407899448e-6*std::sin(0.442479848861694*x_24 - 1.21311986446381) - 8.10790689956235e-5*std::sin(0.827359914779663*x_24 + 1.80167984962463) - 0.000103713478772805*std::sin(0.261439979076385*x_25 - 7.37575960159302) - 0.0277796591599315*std::sin(0.284159928560257*x_26 + 1.98807990550995) - 0.000444943526868326*std::sin(0.304559946060181*x_26 - 1.17807984352112) - 0.00162161437222285*std::sin(0.783759832382202*x_26 - 1.39231991767883) - 2.61131546119618e-7*std::sin(0.463919848203659*x_27 + 4.5776801109314) + 0.000569438822606092*std::sin(0.0912800803780556*x_28 + 2.02471995353699) + 4.32390968244302e-5*std::sin(0.805839836597443*x_28 + 4.79120016098022) + 0.00011036734917769*std::sin(0.323039919137955*x_29 + 4.80983972549438) - 0.000166983310067897*std::sin(0.856159865856171*x_29 - 5.43487977981567) + 0.0299027714511388*std::sin(0.2743199467659*x_3 - 1.15183985233307) + 0.0133214781532809*std::sin(0.316159933805466*x_3 + 8.28087997436523) + 0.000958426080006682*std::sin(0.344079852104187*x_3 - 7.40455961227417) + 0.00179245437042143*std::sin(0.348319828510284*x_3 + 1.97527980804443) - 0.0115638028601291*std::sin(0.372479856014252*x_3 + 5.19831991195679) + 6.66750808540665e-5*std::sin(0.396399825811386*x_3 - 7.40655994415283) + 0.00209160359874192*std::sin(0.259519964456558*x_30 + 1.99079978466034) - 1.07861151186276e-5*std::sin(0.266159951686859*x_30 - 1.1651998758316) + 0.021871624196606*std::sin(0.284959942102432*x_30 - 1.16359984874725) - 0.00187477504620666*std::sin(0.304079920053482*x_30 - 1.16567981243134) + 0.0242698545280001*std::sin(0.312719941139221*x_30 + 1.99159979820251) + 7.05952194036428e-5*std::sin(0.765519857406616*x_30 - 7.37951993942261) + 2.8865593579504e-5*std::sin(0.293119937181473*x_31 - 1.07175981998444) + 0.0237971799486292*std::sin(0.350399851799011*x_31 + 5.15687990188599) + 0.0175119110957955*std::sin(0.375759840011597*x_31 - 7.39991998672485) - 0.0037914220767072*std::sin(0.386079847812653*x_31 - 7.39783954620361) + 0.000179244732881134*std::sin(0.396079838275909*x_31 + 8.38568019866943) - 0.0120809527036201*std::sin(0.405199855566025*x_31 + 5.19992017745972) - 0.013387347622084*std::sin(0.613279819488525*x_31 + 5.1956000328064) - 0.000125814927012155*std::sin(0.285679936408997*x_32 + 8.2425594329834) - 0.0704069672265366*std::sin(0.302159935235977*x_32 - 1.14591991901398) - 9.73655669850837e-5*std::sin(0.213440001010895*x_33 + 1.971599817276) - 0.0327842863441549*std::sin(0.233039990067482*x_33 + 1.9968798160553) + 8.10550178583876e-6*std::sin(0.233519986271858*x_33 - 1.17975986003876) - 0.0022933311634172*std::sin(0.179520010948181*x_35 + 8.40520000457764) - 0.0283383779244555*std::sin(0.1893600076437*x_36 - 7.60423994064331) + 0.00225581592063963*std::sin(0.291999936103821*x_37 + 4.77928018569946) + 3.22718607454808e-6*std::sin(0.538559854030609*x_37 - 0.706639885902405) - 0.0001547579365742*std::sin(0.249199971556664*x_4 - 7.36111974716187) - 7.28608365972441e-7*std::sin(0.772719860076904*x_4 + 8.20959949493408) + 0.000404587959731055*std::sin(0.862319886684418*x_4 + 7.99488019943237) + 0.00051976570189186*std::sin(0.16312001645565*x_40 + 5.19856023788452) + 0.000256456045351187*std::sin(0.171840012073517*x_41 - 1.20207989215851) + 8.51434919259846e-5*std::sin(0.459839850664139*x_44 - 1.4592798948288) + 6.1533247316167e-5*std::sin(0.576399862766266*x_45 + 5.03351974487305) - 0.00258485195793564*std::sin(0.228719994425774*x_48 - 7.5971999168396) + 0.00313607430122746*std::sin(0.467279851436615*x_49 - 1.34599983692169) + 0.00123447663067778*std::sin(0.254319965839386*x_5 - 7.56360006332397) + 0.000746235643382785*std::sin(0.265679955482483*x_5 + 2.00615978240967) + 2.30694174964413e-5*std::sin(0.350159853696823*x_5 - 1.14927983283997) - 0.0215514778797643*std::sin(0.386959850788116*x_5 - 7.39559984207153) - 0.0105991705671699*std::sin(0.224399983882904*x_50 + 4.37063980102539) - 0.0294827059157169*std::sin(0.16872002184391*x_51 + 8.20335960388184) + 0.00635621601050273*std::sin(0.255279958248138*x_52 - 1.2079998254776) + 0.000307144587683709*std::sin(0.233999982476234*x_53 - 7.42159986495972) - 0.00489165724961984*std::sin(0.20024000108242*x_54 + 5.00152015686035) + 1.56159365077849e-6*std::sin(0.5655198097229*x_54 + 4.83576011657715) - 0.0154771338909103*std::sin(0.337999850511551*x_56 + 1.85591995716095) - 3.0010860986437e-5*std::sin(0.169280022382736*x_57 + 1.61479985713959) - 0.0034049541004265*std::sin(0.29351994395256*x_57 - 1.42783987522125) + 8.88048091781353e-7*std::sin(0.48447984457016*x_58 + 4.6911997795105) + 0.000113224016413727*std::sin(0.359359860420227*x_59 + 4.64055967330933) - 0.000518358769345839*std::sin(0.606719851493835*x_59 - 7.81207990646362) - 1.56828117992245e-5*std::sin(0.342959851026535*x_6 + 2.01183986663818) + 0.0380251905654238*std::sin(0.366239845752716*x_6 + 1.99223983287811) - 0.00578822263109359*std::sin(0.367599844932556*x_6 - 1.16799986362457) - 0.00994386174676275*std::sin(0.378479838371277*x_6 + 1.99007987976074) - 0.000203177555224033*std::sin(0.38351982831955*x_6 - 1.17855989933014) - 0.00297015200620942*std::sin(0.452159851789474*x_60 - 7.48456001281738) + 5.54367069145416e-8*std::sin(1.41623985767365*x_64 + 6.79663991928101) + 1.65677051401787e-5*std::sin(1.77119994163513*x_64 + 3.59479999542236) + 0.0614568089617206*std::sin(0.354959845542908*x_7 + 2.00631976127625) + 0.0158060854442431*std::sin(0.359199851751328*x_7 - 1.15143990516663) + 0.000896655989756827*std::sin(0.376479834318161*x_7 + 2.02695989608765) + 0.00460304658803293*std::sin(0.480159848928452*x_7 + 1.93423986434937) + 2.04666757406408e-5*std::sin(1.0732798576355*x_70 + 2.81663990020752) - 6.44037279533966e-5*std::sin(1.18463981151581*x_70 - 9.6071195602417) - 0.000746190015443852*std::sin(0.909999787807465*x_72 + 7.97391986846924) - 0.000147324179383464*std::sin(1.2240799665451*x_73 - 0.783519864082336) + 7.34777775735106e-5*std::sin(1.13831984996796*x_75 - 2.37199997901917) + 1.47339926482257e-6*std::sin(1.22527992725372*x_75 + 3.99287986755371) - 0.000369351221981241*std::sin(1.41495978832245*x_77 + 1.97983980178833) + 0.000431757425337004*std::sin(0.803119838237762*x_78 + 3.78615999221802) - 4.4938423168098e-5*std::sin(0.295279920101166*x_8 - 1.19455993175507) - 0.0322169133010821*std::sin(0.307679921388626*x_8 + 2.11904001235962) - 0.0206763334064809*std::sin(0.314959913492203*x_8 + 5.15392017364502) + 0.000817412438248247*std::sin(0.398239850997925*x_8 - 7.80751991271973) - 6.67536589232069e-5*std::sin(0.451759845018387*x_8 + 7.95944023132324) - 7.6095777738405e-5*std::sin(0.171200007200241*x_87 + 5.50552034378052) - 0.000390089863238456*std::sin(0.180960014462471*x_88 - 7.25880002975464) - 1.26703215597946e-6*std::sin(1.14111983776093*x_88 - 1.60359990596771) + 0.00608856409772303*std::sin(0.376639842987061*x_9 - 4.38687992095947) - 0.033922043660361*std::sin(0.452639847993851*x_9 - 4.27943992614746) + 2.1210030882399e-5*std::sin(0.485359847545624*x_9 - 4.47983980178833) + 0.000114642424262804*std::sin(1.79071986675262*x_90 - 2.39239978790283) + 0.0143406065934129*std::sin(0.329519838094711*x_91 - 4.20544004440308) - 0.00554147076872735*std::sin(0.388959854841232*x_91 + 1.971599817276) - 0.000222690207625887*std::sin(0.417119860649109*x_91 + 8.21047973632813) + 1.63862306132528e-6*std::sin(0.239759981632233*x_92 + 5.19600009918213) - 0.00427128860123993*std::sin(0.253919988870621*x_92 + 2.02055978775024) - 0.0311095600928277*std::sin(0.285359919071198*x_92 + 1.99703979492188) - 0.0135824182148872*std::sin(0.327039837837219*x_92 + 8.22480010986328) - 4.85094993617783e-5*std::sin(0.257679969072342*x_94 - 7.39807987213135) + 0.0052487236408057*std::sin(0.310879945755005*x_94 + 1.79847991466522) + 0.00971719409279858*std::sin(0.262319982051849*x_96 - 1.20431983470917) + 0.00508869654659573*std::sin(0.30447992682457*x_96 - 4.41775989532471) - 0.000356590239036672*std::sin(0.273119956254959*x_97 + 1.96655988693237) + 0.000306540141006561*std::sin(0.27991995215416*x_97 + 1.97735977172852) - 0.00437154321628217*std::sin(0.261359959840775*x_98 - 4.42471981048584) - 0.146114245057106*std::sin(-0.00719817733072681*x_10 + 0.0113195650591993*x_100 - 0.00494513167394395*x_101 - 0.00452024364350084*x_102 + 0.00457895724808274*x_103 + 0.000626947865377167*x_104 + 0.0111341481665937*x_105 + 0.00963306375481692*x_106 + 0.000314496483365713*x_107 + 0.0111607100652451*x_108 + 0.00078558796439854*x_109 - 0.00962412158270774*x_11 - 0.00206514069514013*x_110 - 0.00411582785237448*x_111 + 0.00351716886103585*x_112 + 0.0042805614064677*x_113 + 0.00282428637139846*x_114 + 0.0020195104663125*x_115 + 0.00238661771157208*x_116 + 0.000875642712437381*x_117 + 0.00458989291492353*x_118 - 0.00193407592475645*x_119 - 0.00203536703307176*x_12 + 0.00374191116910826*x_120 - 0.000744587017316272*x_13 - 0.00655165533466504*x_14 - 0.00252147287883504*x_15 - 0.0116822682574128*x_16 + 0.0042594308621176*x_17 + 0.00927869875159015*x_19 - 0.000924695425484626*x_2 + 0.000922225681179427*x_20 - 0.00205951024682961*x_21 - 0.000975912432049557*x_24 - 0.00387708796248935*x_25 + 0.00277472822403465*x_26 - 0.0033246134627346*x_27 - 0.00433702456129118*x_28 + 0.00351609548302582*x_30 + 0.04346860297703*x_33 - 0.0195227846065218*x_36 - 0.00289224912304269*x_37 + 0.0130974194759506*x_38 - 0.00910415809301757*x_39 + 0.00181650393259589*x_40 - 0.00690938865525212*x_41 - 0.00317725301321395*x_42 - 0.00088166826356783*x_43 + 0.00194305188106252*x_44 - 0.00232538749110718*x_45 + 0.0100388243367746*x_46 + 0.0274245660327403*x_48 - 0.000734831482869606*x_49 - 0.00356662627177213*x_5 - 0.000370855816104834*x_51 + 0.00404726001024297*x_52 + 0.0129528687856327*x_53 + 0.000270036891418231*x_54 - 0.00155523442194433*x_55 + 0.00425862609197825*x_56 + 0.000253969210755942*x_57 + 0.00141383815848513*x_58 - 0.000525946811942969*x_59 - 0.0216994553357778*x_6 + 0.0015906624573498*x_60 - 0.00471880992912387*x_61 - 0.00075388950204981*x_62 + 0.00759282341258849*x_63 + 0.00908765764385407*x_64 + 0.0101283622662738*x_65 - 0.00218592801773015*x_66 + 0.00146797660137096*x_67 + 0.00126478154776303*x_68 + 0.00388313181001034*x_69 + 0.00575734140067889*x_70 - 0.00266288068935149*x_71 + 0.000460247150745637*x_72 + 0.00737708728467919*x_73 + 0.0119974095865751*x_74 + 0.00448276116896804*x_75 + 0.00236927679594526*x_76 + 0.0105952505594251*x_77 + 0.00103558258678217*x_78 - 0.00353384911592316*x_79 + 0.00483602419539949*x_8 + 0.00192958394201605*x_80 - 0.0101391424684572*x_81 - 0.00303214831553417*x_82 + 0.00524156681341856*x_83 + 0.00750317837775765*x_84 + 0.000253779545584528*x_85 + 0.000671815779937551*x_86 - 0.00559924353398423*x_87 + 0.00438889853993813*x_88 + 0.000380026402041057*x_89 + 0.00352082800137566*x_9 - 0.00591607447167098*x_90 + 0.0279195576464045*x_93 - 0.00658295755886549*x_96 - 0.000596408142959794*x_97 + 0.00122058806977973*x_98 + 0.00242966320389118*x_99 + 0.0951403424193835*std::exp(0.318959832191467*x_18) - 2.37772354614043*std::sin(0.332799851894379*x_1 - 4.25031995773315) - 0.161835907984678*std::sin(0.317359924316406*x_22 + 8.25111961364746) + 0.548249222586819*std::sin(0.319999933242798*x_23 - 1.16799986362457) - 0.065561306138429*std::sin(0.377759844064713*x_29 - 1.18191993236542) + 0.285668248511314*std::sin(0.359439849853516*x_3 - 7.39336013793945) - 0.0455018423174343*std::sin(0.340319842100143*x_31 - 1.01967978477478) + 0.67980480096189*std::sin(0.30839991569519*x_32 - 1.14823985099792) - 0.0541426719237714*std::sin(0.225599989295006*x_34 + 1.77711987495422) + 0.0341525903624396*std::sin(0.179120019078255*x_35 + 8.19151973724365) - 1.16220015777216*std::sin(0.178640007972717*x_4 + 8.1755199432373) - 0.0051566646442891*std::sin(0.665839850902557*x_47 + 7.57984018325806) + 0.0486348910734771*std::sin(0.209279999136925*x_50 + 8.17591953277588) - 0.364526203089333*std::sin(0.322959840297699*x_7 - 7.339439868927) + 0.0760882741558007*std::sin(0.370879858732224*x_91 + 5.18943977355957) - 0.183522949014659*std::sin(0.321039855480194*x_92 - 1.1814398765564) - 0.26622091047151*std::sin(0.287839949131012*x_94 + 1.97927987575531) - 0.0886955127145814*std::sin(0.253759980201721*x_95 - 7.40999984741211) + 1.54215973612486) + 0.592112740620401);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000106891449079868*x_1 - 0.000702061308947711*x_10 + 0.000308399671396304*x_100 - 0.00224481985935952*x_101 + 0.00130915423712564*x_102 - 0.00158091920929452*x_103 + 8.40526383639169e-6*x_104 + 0.00135920605713543*x_105 + 0.000845180604841979*x_106 - 0.000220839210491524*x_107 - 6.5919283871075e-5*x_108 + 0.00089600861281249*x_109 - 0.000940341034353283*x_11 - 0.000796278532379619*x_110 - 0.000647868143984863*x_111 + 0.00586447018611435*x_112 + 0.00209808566722026*x_113 - 0.000196899901730729*x_114 + 0.000750374287300754*x_115 + 0.00138135799113212*x_116 - 0.000662147339719019*x_117 - 0.000383424553927469*x_118 - 0.000754029375555859*x_119 - 0.000592164170931725*x_12 + 9.42377719726905e-5*x_120 + 0.000109912190535956*x_13 + 9.90936412421877e-5*x_14 + 0.000177436651914173*x_15 - 0.000654208361653932*x_16 - 0.000934703520165879*x_17 + 0.00255022062941464*x_18 + 0.000387402754068142*x_19 - 0.000284393225016488*x_2 - 0.000221297369908756*x_20 - 0.000339734898781719*x_21 + 0.000470510097625816*x_22 + 0.000365588518401924*x_23 - 0.000110909393499825*x_24 - 0.000678592027976543*x_25 - 5.67517589879062e-5*x_26 - 8.95434709911637e-6*x_27 - 0.000595980909773249*x_28 - 0.00115443638258226*x_29 + 0.000432960010946007*x_3 - 0.000792819192239639*x_30 - 0.000745865877170005*x_31 - 0.000542915771771311*x_32 + 0.00134857633336146*x_33 - 6.38851895772178e-5*x_34 - 0.000703068148740206*x_35 + 0.00151555518522406*x_36 - 0.000396391482967275*x_37 + 0.00189607609655241*x_38 + 0.00115148224306955*x_39 - 0.000860271963841476*x_4 + 0.00142776881969895*x_40 - 0.000615502636187131*x_41 + 0.00155514240989064*x_42 + 0.000469519529921723*x_43 + 0.000459474002899074*x_44 + 0.00121439173895685*x_45 + 0.000603964815855416*x_46 + 0.000403498214165106*x_47 + 0.00830923117468306*x_48 + 0.00604230635884326*x_49 + 0.00217398777144994*x_5 + 0.000113623014793969*x_50 - 0.00519575938863113*x_51 - 0.00523237977371419*x_52 - 0.0035776269454905*x_53 - 0.000111812675779552*x_54 - 0.00126971844925887*x_55 + 0.00495256150463415*x_56 - 0.00127971977457516*x_57 - 0.000505787283602483*x_58 - 2.28635133726001e-5*x_59 + 0.000566053854513689*x_6 + 0.000857551418225168*x_60 + 0.000202427661740035*x_61 - 0.000700321482960956*x_62 + 8.44239563215161e-5*x_63 - 0.000230656958049429*x_64 - 3.57571681792472e-5*x_65 + 0.000532088134027482*x_66 - 9.16377074355608e-5*x_67 + 0.00126955196809254*x_68 + 2.22004960008143e-5*x_69 - 0.000671295784741189*x_7 - 9.74837820754792e-5*x_70 - 0.00074325070239316*x_71 - 0.000341377510847033*x_72 + 0.000778564977784281*x_73 - 0.000130661743830483*x_74 + 8.51858935183514e-5*x_75 + 0.000274385164980023*x_76 + 0.000397257401869449*x_77 + 0.000665288997249728*x_78 - 0.000579937372960033*x_79 - 0.000474005792926908*x_8 - 0.00143869033058142*x_80 - 0.000865496085018728*x_81 - 0.000172890209485849*x_82 - 0.000529959843106488*x_83 + 0.000316870333399066*x_84 - 0.000480749218064954*x_85 - 4.36896202372732e-5*x_86 + 0.000169525748396813*x_87 + 0.000309438182172407*x_88 - 1.35746937515618e-5*x_89 - 0.000202514775191939*x_9 - 0.000150426228091775*x_90 - 0.000308953643277256*x_91 + 0.000550629909293863*x_92 - 0.000783192826078499*x_93 - 0.000585805502096813*x_94 - 0.0012127339951127*x_95 - 0.000667956875167163*x_96 - 0.00070787315950546*x_97 + 0.00139791042755218*x_98 - 0.00104667258596044*x_99 - 6.8713905839271e-7*std::pow(2.4696798324585 - 7.17983961105347*x_59, 2) - 2.96248765382548e-7*std::pow(5.30704021453857 - 8.17615985870361*x_15, 2) - 8.31288911783457e-7*std::pow(5.54383993148804 - 0.991999804973602*x_10, 2) + 1.68081349313611e-7*std::pow(-2.62831997871399*x_16 - 9.89848041534424, 2) + 1.71307983747998e-7*std::pow(-3.71199989318848*x_25 - 8.0, 2) + 1.73037425764187e-7*std::pow(-9.3261604309082*x_28 - 1.61375975608826, 2) - 4.39942648358653e-6*std::pow(-5.89263963699341*x_60 - 9.60136032104492, 2) - 2.76128848349067e-6*std::pow(-3.8724000453949*x_61 - 6.51895952224731, 2) - 2.905934666568e-6*std::pow(-2.83240008354187*x_64 - 9.11664009094238, 2) + 2.1569038467833e-7*std::pow(-2.76160001754761*x_64 - 6.32287979125977, 2) - 2.89673877167195e-6*std::pow(-3.67159986495972*x_9 - 7.73672008514404, 2) - 0.010707930054032*std::exp(0.208559840917587*x_13) + 0.000176592214895776*std::exp(0.253679871559143*x_13) + 5.59569976799983e-5*std::exp(0.541759848594666*x_13) + 0.00278350979388*std::exp(0.173759862780571*x_14) - 0.000125601458141832*std::exp(0.318959832191467*x_18) + 1.01356027399848e-5*std::exp(0.403919875621796*x_18) + 0.000175440699534637*std::exp(0.45007985830307*x_18) + 1.60593135468435e-5*std::exp(0.250079840421677*x_20) + 0.00108380302285642*std::exp(0.326959848403931*x_22) - 2.30637843908217e-5*std::exp(0.548639833927155*x_22) - 3.40298060630377e-5*std::exp(0.521439850330353*x_26) - 0.000269506683171873*std::exp(0.310879856348038*x_28) - 0.000816399861863202*std::exp(0.321919828653336*x_30) + 0.000126741794097933*std::exp(0.370639860630035*x_5) + 0.000183212985623068*std::exp(0.319119840860367*x_59) + 0.000117462456800684*std::exp(0.324639827013016*x_6) - 7.45229156082867e-5*std::log(5.16136026382446 - 0.59639984369278*x_9) + 0.00313900010089265*std::sin(0.332799851894379*x_1 - 4.25031995773315) + 0.00982161995256871*std::sin(0.337039858102798*x_1 - 4.24552011489868) + 0.0333839621896574*std::sin(0.344959855079651*x_1 - 4.25184011459351) + 0.0175572724021896*std::sin(0.348479837179184*x_1 + 5.15775966644287) + 0.000201936910721978*std::sin(0.351919859647751*x_1 - 4.22544002532959) + 0.00260246736229372*std::sin(0.353119850158691*x_1 - 4.22032022476196) - 0.0105910299821776*std::sin(0.358719855546951*x_1 - 4.23680019378662) + 0.00191061747760374*std::sin(0.359119862318039*x_1 - 1.03623986244202) + 0.0351968668832269*std::sin(0.403519839048386*x_1 - 4.18416023254395) - 0.000141746620878319*std::sin(1.34607982635498*x_100 - 4.97455978393555) + 0.00534805105464942*std::sin(0.225759983062744*x_107 - 4.39264011383057) + 0.00901242940345197*std::sin(0.206160008907318*x_108 - 4.39903974533081) + 0.022804259361495*std::sin(0.20584000647068*x_109 + 5.18096017837524) + 0.00519212960251457*std::sin(0.102400071918964*x_11 - 4.28399991989136) - 0.0435856568518392*std::sin(0.175360009074211*x_11 + 5.18400001525879) - 0.0482561073903066*std::sin(0.283119946718216*x_11 - 7.42775964736938) - 0.000355890916393595*std::sin(0.282959938049316*x_112 - 7.43111991882324) + 0.00390709053288089*std::sin(0.323279827833176*x_112 - 1.34607982635498) + 0.000302094451821149*std::sin(0.254479974508286*x_113 - 4.22528028488159) - 0.000613134314807245*std::sin(0.287439942359924*x_113 - 7.42911958694458) + 0.0119206737839911*std::sin(0.2880799472332*x_113 - 7.42679977416992) - 0.00645515718780815*std::sin(0.233999982476234*x_114 + 1.97791981697083) + 0.000871820959284157*std::sin(0.241119980812073*x_114 - 1.23959982395172) - 0.0140429674727998*std::sin(0.209199994802475*x_116 + 2.000159740448) - 0.0150435459809177*std::sin(0.233519986271858*x_116 + 1.79903984069824) - 0.00671721230264825*std::sin(0.251039981842041*x_116 + 5.16688013076782) + 0.00240824724785356*std::sin(0.262319952249527*x_116 - 1.23943984508514) + 0.000121268291851012*std::sin(1.02279984951019*x_116 + 8.39000034332275) + 0.000590790478343276*std::sin(0.218319997191429*x_118 - 4.21447992324829) + 0.0112986868957001*std::sin(0.226719990372658*x_119 + 5.18576002120972) + 0.00956643902279292*std::sin(0.235759988427162*x_119 + 5.17343997955322) - 0.0430440992673902*std::sin(0.298639953136444*x_12 + 5.12664031982422) - 0.000597149519233959*std::sin(0.539439857006073*x_12 + 7.83392000198364) - 0.00186605557857061*std::sin(0.179840013384819*x_13 + 1.59295988082886) + 0.0909154054264095*std::sin(0.232399985194206*x_13 - 7.40807962417603) + 0.000200448791247338*std::sin(0.295279920101166*x_13 - 4.40863990783691) - 0.0525855616077949*std::sin(0.121120058000088*x_14 - 1.25951981544495) + 0.0699394584941018*std::sin(0.303039938211441*x_14 - 7.43951988220215) + 0.000701552081244227*std::sin(0.442319840192795*x_14 - 1.44655990600586) + 0.000653187212650364*std::sin(0.53143984079361*x_14 - 1.31679975986481) - 0.0002264717550899*std::sin(0.538719832897186*x_14 + 1.86799991130829) - 0.0343339077887109*std::sin(0.244799971580505*x_15 - 1.17535984516144) - 0.00271808519848327*std::sin(0.267919957637787*x_15 + 1.98791980743408) - 0.000146717119056725*std::sin(0.270559966564178*x_15 + 1.77759981155396) + 0.00283898568787018*std::sin(0.29615992307663*x_15 + 5.17063999176025) + 0.0291655620651364*std::sin(0.316639930009842*x_15 + 5.14856004714966) - 0.000252956577100785*std::sin(0.502879858016968*x_15 + 8.08672046661377) - 0.00941372256988691*std::sin(0.297039926052094*x_16 + 2.00455975532532) - 0.00155516265253942*std::sin(0.314639925956726*x_16 + 1.9968798160553) + 0.004253574294969*std::sin(0.387599855661392*x_16 - 1.18503987789154) - 0.000335183586661224*std::sin(0.51095986366272*x_16 + 8.10847949981689) + 0.000546814523976886*std::sin(0.27975994348526*x_17 - 7.37399959564209) - 0.00210932989788509*std::sin(0.344799846410751*x_17 + 1.99871981143951) + 0.00388664132432565*std::sin(0.380239844322205*x_17 - 1.1743198633194) - 0.000107700119058785*std::sin(0.383119851350784*x_17 + 1.99287974834442) + 0.00968855457515903*std::sin(0.428399860858917*x_17 - 1.20383989810944) + 0.000134848801534721*std::sin(0.606959879398346*x_17 + 5.00175952911377) + 0.0644901902174322*std::sin(0.314559936523438*x_18 - 1.15207993984222) - 0.0040016526184302*std::sin(0.374319821596146*x_18 + 2.02303981781006) + 0.00989906536230088*std::sin(0.431999862194061*x_18 - 7.42375993728638) - 0.0010238229966932*std::sin(0.51775985956192*x_18 + 2.0559196472168) - 8.35140106901471e-5*std::sin(0.524639844894409*x_18 + 2.05535984039307) - 0.0652005048710259*std::sin(0.222240000963211*x_19 + 8.1947193145752) - 0.123738506599051*std::sin(0.25655996799469*x_19 + 8.21303939819336) - 0.0117642927492181*std::sin(0.257999986410141*x_19 + 8.2061595916748) + 0.00104814688558398*std::sin(0.39319983124733*x_19 - 1.2047199010849) + 0.0075943082785055*std::sin(0.365679860115051*x_2 + 5.18024015426636) - 0.134345656913961*std::sin(0.377919852733612*x_2 + 5.17736005783081) + 0.000765955723514737*std::sin(0.388719856739044*x_2 + 5.18279981613159) - 0.058312702263713*std::sin(0.399199843406677*x_2 + 5.20344018936157) + 4.20279309239957e-5*std::sin(0.409279853105545*x_2 - 1.17679977416992) + 0.000760699624794755*std::sin(0.337519854307175*x_20 - 7.79392004013062) + 3.693417859215e-5*std::sin(0.415519863367081*x_20 + 7.59352016448975) - 0.000841884670339564*std::sin(0.317199915647507*x_21 - 1.19207990169525) - 0.000326242870917446*std::sin(0.340239852666855*x_21 + 2.04071974754333) + 0.000213650965570223*std::sin(0.317359924316406*x_22 + 8.25111961364746) - 0.000738011104289764*std::sin(0.399679869413376*x_22 + 2.00927972793579) + 0.000930701798069946*std::sin(0.482559859752655*x_22 + 4.98415994644165) + 0.00713211292032446*std::sin(0.275279939174652*x_23 - 1.15063989162445) - 0.000723782362254784*std::sin(0.319999933242798*x_23 - 1.16799986362457) + 0.000782977380519652*std::sin(0.354399859905243*x_23 - 1.39335989952087) + 0.0181789820645914*std::sin(0.366559833288193*x_23 - 7.36911964416504) - 0.00808658450485757*std::sin(0.370399862527847*x_23 + 1.99191975593567) - 3.04662767666795e-5*std::sin(0.832639873027802*x_23 - 7.78951978683472) + 0.0413159991372387*std::sin(0.386879861354828*x_24 - 1.19351994991302) + 0.0016330912101064*std::sin(0.442479848861694*x_24 - 1.21311986446381) - 0.000331893776614854*std::sin(0.827359914779663*x_24 + 1.80167984962463) + 5.36583356397135e-5*std::sin(0.261439979076385*x_25 - 7.37575960159302) - 0.0032057870325891*std::sin(0.324319839477539*x_25 - 1.13855993747711) + 0.00142488268023823*std::sin(0.338639855384827*x_25 - 1.14871978759766) + 0.012376343274249*std::sin(0.152400031685829*x_26 + 8.14935970306396) - 0.0518103655931004*std::sin(0.284159928560257*x_26 + 1.98807990550995) + 0.00125449541126194*std::sin(0.304559946060181*x_26 - 1.17807984352112) - 0.000226146254647449*std::sin(0.783759832382202*x_26 - 1.39231991767883) + 0.000250082564248078*std::sin(0.285999923944473*x_27 - 7.39047956466675) - 0.00380870121523933*std::sin(0.367839843034744*x_27 + 5.23767995834351) + 0.000132548547233303*std::sin(0.463919848203659*x_27 + 4.5776801109314) - 0.000294611074965629*std::sin(0.0912800803780556*x_28 + 2.02471995353699) - 0.000936539031850353*std::sin(0.805839836597443*x_28 + 4.79120016098022) - 0.00239050623019403*std::sin(0.323039919137955*x_29 + 4.80983972549438) + 8.65520917758655e-5*std::sin(0.377759844064713*x_29 - 1.18191993236542) + 2.39710511535271e-5*std::sin(0.856159865856171*x_29 - 5.43487977981567) + 0.0041701651657071*std::sin(0.2743199467659*x_3 - 1.15183985233307) + 0.00103825212923901*std::sin(0.2882399559021*x_3 - 1.13159990310669) - 0.064599509299328*std::sin(0.316159933805466*x_3 + 8.28087997436523) - 0.000495861761608738*std::sin(0.344079852104187*x_3 - 7.40455961227417) + 0.0073373369696818*std::sin(0.348319828510284*x_3 + 1.97527980804443) - 0.000377130748591191*std::sin(0.359439849853516*x_3 - 7.39336013793945) + 0.00371122470629301*std::sin(0.372479856014252*x_3 + 5.19831991195679) - 0.00123297549056766*std::sin(0.396399825811386*x_3 - 7.40655994415283) - 0.00108213483198633*std::sin(0.259519964456558*x_30 + 1.99079978466034) + 0.00547495662822121*std::sin(0.266159951686859*x_30 - 1.1651998758316) - 0.00701936145634831*std::sin(0.284959942102432*x_30 - 1.16359984874725) + 0.0406067687731988*std::sin(0.304079920053482*x_30 - 1.16567981243134) - 0.000978554248251393*std::sin(0.308239936828613*x_30 + 2.00159978866577) - 0.00348402438628626*std::sin(0.312719941139221*x_30 + 1.99159979820251) - 0.000199039593681084*std::sin(0.765519857406616*x_30 - 7.37951993942261) - 0.000533791169779214*std::sin(0.293119937181473*x_31 - 1.07175981998444) - 0.000203873667737431*std::sin(0.309599936008453*x_31 - 4.056960105896) + 6.00701826152468e-5*std::sin(0.340319842100143*x_31 - 1.01967978477478) + 0.00331869475797561*std::sin(0.350399851799011*x_31 + 5.15687990188599) - 0.0849200704805596*std::sin(0.375759840011597*x_31 - 7.39991998672485) + 0.00370458221853406*std::sin(0.376639842987061*x_31 - 4.22408008575439) - 0.0155200276392815*std::sin(0.386079847812653*x_31 - 7.39783954620361) - 0.000505371314141626*std::sin(0.396079838275909*x_31 + 8.38568019866943) + 0.0017342639520325*std::sin(0.405199855566025*x_31 + 5.19992017745972) + 0.00232660717267185*std::sin(0.285679936408997*x_32 + 8.2425594329834) - 0.131312291893408*std::sin(0.302159935235977*x_32 - 1.14591991901398) - 0.000897458134807339*std::sin(0.30839991569519*x_32 - 1.14823985099792) + 5.03741108181453e-5*std::sin(0.213440001010895*x_33 + 1.971599817276) - 0.0611442297193305*std::sin(0.233039990067482*x_33 + 1.9968798160553) - 0.00411429604073084*std::sin(0.233519986271858*x_33 - 1.17975986003876) + 7.14775495692882e-5*std::sin(0.225599989295006*x_34 + 1.77711987495422) - 4.50872368099566e-5*std::sin(0.179120019078255*x_35 + 8.19151973724365) - 0.000319822185938178*std::sin(0.179520010948181*x_35 + 8.40520000457764) + 0.00031459040470112*std::sin(0.291999936103821*x_37 + 4.77928018569946) - 5.96780878620617e-5*std::sin(0.538559854030609*x_37 - 0.706639885902405) + 0.00153430217672951*std::sin(0.178640007972717*x_4 + 8.1755199432373) + 8.00672526065663e-5*std::sin(0.249199971556664*x_4 - 7.36111974716187) - 0.000410497981603451*std::sin(0.375919848680496*x_4 + 1.9793598651886) + 0.000369836512848733*std::sin(0.772719860076904*x_4 + 8.20959949493408) - 0.00012984628414928*std::sin(0.862319886684418*x_4 + 7.99488019943237) - 0.00146545268911765*std::sin(0.16312001645565*x_40 + 5.19856023788452) - 0.00555472047440334*std::sin(0.171840012073517*x_41 - 1.20207989215851) + 2.63813961068267e-5*std::sin(0.697999835014343*x_42 + 4.62016010284424) - 4.40507648703004e-5*std::sin(0.459839850664139*x_44 - 1.4592798948288) - 3.18355114162669e-5*std::sin(0.576399862766266*x_45 + 5.03351974487305) + 6.80767571359074e-6*std::sin(0.665839850902557*x_47 + 7.57984018325806) + 0.000829568487497854*std::sin(0.228719994425774*x_48 - 7.5971999168396) + 0.000437349020622298*std::sin(0.467279851436615*x_49 - 1.34599983692169) - 0.000177213533794358*std::sin(0.254319965839386*x_5 - 7.56360006332397) - 0.000386080604881326*std::sin(0.265679955482483*x_5 + 2.00615978240967) - 0.0117098750423326*std::sin(0.350159853696823*x_5 - 1.14927983283997) - 0.00157711275372225*std::sin(0.359199851751328*x_5 + 2.00079965591431) - 0.0401945157639926*std::sin(0.386959850788116*x_5 - 7.39559984207153) + 0.000652094842467885*std::sin(0.685359835624695*x_5 - 4.65687990188599) - 6.42063406548489e-5*std::sin(0.209279999136925*x_50 + 8.17591953277588) + 0.00946202109515715*std::sin(0.16872002184391*x_51 + 8.20335960388184) - 0.0020399297862511*std::sin(0.255279958248138*x_52 - 1.2079998254776) - 0.000158907671123027*std::sin(0.233999982476234*x_53 - 7.42159986495972) - 0.00912316990643628*std::sin(0.20024000108242*x_54 + 5.00152015686035) - 0.000792654019995816*std::sin(0.5655198097229*x_54 + 4.83576011657715) + 0.00171115203197694*std::sin(0.589199841022491*x_54 + 1.78703987598419) + 0.000554969796408628*std::sin(0.169280022382736*x_57 + 1.61479985713959) - 0.00635039889277239*std::sin(0.29351994395256*x_57 - 1.42783987522125) + 0.00220602611738813*std::sin(0.299759924411774*x_58 + 1.87479984760284) - 0.00045076700302232*std::sin(0.48447984457016*x_58 + 4.6911997795105) - 0.0024523803340501*std::sin(0.359359860420227*x_59 + 4.64055967330933) + 7.44122545589504e-5*std::sin(0.606719851493835*x_59 - 7.81207990646362) - 0.0134822075682655*std::sin(0.323439925909042*x_6 + 2.01247978210449) + 0.0079604856303661*std::sin(0.342959851026535*x_6 + 2.01183986663818) - 0.000650648929765073*std::sin(0.344479858875275*x_6 + 2.01703977584839) + 0.0709187615873823*std::sin(0.366239845752716*x_6 + 1.99223983287811) + 0.00185764104541291*std::sin(0.367599844932556*x_6 - 1.16799986362457) + 0.00142747690471778*std::sin(0.378479838371277*x_6 + 1.99007987976074) + 0.000105118154184664*std::sin(0.38351982831955*x_6 - 1.17855989933014) + 0.00449305578775862*std::sin(0.358639866113663*x_60 + 8.24847984313965) - 0.000414209915404945*std::sin(0.452159851789474*x_60 - 7.48456001281738) - 2.81392848704496e-5*std::sin(1.41623985767365*x_64 + 6.79663991928101) + 6.78192078045696e-5*std::sin(1.77119994163513*x_64 + 3.59479999542236) - 0.0374469495021232*std::sin(0.26079997420311*x_7 + 2.03239989280701) + 0.00048123668125035*std::sin(0.322959840297699*x_7 - 7.339439868927) + 0.00125822251857251*std::sin(0.330399841070175*x_7 - 1.15071988105774) + 0.114619827484591*std::sin(0.354959845542908*x_7 + 2.00631976127625) - 0.00226902007492194*std::sin(0.359199851751328*x_7 - 1.15143990516663) + 0.00367042377830938*std::sin(0.376479834318161*x_7 + 2.02695989608765) - 0.0014772770193641*std::sin(0.480159848928452*x_7 + 1.93423986434937) + 8.37794808260508e-5*std::sin(1.0732798576355*x_70 + 2.81663990020752) + 0.000312311379785746*std::sin(1.18463981151581*x_70 - 9.6071195602417) - 0.000104061779507193*std::sin(0.909999787807465*x_72 + 7.97391986846924) + 2.11489126590944e-5*std::sin(1.2240799665451*x_73 - 0.783519864082336) - 1.05479976660298e-5*std::sin(1.13831984996796*x_75 - 2.37199997901917) - 2.72465388579404e-5*std::sin(1.22527992725372*x_75 + 3.99287986755371) - 0.000688857330211883*std::sin(1.41495978832245*x_77 + 1.97983980178833) + 6.02118027125941e-5*std::sin(0.803119838237762*x_78 + 3.78615999221802) + 0.000831014730560219*std::sin(0.295279920101166*x_8 - 1.19455993175507) + 0.00663575125776806*std::sin(0.314959913492203*x_8 + 5.15392017364502) - 0.00396385759886556*std::sin(0.398239850997925*x_8 - 7.80751991271973) - 0.000273253309853359*std::sin(0.451759845018387*x_8 + 7.95944023132324) + 3.93697408568947e-5*std::sin(0.171200007200241*x_87 + 5.50552034378052) + 0.00109983832522922*std::sin(0.180960014462471*x_88 - 7.25880002975464) + 2.34303367025988e-5*std::sin(1.14111983776093*x_88 - 1.60359990596771) - 0.00195403102064524*std::sin(0.376639842987061*x_9 - 4.38687992095947) - 0.000392222220013795*std::sin(0.485359847545624*x_9 - 4.47983980178833) + 0.00021381349135134*std::sin(1.79071986675262*x_90 - 2.39239978790283) + 0.00199990486395811*std::sin(0.329519838094711*x_91 - 4.20544004440308) - 0.000100449482716146*std::sin(0.370879858732224*x_91 + 5.18943977355957) + 0.0268721149663255*std::sin(0.388959854841232*x_91 + 1.971599817276) + 0.000115213432678729*std::sin(0.417119860649109*x_91 + 8.21047973632813) + 0.000610050341056896*std::sin(0.227119997143745*x_92 + 2.01871991157532) - 0.000831753610274877*std::sin(0.239759981632233*x_92 + 5.19600009918213) + 0.000613158749279603*std::sin(0.253919988870621*x_92 + 2.02055978775024) - 0.0580207868127748*std::sin(0.285359919071198*x_92 + 1.99703979492188) - 0.0349665890174639*std::sin(0.303839921951294*x_92 + 1.98935985565186) + 0.000242281553887219*std::sin(0.321039855480194*x_92 - 1.1814398765564) - 0.00189416982296573*std::sin(0.327039837837219*x_92 + 8.22480010986328) + 0.000897052137119869*std::sin(0.257679969072342*x_94 - 7.39807987213135) + 0.00058442670145435*std::sin(0.275759935379028*x_94 + 1.97855985164642) + 0.00709894477011806*std::sin(0.285999953746796*x_94 - 1.19919991493225) + 0.000351456949730879*std::sin(0.287839949131012*x_94 + 1.97927987575531) + 0.000731973774640802*std::sin(0.310879945755005*x_94 + 1.79847991466522) + 0.000117093185123109*std::sin(0.253759980201721*x_95 - 7.40999984741211) + 0.0181230221576359*std::sin(0.262319982051849*x_96 - 1.20431983470917) + 0.000709656799275018*std::sin(0.30447992682457*x_96 - 4.41775989532471) - 0.00145968722389083*std::sin(0.273119956254959*x_97 + 1.96655988693237) - 0.000864274176471214*std::sin(0.27991995215416*x_97 + 1.97735977172852) - 0.00815313287098574*std::sin(0.261359959840775*x_98 - 4.42471981048584) - 0.0502531565725803*std::sin(0.00687042270400332*x_1 + 0.0109357014253845*x_10 + 0.007131550892173*x_100 + 0.0051400415316706*x_101 - 0.00207487542693843*x_102 - 0.00015121649078549*x_103 - 0.00390471805633111*x_104 - 0.005330618622802*x_105 + 0.00249061667732975*x_106 + 0.00162524200096918*x_107 + 0.0287386564283581*x_108 + 0.0187480345761953*x_109 + 0.0228472642847476*x_11 + 0.00480321012913325*x_110 + 0.00406023027245148*x_111 + 0.00793659089934813*x_112 + 5.38659996739411e-5*x_114 + 0.00971376058960781*x_115 + 0.00319815449985349*x_117 + 0.00122532250437592*x_118 + 0.0216849881893023*x_119 + 0.00856895466605861*x_120 + 0.0308182701559019*x_15 + 0.000353399297886053*x_16 + 0.00435003968901627*x_17 + 0.0100883636930766*x_18 - 0.00340016445503091*x_2 - 0.00235701548827548*x_20 - 0.000702064890846641*x_21 + 9.72182446208148e-6*x_22 + 0.00320563474847449*x_23 + 0.000710109941355306*x_24 - 0.00394468964067911*x_25 + 0.00510388008752074*x_26 - 0.00927479439370849*x_27 - 0.0064977914109525*x_28 - 0.00594478866623561*x_29 - 0.0118308079490568*x_3 + 0.00212550494894025*x_30 - 0.00656533871426632*x_32 + 0.0155548555996515*x_33 + 0.00211503110505064*x_34 + 0.00125975695953308*x_35 - 0.012883725742546*x_37 + 0.00165909240078241*x_38 - 0.00281543549623886*x_39 + 0.000869970715163146*x_4 - 0.00223687778663858*x_40 - 0.00710111786183408*x_41 + 0.00268501779075521*x_42 + 0.00395067317930485*x_43 - 0.00349002618032683*x_44 + 0.000387829973314478*x_45 + 0.00847276196123475*x_46 + 0.000445355226106343*x_47 + 0.0166345099708878*x_48 - 0.00833535960387534*x_49 + 0.00357530209165599*x_5 - 0.00632700754494778*x_51 + 0.00125496906174689*x_52 + 0.00538638714162108*x_53 - 0.00230655816567931*x_54 - 0.000878336354924386*x_55 - 0.00314831525273794*x_57 + 0.0129826289446829*x_58 + 0.00624340548155502*x_59 + 0.00472998694414574*x_6 + 0.000284303965985281*x_60 - 0.0010126902678271*x_61 - 0.0010160177160544*x_62 - 0.00197358186920285*x_63 + 0.00173101191834183*x_64 - 0.000451691876411401*x_65 - 0.00577335422451885*x_66 - 0.000902417125309506*x_67 - 0.00139165484641234*x_68 - 0.00362864785445358*x_69 + 0.00419992101129268*x_7 + 0.000978670258470849*x_70 + 0.00139927979556503*x_71 + 0.000600750359039002*x_72 - 0.00184560548197814*x_73 - 0.000764659765620905*x_74 - 0.00150370498387632*x_75 - 0.000462939971991997*x_76 - 0.00956603649520555*x_77 - 0.00562284944930889*x_78 - 0.000978370697317178*x_79 - 0.00286390924406214*x_80 + 0.00151407328902891*x_81 + 0.00234959626582071*x_82 - 0.0046292171762672*x_83 + 0.00404897093860452*x_84 + 0.00148953840706801*x_85 + 0.00253843624184173*x_86 + 0.001255461252553*x_87 - 0.000173290816489089*x_88 + 0.00438622297253081*x_89 + 0.00273278309278414*x_90 - 0.00351816027342453*x_91 + 0.0372418529405945*x_92 + 0.0125378322367326*x_93 - 0.00172444458845304*x_94 - 0.00481061579776053*x_95 - 0.000860941028380961*x_96 - 0.000314153300339128*x_97 + 0.00181919940011047*x_98 + 0.00371235854816*x_99 + 0.019879166482168*std::exp(0.356479853391647*x_19) - 0.272627035960902*std::sin(0.283679932355881*x_113 + 1.96335983276367) + 0.370650429564563*std::sin(0.227039992809296*x_116 + 5.1735200881958) + 0.670897682827345*std::sin(0.276479959487915*x_12 - 7.43616008758545) + 0.725383777026387*std::sin(0.305279940366745*x_13 + 5.13495969772339) + 0.238688159484344*std::sin(0.243039980530739*x_14 - 1.1814398765564) - 0.0455175547114006*std::sin(0.613279819488525*x_31 + 5.1956000328064) - 0.0963516974401202*std::sin(0.1893600076437*x_36 - 7.60423994064331) - 0.0360376334286538*std::sin(0.224399983882904*x_50 + 4.37063980102539) - 0.0526229174398263*std::sin(0.337999850511551*x_56 + 1.85591995716095) - 0.109538883669189*std::sin(0.307679921388626*x_8 + 2.11904001235962) - 0.115336399847115*std::sin(0.452639847993851*x_9 - 4.27943992614746) + 0.587980902893948) + 0.0910115099523272);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000404611811966362*x_1 + 0.000446628519086876*x_10 - 0.000380548433824526*x_100 + 0.000235734806721799*x_101 + 0.000455123148122007*x_102 - 0.00174156173302013*x_103 - 0.000553552227926839*x_104 + 0.000662744010645874*x_105 + 0.000110291447578839*x_106 + 0.000158412776671564*x_107 + 0.0004952297847347*x_108 - 2.93273585041017e-5*x_109 + 0.000757399431955946*x_11 - 0.00117656442134276*x_110 + 0.000620837741477291*x_111 + 0.0036688391323935*x_112 + 0.000307119535782566*x_113 - 0.00163561110931855*x_114 + 0.000176867436296837*x_115 - 0.000388643101832469*x_116 - 0.00464120930813811*x_117 - 0.00393004292579517*x_118 - 0.0017117091820167*x_119 - 0.0008020882842888*x_12 - 0.0045393653155719*x_120 - 0.000774137618452587*x_13 + 0.00072079371215613*x_14 + 0.000540905117990403*x_15 + 0.00138047848177987*x_16 + 8.42458198674675e-5*x_17 + 0.00222824311471347*x_18 - 0.000209520981104969*x_19 - 0.000383799084385295*x_2 + 0.000182520637167416*x_20 + 5.10915076464683e-5*x_21 - 0.000356747821957676*x_22 + 0.00117346473366864*x_23 - 4.98368672850801e-5*x_24 + 9.70464054407057e-6*x_25 - 0.00127817265429319*x_26 + 0.000149954940075559*x_27 - 0.000196553069766827*x_28 - 0.000641133677859153*x_29 + 0.000278320781395897*x_3 - 0.000465048826571324*x_30 - 6.68048376548874e-5*x_31 + 0.000363023203211256*x_32 + 0.000479502877395337*x_33 + 0.00065365502996392*x_34 - 0.000703460311317719*x_35 + 0.00100948011706684*x_36 + 0.00163808340628488*x_37 - 0.000185898282228729*x_38 + 0.000918556521922683*x_39 + 0.000175941813780281*x_4 + 0.00078215923527945*x_40 - 0.000115533140760916*x_41 + 0.00111962521726594*x_42 + 0.000452357577046141*x_43 + 0.00111708645900187*x_44 + 0.00112815471867055*x_45 + 7.61567290985666e-5*x_46 + 0.00040483060393228*x_47 - 0.000291053884429802*x_48 - 0.000518708540481041*x_49 + 0.00185073191214895*x_5 + 0.000117538084979271*x_50 - 0.00155148884373077*x_51 + 0.00159505530028891*x_52 + 0.000323071841850551*x_53 - 0.000460292801960965*x_54 + 0.000698806393981063*x_55 + 0.000587725076568832*x_56 - 0.00100413350619287*x_57 - 0.000565428864290635*x_58 - 0.000461288079950795*x_59 + 0.00137412971334413*x_6 - 0.000410646838666936*x_60 - 0.000186435441504638*x_61 - 0.00083313212816119*x_62 - 0.000371400070046159*x_63 - 0.00071390467175076*x_64 - 0.000701504356771291*x_65 - 7.45282892103603e-5*x_66 - 0.00157071922987371*x_67 - 0.000295563617343593*x_68 - 0.000576454174044425*x_69 - 0.000460033159796094*x_7 - 0.00125288592020519*x_70 - 0.000158040405391277*x_71 - 0.00140025784481066*x_72 - 0.000555998316685651*x_73 - 0.00181517481182219*x_74 - 0.000653737018156302*x_75 - 0.000644770154045524*x_76 - 0.00141375879872166*x_77 - 0.000175643151858222*x_78 + 0.000140828157301731*x_79 + 0.000394421286861582*x_8 - 0.00156605660525262*x_80 - 0.00165955301458174*x_81 - 0.000553696905059407*x_82 - 0.000235849874301505*x_83 - 0.000899780929303996*x_84 - 0.000792698181980442*x_85 - 0.00083610959798848*x_86 - 0.00018074626517548*x_87 - 0.000776716478691406*x_88 + 6.2103066279599e-5*x_89 + 0.00148937517379265*x_9 + 0.000860967247429128*x_90 - 0.000974931329917759*x_91 + 0.00114578659447082*x_92 - 0.00168410652560056*x_93 + 0.000642294861929074*x_94 + 2.94698357987484e-5*x_95 + 0.000553988005108897*x_96 - 0.000966634428896912*x_97 + 0.00157907173329863*x_98 - 0.00158978262240728*x_99 - 3.11657585790686e-6*std::pow(2.4696798324585 - 7.17983961105347*x_59, 2) - 2.89627768120501e-7*std::pow(5.30704021453857 - 8.17615985870361*x_15, 2) + 9.44103845562107e-8*std::pow(5.54383993148804 - 0.991999804973602*x_10, 2) + 2.09380204034727e-7*std::pow(-2.62831997871399*x_16 - 9.89848041534424, 2) - 7.44862725863701e-6*std::pow(-3.71199989318848*x_25 - 8.0, 2) + 1.18107457630078e-7*std::pow(-9.3261604309082*x_28 - 1.61375975608826, 2) + 2.63381380979822e-7*std::pow(-5.89263963699341*x_60 - 9.60136032104492, 2) - 9.8101984613636e-6*std::pow(-3.8724000453949*x_61 - 6.51895952224731, 2) - 1.98345851477923e-6*std::pow(-2.83240008354187*x_64 - 9.11664009094238, 2) + 2.68687138321422e-7*std::pow(-2.76160001754761*x_64 - 6.32287979125977, 2) - 8.59508388640142e-7*std::pow(-3.67159986495972*x_9 - 7.73672008514404, 2) - 0.00531452651902456*std::exp(0.208559840917587*x_13) + 3.1916665052532e-5*std::exp(0.253679871559143*x_13) + 3.31351839521985e-6*std::exp(0.541759848594666*x_13) + 0.0026639571030312*std::exp(0.173759862780571*x_14) - 0.00405595800478055*std::exp(0.318959832191467*x_18) + 1.26259967472852e-5*std::exp(0.403919875621796*x_18) + 0.000623298902278952*std::exp(0.45007985830307*x_18) + 4.28493110838209e-5*std::exp(0.356479853391647*x_19) + 2.00052079592835e-5*std::exp(0.250079840421677*x_20) + 0.00103725331499571*std::exp(0.326959848403931*x_22) - 8.19401172665722e-5*std::exp(0.548639833927155*x_22) - 0.000154344991352104*std::exp(0.521439850330353*x_26) - 0.00025793127961275*std::exp(0.310879856348038*x_28) - 0.000781335210569742*std::exp(0.321919828653336*x_30) + 2.290687272238e-5*std::exp(0.370639860630035*x_5) + 0.00012505283086126*std::exp(0.319119840860367*x_59) + 2.12297574509023e-5*std::exp(0.324639827013016*x_6) - 9.28337578145694e-5*std::log(5.16136026382446 - 0.59639984369278*x_9) + 0.101365483924921*std::sin(0.332799851894379*x_1 - 4.25031995773315) + 0.00177512555966531*std::sin(0.337039858102798*x_1 - 4.24552011489868) + 0.00197684610338367*std::sin(0.344959855079651*x_1 - 4.25184011459351) + 0.0168031815905596*std::sin(0.348479837179184*x_1 + 5.15775966644287) + 0.000251554332124143*std::sin(0.351919859647751*x_1 - 4.22544002532959) + 0.00924594495141205*std::sin(0.353119850158691*x_1 - 4.22032022476196) - 0.00314252676252432*std::sin(0.358719855546951*x_1 - 4.23680019378662) + 0.00866576311106971*std::sin(0.359119862318039*x_1 - 1.03623986244202) - 0.00210713815549656*std::sin(0.403519839048386*x_1 - 4.18416023254395) - 0.000642903486817616*std::sin(1.34607982635498*x_100 - 4.97455978393555) - 0.000320172885620275*std::sin(0.225759983062744*x_107 - 4.39264011383057) + 0.00447302091289315*std::sin(0.206160008907318*x_108 - 4.39903974533081) - 0.00136522734162298*std::sin(0.20584000647068*x_109 + 5.18096017837524) + 0.00354391094487596*std::sin(0.102400071918964*x_11 - 4.28399991989136) + 0.00260935159057176*std::sin(0.175360009074211*x_11 + 5.18400001525879) - 0.0239503210365214*std::sin(0.283119946718216*x_11 - 7.42775964736938) - 0.000443335997675517*std::sin(0.282959938049316*x_112 - 7.43111991882324) - 0.000233906602145206*std::sin(0.323279827833176*x_112 - 1.34607982635498) - 3.43091949915984e-5*std::sin(0.254479974508286*x_113 - 4.22528028488159) - 0.00058764439063517*std::sin(0.283679932355881*x_113 + 1.96335983276367) - 0.000763786038482483*std::sin(0.287439942359924*x_113 - 7.42911958694458) + 0.00813650843247868*std::sin(0.2880799472332*x_113 - 7.42679977416992) - 0.0044059959901018*std::sin(0.233999982476234*x_114 + 1.97791981697083) + 0.00309737163809197*std::sin(0.241119980812073*x_114 - 1.23959982395172) - 0.0134398172512462*std::sin(0.209199994802475*x_116 + 2.000159740448) + 0.000798932670240997*std::sin(0.227039992809296*x_116 + 5.1735200881958) - 0.00746636592248266*std::sin(0.233519986271858*x_116 + 1.79903984069824) - 0.00199310354763905*std::sin(0.251039981842041*x_116 + 5.16688013076782) + 0.00164375977354307*std::sin(0.262319952249527*x_116 - 1.23943984508514) + 0.000118558012105941*std::sin(1.02279984951019*x_116 + 8.39000034332275) + 0.000735952152945217*std::sin(0.218319997191429*x_118 - 4.21447992324829) + 0.0108134044568134*std::sin(0.226719990372658*x_119 + 5.18576002120972) + 0.0065296151197661*std::sin(0.235759988427162*x_119 + 5.17343997955322) + 0.00144611211655532*std::sin(0.276479959487915*x_12 - 7.43616008758545) - 0.0213635133858512*std::sin(0.298639953136444*x_12 + 5.12664031982422) - 0.00270842088289736*std::sin(0.539439857006073*x_12 + 7.83392000198364) - 0.00846364894362014*std::sin(0.179840013384819*x_13 + 1.59295988082886) - 0.00544285149959527*std::sin(0.232399985194206*x_13 - 7.40807962417603) + 0.000712146679071708*std::sin(0.295279920101166*x_13 - 4.40863990783691) + 0.00156355625598498*std::sin(0.305279940366745*x_13 + 5.13495969772339) - 0.0260991022795479*std::sin(0.121120058000088*x_14 - 1.25951981544495) + 0.000514489538932313*std::sin(0.243039980530739*x_14 - 1.1814398765564) - 0.00418708011871138*std::sin(0.303039938211441*x_14 - 7.43951988220215) + 0.000478847465193825*std::sin(0.442319840192795*x_14 - 1.44655990600586) + 3.86787700265235e-5*std::sin(0.53143984079361*x_14 - 1.31679975986481) - 4.09317203214734e-5*std::sin(0.538719832897186*x_14 + 1.86799991130829) - 0.0170404982591515*std::sin(0.244799971580505*x_15 - 1.17535984516144) - 0.00185524103237814*std::sin(0.267919957637787*x_15 + 1.98791980743408) + 1.66628225575718e-5*std::sin(0.270559966564178*x_15 + 1.77759981155396) + 0.000842372131659398*std::sin(0.29615992307663*x_15 + 5.17063999176025) + 0.027912891270634*std::sin(0.316639930009842*x_15 + 5.14856004714966) - 4.57184952854559e-5*std::sin(0.502879858016968*x_15 + 8.08672046661377) - 0.00900939998887481*std::sin(0.297039926052094*x_16 + 2.00455975532532) + 0.000176621511477528*std::sin(0.314639925956726*x_16 + 1.9968798160553) + 0.00290329588296162*std::sin(0.387599855661392*x_16 - 1.18503987789154) - 6.05799200881337e-5*std::sin(0.51095986366272*x_16 + 8.10847949981689) + 9.8829362426483e-5*std::sin(0.27975994348526*x_17 - 7.37399959564209) + 0.000239558887400532*std::sin(0.344799846410751*x_17 + 1.99871981143951) + 0.00265284416656589*std::sin(0.380239844322205*x_17 - 1.1743198633194) - 0.000134162850281609*std::sin(0.383119851350784*x_17 + 1.99287974834442) + 0.000573712049232336*std::sin(0.428399860858917*x_17 - 1.20383989810944) + 4.00117805756662e-5*std::sin(0.606959879398346*x_17 + 5.00175952911377) - 0.00386084764059329*std::sin(0.314559936523438*x_18 - 1.15207993984222) - 0.00118735387104974*std::sin(0.374319821596146*x_18 + 2.02303981781006) + 0.00947389714354583*std::sin(0.431999862194061*x_18 - 7.42375993728638) - 0.000698814898965447*std::sin(0.51775985956192*x_18 + 2.0559196472168) + 9.48477689684636e-6*std::sin(0.524639844894409*x_18 + 2.05535984039307) - 0.0323601116595249*std::sin(0.222240000963211*x_19 + 8.1947193145752) + 0.00740787892922583*std::sin(0.25655996799469*x_19 + 8.21303939819336) - 0.0112590123808161*std::sin(0.257999986410141*x_19 + 8.2061595916748) + 0.00372381553963545*std::sin(0.39319983124733*x_19 - 1.2047199010849) + 0.00225335185040772*std::sin(0.365679860115051*x_2 + 5.18024015426636) + 0.00804289940487751*std::sin(0.377919852733612*x_2 + 5.17736005783081) - 8.69904234075651e-5*std::sin(0.388719856739044*x_2 + 5.18279981613159) - 0.0289415789057937*std::sin(0.399199843406677*x_2 + 5.20344018936157) + 5.23545104079614e-5*std::sin(0.409279853105545*x_2 - 1.17679977416992) + 0.00345021587231505*std::sin(0.337519854307175*x_20 - 7.79392004013062) - 0.00160593174595736*std::sin(0.415519863367081*x_20 + 7.59352016448975) - 0.000823069010162617*std::sin(0.317199915647507*x_21 - 1.19207990169525) - 0.000406403203904066*std::sin(0.340239852666855*x_21 + 2.04071974754333) + 0.00689927773812226*std::sin(0.317359924316406*x_22 + 8.25111961364746) + 8.38167226521365e-5*std::sin(0.399679869413376*x_22 + 2.00927972793579) + 0.00422127474686146*std::sin(0.482559859752655*x_22 + 4.98415994644165) + 0.0021162111487911*std::sin(0.275279939174652*x_23 - 1.15063989162445) - 0.0233725858707092*std::sin(0.319999933242798*x_23 - 1.16799986362457) + 0.000534424662102051*std::sin(0.354399859905243*x_23 - 1.39335989952087) - 0.00108832490299422*std::sin(0.366559833288193*x_23 - 7.36911964416504) - 0.00773926295439724*std::sin(0.370399862527847*x_23 + 1.99191975593567) - 3.79520706588548e-5*std::sin(0.832639873027802*x_23 - 7.78951978683472) - 0.00247347351977021*std::sin(0.386879861354828*x_24 - 1.19351994991302) + 0.000484564092636757*std::sin(0.442479848861694*x_24 - 1.21311986446381) - 0.00150533159038709*std::sin(0.827359914779663*x_24 + 1.80167984962463) + 6.68425932459913e-5*std::sin(0.261439979076385*x_25 - 7.37575960159302) - 0.00306809739094428*std::sin(0.324319839477539*x_25 - 1.13855993747711) - 0.000161825473529013*std::sin(0.338639855384827*x_25 - 1.14871978759766) + 0.0118447751279618*std::sin(0.152400031685829*x_26 + 8.14935970306396) + 0.00310174194065762*std::sin(0.284159928560257*x_26 + 1.98807990550995) + 0.0012264581275538*std::sin(0.304559946060181*x_26 - 1.17807984352112) - 0.000803443628816715*std::sin(0.783759832382202*x_26 - 1.39231991767883) - 2.84021484309352e-5*std::sin(0.285999923944473*x_27 - 7.39047956466675) - 0.00364511620471697*std::sin(0.367839843034744*x_27 + 5.23767995834351) + 3.93292586004679e-5*std::sin(0.463919848203659*x_27 + 4.5776801109314) - 0.000366999237209232*std::sin(0.0912800803780556*x_28 + 2.02471995353699) - 5.54575734678271e-5*std::sin(0.805839836597443*x_28 + 4.79120016098022) - 0.000141554884930271*std::sin(0.323039919137955*x_29 + 4.80983972549438) + 0.00279496476125624*std::sin(0.377759844064713*x_29 - 1.18191993236542) - 0.0010422831506966*std::sin(0.856159865856171*x_29 - 5.43487977981567) + 0.0148156008098565*std::sin(0.2743199467659*x_3 - 1.15183985233307) - 0.000117915421940926*std::sin(0.2882399559021*x_3 - 1.13159990310669) - 0.0320618274078079*std::sin(0.316159933805466*x_3 + 8.28087997436523) - 0.000617698734824764*std::sin(0.344079852104187*x_3 - 7.40455961227417) + 0.033279096831618*std::sin(0.348319828510284*x_3 + 1.97527980804443) - 0.0121784133817143*std::sin(0.359439849853516*x_3 - 7.39336013793945) + 0.00253311278076652*std::sin(0.372479856014252*x_3 + 5.19831991195679) - 0.000222843718074748*std::sin(0.396399825811386*x_3 - 7.40655994415283) - 0.00134802351860959*std::sin(0.259519964456558*x_30 + 1.99079978466034) + 0.00162450656421497*std::sin(0.266159951686859*x_30 - 1.1651998758316) - 0.00479109610036423*std::sin(0.284959942102432*x_30 - 1.16359984874725) + 0.0024045477934662*std::sin(0.304079920053482*x_30 - 1.16567981243134) + 0.000111135468760581*std::sin(0.308239936828613*x_30 + 2.00159978866577) + 0.151488555557477*std::sin(0.312719941139221*x_30 + 1.99159979820251) - 0.000194591168037521*std::sin(0.765519857406616*x_30 - 7.37951993942261) - 9.64755665129264e-5*std::sin(0.293119937181473*x_31 - 1.07175981998444) + 2.31541538677348e-5*std::sin(0.309599936008453*x_31 - 4.056960105896) + 0.0019398034197327*std::sin(0.340319842100143*x_31 - 1.01967978477478) + 0.0117905298207998*std::sin(0.350399851799011*x_31 + 5.15687990188599) - 0.0421472650912986*std::sin(0.375759840011597*x_31 - 7.39991998672485) + 0.00354546915427608*std::sin(0.376639842987061*x_31 - 4.22408008575439) - 0.0703923650734873*std::sin(0.386079847812653*x_31 - 7.39783954620361) - 0.00049407654272569*std::sin(0.396079838275909*x_31 + 8.38568019866943) - 0.0754073771937196*std::sin(0.405199855566025*x_31 + 5.19992017745972) - 9.81125573526027e-5*std::sin(0.613279819488525*x_31 + 5.1956000328064) + 0.000420502919014933*std::sin(0.285679936408997*x_32 + 8.2425594329834) + 0.00786130030983411*std::sin(0.302159935235977*x_32 - 1.14591991901398) - 0.0289809733077844*std::sin(0.30839991569519*x_32 - 1.14823985099792) + 6.2751409625417e-5*std::sin(0.213440001010895*x_33 + 1.971599817276) + 0.00366053432703258*std::sin(0.233039990067482*x_33 + 1.9968798160553) - 0.00122077696302453*std::sin(0.233519986271858*x_33 - 1.17975986003876) + 0.00230817335743252*std::sin(0.225599989295006*x_34 + 1.77711987495422) - 0.00145596987294746*std::sin(0.179120019078255*x_35 + 8.19151973724365) - 0.00113625183864686*std::sin(0.179520010948181*x_35 + 8.40520000457764) - 0.000207684958057439*std::sin(0.1893600076437*x_36 - 7.60423994064331) + 0.00111766456949738*std::sin(0.291999936103821*x_37 + 4.77928018569946) - 1.07860108238246e-5*std::sin(0.538559854030609*x_37 - 0.706639885902405) + 0.0495461222148475*std::sin(0.178640007972717*x_4 + 8.1755199432373) + 9.9740380213055e-5*std::sin(0.249199971556664*x_4 - 7.36111974716187) + 4.66207016037109e-5*std::sin(0.375919848680496*x_4 + 1.9793598651886) + 0.00010973636571151*std::sin(0.772719860076904*x_4 + 8.20959949493408) - 8.86271535528018e-5*std::sin(0.862319886684418*x_4 + 7.99488019943237) - 0.0014327006260676*std::sin(0.16312001645565*x_40 + 5.19856023788452) - 0.000328925232506155*std::sin(0.171840012073517*x_41 - 1.20207989215851) - 2.99616380811781e-6*std::sin(0.697999835014343*x_42 + 4.62016010284424) - 5.48743699053729e-5*std::sin(0.459839850664139*x_44 - 1.4592798948288) - 3.96577365847459e-5*std::sin(0.576399862766266*x_45 + 5.03351974487305) + 0.000219835400105855*std::sin(0.665839850902557*x_47 + 7.57984018325806) + 0.000566225627523633*std::sin(0.228719994425774*x_48 - 7.5971999168396) + 0.00155379661156011*std::sin(0.467279851436615*x_49 - 1.34599983692169) + 0.00770540595680481*std::sin(0.254319965839386*x_5 - 7.56360006332397) - 0.000480943520230038*std::sin(0.265679955482483*x_5 + 2.00615978240967) - 0.00347450585715173*std::sin(0.350159853696823*x_5 - 1.14927983283997) + 0.000179114408308393*std::sin(0.359199851751328*x_5 + 2.00079965591431) + 0.002406333441241*std::sin(0.386959850788116*x_5 - 7.39559984207153) + 0.000624087147550818*std::sin(0.685359835624695*x_5 - 4.65687990188599) - 0.00207336941138558*std::sin(0.209279999136925*x_50 + 8.17591953277588) - 7.76786977911906e-5*std::sin(0.224399983882904*x_50 + 4.37063980102539) + 0.00645834420302888*std::sin(0.16872002184391*x_51 + 8.20335960388184) - 0.00139236306674097*std::sin(0.255279958248138*x_52 - 1.2079998254776) - 0.000197952483950748*std::sin(0.233999982476234*x_53 - 7.42159986495972) + 0.000546178711665129*std::sin(0.20024000108242*x_54 + 5.00152015686035) - 0.000235193033675765*std::sin(0.5655198097229*x_54 + 4.83576011657715) + 0.00163765747114442*std::sin(0.589199841022491*x_54 + 1.78703987598419) - 0.000113428083694555*std::sin(0.337999850511551*x_56 + 1.85591995716095) + 0.000100303318108899*std::sin(0.169280022382736*x_57 + 1.61479985713959) + 0.000380180652271656*std::sin(0.29351994395256*x_57 - 1.42783987522125) + 0.00211127654654188*std::sin(0.299759924411774*x_58 + 1.87479984760284) - 0.000133749727178968*std::sin(0.48447984457016*x_58 + 4.6911997795105) - 0.000145218787387785*std::sin(0.359359860420227*x_59 + 4.64055967330933) - 0.00323551264545727*std::sin(0.606719851493835*x_59 - 7.81207990646362) - 0.0129031421750299*std::sin(0.323439925909042*x_6 + 2.01247978210449) + 0.00236200248495305*std::sin(0.342959851026535*x_6 + 2.01183986663818) + 7.38949056091931e-5*std::sin(0.344479858875275*x_6 + 2.01703977584839) - 0.00424570826082679*std::sin(0.366239845752716*x_6 + 1.99223983287811) + 0.0012679410832313*std::sin(0.367599844932556*x_6 - 1.16799986362457) - 0.0620679967793968*std::sin(0.378479838371277*x_6 + 1.99007987976074) + 0.000130946477172031*std::sin(0.38351982831955*x_6 - 1.17855989933014) + 0.00430007751595899*std::sin(0.358639866113663*x_60 + 8.24847984313965) - 0.00147158889738688*std::sin(0.452159851789474*x_60 - 7.48456001281738) - 8.34937262310551e-6*std::sin(1.41623985767365*x_64 + 6.79663991928101) + 0.0003075996090813*std::sin(1.77119994163513*x_64 + 3.59479999542236) - 0.035838590305076*std::sin(0.26079997420311*x_7 + 2.03239989280701) + 0.0155402317647242*std::sin(0.322959840297699*x_7 - 7.339439868927) - 0.000142897697962628*std::sin(0.330399841070175*x_7 - 1.15071988105774) - 0.00686196906873865*std::sin(0.354959845542908*x_7 + 2.00631976127625) + 0.0986590607786294*std::sin(0.359199851751328*x_7 - 1.15143990516663) + 0.0166475096940693*std::sin(0.376479834318161*x_7 + 2.02695989608765) - 0.00100832194077026*std::sin(0.480159848928452*x_7 + 1.93423986434937) + 0.000379988743386518*std::sin(1.0732798576355*x_70 + 2.81663990020752) + 0.000155005412034749*std::sin(1.18463981151581*x_70 - 9.6071195602417) - 0.000369706647933323*std::sin(0.909999787807465*x_72 + 7.97391986846924) - 0.000919573996941078*std::sin(1.2240799665451*x_73 - 0.783519864082336) + 0.000458636551667124*std::sin(1.13831984996796*x_75 - 2.37199997901917) - 4.92444502767537e-6*std::sin(1.22527992725372*x_75 + 3.99287986755371) + 4.12399651650436e-5*std::sin(1.41495978832245*x_77 + 1.97983980178833) + 0.000213918153738251*std::sin(0.803119838237762*x_78 + 3.78615999221802) + 0.000150194723049737*std::sin(0.295279920101166*x_8 - 1.19455993175507) - 0.000236109783894906*std::sin(0.307679921388626*x_8 + 2.11904001235962) + 0.00452926126853411*std::sin(0.314959913492203*x_8 + 5.15392017364502) - 0.00196732946708741*std::sin(0.398239850997925*x_8 - 7.80751991271973) - 0.00123936291814664*std::sin(0.451759845018387*x_8 + 7.95944023132324) + 4.90431830008126e-5*std::sin(0.171200007200241*x_87 + 5.50552034378052) + 0.00107525754248525*std::sin(0.180960014462471*x_88 - 7.25880002975464) + 4.23471787273439e-6*std::sin(1.14111983776093*x_88 - 1.60359990596771) - 0.00133373248567179*std::sin(0.376639842987061*x_9 - 4.38687992095947) - 0.000248606262278155*std::sin(0.452639847993851*x_9 - 4.27943992614746) - 7.08888850492597e-5*std::sin(0.485359847545624*x_9 - 4.47983980178833) - 1.28004167894003e-5*std::sin(1.79071986675262*x_90 - 2.39239978790283) + 0.0071051843139814*std::sin(0.329519838094711*x_91 - 4.20544004440308) - 0.00324374326163116*std::sin(0.370879858732224*x_91 + 5.18943977355957) + 0.0133370844682571*std::sin(0.388959854841232*x_91 + 1.971599817276) + 0.000143522241702162*std::sin(0.417119860649109*x_91 + 8.21047973632813) - 6.92840797963537e-5*std::sin(0.227119997143745*x_92 + 2.01871991157532) - 0.000246794502943858*std::sin(0.239759981632233*x_92 + 5.19600009918213) - 0.0266607012343008*std::sin(0.253919988870621*x_92 + 2.02055978775024) + 0.00347354252043927*std::sin(0.285359919071198*x_92 + 1.99703979492188) - 0.0334647621454935*std::sin(0.303839921951294*x_92 + 1.98935985565186) + 0.00782382483800357*std::sin(0.321039855480194*x_92 - 1.1814398765564) - 0.0067295329676417*std::sin(0.327039837837219*x_92 + 8.22480010986328) + 0.000162130095100799*std::sin(0.257679969072342*x_94 - 7.39807987213135) - 6.63739752174101e-5*std::sin(0.275759935379028*x_94 + 1.97855985164642) + 0.00679404268163947*std::sin(0.285999953746796*x_94 - 1.19919991493225) + 0.0113493477678182*std::sin(0.287839949131012*x_94 + 1.97927987575531) + 0.00260052799288183*std::sin(0.310879945755005*x_94 + 1.79847991466522) + 0.00378120643288255*std::sin(0.253759980201721*x_95 - 7.40999984741211) - 0.00108497473959714*std::sin(0.262319982051849*x_96 - 1.20431983470917) + 0.00252124110970947*std::sin(0.30447992682457*x_96 - 4.41775989532471) - 0.00662053176356234*std::sin(0.273119956254959*x_97 + 1.96655988693237) - 0.000844958123124342*std::sin(0.27991995215416*x_97 + 1.97735977172852) + 0.000488105302562437*std::sin(0.261359959840775*x_98 - 4.42471981048584) - 0.114706242477077);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000136650366099361*x_1 - 0.000286654936493507*x_10 + 0.000992086161672166*x_100 - 4.04333668903136e-5*x_101 - 0.00128488110527605*x_102 + 0.000318723396400988*x_103 + 0.000580382843552263*x_104 - 0.00130811819476037*x_105 + 0.000331514259191991*x_106 - 0.001506936935248*x_107 - 0.000795314707175436*x_108 - 0.00105634439670118*x_109 + 0.000291000060863962*x_11 + 0.00126450530553778*x_110 - 0.000970687244076416*x_111 - 0.00141278496441426*x_112 - 0.00546650866707471*x_113 - 0.000237213875740565*x_114 + 0.000321254028346715*x_115 + 0.000396917483822181*x_116 + 0.000692780574757395*x_117 + 0.000609725327474063*x_118 + 0.000105982789291906*x_119 + 0.000469957688636586*x_12 - 0.000683870278077317*x_120 + 0.000276226124756552*x_13 + 6.03596393560547e-5*x_14 - 6.77007405772057e-6*x_15 - 0.000341528648484073*x_16 + 0.000358526840237721*x_17 - 0.000509091951131802*x_18 + 0.000409046166578403*x_19 - 1.43717230866757e-6*x_2 - 0.000861615766287614*x_20 - 0.000527499240940283*x_21 - 0.000196978196497769*x_22 + 0.000125959308511305*x_23 + 0.000162922755662615*x_24 - 7.89454273507722e-5*x_25 + 0.000300428858255517*x_26 + 0.000163680635036986*x_27 - 4.34706322195108e-6*x_28 - 0.000221598128196461*x_29 + 2.78304507522111e-5*x_3 + 0.000144574753630536*x_30 - 6.16619175194215e-5*x_31 + 0.000127669460545202*x_32 - 0.0020823505351527*x_33 - 0.00328751740364466*x_34 + 0.000512660736826937*x_35 - 0.000656354471519309*x_36 - 9.58053437711873e-5*x_37 - 0.000106292164842964*x_38 - 0.000552130545834573*x_39 + 0.000358541110512283*x_4 + 0.000252424986869965*x_40 - 0.0001291404759872*x_41 - 0.00055773293579026*x_42 - 0.000138758421350383*x_43 - 0.00074394119129952*x_44 - 0.00114718930969155*x_45 - 0.00022950226043833*x_46 - 0.000288775605731566*x_47 - 0.000945403818578095*x_48 - 0.000251752650492337*x_49 + 0.000134083484111935*x_5 + 0.000485226354686702*x_50 + 0.000412191441680829*x_51 + 0.000823103697611402*x_52 + 0.000588006069966199*x_53 + 0.000252410013596589*x_54 + 0.00073676282628432*x_55 - 0.000447088780312374*x_56 + 0.00168146364399072*x_57 + 0.000125902687952536*x_58 + 0.000827988043621633*x_59 - 1.12804462175356e-5*x_6 + 0.000511533157470885*x_60 + 0.000626934128466544*x_61 + 0.00129166793003163*x_62 + 0.000289446231390673*x_63 + 2.27766741500033e-5*x_64 - 0.000806057507252937*x_65 - 0.000215764464840869*x_66 + 1.73885247984224e-5*x_67 - 0.00104685906432965*x_68 + 0.000104781386944558*x_69 - 2.64883105043279e-5*x_7 + 0.000228213700891918*x_70 + 0.000116649729393173*x_71 + 0.000594672302679996*x_72 + 0.000264085800654283*x_73 + 0.00118376681968187*x_74 + 0.000133698442030523*x_75 + 0.000136843315292972*x_76 + 0.00103486962202577*x_77 + 0.000726262192360058*x_78 - 6.21838509813883e-5*x_79 + 4.54817361665806e-6*x_8 + 0.00123257096681949*x_80 + 0.00128694531775153*x_81 + 0.000182933051201923*x_82 - 0.000125535403439384*x_83 + 0.000303429548564575*x_84 + 0.00109966999090414*x_85 + 0.00073573117288128*x_86 - 2.38428243019013e-5*x_87 + 0.000402116981424706*x_88 + 0.000150162917249518*x_89 + 0.000102662640841717*x_9 - 0.000364641323106476*x_90 + 0.00236643259200563*x_91 - 1.75058557743818e-5*x_92 - 0.000450159296467228*x_93 - 0.000114715413970252*x_94 + 0.000476768387899942*x_95 + 0.00159658178118583*x_96 + 0.000103343282933218*x_97 - 0.000657972187005944*x_98 + 0.00326387444038889*x_99 + 2.6659171799544e-7*std::pow(2.4696798324585 - 7.17983961105347*x_59, 2) - 2.30194675779469e-7*std::pow(5.30704021453857 - 8.17615985870361*x_15, 2) + 6.86348701414906e-7*std::pow(5.54383993148804 - 0.991999804973602*x_10, 2) + 2.58773587832008e-7*std::pow(-2.62831997871399*x_16 - 9.89848041534424, 2) + 2.17785229719368e-6*std::pow(-3.71199989318848*x_25 - 8.0, 2) + 1.69490194233397e-7*std::pow(-9.3261604309082*x_28 - 1.61375975608826, 2) + 3.30316019655157e-7*std::pow(-5.89263963699341*x_60 - 9.60136032104492, 2) - 4.72528446304027e-6*std::pow(-3.8724000453949*x_61 - 6.51895952224731, 2) - 2.84636360539357e-6*std::pow(-2.83240008354187*x_64 - 9.11664009094238, 2) + 3.32071196072659e-7*std::pow(-2.76160001754761*x_64 - 6.32287979125977, 2) + 2.12789886560898e-7*std::pow(-3.67159986495972*x_9 - 7.73672008514404, 2) + 0.000737380200272276*std::exp(0.208559840917587*x_13) - 0.000143814863232424*std::exp(0.253679871559143*x_13) - 1.77287969948698e-7*std::exp(0.541759848594666*x_13) - 0.00735097058707361*std::exp(0.173759862780571*x_14) + 0.000572859462493152*std::exp(0.318959832191467*x_18) + 1.56045051790491e-5*std::exp(0.403919875621796*x_18) + 0.000300224774286514*std::exp(0.45007985830307*x_18) + 5.06922834139182e-5*std::exp(0.356479853391647*x_19) + 2.47244932385805e-5*std::exp(0.250079840421677*x_20) - 0.00286221523657499*std::exp(0.326959848403931*x_22) - 3.9468147820285e-5*std::exp(0.548639833927155*x_22) + 1.3202661601885e-5*std::exp(0.521439850330353*x_26) + 0.000711740158188793*std::exp(0.310879856348038*x_28) + 0.00215603026978467*std::exp(0.321919828653336*x_30) - 0.000103217198984587*std::exp(0.370639860630035*x_5) + 0.000179457157214375*std::exp(0.319119840860367*x_59) - 9.56602031958483e-5*std::exp(0.324639827013016*x_6) - 0.000114733504498923*std::log(5.16136026382446 - 0.59639984369278*x_9) - 0.0143167598303894*std::sin(0.332799851894379*x_1 - 4.25031995773315) - 0.00799862514343094*std::sin(0.337039858102798*x_1 - 4.24552011489868) - 0.000105770057916528*std::sin(0.344959855079651*x_1 - 4.25184011459351) - 0.0463669979899123*std::sin(0.348479837179184*x_1 + 5.15775966644287) + 0.000310896712315996*std::sin(0.351919859647751*x_1 - 4.22544002532959) + 0.00445350012001288*std::sin(0.353119850158691*x_1 - 4.22032022476196) + 0.000778000450199336*std::sin(0.358719855546951*x_1 - 4.23680019378662) - 0.000741268873549307*std::sin(0.359119862318039*x_1 - 1.03623986244202) - 0.00264263740207383*std::sin(0.403519839048386*x_1 - 4.18416023254395) + 5.49939269474663e-5*std::sin(1.34607982635498*x_100 - 4.97455978393555) - 0.00040154027891477*std::sin(0.225759983062744*x_107 - 4.39264011383057) - 0.000620622936919056*std::sin(0.206160008907318*x_108 - 4.39903974533081) - 0.00171218048797399*std::sin(0.20584000647068*x_109 + 5.18096017837524) + 0.00508569201679202*std::sin(0.102400071918964*x_11 - 4.28399991989136) + 0.00327248125160582*std::sin(0.175360009074211*x_11 + 5.18400001525879) + 0.00332306038163055*std::sin(0.283119946718216*x_11 - 7.42775964736938) - 0.000547920216538468*std::sin(0.282959938049316*x_112 - 7.43111991882324) - 0.000293350644241576*std::sin(0.323279827833176*x_112 - 1.34607982635498) - 0.000249422471264845*std::sin(0.254479974508286*x_113 - 4.22528028488159) - 0.000695204549226115*std::sin(0.283679932355881*x_113 + 1.96335983276367) - 0.00094396533055879*std::sin(0.287439942359924*x_113 - 7.42911958694458) + 0.0116763024306374*std::sin(0.2880799472332*x_113 - 7.42679977416992) - 0.00632282779714789*std::sin(0.233999982476234*x_114 + 1.97791981697083) + 0.00149191294502142*std::sin(0.241119980812073*x_114 - 1.23959982395172) + 0.0370860706417307*std::sin(0.209199994802475*x_116 + 2.000159740448) + 0.00094516621910841*std::sin(0.227039992809296*x_116 + 5.1735200881958) + 0.00103594372509347*std::sin(0.233519986271858*x_116 + 1.79903984069824) + 0.000493435879639569*std::sin(0.251039981842041*x_116 + 5.16688013076782) + 0.00235887867609057*std::sin(0.262319952249527*x_116 - 1.23943984508514) + 9.42293045134771e-5*std::sin(1.02279984951019*x_116 + 8.39000034332275) + 0.000909565352504565*std::sin(0.218319997191429*x_118 - 4.21447992324829) - 0.0298387004872259*std::sin(0.226719990372658*x_119 + 5.18576002120972) + 0.00937032899636852*std::sin(0.235759988427162*x_119 + 5.17343997955322) + 0.00171080289056042*std::sin(0.276479959487915*x_12 - 7.43616008758545) + 0.00296414585995325*std::sin(0.298639953136444*x_12 + 5.12664031982422) + 0.000231678165122947*std::sin(0.539439857006073*x_12 + 7.83392000198364) + 0.000723980039396627*std::sin(0.179840013384819*x_13 + 1.59295988082886) - 0.00682607493450021*std::sin(0.232399985194206*x_13 - 7.40807962417603) + 0.00034302013881537*std::sin(0.295279920101166*x_13 - 4.40863990783691) + 0.00184974355146453*std::sin(0.305279940366745*x_13 + 5.13495969772339) + 0.00362119959265005*std::sin(0.121120058000088*x_14 - 1.25951981544495) + 0.000608659716139532*std::sin(0.243039980530739*x_14 - 1.1814398765564) - 0.00525116708570961*std::sin(0.303039938211441*x_14 - 7.43951988220215) + 0.000687170408307923*std::sin(0.442319840192795*x_14 - 1.44655990600586) - 2.06948620777459e-6*std::sin(0.53143984079361*x_14 - 1.31679975986481) + 0.000184436242013747*std::sin(0.538719832897186*x_14 + 1.86799991130829) + 0.00236433593361367*std::sin(0.244799971580505*x_15 - 1.17535984516144) - 0.0026623650126515*std::sin(0.267919957637787*x_15 + 1.98791980743408) + 0.000121136108893691*std::sin(0.270559966564178*x_15 + 1.77759981155396) - 0.000208547435611955*std::sin(0.29615992307663*x_15 + 5.17063999176025) - 0.0770233283776009*std::sin(0.316639930009842*x_15 + 5.14856004714966) + 0.000206005205614314*std::sin(0.502879858016968*x_15 + 8.08672046661377) + 0.0248606984887415*std::sin(0.297039926052094*x_16 + 2.00455975532532) + 0.00128401071147384*std::sin(0.314639925956726*x_16 + 1.9968798160553) + 0.0041663768994285*std::sin(0.387599855661392*x_16 - 1.18503987789154) + 0.000272970027030281*std::sin(0.51095986366272*x_16 + 8.10847949981689) - 0.000445320061394846*std::sin(0.27975994348526*x_17 - 7.37399959564209) + 0.00174155557201296*std::sin(0.344799846410751*x_17 + 1.99871981143951) + 0.00380696597898559*std::sin(0.380239844322205*x_17 - 1.1743198633194) - 0.000165812247061247*std::sin(0.383119851350784*x_17 + 1.99287974834442) - 3.06961460332438e-5*std::sin(0.428399860858917*x_17 - 1.20383989810944) - 9.9057814470735e-6*std::sin(0.606959879398346*x_17 + 5.00175952911377) - 0.00484202725489347*std::sin(0.314559936523438*x_18 - 1.15207993984222) + 0.000293955124659172*std::sin(0.374319821596146*x_18 + 2.02303981781006) - 0.0261424401946725*std::sin(0.431999862194061*x_18 - 7.42375993728638) - 0.00100283483647422*std::sin(0.51775985956192*x_18 + 2.0559196472168) + 6.89528417552914e-5*std::sin(0.524639844894409*x_18 + 2.05535984039307) + 0.00448990244585576*std::sin(0.222240000963211*x_19 + 8.1947193145752) + 0.00929048618731574*std::sin(0.25655996799469*x_19 + 8.21303939819336) + 0.0310683189142583*std::sin(0.257999986410141*x_19 + 8.2061595916748) + 0.00179365257308174*std::sin(0.39319983124733*x_19 - 1.2047199010849) - 0.000557865974279398*std::sin(0.365679860115051*x_2 + 5.18024015426636) + 0.0100868881012872*std::sin(0.377919852733612*x_2 + 5.17736005783081) - 0.000632406746587999*std::sin(0.388719856739044*x_2 + 5.18279981613159) + 0.00401558768657099*std::sin(0.399199843406677*x_2 + 5.20344018936157) + 6.47050878563923e-5*std::sin(0.409279853105545*x_2 - 1.17679977416992) - 0.000295131265463038*std::sin(0.337519854307175*x_20 - 7.79392004013062) + 0.000469547209254431*std::sin(0.415519863367081*x_20 + 7.59352016448975) - 0.000654171059522455*std::sin(0.317199915647507*x_21 - 1.19207990169525) - 0.000502274871999053*std::sin(0.340239852666855*x_21 + 2.04071974754333) - 0.000974447105219851*std::sin(0.317359924316406*x_22 + 8.25111961364746) + 0.000609334439421715*std::sin(0.399679869413376*x_22 + 2.00927972793579) - 0.000361087596838528*std::sin(0.482559859752655*x_22 + 4.98415994644165) - 0.000523913828232224*std::sin(0.275279939174652*x_23 - 1.15063989162445) + 0.00330112071258833*std::sin(0.319999933242798*x_23 - 1.16799986362457) + 0.000766926505746126*std::sin(0.354399859905243*x_23 - 1.39335989952087) - 0.00136490722583073*std::sin(0.366559833288193*x_23 - 7.36911964416504) + 0.0213558597766716*std::sin(0.370399862527847*x_23 + 1.99191975593567) - 4.69050717345602e-5*std::sin(0.832639873027802*x_23 - 7.78951978683472) - 0.00310207169820983*std::sin(0.386879861354828*x_24 - 1.19351994991302) - 0.000119964318750623*std::sin(0.442479848861694*x_24 - 1.21311986446381) + 0.000128765976870407*std::sin(0.827359914779663*x_24 + 1.80167984962463) + 8.26109505146526e-5*std::sin(0.261439979076385*x_25 - 7.37575960159302) + 0.0084661624819131*std::sin(0.324319839477539*x_25 - 1.13855993747711) - 0.00117644583415886*std::sin(0.338639855384827*x_25 - 1.14871978759766) - 0.0326846830517934*std::sin(0.152400031685829*x_26 + 8.14935970306396) + 0.00389000561855958*std::sin(0.284159928560257*x_26 + 1.98807990550995) + 0.000974782676610897*std::sin(0.304559946060181*x_26 - 1.17807984352112) - 0.000386995198020552*std::sin(0.783759832382202*x_26 - 1.39231991767883) - 0.000206479168415625*std::sin(0.285999923944473*x_27 - 7.39047956466675) + 0.0100583984542584*std::sin(0.367839843034744*x_27 + 5.23767995834351) - 9.73680837409682e-6*std::sin(0.463919848203659*x_27 + 4.5776801109314) - 0.000453575397836997*std::sin(0.0912800803780556*x_28 + 2.02471995353699) + 2.96722681020139e-6*std::sin(0.805839836597443*x_28 + 4.79120016098022) + 7.57381586346803e-6*std::sin(0.323039919137955*x_29 + 4.80983972549438) - 0.000394758034706817*std::sin(0.377759844064713*x_29 - 1.18191993236542) + 0.000304745918308472*std::sin(0.856159865856171*x_29 - 5.43487977981567) + 0.00713623976040245*std::sin(0.2743199467659*x_3 - 1.15183985233307) - 0.000857226639912264*std::sin(0.2882399559021*x_3 - 1.13159990310669) + 0.00444851608707445*std::sin(0.316159933805466*x_3 + 8.28087997436523) - 0.000763415617760048*std::sin(0.344079852104187*x_3 - 7.40455961227417) - 0.00284669201141671*std::sin(0.348319828510284*x_3 + 1.97527980804443) + 0.00172006695721342*std::sin(0.359439849853516*x_3 - 7.39336013793945) + 0.00363514536543442*std::sin(0.372479856014252*x_3 + 5.19831991195679) + 0.00100412241643593*std::sin(0.396399825811386*x_3 - 7.40655994415283) - 0.00166602608876375*std::sin(0.259519964456558*x_30 + 1.99079978466034) - 0.000402181726304786*std::sin(0.266159951686859*x_30 - 1.1651998758316) - 0.00687546599457752*std::sin(0.284959942102432*x_30 - 1.16359984874725) - 0.000128654000401274*std::sin(0.304079920053482*x_30 - 1.16567981243134) + 0.000807937442724288*std::sin(0.308239936828613*x_30 + 2.00159978866577) - 0.0442926847140657*std::sin(0.312719941139221*x_30 + 1.99159979820251) - 0.000154660069808322*std::sin(0.765519857406616*x_30 - 7.37951993942261) + 0.000434713977180595*std::sin(0.293119937181473*x_31 - 1.07175981998444) + 0.000168327070313107*std::sin(0.309599936008453*x_31 - 4.056960105896) - 0.000273975899913336*std::sin(0.340319842100143*x_31 - 1.01967978477478) + 0.00567915191447556*std::sin(0.350399851799011*x_31 + 5.15687990188599) + 0.00584785091629474*std::sin(0.375759840011597*x_31 - 7.39991998672485) - 0.00978343061185357*std::sin(0.376639842987061*x_31 - 4.22408008575439) + 0.00602135882272628*std::sin(0.386079847812653*x_31 - 7.39783954620361) - 0.000392689521108562*std::sin(0.396079838275909*x_31 + 8.38568019866943) + 0.0220478383391068*std::sin(0.405199855566025*x_31 + 5.19992017745972) - 0.000116070700741332*std::sin(0.613279819488525*x_31 + 5.1956000328064) - 0.00189476468445032*std::sin(0.285679936408997*x_32 + 8.2425594329834) + 0.00985913817445278*std::sin(0.302159935235977*x_32 - 1.14591991901398) + 0.00409324375944175*std::sin(0.30839991569519*x_32 - 1.14823985099792) + 7.75546450780605e-5*std::sin(0.213440001010895*x_33 + 1.971599817276) + 0.00459080715659663*std::sin(0.233039990067482*x_33 + 1.9968798160553) + 0.000302229733777394*std::sin(0.233519986271858*x_33 - 1.17975986003876) - 0.000326004102439258*std::sin(0.225599989295006*x_34 + 1.77711987495422) + 0.000205639732423224*std::sin(0.179120019078255*x_35 + 8.19151973724365) - 0.000547299137770209*std::sin(0.179520010948181*x_35 + 8.40520000457764) - 0.000245698810281003*std::sin(0.1893600076437*x_36 - 7.60423994064331) + 0.000538346196148461*std::sin(0.291999936103821*x_37 + 4.77928018569946) + 4.86012140961049e-5*std::sin(0.538559854030609*x_37 - 0.706639885902405) - 0.00699784487589961*std::sin(0.178640007972717*x_4 + 8.1755199432373) + 0.000123269418703881*std::sin(0.249199971556664*x_4 - 7.36111974716187) + 0.000338925195095541*std::sin(0.375919848680496*x_4 + 1.9793598651886) - 2.71676101361868e-5*std::sin(0.772719860076904*x_4 + 8.20959949493408) - 0.000127184462111325*std::sin(0.862319886684418*x_4 + 7.99488019943237) - 0.00113870316457177*std::sin(0.16312001645565*x_40 + 5.19856023788452) + 1.75989627279708e-5*std::sin(0.171840012073517*x_41 - 1.20207989215851) - 2.17816413797535e-5*std::sin(0.697999835014343*x_42 + 4.62016010284424) - 6.78193893539187e-5*std::sin(0.459839850664139*x_44 - 1.4592798948288) - 4.90131090885235e-5*std::sin(0.576399862766266*x_45 + 5.03351974487305) - 3.10493326097495e-5*std::sin(0.665839850902557*x_47 + 7.57984018325806) + 0.000812562504642955*std::sin(0.228719994425774*x_48 - 7.5971999168396) + 0.000748418191155436*std::sin(0.467279851436615*x_49 - 1.34599983692169) - 0.0022529300341051*std::sin(0.254319965839386*x_5 - 7.56360006332397) - 0.000594399460293969*std::sin(0.265679955482483*x_5 + 2.00615978240967) + 0.00086018905338228*std::sin(0.350159853696823*x_5 - 1.14927983283997) + 0.00130213368079198*std::sin(0.359199851751328*x_5 + 2.00079965591431) + 0.0030178689219293*std::sin(0.386959850788116*x_5 - 7.39559984207153) - 0.00172211716930301*std::sin(0.685359835624695*x_5 - 4.65687990188599) + 0.000292840627332962*std::sin(0.209279999136925*x_50 + 8.17591953277588) - 9.18967064826846e-5*std::sin(0.224399983882904*x_50 + 4.37063980102539) + 0.009268051614708*std::sin(0.16872002184391*x_51 + 8.20335960388184) - 0.00199811164646759*std::sin(0.255279958248138*x_52 - 1.2079998254776) - 0.000244650036178668*std::sin(0.233999982476234*x_53 - 7.42159986495972) + 0.000684982276979664*std::sin(0.20024000108242*x_54 + 5.00152015686035) + 5.82271210115357e-5*std::sin(0.5655198097229*x_54 + 4.83576011657715) - 0.00451898113839223*std::sin(0.589199841022491*x_54 + 1.78703987598419) - 0.000134189521845383*std::sin(0.337999850511551*x_56 + 1.85591995716095) - 0.000451961630447516*std::sin(0.169280022382736*x_57 + 1.61479985713959) + 0.000476798167513198*std::sin(0.29351994395256*x_57 - 1.42783987522125) - 0.0058258940345354*std::sin(0.299759924411774*x_58 + 1.87479984760284) + 3.3112637002871e-5*std::sin(0.48447984457016*x_58 + 4.6911997795105) + 7.76985093896956e-6*std::sin(0.359359860420227*x_59 + 4.64055967330933) + 0.00094600902996423*std::sin(0.606719851493835*x_59 - 7.81207990646362) + 0.0356051598959862*std::sin(0.323439925909042*x_6 + 2.01247978210449) - 0.00058476478818888*std::sin(0.342959851026535*x_6 + 2.01183986663818) + 0.000537204384289422*std::sin(0.344479858875275*x_6 + 2.01703977584839) - 0.00532469473778317*std::sin(0.366239845752716*x_6 + 1.99223983287811) + 0.00181955978721066*std::sin(0.367599844932556*x_6 - 1.16799986362457) + 0.0181476297141165*std::sin(0.378479838371277*x_6 + 1.99007987976074) + 0.000161837122415586*std::sin(0.38351982831955*x_6 - 1.17855989933014) - 0.0118657103396987*std::sin(0.358639866113663*x_60 + 8.24847984313965) - 0.000708821149764819*std::sin(0.452159851789474*x_60 - 7.48456001281738) + 2.06706772942171e-6*std::sin(1.41623985767365*x_64 + 6.79663991928101) - 2.63120527073531e-5*std::sin(1.77119994163513*x_64 + 3.59479999542236) + 0.0988936431878084*std::sin(0.26079997420311*x_7 + 2.03239989280701) - 0.00219488683198055*std::sin(0.322959840297699*x_7 - 7.339439868927) - 0.00103884387181407*std::sin(0.330399841070175*x_7 - 1.15071988105774) - 0.00860584108622394*std::sin(0.354959845542908*x_7 + 2.00631976127625) - 0.0288462363191236*std::sin(0.359199851751328*x_7 - 1.15143990516663) - 0.00142402701298866*std::sin(0.376479834318161*x_7 + 2.02695989608765) - 0.0014469931452273*std::sin(0.480159848928452*x_7 + 1.93423986434937) - 3.25042150542667e-5*std::sin(1.0732798576355*x_70 + 2.81663990020752) - 2.15066989242248e-5*std::sin(1.18463981151581*x_70 - 9.6071195602417) - 0.000178076833638206*std::sin(0.909999787807465*x_72 + 7.97391986846924) + 0.00026886784264248*std::sin(1.2240799665451*x_73 - 0.783519864082336) - 0.000134097550185107*std::sin(1.13831984996796*x_75 - 2.37199997901917) + 2.2189297878869e-5*std::sin(1.22527992725372*x_75 + 3.99287986755371) + 5.1720516816176e-5*std::sin(1.41495978832245*x_77 + 1.97983980178833) + 0.000103038091655601*std::sin(0.803119838237762*x_78 + 3.78615999221802) - 0.000676769753922522*std::sin(0.295279920101166*x_8 - 1.19455993175507) - 0.000279326406405606*std::sin(0.307679921388626*x_8 + 2.11904001235962) + 0.00649971972592992*std::sin(0.314959913492203*x_8 + 5.15392017364502) + 0.000272963130628752*std::sin(0.398239850997925*x_8 - 7.80751991271973) + 0.000106015032084109*std::sin(0.451759845018387*x_8 + 7.95944023132324) + 6.06126089251356e-5*std::sin(0.171200007200241*x_87 + 5.50552034378052) + 0.000854609221270659*std::sin(0.180960014462471*x_88 - 7.25880002975464) - 1.90814225324861e-5*std::sin(1.14111983776093*x_88 - 1.60359990596771) - 0.00191397378783585*std::sin(0.376639842987061*x_9 - 4.38687992095947) - 0.000294110191905455*std::sin(0.452639847993851*x_9 - 4.27943992614746) + 0.000319421696824478*std::sin(0.485359847545624*x_9 - 4.47983980178833) - 1.60534609852534e-5*std::sin(1.79071986675262*x_90 - 2.39239978790283) + 0.00342235859734351*std::sin(0.329519838094711*x_91 - 4.20544004440308) + 0.000458143062411799*std::sin(0.370879858732224*x_91 + 5.18943977355957) - 0.00185049448545357*std::sin(0.388959854841232*x_91 + 1.971599817276) + 0.000177379545455028*std::sin(0.417119860649109*x_91 + 8.21047973632813) - 0.000503684403156325*std::sin(0.227119997143745*x_92 + 2.01871991157532) + 6.10993155847649e-5*std::sin(0.239759981632233*x_92 + 5.19600009918213) + 0.00779513693084721*std::sin(0.253919988870621*x_92 + 2.02055978775024) + 0.00435629403713372*std::sin(0.285359919071198*x_92 + 1.99703979492188) + 0.092343259564888*std::sin(0.303839921951294*x_92 + 1.98935985565186) - 0.00110502921530663*std::sin(0.321039855480194*x_92 - 1.1814398765564) - 0.00324141837708496*std::sin(0.327039837837219*x_92 + 8.22480010986328) - 0.00073054993102832*std::sin(0.257679969072342*x_94 - 7.39807987213135) - 0.000482528398887003*std::sin(0.275759935379028*x_94 + 1.97855985164642) - 0.0187476021529126*std::sin(0.285999953746796*x_94 - 1.19919991493225) - 0.00160297055695772*std::sin(0.287839949131012*x_94 + 1.97927987575531) + 0.00125259795394167*std::sin(0.310879945755005*x_94 + 1.79847991466522) - 0.000534053824562206*std::sin(0.253759980201721*x_95 - 7.40999984741211) - 0.0013607056659695*std::sin(0.262319982051849*x_96 - 1.20431983470917) + 0.00121440779105631*std::sin(0.30447992682457*x_96 - 4.41775989532471) + 0.00056631990279128*std::sin(0.273119956254959*x_97 + 1.96655988693237) - 0.000671568415079979*std::sin(0.27991995215416*x_97 + 1.97735977172852) + 0.000612150335438299*std::sin(0.261359959840775*x_98 - 4.42471981048584) - 0.248533686405309);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-4.32697847245257e-5*x_1 + 0.00506366574934803*x_10 - 0.00692275027212136*x_100 - 0.00675941582251182*x_101 + 0.00013475854716746*x_102 + 0.0128121881684956*x_103 - 0.000137260217251425*x_104 - 0.00888207820100545*x_105 - 0.00839961060339673*x_106 + 0.0318340376659279*x_107 - 0.0121241085454877*x_108 - 0.0110616467703327*x_109 + 0.00481928798599019*x_11 + 0.00925554581082871*x_110 + 0.0246466592338867*x_111 - 0.0014342936484137*x_112 - 0.00167008669978088*x_113 - 0.00254462342221674*x_114 - 0.0134073313729002*x_115 - 0.00599974023652253*x_116 - 0.00220993404451368*x_117 - 0.0003929650284979*x_118 - 0.00137896068071952*x_119 + 0.00228877947211594*x_12 + 0.0663083939346368*x_120 + 0.000274529083735007*x_13 - 0.00137796393882929*x_14 - 0.00190815832081486*x_15 + 0.000584979490366156*x_16 - 0.00102491209231484*x_17 - 0.000215656710895041*x_18 - 0.000440652712466288*x_19 + 0.00664886879763873*x_2 + 3.98394638913782e-5*x_20 - 0.000742332433720905*x_21 - 3.75793902621468e-5*x_22 + 0.00304373556840345*x_23 + 0.000723480120526626*x_24 - 0.000384205170698508*x_25 - 7.91104663372965e-5*x_26 + 0.000114480315259332*x_27 - 0.00170036711435556*x_28 - 0.00225223222769245*x_29 + 0.000165372035827167*x_3 - 0.00211200002179455*x_30 + 0.000597348220606247*x_31 - 0.00353976634291392*x_32 - 0.00421847072945479*x_33 + 0.00578792590400746*x_34 - 0.000159507195713283*x_35 + 0.00225792247747074*x_36 + 0.00164769911131277*x_37 + 0.000665669275131565*x_38 + 0.000660747163507525*x_39 + 0.00131983467219828*x_4 + 0.000489636719956793*x_40 - 0.00199174664422496*x_41 + 0.00204024831033088*x_42 + 0.00326906121543683*x_43 + 0.000233718713320136*x_44 - 0.000187853680053199*x_45 - 0.000705919632710753*x_46 + 0.00170497470311818*x_47 - 0.0160789231182198*x_48 - 2.84015673420176e-5*x_49 - 0.00852922530310487*x_5 - 0.00233166551421721*x_50 + 0.00551314755976375*x_51 - 0.00909634385262808*x_52 - 0.00653812093784473*x_53 - 0.00390355605384347*x_54 - 0.00582624607832039*x_55 + 0.000616621670052419*x_56 - 0.000219471744046385*x_57 + 0.00386506937862769*x_58 + 0.00471544063569166*x_59 - 0.00819787474847364*x_6 + 0.00109978771813919*x_60 + 0.000396704108275357*x_61 + 0.00215121594865606*x_62 + 0.000765492124021079*x_63 - 0.00439878799431604*x_64 - 0.00184590788099307*x_65 - 0.000654382820987837*x_66 - 0.00427363909471898*x_67 - 0.00392301739956231*x_68 + 0.000877905043304921*x_69 + 0.000855526855297682*x_7 - 0.000237292386309138*x_70 - 0.000599533142999587*x_71 - 0.00230888425819411*x_72 - 0.000158378581114905*x_73 - 0.00566397362680505*x_74 - 0.002372956347284*x_75 - 0.00023053699097951*x_76 + 0.000897263083818396*x_77 - 2.26977027699555e-6*x_78 - 0.0045101359854438*x_79 + 0.000485477684031903*x_8 + 0.000121736194920312*x_80 - 0.00229043234097682*x_81 - 0.00440868116869888*x_82 + 0.00279046541537852*x_83 - 0.00768935024143939*x_84 - 0.0043299321999805*x_85 - 0.0036941413824426*x_86 + 0.000267863283861541*x_87 - 0.00101610210854748*x_88 - 0.00239799584609397*x_89 + 0.00915427965058652*x_9 - 0.000358298450333414*x_90 + 0.00185474168066217*x_91 + 0.00165140787908554*x_92 + 0.000706160371988324*x_93 + 0.00156092730499268*x_94 - 0.0021141038244427*x_95 + 0.00146417809897873*x_96 + 0.00873429037470773*x_97 + 0.00911226222295439*x_98 - 0.00681758568940547*x_99 - 7.36826360084946e-6*std::pow(2.4696798324585 - 7.17983961105347*x_59, 2) - 9.84886212543214e-7*std::pow(5.30704021453857 - 8.17615985870361*x_15, 2) + 2.08399498471319e-6*std::pow(5.54383993148804 - 0.991999804973602*x_10, 2) + 3.34136905785715e-7*std::pow(-2.62831997871399*x_16 - 9.89848041534424, 2) - 1.60304320989621e-7*std::pow(-3.71199989318848*x_25 - 8.0, 2) + 4.61583402894786e-8*std::pow(-9.3261604309082*x_28 - 1.61375975608826, 2) + 1.68196774846681e-7*std::pow(-5.89263963699341*x_60 - 9.60136032104492, 2) + 0.000158246770217675*std::pow(-3.8724000453949*x_61 - 6.51895952224731, 2) - 7.75168265512878e-7*std::pow(-2.83240008354187*x_64 - 9.11664009094238, 2) + 4.28781170775093e-7*std::pow(-2.76160001754761*x_64 - 6.32287979125977, 2) - 2.43957226902292e-6*std::pow(-3.67159986495972*x_9 - 7.73672008514404, 2) + 0.00153808574630038*std::exp(0.208559840917587*x_13) + 4.8161106236842e-5*std::exp(0.253679871559143*x_13) - 6.45318822758807e-5*std::exp(0.541759848594666*x_13) + 0.00106666965391229*std::exp(0.173759862780571*x_14) - 0.000179283102444103*std::exp(0.318959832191467*x_18) + 2.01490465875114e-5*std::exp(0.403919875621796*x_18) - 0.0100543366736493*std::exp(0.45007985830307*x_18) - 0.000187062220266012*std::exp(0.356479853391647*x_19) + 3.19250729453203e-5*std::exp(0.250079840421677*x_20) + 0.000415324493501385*std::exp(0.326959848403931*x_22) + 0.00132176315899834*std::exp(0.548639833927155*x_22) - 0.000364905150268645*std::exp(0.521439850330353*x_26) - 0.000103277739887264*std::exp(0.310879856348038*x_28) - 0.000312852845002494*std::exp(0.321919828653336*x_30) + 3.45656517972839e-5*std::exp(0.370639860630035*x_5) + 4.88727065748525e-5*std::exp(0.319119840860367*x_59) + 3.20349448256086e-5*std::exp(0.324639827013016*x_6) - 0.0001481476471552*std::log(5.16136026382446 - 0.59639984369278*x_9) + 0.00448059827478191*std::sin(0.332799851894379*x_1 - 4.25031995773315) + 0.00267860099174091*std::sin(0.337039858102798*x_1 - 4.24552011489868) - 0.0384997410019281*std::sin(0.344959855079651*x_1 - 4.25184011459351) + 0.00672812781836211*std::sin(0.348479837179184*x_1 + 5.15775966644287) + 0.000401439985983643*std::sin(0.351919859647751*x_1 - 4.22544002532959) - 0.149144885491746*std::sin(0.353119850158691*x_1 - 4.22032022476196) - 0.00891954196822445*std::sin(0.358719855546951*x_1 - 4.23680019378662) + 0.0204877499589445*std::sin(0.359119862318039*x_1 - 1.03623986244202) - 0.00134562982619511*std::sin(0.403519839048386*x_1 - 4.18416023254395) - 0.00151996376047106*std::sin(1.34607982635498*x_100 - 4.97455978393555) - 0.000204464136964987*std::sin(0.225759983062744*x_107 - 4.39264011383057) - 0.00129454424291541*std::sin(0.206160008907318*x_108 - 4.39903974533081) - 0.000871841566549786*std::sin(0.20584000647068*x_109 + 5.18096017837524) + 0.00138501878400889*std::sin(0.102400071918964*x_11 - 4.28399991989136) + 0.00166634604292265*std::sin(0.175360009074211*x_11 + 5.18400001525879) + 0.00693150128684521*std::sin(0.283119946718216*x_11 - 7.42775964736938) - 0.000707492473654056*std::sin(0.282959938049316*x_112 - 7.43111991882324) - 0.000149374021617662*std::sin(0.323279827833176*x_112 - 1.34607982635498) - 0.000757333958845043*std::sin(0.254479974508286*x_113 - 4.22528028488159) + 0.00256541031019256*std::sin(0.283679932355881*x_113 + 1.96335983276367) - 0.00121887885608583*std::sin(0.287439942359924*x_113 - 7.42911958694458) + 0.0031798815462684*std::sin(0.2880799472332*x_113 - 7.42679977416992) - 0.00172193582273338*std::sin(0.233999982476234*x_114 + 1.97791981697083) - 0.0499632153031646*std::sin(0.241119980812073*x_114 - 1.23959982395172) - 0.00538140993326023*std::sin(0.209199994802475*x_116 + 2.000159740448) - 0.00348780681318267*std::sin(0.227039992809296*x_116 + 5.1735200881958) + 0.00216085308087639*std::sin(0.233519986271858*x_116 + 1.79903984069824) - 0.00565709446047906*std::sin(0.251039981842041*x_116 + 5.16688013076782) + 0.000642408400822566*std::sin(0.262319952249527*x_116 - 1.23943984508514) + 0.000403159380288052*std::sin(1.02279984951019*x_116 + 8.39000034332275) + 0.00117446048123376*std::sin(0.218319997191429*x_118 - 4.21447992324829) + 0.00432977331971238*std::sin(0.226719990372658*x_119 + 5.18576002120972) + 0.00255188116572185*std::sin(0.235759988427162*x_119 + 5.17343997955322) - 0.00631312234512354*std::sin(0.276479959487915*x_12 - 7.43616008758545) + 0.00618284908581211*std::sin(0.298639953136444*x_12 + 5.12664031982422) - 0.00640329641154192*std::sin(0.539439857006073*x_12 + 7.83392000198364) - 0.0200099080801863*std::sin(0.179840013384819*x_13 + 1.59295988082886) - 0.00347583441470179*std::sin(0.232399985194206*x_13 - 7.40807962417603) - 0.011487526203285*std::sin(0.295279920101166*x_13 - 4.40863990783691) - 0.00682583447335279*std::sin(0.305279940366745*x_13 + 5.13495969772339) + 0.00755338355424678*std::sin(0.121120058000088*x_14 - 1.25951981544495) - 0.00224604673965585*std::sin(0.243039980530739*x_14 - 1.1814398765564) - 0.00267389201686154*std::sin(0.303039938211441*x_14 - 7.43951988220215) + 0.000187141478520337*std::sin(0.442319840192795*x_14 - 1.44655990600586) - 0.000753282021167674*std::sin(0.53143984079361*x_14 - 1.31679975986481) - 6.17645022628325e-5*std::sin(0.538719832897186*x_14 + 1.86799991130829) + 0.00493171826096524*std::sin(0.244799971580505*x_15 - 1.17535984516144) - 0.000725058760977895*std::sin(0.267919957637787*x_15 + 1.98791980743408) + 0.000367811642801545*std::sin(0.270559966564178*x_15 + 1.77759981155396) + 0.00239093384050076*std::sin(0.29615992307663*x_15 + 5.17063999176025) + 0.0111765441108118*std::sin(0.316639930009842*x_15 + 5.14856004714966) - 6.89875745102863e-5*std::sin(0.502879858016968*x_15 + 8.08672046661377) - 0.00360743555410694*std::sin(0.297039926052094*x_16 + 2.00455975532532) + 0.00389870612053786*std::sin(0.314639925956726*x_16 + 1.9968798160553) + 0.00113465586353165*std::sin(0.387599855661392*x_16 - 1.18503987789154) - 9.14129330988027e-5*std::sin(0.51095986366272*x_16 + 8.10847949981689) + 0.00014912997380231*std::sin(0.27975994348526*x_17 - 7.37399959564209) + 0.00528797252794727*std::sin(0.344799846410751*x_17 + 1.99871981143951) + 0.00103677520651433*std::sin(0.380239844322205*x_17 - 1.1743198633194) - 0.000214102187315921*std::sin(0.383119851350784*x_17 + 1.99287974834442) - 0.0111732346121045*std::sin(0.428399860858917*x_17 - 1.20383989810944) + 0.000113566815189623*std::sin(0.606959879398346*x_17 + 5.00175952911377) - 0.00246555819134368*std::sin(0.314559936523438*x_18 - 1.15207993984222) - 0.00337010739582522*std::sin(0.374319821596146*x_18 + 2.02303981781006) + 0.00379342391655183*std::sin(0.431999862194061*x_18 - 7.42375993728638) - 0.000273108375652564*std::sin(0.51775985956192*x_18 + 2.0559196472168) + 0.000209364971629607*std::sin(0.524639844894409*x_18 + 2.05535984039307) + 0.0093653924416468*std::sin(0.222240000963211*x_19 + 8.1947193145752) + 0.00473071156250763*std::sin(0.25655996799469*x_19 + 8.21303939819336) - 0.00450819828366384*std::sin(0.257999986410141*x_19 + 8.2061595916748) - 0.060068283465877*std::sin(0.39319983124733*x_19 - 1.2047199010849) + 0.00639576618362445*std::sin(0.365679860115051*x_2 + 5.18024015426636) + 0.0051362390738635*std::sin(0.377919852733612*x_2 + 5.17736005783081) - 0.00192020832190876*std::sin(0.388719856739044*x_2 + 5.18279981613159) + 0.00837602932849781*std::sin(0.399199843406677*x_2 + 5.20344018936157) + 8.35493221161479e-5*std::sin(0.409279853105545*x_2 - 1.17679977416992) + 0.00815706120630925*std::sin(0.337519854307175*x_20 - 7.79392004013062) - 3.45617775131464e-5*std::sin(0.415519863367081*x_20 + 7.59352016448975) - 0.00279886602497136*std::sin(0.317199915647507*x_21 - 1.19207990169525) - 0.000648553714425567*std::sin(0.340239852666855*x_21 + 2.04071974754333) + 0.000304964675683573*std::sin(0.317359924316406*x_22 + 8.25111961364746) + 0.00185015271850895*std::sin(0.399679869413376*x_22 + 2.00927972793579) + 0.00998001219433619*std::sin(0.482559859752655*x_22 + 4.98415994644165) + 0.00600651500581155*std::sin(0.275279939174652*x_23 - 1.15063989162445) - 0.00103312452991452*std::sin(0.319999933242798*x_23 - 1.16799986362457) + 0.000208861962719227*std::sin(0.354399859905243*x_23 - 1.39335989952087) - 0.000695010171136504*std::sin(0.366559833288193*x_23 - 7.36911964416504) - 0.00309886256340609*std::sin(0.370399862527847*x_23 + 1.99191975593567) - 6.05653601140215e-5*std::sin(0.832639873027802*x_23 - 7.78951978683472) - 0.00157957357177762*std::sin(0.386879861354828*x_24 - 1.19351994991302) + 0.00137535495707165*std::sin(0.442479848861694*x_24 - 1.21311986446381) - 0.00355893149095603*std::sin(0.827359914779663*x_24 + 1.80167984962463) + 0.00010666995662209*std::sin(0.261439979076385*x_25 - 7.37575960159302) - 0.00122849064590565*std::sin(0.324319839477539*x_25 - 1.13855993747711) - 0.00357210148881989*std::sin(0.338639855384827*x_25 - 1.14871978759766) + 0.0047427423557368*std::sin(0.152400031685829*x_26 + 8.14935970306396) + 0.00198078918443087*std::sin(0.284159928560257*x_26 + 1.98807990550995) + 0.0041706004501155*std::sin(0.304559946060181*x_26 - 1.17807984352112) + 0.0129602229570533*std::sin(0.783759832382202*x_26 - 1.39231991767883) - 0.000626943054658436*std::sin(0.285999923944473*x_27 - 7.39047956466675) - 0.00145953357737307*std::sin(0.367839843034744*x_27 + 5.23767995834351) + 0.000111629589554947*std::sin(0.463919848203659*x_27 + 4.5776801109314) - 0.000585671363308402*std::sin(0.0912800803780556*x_28 + 2.02471995353699) + 0.00108005484668341*std::sin(0.805839836597443*x_28 + 4.79120016098022) + 0.00275682886899742*std::sin(0.323039919137955*x_29 + 4.80983972549438) + 0.000123544167131255*std::sin(0.377759844064713*x_29 - 1.18191993236542) - 2.24313134420307e-5*std::sin(0.856159865856171*x_29 - 5.43487977981567) - 0.238988129162504*std::sin(0.2743199467659*x_3 - 1.15183985233307) - 0.00260284023945397*std::sin(0.2882399559021*x_3 - 1.13159990310669) + 0.00927906551218856*std::sin(0.316159933805466*x_3 + 8.28087997436523) - 0.000985747171818902*std::sin(0.344079852104187*x_3 - 7.40455961227417) + 0.0786790275717021*std::sin(0.348319828510284*x_3 + 1.97527980804443) - 0.000538315172727893*std::sin(0.359439849853516*x_3 - 7.39336013793945) + 0.000989982208341701*std::sin(0.372479856014252*x_3 + 5.19831991195679) - 0.000336263201770805*std::sin(0.396399825811386*x_3 - 7.40655994415283) - 0.00215122728297597*std::sin(0.259519964456558*x_30 + 1.99079978466034) + 0.00461089294448272*std::sin(0.266159951686859*x_30 - 1.1651998758316) - 0.00187243929043721*std::sin(0.284959942102432*x_30 - 1.16359984874725) - 0.0468293748900084*std::sin(0.304079920053482*x_30 - 1.16567981243134) + 0.00245318097801947*std::sin(0.308239936828613*x_30 + 2.00159978866577) + 0.00326023429460524*std::sin(0.312719941139221*x_30 + 1.99159979820251) - 0.000661711961275403*std::sin(0.765519857406616*x_30 - 7.37951993942261) - 0.000145578179939572*std::sin(0.293119937181473*x_31 - 1.07175981998444) + 0.000511099925738652*std::sin(0.309599936008453*x_31 - 4.056960105896) + 8.57439783181814e-5*std::sin(0.340319842100143*x_31 - 1.01967978477478) - 0.19019118427064*std::sin(0.350399851799011*x_31 + 5.15687990188599) + 0.0121979084026414*std::sin(0.375759840011597*x_31 - 7.39991998672485) + 0.00141963410425985*std::sin(0.376639842987061*x_31 - 4.22408008575439) - 0.166422870803161*std::sin(0.386079847812653*x_31 - 7.39783954620361) - 0.00168011920275923*std::sin(0.396079838275909*x_31 + 8.38568019866943) - 0.00162286660063849*std::sin(0.405199855566025*x_31 + 5.19992017745972) + 0.00042831850384834*std::sin(0.613279819488525*x_31 + 5.1956000328064) + 0.000634523867774015*std::sin(0.285679936408997*x_32 + 8.2425594329834) + 0.00502026890927652*std::sin(0.302159935235977*x_32 - 1.14591991901398) - 0.00128102874841044*std::sin(0.30839991569519*x_32 - 1.14823985099792) + 0.000100141089949703*std::sin(0.213440001010895*x_33 + 1.971599817276) + 0.00233763702556338*std::sin(0.233039990067482*x_33 + 1.9968798160553) - 0.00346497330918263*std::sin(0.233519986271858*x_33 - 1.17975986003876) + 0.000102026815862388*std::sin(0.225599989295006*x_34 + 1.77711987495422) - 6.43573714470178e-5*std::sin(0.179120019078255*x_35 + 8.19151973724365) + 0.0183286999063184*std::sin(0.179520010948181*x_35 + 8.40520000457764) + 0.000906665904011396*std::sin(0.1893600076437*x_36 - 7.60423994064331) - 0.0180288715876911*std::sin(0.291999936103821*x_37 + 4.77928018569946) - 1.62757046296331e-5*std::sin(0.538559854030609*x_37 - 0.706639885902405) + 0.00219005780983996*std::sin(0.178640007972717*x_4 + 8.1755199432373) + 0.000159169498281477*std::sin(0.249199971556664*x_4 - 7.36111974716187) + 0.00102909556806325*std::sin(0.375919848680496*x_4 + 1.9793598651886) + 0.000311468507150595*std::sin(0.772719860076904*x_4 + 8.20959949493408) - 3.46369517612602e-5*std::sin(0.862319886684418*x_4 + 7.99488019943237) - 0.00487193304175497*std::sin(0.16312001645565*x_40 + 5.19856023788452) + 0.0064059292419427*std::sin(0.171840012073517*x_41 - 1.20207989215851) - 6.6136690141105e-5*std::sin(0.697999835014343*x_42 + 4.62016010284424) - 8.75706098943381e-5*std::sin(0.459839850664139*x_44 - 1.4592798948288) - 6.32873267746656e-5*std::sin(0.576399862766266*x_45 + 5.03351974487305) + 9.71725360853453e-6*std::sin(0.665839850902557*x_47 + 7.57984018325806) + 0.000221290303934232*std::sin(0.228719994425774*x_48 - 7.5971999168396) - 0.0250640490427323*std::sin(0.467279851436615*x_49 - 1.34599983692169) + 0.000165830538563021*std::sin(0.254319965839386*x_5 - 7.56360006332397) - 0.000767507990777871*std::sin(0.265679955482483*x_5 + 2.00615978240967) - 0.00986180966898502*std::sin(0.350159853696823*x_5 - 1.14927983283997) + 0.00395373380120403*std::sin(0.359199851751328*x_5 + 2.00079965591431) + 0.00153669755438582*std::sin(0.386959850788116*x_5 - 7.39559984207153) + 0.000249889467413599*std::sin(0.685359835624695*x_5 - 4.65687990188599) - 9.16479165089436e-5*std::sin(0.209279999136925*x_50 + 8.17591953277588) + 0.00033911279571725*std::sin(0.224399983882904*x_50 + 4.37063980102539) + 0.00252402731725613*std::sin(0.16872002184391*x_51 + 8.20335960388184) - 0.000544158425985493*std::sin(0.255279958248138*x_52 - 1.2079998254776) - 0.000315900114744987*std::sin(0.233999982476234*x_53 - 7.42159986495972) + 0.000348792680219974*std::sin(0.20024000108242*x_54 + 5.00152015686035) - 0.000667556489740087*std::sin(0.5655198097229*x_54 + 4.83576011657715) + 0.000655731102420849*std::sin(0.589199841022491*x_54 + 1.78703987598419) + 0.000495179703937737*std::sin(0.337999850511551*x_56 + 1.85591995716095) + 0.000151354120218999*std::sin(0.169280022382736*x_57 + 1.61479985713959) + 0.000242785421404177*std::sin(0.29351994395256*x_57 - 1.42783987522125) + 0.000845371954619865*std::sin(0.299759924411774*x_58 + 1.87479984760284) - 0.000379626458249499*std::sin(0.48447984457016*x_58 + 4.6911997795105) + 0.00282818459842378*std::sin(0.359359860420227*x_59 + 4.64055967330933) - 6.96325161232819e-5*std::sin(0.606719851493835*x_59 - 7.81207990646362) - 0.00516652095582151*std::sin(0.323439925909042*x_6 + 2.01247978210449) + 0.00670415302260329*std::sin(0.342959851026535*x_6 + 2.01183986663818) + 0.00163114061455523*std::sin(0.344479858875275*x_6 + 2.01703977584839) - 0.00271133226560798*std::sin(0.366239845752716*x_6 + 1.99223983287811) + 0.000495532264948997*std::sin(0.367599844932556*x_6 - 1.16799986362457) - 0.00133578547206399*std::sin(0.378479838371277*x_6 + 1.99007987976074) + 0.000208969376582254*std::sin(0.38351982831955*x_6 - 1.17855989933014) + 0.00172178530597393*std::sin(0.358639866113663*x_60 + 8.24847984313965) + 0.0237379693200717*std::sin(0.452159851789474*x_60 - 7.48456001281738) - 2.36983119470116e-5*std::sin(1.41623985767365*x_64 + 6.79663991928101) + 0.000727232419990401*std::sin(1.77119994163513*x_64 + 3.59479999542236) - 0.0143500571664318*std::sin(0.26079997420311*x_7 + 2.03239989280701) + 0.000686915633790172*std::sin(0.322959840297699*x_7 - 7.339439868927) - 0.00315429374936898*std::sin(0.330399841070175*x_7 - 1.15071988105774) - 0.00438209057210444*std::sin(0.354959845542908*x_7 + 2.00631976127625) + 0.0021232736178674*std::sin(0.359199851751328*x_7 - 1.15143990516663) + 0.0393583359803031*std::sin(0.376479834318161*x_7 + 2.02695989608765) - 0.000394068826789885*std::sin(0.480159848928452*x_7 + 1.93423986434937) + 0.000898376087822175*std::sin(1.0732798576355*x_70 + 2.81663990020752) - 4.48603678985544e-5*std::sin(1.18463981151581*x_70 - 9.6071195602417) + 0.00596367985763658*std::sin(0.909999787807465*x_72 + 7.97391986846924) - 1.97904499796819e-5*std::sin(1.2240799665451*x_73 - 0.783519864082336) + 9.87046585137794e-6*std::sin(1.13831984996796*x_75 - 2.37199997901917) - 7.43081145053864e-6*std::sin(1.22527992725372*x_75 + 3.99287986755371) + 2.63360648719555e-5*std::sin(1.41495978832245*x_77 + 1.97983980178833) - 0.0034506801318371*std::sin(0.803119838237762*x_78 + 3.78615999221802) + 0.000226638466177643*std::sin(0.295279920101166*x_8 - 1.19455993175507) + 0.001030756837969*std::sin(0.307679921388626*x_8 + 2.11904001235962) + 0.00177010992436867*std::sin(0.314959913492203*x_8 + 5.15392017364502) + 0.000569368014398255*std::sin(0.398239850997925*x_8 - 7.80751991271973) - 0.0029301236659632*std::sin(0.451759845018387*x_8 + 7.95944023132324) + 7.82649796972027e-5*std::sin(0.171200007200241*x_87 + 5.50552034378052) + 0.00365643921299085*std::sin(0.180960014462471*x_88 - 7.25880002975464) + 6.39003783810535e-6*std::sin(1.14111983776093*x_88 - 1.60359990596771) - 0.000521244628951291*std::sin(0.376639842987061*x_9 - 4.38687992095947) + 0.00108531125046128*std::sin(0.452639847993851*x_9 - 4.27943992614746) - 0.000106968792580597*std::sin(0.485359847545624*x_9 - 4.47983980178833) - 8.17441541486708e-6*std::sin(1.79071986675262*x_90 - 2.39239978790283) - 0.114612611958572*std::sin(0.329519838094711*x_91 - 4.20544004440308) - 0.00014338125660866*std::sin(0.370879858732224*x_91 + 5.18943977355957) - 0.00385990726443785*std::sin(0.388959854841232*x_91 + 1.971599817276) + 0.000229038260684071*std::sin(0.417119860649109*x_91 + 8.21047973632813) - 0.00152936221470534*std::sin(0.227119997143745*x_92 + 2.01871991157532) - 0.000700485339627334*std::sin(0.239759981632233*x_92 + 5.19600009918213) - 0.000573773590766816*std::sin(0.253919988870621*x_92 + 2.02055978775024) + 0.00221822304620484*std::sin(0.285359919071198*x_92 + 1.99703979492188) - 0.0133995574535994*std::sin(0.303839921951294*x_92 + 1.98935985565186) + 0.000345831881958158*std::sin(0.321039855480194*x_92 - 1.1814398765564) + 0.108553039104842*std::sin(0.327039837837219*x_92 + 8.22480010986328) + 0.000244648515798471*std::sin(0.257679969072342*x_94 - 7.39807987213135) - 0.00146512517790036*std::sin(0.275759935379028*x_94 + 1.97855985164642) + 0.00272038883345519*std::sin(0.285999953746796*x_94 - 1.19919991493225) + 0.000501668477862258*std::sin(0.287839949131012*x_94 + 1.97927987575531) - 0.041948708515424*std::sin(0.310879945755005*x_94 + 1.79847991466522) + 0.000167138421914075*std::sin(0.253759980201721*x_95 - 7.40999984741211) - 0.000692870738665985*std::sin(0.262319982051849*x_96 - 1.20431983470917) - 0.0406697442587816*std::sin(0.30447992682457*x_96 - 4.41775989532471) - 0.0156523779416319*std::sin(0.273119956254959*x_97 + 1.96655988693237) - 0.00287330048165589*std::sin(0.27991995215416*x_97 + 1.97735977172852) + 0.00031170668697669*std::sin(0.261359959840775*x_98 - 4.42471981048584) - 0.346331162251107);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000211060036804158*x_1 - 0.00241237465790611*x_10 + 0.000663871153095379*x_100 + 0.000465670024198149*x_101 + 1.81965486963371e-5*x_102 + 0.000813739513605064*x_103 + 0.000300762362381236*x_104 + 8.97509240222089e-5*x_105 - 0.00158302948499462*x_106 + 0.00150845141411974*x_107 - 0.00140540870643641*x_108 - 0.00143754107160632*x_109 - 0.0059817439791059*x_11 - 0.000670518460939288*x_110 - 0.00033813043960257*x_111 - 0.0123180882357306*x_112 - 0.00417216983337941*x_113 - 0.0060480546382949*x_114 - 0.000208375348501349*x_115 + 0.000846082718636107*x_116 + 0.00308159443984928*x_117 + 0.000749416598488171*x_118 - 0.00173553565419398*x_119 - 0.00436140302569442*x_12 + 0.00699842375745971*x_120 - 0.000559413975633319*x_13 - 0.00160920312170658*x_14 - 0.000340410841071451*x_15 + 0.00220968246200364*x_16 - 0.0004334924802182*x_17 - 0.000720504760644295*x_18 + 0.000991532539218777*x_19 + 0.000393576943805998*x_2 - 0.00156086737213588*x_20 - 0.00111109323699203*x_21 + 0.000690004880678082*x_22 + 0.000163281158116832*x_23 + 1.21619451935577e-5*x_24 - 0.00165063987505348*x_25 - 0.000541426618980217*x_26 + 0.000155580693205264*x_27 - 0.00100842769985121*x_28 - 0.000575401922934027*x_29 - 0.000239453741908026*x_3 - 0.000199028753606362*x_30 - 0.000174880518114413*x_31 + 0.000395577462256168*x_32 + 0.000500100572037458*x_33 + 0.00125128890621068*x_34 - 0.000797654993243507*x_35 - 9.29484607892267e-5*x_36 - 0.00211345499261471*x_37 + 0.00192470265778262*x_38 - 0.000931943535549795*x_39 - 0.000421980655934744*x_4 + 0.00115978759492965*x_40 + 0.000343831430921552*x_41 + 0.000462456376663689*x_42 - 0.000365351654084835*x_43 - 0.000550092661663387*x_44 - 0.00136818522883754*x_45 - 0.000962154589505433*x_46 + 0.00271428641603025*x_47 + 0.016743016012479*x_48 + 0.00484065836920563*x_49 - 0.000749724362460155*x_5 + 9.57845506437496e-5*x_50 - 0.00201285008830729*x_51 - 0.00461209407678259*x_52 - 0.00301677726392062*x_53 - 0.000283407633361121*x_54 - 0.00213766750190081*x_55 + 0.00140853487571089*x_56 - 0.00136731931828753*x_57 - 3.56409878791929e-5*x_58 - 0.000476216772410009*x_59 - 0.000956982360344421*x_6 + 0.00313610917150977*x_60 + 0.000812491100493854*x_61 + 7.73266726149158e-5*x_62 - 0.000530806833275164*x_63 + 0.000445923568151896*x_64 + 0.000515086199590555*x_65 - 0.000340509684058906*x_66 + 0.000262408385669106*x_67 - 9.24027016424421e-6*x_68 - 0.000326469007489757*x_69 - 0.000795295627307286*x_7 + 0.000615795415097772*x_70 + 0.000151642272228227*x_71 + 0.00134703815831813*x_72 + 0.00105918505013424*x_73 + 0.000637680802796782*x_74 - 5.28260285560013e-5*x_75 + 0.000145857322015437*x_76 + 0.000472490444606514*x_77 - 0.000350259244304362*x_78 - 0.00267928801223229*x_79 - 0.000846789294937336*x_8 - 0.00208770836248667*x_80 + 0.000375919053253786*x_81 + 0.000381828301773974*x_82 - 0.001378426581046*x_83 - 0.00130051903490797*x_84 - 0.00114236666775095*x_85 - 0.000620763834499784*x_86 - 0.000986250410271624*x_87 - 0.000157785014969785*x_88 - 0.000902464972966273*x_89 + 6.98316764476991e-5*x_9 - 0.00176744966532554*x_90 - 0.00101484927025741*x_91 - 7.79213371670557e-5*x_92 + 0.00186414791114135*x_93 + 0.000320320768428875*x_94 - 0.00439330797671664*x_95 - 0.000842950843918937*x_96 - 0.000447945994272635*x_97 + 0.000916422257058482*x_98 - 0.00201750938370783*x_99 + 1.02361013237295e-7*std::pow(2.4696798324585 - 7.17983961105347*x_59, 2) - 3.52871311167883e-8*std::pow(5.30704021453857 - 8.17615985870361*x_15, 2) - 6.76936926103315e-7*std::pow(5.54383993148804 - 0.991999804973602*x_10, 2) - 1.83115309346067e-6*std::pow(-2.62831997871399*x_16 - 9.89848041534424, 2) + 4.52280112875074e-6*std::pow(-3.71199989318848*x_25 - 8.0, 2) + 3.05179606482104e-8*std::pow(-9.3261604309082*x_28 - 1.61375975608826, 2) - 2.35945820636644e-6*std::pow(-5.89263963699341*x_60 - 9.60136032104492, 2) + 1.00343400013086e-5*std::pow(-3.8724000453949*x_61 - 6.51895952224731, 2) - 5.1250877900512e-7*std::pow(-2.83240008354187*x_64 - 9.11664009094238, 2) - 2.34982713279218e-6*std::pow(-2.76160001754761*x_64 - 6.32287979125977, 2) - 4.56541143647241e-5*std::pow(-3.67159986495972*x_9 - 7.73672008514404, 2) - 0.000358560519220712*std::exp(0.208559840917587*x_13) - 7.18273697795627e-6*std::exp(0.253679871559143*x_13) + 6.76470214429169e-5*std::exp(0.541759848594666*x_13) + 0.00323163971678112*std::exp(0.318959832191467*x_18) - 0.000110421771286367*std::exp(0.403919875621796*x_18) - 0.000637539916500331*std::exp(0.45007985830307*x_18) - 0.00017495731561084*std::exp(0.250079840421677*x_20) + 8.38122694090325e-5*std::exp(0.548639833927155*x_22) + 5.0693165907772e-6*std::exp(0.521439850330353*x_26) - 5.15511384042062e-6*std::exp(0.370639860630035*x_5) + 3.23125859090487e-5*std::exp(0.319119840860367*x_59) - 4.77768474947672e-6*std::exp(0.324639827013016*x_6) + 0.000811885839845359*std::log(5.16136026382446 - 0.59639984369278*x_9) - 0.0807643282737184*std::sin(0.332799851894379*x_1 - 4.25031995773315) - 0.000399485973140914*std::sin(0.337039858102798*x_1 - 4.24552011489868) + 0.0403582339961837*std::sin(0.344959855079651*x_1 - 4.25184011459351) - 0.00219999066084661*std::sin(0.351919859647751*x_1 - 4.22544002532959) - 0.00945719453497737*std::sin(0.353119850158691*x_1 - 4.22032022476196) - 0.166920158205179*std::sin(0.358719855546951*x_1 - 4.23680019378662) - 0.000284618867939*std::sin(0.359119862318039*x_1 - 1.03623986244202) + 0.0188764459903682*std::sin(0.403519839048386*x_1 - 4.18416023254395) + 2.1115562503471e-5*std::sin(1.34607982635498*x_100 - 4.97455978393555) + 0.0028682154358157*std::sin(0.225759983062744*x_107 - 4.39264011383057) + 0.000301785812013682*std::sin(0.206160008907318*x_108 - 4.39903974533081) + 0.012230161611139*std::sin(0.20584000647068*x_109 + 5.18096017837524) + 0.00091571639019807*std::sin(0.102400071918964*x_11 - 4.28399991989136) - 0.0233754413495977*std::sin(0.175360009074211*x_11 + 5.18400001525879) - 0.00161588045813986*std::sin(0.283119946718216*x_11 - 7.42775964736938) + 0.00387723417946115*std::sin(0.282959938049316*x_112 - 7.43111991882324) + 0.00209541331244321*std::sin(0.323279827833176*x_112 - 1.34607982635498) + 0.000246002186135191*std::sin(0.254479974508286*x_113 - 4.22528028488159) + 0.00667975835422004*std::sin(0.287439942359924*x_113 - 7.42911958694458) + 0.00210240444709209*std::sin(0.2880799472332*x_113 - 7.42679977416992) - 0.00113847181998655*std::sin(0.233999982476234*x_114 + 1.97791981697083) - 0.00316813979344358*std::sin(0.241119980812073*x_114 - 1.23959982395172) - 0.000503740837922958*std::sin(0.233519986271858*x_116 + 1.79903984069824) - 0.105866770478662*std::sin(0.251039981842041*x_116 + 5.16688013076782) + 0.00042473351887073*std::sin(0.262319952249527*x_116 - 1.23943984508514) + 1.44446513028665e-5*std::sin(1.02279984951019*x_116 + 8.39000034332275) - 0.00643633464642701*std::sin(0.218319997191429*x_118 - 4.21447992324829) + 0.0016871969075578*std::sin(0.235759988427162*x_119 + 5.17343997955322) - 0.00144135369813065*std::sin(0.298639953136444*x_12 + 5.12664031982422) + 8.89555456008119e-5*std::sin(0.539439857006073*x_12 + 7.83392000198364) + 0.000277980617527972*std::sin(0.179840013384819*x_13 + 1.59295988082886) + 0.0487588780534863*std::sin(0.232399985194206*x_13 - 7.40807962417603) - 0.000728417670320509*std::sin(0.295279920101166*x_13 - 4.40863990783691) - 0.00176085444884877*std::sin(0.121120058000088*x_14 - 1.25951981544495) + 0.0375092594246979*std::sin(0.303039938211441*x_14 - 7.43951988220215) + 0.000123730104707282*std::sin(0.442319840192795*x_14 - 1.44655990600586) + 0.00078964510628476*std::sin(0.53143984079361*x_14 - 1.31679975986481) + 9.21154452197652e-6*std::sin(0.538719832897186*x_14 + 1.86799991130829) - 0.00114968847774279*std::sin(0.244799971580505*x_15 - 1.17535984516144) - 0.000479378474104436*std::sin(0.267919957637787*x_15 + 1.98791980743408) - 0.000119474991393684*std::sin(0.270559966564178*x_15 + 1.77759981155396) + 0.0447438956323392*std::sin(0.29615992307663*x_15 + 5.17063999176025) + 1.02887919562671e-5*std::sin(0.502879858016968*x_15 + 8.08672046661377) - 0.00126640330537086*std::sin(0.314639925956726*x_16 + 1.9968798160553) + 0.00075018691693326*std::sin(0.387599855661392*x_16 - 1.18503987789154) + 1.36333050906944e-5*std::sin(0.51095986366272*x_16 + 8.10847949981689) - 2.22412120702513e-5*std::sin(0.27975994348526*x_17 - 7.37399959564209) - 0.00171767393618755*std::sin(0.344799846410751*x_17 + 1.99871981143951) + 0.000685472327536367*std::sin(0.380239844322205*x_17 - 1.1743198633194) + 0.00117333307345484*std::sin(0.383119851350784*x_17 + 1.99287974834442) + 0.0117125987145469*std::sin(0.428399860858917*x_17 - 1.20383989810944) + 0.00212528746720878*std::sin(0.606959879398346*x_17 + 5.00175952911377) + 0.0345867601393822*std::sin(0.314559936523438*x_18 - 1.15207993984222) - 0.0630681330592552*std::sin(0.374319821596146*x_18 + 2.02303981781006) - 0.000180567815233197*std::sin(0.51775985956192*x_18 + 2.0559196472168) - 6.80073039370385e-5*std::sin(0.524639844894409*x_18 + 2.05535984039307) - 0.0021832722815746*std::sin(0.222240000963211*x_19 + 8.1947193145752) - 0.0663622487903577*std::sin(0.25655996799469*x_19 + 8.21303939819336) - 0.0038088965655507*std::sin(0.39319983124733*x_19 - 1.2047199010849) + 0.119690260667773*std::sin(0.365679860115051*x_2 + 5.18024015426636) - 0.07205097388897*std::sin(0.377919852733612*x_2 + 5.17736005783081) + 0.000623734667523596*std::sin(0.388719856739044*x_2 + 5.18279981613159) - 0.00195263068542055*std::sin(0.399199843406677*x_2 + 5.20344018936157) - 0.000457871001378222*std::sin(0.409279853105545*x_2 - 1.17679977416992) - 0.000113319106827311*std::sin(0.337519854307175*x_20 - 7.79392004013062) + 0.000975120604255026*std::sin(0.415519863367081*x_20 + 7.59352016448975) - 0.000100279556301693*std::sin(0.317199915647507*x_21 - 1.19207990169525) + 0.00355423516493387*std::sin(0.340239852666855*x_21 + 2.04071974754333) - 0.00549709339429565*std::sin(0.317359924316406*x_22 + 8.25111961364746) - 0.000600978746722612*std::sin(0.399679869413376*x_22 + 2.00927972793579) - 0.000138643812935118*std::sin(0.482559859752655*x_22 + 4.98415994644165) + 0.112405820680435*std::sin(0.275279939174652*x_23 - 1.15063989162445) + 0.0186224257486482*std::sin(0.319999933242798*x_23 - 1.16799986362457) + 0.000138090778810482*std::sin(0.354399859905243*x_23 - 1.39335989952087) + 0.00974957726324396*std::sin(0.366559833288193*x_23 - 7.36911964416504) + 0.000331913190698168*std::sin(0.832639873027802*x_23 - 7.78951978683472) + 0.0221582002977614*std::sin(0.386879861354828*x_24 - 1.19351994991302) + 0.0257383695082695*std::sin(0.442479848861694*x_24 - 1.21311986446381) + 4.94412053084499e-5*std::sin(0.827359914779663*x_24 + 1.80167984962463) - 0.00058457781126734*std::sin(0.261439979076385*x_25 - 7.37575960159302) + 0.00116031344571763*std::sin(0.338639855384827*x_25 - 1.14871978759766) - 0.0277864382390655*std::sin(0.284159928560257*x_26 + 1.98807990550995) + 0.000149426931806606*std::sin(0.304559946060181*x_26 - 1.17807984352112) + 0.000821800555328571*std::sin(0.783759832382202*x_26 - 1.39231991767883) + 0.000203647757012579*std::sin(0.285999923944473*x_27 - 7.39047956466675) + 0.00208903425930067*std::sin(0.463919848203659*x_27 + 4.5776801109314) + 0.00320962428903703*std::sin(0.0912800803780556*x_28 + 2.02471995353699) - 0.00113219219394173*std::sin(0.805839836597443*x_28 + 4.79120016098022) - 0.00288990891073424*std::sin(0.323039919137955*x_29 + 4.80983972549438) - 0.0022269261956937*std::sin(0.377759844064713*x_29 - 1.18191993236542) + 0.00063287358150219*std::sin(0.856159865856171*x_29 - 5.43487977981567) - 0.0151541048262442*std::sin(0.2743199467659*x_3 - 1.15183985233307) + 0.000845471646409206*std::sin(0.2882399559021*x_3 - 1.13159990310669) - 0.00216314763720823*std::sin(0.316159933805466*x_3 + 8.28087997436523) + 0.00540213891908093*std::sin(0.344079852104187*x_3 - 7.40455961227417) - 0.00109302074668393*std::sin(0.348319828510284*x_3 + 1.97527980804443) + 0.00970331653467308*std::sin(0.359439849853516*x_3 - 7.39336013793945) + 0.000654534757686837*std::sin(0.372479856014252*x_3 + 5.19831991195679) + 5.01502212554557e-5*std::sin(0.396399825811386*x_3 - 7.40655994415283) + 0.0117892589107912*std::sin(0.259519964456558*x_30 + 1.99079978466034) + 0.086288172924356*std::sin(0.266159951686859*x_30 - 1.1651998758316) - 0.00123797840700852*std::sin(0.284959942102432*x_30 - 1.16359984874725) + 0.0490899632184882*std::sin(0.304079920053482*x_30 - 1.16567981243134) - 0.000796858343046433*std::sin(0.308239936828613*x_30 + 2.00159978866577) - 0.0919837422759627*std::sin(0.312719941139221*x_30 + 1.99159979820251) - 2.370823800932e-5*std::sin(0.765519857406616*x_30 - 7.37951993942261) + 2.17114983010013e-5*std::sin(0.293119937181473*x_31 - 1.07175981998444) - 0.000166018831714593*std::sin(0.309599936008453*x_31 - 4.056960105896) - 0.00154556476338448*std::sin(0.340319842100143*x_31 - 1.01967978477478) - 0.01205991759325*std::sin(0.350399851799011*x_31 + 5.15687990188599) - 0.00284359203040401*std::sin(0.375759840011597*x_31 - 7.39991998672485) + 0.00231197126000039*std::sin(0.386079847812653*x_31 - 7.39783954620361) - 6.01963819216297e-5*std::sin(0.396079838275909*x_31 + 8.38568019866943) + 0.0457873053444072*std::sin(0.405199855566025*x_31 + 5.19992017745972) - 9.46327525377686e-5*std::sin(0.285679936408997*x_32 + 8.2425594329834) - 0.0704241486613291*std::sin(0.302159935235977*x_32 - 1.14591991901398) + 0.0230909847345614*std::sin(0.30839991569519*x_32 - 1.14823985099792) - 0.00054879800306022*std::sin(0.213440001010895*x_33 + 1.971599817276) - 0.0327922867040657*std::sin(0.233039990067482*x_33 + 1.9968798160553) - 0.0648434521644637*std::sin(0.233519986271858*x_33 - 1.17975986003876) - 0.00183906852248056*std::sin(0.225599989295006*x_34 + 1.77711987495422) + 0.00116006380300487*std::sin(0.179120019078255*x_35 + 8.19151973724365) + 0.00116221270354502*std::sin(0.179520010948181*x_35 + 8.40520000457764) - 0.00114320075602161*std::sin(0.291999936103821*x_37 + 4.77928018569946) + 2.42735507175978e-6*std::sin(0.538559854030609*x_37 - 0.706639885902405) - 0.0394765468905924*std::sin(0.178640007972717*x_4 + 8.1755199432373) - 0.000872288316902138*std::sin(0.249199971556664*x_4 - 7.36111974716187) - 0.000334277575340306*std::sin(0.375919848680496*x_4 + 1.9793598651886) + 0.0058288163982772*std::sin(0.772719860076904*x_4 + 8.20959949493408) - 2.29005012787482e-5*std::sin(0.862319886684418*x_4 + 7.99488019943237) - 0.000174554723019922*std::sin(0.16312001645565*x_40 + 5.19856023788452) - 0.00671516183177367*std::sin(0.171840012073517*x_41 - 1.20207989215851) + 2.14829536803941e-5*std::sin(0.697999835014343*x_42 + 4.62016010284424) + 0.000479908655487137*std::sin(0.459839850664139*x_44 - 1.4592798948288) + 0.000346830242914279*std::sin(0.576399862766266*x_45 + 5.03351974487305) - 0.000175156845632821*std::sin(0.665839850902557*x_47 + 7.57984018325806) + 0.000146307877296766*std::sin(0.228719994425774*x_48 - 7.5971999168396) - 0.00158929745964672*std::sin(0.467279851436615*x_49 - 1.34599983692169) - 0.004678716970098*std::sin(0.254319965839386*x_5 - 7.56360006332397) + 0.00420613409423858*std::sin(0.265679955482483*x_5 + 2.00615978240967) - 0.184553740091211*std::sin(0.350159853696823*x_5 - 1.14927983283997) - 0.00128427775769632*std::sin(0.359199851751328*x_5 + 2.00079965591431) - 0.0215567370938231*std::sin(0.386959850788116*x_5 - 7.39559984207153) + 0.00165198528423996*std::sin(0.209279999136925*x_50 + 8.17591953277588) + 0.00166878110997827*std::sin(0.16872002184391*x_51 + 8.20335960388184) - 0.00035977475200517*std::sin(0.255279958248138*x_52 - 1.2079998254776) + 0.00173121095671735*std::sin(0.233999982476234*x_53 - 7.42159986495972) - 0.00489285096230727*std::sin(0.20024000108242*x_54 + 5.00152015686035) - 0.0124926409086106*std::sin(0.5655198097229*x_54 + 4.83576011657715) - 2.25729207862632e-5*std::sin(0.169280022382736*x_57 + 1.61479985713959) - 0.00340578501246763*std::sin(0.29351994395256*x_57 - 1.42783987522125) - 0.00710432314749144*std::sin(0.48447984457016*x_58 + 4.6911997795105) - 0.00296470918601436*std::sin(0.359359860420227*x_59 + 4.64055967330933) + 0.00196460095757821*std::sin(0.606719851493835*x_59 - 7.81207990646362) + 0.125461406779774*std::sin(0.342959851026535*x_6 + 2.01183986663818) - 0.000529837797959601*std::sin(0.344479858875275*x_6 + 2.01703977584839) + 0.0380344698648726*std::sin(0.366239845752716*x_6 + 1.99223983287811) + 0.000327625171676269*std::sin(0.367599844932556*x_6 - 1.16799986362457) + 0.0376876431247979*std::sin(0.378479838371277*x_6 + 1.99007987976074) - 0.0011452039979461*std::sin(0.38351982831955*x_6 - 1.17855989933014) + 0.00150521147932805*std::sin(0.452159851789474*x_60 - 7.48456001281738) - 0.000443489810741741*std::sin(1.41623985767365*x_64 + 6.79663991928101) - 1.01028208817944e-5*std::sin(1.77119994163513*x_64 + 3.59479999542236) - 0.0123818910648666*std::sin(0.322959840297699*x_7 - 7.339439868927) + 0.00102459839413606*std::sin(0.330399841070175*x_7 - 1.15071988105774) + 0.0614718062865213*std::sin(0.354959845542908*x_7 + 2.00631976127625) - 0.059905710939377*std::sin(0.359199851751328*x_7 - 1.15143990516663) - 0.000546771854065217*std::sin(0.376479834318161*x_7 + 2.02695989608765) - 0.000260541797500492*std::sin(0.480159848928452*x_7 + 1.93423986434937) - 1.2480374155864e-5*std::sin(1.0732798576355*x_70 + 2.81663990020752) + 1.0457906423506e-5*std::sin(1.18463981151581*x_70 - 9.6071195602417) + 0.000378153634782981*std::sin(0.909999787807465*x_72 + 7.97391986846924) + 0.000558364671357711*std::sin(1.2240799665451*x_73 - 0.783519864082336) - 0.000278483785205005*std::sin(1.13831984996796*x_75 - 2.37199997901917) + 1.10822961415233e-6*std::sin(1.22527992725372*x_75 + 3.99287986755371) - 0.000369441354878396*std::sin(1.41495978832245*x_77 + 1.97983980178833) - 0.00021880571484009*std::sin(0.803119838237762*x_78 + 3.78615999221802) - 3.38008118757903e-5*std::sin(0.295279920101166*x_8 - 1.19455993175507) + 0.00117032251757984*std::sin(0.314959913492203*x_8 + 5.15392017364502) - 0.000132731800786374*std::sin(0.398239850997925*x_8 - 7.80751991271973) + 4.07057135312033e-5*std::sin(0.451759845018387*x_8 + 7.95944023132324) - 0.000428911494661647*std::sin(0.171200007200241*x_87 + 5.50552034378052) + 0.000131005235210065*std::sin(0.180960014462471*x_88 - 7.25880002975464) - 9.53008862474763e-7*std::sin(1.14111983776093*x_88 - 1.60359990596771) - 0.000344625109452916*std::sin(0.376639842987061*x_9 - 4.38687992095947) + 1.59533026126429e-5*std::sin(0.485359847545624*x_9 - 4.47983980178833) + 0.000114670400490364*std::sin(1.79071986675262*x_90 - 2.39239978790283) - 0.00726752220755216*std::sin(0.329519838094711*x_91 - 4.20544004440308) + 0.00258449657096378*std::sin(0.370879858732224*x_91 + 5.18943977355957) + 0.000899826525412934*std::sin(0.388959854841232*x_91 + 1.971599817276) - 0.00125518645893445*std::sin(0.417119860649109*x_91 + 8.21047973632813) + 0.00049677747025081*std::sin(0.227119997143745*x_92 + 2.01871991157532) - 0.0131088708509411*std::sin(0.239759981632233*x_92 + 5.19600009918213) + 0.0161883586664862*std::sin(0.253919988870621*x_92 + 2.02055978775024) - 0.0311171517687543*std::sin(0.285359919071198*x_92 + 1.99703979492188) - 0.00623373887348693*std::sin(0.321039855480194*x_92 - 1.1814398765564) + 0.0068832880510295*std::sin(0.327039837837219*x_92 + 8.22480010986328) - 3.64868267847956e-5*std::sin(0.257679969072342*x_94 - 7.39807987213135) + 0.000475911574432576*std::sin(0.275759935379028*x_94 + 1.97855985164642) - 0.00904274722835225*std::sin(0.287839949131012*x_94 + 1.97927987575531) - 0.00265994435956291*std::sin(0.310879945755005*x_94 + 1.79847991466522) - 0.00301272766420388*std::sin(0.253759980201721*x_95 - 7.40999984741211) + 0.00971956538278945*std::sin(0.262319982051849*x_96 - 1.20431983470917) - 0.00257884594483371*std::sin(0.30447992682457*x_96 - 4.41775989532471) + 0.00021744516109519*std::sin(0.273119956254959*x_97 + 1.96655988693237) - 0.000102946441469931*std::sin(0.27991995215416*x_97 + 1.97735977172852) - 0.00437261000537524*std::sin(0.261359959840775*x_98 - 4.42471981048584) + 0.149376064538956*std::sin(0.0020643035890737*x_1 + 0.00328576692789305*x_10 + 0.00214276278718576*x_100 + 0.00154438913571254*x_101 - 0.000623422018591967*x_102 - 4.54348674170697e-5*x_103 - 0.00117322089852032*x_104 - 0.00160165038297009*x_105 + 0.000748336626074375*x_106 + 0.000488324087215054*x_107 + 0.00863488524158018*x_108 + 0.00563307917592418*x_109 + 0.00686474350930956*x_11 + 0.00144318396928728*x_110 + 0.00121994646981523*x_111 + 0.00238464702746565*x_112 + 1.61847067126113e-5*x_114 + 0.00291861967049653*x_115 + 0.000960925127447089*x_117 + 0.000368163321607871*x_118 + 0.00651552326207148*x_119 + 0.00257464855276627*x_120 + 0.00925973094127114*x_15 + 0.000106183195770068*x_16 + 0.00130702329820506*x_17 + 0.00303117381225525*x_18 - 0.00102162152029907*x_2 - 0.000708194494221476*x_20 - 0.000210944091270087*x_21 + 2.92104256084934e-6*x_22 + 0.000963172660785396*x_23 + 0.000213361326330405*x_24 - 0.00118523085607104*x_25 + 0.00153352398197154*x_26 - 0.00278672684050385*x_27 - 0.0019523419021752*x_28 - 0.0017861853787896*x_29 - 0.00355471276849516*x_3 + 0.000638634285505406*x_30 - 0.00197263732600432*x_32 + 0.00467364900607552*x_33 + 0.00063548728939407*x_34 + 0.000378509580117891*x_35 - 0.00387107495954825*x_37 + 0.000498494859063679*x_38 - 0.000845932462977108*x_39 + 0.000261393475637803*x_4 - 0.000672097633903463*x_40 - 0.00213361880631856*x_41 + 0.000806746848189277*x_42 + 0.00118702868435506*x_43 - 0.00104862158856862*x_44 + 0.000116528318613778*x_45 + 0.0025457462632907*x_46 + 0.000133812493244172*x_47 + 0.00499804453303537*x_48 - 0.00250446202334445*x_49 + 0.00107424379223823*x_5 - 0.00190102777453878*x_51 + 0.000377070996931677*x_52 + 0.00161840672512185*x_53 - 0.000693033966752091*x_54 - 0.000263907035709436*x_55 - 0.000945950308410495*x_57 + 0.00390079165151001*x_58 + 0.00187590849921164*x_59 + 0.00142118315651559*x_6 + 8.54226475802324e-5*x_60 - 0.000304275332764806*x_61 - 0.000305275105793919*x_62 - 0.000592987114686889*x_63 + 0.000520103968811156*x_64 - 0.000135716418305409*x_65 - 0.00173467577762335*x_66 - 0.000271142401403121*x_67 - 0.000418139933737536*x_68 - 0.0010902721873384*x_69 + 0.00126191828231845*x_7 + 0.000294053599628429*x_70 + 0.000420430944142649*x_71 + 0.000180502885445304*x_72 - 0.000554535024204783*x_73 - 0.000229751496610496*x_74 - 0.000451806785238291*x_75 - 0.000139096047926122*x_76 - 0.00287423413682485*x_77 - 0.00168945475396529*x_78 - 0.000293963592769854*x_79 - 0.000860497000840135*x_80 + 0.000454922070929028*x_81 + 0.000705965296950602*x_82 - 0.00139090563176*x_83 + 0.00121656346351821*x_84 + 0.000447550261788394*x_85 + 0.000762704606459701*x_86 + 0.000377218881754974*x_87 - 5.20673719571135e-5*x_88 + 0.00131789501385365*x_89 + 0.00082109852473955*x_90 - 0.00105707482527021*x_91 + 0.01118977594264*x_92 + 0.00376714697196286*x_93 - 0.000518130733212105*x_94 - 0.00144540909414282*x_95 - 0.000258680394414749*x_96 - 9.4391249759863e-5*x_97 + 0.000546600989878039*x_98 + 0.00111542410198862*x_99 + 0.00597294176572591*std::exp(0.356479853391647*x_19) - 0.0819141693399281*std::sin(0.283679932355881*x_113 + 1.96335983276367) + 0.111366511931791*std::sin(0.227039992809296*x_116 + 5.1735200881958) + 0.201579517626293*std::sin(0.276479959487915*x_12 - 7.43616008758545) + 0.217950539418613*std::sin(0.305279940366745*x_13 + 5.13495969772339) + 0.0717168135820554*std::sin(0.243039980530739*x_14 - 1.1814398765564) - 0.0136763130311985*std::sin(0.613279819488525*x_31 + 5.1956000328064) - 0.0289500607761859*std::sin(0.1893600076437*x_36 - 7.60423994064331) - 0.0108279532764621*std::sin(0.224399983882904*x_50 + 4.37063980102539) - 0.0158112072602556*std::sin(0.337999850511551*x_56 + 1.85591995716095) - 0.0329123141971563*std::sin(0.307679921388626*x_8 + 2.11904001235962) - 0.0346542497329176*std::sin(0.452639847993851*x_9 - 4.27943992614746) + 9.31730209027565) + 0.102575100958347*std::sin(0.00178331343182657*x_10 - 0.00430674030415107*x_100 + 0.00393072476615119*x_101 + 0.00874050264884603*x_102 - 0.00497388448484487*x_103 - 0.00523506412456582*x_104 + 0.00989388166551512*x_105 + 0.000268327991542841*x_106 + 0.00323255928978691*x_107 + 0.011927294287287*x_108 + 0.0131107092784303*x_109 - 0.00384179109861778*x_11 - 0.0113818128443959*x_110 + 0.000984254087817962*x_111 + 0.0238281817813947*x_112 + 0.0437338419202638*x_113 + 0.00212914752320199*x_114 + 0.00249805912140165*x_115 + 0.00100327452546466*x_117 + 0.00429116931260462*x_118 - 0.00278693002825114*x_12 + 0.000609268950720065*x_120 + 0.000657647933266549*x_13 - 0.003358417364422*x_17 - 0.00302673207558648*x_2 + 0.00635412803431424*x_20 + 0.00276179283472162*x_21 - 0.00120439717499593*x_24 + 5.6899772427972e-5*x_29 - 0.000842073724814066*x_3 - 0.00113496531055642*x_32 + 0.0172737353179094*x_33 + 0.0182769223644021*x_34 - 0.0033645792611415*x_35 + 0.00229095266898013*x_36 - 0.00217575229051946*x_37 + 0.000861498026569735*x_38 + 0.002794227174251*x_39 - 0.00337181927513216*x_4 - 0.00135765288425916*x_40 + 0.0013876221405648*x_41 + 0.00277080860801147*x_42 - 0.00174237702687841*x_43 + 0.00469859060281974*x_44 + 0.00815938111110958*x_45 + 0.00340463797334122*x_46 + 0.00333136191197528*x_47 + 0.00744663623382502*x_48 - 0.000309913960286613*x_49 - 0.0031528115088323*x_50 - 0.00164625321468445*x_51 + 0.00194522812072231*x_52 + 0.000797042534766944*x_53 - 0.00248219103922028*x_55 + 0.00206094746251482*x_56 - 0.0118183164247418*x_57 - 0.00711785043893654*x_59 - 0.0040090185235505*x_61 - 0.00987390593920284*x_62 - 0.00275854754710509*x_63 + 0.000914719468919271*x_64 + 0.00643501787969483*x_65 + 0.00131089408684727*x_66 + 0.00298388529740423*x_67 + 0.0079157532735468*x_68 - 0.000487140836440843*x_69 - 0.000433783779473056*x_70 + 0.000511141983874829*x_71 - 0.00239001880007328*x_72 - 0.00193011848131855*x_73 - 0.00628159812445932*x_74 - 0.000386873688610955*x_75 + 0.00123145054275596*x_76 - 0.00510617024855869*x_77 - 0.0045005083093786*x_78 + 0.00165514495164243*x_79 - 0.00218384208693994*x_8 - 0.00591225871818598*x_80 - 0.00700450193610809*x_81 + 0.000513239916147866*x_82 + 2.37486028076051e-5*x_83 - 0.000721299144076567*x_84 - 0.00732029255254175*x_85 - 0.00482543048029517*x_86 + 0.000756694098437589*x_87 - 0.00222586644196124*x_88 + 0.000277220518951893*x_89 - 0.00302039791979518*x_9 + 0.00230843347103243*x_90 - 0.0154619777086122*x_91 + 0.00561479980555196*x_93 - 0.00420970534105822*x_95 - 0.0138885352456888*x_96 - 0.00231525902835496*x_97 + 0.00215379056811217*x_98 - 0.0225241666763708*x_99 + 0.0555105419747415*std::exp(0.173759862780571*x_14) + 0.0216138967159017*std::exp(0.326959848403931*x_22) - 0.00537467555586786*std::exp(0.310879856348038*x_28) - 0.0162811709517859*std::exp(0.321919828653336*x_30) + 0.350138414740471*std::sin(0.348479837179184*x_1 + 5.15775966644287) - 0.280053886306675*std::sin(0.209199994802475*x_116 + 2.000159740448) + 0.225325678595496*std::sin(0.226719990372658*x_119 + 5.18576002120972) + 0.581638390780341*std::sin(0.316639930009842*x_15 + 5.14856004714966) - 0.187734508067194*std::sin(0.297039926052094*x_16 + 2.00455975532532) + 0.197413526085981*std::sin(0.431999862194061*x_18 - 7.42375993728638) - 0.234611089888901*std::sin(0.257999986410141*x_19 + 8.2061595916748) - 0.161267867487354*std::sin(0.370399862527847*x_23 + 1.99191975593567) - 0.0639318661733768*std::sin(0.324319839477539*x_25 - 1.13855993747711) + 0.246816994978616*std::sin(0.152400031685829*x_26 + 8.14935970306396) - 0.0759555684490998*std::sin(0.367839843034744*x_27 + 5.23767995834351) + 0.0738791604732114*std::sin(0.376639842987061*x_31 - 4.22408008575439) + 0.0130044946146457*std::sin(0.685359835624695*x_5 - 4.65687990188599) + 0.0341248940115335*std::sin(0.589199841022491*x_54 + 1.78703987598419) + 0.0439939912034415*std::sin(0.299759924411774*x_58 + 1.87479984760284) - 0.268870851748346*std::sin(0.323439925909042*x_6 + 2.01247978210449) + 0.0896034073419116*std::sin(0.358639866113663*x_60 + 8.24847984313965) - 0.746791143589292*std::sin(0.26079997420311*x_7 + 2.03239989280701) - 0.697326200049702*std::sin(0.303839921951294*x_92 + 1.98935985565186) + 0.141571720891527*std::sin(0.285999953746796*x_94 - 1.19919991493225) + 10.2823661696512) + 0.136882333852405);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000590024442304451*x_1 + 0.00138346916745334*x_10 + 0.000192009517701599*x_100 - 2.41969656425337e-5*x_101 - 0.000529774332656925*x_102 - 0.000282217215207103*x_103 - 0.000527416119527142*x_104 - 0.00192375508065112*x_105 - 0.00039175871673082*x_106 + 7.78437398445427e-6*x_107 + 0.0017058815301928*x_108 + 0.00156884675983492*x_109 + 0.0024699130656085*x_11 - 0.000149394994500272*x_110 + 0.000585579201378045*x_111 + 0.00141445858362388*x_112 - 0.000371032878105886*x_113 - 0.00538455944414651*x_114 - 0.000778338975530173*x_115 - 0.00103190667220145*x_116 - 0.00972076389785686*x_117 - 0.000336160207220356*x_118 - 0.0106235384371992*x_119 + 0.000564643096420539*x_12 - 0.0120547970423154*x_120 + 0.000536246587116863*x_13 + 0.000737931199689932*x_14 + 0.00339445288836159*x_15 + 0.000463469636255759*x_16 + 0.000245795564324375*x_17 + 0.000640541435833092*x_18 + 0.000206712771425712*x_19 - 0.000226156182584297*x_2 - 0.000162720049407932*x_20 + 0.00110808883637074*x_21 + 9.24394280302238e-5*x_22 + 0.000295684066282909*x_23 + 8.15653200809125e-5*x_24 - 0.000505286856378989*x_25 + 0.000982583912208363*x_26 - 0.00022245848996723*x_27 - 0.000220026504443413*x_28 - 0.000149031060163231*x_29 - 0.000943409883317664*x_3 + 0.000107722018954857*x_30 - 0.00125243136789991*x_31 - 0.00120754643002429*x_32 - 0.000561353450756227*x_33 - 0.00092102437189598*x_34 - 1.80738887633912e-5*x_35 - 0.000273259318889421*x_36 - 0.00144315105610811*x_37 - 0.000761030654906774*x_38 - 0.00019875109792186*x_39 + 0.000178146440765813*x_4 - 5.54933814932855e-5*x_40 - 0.000896874581951197*x_41 + 0.00014636646987488*x_42 - 0.000384334690397264*x_43 - 0.000564442792659615*x_44 - 0.000102997533993206*x_45 - 0.000562966431653314*x_46 - 0.00028160513403606*x_47 - 0.00448798789009984*x_48 - 0.00111186350621631*x_49 + 0.000353250725986487*x_5 - 0.000237580563278773*x_50 + 0.000867081220131542*x_51 + 0.000383080633665948*x_52 + 0.000284584588959862*x_53 - 0.00165721671490148*x_54 - 0.00175358685562152*x_55 - 0.000568986113839715*x_56 - 0.00196619692275298*x_57 + 0.000404927207372958*x_58 - 0.000544527127708442*x_59 + 0.00140685454764609*x_6 - 0.000914869809876711*x_60 + 0.000328845916243366*x_61 - 2.24370008765218e-5*x_62 - 0.000142216296395993*x_63 - 0.000110908918101784*x_64 + 0.000104060839237227*x_65 - 0.000255680734952596*x_66 - 0.00018465691249937*x_67 + 1.28379027328687e-5*x_68 - 0.000126241347105375*x_69 + 0.00152301769258996*x_7 + 0.000132526649261869*x_70 + 0.000274794074020491*x_71 - 1.6012786296292e-5*x_72 + 6.0196523072751e-5*x_73 - 0.000596450506027174*x_74 - 0.000617827306647313*x_75 - 9.70177604171311e-5*x_76 - 0.000935407242390146*x_77 - 0.000308013088370542*x_78 + 0.00037369706929154*x_79 + 0.000670650067524503*x_8 + 9.03527828194934e-5*x_80 + 0.000635920942158626*x_81 + 0.0003194672774227*x_82 - 0.000459497746146515*x_83 + 0.000140987577586712*x_84 + 0.000248519815737969*x_85 + 0.000154805324668122*x_86 + 0.000363870041112408*x_87 - 0.00037480436699493*x_88 + 0.000298299094283726*x_89 - 0.000245163176594271*x_9 + 0.000290355012048486*x_90 - 0.000557975818774424*x_91 + 0.00305630818134776*x_92 - 0.000921594698555087*x_93 - 0.000342740177483008*x_94 - 0.000101739301734921*x_95 - 0.000243826913129404*x_96 - 0.000340633743470422*x_97 - 0.000253897094162346*x_98 - 0.000116941321107289*x_99 + 2.21095473706371e-7*std::pow(2.4696798324585 - 7.17983961105347*x_59, 2) - 1.50896910389942e-7*std::pow(5.30704021453857 - 8.17615985870361*x_15, 2) - 8.93105997076036e-6*std::pow(5.54383993148804 - 0.991999804973602*x_10, 2) + 9.11923730631079e-6*std::pow(-2.62831997871399*x_16 - 9.89848041534424, 2) - 6.37032003937266e-7*std::pow(-3.71199989318848*x_25 - 8.0, 2) + 9.49119889949293e-8*std::pow(-9.3261604309082*x_28 - 1.61375975608826, 2) + 3.14612396779726e-7*std::pow(-5.89263963699341*x_60 - 9.60136032104492, 2) + 2.48522024216147e-7*std::pow(-3.8724000453949*x_61 - 6.51895952224731, 2) - 1.59392130271952e-6*std::pow(-2.83240008354187*x_64 - 9.11664009094238, 2) + 1.17022609028512e-5*std::pow(-2.76160001754761*x_64 - 6.32287979125977, 2) + 1.98833926465162e-7*std::pow(-3.67159986495972*x_9 - 7.73672008514404, 2) + 0.0022124582901597*std::pow(0.0301202546717372*x_10 + 0.0107690991613438*x_100 + 0.0395509002168744*x_101 - 0.0151702407236893*x_102 - 0.0272148963001085*x_103 - 0.0327407663958585*x_104 - 0.0291346559508213*x_105 - 0.0302383771133353*x_106 + 0.00817836985939837*x_107 + 0.013251898645282*x_108 + 0.0238655549137132*x_109 + 0.0146704547190886*x_11 - 0.0141458407292954*x_110 - 0.00683881257533822*x_111 + 0.00396471072518188*x_112 + 0.0125210307853724*x_113 - 0.00432923904451358*x_114 + 0.013887156533935*x_115 + 0.0417023528551798*x_116 + 0.00171181323259675*x_117 + 0.00233214190230084*x_118 + 0.0100135006125008*x_119 - 0.0571898792109347*x_12 + 0.00554258447001399*x_120 - 0.00207973676327311*x_18 - 0.0253015244558541*x_19 - 0.00677774464197346*x_2 - 0.0449496977249583*x_20 - 0.070893491710434*x_21 - 0.0274614986748995*x_22 + 0.205202058593723*x_23 - 0.0259216359788497*x_24 - 0.0879541792021848*x_25 - 0.0213776618421761*x_26 + 0.0210514215359311*x_27 - 0.0220323591613748*x_28 - 0.0100842130615872*x_29 - 0.00719039152394143*x_30 - 0.147383960525869*x_33 + 0.0292421805195961*x_34 + 0.00197366733655367*x_35 + 0.0686834646760454*x_36 - 0.0448316483356317*x_38 + 0.0124991067378799*x_39 - 0.0206979222063602*x_4 - 0.00239262278121438*x_40 + 0.0366238362578213*x_41 - 0.00430815647697491*x_42 - 0.012370081506206*x_43 - 0.0228915898214553*x_44 + 0.00948083288337315*x_45 - 0.0415181063402807*x_46 + 0.00153138452762144*x_47 - 0.0156162405981671*x_48 - 0.001351715399691*x_49 + 0.00661021089899884*x_50 - 0.0269806618674511*x_51 + 0.501070903991231*x_52 + 0.0249612711913952*x_53 - 0.02732789010527*x_54 + 0.0280225412891893*x_55 + 0.00752847926097809*x_56 + 0.0316021225644745*x_58 + 0.0209288196504349*x_59 + 0.0144619353563596*x_60 + 0.00524787507764597*x_61 - 0.0217165065196688*x_62 - 0.0177814791538394*x_63 - 0.0452450688595948*x_64 - 0.0326095917894897*x_65 - 0.0210012125553779*x_66 + 0.0181208414433194*x_67 - 0.00559154528378724*x_68 + 0.0111859796484092*x_69 - 0.0507218764122112*x_7 - 0.00859771807942382*x_70 + 0.00933290536037086*x_71 + 0.00602384511959273*x_72 - 0.0107589852672967*x_73 - 0.0107250889381656*x_74 + 0.0388272845096704*x_76 + 0.00908787324349256*x_77 - 0.0233781985203188*x_78 + 0.000223679524519619*x_79 + 0.0255285234345323*x_80 - 0.0106787526898747*x_81 + 0.00178835636058986*x_82 - 0.0397453384510683*x_83 - 0.0365788297620912*x_84 - 0.0173167852900455*x_85 + 0.0231893932369987*x_86 - 0.00378324268632963*x_87 + 0.00839688232589764*x_89 + 0.0355578106166286*x_90 - 0.00222313511358615*x_91 - 0.027826373654016*x_92 - 0.00423143845945631*x_93 + 0.0541532131460795*x_95 + 0.0455924081356947*x_96 + 0.0381082214702242*x_97 - 0.0367097139798028*x_98 + 0.00928029046335921*x_99 - 0.192526178765873*std::exp(0.253679871559143*x_13) - 0.138177740859118*std::exp(0.370639860630035*x_5) - 0.128061126418479*std::exp(0.324639827013016*x_6) - 10.7078274083301*std::sin(0.337039858102798*x_1 - 4.24552011489868) + 0.246906363520004*std::sin(0.538719832897186*x_14 + 1.86799991130829) + 0.275780918267841*std::sin(0.502879858016968*x_15 + 8.08672046661377) + 0.365427293400288*std::sin(0.51095986366272*x_16 + 8.10847949981689) - 0.596153748097464*std::sin(0.27975994348526*x_17 - 7.37399959564209) + 1.34422720645455*std::sin(0.396399825811386*x_3 - 7.40655994415283) + 0.58195529308702*std::sin(0.293119937181473*x_31 - 1.07175981998444) - 2.53653757448001*std::sin(0.285679936408997*x_32 + 8.2425594329834) + 0.0650628580592745*std::sin(0.538559854030609*x_37 - 0.706639885902405) - 0.60504487299221*std::sin(0.169280022382736*x_57 + 1.61479985713959) + 0.0297050015144276*std::sin(1.22527992725372*x_75 + 3.99287986755371) - 0.905997417085104*std::sin(0.295279920101166*x_8 - 1.19455993175507) - 0.025544462394401*std::sin(1.14111983776093*x_88 - 1.60359990596771) + 0.427612538247459*std::sin(0.485359847545624*x_9 - 4.47983980178833) - 0.977993396908118*std::sin(0.257679969072342*x_94 - 7.39807987213135) + 4.70246100668851, 2) - 7.90554960753638e-5*std::exp(0.208559840917587*x_13) + 5.69334691952809e-5*std::exp(0.541759848594666*x_13) - 0.00361213414377522*std::exp(0.318959832191467*x_18) + 0.000549906143696875*std::exp(0.403919875621796*x_18) - 1.57900480297252e-5*std::exp(0.45007985830307*x_18) + 0.00185756380497177*std::exp(0.356479853391647*x_19) + 0.000871296499035531*std::exp(0.250079840421677*x_20) + 2.0757912174558e-6*std::exp(0.548639833927155*x_22) + 1.09495101460864e-5*std::exp(0.521439850330353*x_26) + 0.000100493340087493*std::exp(0.319119840860367*x_59) - 0.00404323355901989*std::log(5.16136026382446 - 0.59639984369278*x_9) + 0.0902735494435462*std::sin(0.332799851894379*x_1 - 4.25031995773315) + 0.0339665253988541*std::sin(0.344959855079651*x_1 - 4.25184011459351) + 0.0109560675071752*std::sin(0.351919859647751*x_1 - 4.22544002532959) - 0.000234227774714825*std::sin(0.353119850158691*x_1 - 4.22032022476196) + 0.000726974795677268*std::sin(0.358719855546951*x_1 - 4.23680019378662) - 0.000614764757035608*std::sin(0.359119862318039*x_1 - 1.03623986244202) - 0.00251700322543899*std::sin(0.403519839048386*x_1 - 4.18416023254395) + 4.560872491032e-5*std::sin(1.34607982635498*x_100 - 4.97455978393555) - 0.000382450568655014*std::sin(0.225759983062744*x_107 - 4.39264011383057) + 6.65377971035411e-5*std::sin(0.206160008907318*x_108 - 4.39903974533081) - 0.00163078135781408*std::sin(0.20584000647068*x_109 + 5.18096017837524) + 0.00284791192146885*std::sin(0.102400071918964*x_11 - 4.28399991989136) + 0.00311690353698034*std::sin(0.175360009074211*x_11 + 5.18400001525879) - 0.000356269651478555*std::sin(0.283119946718216*x_11 - 7.42775964736938) - 0.0193088271542736*std::sin(0.282959938049316*x_112 - 7.43111991882324) - 0.000279404399998735*std::sin(0.323279827833176*x_112 - 1.34607982635498) + 0.00324559082625111*std::sin(0.254479974508286*x_113 - 4.22528028488159) - 0.0254750175120259*std::sin(0.283679932355881*x_113 + 1.96335983276367) - 0.0332655427874813*std::sin(0.287439942359924*x_113 - 7.42911958694458) + 0.00653855577197607*std::sin(0.2880799472332*x_113 - 7.42679977416992) - 0.00354068956622556*std::sin(0.233999982476234*x_114 + 1.97791981697083) - 7.8465799879578e-5*std::sin(0.241119980812073*x_114 - 1.23959982395172) + 0.0346345920928815*std::sin(0.227039992809296*x_116 + 5.1735200881958) - 0.000111064882218406*std::sin(0.233519986271858*x_116 + 1.79903984069824) + 0.000461073573529295*std::sin(0.251039981842041*x_116 + 5.16688013076782) + 0.00132093698964778*std::sin(0.262319952249527*x_116 - 1.23943984508514) + 6.17690694675264e-5*std::sin(1.02279984951019*x_116 + 8.39000034332275) + 0.0320532801070565*std::sin(0.218319997191429*x_118 - 4.21447992324829) + 0.00524724493121709*std::sin(0.235759988427162*x_119 + 5.17343997955322) + 0.0626905184167256*std::sin(0.276479959487915*x_12 - 7.43616008758545) - 0.000317789955998023*std::sin(0.298639953136444*x_12 + 5.12664031982422) + 0.000192140228700416*std::sin(0.539439857006073*x_12 + 7.83392000198364) + 0.000600426415974003*std::sin(0.179840013384819*x_13 + 1.59295988082886) - 0.0065015550804443*std::sin(0.232399985194206*x_13 - 7.40807962417603) - 1.80408311736751e-5*std::sin(0.295279920101166*x_13 - 4.40863990783691) + 0.0677818484052949*std::sin(0.305279940366745*x_13 + 5.13495969772339) - 0.000388233546383736*std::sin(0.121120058000088*x_14 - 1.25951981544495) + 0.0223036758674548*std::sin(0.243039980530739*x_14 - 1.1814398765564) - 0.00500152025460543*std::sin(0.303039938211441*x_14 - 7.43951988220215) + 0.000384805212631653*std::sin(0.442319840192795*x_14 - 1.44655990600586) + 0.000664585585217588*std::sin(0.53143984079361*x_14 - 1.31679975986481) - 0.000253483548990899*std::sin(0.244799971580505*x_15 - 1.17535984516144) - 0.00149088482625311*std::sin(0.267919957637787*x_15 + 1.98791980743408) - 0.00157627434993879*std::sin(0.270559966564178*x_15 + 1.77759981155396) - 0.000194869719360927*std::sin(0.29615992307663*x_15 + 5.17063999176025) - 0.0167080911548768*std::sin(0.314639925956726*x_16 + 1.9968798160553) + 0.0023331091230136*std::sin(0.387599855661392*x_16 - 1.18503987789154) - 0.0226618586499766*std::sin(0.344799846410751*x_17 + 1.99871981143951) + 0.00213184435085362*std::sin(0.380239844322205*x_17 - 1.1743198633194) - 0.00584325951466795*std::sin(0.383119851350784*x_17 + 1.99287974834442) + 0.00985762364532261*std::sin(0.428399860858917*x_17 - 1.20383989810944) - 9.2561044684034e-6*std::sin(0.606959879398346*x_17 + 5.00175952911377) - 0.00461183142593312*std::sin(0.314559936523438*x_18 - 1.15207993984222) + 0.000274675890782113*std::sin(0.374319821596146*x_18 + 2.02303981781006) - 0.00056157259948681*std::sin(0.51775985956192*x_18 + 2.0559196472168) - 0.000897243578375454*std::sin(0.524639844894409*x_18 + 2.05535984039307) - 0.000481368315905487*std::sin(0.222240000963211*x_19 + 8.1947193145752) + 0.00884880524320861*std::sin(0.25655996799469*x_19 + 8.21303939819336) - 9.43355202611377e-5*std::sin(0.39319983124733*x_19 - 1.2047199010849) - 0.000521277979419107*std::sin(0.365679860115051*x_2 + 5.18024015426636) + 0.00960734524746306*std::sin(0.377919852733612*x_2 + 5.17736005783081) + 0.0082291444101918*std::sin(0.388719856739044*x_2 + 5.18279981613159) - 0.000430516409958896*std::sin(0.399199843406677*x_2 + 5.20344018936157) + 0.00228022131637015*std::sin(0.409279853105545*x_2 - 1.17679977416992) - 0.000244764493937607*std::sin(0.337519854307175*x_20 - 7.79392004013062) - 0.000137344759348434*std::sin(0.415519863367081*x_20 + 7.59352016448975) - 0.000428821350512129*std::sin(0.317199915647507*x_21 - 1.19207990169525) - 0.0177002753222626*std::sin(0.340239852666855*x_21 + 2.04071974754333) + 0.00614432315519205*std::sin(0.317359924316406*x_22 + 8.25111961364746) - 0.00792891777824641*std::sin(0.399679869413376*x_22 + 2.00927972793579) - 0.000299464791602697*std::sin(0.482559859752655*x_22 + 4.98415994644165) - 0.000489552606472182*std::sin(0.275279939174652*x_23 - 1.15063989162445) - 0.0208150368796717*std::sin(0.319999933242798*x_23 - 1.16799986362457) + 0.00042946744147959*std::sin(0.354399859905243*x_23 - 1.39335989952087) - 0.00130001788635282*std::sin(0.366559833288193*x_23 - 7.36911964416504) - 0.00165294489132587*std::sin(0.832639873027802*x_23 - 7.78951978683472) - 0.00295459545975161*std::sin(0.386879861354828*x_24 - 1.19351994991302) - 0.000112096382579151*std::sin(0.442479848861694*x_24 - 1.21311986446381) + 0.000106790919340987*std::sin(0.827359914779663*x_24 + 1.80167984962463) + 0.00291122779629301*std::sin(0.261439979076385*x_25 - 7.37575960159302) + 0.0153084114176424*std::sin(0.338639855384827*x_25 - 1.14871978759766) + 0.00370507004903758*std::sin(0.284159928560257*x_26 + 1.98807990550995) + 0.000638988255067808*std::sin(0.304559946060181*x_26 - 1.17807984352112) + 2.03536592825812e-5*std::sin(0.783759832382202*x_26 - 1.39231991767883) + 0.0026867943831337*std::sin(0.285999923944473*x_27 - 7.39047956466675) - 9.09821360192548e-6*std::sin(0.463919848203659*x_27 + 4.5776801109314) - 0.0159840953005803*std::sin(0.0912800803780556*x_28 + 2.02471995353699) - 0.000952882004587774*std::sin(0.805839836597443*x_28 + 4.79120016098022) - 0.00243222149973439*std::sin(0.323039919137955*x_29 + 4.80983972549438) + 0.00248912528997658*std::sin(0.377759844064713*x_29 - 1.18191993236542) - 8.9139609367404e-5*std::sin(0.856159865856171*x_29 - 5.43487977981567) - 0.000375324017933491*std::sin(0.2743199467659*x_3 - 1.15183985233307) + 0.0111545960731143*std::sin(0.2882399559021*x_3 - 1.13159990310669) - 0.000476931230229737*std::sin(0.316159933805466*x_3 + 8.28087997436523) - 0.0269029317869071*std::sin(0.344079852104187*x_3 - 7.40455961227417) - 0.00236087873806749*std::sin(0.348319828510284*x_3 + 1.97527980804443) - 0.0108457885267181*std::sin(0.359439849853516*x_3 - 7.39336013793945) + 0.0020356273616866*std::sin(0.372479856014252*x_3 + 5.19831991195679) - 0.058711120362888*std::sin(0.259519964456558*x_30 + 1.99079978466034) - 0.000375804381900604*std::sin(0.266159951686859*x_30 - 1.1651998758316) - 0.00385015874082801*std::sin(0.284959942102432*x_30 - 1.16359984874725) + 0.0413153727848266*std::sin(0.304079920053482*x_30 - 1.16567981243134) - 0.0105132241653815*std::sin(0.308239936828613*x_30 + 2.00159978866577) + 0.0129558178667676*std::sin(0.312719941139221*x_30 + 1.99159979820251) - 0.00010138256506474*std::sin(0.765519857406616*x_30 - 7.37951993942261) - 0.00219034312525051*std::sin(0.309599936008453*x_31 - 4.056960105896) + 0.00172754011663085*std::sin(0.340319842100143*x_31 - 1.01967978477478) - 0.00029868981236071*std::sin(0.350399851799011*x_31 + 5.15687990188599) - 0.000626955748190344*std::sin(0.375759840011597*x_31 - 7.39991998672485) + 0.00499376046366704*std::sin(0.386079847812653*x_31 - 7.39783954620361) - 0.000257415317175086*std::sin(0.396079838275909*x_31 + 8.38568019866943) - 0.00644909604647857*std::sin(0.405199855566025*x_31 + 5.19992017745972) - 0.00425328507604002*std::sin(0.613279819488525*x_31 + 5.1956000328064) + 0.00939042282746477*std::sin(0.302159935235977*x_32 - 1.14591991901398) - 0.0258097256138998*std::sin(0.30839991569519*x_32 - 1.14823985099792) + 0.00273304249710627*std::sin(0.213440001010895*x_33 + 1.971599817276) + 0.00437255463479559*std::sin(0.233039990067482*x_33 + 1.9968798160553) + 0.000282407804396671*std::sin(0.233519986271858*x_33 - 1.17975986003876) + 0.0020556011142885*std::sin(0.225599989295006*x_34 + 1.77711987495422) - 0.00129665013399618*std::sin(0.179120019078255*x_35 + 8.19151973724365) + 2.87846987063486e-5*std::sin(0.179520010948181*x_35 + 8.40520000457764) - 0.00900336670920818*std::sin(0.1893600076437*x_36 - 7.60423994064331) - 2.83138269118717e-5*std::sin(0.291999936103821*x_37 + 4.77928018569946) + 0.0441245297739698*std::sin(0.178640007972717*x_4 + 8.1755199432373) + 0.00434404102516614*std::sin(0.249199971556664*x_4 - 7.36111974716187) - 0.00441023817304508*std::sin(0.375919848680496*x_4 + 1.9793598651886) - 2.53858051402589e-5*std::sin(0.772719860076904*x_4 + 8.20959949493408) - 7.12214079571656e-5*std::sin(0.862319886684418*x_4 + 7.99488019943237) - 0.000746441197231443*std::sin(0.16312001645565*x_40 + 5.19856023788452) - 0.00565165252121597*std::sin(0.171840012073517*x_41 - 1.20207989215851) + 0.000283431942135454*std::sin(0.697999835014343*x_42 + 4.62016010284424) - 0.00238996997595043*std::sin(0.459839850664139*x_44 - 1.4592798948288) - 0.00172723258444948*std::sin(0.576399862766266*x_45 + 5.03351974487305) + 0.000195779875875665*std::sin(0.665839850902557*x_47 + 7.57984018325806) + 0.000455022922400827*std::sin(0.228719994425774*x_48 - 7.5971999168396) - 3.93623717854363e-5*std::sin(0.467279851436615*x_49 - 1.34599983692169) + 0.000658992593853021*std::sin(0.254319965839386*x_5 - 7.56360006332397) - 0.0209467657753489*std::sin(0.265679955482483*x_5 + 2.00615978240967) + 0.000803773007028704*std::sin(0.350159853696823*x_5 - 1.14927983283997) - 0.0169439149067027*std::sin(0.359199851751328*x_5 + 2.00079965591431) + 0.0028743957852436*std::sin(0.386959850788116*x_5 - 7.39559984207153) - 0.00184649062803356*std::sin(0.209279999136925*x_50 + 8.17591953277588) - 0.0033674552468765*std::sin(0.224399983882904*x_50 + 4.37063980102539) + 0.00518997111802395*std::sin(0.16872002184391*x_51 + 8.20335960388184) - 0.00111891281650796*std::sin(0.255279958248138*x_52 - 1.2079998254776) - 0.0086215202857532*std::sin(0.233999982476234*x_53 - 7.42159986495972) + 0.000652417391494329*std::sin(0.20024000108242*x_54 + 5.00152015686035) + 5.44082582335154e-5*std::sin(0.5655198097229*x_54 + 4.83576011657715) - 0.0049172296452129*std::sin(0.337999850511551*x_56 + 1.85591995716095) + 0.000454130606254316*std::sin(0.29351994395256*x_57 - 1.42783987522125) + 3.09409236374221e-5*std::sin(0.48447984457016*x_58 + 4.6911997795105) - 0.00249517533092491*std::sin(0.359359860420227*x_59 + 4.64055967330933) - 0.000276712074954488*std::sin(0.606719851493835*x_59 - 7.81207990646362) - 0.000546412617504209*std::sin(0.342959851026535*x_6 + 2.01183986663818) - 0.00699033095386291*std::sin(0.344479858875275*x_6 + 2.01703977584839) - 0.00507155231321585*std::sin(0.366239845752716*x_6 + 1.99223983287811) + 0.00101892642981776*std::sin(0.367599844932556*x_6 - 1.16799986362457) - 0.00530826674443984*std::sin(0.378479838371277*x_6 + 1.99007987976074) + 0.00570317526082409*std::sin(0.38351982831955*x_6 - 1.17855989933014) + 3.72798015282723e-5*std::sin(0.452159851789474*x_60 - 7.48456001281738) + 1.93149777723445e-6*std::sin(1.41623985767365*x_64 + 6.79663991928101) - 2.1821667234309e-5*std::sin(1.77119994163513*x_64 + 3.59479999542236) + 0.0138397393891601*std::sin(0.322959840297699*x_7 - 7.339439868927) + 0.0135178764093264*std::sin(0.330399841070175*x_7 - 1.15071988105774) - 0.00819670899785285*std::sin(0.354959845542908*x_7 + 2.00631976127625) + 0.00843765931789682*std::sin(0.359199851751328*x_7 - 1.15143990516663) - 0.00118100415637361*std::sin(0.376479834318161*x_7 + 2.02695989608765) - 0.00081029464917853*std::sin(0.480159848928452*x_7 + 1.93423986434937) - 2.69570820838469e-5*std::sin(1.0732798576355*x_70 + 2.81663990020752) + 2.30576133149532e-6*std::sin(1.18463981151581*x_70 - 9.6071195602417) + 9.36578855895896e-6*std::sin(0.909999787807465*x_72 + 7.97391986846924) - 7.8645104084208e-5*std::sin(1.2240799665451*x_73 - 0.783519864082336) + 3.92241619083041e-5*std::sin(1.13831984996796*x_75 - 2.37199997901917) + 4.92616609246225e-5*std::sin(1.41495978832245*x_77 + 1.97983980178833) - 5.41919440192666e-6*std::sin(0.803119838237762*x_78 + 3.78615999221802) - 0.0102356135365847*std::sin(0.307679921388626*x_8 + 2.11904001235962) + 0.00363974641652766*std::sin(0.314959913492203*x_8 + 5.15392017364502) - 2.92647343855615e-5*std::sin(0.398239850997925*x_8 - 7.80751991271973) + 8.7922625334644e-5*std::sin(0.451759845018387*x_8 + 7.95944023132324) + 0.00213600147207355*std::sin(0.171200007200241*x_87 + 5.50552034378052) + 0.000560212310053779*std::sin(0.180960014462471*x_88 - 7.25880002975464) - 0.00107179686653438*std::sin(0.376639842987061*x_9 - 4.38687992095947) - 0.010777349339266*std::sin(0.452639847993851*x_9 - 4.27943992614746) - 1.52902600438609e-5*std::sin(1.79071986675262*x_90 - 2.39239978790283) - 0.000179995827311126*std::sin(0.329519838094711*x_91 - 4.20544004440308) - 0.00288879613032696*std::sin(0.370879858732224*x_91 + 5.18943977355957) + 0.000198393935012411*std::sin(0.388959854841232*x_91 + 1.971599817276) + 0.00625089361646925*std::sin(0.417119860649109*x_91 + 8.21047973632813) + 0.00655415476368246*std::sin(0.227119997143745*x_92 + 2.01871991157532) + 5.70920780982516e-5*std::sin(0.239759981632233*x_92 + 5.19600009918213) - 0.00228011408598357*std::sin(0.253919988870621*x_92 + 2.02055978775024) + 0.00414919055252207*std::sin(0.285359919071198*x_92 + 1.99703979492188) + 0.0069677015390593*std::sin(0.321039855480194*x_92 - 1.1814398765564) + 0.00017047944154589*std::sin(0.327039837837219*x_92 + 8.22480010986328) + 0.00627886387658459*std::sin(0.275759935379028*x_94 + 1.97855985164642) + 0.0101074435517814*std::sin(0.287839949131012*x_94 + 1.97927987575531) - 6.5879246313628e-5*std::sin(0.310879945755005*x_94 + 1.79847991466522) + 0.00336744730709226*std::sin(0.253759980201721*x_95 - 7.40999984741211) - 0.00129601607372643*std::sin(0.262319982051849*x_96 - 1.20431983470917) - 6.38706695475832e-5*std::sin(0.30447992682457*x_96 - 4.41775989532471) + 0.000469672381867188*std::sin(0.273119956254959*x_97 + 1.96655988693237) - 0.000440225642091403*std::sin(0.27991995215416*x_97 + 1.97735977172852) + 0.000583047968496402*std::sin(0.261359959840775*x_98 - 4.42471981048584) - 0.0877774953842163*std::sin(0.00207574430017878*x_10 - 0.00501296714259324*x_100 + 0.00457529191632498*x_101 + 0.010173785623011*x_102 - 0.0057895107976557*x_103 - 0.0060935191333739*x_104 + 0.011516297756363*x_105 + 0.000312328886825565*x_106 + 0.00376264003904934*x_107 + 0.013883152950871*x_108 + 0.0152606264105396*x_109 - 0.00447177474980682*x_11 - 0.0132482225030165*x_110 + 0.00114565380165571*x_111 + 0.0277355688762422*x_112 + 0.0509053941224032*x_113 + 0.00247828887320134*x_114 + 0.0029076952431452*x_115 + 0.00116779324407083*x_117 + 0.0049948427925077*x_118 - 0.00324393570860625*x_12 + 0.000709177943238904*x_120 + 0.00076549019630507*x_13 - 0.00390913654179124*x_17 - 0.00352306091679677*x_2 + 0.00739608910830917*x_20 + 0.00321467647393658*x_21 - 0.00140189633887777*x_24 + 6.62302970363757e-5*x_29 - 0.000980158453033564*x_3 - 0.00132107891537332*x_32 + 0.0201063127709534*x_33 + 0.0212740041910967*x_34 - 0.00391630887715614*x_35 + 0.00266662711094149*x_36 - 0.00253253597210941*x_37 + 0.0010027679859035*x_38 + 0.0032524294534222*x_39 - 0.00392473612135568*x_4 - 0.00158028318848903*x_40 + 0.00161516685607478*x_41 + 0.00322517066956373*x_42 - 0.00202809507165594*x_43 + 0.00546907374139328*x_44 + 0.00949737075496844*x_45 + 0.00396293648733227*x_46 + 0.00387764448873833*x_47 + 0.00866774872100568*x_48 - 0.000360734195755965*x_49 - 0.00366981507692314*x_50 - 0.00191620870792867*x_51 + 0.00226421004410934*x_52 + 0.000927742969360096*x_53 - 0.00288922508498069*x_55 + 0.00239890524679179*x_56 - 0.013756304707042*x_57 - 0.00828504805406769*x_59 - 0.00466642442155977*x_61 - 0.0114930463753692*x_62 - 0.00321089901835742*x_63 + 0.00106471677383541*x_64 + 0.00749024341259157*x_65 + 0.00152585680136115*x_66 + 0.00347318804868197*x_67 + 0.00921379239675025*x_68 - 0.000567023046302462*x_69 - 0.000504916405429043*x_70 + 0.000594959944042765*x_71 - 0.00278193828018825*x_72 - 0.00224662269950105*x_73 - 0.00731166561646139*x_74 - 0.000450313915485287*x_75 + 0.0014333859653934*x_76 - 0.00594348901321959*x_77 - 0.00523850956560751*x_78 + 0.00192655852752842*x_79 - 0.00254195234755399*x_8 - 0.00688176128572462*x_80 - 0.00815311246468621*x_81 + 0.00059740189893426*x_82 + 2.76429404025764e-5*x_83 - 0.000839579044446052*x_84 - 0.00852068698098462*x_85 - 0.0056167130447295*x_86 + 0.000880778125582746*x_87 - 0.00259086793011358*x_88 + 0.000322679626495942*x_89 - 0.00351568807501495*x_9 + 0.00268697444561359*x_90 - 0.0179974599671294*x_91 + 0.00653552453820851*x_93 - 0.00490002021584254*x_95 - 0.0161660016459037*x_96 - 0.0026949192698127*x_97 + 0.00250697292789326*x_98 - 0.0262177190842244*x_99 + 0.0646132581336998*std::exp(0.173759862780571*x_14) + 0.0251581814570491*std::exp(0.326959848403931*x_22) - 0.00625602429236224*std::exp(0.310879856348038*x_28) - 0.0189509859569613*std::exp(0.321919828653336*x_30) + 0.40755472689214*std::sin(0.348479837179184*x_1 + 5.15775966644287) - 0.325977614405435*std::sin(0.209199994802475*x_116 + 2.000159740448) + 0.262274979081749*std::sin(0.226719990372658*x_119 + 5.18576002120972) + 0.677016475556307*std::sin(0.316639930009842*x_15 + 5.14856004714966) - 0.218519542393736*std::sin(0.297039926052094*x_16 + 2.00455975532532) + 0.229785742785243*std::sin(0.431999862194061*x_18 - 7.42375993728638) - 0.273083028425805*std::sin(0.257999986410141*x_19 + 8.2061595916748) - 0.187712855611696*std::sin(0.370399862527847*x_23 + 1.99191975593567) - 0.0744155258637029*std::sin(0.324319839477539*x_25 - 1.13855993747711) + 0.287290479267774*std::sin(0.152400031685829*x_26 + 8.14935970306396) - 0.0884108959542624*std::sin(0.367839843034744*x_27 + 5.23767995834351) + 0.0859939949519628*std::sin(0.376639842987061*x_31 - 4.22408008575439) + 0.0151369944796567*std::sin(0.685359835624695*x_5 - 4.65687990188599) + 0.0397207540606548*std::sin(0.589199841022491*x_54 + 1.78703987598419) + 0.0512082031419028*std::sin(0.299759924411774*x_58 + 1.87479984760284) - 0.312960766200924*std::sin(0.323439925909042*x_6 + 2.01247978210449) + 0.104296731436641*std::sin(0.358639866113663*x_60 + 8.24847984313965) - 0.869251266807154*std::sin(0.26079997420311*x_7 + 2.03239989280701) - 0.8116749749571*std::sin(0.303839921951294*x_92 + 1.98935985565186) + 0.164786900307307*std::sin(0.285999953746796*x_94 - 1.19919991493225) + 13.6211544063344) + 0.139252092307218);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-8.17624560262019e-5*x_1 + 0.000681786285147386*x_10 + 0.000287129690346399*x_100 - 0.00121799834808541*x_101 + 0.000225612328759159*x_102 + 0.000561946567455108*x_103 + 0.000258637879053984*x_104 - 0.000771687081071939*x_105 + 0.00107454461422312*x_106 - 0.00119308375280955*x_107 + 0.000567461596844416*x_108 + 0.00125485979541369*x_109 + 0.00383698876884737*x_11 + 0.0015461258773815*x_110 - 0.000123483219365538*x_111 + 0.0114578117195894*x_112 + 0.00289272943001195*x_113 + 0.00851672173307794*x_114 + 0.00147025124063805*x_115 - 0.000394573356294969*x_116 + 0.00824820049421809*x_117 + 0.00208961462294518*x_118 + 0.0113702796604397*x_119 + 0.00310169322693134*x_12 + 0.0126259798562654*x_120 + 0.000683734987411613*x_13 + 0.000226688283295018*x_14 + 0.000351982424453239*x_15 - 0.00279839976669481*x_16 - 8.82107793503727e-5*x_17 - 5.33029012024087e-5*x_18 + 0.000503888391981273*x_19 - 0.000140154160550666*x_2 + 0.000947630357847333*x_20 + 0.00164311717175329*x_21 - 0.000808810490210291*x_22 - 0.00119677855657932*x_23 + 0.000455217599608955*x_24 + 0.000873135967715607*x_25 + 0.000852240999472355*x_26 - 0.00046684709627637*x_27 + 0.000754377496541867*x_28 - 0.000537419453174219*x_29 + 4.1767744498234e-5*x_3 + 0.000248088224353902*x_30 + 0.000208996629927961*x_31 - 0.000605160196809*x_32 - 0.000160971393388908*x_33 - 0.00402019999931709*x_34 + 0.000696139505855719*x_35 - 8.52865834813872e-5*x_36 - 6.76511159830844e-7*x_37 - 0.000718691437035109*x_38 - 5.20138348635283e-5*x_39 + 2.11700367052059e-5*x_4 - 0.00040189394723544*x_40 - 0.000460603599319562*x_41 - 0.000269766810186473*x_42 - 0.000346530668849524*x_43 - 0.000243261972877014*x_44 + 0.000446610067740102*x_45 + 0.000755162705163505*x_46 - 0.00199147977963745*x_47 - 0.00658716540198443*x_48 - 0.00135136013231791*x_49 - 2.33072607349238e-5*x_5 - 0.000376228167197986*x_50 - 0.000445942520540194*x_51 - 0.0003467891192335*x_52 + 0.00107795631968816*x_53 + 0.00170884733545533*x_54 + 0.00177779123921373*x_55 + 9.74190376399134e-5*x_56 + 0.00274214948763386*x_57 + 0.000690894589790541*x_58 + 0.0020108650930114*x_59 - 0.000174699162563068*x_6 - 0.000553407416059304*x_60 - 0.00033303590212422*x_61 + 0.000395619899097924*x_62 - 4.92492386903998e-6*x_63 - 0.000191234111799617*x_64 - 0.000512329316963416*x_65 + 0.000301222991861509*x_66 + 0.000332740837306561*x_67 + 0.000157146383399777*x_68 + 0.000313654312210934*x_69 - 2.86672993868688e-6*x_7 - 0.000191058255559783*x_70 + 7.91056279447035e-5*x_71 + 0.000262677249241501*x_72 - 3.25952420892818e-6*x_73 + 0.000634711441969042*x_74 + 0.000502779083728147*x_75 + 0.000379813747444397*x_76 + 0.000859426409190688*x_77 + 0.000782630969338742*x_78 + 0.0013482017726451*x_79 - 7.84745090709465e-5*x_8 + 0.00166873659247614*x_80 + 0.000598979386629133*x_81 - 2.36512339654397e-5*x_82 + 0.000663673599809756*x_83 + 0.00127832974700224*x_84 + 0.000894503215578114*x_85 + 0.000685655144958719*x_86 + 0.000969790158501044*x_87 + 0.00107444956207142*x_88 + 0.000638403959410674*x_89 - 0.00124315060229333*x_9 + 0.000574294494563246*x_90 + 0.0016014379709326*x_91 + 0.000294303494455646*x_92 - 0.000479898666194629*x_93 - 0.00110082100282924*x_94 + 0.00197966666266944*x_95 - 1.25955423910783e-5*x_96 + 0.000840443465923643*x_97 - 0.00106486052516707*x_98 + 0.00102340091839056*x_99 + 2.40586844422129e-6*std::pow(2.4696798324585 - 7.17983961105347*x_59, 2) - 2.88848950379605e-7*std::pow(5.30704021453857 - 8.17615985870361*x_15, 2) - 8.83333009467951e-6*std::pow(5.54383993148804 - 0.991999804973602*x_10, 2) - 5.2627577776782e-6*std::pow(-2.62831997871399*x_16 - 9.89848041534424, 2) + 8.996480846289e-7*std::pow(-3.71199989318848*x_25 - 8.0, 2) + 3.48927047355428e-7*std::pow(-9.3261604309082*x_28 - 1.61375975608826, 2) + 2.42490021528325e-7*std::pow(-5.89263963699341*x_60 - 9.60136032104492, 2) + 2.74708776447294e-6*std::pow(-3.8724000453949*x_61 - 6.51895952224731, 2) - 5.85976818908045e-6*std::pow(-2.83240008354187*x_64 - 9.11664009094238, 2) - 6.75343370440422e-6*std::pow(-2.76160001754761*x_64 - 6.32287979125977, 2) + 3.0811324746882e-5*std::pow(-3.67159986495972*x_9 - 7.73672008514404, 2) + 0.000316691784446954*std::exp(0.253679871559143*x_13) - 2.11336116523608e-5*std::exp(0.541759848594666*x_13) - 0.00148124437634772*std::exp(0.173759862780571*x_14) - 0.000317353605079561*std::exp(0.403919875621796*x_18) - 0.000174538445353931*std::exp(0.45007985830307*x_18) + 0.000353005441558704*std::exp(0.356479853391647*x_19) - 0.000502829597798687*std::exp(0.250079840421677*x_20) - 0.000576745638260164*std::exp(0.326959848403931*x_22) + 2.29451722560963e-5*std::exp(0.548639833927155*x_22) + 0.000119147988416694*std::exp(0.521439850330353*x_26) + 0.0001434179465487*std::exp(0.310879856348038*x_28) + 0.000434447080766427*std::exp(0.321919828653336*x_30) + 0.000227292493956047*std::exp(0.370639860630035*x_5) + 0.00036944589199882*std::exp(0.319119840860367*x_59) + 0.00021065138727484*std::exp(0.324639827013016*x_6) + 0.00163706837343138*std::exp(0.00426140155776255*x_1 - 0.0058338974975925*x_10 + 0.00197052297504166*x_100 - 0.0346393260381889*x_101 - 0.00352389542548432*x_102 - 0.0239911063316842*x_103 - 0.00449830896370934*x_104 + 0.0102525584570722*x_105 + 0.0126805986829708*x_106 - 0.00191870626360589*x_107 + 0.00479617249788628*x_109 - 0.00421583448307717*x_110 - 0.000168100070643891*x_111 + 0.0941950299007317*x_112 + 0.0161263706379341*x_113 + 0.00993544653202034*x_114 + 0.00271632556867949*x_115 - 0.00907477467748225*x_117 - 0.0113674132432855*x_118 - 0.0113606741443479*x_119 + 0.00648164552228979*x_120 - 0.0151111781810458*x_16 - 0.00553952446357521*x_17 + 0.0755260201112224*x_18 - 0.00150867825921341*x_20 - 0.0141340035501266*x_21 - 0.000717837607509273*x_22 + 0.00569329214322554*x_23 - 0.00268171421274297*x_24 - 0.00519432740759457*x_25 + 0.00232816894021556*x_26 - 0.0102348382873245*x_27 - 0.00896300815516599*x_28 - 0.0140951255213885*x_29 - 0.00912102301739061*x_30 - 0.0135556449879459*x_32 + 0.0106542433909697*x_33 - 0.0464897640844576*x_34 - 0.00715229779335965*x_35 - 0.00691763886492603*x_36 - 0.00249019705218174*x_37 + 0.0158698945921493*x_38 - 0.00163501987614334*x_39 + 0.000259520811994272*x_4 + 0.00276771009486841*x_40 - 0.0120978544242363*x_41 + 0.00253141999434511*x_42 - 0.00921926457645548*x_43 + 0.0012574600621302*x_44 + 0.00449416031064548*x_45 + 0.0121661772156025*x_46 + 0.00384349129557477*x_47 - 0.00922999823185006*x_48 + 0.00418783233645364*x_49 + 0.0531773209869992*x_5 + 0.00907954437339238*x_50 - 0.0778543588855734*x_51 + 0.0167550403708276*x_52 + 0.0280281569556637*x_53 + 0.00522652975280597*x_54 + 0.00608520776557523*x_55 + 0.0365187197085195*x_56 - 0.0142379889418165*x_57 - 0.00283814821831584*x_58 + 0.00627236945211287*x_59 + 0.008817442413367*x_6 + 0.0125460938872394*x_60 - 0.00674362247233803*x_61 - 0.00108723573347028*x_62 + 0.00363885458718557*x_63 - 0.0112740756489345*x_64 - 0.00855651721223336*x_65 + 0.00242714985272223*x_66 - 0.00811911983228717*x_67 + 0.00180293053591931*x_68 - 0.000371029890028104*x_69 - 0.01863769000731*x_7 - 0.00822909007702507*x_71 + 0.000924135973459575*x_72 - 0.00513472022385823*x_73 - 0.0116127654169949*x_74 - 0.0049660861737311*x_75 + 1.50229396595824e-6*x_76 + 0.0140070643357212*x_77 + 0.00916540395141965*x_78 + 0.00439921522769253*x_79 - 0.00826464125626076*x_80 - 0.0130770383656667*x_81 - 0.00251983620618973*x_82 - 0.00223837651882834*x_83 - 0.00829013814865346*x_84 - 0.00485939800847*x_85 - 0.00315209679180693*x_86 - 0.00300269803348034*x_87 + 0.00563160890898414*x_88 - 0.00232694723672467*x_89 - 0.0080111733987115*x_9 - 0.0021129206113444*x_90 + 0.0109027518362275*x_92 - 0.0127300294979344*x_93 - 0.00310333388022253*x_94 + 0.0079809704549946*x_95 + 0.00318469749285785*x_96 - 0.00185815588498427*x_97 + 0.0324149875955397*x_98 - 0.00671835075882853*x_99 - 0.272941371346526*std::exp(0.208559840917587*x_13) + 0.229723656031512*std::sin(0.206160008907318*x_108 - 4.39903974533081) - 1.23003120682471*std::sin(0.283119946718216*x_11 - 7.42775964736938) - 0.383454696587236*std::sin(0.233519986271858*x_116 + 1.79903984069824) - 1.09717895271399*std::sin(0.298639953136444*x_12 + 5.12664031982422) - 1.34038747225981*std::sin(0.121120058000088*x_14 - 1.25951981544495) - 0.875159235094863*std::sin(0.244799971580505*x_15 - 1.17535984516144) - 1.66193793965648*std::sin(0.222240000963211*x_19 + 8.1947193145752) - 1.48637027347657*std::sin(0.399199843406677*x_2 + 5.20344018936157) - 1.64661877389011*std::sin(0.316159933805466*x_3 + 8.28087997436523) - 2.16458273212945*std::sin(0.375759840011597*x_31 - 7.39991998672485) + 0.00796070723806697*std::sin(1.18463981151581*x_70 - 9.6071195602417) - 0.101037336198263*std::sin(0.398239850997925*x_8 - 7.80751991271973) + 0.6849607601918*std::sin(0.388959854841232*x_91 + 1.971599817276)) + 0.00233337045028711*std::log(5.16136026382446 - 0.59639984369278*x_9) + 0.0176136096983356*std::sin(0.337039858102798*x_1 - 4.24552011489868) - 0.0126083192734535*std::sin(0.344959855079651*x_1 - 4.25184011459351) - 0.0093431002351521*std::sin(0.348479837179184*x_1 + 5.15775966644287) - 0.00632280173762466*std::sin(0.351919859647751*x_1 - 4.22544002532959) - 0.00258908342650226*std::sin(0.353119850158691*x_1 - 4.22032022476196) + 0.112652085640601*std::sin(0.358719855546951*x_1 - 4.23680019378662) - 0.00668961288432163*std::sin(0.359119862318039*x_1 - 1.03623986244202) - 0.00194000037052225*std::sin(0.403519839048386*x_1 - 4.18416023254395) + 0.000496295062958343*std::sin(1.34607982635498*x_100 - 4.97455978393555) - 0.000294776835165863*std::sin(0.225759983062744*x_107 - 4.39264011383057) - 0.0012569377768073*std::sin(0.20584000647068*x_109 + 5.18096017837524) + 0.0104698416755289*std::sin(0.102400071918964*x_11 - 4.28399991989136) + 0.0024023783344852*std::sin(0.175360009074211*x_11 + 5.18400001525879) + 0.0111432213978767*std::sin(0.282959938049316*x_112 - 7.43111991882324) - 0.000215353176366532*std::sin(0.323279827833176*x_112 - 1.34607982635498) + 0.00321007531182201*std::sin(0.254479974508286*x_113 - 4.22528028488159) - 0.00484119026300962*std::sin(0.283679932355881*x_113 + 1.96335983276367) + 0.0191977122815251*std::sin(0.287439942359924*x_113 - 7.42911958694458) + 0.0240378374075196*std::sin(0.2880799472332*x_113 - 7.42679977416992) - 0.0130167154753364*std::sin(0.233999982476234*x_114 + 1.97791981697083) - 0.000867337369630059*std::sin(0.241119980812073*x_114 - 1.23959982395172) + 0.00747296332208109*std::sin(0.209199994802475*x_116 + 2.000159740448) + 0.00658184630979018*std::sin(0.227039992809296*x_116 + 5.1735200881958) + 0.0714480061766801*std::sin(0.251039981842041*x_116 + 5.16688013076782) + 0.00485618991258303*std::sin(0.262319952249527*x_116 - 1.23943984508514) + 0.000118239206061366*std::sin(1.02279984951019*x_116 + 8.39000034332275) - 0.0184981093832016*std::sin(0.218319997191429*x_118 - 4.21447992324829) - 0.00601259476836276*std::sin(0.226719990372658*x_119 + 5.18576002120972) + 0.0192905627622885*std::sin(0.235759988427162*x_119 + 5.17343997955322) + 0.011913504169283*std::sin(0.276479959487915*x_12 - 7.43616008758545) + 0.0020907895821952*std::sin(0.539439857006073*x_12 + 7.83392000198364) + 0.00653358905568184*std::sin(0.179840013384819*x_13 + 1.59295988082886) - 0.005011125586791*std::sin(0.232399985194206*x_13 - 7.40807962417603) - 0.000199417925773135*std::sin(0.295279920101166*x_13 - 4.40863990783691) + 0.0128810441191493*std::sin(0.305279940366745*x_13 + 5.13495969772339) + 0.00423851871300472*std::sin(0.243039980530739*x_14 - 1.1814398765564) - 0.00385496174539737*std::sin(0.303039938211441*x_14 - 7.43951988220215) + 0.00141466792627972*std::sin(0.442319840192795*x_14 - 1.44655990600586) - 0.000246693093996626*std::sin(0.53143984079361*x_14 - 1.31679975986481) - 0.000406143296229588*std::sin(0.538719832897186*x_14 + 1.86799991130829) - 0.00548097290848366*std::sin(0.267919957637787*x_15 + 1.98791980743408) - 0.001559025658586*std::sin(0.270559966564178*x_15 + 1.77759981155396) - 0.030197030825196*std::sin(0.29615992307663*x_15 + 5.17063999176025) - 0.0155204500760115*std::sin(0.316639930009842*x_15 + 5.14856004714966) - 0.000453639872159265*std::sin(0.502879858016968*x_15 + 8.08672046661377) + 0.00500951124648486*std::sin(0.297039926052094*x_16 + 2.00455975532532) - 0.0165252595891434*std::sin(0.314639925956726*x_16 + 1.9968798160553) + 0.00857726074515875*std::sin(0.387599855661392*x_16 - 1.18503987789154) - 0.000601101743016943*std::sin(0.51095986366272*x_16 + 8.10847949981689) + 0.000980630247273116*std::sin(0.27975994348526*x_17 - 7.37399959564209) - 0.0224138768152476*std::sin(0.344799846410751*x_17 + 1.99871981143951) + 0.0078373466054372*std::sin(0.380239844322205*x_17 - 1.1743198633194) + 0.00337217449495802*std::sin(0.383119851350784*x_17 + 1.99287974834442) - 0.00365913394844811*std::sin(0.428399860858917*x_17 - 1.20383989810944) - 0.00143432685627224*std::sin(0.606959879398346*x_17 + 5.00175952911377) - 0.00355460596342144*std::sin(0.314559936523438*x_18 - 1.15207993984222) + 0.0425638029760961*std::sin(0.374319821596146*x_18 + 2.02303981781006) - 0.00526778635061589*std::sin(0.431999862194061*x_18 - 7.42375993728638) - 0.00206452178581057*std::sin(0.51775985956192*x_18 + 2.0559196472168) - 0.000887425314472171*std::sin(0.524639844894409*x_18 + 2.05535984039307) + 0.00682028742633412*std::sin(0.25655996799469*x_19 + 8.21303939819336) + 0.00626036686301624*std::sin(0.257999986410141*x_19 + 8.2061595916748) - 0.00104275648921631*std::sin(0.39319983124733*x_19 - 1.2047199010849) - 0.0807772868182767*std::sin(0.365679860115051*x_2 + 5.18024015426636) + 0.00740493820247801*std::sin(0.377919852733612*x_2 + 5.17736005783081) + 0.00813909538285434*std::sin(0.388719856739044*x_2 + 5.18279981613159) - 0.00131592720580373*std::sin(0.409279853105545*x_2 - 1.17679977416992) - 0.00266342481986917*std::sin(0.337519854307175*x_20 - 7.79392004013062) + 0.000193965058141418*std::sin(0.415519863367081*x_20 + 7.59352016448975) - 0.000820855752948863*std::sin(0.317199915647507*x_21 - 1.19207990169525) + 0.0102149180342986*std::sin(0.340239852666855*x_21 + 2.04071974754333) - 0.00784215403973607*std::sin(0.399679869413376*x_22 + 2.00927972793579) - 0.00325865057386506*std::sin(0.482559859752655*x_22 + 4.98415994644165) - 0.0758611199147634*std::sin(0.275279939174652*x_23 - 1.15063989162445) + 0.00157886066742073*std::sin(0.354399859905243*x_23 - 1.39335989952087) - 0.00100199918526928*std::sin(0.366559833288193*x_23 - 7.36911964416504) + 0.00430327489704435*std::sin(0.370399862527847*x_23 + 1.99191975593567) + 0.000953922821690218*std::sin(0.832639873027802*x_23 - 7.78951978683472) - 0.00227727808559395*std::sin(0.386879861354828*x_24 - 1.19351994991302) - 0.0173704664389962*std::sin(0.442479848861694*x_24 - 1.21311986446381) + 0.00116205410569858*std::sin(0.827359914779663*x_24 + 1.80167984962463) - 0.00168008422337374*std::sin(0.261439979076385*x_25 - 7.37575960159302) + 0.00170595915424172*std::sin(0.324319839477539*x_25 - 1.13855993747711) + 0.0151408961220628*std::sin(0.338639855384827*x_25 - 1.14871978759766) - 0.00658606947065068*std::sin(0.152400031685829*x_26 + 8.14935970306396) + 0.00285571237863241*std::sin(0.284159928560257*x_26 + 1.98807990550995) + 0.00122316014492457*std::sin(0.304559946060181*x_26 - 1.17807984352112) + 0.000224983232587871*std::sin(0.783759832382202*x_26 - 1.39231991767883) + 0.00265739360842408*std::sin(0.285999923944473*x_27 - 7.39047956466675) + 0.00202679985846143*std::sin(0.367839843034744*x_27 + 5.23767995834351) - 0.00140986007211672*std::sin(0.463919848203659*x_27 + 4.5776801109314) + 0.00922450190040176*std::sin(0.0912800803780556*x_28 + 2.02471995353699) + 0.000353708258430707*std::sin(0.805839836597443*x_28 + 4.79120016098022) + 0.000902836685598805*std::sin(0.323039919137955*x_29 + 4.80983972549438) + 0.00012588736254427*std::sin(0.856159865856171*x_29 - 5.43487977981567) - 0.00414871889374754*std::sin(0.2743199467659*x_3 - 1.15183985233307) + 0.0110325347169566*std::sin(0.2882399559021*x_3 - 1.13159990310669) + 0.0155258174283842*std::sin(0.344079852104187*x_3 - 7.40455961227417) - 0.0256900946967956*std::sin(0.348319828510284*x_3 + 1.97527980804443) + 0.00748362195704455*std::sin(0.372479856014252*x_3 + 5.19831991195679) - 0.00221115754461593*std::sin(0.396399825811386*x_3 - 7.40655994415283) + 0.033882483254621*std::sin(0.259519964456558*x_30 + 1.99079978466034) - 0.0582346838786062*std::sin(0.266159951686859*x_30 - 1.1651998758316) - 0.0141544238563853*std::sin(0.284959942102432*x_30 - 1.16359984874725) - 0.0153361995333918*std::sin(0.304079920053482*x_30 - 1.16567981243134) - 0.0103981811471668*std::sin(0.308239936828613*x_30 + 2.00159978866577) - 0.0182968464011208*std::sin(0.312719941139221*x_30 + 1.99159979820251) - 0.000194067906559961*std::sin(0.765519857406616*x_30 - 7.37951993942261) - 0.000957274805003026*std::sin(0.293119937181473*x_31 - 1.07175981998444) - 0.00216637486583829*std::sin(0.309599936008453*x_31 - 4.056960105896) - 0.0033016274171145*std::sin(0.350399851799011*x_31 + 5.15687990188599) - 0.00197139294784817*std::sin(0.376639842987061*x_31 - 4.22408008575439) + 0.0543400121048711*std::sin(0.386079847812653*x_31 - 7.39783954620361) - 0.000492747956108004*std::sin(0.396079838275909*x_31 + 8.38568019866943) + 0.00910773221744385*std::sin(0.405199855566025*x_31 + 5.19992017745972) - 0.000808280594359111*std::sin(0.613279819488525*x_31 + 5.1956000328064) + 0.00417242276311784*std::sin(0.285679936408997*x_32 + 8.2425594329834) + 0.00723774351201517*std::sin(0.302159935235977*x_32 - 1.14591991901398) - 0.00157725258979908*std::sin(0.213440001010895*x_33 + 1.971599817276) + 0.00337018146258147*std::sin(0.233039990067482*x_33 + 1.9968798160553) + 0.0437619410681624*std::sin(0.233519986271858*x_33 - 1.17975986003876) + 0.000318177408499929*std::sin(0.179520010948181*x_35 + 8.40520000457764) - 0.00171097080605922*std::sin(0.1893600076437*x_36 - 7.60423994064331) - 0.000312972533200354*std::sin(0.291999936103821*x_37 + 4.77928018569946) - 0.000107023744781574*std::sin(0.538559854030609*x_37 - 0.706639885902405) - 0.00250696795398946*std::sin(0.249199971556664*x_4 - 7.36111974716187) - 0.00436197827650986*std::sin(0.375919848680496*x_4 + 1.9793598651886) - 0.00393378685440096*std::sin(0.772719860076904*x_4 + 8.20959949493408) - 0.00026183283956169*std::sin(0.862319886684418*x_4 + 7.99488019943237) - 0.00142884805118428*std::sin(0.16312001645565*x_40 + 5.19856023788452) + 0.00209788427204018*std::sin(0.171840012073517*x_41 - 1.20207989215851) + 0.000280330432496851*std::sin(0.697999835014343*x_42 + 4.62016010284424) + 0.00137926370998661*std::sin(0.459839850664139*x_44 - 1.4592798948288) + 0.000996794623535036*std::sin(0.576399862766266*x_45 + 5.03351974487305) + 0.00167281084796191*std::sin(0.228719994425774*x_48 - 7.5971999168396) - 0.000435099827685136*std::sin(0.467279851436615*x_49 - 1.34599983692169) - 0.00093066191522598*std::sin(0.254319965839386*x_5 - 7.56360006332397) + 0.0120884840254276*std::sin(0.265679955482483*x_5 + 2.00615978240967) + 0.124552744004069*std::sin(0.350159853696823*x_5 - 1.14927983283997) - 0.0167585027932943*std::sin(0.359199851751328*x_5 + 2.00079965591431) + 0.00221546354491764*std::sin(0.386959850788116*x_5 - 7.39559984207153) - 0.000347012185972768*std::sin(0.685359835624695*x_5 - 4.65687990188599) - 0.000639940347228547*std::sin(0.224399983882904*x_50 + 4.37063980102539) + 0.0190800057742842*std::sin(0.16872002184391*x_51 + 8.20335960388184) - 0.00411348397021925*std::sin(0.255279958248138*x_52 - 1.2079998254776) + 0.00497552277840808*std::sin(0.233999982476234*x_53 - 7.42159986495972) + 0.000502855923441819*std::sin(0.20024000108242*x_54 + 5.00152015686035) + 0.00843110903228468*std::sin(0.5655198097229*x_54 + 4.83576011657715) - 0.000910589332221727*std::sin(0.589199841022491*x_54 + 1.78703987598419) - 0.000934454481460091*std::sin(0.337999850511551*x_56 + 1.85591995716095) + 0.000995255511362951*std::sin(0.169280022382736*x_57 + 1.61479985713959) + 0.000350024797542805*std::sin(0.29351994395256*x_57 - 1.42783987522125) - 0.00117393651268692*std::sin(0.299759924411774*x_58 + 1.87479984760284) + 0.00479460856157323*std::sin(0.48447984457016*x_58 + 4.6911997795105) + 0.000926205045883427*std::sin(0.359359860420227*x_59 + 4.64055967330933) + 0.000390786470205364*std::sin(0.606719851493835*x_59 - 7.81207990646362) + 0.00717455501150174*std::sin(0.323439925909042*x_6 + 2.01247978210449) - 0.0846721528011759*std::sin(0.342959851026535*x_6 + 2.01183986663818) - 0.00691383788583719*std::sin(0.344479858875275*x_6 + 2.01703977584839) - 0.00390893951478579*std::sin(0.366239845752716*x_6 + 1.99223983287811) + 0.00374590180222346*std::sin(0.367599844932556*x_6 - 1.16799986362457) + 0.00749659668559584*std::sin(0.378479838371277*x_6 + 1.99007987976074) - 0.00329133116654317*std::sin(0.38351982831955*x_6 - 1.17855989933014) - 0.00239097905560341*std::sin(0.358639866113663*x_60 + 8.24847984313965) + 0.000412079721961489*std::sin(0.452159851789474*x_60 - 7.48456001281738) + 0.000299305085003582*std::sin(1.41623985767365*x_64 + 6.79663991928101) - 0.00023745425322024*std::sin(1.77119994163513*x_64 + 3.59479999542236) + 0.0199273893281614*std::sin(0.26079997420311*x_7 + 2.03239989280701) + 0.0133699543943937*std::sin(0.330399841070175*x_7 - 1.15071988105774) - 0.00631767902884758*std::sin(0.354959845542908*x_7 + 2.00631976127625) - 0.0119160795645749*std::sin(0.359199851751328*x_7 - 1.15143990516663) - 0.0128511931279378*std::sin(0.376479834318161*x_7 + 2.02695989608765) - 0.00297890416605717*std::sin(0.480159848928452*x_7 + 1.93423986434937) - 0.000293335689087612*std::sin(1.0732798576355*x_70 + 2.81663990020752) + 0.000103526611921444*std::sin(0.909999787807465*x_72 + 7.97391986846924) + 0.000111066503437033*std::sin(1.2240799665451*x_73 - 0.783519864082336) - 5.53943003081125e-5*std::sin(1.13831984996796*x_75 - 2.37199997901917) - 4.88626014233815e-5*std::sin(1.22527992725372*x_75 + 3.99287986755371) + 3.79688192213744e-5*std::sin(1.41495978832245*x_77 + 1.97983980178833) - 5.99021462254199e-5*std::sin(0.803119838237762*x_78 + 3.78615999221802) + 0.00149030090640262*std::sin(0.295279920101166*x_8 - 1.19455993175507) - 0.00194514302358579*std::sin(0.307679921388626*x_8 + 2.11904001235962) + 0.0133808803681203*std::sin(0.314959913492203*x_8 + 5.15392017364502) + 0.000956737224329779*std::sin(0.451759845018387*x_8 + 7.95944023132324) - 0.00123269720731007*std::sin(0.171200007200241*x_87 + 5.50552034378052) + 0.00107236614275672*std::sin(0.180960014462471*x_88 - 7.25880002975464) + 4.20188123520527e-5*std::sin(1.14111983776093*x_88 - 1.60359990596771) - 0.00394027055975639*std::sin(0.376639842987061*x_9 - 4.38687992095947) - 0.00204809275038486*std::sin(0.452639847993851*x_9 - 4.27943992614746) - 0.000703392020023222*std::sin(0.485359847545624*x_9 - 4.47983980178833) - 1.17850902417092e-5*std::sin(1.79071986675262*x_90 - 2.39239978790283) - 0.00198961977885923*std::sin(0.329519838094711*x_91 - 4.20544004440308) - 0.0036074221881195*std::sin(0.417119860649109*x_91 + 8.21047973632813) + 0.00648243463919931*std::sin(0.227119997143745*x_92 + 2.01871991157532) + 0.00884699402175607*std::sin(0.239759981632233*x_92 + 5.19600009918213) + 0.00322008981889786*std::sin(0.253919988870621*x_92 + 2.02055978775024) + 0.00319802180939055*std::sin(0.285359919071198*x_92 + 1.99703979492188) + 0.0186074658174576*std::sin(0.303839921951294*x_92 + 1.98935985565186) + 0.00188442851068032*std::sin(0.327039837837219*x_92 + 8.22480010986328) + 0.00160872914026314*std::sin(0.257679969072342*x_94 - 7.39807987213135) + 0.00621015617664795*std::sin(0.275759935379028*x_94 + 1.97855985164642) - 0.00377770254010242*std::sin(0.285999953746796*x_94 - 1.19919991493225) - 0.000728209389295277*std::sin(0.310879945755005*x_94 + 1.79847991466522) - 0.000998914756175398*std::sin(0.262319982051849*x_96 - 1.20431983470917) - 0.000706007185384337*std::sin(0.30447992682457*x_96 - 4.41775989532471) + 0.00511077836065152*std::sin(0.273119956254959*x_97 + 1.96655988693237) - 0.000842686005430401*std::sin(0.27991995215416*x_97 + 1.97735977172852) + 0.000449388885752417*std::sin(0.261359959840775*x_98 - 4.42471981048584) - 0.0845856443047523*std::sin(-0.0068877491734433*x_10 + 0.01083139818568*x_100 - 0.0047318682264718*x_101 - 0.00432530389135907*x_102 + 0.00438148541660471*x_103 + 0.000599910149908408*x_104 + 0.0106539775706953*x_105 + 0.00921762883386306*x_106 + 0.000300933527173093*x_107 + 0.0106793939625228*x_108 + 0.000751708745678637*x_109 - 0.0092090723013238*x_11 - 0.00197607956326346*x_110 - 0.00393832891101682*x_111 + 0.00336548765088761*x_112 + 0.00409595817588648*x_113 + 0.00270248636931021*x_114 + 0.00193241718090593*x_115 + 0.0022836925814588*x_116 + 0.000837879798136794*x_117 + 0.00439194947254317*x_118 - 0.0018506670841871*x_119 - 0.0019475899183326*x_12 + 0.00358053773586616*x_120 - 0.000712476002943781*x_13 - 0.00626910904561838*x_14 - 0.00241273199298942*x_15 - 0.0111784594678516*x_16 + 0.00407573890610543*x_17 + 0.00887854615418893*x_19 - 0.000884817066867876*x_2 + 0.000882453832605206*x_20 - 0.00197069193332396*x_21 - 0.000933825291926181*x_24 - 0.00370988490308652*x_25 + 0.00265506546359212*x_26 - 0.00318123638496921*x_27 - 0.00414998630413296*x_28 + 0.00336446056331228*x_30 + 0.0415939786517517*x_33 - 0.018680846186281*x_36 - 0.00276751816346514*x_37 + 0.0125325809611043*x_38 - 0.00871153272543055*x_39 + 0.00173816549460175*x_40 - 0.00661141478080342*x_41 - 0.00304023099322214*x_42 - 0.000843645491716073*x_43 + 0.00185925594394804*x_44 - 0.0022251029717535*x_45 + 0.00960589060966908*x_46 + 0.0262418558678348*x_48 - 0.000703141185081668*x_49 - 0.00341281216433983*x_5 - 0.000354862310760104*x_51 + 0.00387271812147012*x_52 + 0.0123942641550556*x_53 + 0.00025839129688089*x_54 - 0.00148816347695841*x_55 + 0.00407496884243411*x_56 + 0.000243016550036516*x_57 + 0.00135286506014784*x_58 - 0.000503264861754878*x_59 - 0.0207636459461999*x_6 + 0.00152206364506613*x_60 - 0.00451530681943859*x_61 - 0.000721377309287108*x_62 + 0.00726537577240776*x_63 + 0.00869574387363301*x_64 + 0.0096915671318725*x_65 - 0.00209165781913394*x_66 + 0.00140466873184215*x_67 + 0.00121023665574401*x_68 + 0.00371566810400732*x_69 + 0.00550905064598526*x_70 - 0.00254804145887955*x_71 + 0.000440398560146032*x_72 + 0.00705894346761497*x_73 + 0.0114800100312408*x_74 + 0.00428943788374073*x_75 + 0.00226709950910345*x_76 + 0.0101383204289212*x_77 + 0.000990922115198984*x_78 - 0.00338144855411827*x_79 + 0.00462746611040372*x_8 + 0.00184636882242085*x_80 - 0.00970188242771289*x_81 - 0.00290138407189939*x_82 + 0.00501551932217072*x_83 + 0.00717959676389075*x_84 + 0.000242835064353736*x_85 + 0.000642843093517372*x_86 - 0.00535777089826343*x_87 + 0.00419962316873528*x_88 + 0.000363637406565618*x_89 + 0.00336898898736392*x_9 - 0.00566093820422265*x_90 + 0.026715500503307*x_93 - 0.00629906133200388*x_96 - 0.000570687481700509*x_97 + 0.00116794906300137*x_98 + 0.00232488169649709*x_99 + 0.0910373258050944*std::exp(0.318959832191467*x_18) - 2.27518198526401*std::sin(0.332799851894379*x_1 - 4.25031995773315) - 0.154856582470768*std::sin(0.317359924316406*x_22 + 8.25111961364746) + 0.524605459995247*std::sin(0.319999933242798*x_23 - 1.16799986362457) - 0.062733913241789*std::sin(0.377759844064713*x_29 - 1.18191993236542) + 0.273348537019736*std::sin(0.359439849853516*x_3 - 7.39336013793945) - 0.0435395326361612*std::sin(0.340319842100143*x_31 - 1.01967978477478) + 0.650487580507448*std::sin(0.30839991569519*x_32 - 1.14823985099792) - 0.0518077183510168*std::sin(0.225599989295006*x_34 + 1.77711987495422) + 0.0326797278299462*std::sin(0.179120019078255*x_35 + 8.19151973724365) - 1.11207918453193*std::sin(0.178640007972717*x_4 + 8.1755199432373) - 0.00493427863881762*std::sin(0.665839850902557*x_47 + 7.57984018325806) + 0.0465374657223154*std::sin(0.209279999136925*x_50 + 8.17591953277588) - 0.348805668250113*std::sin(0.322959840297699*x_7 - 7.339439868927) + 0.0728068958774077*std::sin(0.370879858732224*x_91 + 5.18943977355957) - 0.175608349489767*std::sin(0.321039855480194*x_92 - 1.1814398765564) - 0.25473988369613*std::sin(0.287839949131012*x_94 + 1.97927987575531) - 0.08487043543373*std::sin(0.253759980201721*x_95 - 7.40999984741211) - 4.64210111409908) - 0.0717866327337993);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000221960365571012*x_1 + 0.00219285179824309*x_10 - 0.000625497285392638*x_100 + 0.000123313757599983*x_101 - 0.000578910933174956*x_102 - 0.000839701033088741*x_103 - 0.00106943431154184*x_104 - 0.000908022531490775*x_105 + 0.000212402051882346*x_106 + 0.000907998265282547*x_107 + 1.03731604241946e-5*x_108 + 0.00288800577762601*x_109 + 0.000529193062247168*x_11 - 0.000157970891057428*x_110 + 0.000164722685175765*x_111 - 0.00397694255320418*x_112 + 0.00388887606110449*x_113 - 0.0023073114795838*x_114 - 0.00140643172993733*x_115 + 0.00160463961571279*x_116 - 0.00465992670598997*x_117 + 0.00531737084610295*x_118 - 0.0087112714310526*x_119 + 0.00122358943226672*x_12 - 0.016555374039537*x_120 + 0.00240932631040164*x_13 + 0.00102019526295437*x_14 + 1.97380260874836e-5*x_15 - 0.00173085896081848*x_16 - 0.00085190617593067*x_17 - 0.00128524215959143*x_18 - 0.00239290254629889*x_19 - 0.000481569889287159*x_2 - 0.000373474498218455*x_20 - 0.000398833552539187*x_21 + 0.00079198520356598*x_22 + 0.00324853087830014*x_23 - 0.000945546197338813*x_24 - 0.00108572866267782*x_25 + 0.00296231862036618*x_26 + 0.000554063329438858*x_27 - 0.000244728936296481*x_28 + 0.00172806734976997*x_29 - 0.000621692820275165*x_3 - 5.85417303287886e-5*x_30 - 0.000471011265780305*x_31 - 0.0017078704224224*x_32 - 0.00362114213288674*x_33 + 0.00463671956857597*x_34 + 0.000732740249432285*x_35 - 0.00037598214124491*x_36 - 0.00220330706650962*x_37 - 0.000180007316578804*x_38 + 0.000746205415516301*x_39 - 0.000733083052518311*x_4 - 0.00102284993514521*x_40 - 3.85947816030089e-5*x_41 - 0.00120211882609296*x_42 - 0.000244580494642015*x_43 - 0.00131464028847029*x_44 + 0.000288936048566036*x_45 + 0.00078245790958926*x_46 + 0.000911115999369606*x_47 - 0.00615322089463522*x_48 - 0.000244873368246675*x_49 - 0.00019539681652584*x_5 + 0.000822623521753911*x_50 + 0.00121156265217342*x_51 + 0.00676187712658867*x_52 + 0.00053451508943793*x_53 - 0.00252177642474915*x_54 - 0.000911244437828671*x_55 - 6.90083644130308e-5*x_56 - 0.00189256800664456*x_57 + 0.00155833888560875*x_58 - 0.00076811026914909*x_59 + 5.78359404651349e-5*x_6 + 0.000122153642980117*x_60 + 0.000327242921848127*x_61 - 0.0003556439661022*x_62 + 0.000724444530825243*x_63 - 0.000202899668138662*x_64 + 0.00070511978249116*x_65 + 0.000226804064063524*x_66 + 0.00280261374749688*x_67 + 0.000662573873206449*x_68 + 0.000752530636647066*x_69 + 0.000451717141279437*x_7 + 0.00205437983908059*x_70 - 5.07410358627547e-5*x_71 + 0.000111556745384604*x_72 + 1.44440562073036e-5*x_73 + 0.000425194248737279*x_74 - 0.000133054056927159*x_75 + 0.00151073954800866*x_76 + 0.000827172004494601*x_77 - 0.000350170987782475*x_78 + 0.000756792909880746*x_79 - 0.00104705677443953*x_8 + 0.00256575172855194*x_80 + 0.00135046248117839*x_81 + 0.000613496704381256*x_82 - 0.000349626253712276*x_83 + 0.00040907912482059*x_84 + 0.000488284145121463*x_85 + 0.000491263146751979*x_86 + 0.000659711809199506*x_87 - 0.000254683098722726*x_88 + 0.000819912527657322*x_89 - 0.000456950786181275*x_9 + 0.000101872358121563*x_90 + 0.000870677158417092*x_91 - 0.000269500199347456*x_92 + 0.000244078337536839*x_93 - 0.000239290760569325*x_94 + 0.00192331958966567*x_95 - 0.000106580542811991*x_96 + 0.00111929840786791*x_97 - 0.00146440962607028*x_98 + 0.00172032810563932*x_99 + 2.94887996200246e-9*std::pow(2.4696798324585 - 7.17983961105347*x_59, 2) - 3.0090462466746e-7*std::pow(5.30704021453857 - 8.17615985870361*x_15, 2) - 2.38816559614439e-6*std::pow(5.54383993148804 - 0.991999804973602*x_10, 2) + 8.36406932771611e-6*std::pow(-2.62831997871399*x_16 - 9.89848041534424, 2) + 1.35683164141349e-5*std::pow(-3.71199989318848*x_25 - 8.0, 2) - 8.25617386276132e-7*std::pow(-9.3261604309082*x_28 - 1.61375975608826, 2) + 3.44240555672152e-7*std::pow(-5.89263963699341*x_60 - 9.60136032104492, 2) + 6.88504413152912e-7*std::pow(-3.8724000453949*x_61 - 6.51895952224731, 2) + 1.38651518508525e-5*std::pow(-2.83240008354187*x_64 - 9.11664009094238, 2) + 1.07331916249985e-5*std::pow(-2.76160001754761*x_64 - 6.32287979125977, 2) + 7.50562835380075e-6*std::pow(-3.67159986495972*x_9 - 7.73672008514404, 2) - 0.000230218931987226*std::exp(0.208559840917587*x_13) - 0.0023658354677555*std::exp(0.253679871559143*x_13) + 4.61725793551531e-6*std::exp(0.541759848594666*x_13) + 0.00205064259486384*std::exp(0.173759862780571*x_14) - 0.000518376324816659*std::exp(0.318959832191467*x_18) + 0.000504368178513648*std::exp(0.403919875621796*x_18) - 4.37446853519387e-5*std::exp(0.45007985830307*x_18) + 0.000293096635203111*std::exp(0.356479853391647*x_19) + 0.000799144059765424*std::exp(0.250079840421677*x_20) + 0.00079844972990506*std::exp(0.326959848403931*x_22) + 5.75076361344685e-6*std::exp(0.548639833927155*x_22) + 1.46040036560941e-7*std::exp(0.521439850330353*x_26) - 0.000198548568188204*std::exp(0.310879856348038*x_28) - 0.000601450849879717*std::exp(0.321919828653336*x_30) - 0.00169798103444609*std::exp(0.370639860630035*x_5) - 0.000874168265356099*std::exp(0.319119840860367*x_59) - 0.00157366419914247*std::exp(0.324639827013016*x_6) - 0.00370841164231878*std::log(5.16136026382446 - 0.59639984369278*x_9) + 0.0129551309353622*std::sin(0.332799851894379*x_1 - 4.25031995773315) - 0.131581886825057*std::sin(0.337039858102798*x_1 - 4.24552011489868) + 0.00275465751791463*std::sin(0.344959855079651*x_1 - 4.25184011459351) + 0.0129346376710143*std::sin(0.348479837179184*x_1 + 5.15775966644287) + 0.0100487908265897*std::sin(0.351919859647751*x_1 - 4.22544002532959) - 0.000648903682008818*std::sin(0.353119850158691*x_1 - 4.22032022476196) + 0.0274420102038765*std::sin(0.358719855546951*x_1 - 4.23680019378662) - 8.19947800367555e-6*std::sin(0.359119862318039*x_1 - 1.03623986244202) - 0.00275403829544695*std::sin(0.403519839048386*x_1 - 4.18416023254395) + 6.08310304710907e-7*std::sin(1.34607982635498*x_100 - 4.97455978393555) - 0.000418467287425772*std::sin(0.225759983062744*x_107 - 4.39264011383057) + 0.000193765915672163*std::sin(0.206160008907318*x_108 - 4.39903974533081) - 0.00178435778926649*std::sin(0.20584000647068*x_109 + 5.18096017837524) - 0.0247733254970915*std::sin(0.102400071918964*x_11 - 4.28399991989136) + 0.00341043333488807*std::sin(0.175360009074211*x_11 + 5.18400001525879) - 0.00103749925981951*std::sin(0.283119946718216*x_11 - 7.42775964736938) - 0.017709854840982*std::sin(0.282959938049316*x_112 - 7.43111991882324) - 0.000305716897672503*std::sin(0.323279827833176*x_112 - 1.34607982635498) + 0.000867871045070907*std::sin(0.254479974508286*x_113 - 4.22528028488159) - 0.00401958839558063*std::sin(0.283679932355881*x_113 + 1.96335983276367) - 0.0305108088267483*std::sin(0.287439942359924*x_113 - 7.42911958694458) - 0.0568773806517531*std::sin(0.2880799472332*x_113 - 7.42679977416992) + 0.0307996376036171*std::sin(0.233999982476234*x_114 + 1.97791981697083) - 0.00021738133539294*std::sin(0.241119980812073*x_114 - 1.23959982395172) - 0.0103456101793951*std::sin(0.209199994802475*x_116 + 2.000159740448) + 0.00546483645777655*std::sin(0.227039992809296*x_116 + 5.1735200881958) - 0.000323434041084674*std::sin(0.233519986271858*x_116 + 1.79903984069824) + 0.0174047102936231*std::sin(0.251039981842041*x_116 + 5.16688013076782) - 0.0114905246047127*std::sin(0.262319952249527*x_116 - 1.23943984508514) + 0.000123174149928938*std::sin(1.02279984951019*x_116 + 8.39000034332275) + 0.0293989341422877*std::sin(0.218319997191429*x_118 - 4.21447992324829) + 0.00832386818443914*std::sin(0.226719990372658*x_119 + 5.18576002120972) - 0.0456445670471998*std::sin(0.235759988427162*x_119 + 5.17343997955322) + 0.00989165484270415*std::sin(0.276479959487915*x_12 - 7.43616008758545) - 0.000925441846527503*std::sin(0.298639953136444*x_12 + 5.12664031982422) + 2.56268688277946e-6*std::sin(0.539439857006073*x_12 + 7.83392000198364) + 8.00823914230891e-6*std::sin(0.179840013384819*x_13 + 1.59295988082886) - 0.00711382945024967*std::sin(0.232399985194206*x_13 - 7.40807962417603) - 4.99802458924881e-5*std::sin(0.295279920101166*x_13 - 4.40863990783691) + 0.0106949928946*std::sin(0.305279940366745*x_13 + 5.13495969772339) - 0.00113058189306499*std::sin(0.121120058000088*x_14 - 1.25951981544495) + 0.00351919666603925*std::sin(0.243039980530739*x_14 - 1.1814398765564) - 0.00547253105495506*std::sin(0.303039938211441*x_14 - 7.43951988220215) - 0.00334733132497465*std::sin(0.442319840192795*x_14 - 1.44655990600586) + 5.38973491436096e-5*std::sin(0.53143984079361*x_14 - 1.31679975986481) + 0.00303408001849203*std::sin(0.538719832897186*x_14 + 1.86799991130829) - 0.000738174002088165*std::sin(0.244799971580505*x_15 - 1.17535984516144) + 0.0129688614317797*std::sin(0.267919957637787*x_15 + 1.98791980743408) - 0.000421495789406081*std::sin(0.270559966564178*x_15 + 1.77759981155396) - 0.00735598656091938*std::sin(0.29615992307663*x_15 + 5.17063999176025) + 0.0214865936543179*std::sin(0.316639930009842*x_15 + 5.14856004714966) + 0.00338890161301999*std::sin(0.502879858016968*x_15 + 8.08672046661377) - 0.00693519402032809*std::sin(0.297039926052094*x_16 + 2.00455975532532) - 0.00446774387407054*std::sin(0.314639925956726*x_16 + 1.9968798160553) - 0.0202951753138625*std::sin(0.387599855661392*x_16 - 1.18503987789154) + 0.00449051062642056*std::sin(0.51095986366272*x_16 + 8.10847949981689) - 0.00732576572456425*std::sin(0.27975994348526*x_17 - 7.37399959564209) - 0.00605978140889738*std::sin(0.344799846410751*x_17 + 1.99871981143951) - 0.0185444197254504*std::sin(0.380239844322205*x_17 - 1.1743198633194) - 0.00535937667141282*std::sin(0.383119851350784*x_17 + 1.99287974834442) + 0.000799445240998276*std::sin(0.428399860858917*x_17 - 1.20383989810944) - 0.000349401540164036*std::sin(0.606959879398346*x_17 + 5.00175952911377) - 0.00504614385504029*std::sin(0.314559936523438*x_18 - 1.15207993984222) + 0.0103685281008667*std::sin(0.374319821596146*x_18 + 2.02303981781006) + 0.00729275144851551*std::sin(0.431999862194061*x_18 - 7.42375993728638) + 0.00488498983850568*std::sin(0.51775985956192*x_18 + 2.0559196472168) - 0.000239922948928011*std::sin(0.524639844894409*x_18 + 2.05535984039307) - 0.00140180133048063*std::sin(0.222240000963211*x_19 + 8.1947193145752) + 0.00968212843847188*std::sin(0.25655996799469*x_19 + 8.21303939819336) - 0.00866688519042964*std::sin(0.257999986410141*x_19 + 8.2061595916748) - 0.000261346744706939*std::sin(0.39319983124733*x_19 - 1.2047199010849) - 0.019677319922692*std::sin(0.365679860115051*x_2 + 5.18024015426636) + 0.0105121028299353*std::sin(0.377919852733612*x_2 + 5.17736005783081) + 0.00220047336267644*std::sin(0.388719856739044*x_2 + 5.18279981613159) - 0.0012537145805679*std::sin(0.399199843406677*x_2 + 5.20344018936157) + 0.00209139520466889*std::sin(0.409279853105545*x_2 - 1.17679977416992) - 3.26456756206983e-6*std::sin(0.337519854307175*x_20 - 7.79392004013062) + 0.00292534306148658*std::sin(0.415519863367081*x_20 + 7.59352016448975) - 0.00085511576871786*std::sin(0.317199915647507*x_21 - 1.19207990169525) - 0.0162345078806771*std::sin(0.340239852666855*x_21 + 2.04071974754333) + 0.000881770036465334*std::sin(0.317359924316406*x_22 + 8.25111961364746) - 0.00212019275591692*std::sin(0.399679869413376*x_22 + 2.00927972793579) - 3.9941375030374e-6*std::sin(0.482559859752655*x_22 + 4.98415994644165) - 0.0184797433171369*std::sin(0.275279939174652*x_23 - 1.15063989162445) - 0.00298715991409175*std::sin(0.319999933242798*x_23 - 1.16799986362457) - 0.00373583769848106*std::sin(0.354399859905243*x_23 - 1.39335989952087) - 0.00142244515525292*std::sin(0.366559833288193*x_23 - 7.36911964416504) - 0.00595747666097193*std::sin(0.370399862527847*x_23 + 1.99191975593567) - 0.00151606381121108*std::sin(0.832639873027802*x_23 - 7.78951978683472) - 0.00323284013364363*std::sin(0.386879861354828*x_24 - 1.19351994991302) - 0.0042314397869721*std::sin(0.442479848861694*x_24 - 1.21311986446381) + 1.42433310320357e-6*std::sin(0.827359914779663*x_24 + 1.80167984962463) + 0.00267014776555033*std::sin(0.261439979076385*x_25 - 7.37575960159302) - 0.00236173892886716*std::sin(0.324319839477539*x_25 - 1.13855993747711) + 0.00409346948726457*std::sin(0.338639855384827*x_25 - 1.14871978759766) + 0.00911778961318279*std::sin(0.152400031685829*x_26 + 8.14935970306396) + 0.00405398956156815*std::sin(0.284159928560257*x_26 + 1.98807990550995) + 0.00127421111910923*std::sin(0.304559946060181*x_26 - 1.17807984352112) + 5.63876955536135e-5*std::sin(0.783759832382202*x_26 - 1.39231991767883) + 0.00071844886617278*std::sin(0.285999923944473*x_27 - 7.39047956466675) - 0.00280591250666753*std::sin(0.367839843034744*x_27 + 5.23767995834351) - 0.000343441439766127*std::sin(0.463919848203659*x_27 + 4.5776801109314) - 0.0146604454675563*std::sin(0.0912800803780556*x_28 + 2.02471995353699) - 7.72779537147426e-5*std::sin(0.805839836597443*x_28 + 4.79120016098022) - 0.000197251180708138*std::sin(0.323039919137955*x_29 + 4.80983972549438) + 0.000357213649457022*std::sin(0.377759844064713*x_29 - 1.18191993236542) + 0.00189860857453628*std::sin(0.856159865856171*x_29 - 5.43487977981567) - 0.00103979614492735*std::sin(0.2743199467659*x_3 - 1.15183985233307) + 0.00298273918973931*std::sin(0.2882399559021*x_3 - 1.13159990310669) - 0.00138888001348031*std::sin(0.316159933805466*x_3 + 8.28087997436523) - 0.0246750883902088*std::sin(0.344079852104187*x_3 - 7.40455961227417) - 3.14884239224671e-5*std::sin(0.348319828510284*x_3 + 1.97527980804443) - 0.00155647597028132*std::sin(0.359439849853516*x_3 - 7.39336013793945) - 0.0177074504452504*std::sin(0.372479856014252*x_3 + 5.19831991195679) + 0.0165183790699937*std::sin(0.396399825811386*x_3 - 7.40655994415283) - 0.0538492271369284*std::sin(0.259519964456558*x_30 + 1.99079978466034) - 0.0141859494223182*std::sin(0.266159951686859*x_30 - 1.1651998758316) + 0.033491638200949*std::sin(0.284959942102432*x_30 - 1.16359984874725) + 0.00335064304961283*std::sin(0.304079920053482*x_30 - 1.16567981243134) - 0.00281123633012401*std::sin(0.308239936828613*x_30 + 2.00159978866577) - 0.275949458007948*std::sin(0.312719941139221*x_30 + 1.99159979820251) - 0.00020216770913199*std::sin(0.765519857406616*x_30 - 7.37951993942261) + 0.00715128966802812*std::sin(0.293119937181473*x_31 - 1.07175981998444) - 0.00058569779092294*std::sin(0.309599936008453*x_31 - 4.056960105896) + 0.000247918781802631*std::sin(0.340319842100143*x_31 - 1.01967978477478) - 0.00082748905101185*std::sin(0.350399851799011*x_31 + 5.15687990188599) - 0.00182576911052505*std::sin(0.375759840011597*x_31 - 7.39991998672485) + 0.00272920688484872*std::sin(0.376639842987061*x_31 - 4.22408008575439) + 6.66047111661134e-5*std::sin(0.386079847812653*x_31 - 7.39783954620361) - 0.000513313753065332*std::sin(0.396079838275909*x_31 + 8.38568019866943) + 0.137361035556991*std::sin(0.405199855566025*x_31 + 5.19992017745972) - 0.000671106715694153*std::sin(0.613279819488525*x_31 + 5.1956000328064) - 0.0311699458092764*std::sin(0.285679936408997*x_32 + 8.2425594329834) + 0.010274752060664*std::sin(0.302159935235977*x_32 - 1.14591991901398) - 0.00370394624776492*std::sin(0.30839991569519*x_32 - 1.14823985099792) + 0.0025067180679213*std::sin(0.213440001010895*x_33 + 1.971599817276) + 0.00478433352466636*std::sin(0.233039990067482*x_33 + 1.9968798160553) + 0.0106603941374444*std::sin(0.233519986271858*x_33 - 1.17975986003876) + 0.000294998720562526*std::sin(0.225599989295006*x_34 + 1.77711987495422) - 0.000186081885190308*std::sin(0.179120019078255*x_35 + 8.19151973724365) + 7.97450131557002e-5*std::sin(0.179520010948181*x_35 + 8.40520000457764) - 0.00142060072494184*std::sin(0.1893600076437*x_36 - 7.60423994064331) - 7.84405118361527e-5*std::sin(0.291999936103821*x_37 + 4.77928018569946) + 0.00079951733430165*std::sin(0.538559854030609*x_37 - 0.706639885902405) + 0.00633229848839111*std::sin(0.178640007972717*x_4 + 8.1755199432373) + 0.0039843091123189*std::sin(0.249199971556664*x_4 - 7.36111974716187) - 0.00117929776646346*std::sin(0.375919848680496*x_4 + 1.9793598651886) - 0.000958269155732697*std::sin(0.772719860076904*x_4 + 8.20959949493408) + 0.000619538514651112*std::sin(0.862319886684418*x_4 + 7.99488019943237) - 0.00148848381129099*std::sin(0.16312001645565*x_40 + 5.19856023788452) - 0.000458344411840664*std::sin(0.171840012073517*x_41 - 1.20207989215851) + 7.57897064035335e-5*std::sin(0.697999835014343*x_42 + 4.62016010284424) - 0.002192055530365*std::sin(0.459839850664139*x_44 - 1.4592798948288) - 0.00158419970839317*std::sin(0.576399862766266*x_45 + 5.03351974487305) + 2.80963132845944e-5*std::sin(0.665839850902557*x_47 + 7.57984018325806) - 0.00395813890180269*std::sin(0.228719994425774*x_48 - 7.5971999168396) - 0.000109049355975259*std::sin(0.467279851436615*x_49 - 1.34599983692169) - 0.0140360609399616*std::sin(0.254319965839386*x_5 - 7.56360006332397) - 0.019212155057661*std::sin(0.265679955482483*x_5 + 2.00615978240967) + 0.0303410065818488*std::sin(0.350159853696823*x_5 - 1.14927983283997) - 0.0045308031495326*std::sin(0.359199851751328*x_5 + 2.00079965591431) + 0.00314508777296125*std::sin(0.386959850788116*x_5 - 7.39559984207153) + 0.000480405516372084*std::sin(0.685359835624695*x_5 - 4.65687990188599) - 0.00026498933524325*std::sin(0.209279999136925*x_50 + 8.17591953277588) - 0.000531335612491418*std::sin(0.224399983882904*x_50 + 4.37063980102539) - 0.0451463554255561*std::sin(0.16872002184391*x_51 + 8.20335960388184) + 0.00973316316324926*std::sin(0.255279958248138*x_52 - 1.2079998254776) - 0.00790756846852177*std::sin(0.233999982476234*x_53 - 7.42159986495972) + 0.000713857838015925*std::sin(0.20024000108242*x_54 + 5.00152015686035) + 0.00205381532688254*std::sin(0.5655198097229*x_54 + 4.83576011657715) + 0.00126062471588021*std::sin(0.589199841022491*x_54 + 1.78703987598419) - 0.000775867542032986*std::sin(0.337999850511551*x_56 + 1.85591995716095) - 0.00743502327467546*std::sin(0.169280022382736*x_57 + 1.61479985713959) + 0.000496897686947061*std::sin(0.29351994395256*x_57 - 1.42783987522125) + 0.00162520395352819*std::sin(0.299759924411774*x_58 + 1.87479984760284) + 0.00116796503430972*std::sin(0.48447984457016*x_58 + 4.6911997795105) - 0.000202356685093239*std::sin(0.359359860420227*x_59 + 4.64055967330933) + 0.00589376509404394*std::sin(0.606719851493835*x_59 - 7.81207990646362) - 0.00993249212669119*std::sin(0.323439925909042*x_6 + 2.01247978210449) - 0.0206261079672067*std::sin(0.342959851026535*x_6 + 2.01183986663818) - 0.00186921462226586*std::sin(0.344479858875275*x_6 + 2.01703977584839) - 0.00554915827949445*std::sin(0.366239845752716*x_6 + 1.99223983287811) - 0.00886340476795564*std::sin(0.367599844932556*x_6 - 1.16799986362457) + 0.113062204652252*std::sin(0.378479838371277*x_6 + 1.99007987976074) + 0.00523089285511158*std::sin(0.38351982831955*x_6 - 1.17855989933014) + 0.00331008412463109*std::sin(0.358639866113663*x_60 + 8.24847984313965) + 0.000103279811737556*std::sin(0.452159851789474*x_60 - 7.48456001281738) + 7.29106181215713e-5*std::sin(1.41623985767365*x_64 + 6.79663991928101) - 2.91048370036737e-7*std::sin(1.77119994163513*x_64 + 3.59479999542236) - 0.0275875837999943*std::sin(0.26079997420311*x_7 + 2.03239989280701) + 0.00198613699143384*std::sin(0.322959840297699*x_7 - 7.339439868927) + 0.00361468039397083*std::sin(0.330399841070175*x_7 - 1.15071988105774) - 0.00896862199005891*std::sin(0.354959845542908*x_7 + 2.00631976127625) - 0.17971598084917*std::sin(0.359199851751328*x_7 - 1.15143990516663) - 1.57517448611225e-5*std::sin(0.376479834318161*x_7 + 2.02695989608765) + 0.00704856528087357*std::sin(0.480159848928452*x_7 + 1.93423986434937) - 3.59542408799755e-7*std::sin(1.0732798576355*x_70 + 2.81663990020752) + 6.71464904411269e-6*std::sin(1.18463981151581*x_70 - 9.6071195602417) + 2.59469428347e-5*std::sin(0.909999787807465*x_72 + 7.97391986846924) + 0.00167508327688697*std::sin(1.2240799665451*x_73 - 0.783519864082336) - 0.000835446000454853*std::sin(1.13831984996796*x_75 - 2.37199997901917) + 0.000365026442653424*std::sin(1.22527992725372*x_75 + 3.99287986755371) + 5.39008052562472e-5*std::sin(1.41495978832245*x_77 + 1.97983980178833) - 1.50133143057574e-5*std::sin(0.803119838237762*x_78 + 3.78615999221802) - 0.0111332434725223*std::sin(0.295279920101166*x_8 - 1.19455993175507) - 0.00161503140768722*std::sin(0.307679921388626*x_8 + 2.11904001235962) - 0.03166131017739*std::sin(0.314959913492203*x_8 + 5.15392017364502) - 8.52223593500841e-5*std::sin(0.398239850997925*x_8 - 7.80751991271973) + 1.17267560348301e-6*std::sin(0.451759845018387*x_8 + 7.95944023132324) + 0.00195911826794585*std::sin(0.171200007200241*x_87 + 5.50552034378052) + 0.0011171234351665*std::sin(0.180960014462471*x_88 - 7.25880002975464) - 0.000313900143475621*std::sin(1.14111983776093*x_88 - 1.60359990596771) + 0.00932331243858289*std::sin(0.376639842987061*x_9 - 4.38687992095947) - 0.00170050946260516*std::sin(0.452639847993851*x_9 - 4.27943992614746) + 0.00525466674676515*std::sin(0.485359847545624*x_9 - 4.47983980178833) - 1.67301977536365e-5*std::sin(1.79071986675262*x_90 - 2.39239978790283) - 0.00049865971373642*std::sin(0.329519838094711*x_91 - 4.20544004440308) - 0.000414570296001904*std::sin(0.370879858732224*x_91 + 5.18943977355957) + 0.000577746546397726*std::sin(0.388959854841232*x_91 + 1.971599817276) + 0.00573325441724666*std::sin(0.417119860649109*x_91 + 8.21047973632813) + 0.00175258110119931*std::sin(0.227119997143745*x_92 + 2.01871991157532) + 0.0021551247705543*std::sin(0.239759981632233*x_92 + 5.19600009918213) + 0.0485647647021479*std::sin(0.253919988870621*x_92 + 2.02055978775024) + 0.00453993445906669*std::sin(0.285359919071198*x_92 + 1.99703979492188) - 0.0257602746697579*std::sin(0.303839921951294*x_92 + 1.98935985565186) + 0.000999932829864944*std::sin(0.321039855480194*x_92 - 1.1814398765564) + 0.000472295557009078*std::sin(0.327039837837219*x_92 + 8.22480010986328) - 0.0120179576640829*std::sin(0.257679969072342*x_94 - 7.39807987213135) + 0.00167896831305864*std::sin(0.275759935379028*x_94 + 1.97855985164642) + 0.00522987149396666*std::sin(0.285999953746796*x_94 - 1.19919991493225) + 0.00145051629676971*std::sin(0.287839949131012*x_94 + 1.97927987575531) - 0.000182511598178*std::sin(0.310879945755005*x_94 + 1.79847991466522) + 0.000483261387751183*std::sin(0.253759980201721*x_95 - 7.40999984741211) - 0.00141806647781903*std::sin(0.262319982051849*x_96 - 1.20431983470917) - 0.000176947045209545*std::sin(0.30447992682457*x_96 - 4.41775989532471) + 6.2642959278013e-6*std::sin(0.273119956254959*x_97 + 1.96655988693237) - 0.000877857149362381*std::sin(0.27991995215416*x_97 + 1.97735977172852) + 0.000637955651821456*std::sin(0.261359959840775*x_98 - 4.42471981048584) + 0.277123941574988);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000634131707403491*x_1 + 0.000581211653607587*x_10 - 0.000112653977175895*x_100 + 0.00237332148897859*x_101 + 0.000249792756002525*x_102 + 0.000649150027480964*x_103 + 9.62723385891334e-5*x_104 - 0.00115580231243778*x_105 - 0.000458484216233339*x_106 - 0.00046982875155486*x_107 - 0.00052789991389346*x_108 + 0.00137421649197775*x_109 - 0.0008866422476349*x_11 + 0.000635047318277693*x_110 - 0.000767798215567807*x_111 - 0.00639437587014778*x_112 + 8.15391471659323e-5*x_113 + 0.00373871209681957*x_114 + 0.00124701491510162*x_115 + 0.00164469101439374*x_116 + 0.0113500257157556*x_117 + 0.00475621162128463*x_118 + 0.0109374005348344*x_119 + 0.000156444668747629*x_12 + 0.00737400723191605*x_120 + 0.00117066150572199*x_13 + 0.000209099339967445*x_14 - 0.00070877395311881*x_15 + 0.000127749748371567*x_16 - 0.000516481620604588*x_17 - 0.00516152684590849*x_18 - 0.00120808660482702*x_19 - 0.000419770267684634*x_2 - 0.000117004334742935*x_20 + 0.000738388785149139*x_21 + 6.49192489473872e-5*x_22 + 0.000317622428403396*x_23 + 7.42231230966457e-5*x_24 + 0.000208730868902315*x_25 + 0.00115666615307784*x_26 + 0.00079448996178542*x_27 + 0.000569576696290105*x_28 + 0.000846348492514591*x_29 - 0.000332895648407743*x_3 + 0.000371485357505253*x_30 + 0.000406986905702557*x_31 + 0.000346279938588206*x_32 - 0.00349538924628793*x_33 + 0.00366555456999824*x_34 + 0.000796894637061488*x_35 + 0.000765600106900998*x_36 - 0.00132491207010892*x_37 - 0.000640843447629523*x_38 + 0.000584247121328287*x_39 - 0.00039756624831214*x_4 - 8.49938724332716e-5*x_40 + 0.00133424373241295*x_41 - 0.000513247930419302*x_42 + 9.31454601177758e-5*x_43 - 0.000923354119966362*x_44 - 0.000354621356038489*x_45 + 0.000145671760444197*x_46 + 0.000990564711891539*x_47 + 0.00296572318815731*x_48 + 0.000428262272636983*x_49 - 0.00254500185942351*x_5 + 0.000108817918473186*x_50 + 0.00290486642104464*x_51 - 0.000876628244517657*x_52 - 0.00187434938173314*x_53 + 0.000203087587402203*x_54 + 0.000952826734390573*x_55 - 0.00177937811533198*x_56 + 0.0020215100970323*x_57 + 0.00104884638612761*x_58 + 0.000614600655229677*x_59 + 0.000372266763561448*x_6 + 0.00136393584002269*x_60 + 0.000935866310975365*x_61 + 0.000223885366951672*x_62 - 0.00039673504219206*x_63 + 0.000665135865746104*x_64 + 6.03158339429549e-5*x_65 + 0.000171733982339991*x_66 + 0.00231066947813058*x_67 - 0.000148911690434594*x_68 - 0.000167696909535161*x_69 + 0.000143315938504061*x_7 + 0.000860534336055303*x_70 + 0.000703713821705891*x_71 + 0.00054056048821482*x_72 + 0.00025038431678552*x_73 + 0.00102953604438686*x_74 + 0.000287398082908471*x_75 + 0.000721914311226221*x_76 - 0.000213142618289624*x_77 - 0.000185559127993544*x_78 - 0.000215571907670432*x_79 - 0.00189803118197662*x_8 + 0.00148062173738642*x_80 + 0.002387687453384*x_81 + 0.000768013777052325*x_82 - 0.000701689124863049*x_83 + 0.000529402727616981*x_84 + 0.0006220598801305*x_85 + 0.000291650826564642*x_86 + 0.000773328900863764*x_87 - 0.000135499990561158*x_88 + 0.000614908658234746*x_89 - 0.000102551646136878*x_9 - 0.000139242136842103*x_90 + 0.00123632622295585*x_91 - 0.000477381486853115*x_92 + 0.000542639172924231*x_93 - 8.33443432942771e-5*x_94 - 0.000515277914304312*x_95 - 3.11584947853368e-5*x_96 + 0.000351597944291054*x_97 - 0.00239918042715608*x_98 + 0.00109913564741039*x_99 - 2.94331038508292e-7*std::pow(5.30704021453857 - 8.17615985870361*x_15, 2) - 9.11152818365462e-7*std::pow(5.54383993148804 - 0.991999804973602*x_10, 2) - 6.55341270310853e-6*std::pow(-2.62831997871399*x_16 - 9.89848041534424, 2) + 1.11368440613169e-5*std::pow(-3.71199989318848*x_25 - 8.0, 2) - 2.21504559803104e-7*std::pow(-9.3261604309082*x_28 - 1.61375975608826, 2) - 5.08405743230494e-8*std::pow(-5.89263963699341*x_60 - 9.60136032104492, 2) - 3.16814167759183e-6*std::pow(-3.8724000453949*x_61 - 6.51895952224731, 2) + 3.71987606896049e-6*std::pow(-2.83240008354187*x_64 - 9.11664009094238, 2) - 8.40966658502939e-6*std::pow(-2.76160001754761*x_64 - 6.32287979125977, 2) - 2.6768468568694e-7*std::pow(-3.67159986495972*x_9 - 7.73672008514404, 2) + 0.0139463848352722*std::exp(0.208559840917587*x_13) - 6.24215964775299e-5*std::exp(0.253679871559143*x_13) + 1.75386149508865e-5*std::exp(0.541759848594666*x_13) - 0.00320906482504404*std::exp(0.318959832191467*x_18) - 0.00039518238056231*std::exp(0.403919875621796*x_18) + 0.000201290446639212*std::exp(0.45007985830307*x_18) + 3.33544738491649e-6*std::exp(0.356479853391647*x_19) - 0.000626145076957475*std::exp(0.250079840421677*x_20) - 2.64620437192364e-5*std::exp(0.548639833927155*x_22) - 4.48005317374193e-5*std::exp(0.370639860630035*x_5) - 0.000234530255818504*std::exp(0.319119840860367*x_59) - 4.15204831311449e-5*std::exp(0.324639827013016*x_6) + 0.00290561340573723*std::log(5.16136026382446 - 0.59639984369278*x_9) + 0.0802001422484232*std::sin(0.332799851894379*x_1 - 4.25031995773315) - 0.0034717340047903*std::sin(0.337039858102798*x_1 - 4.24552011489868) + 0.0104635431251638*std::sin(0.344959855079651*x_1 - 4.25184011459351) - 0.00787342510847358*std::sin(0.351919859647751*x_1 - 4.22544002532959) + 0.00298591956774916*std::sin(0.353119850158691*x_1 - 4.22032022476196) - 0.000978706316083803*std::sin(0.358719855546951*x_1 - 4.23680019378662) + 0.000406741408997561*std::sin(0.403519839048386*x_1 - 4.18416023254395) + 6.18030527710303e-5*std::sin(0.225759983062744*x_107 - 4.39264011383057) - 0.0117381051358228*std::sin(0.206160008907318*x_108 - 4.39903974533081) + 0.000263530177689211*std::sin(0.20584000647068*x_109 + 5.18096017837524) - 0.00664642563287419*std::sin(0.102400071918964*x_11 - 4.28399991989136) - 0.000503683794890552*std::sin(0.175360009074211*x_11 + 5.18400001525879) + 0.0628504520408243*std::sin(0.283119946718216*x_11 - 7.42775964736938) + 0.0138760193319429*std::sin(0.282959938049316*x_112 - 7.43111991882324) + 4.5151050339152e-5*std::sin(0.323279827833176*x_112 - 1.34607982635498) + 0.000331117385649804*std::sin(0.254479974508286*x_113 - 4.22528028488159) - 4.57430212161569e-5*std::sin(0.283679932355881*x_113 + 1.96335983276367) + 0.0239058183657986*std::sin(0.287439942359924*x_113 - 7.42911958694458) - 0.0152596098064806*std::sin(0.2880799472332*x_113 - 7.42679977416992) + 0.0082632225082559*std::sin(0.233999982476234*x_114 + 1.97791981697083) + 0.00100027662195389*std::sin(0.241119980812073*x_114 - 1.23959982395172) + 6.2189982015507e-5*std::sin(0.227039992809296*x_116 + 5.1735200881958) + 0.0195932435567218*std::sin(0.233519986271858*x_116 + 1.79903984069824) - 0.000620730761610587*std::sin(0.251039981842041*x_116 + 5.16688013076782) - 0.00308278827067043*std::sin(0.262319952249527*x_116 - 1.23943984508514) + 0.000120483277736346*std::sin(1.02279984951019*x_116 + 8.39000034332275) - 0.023034642698081*std::sin(0.218319997191429*x_118 - 4.21447992324829) - 0.0122459627174224*std::sin(0.235759988427162*x_119 + 5.17343997955322) + 0.000112567291175931*std::sin(0.276479959487915*x_12 - 7.43616008758545) + 0.0560621492895015*std::sin(0.298639953136444*x_12 + 5.12664031982422) + 0.00105063499616055*std::sin(0.232399985194206*x_13 - 7.40807962417603) + 0.000229983275405836*std::sin(0.295279920101166*x_13 - 4.40863990783691) + 0.000121709299246215*std::sin(0.305279940366745*x_13 + 5.13495969772339) + 0.0684892855351697*std::sin(0.121120058000088*x_14 - 1.25951981544495) + 4.00485502285386e-5*std::sin(0.243039980530739*x_14 - 1.1814398765564) + 0.000808233130147559*std::sin(0.303039938211441*x_14 - 7.43951988220215) - 0.000898054188269808*std::sin(0.442319840192795*x_14 - 1.44655990600586) + 0.000204728621771866*std::sin(0.53143984079361*x_14 - 1.31679975986481) + 8.00529543056198e-5*std::sin(0.538719832897186*x_14 + 1.86799991130829) + 0.0447176894604211*std::sin(0.244799971580505*x_15 - 1.17535984516144) + 0.00347941066933035*std::sin(0.267919957637787*x_15 + 1.98791980743408) - 0.000160812582287659*std::sin(0.270559966564178*x_15 + 1.77759981155396) + 0.000262347781912215*std::sin(0.29615992307663*x_15 + 5.17063999176025) + 8.94147762484409e-5*std::sin(0.502879858016968*x_15 + 8.08672046661377) - 0.00170457083426985*std::sin(0.314639925956726*x_16 + 1.9968798160553) - 0.00544498450341551*std::sin(0.387599855661392*x_16 - 1.18503987789154) + 0.00011848027731464*std::sin(0.51095986366272*x_16 + 8.10847949981689) - 0.0001932873178123*std::sin(0.27975994348526*x_17 - 7.37399959564209) - 0.00231197824736675*std::sin(0.344799846410751*x_17 + 1.99871981143951) - 0.00497527498375145*std::sin(0.380239844322205*x_17 - 1.1743198633194) + 0.00419917695359069*std::sin(0.383119851350784*x_17 + 1.99287974834442) + 0.00303668594044499*std::sin(0.428399860858917*x_17 - 1.20383989810944) + 1.2461240691458e-5*std::sin(0.606959879398346*x_17 + 5.00175952911377) + 0.00074526039271011*std::sin(0.314559936523438*x_18 - 1.15207993984222) - 0.000369788651247465*std::sin(0.374319821596146*x_18 + 2.02303981781006) + 0.00131059197856929*std::sin(0.51775985956192*x_18 + 2.0559196472168) - 9.15374006975239e-5*std::sin(0.524639844894409*x_18 + 2.05535984039307) + 0.0849194314678001*std::sin(0.222240000963211*x_19 + 8.1947193145752) - 0.00142994473594286*std::sin(0.25655996799469*x_19 + 8.21303939819336) + 0.00120258272625642*std::sin(0.39319983124733*x_19 - 1.2047199010849) + 0.00070178230927193*std::sin(0.365679860115051*x_2 + 5.18024015426636) - 0.00155252289833582*std::sin(0.377919852733612*x_2 + 5.17736005783081) + 0.00083954291502135*std::sin(0.388719856739044*x_2 + 5.18279981613159) + 0.0759485150211796*std::sin(0.399199843406677*x_2 + 5.20344018936157) - 0.00163864924649541*std::sin(0.409279853105545*x_2 - 1.17679977416992) + 0.00240111510575415*std::sin(0.415519863367081*x_20 + 7.59352016448975) - 0.000836434842201884*std::sin(0.317199915647507*x_21 - 1.19207990169525) + 0.0127200559925292*std::sin(0.340239852666855*x_21 + 2.04071974754333) + 0.00545869298486869*std::sin(0.317359924316406*x_22 + 8.25111961364746) - 0.000808913589639928*std::sin(0.399679869413376*x_22 + 2.00927972793579) + 0.000659071305991077*std::sin(0.275279939174652*x_23 - 1.15063989162445) - 0.0184923372233171*std::sin(0.319999933242798*x_23 - 1.16799986362457) - 0.00100228640851457*std::sin(0.354399859905243*x_23 - 1.39335989952087) + 0.000210079630201886*std::sin(0.366559833288193*x_23 - 7.36911964416504) + 0.00118786579233517*std::sin(0.832639873027802*x_23 - 7.78951978683472) + 0.000477455216652563*std::sin(0.386879861354828*x_24 - 1.19351994991302) + 0.000150912298875718*std::sin(0.442479848861694*x_24 - 1.21311986446381) - 0.00209211325257063*std::sin(0.261439979076385*x_25 - 7.37575960159302) + 0.00156177455459359*std::sin(0.338639855384827*x_25 - 1.14871978759766) - 0.000598730028213364*std::sin(0.284159928560257*x_26 + 1.98807990550995) + 0.00124637460251966*std::sin(0.304559946060181*x_26 - 1.17807984352112) - 0.000259467049119824*std::sin(0.783759832382202*x_26 - 1.39231991767883) + 0.000274108592101676*std::sin(0.285999923944473*x_27 - 7.39047956466675) + 1.2248676529409e-5*std::sin(0.463919848203659*x_27 + 4.5776801109314) + 0.0114867471557111*std::sin(0.0912800803780556*x_28 + 2.02471995353699) - 0.000293539649143304*std::sin(0.805839836597443*x_28 + 4.79120016098022) - 0.000749256930274063*std::sin(0.323039919137955*x_29 + 4.80983972549438) + 0.00221136981497675*std::sin(0.377759844064713*x_29 - 1.18191993236542) + 0.00155837371289943*std::sin(0.856159865856171*x_29 - 5.43487977981567) + 0.00478460477523769*std::sin(0.2743199467659*x_3 - 1.15183985233307) + 0.00113799948528183*std::sin(0.2882399559021*x_3 - 1.13159990310669) + 0.0841366736906294*std::sin(0.316159933805466*x_3 + 8.28087997436523) + 0.0193334167103174*std::sin(0.344079852104187*x_3 - 7.40455961227417) - 0.00963553319882553*std::sin(0.359439849853516*x_3 - 7.39336013793945) - 0.00475072482884784*std::sin(0.372479856014252*x_3 + 5.19831991195679) + 0.00043583064284189*std::sin(0.396399825811386*x_3 - 7.40655994415283) + 0.0421919277979113*std::sin(0.259519964456558*x_30 + 1.99079978466034) + 0.000505935177347431*std::sin(0.266159951686859*x_30 - 1.1651998758316) + 0.00898545827655919*std::sin(0.284959942102432*x_30 - 1.16359984874725) + 0.0127273890923455*std::sin(0.304079920053482*x_30 - 1.16567981243134) - 0.00107256628661734*std::sin(0.308239936828613*x_30 + 2.00159978866577) - 0.226498703954006*std::sin(0.312719941139221*x_30 + 1.99159979820251) - 0.000197751137415788*std::sin(0.765519857406616*x_30 - 7.37951993942261) + 0.000188683838768839*std::sin(0.293119937181473*x_31 - 1.07175981998444) - 0.000223460296794928*std::sin(0.309599936008453*x_31 - 4.056960105896) + 0.00153476809040609*std::sin(0.340319842100143*x_31 - 1.01967978477478) + 0.0038076771915757*std::sin(0.350399851799011*x_31 + 5.15687990188599) + 0.110602887503395*std::sin(0.375759840011597*x_31 - 7.39991998672485) - 0.000502099860337064*std::sin(0.396079838275909*x_31 + 8.38568019866943) + 0.112745633754941*std::sin(0.405199855566025*x_31 + 5.19992017745972) - 7.63721200112296e-6*std::sin(0.613279819488525*x_31 + 5.1956000328064) - 0.000822406209582703*std::sin(0.285679936408997*x_32 + 8.2425594329834) - 0.00151746877927013*std::sin(0.302159935235977*x_32 - 1.14591991901398) - 0.0229296807136403*std::sin(0.30839991569519*x_32 - 1.14823985099792) - 0.00196406287248133*std::sin(0.213440001010895*x_33 + 1.971599817276) - 0.000706593863329433*std::sin(0.233039990067482*x_33 + 1.9968798160553) - 0.000380197915413127*std::sin(0.233519986271858*x_33 - 1.17975986003876) + 0.00182622155424444*std::sin(0.225599989295006*x_34 + 1.77711987495422) - 0.0011519600794911*std::sin(0.179120019078255*x_35 + 8.19151973724365) - 0.000366945360018444*std::sin(0.179520010948181*x_35 + 8.40520000457764) - 1.61664734558763e-5*std::sin(0.1893600076437*x_36 - 7.60423994064331) + 0.000360942718757212*std::sin(0.291999936103821*x_37 + 4.77928018569946) + 2.10949362704058e-5*std::sin(0.538559854030609*x_37 - 0.706639885902405) + 0.0392007801435812*std::sin(0.178640007972717*x_4 + 8.1755199432373) - 0.00312178449588624*std::sin(0.249199971556664*x_4 - 7.36111974716187) - 0.000449935500846363*std::sin(0.375919848680496*x_4 + 1.9793598651886) + 3.41762162558849e-5*std::sin(0.772719860076904*x_4 + 8.20959949493408) + 0.000166215741395453*std::sin(0.862319886684418*x_4 + 7.99488019943237) - 0.00145596627657094*std::sin(0.16312001645565*x_40 + 5.19856023788452) - 0.00174101734545328*std::sin(0.171840012073517*x_41 - 1.20207989215851) + 2.89159196934078e-5*std::sin(0.697999835014343*x_42 + 4.62016010284424) + 0.00171751859002536*std::sin(0.459839850664139*x_44 - 1.4592798948288) + 0.00124125160689929*std::sin(0.576399862766266*x_45 + 5.03351974487305) + 0.00017393327271823*std::sin(0.665839850902557*x_47 + 7.57984018325806) - 0.00106192750983337*std::sin(0.228719994425774*x_48 - 7.5971999168396) + 0.000501788809163429*std::sin(0.467279851436615*x_49 - 1.34599983692169) - 0.0115207677321445*std::sin(0.254319965839386*x_5 - 7.56360006332397) + 0.0150531010774567*std::sin(0.265679955482483*x_5 + 2.00615978240967) - 0.00108209765091483*std::sin(0.350159853696823*x_5 - 1.14927983283997) - 0.00172862973397685*std::sin(0.359199851751328*x_5 + 2.00079965591431) - 0.000464495150379765*std::sin(0.386959850788116*x_5 - 7.39559984207153) - 0.00164044520173964*std::sin(0.209279999136925*x_50 + 8.17591953277588) - 6.04661318602096e-6*std::sin(0.224399983882904*x_50 + 4.37063980102539) - 0.0121122977198396*std::sin(0.16872002184391*x_51 + 8.20335960388184) + 0.00261130646932168*std::sin(0.255279958248138*x_52 - 1.2079998254776) + 0.00619573530800245*std::sin(0.233999982476234*x_53 - 7.42159986495972) - 0.000105429014309124*std::sin(0.20024000108242*x_54 + 5.00152015686035) - 7.32483523457664e-5*std::sin(0.5655198097229*x_54 + 4.83576011657715) - 8.82939294858218e-6*std::sin(0.337999850511551*x_56 + 1.85591995716095) - 0.000196170033368017*std::sin(0.169280022382736*x_57 + 1.61479985713959) - 7.33863670852395e-5*std::sin(0.29351994395256*x_57 - 1.42783987522125) - 4.165492059625e-5*std::sin(0.48447984457016*x_58 + 4.6911997795105) - 0.000768650145206154*std::sin(0.359359860420227*x_59 + 4.64055967330933) + 0.00483758933555094*std::sin(0.606719851493835*x_59 - 7.81207990646362) + 0.000735620386180019*std::sin(0.342959851026535*x_6 + 2.01183986663818) - 0.000713158322838723*std::sin(0.344479858875275*x_6 + 2.01703977584839) + 0.000819550135190028*std::sin(0.366239845752716*x_6 + 1.99223983287811) - 0.00237795933578622*std::sin(0.367599844932556*x_6 - 1.16799986362457) + 0.0928012071659157*std::sin(0.378479838371277*x_6 + 1.99007987976074) - 0.00409850735833731*std::sin(0.38351982831955*x_6 - 1.17855989933014) - 0.000475240346712084*std::sin(0.452159851789474*x_60 - 7.48456001281738) - 2.60032271451732e-6*std::sin(1.41623985767365*x_64 + 6.79663991928101) + 0.0122953963207779*std::sin(0.322959840297699*x_7 - 7.339439868927) + 0.00137910295407244*std::sin(0.330399841070175*x_7 - 1.15071988105774) + 0.00132456761804435*std::sin(0.354959845542908*x_7 + 2.00631976127625) - 0.147510479042099*std::sin(0.359199851751328*x_7 - 1.15143990516663) + 0.00189105677246623*std::sin(0.480159848928452*x_7 + 1.93423986434937) - 0.000406765328961669*std::sin(1.18463981151581*x_70 - 9.6071195602417) - 0.000119394428605425*std::sin(0.909999787807465*x_72 + 7.97391986846924) + 0.00137490464365761*std::sin(1.2240799665451*x_73 - 0.783519864082336) - 0.000685732226809199*std::sin(1.13831984996796*x_75 - 2.37199997901917) + 9.63107266650166e-6*std::sin(1.22527992725372*x_75 + 3.99287986755371) - 7.96056086521165e-6*std::sin(1.41495978832245*x_77 + 1.97983980178833) + 6.90835176394024e-5*std::sin(0.803119838237762*x_78 + 3.78615999221802) - 0.000293746053349683*std::sin(0.295279920101166*x_8 - 1.19455993175507) - 1.83790997177274e-5*std::sin(0.307679921388626*x_8 + 2.11904001235962) - 0.00849440029995535*std::sin(0.314959913492203*x_8 + 5.15392017364502) + 0.00516266759560885*std::sin(0.398239850997925*x_8 - 7.80751991271973) - 0.00153500766684273*std::sin(0.171200007200241*x_87 + 5.50552034378052) + 0.00109271866850793*std::sin(0.180960014462471*x_88 - 7.25880002975464) - 8.28212627518986e-6*std::sin(1.14111983776093*x_88 - 1.60359990596771) + 0.00250134778160353*std::sin(0.376639842987061*x_9 - 4.38687992095947) - 1.93518422213941e-5*std::sin(0.452639847993851*x_9 - 4.27943992614746) + 0.000138642222487961*std::sin(0.485359847545624*x_9 - 4.47983980178833) + 2.47086767761071e-6*std::sin(1.79071986675262*x_90 - 2.39239978790283) + 0.00229457443096083*std::sin(0.329519838094711*x_91 - 4.20544004440308) - 0.00256644235223964*std::sin(0.370879858732224*x_91 + 5.18943977355957) - 0.0349991879632176*std::sin(0.388959854841232*x_91 + 1.971599817276) - 0.0044921175155296*std::sin(0.417119860649109*x_91 + 8.21047973632813) + 0.000668659330973485*std::sin(0.227119997143745*x_92 + 2.01871991157532) - 7.68615057431981e-5*std::sin(0.239759981632233*x_92 + 5.19600009918213) + 0.0398618513052159*std::sin(0.253919988870621*x_92 + 2.02055978775024) - 0.000670498787794703*std::sin(0.285359919071198*x_92 + 1.99703979492188) + 0.0061901925649503*std::sin(0.321039855480194*x_92 - 1.1814398765564) - 0.00217326019952408*std::sin(0.327039837837219*x_92 + 8.22480010986328) - 0.000317088873683648*std::sin(0.257679969072342*x_94 - 7.39807987213135) + 0.000640573967257335*std::sin(0.275759935379028*x_94 + 1.97855985164642) + 0.00897957835509396*std::sin(0.287839949131012*x_94 + 1.97927987575531) + 0.000839824102482833*std::sin(0.310879945755005*x_94 + 1.79847991466522) + 0.00299168200106899*std::sin(0.253759980201721*x_95 - 7.40999984741211) + 0.000209432947317356*std::sin(0.262319982051849*x_96 - 1.20431983470917) + 0.000814218903968859*std::sin(0.30447992682457*x_96 - 4.41775989532471) - 0.00085867941285151*std::sin(0.27991995215416*x_97 + 1.97735977172852) - 9.42190895198522e-5*std::sin(0.261359959840775*x_98 - 4.42471981048584) + 0.361231803894043*std::sin(-0.0101354908388936*x_10 - 7.88369859383005e-5*x_101 + 0.00164403620964177*x_102 + 0.00147918558781973*x_103 + 0.000904065805381372*x_104 + 0.000446998717630135*x_105 + 4.0678516462326e-5*x_106 - 0.0237084733805545*x_107 + 0.00525710012748087*x_108 + 0.00772343540146997*x_109 - 0.00297700717906542*x_11 - 0.00257612279014885*x_110 - 0.0187806539688956*x_111 - 0.00293944598237916*x_112 + 0.0139640842864891*x_113 + 0.0106030228976933*x_114 + 0.00523638368166063*x_115 - 0.00398641304316183*x_116 + 0.0215771128451366*x_117 + 0.0108968689926319*x_118 + 0.00675929608621325*x_119 + 0.0029433387003391*x_120 - 0.00651798631661977*x_14 + 0.00162356889391368*x_15 - 0.00746958988329904*x_16 - 0.0020464788055497*x_17 - 0.00222742616853915*x_18 + 0.00372052888555528*x_19 - 0.00104437669452288*x_2 + 0.000302495946034223*x_21 - 0.0189247772243347*x_23 + 0.000283794113891275*x_25 - 0.00362578669817592*x_27 + 0.00349653069299323*x_28 + 0.00331076410931048*x_29 + 0.00349077742732174*x_30 + 0.000393637052872644*x_32 - 0.00211843045399963*x_33 - 0.022025635616349*x_34 + 0.000596102173595983*x_35 - 0.00224273764365183*x_36 - 0.00765724271453161*x_37 - 0.0053661246629861*x_38 - 0.0083207127208996*x_39 - 0.00195229914096455*x_4 - 0.0105029895167483*x_40 - 0.00100012310708144*x_41 - 0.0067818477439998*x_42 - 0.00955608784752632*x_43 - 0.00655021214012453*x_44 - 0.00563561899650777*x_45 - 0.00854513738924462*x_46 - 0.00872054993403613*x_47 + 0.000465545714570592*x_48 + 0.00108590933690795*x_49 - 0.00141946601139019*x_5 - 0.00244479213464174*x_50 - 0.00444409002234453*x_51 - 0.00446396461200445*x_52 + 0.00568567895995857*x_53 + 0.00967492403316684*x_54 - 0.00144536252314384*x_55 - 0.00425697571281028*x_56 + 0.000698101963372788*x_57 - 0.00373781313633811*x_58 + 0.00107234284993839*x_6 - 0.00346812369556736*x_60 - 0.00300965626637265*x_61 - 0.000969781753909776*x_62 - 0.00611557790363667*x_63 + 0.00401131205404612*x_65 + 0.00178801218613697*x_66 + 0.00401117064096252*x_67 + 0.00751973412831433*x_68 + 0.0015677381110937*x_69 + 0.00177959244370369*x_71 + 0.0128107621411989*x_72 + 0.000805475723213634*x_73 + 0.00738027548328015*x_74 + 0.00540226861540595*x_75 + 0.00174002693441027*x_76 + 0.00326827756951812*x_77 - 0.00132053526995292*x_78 + 0.00498581301285966*x_79 + 0.000650969531331673*x_80 + 0.00633903202218698*x_81 + 0.00650903046456178*x_82 - 0.00128418137757373*x_83 + 0.00625211710061173*x_84 + 0.0018773770537596*x_85 + 0.00278038187087583*x_86 + 0.000901235957403625*x_87 + 0.0060454966153281*x_88 - 0.00022630705495151*x_89 - 0.0262219611105206*x_9 - 0.00319181045456721*x_90 - 0.00829806078823839*x_91 - 0.0114308088245528*x_92 - 0.00105725214871188*x_93 - 0.00776059777760905*x_94 + 0.00046352749859793*x_95 - 0.00893562551126779*x_96 - 0.0136593958627299*x_98 - 0.00213761670653027*x_99 + 4.14192331806805e-5*std::pow(2.4696798324585 - 7.17983961105347*x_59, 2) + 0.00205124196507652*std::exp(0.521439850330353*x_26) - 0.115167824994639*std::sin(0.359119862318039*x_1 - 1.03623986244202) + 0.00854417496869642*std::sin(1.34607982635498*x_100 - 4.97455978393555) + 0.0359948614167513*std::sin(0.539439857006073*x_12 + 7.83392000198364) + 0.112481731598429*std::sin(0.179840013384819*x_13 + 1.59295988082886) - 0.0458533025520769*std::sin(0.337519854307175*x_20 - 7.79392004013062) - 0.056100660157651*std::sin(0.482559859752655*x_22 + 4.98415994644165) + 0.0200058278698092*std::sin(0.827359914779663*x_24 + 1.80167984962463) - 0.442278556517145*std::sin(0.348319828510284*x_3 + 1.97527980804443) + 0.935513177297253*std::sin(0.386079847812653*x_31 - 7.39783954620361) - 0.00408799288568618*std::sin(1.77119994163513*x_64 + 3.59479999542236) - 0.221245083493457*std::sin(0.376479834318161*x_7 + 2.02695989608765) - 0.00505004308765017*std::sin(1.0732798576355*x_70 + 2.81663990020752) + 0.016471109333652*std::sin(0.451759845018387*x_8 + 7.95944023132324) + 0.0879867397417557*std::sin(0.273119956254959*x_97 + 1.96655988693237) + 6.44193911994988) - 0.182870447635651*std::sin(0.00165627781839771*x_10 - 0.00399994656467013*x_100 + 0.00365071676364509*x_101 + 0.00811786666357478*x_102 - 0.00461956625038319*x_103 - 0.00486214057084005*x_104 + 0.00918908389741669*x_105 + 0.000249213454301417*x_106 + 0.003002285606544*x_107 + 0.0110776449102955*x_108 + 0.0121767584843924*x_109 - 0.00356811834980739*x_11 - 0.0105710212298565*x_110 + 0.000914140040794968*x_111 + 0.022130764134294*x_112 + 0.0406184302731641*x_113 + 0.0019774761698306*x_114 + 0.00232010808531048*x_115 + 0.000931805543901833*x_117 + 0.00398548478389253*x_118 - 0.00258840106558887*x_12 + 0.000565867239323427*x_120 + 0.000610799910293285*x_13 - 0.00311917809081741*x_17 - 0.00281112064181114*x_2 + 0.00590148715905437*x_20 + 0.00256505453809872*x_21 - 0.00111860107700945*x_24 + 5.28464762628965e-5*x_29 - 0.00078208799809046*x_3 - 0.00105411524131238*x_32 + 0.0160432283732772*x_33 + 0.0169749526698344*x_34 - 0.00312490104039746*x_35 + 0.0021277550098102*x_36 - 0.00202076101306785*x_37 + 0.000800128595756359*x_38 + 0.00259517839415125*x_39 - 0.00313162530679034*x_4 - 0.0012609395057261*x_40 + 0.00128877388052922*x_41 + 0.00257342806630143*x_42 - 0.00161825754766429*x_43 + 0.00436388312581221*x_44 + 0.0075781417360503*x_45 + 0.00316210614145589*x_46 + 0.00309404995296206*x_47 + 0.00691616975212715*x_48 - 0.000287837016686825*x_49 - 0.00292821871605562*x_50 - 0.00152898118428625*x_51 + 0.00180665839811223*x_52 + 0.000740264637216255*x_53 - 0.00230537037736276*x_55 + 0.00191413438946065*x_56 - 0.0109764301640772*x_57 - 0.00661080524953365*x_59 - 0.00372343320899069*x_61 - 0.0091705311563186*x_62 - 0.00256204043087693*x_63 + 0.000849558770426429*x_64 + 0.0059766147581889*x_65 + 0.00121751160483885*x_66 + 0.00277132608465335*x_67 + 0.00735186890251585*x_68 - 0.000452439009000376*x_69 - 0.000402882880316811*x_70 + 0.000474730417454742*x_71 - 0.00221976409388691*x_72 - 0.001792625104726*x_73 - 0.00583412396943265*x_74 - 0.000359314463476962*x_75 + 0.00114372727868225*x_76 - 0.00474242854268623*x_77 - 0.00417991136684449*x_78 + 0.00153723951197431*x_79 - 0.00202827452702871*x_8 - 0.00549109472109454*x_80 - 0.00650553120873249*x_81 + 0.000476678902015178*x_82 + 2.2056854025871e-5*x_83 - 0.000669916881374923*x_84 - 0.00679882625374401*x_85 - 0.00448168747349531*x_86 + 0.000702790450734693*x_87 - 0.00206730524693023*x_88 + 0.000257472516132192*x_89 - 0.00280523770415802*x_9 + 0.00214399055437029*x_90 - 0.0143605326188249*x_91 + 0.00521482550779322*x_93 - 0.00390982395688205*x_95 - 0.0128991754600916*x_96 - 0.00215032988821354*x_97 + 0.00200036374973331*x_98 - 0.0209196414820666*x_99 + 0.0515562086390097*std::exp(0.173759862780571*x_14) + 0.0200742152561595*std::exp(0.326959848403931*x_22) - 0.00499180668153798*std::exp(0.310879856348038*x_28) - 0.0151213700428218*std::exp(0.321919828653336*x_30) + 0.325196053230858*std::sin(0.348479837179184*x_1 + 5.15775966644287) - 0.260104046527996*std::sin(0.209199994802475*x_116 + 2.000159740448) + 0.209274442009264*std::sin(0.226719990372658*x_119 + 5.18576002120972) + 0.540204962170499*std::sin(0.316639930009842*x_15 + 5.14856004714966) - 0.174361105518628*std::sin(0.297039926052094*x_16 + 2.00455975532532) + 0.183350631735546*std::sin(0.431999862194061*x_18 - 7.42375993728638) - 0.217898400358646*std::sin(0.257999986410141*x_19 + 8.2061595916748) - 0.149779835093835*std::sin(0.370399862527847*x_23 + 1.99191975593567) - 0.0593776337585687*std::sin(0.324319839477539*x_25 - 1.13855993747711) + 0.229234809030707*std::sin(0.152400031685829*x_26 + 8.14935970306396) - 0.0705448189649855*std::sin(0.367839843034744*x_27 + 5.23767995834351) + 0.0686163254029282*std::sin(0.376639842987061*x_31 - 4.22408008575439) + 0.0120781100984859*std::sin(0.685359835624695*x_5 - 4.65687990188599) + 0.0316939826716744*std::sin(0.589199841022491*x_54 + 1.78703987598419) + 0.0408600476352663*std::sin(0.299759924411774*x_58 + 1.87479984760284) - 0.249717643470198*std::sin(0.323439925909042*x_6 + 2.01247978210449) + 0.083220444249811*std::sin(0.358639866113663*x_60 + 8.24847984313965) - 0.693592939989188*std::sin(0.26079997420311*x_7 + 2.03239989280701) - 0.64765166723771*std::sin(0.303839921951294*x_92 + 1.98935985565186) + 0.131486757650256*std::sin(0.285999953746796*x_94 - 1.19919991493225) + 0.913071605618395) + 0.282314566951904);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000246457295028879*x_1 + 0.000920916576491816*x_10 - 0.000746150409233733*x_100 + 0.00358269054072417*x_101 - 0.00270541912814878*x_102 - 0.000121162064121315*x_103 - 0.00185937832196935*x_104 - 0.0018948647889301*x_105 - 0.00151987820162731*x_106 + 0.000397400959291216*x_107 + 0.00128130194414522*x_108 - 0.000929546583003671*x_109 + 0.00121934384289464*x_11 - 0.00115716498102373*x_110 + 0.00144627240212045*x_111 - 0.00094392232222297*x_112 - 0.000527441959074627*x_113 - 0.00305498330418377*x_114 - 0.00142497028081268*x_115 - 0.00341822993871946*x_116 - 0.00536819723581416*x_117 - 0.00284837138861691*x_118 - 0.00495262754609877*x_119 - 0.00127055669398465*x_12 - 0.00372079330931365*x_120 - 0.000786789114723807*x_13 - 0.000152667521968713*x_14 - 0.000425533752306356*x_15 + 0.00129834807012316*x_16 + 0.00132053990695035*x_17 + 0.000890581221107051*x_18 - 4.10689780088513e-6*x_19 - 0.000187376716310008*x_2 + 3.5577400313252e-5*x_20 - 0.00101981451307326*x_21 - 0.00221586046216187*x_22 + 0.00323413167968012*x_23 - 0.000436207951149796*x_24 - 0.000715304521623382*x_25 - 0.00145760451673781*x_26 + 0.000124492492159477*x_27 + 0.000140332005798952*x_28 + 0.000587607022892215*x_29 - 0.00033683440223431*x_3 + 0.0007961029559011*x_30 + 0.00119522485749269*x_31 + 0.000630129585203426*x_32 - 0.00188097945864805*x_33 - 0.00326366036848905*x_34 - 0.000125179596958693*x_35 - 0.00298510300547515*x_36 + 0.00184044294224593*x_37 - 0.00374117524177369*x_38 - 0.00249401113950433*x_39 + 0.00153064172405876*x_4 - 0.00224323924299495*x_40 + 0.000467536127907954*x_41 - 0.0024434585614419*x_42 - 0.00263601435958552*x_43 - 9.39223165274232e-5*x_44 - 0.00125772128566548*x_45 - 0.00156206848868675*x_46 + 0.000210625808092563*x_47 - 0.018420042311988*x_48 - 0.0135011813192772*x_49 + 0.000159400223411994*x_5 + 0.000170727516639487*x_50 + 0.00445655387497994*x_51 + 0.0226329556568857*x_52 + 0.0116386632390468*x_53 - 0.000156773200442768*x_54 + 0.00382998417979015*x_55 - 0.00799727889147977*x_56 - 0.000326587194205737*x_57 + 0.000414635831206986*x_58 - 0.000429359173462563*x_59 - 0.000643870598205667*x_6 - 0.000590460858483608*x_60 - 0.00130370995005089*x_61 - 0.000428341203531165*x_62 - 0.00112004191834595*x_63 - 0.00172350427560149*x_64 - 0.000832350864123332*x_65 - 0.00135000564211278*x_66 - 0.00172799020726417*x_67 - 0.00261043284824509*x_68 - 0.000236561733041852*x_69 - 0.00107912237222366*x_7 - 0.00123641383949046*x_70 + 0.00130182063684145*x_71 + 0.000129824533877511*x_72 - 0.00228423996707354*x_73 - 0.00228881191113556*x_74 - 0.000993886566256633*x_75 - 0.000229486348461367*x_76 - 0.000449773661935312*x_77 - 0.00143890480385915*x_78 + 0.00157442313548831*x_79 + 0.0014841023268196*x_8 + 0.00108576779924213*x_80 - 0.00151287078567434*x_81 - 0.000241479515366854*x_82 + 0.000214327804378527*x_83 - 0.00300955554555129*x_84 - 0.00125259468528262*x_85 - 0.00147558688004037*x_86 - 0.00111872426654001*x_87 - 0.000930143220102734*x_88 - 1.86625060389369e-5*x_89 + 0.000530927797913448*x_9 + 0.00102938211072691*x_90 - 0.00153758534577794*x_91 - 0.00108909962871508*x_92 - 0.000126533536115358*x_93 + 0.00147726362878332*x_94 + 0.00313523713896172*x_95 + 0.00124914042278841*x_96 + 0.000780262681774053*x_97 - 1.60262964663118e-5*x_98 - 0.00206912998039378*x_99 - 4.79084898083469e-7*std::pow(5.30704021453857 - 8.17615985870361*x_15, 2) - 1.16509704658377e-6*std::pow(5.54383993148804 - 0.991999804973602*x_10, 2) + 2.32143569746543e-6*std::pow(-2.62831997871399*x_16 - 9.89848041534424, 2) - 8.1466266228261e-6*std::pow(-3.71199989318848*x_25 - 8.0, 2) + 2.84754101536351e-8*std::pow(-9.3261604309082*x_28 - 1.61375975608826, 2) + 1.04514000711384e-5*std::pow(-5.89263963699341*x_60 - 9.60136032104492, 2) + 1.31659044273374e-7*std::pow(-3.8724000453949*x_61 - 6.51895952224731, 2) - 4.78206845396313e-7*std::pow(-2.83240008354187*x_64 - 9.11664009094238, 2) + 2.97898226446339e-6*std::pow(-2.76160001754761*x_64 - 6.32287979125977, 2) - 2.64773213608044e-6*std::pow(-3.67159986495972*x_9 - 7.73672008514404, 2) - 4.11941842937457e-5*std::exp(0.208559840917587*x_13) - 0.00340081864439491*std::exp(0.253679871559143*x_13) - 9.94017115231647e-5*std::exp(0.541759848594666*x_13) + 0.000139986679735821*std::exp(0.403919875621796*x_18) - 8.36506397845938e-6*std::exp(0.45007985830307*x_18) - 0.000357411776981287*std::exp(0.356479853391647*x_19) + 0.000221801311666491*std::exp(0.250079840421677*x_20) + 1.09968800014119e-6*std::exp(0.548639833927155*x_22) - 0.00244079761186926*std::exp(0.370639860630035*x_5) + 3.01499221226202e-5*std::exp(0.319119840860367*x_59) - 0.00226209583100797*std::exp(0.324639827013016*x_6) - 0.00102926444414419*std::log(5.16136026382446 - 0.59639984369278*x_9) - 0.189145077955844*std::sin(0.337039858102798*x_1 - 4.24552011489868) - 0.0593030919573929*std::sin(0.344959855079651*x_1 - 4.25184011459351) + 0.00278902778386922*std::sin(0.351919859647751*x_1 - 4.22544002532959) - 0.000124086406661536*std::sin(0.353119850158691*x_1 - 4.22032022476196) - 0.00968061418317593*std::sin(0.358719855546951*x_1 - 4.23680019378662) - 0.0836146571421555*std::sin(0.403519839048386*x_1 - 4.18416023254395) - 0.0127049790197762*std::sin(0.225759983062744*x_107 - 4.39264011383057) + 3.46714702007582e-5*std::sin(0.206160008907318*x_108 - 4.39903974533081) - 0.0541744335999653*std::sin(0.20584000647068*x_109 + 5.18096017837524) + 0.000854427990647051*std::sin(0.102400071918964*x_11 - 4.28399991989136) + 0.103543300205477*std::sin(0.175360009074211*x_11 + 5.18400001525879) - 0.000185644748434508*std::sin(0.283119946718216*x_11 - 7.42775964736938) - 0.00491534534374939*std::sin(0.282959938049316*x_112 - 7.43111991882324) - 0.00928179307590251*std::sin(0.323279827833176*x_112 - 1.34607982635498) + 0.000423401958834076*std::sin(0.254479974508286*x_113 - 4.22528028488159) + 0.00490161966616322*std::sin(0.283679932355881*x_113 + 1.96335983276367) - 0.00846823214798691*std::sin(0.287439942359924*x_113 - 7.42911958694458) + 0.00196169166183403*std::sin(0.2880799472332*x_113 - 7.42679977416992) - 0.00106227452077056*std::sin(0.233999982476234*x_114 + 1.97791981697083) - 4.15686788841947e-5*std::sin(0.241119980812073*x_114 - 1.23959982395172) - 0.00666400318083661*std::sin(0.227039992809296*x_116 + 5.1735200881958) - 5.78736135221591e-5*std::sin(0.233519986271858*x_116 + 1.79903984069824) - 0.00613979384421027*std::sin(0.251039981842041*x_116 + 5.16688013076782) + 0.000396306335644678*std::sin(0.262319952249527*x_116 - 1.23943984508514) + 0.000196111559037812*std::sin(1.02279984951019*x_116 + 8.39000034332275) + 0.00815963289055826*std::sin(0.218319997191429*x_118 - 4.21447992324829) + 0.00157427373691402*std::sin(0.235759988427162*x_119 + 5.17343997955322) - 0.0120622126288365*std::sin(0.276479959487915*x_12 - 7.43616008758545) - 0.000165593774803514*std::sin(0.298639953136444*x_12 + 5.12664031982422) - 0.215981168974218*std::sin(0.232399985194206*x_13 - 7.40807962417603) - 9.5574571216173e-6*std::sin(0.295279920101166*x_13 - 4.40863990783691) - 0.0130418297453749*std::sin(0.305279940366745*x_13 + 5.13495969772339) - 0.000202300473119541*std::sin(0.121120058000088*x_14 - 1.25951981544495) - 0.00429142536243746*std::sin(0.243039980530739*x_14 - 1.1814398765564) - 0.166150125296499*std::sin(0.303039938211441*x_14 - 7.43951988220215) + 0.00011544891614829*std::sin(0.442319840192795*x_14 - 1.44655990600586) - 0.00116031827250267*std::sin(0.53143984079361*x_14 - 1.31679975986481) + 0.0043614004592056*std::sin(0.538719832897186*x_14 + 1.86799991130829) - 0.00013208503584127*std::sin(0.244799971580505*x_15 - 1.17535984516144) - 0.000447293933769065*std::sin(0.267919957637787*x_15 + 1.98791980743408) - 0.000205632096943929*std::sin(0.270559966564178*x_15 + 1.77759981155396) + 0.00259494356659151*std::sin(0.29615992307663*x_15 + 5.17063999176025) + 0.00487144602685*std::sin(0.502879858016968*x_15 + 8.08672046661377) - 0.00217964583401427*std::sin(0.314639925956726*x_16 + 1.9968798160553) + 0.000699977314926455*std::sin(0.387599855661392*x_16 - 1.18503987789154) + 0.0064549764636307*std::sin(0.51095986366272*x_16 + 8.10847949981689) - 0.0105305719692347*std::sin(0.27975994348526*x_17 - 7.37399959564209) - 0.00295634165145335*std::sin(0.344799846410751*x_17 + 1.99871981143951) + 0.000639594037772296*std::sin(0.380239844322205*x_17 - 1.1743198633194) - 0.00148748746975994*std::sin(0.383119851350784*x_17 + 1.99287974834442) - 0.0172106965506593*std::sin(0.428399860858917*x_17 - 1.20383989810944) + 0.000123257060259298*std::sin(0.606959879398346*x_17 + 5.00175952911377) - 0.15320469182536*std::sin(0.314559936523438*x_18 - 1.15207993984222) - 0.00365766645541622*std::sin(0.374319821596146*x_18 + 2.02303981781006) - 0.000168482509646745*std::sin(0.51775985956192*x_18 + 2.0559196472168) - 0.000117049470796745*std::sin(0.524639844894409*x_18 + 2.05535984039307) - 0.000250831075674701*std::sin(0.222240000963211*x_19 + 8.1947193145752) + 0.293956642188868*std::sin(0.25655996799469*x_19 + 8.21303939819336) - 4.99759507342929e-5*std::sin(0.39319983124733*x_19 - 1.2047199010849) + 0.00694149375046853*std::sin(0.365679860115051*x_2 + 5.18024015426636) + 0.319155283868512*std::sin(0.377919852733612*x_2 + 5.17736005783081) + 0.00107352899651502*std::sin(0.388719856739044*x_2 + 5.18279981613159) - 0.000224333199002659*std::sin(0.399199843406677*x_2 + 5.20344018936157) + 0.000580463802414715*std::sin(0.409279853105545*x_2 - 1.17679977416992) - 0.00175642113127457*std::sin(0.415519863367081*x_20 + 7.59352016448975) - 0.00136147143420779*std::sin(0.317199915647507*x_21 - 1.19207990169525) - 0.00450586486653123*std::sin(0.340239852666855*x_21 + 2.04071974754333) - 0.00103436307854665*std::sin(0.399679869413376*x_22 + 2.00927972793579) + 0.00651902917928567*std::sin(0.275279939174652*x_23 - 1.15063989162445) + 0.0001288484381506*std::sin(0.354399859905243*x_23 - 1.39335989952087) - 0.0431864960471404*std::sin(0.366559833288193*x_23 - 7.36911964416504) - 0.000420781382014429*std::sin(0.832639873027802*x_23 - 7.78951978683472) - 0.0981514381324694*std::sin(0.386879861354828*x_24 - 1.19351994991302) + 0.0014927090148531*std::sin(0.442479848861694*x_24 - 1.21311986446381) + 0.00074109576302958*std::sin(0.261439979076385*x_25 - 7.37575960159302) + 0.00199705130062697*std::sin(0.338639855384827*x_25 - 1.14871978759766) + 0.123082147335713*std::sin(0.284159928560257*x_26 + 1.98807990550995) + 0.00202873353910697*std::sin(0.304559946060181*x_26 - 1.17807984352112) + 1.07827197088974e-5*std::sin(0.783759832382202*x_26 - 1.39231991767883) + 0.000350504443012986*std::sin(0.285999923944473*x_27 - 7.39047956466675) + 0.000121154538176678*std::sin(0.463919848203659*x_27 + 4.5776801109314) - 0.00406898605399576*std::sin(0.0912800803780556*x_28 + 2.02471995353699) + 0.00166366292928273*std::sin(0.805839836597443*x_28 + 4.79120016098022) + 0.00424648248726561*std::sin(0.323039919137955*x_29 + 4.80983972549438) - 0.00113995389608765*std::sin(0.856159865856171*x_29 - 5.43487977981567) - 0.000198834697447131*std::sin(0.2743199467659*x_3 - 1.15183985233307) + 0.00145516735786894*std::sin(0.2882399559021*x_3 - 1.13159990310669) - 0.000248519002079214*std::sin(0.316159933805466*x_3 + 8.28087997436523) - 0.00684853613507609*std::sin(0.344079852104187*x_3 - 7.40455961227417) + 0.000610727102632784*std::sin(0.372479856014252*x_3 + 5.19831991195679) + 0.0237446822833002*std::sin(0.396399825811386*x_3 - 7.40655994415283) - 0.0149457773792418*std::sin(0.259519964456558*x_30 + 1.99079978466034) + 0.00500432374156436*std::sin(0.266159951686859*x_30 - 1.1651998758316) - 0.00115512118608681*std::sin(0.284959942102432*x_30 - 1.16359984874725) - 0.0721336469580489*std::sin(0.304079920053482*x_30 - 1.16567981243134) - 0.00137149750032596*std::sin(0.308239936828613*x_30 + 2.00159978866577) + 0.1656843142912*std::sin(0.312719941139221*x_30 + 1.99159979820251) - 0.00032188104929363*std::sin(0.765519857406616*x_30 - 7.37951993942261) + 0.0102797677885739*std::sin(0.293119937181473*x_31 - 1.07175981998444) - 0.000285740137742818*std::sin(0.309599936008453*x_31 - 4.056960105896) - 0.00015823633882606*std::sin(0.350399851799011*x_31 + 5.15687990188599) - 0.000326693676178509*std::sin(0.375759840011597*x_31 - 7.39991998672485) - 0.000817271809444349*std::sin(0.396079838275909*x_31 + 8.38568019866943) - 0.0824736861267315*std::sin(0.405199855566025*x_31 + 5.19992017745972) + 0.000818369830940239*std::sin(0.613279819488525*x_31 + 5.1956000328064) - 0.0448058769503243*std::sin(0.285679936408997*x_32 + 8.2425594329834) + 0.311949137451501*std::sin(0.302159935235977*x_32 - 1.14591991901398) + 0.000695736079933122*std::sin(0.213440001010895*x_33 + 1.971599817276) + 0.145255934886619*std::sin(0.233039990067482*x_33 + 1.9968798160553) - 0.00376062693361334*std::sin(0.233519986271858*x_33 - 1.17975986003876) + 1.52492155708454e-5*std::sin(0.179520010948181*x_35 + 8.40520000457764) + 0.00173232773256*std::sin(0.1893600076437*x_36 - 7.60423994064331) - 1.49997627079386e-5*std::sin(0.291999936103821*x_37 + 4.77928018569946) + 0.00114928256595524*std::sin(0.538559854030609*x_37 - 0.706639885902405) + 0.00110583939954016*std::sin(0.249199971556664*x_4 - 7.36111974716187) - 0.000575335457041877*std::sin(0.375919848680496*x_4 + 1.9793598651886) + 0.000338044986914827*std::sin(0.772719860076904*x_4 + 8.20959949493408) - 2.13677831934173e-5*std::sin(0.862319886684418*x_4 + 7.99488019943237) - 0.00236988752106859*std::sin(0.16312001645565*x_40 + 5.19856023788452) + 0.00986737575425391*std::sin(0.171840012073517*x_41 - 1.20207989215851) + 3.69749749492954e-5*std::sin(0.697999835014343*x_42 + 4.62016010284424) - 0.000608401934469062*std::sin(0.459839850664139*x_44 - 1.4592798948288) - 0.000439692404604021*std::sin(0.576399862766266*x_45 + 5.03351974487305) + 0.000136515570707948*std::sin(0.228719994425774*x_48 - 7.5971999168396) - 2.0852929497695e-5*std::sin(0.467279851436615*x_49 - 1.34599983692169) + 0.00842746765648674*std::sin(0.254319965839386*x_5 - 7.56360006332397) - 0.00533230665942764*std::sin(0.265679955482483*x_5 + 2.00615978240967) - 0.0107032821745175*std::sin(0.350159853696823*x_5 - 1.14927983283997) - 0.00221041010585504*std::sin(0.359199851751328*x_5 + 2.00079965591431) + 0.0954872109995342*std::sin(0.386959850788116*x_5 - 7.39559984207153) + 0.000647928302903912*std::sin(0.224399983882904*x_50 + 4.37063980102539) + 0.00155709049864235*std::sin(0.16872002184391*x_51 + 8.20335960388184) - 0.000335695223686918*std::sin(0.255279958248138*x_52 - 1.2079998254776) - 0.00219473452499359*std::sin(0.233999982476234*x_53 - 7.42159986495972) + 0.0216732564948793*std::sin(0.20024000108242*x_54 + 5.00152015686035) - 0.000724516667522944*std::sin(0.5655198097229*x_54 + 4.83576011657715) + 0.000946118663927841*std::sin(0.337999850511551*x_56 + 1.85591995716095) - 0.0106876264721886*std::sin(0.169280022382736*x_57 + 1.61479985713959) + 0.0150861844577459*std::sin(0.29351994395256*x_57 - 1.42783987522125) - 0.000412018609154042*std::sin(0.48447984457016*x_58 + 4.6911997795105) + 0.0043563953145661*std::sin(0.359359860420227*x_59 + 4.64055967330933) - 0.00353870754177004*std::sin(0.606719851493835*x_59 - 7.81207990646362) + 0.00727619412162646*std::sin(0.342959851026535*x_6 + 2.01183986663818) - 0.00091192019487642*std::sin(0.344479858875275*x_6 + 2.01703977584839) - 0.168476584996863*std::sin(0.366239845752716*x_6 + 1.99223983287811) + 0.000305697397269694*std::sin(0.367599844932556*x_6 - 1.16799986362457) - 0.0678842929617939*std::sin(0.378479838371277*x_6 + 1.99007987976074) + 0.00145182696695661*std::sin(0.38351982831955*x_6 - 1.17855989933014) + 1.9749650178467e-5*std::sin(0.452159851789474*x_60 - 7.48456001281738) - 2.57204030844687e-5*std::sin(1.41623985767365*x_64 + 6.79663991928101) + 0.00176346793461849*std::sin(0.330399841070175*x_7 - 1.15071988105774) - 0.272294054144469*std::sin(0.354959845542908*x_7 + 2.00631976127625) + 0.107904249093715*std::sin(0.359199851751328*x_7 - 1.15143990516663) - 0.000243103876812519*std::sin(0.480159848928452*x_7 + 1.93423986434937) + 1.20148455126336e-6*std::sin(1.18463981151581*x_70 - 9.6071195602417) + 4.96169614917744e-6*std::sin(0.909999787807465*x_72 + 7.97391986846924) - 0.00100574585692312*std::sin(1.2240799665451*x_73 - 0.783519864082336) + 0.000501614675063798*std::sin(1.13831984996796*x_75 - 2.37199997901917) + 0.000524714735573151*std::sin(1.22527992725372*x_75 + 3.99287986755371) + 0.00163646865718539*std::sin(1.41495978832245*x_77 + 1.97983980178833) - 2.87091640243822e-6*std::sin(0.803119838237762*x_78 + 3.78615999221802) - 0.0160037088335065*std::sin(0.295279920101166*x_8 - 1.19455993175507) + 0.00196942296830555*std::sin(0.307679921388626*x_8 + 2.11904001235962) + 0.00109199346851098*std::sin(0.314959913492203*x_8 + 5.15392017364502) - 1.52492479515541e-5*std::sin(0.398239850997925*x_8 - 7.80751991271973) + 0.000543750524364438*std::sin(0.171200007200241*x_87 + 5.50552034378052) + 0.0017786265919803*std::sin(0.180960014462471*x_88 - 7.25880002975464) - 0.0004512221897759*std::sin(1.14111983776093*x_88 - 1.60359990596771) - 0.000321559538464397*std::sin(0.376639842987061*x_9 - 4.38687992095947) + 0.00207365774902882*std::sin(0.452639847993851*x_9 - 4.27943992614746) + 0.00755342832840126*std::sin(0.485359847545624*x_9 - 4.47983980178833) - 0.000507941284405326*std::sin(1.79071986675262*x_90 - 2.39239978790283) - 9.53560501195952e-5*std::sin(0.329519838094711*x_91 - 4.20544004440308) + 0.000103378977141218*std::sin(0.388959854841232*x_91 + 1.971599817276) + 0.00159125671313416*std::sin(0.417119860649109*x_91 + 8.21047973632813) + 0.00085501904399028*std::sin(0.227119997143745*x_92 + 2.01871991157532) - 0.000760255216922652*std::sin(0.239759981632233*x_92 + 5.19600009918213) - 0.0291590343988177*std::sin(0.253919988870621*x_92 + 2.02055978775024) + 0.137835796935101*std::sin(0.285359919071198*x_92 + 1.99703979492188) + 9.0314572372343e-5*std::sin(0.327039837837219*x_92 + 8.22480010986328) - 0.0172754593667228*std::sin(0.257679969072342*x_94 - 7.39807987213135) + 0.000819106106381616*std::sin(0.275759935379028*x_94 + 1.97855985164642) - 3.49007241288152e-5*std::sin(0.310879945755005*x_94 + 1.79847991466522) - 0.0430535561337862*std::sin(0.262319982051849*x_96 - 1.20431983470917) - 3.38366442018902e-5*std::sin(0.30447992682457*x_96 - 4.41775989532471) - 0.00139767909316417*std::sin(0.27991995215416*x_97 + 1.97735977172852) + 0.0193688094995406*std::sin(0.261359959840775*x_98 - 4.42471981048584) - 0.203130751848221*std::sin(-0.00929633049729803*x_10 - 7.23097369770087e-5*x_101 + 0.0015079194680643*x_102 + 0.00135671752949986*x_103 + 0.000829214356928822*x_104 + 0.000409989794969982*x_105 + 3.7310569284165e-5*x_106 - 0.0217455481570033*x_107 + 0.00482184247603587*x_108 + 0.00708397937582607*x_109 - 0.00273052810853727*x_11 - 0.00236283464111536*x_110 - 0.0172257238475589*x_111 - 0.00269607676288269*x_112 + 0.0128079384296991*x_113 + 0.00972515359089758*x_114 + 0.00480284123276749*x_115 - 0.00365636097324096*x_116 + 0.0197906520142226*x_117 + 0.00999467091939307*x_118 + 0.00619966525009366*x_119 + 0.00269964718618667*x_120 - 0.00597833454139631*x_14 + 0.00148914672834944*x_15 - 0.00685115080642721*x_16 - 0.00187704213190157*x_17 - 0.00204300809405404*x_18 + 0.00341249049450488*x_19 - 0.000957908311524868*x_2 + 0.000277451021674835*x_21 - 0.0173579145264521*x_23 + 0.000260297593659422*x_25 - 0.0033255924152786*x_27 + 0.00320703806383784*x_28 + 0.00303665188474507*x_29 + 0.00320176113547087*x_30 + 0.000361046169115371*x_32 - 0.00194303659772943*x_33 - 0.0202020396799047*x_34 + 0.000546748342432608*x_35 - 0.00205705186709977*x_36 - 0.00702326706262246*x_37 - 0.004921840407116*x_38 - 0.00763180556877679*x_39 - 0.0017906600018178*x_4 - 0.00963340239849764*x_40 - 0.000917318666574663*x_41 - 0.00622034976033378*x_42 - 0.00876489874086011*x_43 - 0.00600789225207946*x_44 - 0.00516902215996735*x_45 - 0.00783764916548508*x_46 - 0.00799853856054984*x_47 + 0.00042700120724705*x_48 + 0.00099600229001835*x_49 - 0.00130194239048861*x_5 - 0.00224237740846355*x_50 - 0.00407614493112887*x_51 - 0.00409437401908461*x_52 + 0.00521493744639192*x_53 + 0.00887389597388146*x_54 - 0.00132569482002713*x_55 - 0.00390452261013291*x_56 + 0.000640303136323933*x_57 - 0.00342834370874279*x_58 + 0.000983559030134737*x_6 - 0.00318098300240032*x_60 - 0.00276047403921469*x_61 - 0.000889489402920592*x_62 - 0.00560924323033431*x_63 + 0.00367919848924442*x_65 + 0.00163997506186292*x_66 + 0.00367906878435073*x_67 + 0.00689714339638751*x_68 + 0.00143793841320542*x_69 + 0.00163225242567232*x_71 + 0.0117501047240706*x_72 + 0.000738786966469348*x_73 + 0.00676923112498886*x_74 + 0.00495499184817737*x_75 + 0.00159596271296555*x_76 + 0.00299768298606276*x_77 - 0.00121120254538763*x_78 + 0.00457301637404786*x_79 + 0.000597072998547648*x_80 + 0.00581419663318824*x_81 + 0.00597012018237419*x_82 - 0.00117785854618799*x_83 + 0.00573447776718032*x_84 + 0.00172194103247771*x_85 + 0.00255018224486689*x_86 + 0.000826618804086202*x_87 + 0.00554496426958652*x_88 - 0.000207570132531349*x_89 - 0.024050933560639*x_9 - 0.002927546908387*x_90 - 0.00761102908584485*x_91 - 0.0104844036044803*x_92 - 0.000969717752167292*x_93 - 0.00711806492098073*x_94 + 0.000425150087948042*x_95 - 0.0081958071171125*x_96 - 0.0125284764548436*x_98 - 0.00196063433891084*x_99 + 3.79899589188805e-5*std::pow(2.4696798324585 - 7.17983961105347*x_59, 2) + 0.00188141092921751*std::exp(0.521439850330353*x_26) - 0.105632591536338*std::sin(0.359119862318039*x_1 - 1.03623986244202) + 0.00783676642782238*std::sin(1.34607982635498*x_100 - 4.97455978393555) + 0.0330146939357392*std::sin(0.539439857006073*x_12 + 7.83392000198364) + 0.103168891222786*std::sin(0.179840013384819*x_13 + 1.59295988082886) - 0.0420569128513204*std::sin(0.337519854307175*x_20 - 7.79392004013062) - 0.0514558481904812*std::sin(0.482559859752655*x_22 + 4.98415994644165) + 0.0183494603967402*std::sin(0.827359914779663*x_24 + 1.80167984962463) - 0.405660436046539*std::sin(0.348319828510284*x_3 + 1.97527980804443) + 0.85805806733697*std::sin(0.386079847812653*x_31 - 7.39783954620361) - 0.00374953058909677*std::sin(1.77119994163513*x_64 + 3.59479999542236) - 0.202927263193303*std::sin(0.376479834318161*x_7 + 2.02695989608765) - 0.00463192856810041*std::sin(1.0732798576355*x_70 + 2.81663990020752) + 0.015107396223494*std::sin(0.451759845018387*x_8 + 7.95944023132324) + 0.0807019437953924*std::sin(0.273119956254959*x_97 + 1.96655988693237) + 9.51826687471607) - 0.0987310707569122*std::sin(-0.00605115978122983*x_10 + 0.00951581125055791*x_100 - 0.00415713319127607*x_101 - 0.00379995035967671*x_102 + 0.00384930804931578*x_103 + 0.000527044768917238*x_104 + 0.00935994023047258*x_105 + 0.00809805111557112*x_106 + 0.000264381993391189*x_107 + 0.00938226953488499*x_108 + 0.000660405832806382*x_109 - 0.00809053386367002*x_11 - 0.00173606397048171*x_110 - 0.00345997755021121*x_111 + 0.00295671387044658*x_112 + 0.00359846108727173*x_113 + 0.00237424104965143*x_114 + 0.00169770484249643*x_115 + 0.0020063141606401*x_116 + 0.000736110506976503*x_117 + 0.00385850113588861*x_118 - 0.0016258841526136*x_119 - 0.00171103469179487*x_12 + 0.0031456438666476*x_120 - 0.000625938318243012*x_13 - 0.0055076599866986*x_14 - 0.002119680381968*x_15 - 0.00982071829920537*x_16 + 0.00358069765991339*x_17 + 0.00780015358444921*x_19 - 0.00077734675203046*x_2 + 0.000775270557360214*x_20 - 0.00173133072471663*x_21 - 0.000820402414040583*x_24 - 0.00325928046350826*x_25 + 0.00233257991039607*x_26 - 0.00279484185363957*x_27 - 0.00364592693256714*x_28 + 0.00295581153343181*x_30 + 0.0365419536078993*x_33 - 0.016411861447802*x_36 - 0.00243137405019807*x_37 + 0.0110103675318549*x_38 - 0.00765342568864769*x_39 + 0.00152704706126769*x_40 - 0.00580838909942855*x_41 - 0.00267096304592016*x_42 - 0.000741175896586268*x_43 + 0.00163342980525618*x_44 - 0.00195484087366071*x_45 + 0.00843915442569235*x_46 + 0.0230545071856744*x_48 - 0.000617737311936029*x_49 - 0.00299829032528795*x_5 - 0.000311760560478183*x_51 + 0.003402335879337*x_52 + 0.0108888507528966*x_53 + 0.00022700696325209*x_54 - 0.00130741041128304*x_55 + 0.00358002112855321*x_56 + 0.000213499640698886*x_57 + 0.00118854540652577*x_58 - 0.000442138064855648*x_59 - 0.01824168332752*x_6 + 0.00133719304834846*x_60 - 0.00396687543893826*x_61 - 0.000633758467552865*x_62 + 0.00638291966830394*x_63 + 0.00763955455853199*x_64 + 0.00851442463549498*x_65 - 0.00183760403471701*x_66 + 0.00123405697885265*x_67 + 0.00106324071806279*x_68 + 0.00326436123400925*x_69 + 0.00483991865300155*x_70 - 0.0022385550937782*x_71 + 0.000386907535068522*x_72 + 0.00620156073248134*x_73 + 0.0100856423832913*x_74 + 0.00376844065493164*x_75 + 0.00199173649098992*x_76 + 0.00890691505800576*x_77 + 0.000870564229159592*x_78 - 0.00297073615454395*x_79 + 0.00406541180742222*x_8 + 0.00162210795982925*x_80 - 0.00852348703044419*x_81 - 0.00254898053974888*x_82 + 0.00440633188579488*x_83 + 0.00630755942022562*x_84 + 0.000213340198356133*x_85 + 0.000564763056142045*x_86 - 0.00470701341762241*x_87 + 0.00368953487925399*x_88 + 0.000319469828844037*x_89 + 0.0029597899328775*x_9 - 0.00497335787393297*x_90 + 0.0234706227114569*x_93 - 0.00553397425369175*x_96 - 0.00050137150032005*x_97 + 0.00102608939707161*x_98 + 0.00204250042556757*x_99 + 0.0799798875700215*std::exp(0.318959832191467*x_18) - 1.99883726563255*std::sin(0.332799851894379*x_1 - 4.25031995773315) - 0.136047626025464*std::sin(0.317359924316406*x_22 + 8.25111961364746) + 0.460886623568761*std::sin(0.319999933242798*x_23 - 1.16799986362457) - 0.0551142213760523*std::sin(0.377759844064713*x_29 - 1.18191993236542) + 0.240147489668956*std::sin(0.359439849853516*x_3 - 7.39336013793945) - 0.0382511996513037*std::sin(0.340319842100143*x_31 - 1.01967978477478) + 0.571479039993612*std::sin(0.30839991569519*x_32 - 1.14823985099792) - 0.045515127474689*std::sin(0.225599989295006*x_34 + 1.77711987495422) + 0.0287104320622711*std::sin(0.179120019078255*x_35 + 8.19151973724365) - 0.977005501438484*std::sin(0.178640007972717*x_4 + 8.1755199432373) - 0.00433495873568057*std::sin(0.665839850902557*x_47 + 7.57984018325806) + 0.0408850023146905*std::sin(0.209279999136925*x_50 + 8.17591953277588) - 0.306439560737505*std::sin(0.322959840297699*x_7 - 7.339439868927) + 0.0639637346011703*std::sin(0.370879858732224*x_91 + 5.18943977355957) - 0.154278873246106*std::sin(0.321039855480194*x_92 - 1.1814398765564) - 0.223799052503328*std::sin(0.287839949131012*x_94 + 1.97927987575531) - 0.0745620307272761*std::sin(0.253759980201721*x_95 - 7.40999984741211) + 1.03124702468146) - 0.0676577463746071*std::sin(0.00159068429386003*x_10 - 0.00384153679172945*x_100 + 0.00350613752883537*x_101 + 0.00779637501508681*x_102 - 0.0044366176962022*x_103 - 0.00466958535256903*x_104 + 0.00882516886250604*x_105 + 0.000239343860777758*x_106 + 0.00288338617287746*x_107 + 0.0106389372459339*x_108 + 0.0116945226556182*x_109 - 0.00342681025769165*x_11 - 0.0101523773690701*x_110 + 0.000877937378095083*x_111 + 0.0212543200956456*x_112 + 0.0390098197048103*x_113 + 0.00189916223588326*x_114 + 0.00222822490911055*x_115 + 0.000894903274772012*x_117 + 0.00382764774045517*x_118 - 0.00248589268992682*x_12 + 0.000543457214727715*x_120 + 0.000586610418374478*x_13 - 0.0029956493673359*x_17 - 0.0026997919089447*x_2 + 0.00566777072665617*x_20 + 0.0024634707543178*x_21 - 0.00107430114955907*x_24 + 5.0753598728116e-5*x_29 - 0.000751114988777932*x_3 - 0.00101236914462586*x_32 + 0.0154078688446541*x_33 + 0.0163026940897179*x_34 - 0.00300114567110235*x_35 + 0.00204348958712818*x_36 - 0.00194073287067344*x_37 + 0.00076844112515447*x_38 + 0.00249240161613397*x_39 - 0.00300760363655964*x_4 - 0.00121100255342822*x_40 + 0.00123773460425745*x_41 + 0.00247151266591518*x_42 - 0.00155416973885473*x_43 + 0.00419106038332725*x_44 + 0.0072780247989084*x_45 + 0.00303687733957471*x_46 + 0.00297151637842761*x_47 + 0.00664226887311778*x_48 - 0.000276437815292483*x_49 - 0.0028122525514003*x_50 - 0.00146842898482123*x_51 + 0.00173510935564398*x_52 + 0.000710947957305278*x_53 - 0.00221407085820223*x_55 + 0.00183832897828576*x_56 - 0.0105417309045049*x_57 - 0.0063489977124572*x_59 - 0.00357597418681132*x_61 - 0.00880735086509947*x_62 - 0.00246057601470078*x_63 + 0.000815913717987056*x_64 + 0.00573992304956436*x_65 + 0.00116929452649619*x_66 + 0.00266157333453112*x_67 + 0.00706071304212919*x_68 - 0.000434521079466443*x_69 - 0.000386927520773667*x_70 + 0.000455929681889605*x_71 - 0.00213185483799826*x_72 - 0.00172163182238678*x_73 - 0.00560307531956604*x_74 - 0.000345084542738413*x_75 + 0.00109843227896341*x_76 - 0.00455461427654833*x_77 - 0.00401437445283108*x_78 + 0.00147636025818673*x_79 - 0.00194794882714914*x_8 - 0.00527363104904269*x_80 - 0.00624789283657618*x_81 + 0.000457801000669997*x_82 + 2.1183337047198e-5*x_83 - 0.000643386181688818*x_84 - 0.00652957252604888*x_85 - 0.00430419932869405*x_86 + 0.000674957859992335*x_87 - 0.00198543381453216*x_88 + 0.000247275839211751*x_89 - 0.00269414195310841*x_9 + 0.00205908215586703*x_90 - 0.0137918128435289*x_91 + 0.00500830291773884*x_93 - 0.00375498330707982*x_95 - 0.0123883297718509*x_96 - 0.00206517043324778*x_97 + 0.00192114339959342*x_98 - 0.0200911615002476*x_99 + 0.0495144295371777*std::exp(0.173759862780571*x_14) + 0.0192792166657338*std::exp(0.326959848403931*x_22) - 0.00479411629987874*std::exp(0.310879856348038*x_28) - 0.0145225188441101*std::exp(0.321919828653336*x_30) + 0.312317322947681*std::sin(0.348479837179184*x_1 + 5.15775966644287) - 0.249803153182224*std::sin(0.209199994802475*x_116 + 2.000159740448) + 0.200986552082487*std::sin(0.226719990372658*x_119 + 5.18576002120972) + 0.518811240025634*std::sin(0.316639930009842*x_15 + 5.14856004714966) - 0.167455887489254*std::sin(0.297039926052094*x_16 + 2.00455975532532) + 0.176089401748552*std::sin(0.431999862194061*x_18 - 7.42375993728638) - 0.209268976048374*std::sin(0.257999986410141*x_19 + 8.2061595916748) - 0.143848108435815*std::sin(0.370399862527847*x_23 + 1.99191975593567) - 0.0570261029745005*std::sin(0.324319839477539*x_25 - 1.13855993747711) + 0.220156429241989*std::sin(0.152400031685829*x_26 + 8.14935970306396) - 0.0677510344546901*std::sin(0.367839843034744*x_27 + 5.23767995834351) + 0.065898914969722*std::sin(0.376639842987061*x_31 - 4.22408008575439) + 0.0115997810390047*std::sin(0.685359835624695*x_5 - 4.65687990188599) + 0.0304388067543382*std::sin(0.589199841022491*x_54 + 1.78703987598419) + 0.0392418683012177*std::sin(0.299759924411774*x_58 + 1.87479984760284) - 0.239828082556862*std::sin(0.323439925909042*x_6 + 2.01247978210449) + 0.0799246673026701*std::sin(0.358639866113663*x_60 + 8.24847984313965) - 0.666124598009972*std::sin(0.26079997420311*x_7 + 2.03239989280701) - 0.622002736209993*std::sin(0.303839921951294*x_92 + 1.98935985565186) + 0.126279491231235*std::sin(0.285999953746796*x_94 - 1.19919991493225) + 1.02848303926035) + 0.0893366695758554);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
