
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00808078389130163*x_1 + 0.00133478496924636*x_10 + 0.000862409396544361*x_100 + 0.000607003240064442*x_101 + 0.000902406310765517*x_102 - 0.00165356688631168*x_103 - 0.000248791800335102*x_104 - 6.74298993407054e-6*x_106 - 0.000466955173147126*x_108 - 0.0027953504723024*x_109 + 0.00115163970072156*x_11 + 0.000147300322461955*x_110 + 0.00144706671047714*x_112 - 0.00180484776979779*x_113 + 0.000440031944458821*x_114 - 0.00051727831935026*x_116 + 0.000501486121876183*x_117 - 2.73025548186844e-5*x_118 - 0.000836877287200295*x_119 + 0.000186128521803277*x_120 - 0.000428829291245703*x_13 - 0.0018409893020418*x_14 + 9.37541360369301e-6*x_15 - 0.00124493798002519*x_18 + 0.000425971318392577*x_19 + 0.0033860882835242*x_2 - 0.00399683425215333*x_20 + 6.14124972293163e-6*x_21 + 0.00117521345897463*x_22 + 0.00015536953968637*x_23 - 0.000766391393062447*x_24 - 0.00275853316211691*x_25 + 2.9700313500696e-6*x_26 - 6.51651205618854e-6*x_28 - 0.00115281341614732*x_29 - 0.000194285462765189*x_3 + 0.00162004120059986*x_30 + 0.0082647865889434*x_31 - 0.000176272045189598*x_32 - 0.00238847300174262*x_33 - 3.16328879112259e-5*x_34 - 0.000509651404611763*x_36 - 4.36550633317961e-5*x_37 - 0.00379433952391994*x_39 + 0.00213647220299104*x_4 - 0.000392232369706537*x_40 + 0.000816908085925242*x_41 - 0.00109840838083285*x_42 - 6.29586320864983e-5*x_43 - 5.304642563492e-5*x_44 - 0.000450258606448811*x_46 + 0.00119573909941442*x_48 + 2.24670400239528e-5*x_49 - 0.000898110463753201*x_5 + 0.00090900050772696*x_50 - 0.00130781448220365*x_51 - 0.00540439941918466*x_52 - 0.000261993050854193*x_53 + 0.00099935471946759*x_54 - 0.000466631134977309*x_55 - 3.31974969440055e-5*x_56 - 0.000316715367013411*x_57 + 0.00245397040944492*x_59 + 0.00157430109865314*x_6 - 0.000704700876166709*x_60 - 0.00359145702426787*x_61 + 0.00110329230659265*x_62 - 0.00156678153523365*x_63 - 9.21895394966732e-5*x_64 - 0.00053711355919888*x_65 - 0.000594910892367888*x_66 + 1.40335272016736e-5*x_67 + 0.000632240771953471*x_69 - 0.000811867537421781*x_70 - 8.43399637713303e-5*x_71 - 0.000113529532671561*x_72 + 0.0047884349143541*x_76 + 0.00046228070588856*x_77 + 5.48391859198358e-6*x_79 + 0.004857586661394*x_8 + 0.000264940388139752*x_80 - 0.00244965180261764*x_82 - 0.000570987583882599*x_83 + 0.000482378779089729*x_86 - 4.67696865991909e-5*x_87 + 0.000741836077747353*x_88 + 6.12925137226835e-5*x_89 + 0.000483805397123314*x_91 + 0.000802429443361323*x_92 + 0.000994083532344252*x_94 + 0.00140509734127975*x_97 - 0.000630936901182347*x_98 + 5.40997020915315e-5*std::pow(-5.59087991714478*x_17 - 8.77711963653564, 2) + 0.000102532925900036*std::pow(-4.67167949676514*x_17 - 6.90744018554688, 2) + 0.000337004548848546*std::pow(-1.91071999073029*x_18 - 2.75584006309509, 2) + 3.95931027732418e-5*std::pow(-6.07679986953735*x_22 - 9.73752021789551, 2) - 2.70509356412728e-6*std::pow(-6.36255979537964*x_23 - 8.93599987030029, 2) - 0.000123161208325103*std::pow(-4.91200017929077*x_4 - 8.39608001708984, 2) + 1.94464261122319e-5*std::pow(-5.77103996276855*x_58 - 7.56695985794067, 2) + 0.000197975422658181*std::pow(-2.89567995071411*x_6 - 4.63944005966187, 2) - 1.76603646717189e-5*std::pow(-6.9987998008728*x_67 - 9.77744007110596, 2) - 3.78892948250298e-6*std::pow(-5.72896003723145*x_7 - 8.99792003631592, 2) - 8.40926167901509e-5*std::pow(-5.27688026428223*x_7 - 8.52688026428223, 2) + 1.48353849773331e-6*std::pow(-6.60000038146973*x_71 - 9.96463966369629, 2) + 2.514788929706e-5*std::pow(-7.60000038146973*x_72 - 9.99660015106201, 2) - 8.67404292638634e-6*std::pow(-6.59600019454956*x_75 - 9.96208000183105, 2) + 6.88725545198381e-7*std::pow(-6.40000009536743*x_78 - 9.99993991851807, 2) - 1.64165233251018e-5*std::pow(-7.19984006881714*x_81 - 9.79320049285889, 2) + 4.21076839404262e-5*std::pow(-5.49191999435425*x_83 - 7.52191972732544, 2) + 5.19980769009596e-5*std::pow(-4.27015972137451*x_84 - 6.41544008255005, 2) - 2.07955325540204e-6*std::pow(-3.90391993522644*x_85 - 6.36783981323242, 2) + 4.85072196143723e-5*std::pow(-3.28543996810913*x_85 - 7.1800799369812, 2) + 2.08964846693671e-5*std::pow(-4.28991985321045*x_87 - 6.95071983337402, 2) + 1.8072381084251e-5*std::pow(-4.93191957473755*x_88 - 5.71687984466553, 2) + 6.21600416346915e-5*std::pow(-4.09903955459595*x_89 - 5.94736003875732, 2) - 1.54718280104839e-6*std::pow(-6.60000038146973*x_90 - 9.96016025543213, 2) - 1.34668599611268e-5*std::pow(-5.74399995803833*x_90 - 7.7992000579834, 2) - 4.62049674563761e-5*std::pow(-4.90768003463745*x_90 - 7.15335988998413, 2) + 2.56334845456116e-5*std::exp(1.29391980171204*x_17) - 0.000114802906683582*std::exp(0.730479836463928*x_22) - 0.000600020490197102*std::exp(0.602479875087738*x_29) - 0.0333504518420901*std::exp(-0.0145539191951151*x_100 - 0.0101025913894915*x_101 - 0.00342386966284788*x_102 + 0.00306030739623711*x_103 + 0.00658274641112685*x_107 - 0.002102668118479*x_109 + 0.0160320973135929*x_11 - 0.0248599350425487*x_113 - 0.00801377696449587*x_116 - 0.0191173467167039*x_12 - 0.0153155436826694*x_13 - 0.00320109691805179*x_16 - 0.0150878995179873*x_17 + 0.00460183161158594*x_18 - 9.32605675689238e-5*x_19 - 0.00498907811448356*x_2 + 0.0335188890229814*x_20 + 0.0333323391068607*x_22 + 0.0323955704344975*x_25 + 0.033395647685653*x_29 - 0.00626422070572943*x_3 + 0.0143171714426696*x_30 + 0.0611941997790615*x_31 + 0.00154000764276757*x_32 - 0.014957194829211*x_34 + 0.00832472754402188*x_39 - 0.0178643701830135*x_4 - 0.00210727135970499*x_41 - 0.0113310716104125*x_42 + 0.00120246495844504*x_44 - 0.00188051583481712*x_45 + 0.00105108997334267*x_47 - 0.035894032519981*x_48 + 0.0204420166578435*x_5 - 0.000533463101488431*x_52 + 0.0096548542776176*x_55 + 0.00556438531974807*x_58 - 0.0039757561747478*x_6 + 0.00715491017320044*x_61 + 0.00835541133217818*x_62 + 0.00546843290425103*x_63 - 0.0142161394301548*x_64 - 0.00504903852390903*x_65 - 0.00578660311753658*x_69 + 0.00267316439454495*x_71 + 0.00528796682936448*x_76 - 0.00115843717746749*x_78 + 0.000400851050815168*x_79 + 0.00297740253904992*x_8 - 0.00189722455759605*x_81 - 0.0187724577418118*x_83 - 0.00758687250077558*x_88 - 0.00388511490059527*x_90 + 0.0354747578270203*x_91 + 0.00636055356152052*x_92 + 0.00970547593702594*x_97 - 0.00124891884288533*x_99 - 0.00101583068487596*std::pow(-3.28623986244202*x_14 - 4.83031988143921, 2) + 0.000304512047943926*std::pow(-3.721519947052*x_56 - 5.28943967819214, 2) - 0.000240436909852662*std::pow(-5.1267204284668*x_66 - 7.49520015716553, 2) - 0.000209792273125165*std::pow(-6.21640014648438*x_67 - 8.61551952362061, 2) - 0.000403364756746474*std::pow(-5.43391990661621*x_7 - 8.85800075531006, 2) + 0.00126445688005686*std::pow(-2.52336001396179*x_72 - 3.5783998966217, 2) + 0.000167748781316229*std::pow(-6.69712018966675*x_86 - 9.7344799041748, 2) - 0.193926932886576*std::sin(0.341919839382172*x_1 - 4.35288000106812) - 0.675885631704318*std::sin(0.270319938659668*x_10 - 7.50264024734497) - 0.0838382546047001*std::sin(0.428879857063293*x_104 + 5.22983980178833) + 0.153473450114895*std::sin(0.37391984462738*x_105 - 7.43215990066528) + 0.0634102975168176*std::sin(0.442479848861694*x_106 + 5.22079992294312) + 0.179082318139777*std::sin(0.296719938516617*x_108 - 7.49255990982056) + 0.125259463881957*std::sin(0.36959981918335*x_110 - 7.41879987716675) - 0.181198745119826*std::sin(0.253279983997345*x_111 - 4.3439998626709) + 0.242335574139673*std::sin(0.350879848003387*x_112 - 4.24528026580811) - 0.160462469958141*std::sin(0.181760013103485*x_114 - 1.20503985881805) + 0.161956696102109*std::sin(0.3642398416996*x_115 - 7.42384004592896) - 0.0986457833492569*std::sin(0.363599836826324*x_117 - 7.42176008224487) + 0.0327581337300842*std::sin(0.450399875640869*x_118 + 5.2403998374939) + 0.0910124827299263*std::sin(0.367199838161469*x_119 + 8.1812801361084) + 0.178958721974155*std::sin(0.302719920873642*x_120 - 7.48975992202759) + 0.281608713529664*std::sin(0.254239976406097*x_15 - 1.0914398431778) - 0.240221621943959*std::sin(0.364319831132889*x_21 + 8.36192035675049) - 0.258713811308233*std::sin(0.341359853744507*x_23 - 4.26792001724243) - 0.180885749274477*std::sin(0.437999874353409*x_24 + 8.44855976104736) - 0.262584459838521*std::sin(0.319279849529266*x_26 - 4.28200006484985) - 0.313332816561157*std::sin(0.366799861192703*x_27 - 4.24416017532349) + 0.210674570956161*std::sin(0.333199828863144*x_28 - 4.27544021606445) + 0.241331555565559*std::sin(0.295999944210052*x_33 - 1.16031992435455) + 0.208045019617217*std::sin(0.331839829683304*x_35 + 1.95959985256195) - 0.228177347265429*std::sin(0.358079850673676*x_36 + 5.17239999771118) - 0.328186071595461*std::sin(0.389999836683273*x_37 + 5.19632005691528) + 0.206323070399112*std::sin(0.262399971485138*x_38 - 7.52008008956909) - 0.0942370194298245*std::sin(0.309679925441742*x_40 - 7.48591995239258) - 0.171655504656172*std::sin(0.364639848470688*x_43 - 4.23912000656128) - 0.050418266268732*std::sin(0.29479992389679*x_46 + 5.11055994033813) + 0.1372373485368*std::sin(0.35455983877182*x_49 - 7.43215990066528) + 0.317385798045962*std::sin(0.249039962887764*x_50 + 5.05631971359253) + 0.150518929552057*std::sin(0.300319939851761*x_51 - 4.28999948501587) + 0.26705961378164*std::sin(0.290879935026169*x_53 + 5.103919506073) + 0.309475529005255*std::sin(0.26215997338295*x_54 - 7.52416038513184) - 0.129325305662235*std::sin(0.254079967737198*x_57 - 7.52976036071777) - 0.164735120739159*std::sin(0.367759823799133*x_59 - 4.2294397354126) + 0.307939903867847*std::sin(0.245839968323708*x_60 - 7.53416013717651) + 0.643520716886343*std::sin(0.196959987282753*x_68 + 4.9846396446228) + 0.248521991382411*std::sin(0.242239981889725*x_70 - 7.54864025115967) - 0.179041720232597*std::sin(0.275279968976974*x_73 + 5.07599973678589) - 0.259140275300076*std::sin(0.274639964103699*x_74 - 4.31271982192993) - 0.35519163351232*std::sin(0.246879979968071*x_75 + 5.0577597618103) - 0.281349361853422*std::sin(0.178640007972717*x_77 - 7.62040042877197) - 0.371790140791788*std::sin(0.177920013666153*x_80 - 7.6255202293396) - 0.727563763471025*std::sin(0.193039998412132*x_82 + 4.98015975952148) - 0.345461010389698*std::sin(0.249119967222214*x_84 + 5.05751991271973) - 0.680512019288983*std::sin(0.164800018072128*x_85 - 7.63064002990723) - 0.26625374961565*std::sin(0.259839981794357*x_87 + 5.06343984603882) + 0.0872022232289407*std::sin(0.341119825839996*x_89 - 4.27016019821167) + 0.898240626821348*std::sin(0.178000003099442*x_9 - 4.42439985275269) + 0.25215872272517*std::sin(0.335999846458435*x_93 + 1.99351978302002) + 0.0421508629603355*std::sin(0.411759853363037*x_94 - 4.18368005752563) - 0.102856993675259*std::sin(0.374639838933945*x_95 - 7.41559982299805) + 0.13441954192707*std::sin(0.383999854326248*x_96 - 7.40655994415283) - 0.0859120094363632*std::sin(0.362719833850861*x_98 - 7.41815996170044)) - 0.170970901846886*std::log(-0.0947074050252698*x_10 - 0.0483970847660689*x_100 + 0.0443422902805*x_101 + 0.0597993264508025*x_105 - 0.00017959886358034*x_108 + 0.0408027217051476*x_116 - 0.00166801351632823*x_118 + 0.0657174980653104*x_119 + 0.0333953113046324*x_120 + 0.00819993868925094*x_15 - 0.00594140807206951*x_17 + 0.00982531956605641*x_19 - 0.0859937624205524*x_2 - 0.10041928911246*x_20 + 0.0153505522194595*x_21 + 0.0622434102254643*x_22 + 0.0213262327406877*x_24 + 0.0447866197947506*x_25 - 0.00719667688208102*x_29 + 0.0118185636176289*x_3 + 0.0740705421763262*x_31 - 0.0477904231932753*x_32 + 0.0179992343162092*x_33 - 0.0429227865206986*x_39 + 0.0323617028866242*x_4 - 0.000866795345202387*x_40 - 0.00190044730408656*x_41 - 0.0848462632345454*x_42 + 0.00853356523125077*x_43 - 0.00428005549490389*x_44 - 0.0525693674814274*x_48 + 0.0097825706725289*x_49 + 0.00445015988146507*x_52 + 0.0111385573477714*x_55 - 0.019923185681612*x_58 + 0.0123501715167577*x_61 - 0.0141817383622791*x_62 + 0.00598415311405431*x_71 + 0.00275954896169265*x_72 + 0.000962930155675828*x_73 - 0.00929406443698537*x_76 - 0.017010874487747*x_78 - 0.007937955119324*x_79 - 0.058544923441374*x_9 - 0.0159733583319978*x_90 - 0.0891964830073054*x_91 + 0.043382508628153*x_92 - 0.100929825774274*x_97 - 0.00103293947200941*std::pow(-3.57223987579346*x_47 - 6.35407972335815, 2) - 0.00381316667362661*std::pow(-3.41503977775574*x_5 - 5.42375993728638, 2) + 0.000637616006267723*std::pow(-5.90503978729248*x_6 - 9.16919994354248, 2) + 0.000214112864789624*std::pow(-5.79999971389771*x_67 - 10.0, 2) - 0.00137338391066459*std::pow(-3.71591997146606*x_68 - 4.97343969345093, 2) - 0.000282628224091645*std::pow(-5.51319980621338*x_7 - 8.79199981689453, 2) + 0.000841090066706823*std::pow(-4.73992013931274*x_82 - 7.30111980438232, 2) + 0.00135396176889344*std::pow(-4.22168016433716*x_86 - 6.42952013015747, 2) + 0.00123280890882489*std::pow(-3.91824007034302*x_87 - 5.3600001335144, 2) + 0.000383821833540906*std::pow(-5.10663986206055*x_89 - 7.55287981033325, 2) - 0.95131288795443*std::sin(0.225279986858368*x_1 - 4.18847990036011) + 0.335026480301186*std::sin(0.397359818220139*x_102 + 1.99735975265503) + 0.157422914682774*std::sin(0.416559875011444*x_103 + 5.21712017059326) + 0.652271392679225*std::sin(0.394079834222794*x_104 - 7.39215993881226) + 0.725009207506432*std::sin(0.40055987238884*x_106 - 7.38775968551636) - 0.37011780766721*std::sin(0.392639845609665*x_107 - 7.40319967269897) + 0.564750380971379*std::sin(0.3504798412323*x_109 + 5.14728021621704) - 0.451496630278243*std::sin(0.300399929285049*x_11 - 1.06567990779877) - 0.325855981166843*std::sin(0.400079846382141*x_110 - 4.20775985717773) - 0.590769948943599*std::sin(0.355199843645096*x_111 - 4.24304008483887) + 0.535664271291814*std::sin(0.372479856014252*x_112 - 7.41504001617432) - 0.554359456204935*std::sin(0.377519845962524*x_113 - 7.42136001586914) + 0.442651598304309*std::sin(0.321759849786758*x_114 + 5.13535976409912) - 0.327708479349647*std::sin(0.33231982588768*x_115 + 5.14056015014648) + 0.31072239845105*std::sin(0.355279833078384*x_117 - 7.42416000366211) - 0.87817182149027*std::sin(0.283599942922592*x_12 + 8.31063938140869) - 0.183706283209229*std::sin(0.417599856853485*x_13 - 7.16351985931396) + 0.324021165893521*std::sin(0.351519852876663*x_14 - 1.0487197637558) + 0.585251742974531*std::sin(0.313599914312363*x_16 - 4.26719999313354) + 0.258068242784706*std::sin(0.237599983811378*x_18 - 4.33536005020142) + 1.54325767314396*std::sin(0.222559988498688*x_23 - 4.36664009094238) + 0.554856854091*std::sin(0.327199846506119*x_26 - 4.26272010803223) + 0.65511114599115*std::sin(0.366399854421616*x_27 + 5.17136001586914) + 1.14383790235038*std::sin(0.348239839076996*x_28 - 4.23992013931274) - 0.319358507865697*std::sin(0.296799927949905*x_30 - 4.29607963562012) + 0.541982761028695*std::sin(0.356959849596024*x_34 + 1.98511981964111) + 0.296132026584512*std::sin(0.333759844303131*x_35 + 1.97559976577759) - 0.325720249592671*std::sin(0.361599832773209*x_36 - 4.23776006698608) + 0.883136613368059*std::sin(0.385359823703766*x_37 + 5.19280004501343) + 0.838134055886989*std::sin(0.367359846830368*x_38 + 5.17296028137207) + 0.509845272228539*std::sin(0.341919839382172*x_45 + 5.13479995727539) + 0.272576887089137*std::sin(0.347519844770432*x_46 - 4.24232006072998) - 0.42261377243182*std::sin(0.366719841957092*x_50 + 5.16960000991821) + 0.664928006280068*std::sin(0.338239848613739*x_51 - 4.25888013839722) + 0.671787186543472*std::sin(0.305999934673309*x_53 + 5.12415981292725) - 0.461952554980925*std::sin(0.324559837579727*x_54 - 4.27511978149414) - 0.761250391468089*std::sin(0.300399929285049*x_56 + 5.12975978851318) + 0.865987443198549*std::sin(0.275119960308075*x_57 + 5.07976007461548) + 0.272195403723513*std::sin(0.280559957027435*x_59 + 1.87903988361359) - 0.450669192065522*std::sin(0.313439846038818*x_60 + 8.30096054077148) + 0.380631699792705*std::sin(0.270399957895279*x_63 + 8.28127956390381) + 1.94040281202247*std::sin(0.155440032482147*x_64 - 4.47199964523315) - 0.891238637940759*std::sin(0.295599937438965*x_65 - 4.2902398109436) - 0.507185071586012*std::sin(0.262159943580627*x_66 - 7.51416015625) - 0.987480982556889*std::sin(0.238479986786842*x_69 + 5.03991985321045) + 0.102089645790829*std::sin(0.332239836454391*x_70 - 4.28344011306763) + 0.590816534263755*std::sin(0.305599927902222*x_74 + 5.12239980697632) - 0.737534723674898*std::sin(0.202880010008812*x_75 - 4.40423965454102) - 0.521827740149217*std::sin(0.227039992809296*x_77 - 7.55208015441895) + 1.49671088953541*std::sin(0.202159985899925*x_8 - 4.39463996887207) + 0.463298569920724*std::sin(0.313839852809906*x_80 - 4.29152011871338) + 0.631953932934699*std::sin(0.360079854726791*x_81 - 4.23920011520386) - 2.64157009169696*std::sin(0.155760034918785*x_83 + 4.93103981018066) + 0.381992145612656*std::sin(0.302159935235977*x_84 + 5.14359951019287) - 1.02780956088303*std::sin(0.238879978656769*x_85 + 5.03191947937012) + 0.438467293465784*std::sin(0.345679849386215*x_88 - 4.25648021697998) + 0.698946306243386*std::sin(0.358159840106964*x_93 - 7.40423965454102) + 0.77461980924776*std::sin(0.396719843149185*x_94 - 7.39343976974487) + 0.45409642447596*std::sin(0.364079833030701*x_95 + 5.16887998580933) + 0.760451042658708*std::sin(0.395359843969345*x_96 - 7.38895988464355) - 0.245306405709846*std::sin(0.410319864749908*x_98 - 7.4031195640564) + 0.360262126278162*std::sin(0.397759854793549*x_99 + 1.99927973747253) + 0.545059663400574) + 0.0437414580522915*std::sin(0.281839966773987*x_1 + 2.15455985069275) + 0.0385211911492023*std::sin(0.34623983502388*x_10 - 1.06567978858948) + 0.00156081467106506*std::sin(0.36847984790802*x_10 + 5.17600011825562) + 0.0278097217365251*std::sin(0.316399842500687*x_101 - 4.24911975860596) - 0.00929710836635636*std::sin(0.301919937133789*x_102 + 5.10527992248535) + 0.000457619242365551*std::sin(0.300079941749573*x_103 + 5.10311985015869) - 0.0200490532205248*std::sin(0.398559838533401*x_104 + 5.20975971221924) + 0.00080491795537852*std::sin(0.40055987238884*x_104 + 5.20408010482788) + 0.0455688800227161*std::sin(0.162960022687912*x_105 - 7.63632011413574) - 0.0206824418840309*std::sin(0.324799835681915*x_105 + 8.32863998413086) - 0.000973031175992103*std::sin(0.403519839048386*x_105 + 2.01263976097107) - 0.017772879288061*std::sin(0.386079847812653*x_106 + 1.99143981933594) + 0.010724799424659*std::sin(0.396559834480286*x_106 - 7.3874397277832) + 0.00121514485855018*std::sin(0.35455983877182*x_107 + 5.15592002868652) - 0.0128116621650009*std::sin(0.369519859552383*x_107 + 5.18247985839844) + 0.00349639945208413*std::sin(0.570399820804596*x_107 + 2.1801598072052) - 0.00862539730418824*std::sin(0.127280056476593*x_108 + 1.72391986846924) - 0.0344553104019659*std::sin(0.388879835605621*x_108 + 5.17456007003784) + 0.000739830618729232*std::sin(0.432159870862961*x_109 + 5.23464012145996) + 0.000982894612888349*std::sin(0.262559980154037*x_11 + 8.27199935913086) + 0.0168712310438324*std::sin(0.298159927129745*x_11 - 4.2611198425293) + 0.0203736564947427*std::sin(0.357679843902588*x_111 - 4.2388801574707) + 0.00151869547519978*std::sin(0.388959854841232*x_111 + 5.20007991790771) - 0.0023525464158956*std::sin(0.762639880180359*x_111 - 1.20167982578278) + 0.021192092688304*std::sin(0.362399846315384*x_112 + 5.16552019119263) + 0.00138482320564388*std::sin(0.32423985004425*x_114 + 5.132080078125) + 0.0164032832439167*std::sin(0.389039844274521*x_114 - 7.40039968490601) + 0.0625736327183569*std::sin(0.189999997615814*x_115 - 7.61768007278442) + 0.0277307575260619*std::sin(0.230639979243279*x_115 + 1.83319985866547) + 0.000255543184694201*std::sin(0.491039872169495*x_115 - 4.1386399269104) + 0.056058622913343*std::sin(0.260159969329834*x_116 - 4.30823993682861) - 0.000829187743784118*std::sin(0.453839868307114*x_116 + 8.24575996398926) + 0.0353086770047269*std::sin(0.240879982709885*x_117 - 7.5633602142334) - 0.00143198587500837*std::sin(0.413519859313965*x_117 + 5.20032024383545) + 0.00814630267063734*std::sin(0.322159856557846*x_118 + 1.92447984218597) - 0.000716786662355234*std::sin(0.345439821481705*x_118 + 5.1592001914978) + 0.0202164105385438*std::sin(0.299039930105209*x_119 + 5.09831953048706) + 0.00109150301595469*std::sin(0.369119822978973*x_119 + 1.97495973110199) + 0.0461763991414162*std::sin(0.249199971556664*x_12 + 5.06543970108032) - 0.0012301908954162*std::sin(0.318879842758179*x_12 - 4.26143980026245) + 0.0362954183575912*std::sin(0.342079848051071*x_12 + 8.34247970581055) - 0.000930974781556284*std::sin(0.482079833745956*x_120 + 2.02687978744507) - 0.0590087155059733*std::sin(0.23319998383522*x_14 + 8.24967956542969) + 0.00196048352388989*std::sin(0.417839854955673*x_15 + 2.22183990478516) + 0.0403055861027856*std::sin(0.321199834346771*x_16 - 4.25663995742798) + 0.000998264660669181*std::sin(0.373839825391769*x_16 + 2.15111970901489) + 0.0257840716112363*std::sin(0.402399867773056*x_16 + 5.189040184021) + 0.0647925295226475*std::sin(0.238399982452393*x_19 - 4.33599996566772) + 0.00157163578344677*std::sin(0.254319965839386*x_19 - 4.31472015380859) + 0.0297782625650793*std::sin(0.311999946832657*x_21 - 4.27687978744507) + 0.0319609284928741*std::sin(0.333199828863144*x_21 - 4.25576019287109) + 0.00883731536335703*std::sin(0.477199852466583*x_23 - 7.31928014755249) - 0.00221350881587478*std::sin(0.359199821949005*x_24 + 2.12399983406067) + 0.0132223697665105*std::sin(0.382639855146408*x_24 + 5.38751983642578) - 0.0507818678897187*std::sin(0.350639849901199*x_27 + 8.32791996002197) + 0.000585830491032584*std::sin(0.444319844245911*x_27 - 0.939439833164215) + 0.0119696409319163*std::sin(0.536719858646393*x_27 - 4.05399990081787) + 0.0254181251820002*std::sin(0.311599940061569*x_28 + 5.12759971618652) + 0.014465015416497*std::sin(0.320399850606918*x_28 - 4.2739200592041) + 0.0276008693441156*std::sin(0.342559844255447*x_3 - 4.24079990386963) - 0.0417836350407006*std::sin(0.376959830522537*x_3 - 1.01671981811523) + 0.0289430503254756*std::sin(0.352079838514328*x_34 + 1.99303984642029) - 0.00223373828635788*std::sin(0.360879838466644*x_34 + 1.99647974967957) + 0.0367998144241835*std::sin(0.307439923286438*x_35 - 1.14431989192963) - 0.0366664470587981*std::sin(0.312399834394455*x_35 - 7.41991996765137) + 0.00139798149452714*std::sin(0.316639840602875*x_35 + 1.94799983501434) + 0.0230538491304949*std::sin(0.345039844512939*x_36 - 7.4507999420166) + 0.0197700701265746*std::sin(0.305039942264557*x_37 + 5.12063980102539) - 0.0191561155112079*std::sin(0.369439840316772*x_37 + 5.18287992477417) - 0.00205819736098519*std::sin(0.218799993395805*x_38 + 5.01575994491577) + 0.015924562892043*std::sin(0.320239841938019*x_38 + 5.11552000045776) + 0.044106870378016*std::sin(0.344159841537476*x_38 + 5.13088035583496) - 0.025907848431087*std::sin(0.352319836616516*x_39 - 7.42647981643677) + 0.0489829169749462*std::sin(0.2291199862957*x_40 + 5.04504013061523) + 0.00143033988474076*std::sin(0.317279845476151*x_40 - 7.46495962142944) + 0.00151424843002545*std::sin(0.333999842405319*x_41 + 5.14592027664185) + 0.0119926350078465*std::sin(0.341359823942184*x_41 + 1.95199990272522) - 0.0248211983860195*std::sin(0.317679852247238*x_42 + 8.32288074493408) + 0.00125113331959034*std::sin(0.355359852313995*x_43 + 5.16279983520508) + 0.0403059807628542*std::sin(0.360879838466644*x_43 + 5.16096019744873) + 0.00126607561368204*std::sin(0.269999951124191*x_44 - 4.30319976806641) + 0.0315238397588786*std::sin(0.329999834299088*x_44 + 5.11872005462646) + 0.0266027525816151*std::sin(0.328879833221436*x_45 - 7.44984006881714) - 0.00128655517835324*std::sin(0.351679861545563*x_45 + 5.14408016204834) + 0.0140689648568974*std::sin(0.35471984744072*x_45 + 8.35632038116455) + 0.0428575010044277*std::sin(0.246319979429245*x_46 - 7.53096008300781) + 0.0236539191481498*std::sin(0.29215994477272*x_47 - 7.47575998306274) + 0.00144467148587611*std::sin(0.324559837579727*x_47 - 4.27048015594482) + 0.0266524647360217*std::sin(0.336879849433899*x_47 - 4.26936006546021) + 0.0277477043385654*std::sin(0.300879925489426*x_48 + 5.12215948104858) - 0.00105706226742896*std::sin(0.337039858102798*x_49 + 5.13264036178589) + 0.0121822392832505*std::sin(0.433759868144989*x_49 - 4.17463970184326) + 0.0535299071600834*std::sin(0.246479973196983*x_50 - 7.53216028213501) - 0.000715894752378487*std::sin(0.31879985332489*x_50 + 5.11704015731812) + 0.0188015101727463*std::sin(0.22647999227047*x_51 - 7.58319997787476) + 0.000251393195838845*std::sin(0.449919849634171*x_51 - 4.16607999801636) + 0.00164609641869737*std::sin(0.281759947538376*x_52 + 5.10095977783203) + 0.0258313015369048*std::sin(0.236559987068176*x_53 - 4.34311962127686) + 0.000371039343798912*std::sin(0.350879848003387*x_54 + 2.13367986679077) + 0.00167657956563763*std::sin(0.239439979195595*x_55 + 5.03903961181641) - 0.00744652124625668*std::sin(0.378319829702377*x_55 - 1.00887978076935) - 0.0021660305646959*std::sin(0.22503998875618*x_56 + 5.03327989578247) + 0.00768474793018785*std::sin(0.318239837884903*x_56 + 5.1159200668335) - 0.00110444770587581*std::sin(0.318639844655991*x_57 - 4.29200029373169) + 0.00295195655268503*std::sin(0.213919997215271*x_58 + 5.01063966751099) - 0.0269033548604161*std::sin(0.286479920148849*x_58 + 5.09591960906982) + 0.00133325517346975*std::sin(0.376079827547073*x_59 - 7.42407989501953) + 0.00134191158171224*std::sin(0.253439962863922*x_60 - 7.54631996154785) + 0.0486817784732259*std::sin(0.281599938869476*x_60 + 5.08191967010498) + 0.0230942005950106*std::sin(0.289519935846329*x_65 - 4.28743982315063) + 0.00249079305885045*std::sin(0.292959928512573*x_65 + 5.12455987930298) - 0.0959665289400096*std::sin(0.162640020251274*x_66 + 4.94399976730347) - 0.00126040403326079*std::sin(0.230159983038902*x_66 + 5.02184009552002) + 0.00499244354005364*std::sin(0.20168000459671*x_67 + 4.99440002441406) + 0.0460442717359083*std::sin(0.183040007948875*x_68 - 4.43607997894287) + 0.0193604293128281*std::sin(0.196959987282753*x_68 + 4.98943948745728) + 0.000371582881834383*std::sin(0.353599846363068*x_68 + 8.35048007965088) - 0.053618551243326*std::sin(0.156880035996437*x_69 - 4.47191953659058) - 0.0041386657020482*std::sin(0.174560010433197*x_69 - 4.44608020782471) + 0.0297612964719113*std::sin(0.298639923334122*x_7 - 1.02047991752625) + 0.00203734135824717*std::sin(0.274159938097*x_70 + 1.88463997840881) - 0.158537489123336*std::sin(0.128320053219795*x_71 - 4.51495981216431) + 0.00634279913520344*std::sin(0.138400033116341*x_73 + 4.90935945510864) - 0.0638722713387607*std::sin(0.15776002407074*x_73 + 4.92848014831543) + 0.00359221873421048*std::sin(0.470879852771759*x_73 + 2.04903984069824) + 0.00401757565381863*std::sin(0.195040002465248*x_74 + 4.98744010925293) + 0.0298087629247316*std::sin(0.312799841165543*x_74 + 5.11303997039795) - 0.014514871079439*std::sin(0.326879858970642*x_74 - 4.27383995056152) + 0.0771840299651923*std::sin(0.19055999815464*x_75 + 4.97583961486816) - 0.00240207594334841*std::sin(0.285679936408997*x_75 - 7.48791980743408) - 0.00323518284831502*std::sin(0.191040009260178*x_76 + 4.97191953659058) + 0.000508501877523078*std::sin(0.321919828653336*x_77 - 4.29168033599854) + 0.00975264193877917*std::sin(0.332159847021103*x_77 - 1.0759197473526) - 0.0598487537518511*std::sin(0.221759989857674*x_78 + 5.01408004760742) - 0.0138954297801329*std::sin(0.377519845962524*x_78 + 5.1831202507019) + 0.0262189707048641*std::sin(0.286319941282272*x_79 + 5.09559965133667) + 0.00527879934186623*std::sin(0.487999856472015*x_79 - 7.32823991775513) + 0.00250057211211509*std::sin(0.273039966821671*x_8 - 4.31079959869385) - 0.0408787211746717*std::sin(0.169440016150475*x_80 - 7.63960027694702) - 0.000882032182592338*std::sin(0.249199971556664*x_80 + 5.05807971954346) - 0.00229090703893331*std::sin(0.193200007081032*x_81 - 7.60736036300659) - 0.00930791937138762*std::sin(0.36831983923912*x_81 - 7.42639970779419) - 0.0128858712950373*std::sin(0.209600001573563*x_82 + 8.20239925384521) - 0.00200072849538404*std::sin(0.322719842195511*x_84 + 5.12712001800537) + 0.0168560130969619*std::sin(0.390079826116562*x_84 + 5.18688011169434) - 0.0147728923504807*std::sin(0.346639841794968*x_85 - 4.24584007263184) - 0.0118885715336324*std::sin(0.391279846429825*x_86 - 4.19704008102417) - 0.141146244106566*std::sin(0.152880027890205*x_87 - 7.64616012573242) - 0.000345140029659755*std::sin(0.572799861431122*x_88 - 0.833039879798889) + 0.106766171454299*std::sin(0.180400013923645*x_89 + 4.9684796333313) - 0.074533887604293*std::sin(0.240079984068871*x_9 - 4.34311962127686) - 0.0311378579006085*std::sin(0.400879859924316*x_9 - 0.971039831638336) - 0.000227918822735753*std::sin(0.627359867095947*x_9 - 6.96623992919922) - 0.0351244775645931*std::sin(0.374399840831757*x_92 + 2.0020797252655) + 0.0286997960154527*std::sin(0.340079843997955*x_93 - 7.4270396232605) - 0.0330219880727438*std::sin(0.361279845237732*x_93 + 2.00159978866577) + 0.00179914313177249*std::sin(0.36151984333992*x_93 - 7.41088008880615) + 0.000193185938725764*std::sin(0.380799859762192*x_94 + 1.97039985656738) - 0.011931040876968*std::sin(0.384719848632813*x_94 + 2.0019998550415) + 0.000467385790920778*std::sin(0.353599846363068*x_95 + 1.95167982578278) + 0.00878557336688236*std::sin(0.357599824666977*x_95 - 7.42639970779419) - 0.0148889907770835*std::sin(0.358639866113663*x_95 - 7.41207981109619) - 0.0269416712053408*std::sin(0.393039852380753*x_96 + 5.19248008728027) - 0.00580572440127895*std::sin(0.414799869060516*x_96 + 8.39535999298096) + 0.000750806743193833*std::sin(0.415759861469269*x_96 - 7.37639951705933) - 0.00103672433017021*std::sin(0.33519983291626*x_97 - 7.44375991821289) + 0.000724575104823803*std::sin(0.343839854001999*x_98 + 1.95423984527588) + 0.0173577982103692*std::sin(0.41839987039566*x_98 + 2.01895976066589) + 0.0176838632368846*std::sin(0.310559868812561*x_99 - 7.46631956100464) - 0.000413250078768405*std::sin(0.389679849147797*x_99 - 7.41063976287842) - 0.0179058506453443*std::sin(0.409279853105545*x_99 - 7.38895988464355) + 0.871246672647903);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00323506550845595*x_1 + 0.000564237167133032*x_10 - 0.00211461030833171*x_100 - 0.00145742614074431*x_101 - 0.000195562823467025*x_102 - 0.000170504576503156*x_103 - 9.95639439189669e-5*x_104 - 2.76995509994482e-6*x_106 + 0.0011083269186194*x_107 - 0.000186870703171372*x_108 - 0.00153178832291453*x_109 + 0.00316017411537527*x_11 + 9.26986288003726e-5*x_110 + 0.000611855367937545*x_112 - 0.00491959762163261*x_113 + 0.000176096301331643*x_114 - 0.0015562768520221*x_116 + 0.000200689637067496*x_117 - 1.15412718462711e-5*x_118 - 0.000334909764621014*x_119 - 0.00321875835029714*x_12 + 6.53707019341122e-5*x_120 - 0.00276409686490625*x_13 - 0.000737689943037409*x_14 - 1.56091826750067e-5*x_15 - 0.000538963779219782*x_16 - 0.00254032650459451*x_17 + 0.000248740716501025*x_18 + 0.000164363456467002*x_19 + 0.00063057994911105*x_2 + 0.00396549774045837*x_20 + 2.52276603649031e-6*x_21 + 0.00610889829348274*x_22 + 6.56774468931113e-5*x_23 - 0.000323967169618975*x_24 + 0.00435650431903455*x_25 - 2.3853355455972e-5*x_26 - 2.67692017641718e-6*x_28 + 0.00513559227516615*x_29 - 0.00113450782456843*x_3 + 0.00306576954930424*x_30 + 0.0137274674104856*x_31 + 0.000178204484351126*x_32 - 0.000958734057816627*x_33 - 0.00253097911606142*x_34 - 0.000204049535020949*x_36 - 1.79330781295302e-5*x_37 - 0.000117406499980755*x_39 - 0.00210123525789685*x_4 - 0.000156967398475613*x_40 - 9.47657996396061e-6*x_41 - 0.00237158527565396*x_42 - 2.5195403167757e-5*x_43 + 0.000181228541950172*x_44 - 0.000316619567342722*x_45 - 0.000180196298419751*x_46 + 0.000176970406968359*x_47 - 0.00556299224453704*x_48 + 9.49721438962342e-6*x_49 + 0.00308468677546892*x_5 + 0.000363772742717962*x_50 - 0.000552836266197083*x_51 - 0.00239696471380494*x_52 - 0.000105042636741732*x_53 + 0.000414773645178933*x_54 + 0.00143883198263521*x_55 - 1.32853000763333e-5*x_56 - 0.000136450619839273*x_57 + 0.000936867023317653*x_58 + 0.00103711569878292*x_59 - 4.34797933590635e-6*x_6 - 0.000282014111477169*x_60 - 0.000254788120052159*x_61 + 0.00187403469613887*x_62 + 0.000295037229201549*x_63 - 0.00243396910217982*x_64 - 0.00107714625578788*x_65 - 0.000238077278450169*x_66 + 5.93221965754338e-6*x_67 - 0.000721265177200103*x_69 - 0.000332466187017135*x_70 + 0.000416324595534924*x_71 - 4.57796326237282e-5*x_72 + 0.0028584089726022*x_76 + 0.000195414214214663*x_77 - 0.000195044291110237*x_78 + 6.9743417482271e-5*x_79 + 0.00250139556583742*x_8 + 0.000111994978597567*x_80 - 0.000319432789374234*x_81 - 0.00103596958820503*x_82 - 0.00338872834128776*x_83 + 0.000192501233078834*x_86 - 1.92125352677257e-5*x_87 - 0.000963802884106079*x_88 + 2.51783722999117e-5*x_89 - 0.000654130838001087*x_90 + 0.00625337316122972*x_91 + 0.00140976407039134*x_92 + 0.000420216655945873*x_94 + 0.00220000845625455*x_97 - 0.000266708164959203*x_98 - 0.000210278550363274*x_99 - 0.000171033854639233*std::pow(-3.28623986244202*x_14 - 4.83031988143921, 2) + 2.28688990018383e-5*std::pow(-5.59087991714478*x_17 - 8.77711963653564, 2) + 4.10326323874366e-5*std::pow(-4.67167949676514*x_17 - 6.90744018554688, 2) + 0.000134865787203596*std::pow(-1.91071999073029*x_18 - 2.75584006309509, 2) + 1.58447563737363e-5*std::pow(-6.07679986953735*x_22 - 9.73752021789551, 2) - 1.11122629383179e-6*std::pow(-6.36255979537964*x_23 - 8.93599987030029, 2) - 4.9287860862602e-5*std::pow(-4.91200017929077*x_4 - 8.39608001708984, 2) + 5.12702265439996e-5*std::pow(-3.721519947052*x_56 - 5.28943967819214, 2) + 7.78226161897112e-6*std::pow(-5.77103996276855*x_58 - 7.56695985794067, 2) + 7.92277472662828e-5*std::pow(-2.89567995071411*x_6 - 4.63944005966187, 2) - 4.0481993802607e-5*std::pow(-5.1267204284668*x_66 - 7.49520015716553, 2) - 7.06749802604103e-6*std::pow(-6.9987998008728*x_67 - 9.77744007110596, 2) - 3.53224033102575e-5*std::pow(-6.21640014648438*x_67 - 8.61551952362061, 2) - 1.55645561479503e-6*std::pow(-5.72896003723145*x_7 - 8.99792003631592, 2) - 6.79139055347497e-5*std::pow(-5.43391990661621*x_7 - 8.85800075531006, 2) - 3.36530085429527e-5*std::pow(-5.27688026428223*x_7 - 8.52688026428223, 2) + 6.09423277795136e-7*std::pow(-6.60000038146973*x_71 - 9.96463966369629, 2) + 1.06304566977255e-5*std::pow(-7.60000038146973*x_72 - 9.99660015106201, 2) + 0.00021289466585431*std::pow(-2.52336001396179*x_72 - 3.5783998966217, 2) - 3.47126361202505e-6*std::pow(-6.59600019454956*x_75 - 9.96208000183105, 2) + 2.8292179805063e-7*std::pow(-6.40000009536743*x_78 - 9.99993991851807, 2) - 6.93955418179361e-6*std::pow(-7.19984006881714*x_81 - 9.79320049285889, 2) + 1.77996612551711e-5*std::pow(-5.49191999435425*x_83 - 7.52191972732544, 2) + 2.19805049374571e-5*std::pow(-4.27015972137451*x_84 - 6.41544008255005, 2) - 8.54260380295486e-7*std::pow(-3.90391993522644*x_85 - 6.36783981323242, 2) + 2.05048579443973e-5*std::pow(-3.28543996810913*x_85 - 7.1800799369812, 2) + 2.82436050679566e-5*std::pow(-6.69712018966675*x_86 - 9.7344799041748, 2) + 8.36256028101453e-6*std::pow(-4.28991985321045*x_87 - 6.95071983337402, 2) + 7.23238279690482e-6*std::pow(-4.93191957473755*x_88 - 5.71687984466553, 2) + 2.62761468018572e-5*std::pow(-4.09903955459595*x_89 - 5.94736003875732, 2) - 6.3556774253166e-7*std::pow(-6.60000038146973*x_90 - 9.96016025543213, 2) - 5.38930016233754e-6*std::pow(-5.74399995803833*x_90 - 7.7992000579834, 2) - 1.95316553195677e-5*std::pow(-4.90768003463745*x_90 - 7.15335988998413, 2) + 1.05299877266183e-5*std::exp(1.29391980171204*x_17) - 4.71599245981244e-5*std::exp(0.730479836463928*x_22) - 0.000240122087447215*std::exp(0.602479875087738*x_29) - 0.496231638455774*std::exp(0.0429682730985185*x_10 + 0.0219575138274113*x_100 - 0.0201178739727684*x_101 - 0.0271306535044431*x_105 + 8.1483100676706e-5*x_108 - 0.0185119895210078*x_116 + 0.000756769339023579*x_118 - 0.0298156981860942*x_119 - 0.015151284695897*x_120 - 0.00372027092175984*x_15 + 0.00269558694552246*x_17 - 0.00445769804675658*x_19 + 0.039014937295236*x_2 + 0.0455597261670511*x_20 - 0.00696446829899748*x_21 - 0.028239522014538*x_22 - 0.0096756044822465*x_24 - 0.0203194640375469*x_25 + 0.00326509608819441*x_29 - 0.00536202284308179*x_3 - 0.0336054322672923*x_31 + 0.021682274524516*x_32 - 0.00816616203829832*x_33 + 0.0194738522597962*x_39 - 0.0146823417576964*x_4 + 0.000393260686461034*x_40 + 0.000862223378937967*x_41 + 0.0384943226886852*x_42 - 0.0038716356050783*x_43 + 0.00194183964107955*x_44 + 0.0238504575007166*x_48 - 0.00443830308887278*x_49 - 0.00201901514530825*x_52 - 0.00505350742019433*x_55 + 0.00903904909158459*x_58 - 0.00560321067190044*x_61 + 0.00643418333338934*x_62 - 0.00271498015598072*x_71 - 0.00125199347805069*x_72 - 0.000436876566228778*x_73 + 0.00421667026793799*x_76 + 0.00771774815748685*x_78 + 0.00360141029436811*x_79 + 0.026561537171139*x_9 + 0.00724703229833664*x_90 + 0.040467995509566*x_91 - 0.0196824258666568*x_92 + 0.0457913540815288*x_97 + 0.000468639440767041*std::pow(-3.57223987579346*x_47 - 6.35407972335815, 2) + 0.00173001453221995*std::pow(-3.41503977775574*x_5 - 5.42375993728638, 2) - 0.00028928317360177*std::pow(-5.90503978729248*x_6 - 9.16919994354248, 2) - 9.71419293531693e-5*std::pow(-5.79999971389771*x_67 - 10.0, 2) + 0.000623097369490823*std::pow(-3.71591997146606*x_68 - 4.97343969345093, 2) + 0.000128227003103705*std::pow(-5.51319980621338*x_7 - 8.79199981689453, 2) - 0.000381598330954872*std::pow(-4.73992013931274*x_82 - 7.30111980438232, 2) - 0.000614285641500192*std::pow(-4.22168016433716*x_86 - 6.42952013015747, 2) - 0.000559319198520335*std::pow(-3.91824007034302*x_87 - 5.3600001335144, 2) - 0.000174138034511233*std::pow(-5.10663986206055*x_89 - 7.55287981033325, 2) + 0.431605870320908*std::sin(0.225279986858368*x_1 - 4.18847990036011) - 0.151999828281387*std::sin(0.397359818220139*x_102 + 1.99735975265503) - 0.0714219842497998*std::sin(0.416559875011444*x_103 + 5.21712017059326) - 0.295932248671726*std::sin(0.394079834222794*x_104 - 7.39215993881226) - 0.328933029246919*std::sin(0.40055987238884*x_106 - 7.38775968551636) + 0.167920586930096*std::sin(0.392639845609665*x_107 - 7.40319967269897) - 0.256224406059863*std::sin(0.3504798412323*x_109 + 5.14728021621704) + 0.204841749255827*std::sin(0.300399929285049*x_11 - 1.06567990779877) + 0.147839218969485*std::sin(0.400079846382141*x_110 - 4.20775985717773) + 0.268029353120101*std::sin(0.355199843645096*x_111 - 4.24304008483887) - 0.243028184457639*std::sin(0.372479856014252*x_112 - 7.41504001617432) + 0.251510095779778*std::sin(0.377519845962524*x_113 - 7.42136001586914) - 0.200828802756874*std::sin(0.321759849786758*x_114 + 5.13535976409912) + 0.148679688073375*std::sin(0.33231982588768*x_115 + 5.14056015014648) - 0.140973188642525*std::sin(0.355279833078384*x_117 - 7.42416000366211) + 0.398422136507165*std::sin(0.283599942922592*x_12 + 8.31063938140869) + 0.083346616294067*std::sin(0.417599856853485*x_13 - 7.16351985931396) - 0.14700677251265*std::sin(0.351519852876663*x_14 - 1.0487197637558) - 0.265525770839185*std::sin(0.313599914312363*x_16 - 4.26719999313354) - 0.117084263168961*std::sin(0.237599983811378*x_18 - 4.33536005020142) - 0.700168240734087*std::sin(0.222559988498688*x_23 - 4.36664009094238) - 0.251735762697813*std::sin(0.327199846506119*x_26 - 4.26272010803223) - 0.297220630459893*std::sin(0.366399854421616*x_27 + 5.17136001586914) - 0.518953500579116*std::sin(0.348239839076996*x_28 - 4.23992013931274) + 0.144891348027615*std::sin(0.296799927949905*x_30 - 4.29607963562012) - 0.245894851457036*std::sin(0.356959849596024*x_34 + 1.98511981964111) - 0.134353610344471*std::sin(0.333759844303131*x_35 + 1.97559976577759) + 0.147777638237276*std::sin(0.361599832773209*x_36 - 4.23776006698608) - 0.400674637599611*std::sin(0.385359823703766*x_37 + 5.19280004501343) - 0.380257203720365*std::sin(0.367359846830368*x_38 + 5.17296028137207) - 0.23131423450214*std::sin(0.341919839382172*x_45 + 5.13479995727539) - 0.123666762083335*std::sin(0.347519844770432*x_46 - 4.24232006072998) + 0.19173774198755*std::sin(0.366719841957092*x_50 + 5.16960000991821) - 0.301674490575179*std::sin(0.338239848613739*x_51 - 4.25888013839722) - 0.304786466145741*std::sin(0.305999934673309*x_53 + 5.12415981292725) + 0.209585549679908*std::sin(0.324559837579727*x_54 - 4.27511978149414) + 0.345375472047063*std::sin(0.300399929285049*x_56 + 5.12975978851318) - 0.392894145387203*std::sin(0.275119960308075*x_57 + 5.07976007461548) - 0.123493684999951*std::sin(0.280559957027435*x_59 + 1.87903988361359) + 0.204466344702331*std::sin(0.313439846038818*x_60 + 8.30096054077148) - 0.172690686882218*std::sin(0.270399957895279*x_63 + 8.28127956390381) - 0.880350991834995*std::sin(0.155440032482147*x_64 - 4.47199964523315) + 0.404350485379389*std::sin(0.295599937438965*x_65 - 4.2902398109436) + 0.23010731485658*std::sin(0.262159943580627*x_66 - 7.51416015625) + 0.448015152846565*std::sin(0.238479986786842*x_69 + 5.03991985321045) - 0.0463175585869018*std::sin(0.332239836454391*x_70 - 4.28344011306763) - 0.268050488645441*std::sin(0.305599927902222*x_74 + 5.12239980697632) + 0.334615792904977*std::sin(0.202880010008812*x_75 - 4.40423965454102) + 0.236750619902759*std::sin(0.227039992809296*x_77 - 7.55208015441895) - 0.679050199231249*std::sin(0.202159985899925*x_8 - 4.39463996887207) - 0.210196229885035*std::sin(0.313839852809906*x_80 - 4.29152011871338) - 0.286714319421758*std::sin(0.360079854726791*x_81 - 4.23920011520386) + 1.19846705839558*std::sin(0.155760034918785*x_83 + 4.93103981018066) - 0.173307914305056*std::sin(0.302159935235977*x_84 + 5.14359951019287) + 0.466312025902376*std::sin(0.238879978656769*x_85 + 5.03191947937012) - 0.198930404706783*std::sin(0.345679849386215*x_88 - 4.25648021697998) - 0.317108422090683*std::sin(0.358159840106964*x_93 - 7.40423965454102) - 0.351441109619667*std::sin(0.396719843149185*x_94 - 7.39343976974487) - 0.206021262801338*std::sin(0.364079833030701*x_95 + 5.16887998580933) - 0.345012811514518*std::sin(0.395359843969345*x_96 - 7.38895988464355) + 0.111294281904823*std::sin(0.410319864749908*x_98 - 7.4031195640564) - 0.163449113877027*std::sin(0.397759854793549*x_99 + 1.99927973747253)) + 0.0184902864104234*std::sin(0.281839966773987*x_1 + 2.15455985069275) - 0.0326511803037384*std::sin(0.341919839382172*x_1 - 4.35288000106812) - 0.113797827341451*std::sin(0.270319938659668*x_10 - 7.50264024734497) + 0.0154157882619328*std::sin(0.34623983502388*x_10 - 1.06567978858948) + 0.000641167582994665*std::sin(0.36847984790802*x_10 + 5.17600011825562) + 0.011755660254576*std::sin(0.316399842500687*x_101 - 4.24911975860596) - 0.00372060805360016*std::sin(0.301919937133789*x_102 + 5.10527992248535) + 0.000187985562282775*std::sin(0.300079941749573*x_103 + 5.10311985015869) - 0.00847508868730782*std::sin(0.398559838533401*x_104 + 5.20975971221924) + 0.00033065251725683*std::sin(0.40055987238884*x_104 + 5.20408010482788) - 0.0141157183620794*std::sin(0.428879857063293*x_104 + 5.22983980178833) + 0.0192627699336168*std::sin(0.162960022687912*x_105 - 7.63632011413574) - 0.0082769025388913*std::sin(0.324799835681915*x_105 + 8.32863998413086) + 0.0258400894447658*std::sin(0.37391984462738*x_105 - 7.43215990066528) - 0.000399711803620859*std::sin(0.403519839048386*x_105 + 2.01263976097107) - 0.00711252522925457*std::sin(0.386079847812653*x_106 + 1.99143981933594) + 0.00453356202299479*std::sin(0.396559834480286*x_106 - 7.3874397277832) + 0.010676294553404*std::sin(0.442479848861694*x_106 + 5.22079992294312) + 0.000499169764603357*std::sin(0.35455983877182*x_107 + 5.15592002868652) - 0.00512709667917835*std::sin(0.369519859552383*x_107 + 5.18247985839844) + 0.00147798976424143*std::sin(0.570399820804596*x_107 + 2.1801598072052) - 0.00354322985580429*std::sin(0.127280056476593*x_108 + 1.72391986846924) + 0.0301518152829923*std::sin(0.296719938516617*x_108 - 7.49255990982056) - 0.0145648678864516*std::sin(0.388879835605621*x_108 + 5.17456007003784) + 0.000303915268372242*std::sin(0.432159870862961*x_109 + 5.23464012145996) + 0.000403763608176535*std::sin(0.262559980154037*x_11 + 8.27199935913086) + 0.00713176716066386*std::sin(0.298159927129745*x_11 - 4.2611198425293) + 0.0210897438487899*std::sin(0.36959981918335*x_110 - 7.41879987716675) - 0.0305081548480886*std::sin(0.253279983997345*x_111 - 4.3439998626709) + 0.00815332977186012*std::sin(0.357679843902588*x_111 - 4.2388801574707) + 0.000623865424377595*std::sin(0.388959854841232*x_111 + 5.20007991790771) - 0.000994462895400577*std::sin(0.762639880180359*x_111 - 1.20167982578278) + 0.040801668997015*std::sin(0.350879848003387*x_112 - 4.24528026580811) + 0.00848085959867606*std::sin(0.362399846315384*x_112 + 5.16552019119263) - 0.027016819998132*std::sin(0.181760013103485*x_114 - 1.20503985881805) + 0.000568871989799872*std::sin(0.32423985004425*x_114 + 5.132080078125) + 0.00693395736577259*std::sin(0.389039844274521*x_114 - 7.40039968490601) + 0.026450979053325*std::sin(0.189999997615814*x_115 - 7.61768007278442) + 0.0110975666538707*std::sin(0.230639979243279*x_115 + 1.83319985866547) + 0.0272684005626006*std::sin(0.3642398416996*x_115 - 7.42384004592896) + 0.000104974670675882*std::sin(0.491039872169495*x_115 - 4.1386399269104) + 0.023696969410633*std::sin(0.260159969329834*x_116 - 4.30823993682861) - 0.000340622311788036*std::sin(0.453839868307114*x_116 + 8.24575996398926) + 0.0149256010124319*std::sin(0.240879982709885*x_117 - 7.5633602142334) - 0.0166088392694992*std::sin(0.363599836826324*x_117 - 7.42176008224487) - 0.000588245958589754*std::sin(0.413519859313965*x_117 + 5.20032024383545) + 0.00326006733804656*std::sin(0.322159856557846*x_118 + 1.92447984218597) - 0.000294449033793047*std::sin(0.345439821481705*x_118 + 5.1592001914978) + 0.00551543674163368*std::sin(0.450399875640869*x_118 + 5.2403998374939) + 0.00854583357970148*std::sin(0.299039930105209*x_119 + 5.09831953048706) + 0.0153236321498663*std::sin(0.367199838161469*x_119 + 8.1812801361084) + 0.000448378890553039*std::sin(0.369119822978973*x_119 + 1.97495973110199) + 0.0195195789885675*std::sin(0.249199971556664*x_12 + 5.06543970108032) - 0.000505350531141421*std::sin(0.318879842758179*x_12 - 4.26143980026245) + 0.0145250566658679*std::sin(0.342079848051071*x_12 + 8.34247970581055) + 0.0301310055861209*std::sin(0.302719920873642*x_120 - 7.48975992202759) - 0.000382435443224091*std::sin(0.482079833745956*x_120 + 2.02687978744507) - 0.0249440256223805*std::sin(0.23319998383522*x_14 + 8.24967956542969) + 0.0474140272508654*std::sin(0.254239976406097*x_15 - 1.0914398431778) + 0.000805347685292836*std::sin(0.417839854955673*x_15 + 2.22183990478516) + 0.0170378826899083*std::sin(0.321199834346771*x_16 - 4.25663995742798) + 0.000410077475267126*std::sin(0.373839825391769*x_16 + 2.15111970901489) + 0.0103185227826882*std::sin(0.402399867773056*x_16 + 5.189040184021) + 0.0259293102388098*std::sin(0.238399982452393*x_19 - 4.33599996566772) + 0.000645612791384694*std::sin(0.254319965839386*x_19 - 4.31472015380859) + 0.012587797210026*std::sin(0.311999946832657*x_21 - 4.27687978744507) + 0.0127904379797748*std::sin(0.333199828863144*x_21 - 4.25576019287109) - 0.0404457461075621*std::sin(0.364319831132889*x_21 + 8.36192035675049) - 0.0435592476731075*std::sin(0.341359853744507*x_23 - 4.26792001724243) + 0.00353660357795708*std::sin(0.477199852466583*x_23 - 7.31928014755249) - 0.000909288029976917*std::sin(0.359199821949005*x_24 + 2.12399983406067) + 0.00529145767720448*std::sin(0.382639855146408*x_24 + 5.38751983642578) - 0.0304554562175855*std::sin(0.437999874353409*x_24 + 8.44855976104736) - 0.0442109428305241*std::sin(0.319279849529266*x_26 - 4.28200006484985) - 0.0203223861874156*std::sin(0.350639849901199*x_27 + 8.32791996002197) - 0.0527553658294603*std::sin(0.366799861192703*x_27 - 4.24416017532349) + 0.000240653504188059*std::sin(0.444319844245911*x_27 - 0.939439833164215) + 0.00505977850112991*std::sin(0.536719858646393*x_27 - 4.05399990081787) + 0.0101720747497999*std::sin(0.311599940061569*x_28 + 5.12759971618652) + 0.00611461734225861*std::sin(0.320399850606918*x_28 - 4.2739200592041) + 0.0354709544430613*std::sin(0.333199828863144*x_28 - 4.27544021606445) + 0.0116673746617972*std::sin(0.342559844255447*x_3 - 4.24079990386963) - 0.0167213850710495*std::sin(0.376959830522537*x_3 - 1.01671981811523) + 0.0406326239293508*std::sin(0.295999944210052*x_33 - 1.16031992435455) + 0.0122347382537996*std::sin(0.352079838514328*x_34 + 1.99303984642029) - 0.000917598100951621*std::sin(0.360879838466644*x_34 + 1.99647974967957) + 0.0147269108331657*std::sin(0.307439923286438*x_35 - 1.14431989192963) - 0.0154995543806361*std::sin(0.312399834394455*x_35 - 7.41991996765137) + 0.00057427728771001*std::sin(0.316639840602875*x_35 + 1.94799983501434) + 0.0350282209165323*std::sin(0.331839829683304*x_35 + 1.95959985256195) + 0.00974526895687717*std::sin(0.345039844512939*x_36 - 7.4507999420166) - 0.0384178700497973*std::sin(0.358079850673676*x_36 + 5.17239999771118) + 0.00791178065637639*std::sin(0.305039942264557*x_37 + 5.12063980102539) - 0.00809762815610652*std::sin(0.369439840316772*x_37 + 5.18287992477417) - 0.0552561856021636*std::sin(0.389999836683273*x_37 + 5.19632005691528) - 0.00084548758525468*std::sin(0.218799993395805*x_38 + 5.01575994491577) + 0.034738298967284*std::sin(0.262399971485138*x_38 - 7.52008008956909) + 0.00637284783735589*std::sin(0.320239841938019*x_38 + 5.11552000045776) + 0.018644752650494*std::sin(0.344159841537476*x_38 + 5.13088035583496) - 0.0109517048379127*std::sin(0.352319836616516*x_39 - 7.42647981643677) + 0.0207059436153683*std::sin(0.2291199862957*x_40 + 5.04504013061523) - 0.0158665424492107*std::sin(0.309679925441742*x_40 - 7.48591995239258) + 0.000587569801694846*std::sin(0.317279845476151*x_40 - 7.46495962142944) + 0.000622038621196696*std::sin(0.333999842405319*x_41 + 5.14592027664185) + 0.00479933035475288*std::sin(0.341359823942184*x_41 + 1.95199990272522) - 0.00993319072726097*std::sin(0.317679852247238*x_42 + 8.32288074493408) + 0.000513953476602344*std::sin(0.355359852313995*x_43 + 5.16279983520508) + 0.0170380495196855*std::sin(0.360879838466644*x_43 + 5.16096019744873) - 0.0289013740857542*std::sin(0.364639848470688*x_43 - 4.23912000656128) + 0.000520091626611297*std::sin(0.269999951124191*x_44 - 4.30319976806641) + 0.0133256835014767*std::sin(0.329999834299088*x_44 + 5.11872005462646) + 0.0112454530882728*std::sin(0.328879833221436*x_45 - 7.44984006881714) - 0.000528504433861536*std::sin(0.351679861545563*x_45 + 5.14408016204834) + 0.0056302564076603*std::sin(0.35471984744072*x_45 + 8.35632038116455) + 0.0181166221633383*std::sin(0.246319979429245*x_46 - 7.53096008300781) - 0.00848884617540512*std::sin(0.29479992389679*x_46 + 5.11055994033813) + 0.00946605746796347*std::sin(0.29215994477272*x_47 - 7.47575998306274) + 0.000593457084939132*std::sin(0.324559837579727*x_47 - 4.27048015594482) + 0.0112664672934224*std::sin(0.336879849433899*x_47 - 4.26936006546021) + 0.0117294444057734*std::sin(0.300879925489426*x_48 + 5.12215948104858) - 0.000434230963897722*std::sin(0.337039858102798*x_49 + 5.13264036178589) + 0.0231064419200755*std::sin(0.35455983877182*x_49 - 7.43215990066528) + 0.00487520805416938*std::sin(0.433759868144989*x_49 - 4.17463970184326) + 0.0226280366267184*std::sin(0.246479973196983*x_50 - 7.53216028213501) + 0.0534377601068217*std::sin(0.249039962887764*x_50 + 5.05631971359253) - 0.000294082645794112*std::sin(0.31879985332489*x_50 + 5.11704015731812) + 0.00752417283009261*std::sin(0.22647999227047*x_51 - 7.58319997787476) + 0.0253426413483492*std::sin(0.300319939851761*x_51 - 4.28999948501587) + 0.000103269895360036*std::sin(0.449919849634171*x_51 - 4.16607999801636) + 0.000676200500750146*std::sin(0.281759947538376*x_52 + 5.10095977783203) + 0.010919347114593*std::sin(0.236559987068176*x_53 - 4.34311962127686) + 0.0449644176372918*std::sin(0.290879935026169*x_53 + 5.103919506073) + 0.0521059202388119*std::sin(0.26215997338295*x_54 - 7.52416038513184) + 0.000152419376668941*std::sin(0.350879848003387*x_54 + 2.13367986679077) + 0.000688722682920833*std::sin(0.239439979195595*x_55 + 5.03903961181641) - 0.00314777597125334*std::sin(0.378319829702377*x_55 - 1.00887978076935) - 0.000889784423227498*std::sin(0.22503998875618*x_56 + 5.03327989578247) + 0.00324847859555148*std::sin(0.318239837884903*x_56 + 5.1159200668335) - 0.0217743033943791*std::sin(0.254079967737198*x_57 - 7.52976036071777) - 0.000453696444073776*std::sin(0.318639844655991*x_57 - 4.29200029373169) + 0.00121263522382116*std::sin(0.213919997215271*x_58 + 5.01063966751099) - 0.01137252297753*std::sin(0.286479920148849*x_58 + 5.09591960906982) - 0.0277361996580348*std::sin(0.367759823799133*x_59 - 4.2294397354126) + 0.00054768834054168*std::sin(0.376079827547073*x_59 - 7.42407989501953) + 0.0518473693893033*std::sin(0.245839968323708*x_60 - 7.53416013717651) + 0.000551244309391246*std::sin(0.253439962863922*x_60 - 7.54631996154785) + 0.020578647055218*std::sin(0.281599938869476*x_60 + 5.08191967010498) + 0.00924206380514943*std::sin(0.289519935846329*x_65 - 4.28743982315063) + 0.00102319371728693*std::sin(0.292959928512573*x_65 + 5.12455987930298) - 0.0405667457128125*std::sin(0.162640020251274*x_66 + 4.94399976730347) - 0.000517761796185002*std::sin(0.230159983038902*x_66 + 5.02184009552002) + 0.00205084755874908*std::sin(0.20168000459671*x_67 + 4.99440002441406) + 0.0184264484710867*std::sin(0.183040007948875*x_68 - 4.43607997894287) + 0.108348596265049*std::sin(0.196959987282753*x_68 + 4.9846396446228) + 0.0081839952064468*std::sin(0.196959987282753*x_68 + 4.98943948745728) + 0.000152642656841104*std::sin(0.353599846363068*x_68 + 8.35048007965088) - 0.0226655080453845*std::sin(0.156880035996437*x_69 - 4.47191953659058) - 0.00170012387389621*std::sin(0.174560010433197*x_69 - 4.44608020782471) + 0.012580625342971*std::sin(0.298639923334122*x_7 - 1.02047991752625) + 0.0418432665813223*std::sin(0.242239981889725*x_70 - 7.54864025115967) + 0.000836920140884525*std::sin(0.274159938097*x_70 + 1.88463997840881) - 0.0670165950384067*std::sin(0.128320053219795*x_71 - 4.51495981216431) + 0.00260556058725663*std::sin(0.138400033116341*x_73 + 4.90935945510864) - 0.0255610322887807*std::sin(0.15776002407074*x_73 + 4.92848014831543) - 0.0301449798756172*std::sin(0.275279968976974*x_73 + 5.07599973678589) + 0.00151849426612702*std::sin(0.470879852771759*x_73 + 2.04903984069824) + 0.0016503812523106*std::sin(0.195040002465248*x_74 + 4.98744010925293) - 0.0436310507614329*std::sin(0.274639964103699*x_74 - 4.31271982192993) + 0.0126006902504207*std::sin(0.312799841165543*x_74 + 5.11303997039795) - 0.00580870353523626*std::sin(0.326879858970642*x_74 - 4.27383995056152) + 0.0326270518614398*std::sin(0.19055999815464*x_75 + 4.97583961486816) - 0.0598030706491562*std::sin(0.246879979968071*x_75 + 5.0577597618103) - 0.000986749583610324*std::sin(0.285679936408997*x_75 - 7.48791980743408) - 0.00132898184893694*std::sin(0.191040009260178*x_76 + 4.97191953659058) - 0.0473703606068516*std::sin(0.178640007972717*x_77 - 7.62040042877197) + 0.000208887657070293*std::sin(0.321919828653336*x_77 - 4.29168033599854) + 0.00390290794851962*std::sin(0.332159847021103*x_77 - 1.0759197473526) - 0.025299124616644*std::sin(0.221759989857674*x_78 + 5.01408004760742) - 0.00556080943783381*std::sin(0.377519845962524*x_78 + 5.1831202507019) + 0.0104925649694083*std::sin(0.286319941282272*x_79 + 5.09559965133667) + 0.00223144165925095*std::sin(0.487999856472015*x_79 - 7.32823991775513) + 0.00102721085786223*std::sin(0.273039966821671*x_8 - 4.31079959869385) - 0.0163592477607063*std::sin(0.169440016150475*x_80 - 7.63960027694702) - 0.0625977358660388*std::sin(0.177920013666153*x_80 - 7.6255202293396) - 0.00036233029655618*std::sin(0.249199971556664*x_80 + 5.05807971954346) - 0.000941082472024707*std::sin(0.193200007081032*x_81 - 7.60736036300659) - 0.00372493450767618*std::sin(0.36831983923912*x_81 - 7.42639970779419) - 0.12249879513875*std::sin(0.193039998412132*x_82 + 4.98015975952148) - 0.0051567944170108*std::sin(0.209600001573563*x_82 + 8.20239925384521) - 0.0581647405558821*std::sin(0.249119967222214*x_84 + 5.05751991271973) - 0.000821879930650953*std::sin(0.322719842195511*x_84 + 5.12712001800537) + 0.006745604720183*std::sin(0.390079826116562*x_84 + 5.18688011169434) - 0.11457676512453*std::sin(0.164800018072128*x_85 - 7.63064002990723) - 0.00591196101930647*std::sin(0.346639841794968*x_85 - 4.24584007263184) - 0.00502550903549849*std::sin(0.391279846429825*x_86 - 4.19704008102417) - 0.0596650087924816*std::sin(0.152880027890205*x_87 - 7.64616012573242) - 0.0448287355234543*std::sin(0.259839981794357*x_87 + 5.06343984603882) - 0.0001417801887143*std::sin(0.572799861431122*x_88 - 0.833039879798889) + 0.0427267341319162*std::sin(0.180400013923645*x_89 + 4.9684796333313) + 0.0146821046007069*std::sin(0.341119825839996*x_89 - 4.27016019821167) + 0.151235396888582*std::sin(0.178000003099442*x_9 - 4.42439985275269) - 0.0315067899071436*std::sin(0.240079984068871*x_9 - 4.34311962127686) - 0.0124610535138104*std::sin(0.400879859924316*x_9 - 0.971039831638336) - 9.36268497481216e-5*std::sin(0.627359867095947*x_9 - 6.96623992919922) - 0.0140564580895102*std::sin(0.374399840831757*x_92 + 2.0020797252655) + 0.042455577460586*std::sin(0.335999846458435*x_93 + 1.99351978302002) + 0.0121319103632086*std::sin(0.340079843997955*x_93 - 7.4270396232605) - 0.0132150632140572*std::sin(0.361279845237732*x_93 + 2.00159978866577) + 0.000739070611421707*std::sin(0.36151984333992*x_93 - 7.41088008880615) + 7.93589166591006e-5*std::sin(0.380799859762192*x_94 + 1.97039985656738) - 0.00477468101106763*std::sin(0.384719848632813*x_94 + 2.0019998550415) + 0.00709687615840878*std::sin(0.411759853363037*x_94 - 4.18368005752563) + 0.000191997566044299*std::sin(0.353599846363068*x_95 + 1.95167982578278) + 0.003713816938595*std::sin(0.357599824666977*x_95 - 7.42639970779419) - 0.00595842242687614*std::sin(0.358639866113663*x_95 - 7.41207981109619) - 0.0173178742942096*std::sin(0.374639838933945*x_95 - 7.41559982299805) + 0.0226320121422932*std::sin(0.383999854326248*x_96 - 7.40655994415283) - 0.0113887199728613*std::sin(0.393039852380753*x_96 + 5.19248008728027) - 0.00232339175937206*std::sin(0.414799869060516*x_96 + 8.39535999298096) + 0.000308424154227866*std::sin(0.415759861469269*x_96 - 7.37639951705933) - 0.000425876335819814*std::sin(0.33519983291626*x_97 - 7.44375991821289) + 0.000297648450690799*std::sin(0.343839854001999*x_98 + 1.95423984527588) - 0.0144648732829897*std::sin(0.362719833850861*x_98 - 7.41815996170044) + 0.00694641401061525*std::sin(0.41839987039566*x_98 + 2.01895976066589) + 0.00707690191242789*std::sin(0.310559868812561*x_99 - 7.46631956100464) - 0.00016975913866538*std::sin(0.389679849147797*x_99 - 7.41063976287842) - 0.00756911912855945*std::sin(0.409279853105545*x_99 - 7.38895988464355) + 0.134810824327962);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00193115103648636*x_1 - 0.00225737553181295*x_10 - 0.00574115791922447*x_100 + 0.00112093738536626*x_101 + 0.00102311291636488*x_102 - 0.000912445563016365*x_103 - 2.46501238754465e-5*x_104 + 0.00241127920710118*x_105 - 6.70065906359967e-5*x_106 + 0.000845852120039391*x_107 - 5.35075416431271e-5*x_108 - 0.00335596407868713*x_109 + 0.00217415319263741*x_11 + 0.000384554088153179*x_110 + 0.00157911495118717*x_112 - 0.00427080475585624*x_113 + 4.35980684470057e-5*x_114 + 0.000564297544544081*x_116 + 4.96869069214298e-5*x_117 - 9.91989233530252e-5*x_118 + 0.00256699950959882*x_119 - 0.00245648962301192*x_12 + 0.000931741679637842*x_120 - 0.0031438133879875*x_13 - 0.00105923576851829*x_14 - 0.000588679070225843*x_15 - 0.000411325979382846*x_16 - 0.00217829900772103*x_17 - 0.00100815182483942*x_18 + 0.00088252344855301*x_19 + 0.00267290837781256*x_2 - 0.0046484104729179*x_20 + 0.000680004962597272*x_21 + 0.00816770355950502*x_22 + 0.000181758899805268*x_23 - 3.66277394713788e-5*x_24 + 0.00888287885540971*x_25 - 0.00137843425440706*x_26 - 6.47560295941256e-5*x_28 + 0.00255471093772061*x_29 - 0.00225902275468665*x_3 + 0.00146787982093534*x_30 + 0.0166716706580823*x_31 - 0.00478980727228044*x_32 + 0.00172833847803968*x_33 - 0.00192506373168336*x_34 - 0.000136097445021048*x_36 - 0.000433810073344767*x_37 - 0.00156796513305903*x_39 - 0.00101753140541818*x_4 - 7.38137765657639e-5*x_40 + 0.000608253141501639*x_41 - 0.00654920713335351*x_42 + 0.000337859762897821*x_43 - 2.33287131812761e-5*x_44 - 0.000241637487805856*x_45 - 5.147089880269e-5*x_46 + 0.000135060144623109*x_47 - 0.00484237508632806*x_48 + 0.000420744163644167*x_49 + 0.00133836917486882*x_5 + 9.0063157580487e-5*x_50 - 0.00152994545722778*x_51 - 0.007286173251534*x_52 - 0.000207571321177382*x_53 + 0.000804473014865783*x_54 + 0.00164350847671487*x_55 - 3.28918561995323e-6*x_56 - 0.000492637267664968*x_57 - 8.83621229693906e-5*x_58 + 0.00286027480322521*x_59 + 0.00165489870449825*x_6 - 6.98212877966549e-5*x_60 + 4.63140699030562e-5*x_61 + 0.00133190003947718*x_62 - 0.000363457422110557*x_63 - 0.00233720210608382*x_64 - 0.00127711958840343*x_65 - 5.89433702074137e-5*x_66 + 1.64171076886267e-5*x_67 - 0.00068090944162141*x_69 - 0.00044001425713081*x_70 + 0.000576430875039851*x_71 - 0.000221342336591086*x_72 + 3.88280872056656e-5*x_73 + 0.00324121786188451*x_76 + 0.000540798619041533*x_77 - 0.000834780680469387*x_78 - 0.000214078561602201*x_79 + 0.00353216953781378*x_8 + 0.000309940246714179*x_80 - 0.000243784480520298*x_81 - 0.0025286711970039*x_82 - 0.00203719281594746*x_83 - 0.000455077635719189*x_86 - 0.000464760777454404*x_87 - 0.000107041435536126*x_88 + 0.000609077340500758*x_89 - 0.00236069810404396*x_9 - 0.00114331040539651*x_90 + 0.00322235609439399*x_91 + 0.00376529894391473*x_92 + 0.00116292762093622*x_94 - 0.00251202318105079*x_97 - 0.000738100899551735*x_98 - 0.000160480228924824*x_99 - 0.000130529490996495*std::pow(-3.28623986244202*x_14 - 4.83031988143921, 2) + 6.32884821040128e-5*std::pow(-5.59087991714478*x_17 - 8.77711963653564, 2) + 1.01588931843557e-5*std::pow(-4.67167949676514*x_17 - 6.90744018554688, 2) + 3.3390183537064e-5*std::pow(-1.91071999073029*x_18 - 2.75584006309509, 2) + 3.92285793446222e-6*std::pow(-6.07679986953735*x_22 - 9.73752021789551, 2) - 2.68811163676357e-5*std::pow(-6.36255979537964*x_23 - 8.93599987030029, 2) - 1.22027295022356e-5*std::pow(-4.91200017929077*x_4 - 8.39608001708984, 2) - 4.16510622924741e-5*std::pow(-3.57223987579346*x_47 - 6.35407972335815, 2) - 0.000153757743758059*std::pow(-3.41503977775574*x_5 - 5.42375993728638, 2) + 3.91283736671872e-5*std::pow(-3.721519947052*x_56 - 5.28943967819214, 2) + 1.92673879105171e-6*std::pow(-5.77103996276855*x_58 - 7.56695985794067, 2) + 2.57104939015182e-5*std::pow(-5.90503978729248*x_6 - 9.16919994354248, 2) + 1.96152714287406e-5*std::pow(-2.89567995071411*x_6 - 4.63944005966187, 2) - 3.08950181630618e-5*std::pow(-5.1267204284668*x_66 - 7.49520015716553, 2) - 1.74977702744655e-6*std::pow(-6.9987998008728*x_67 - 9.77744007110596, 2) - 2.6957325697805e-5*std::pow(-6.21640014648438*x_67 - 8.61551952362061, 2) + 8.63364070270658e-6*std::pow(-5.79999971389771*x_67 - 10.0, 2) - 5.53787519643273e-5*std::pow(-3.71591997146606*x_68 - 4.97343969345093, 2) - 3.76514349368863e-5*std::pow(-5.72896003723145*x_7 - 8.99792003631592, 2) - 1.13963751858106e-5*std::pow(-5.51319980621338*x_7 - 8.79199981689453, 2) - 5.18304843198074e-5*std::pow(-5.43391990661621*x_7 - 8.85800075531006, 2) - 8.33183978770867e-6*std::pow(-5.27688026428223*x_7 - 8.52688026428223, 2) + 1.47422519953769e-5*std::pow(-6.60000038146973*x_71 - 9.96463966369629, 2) + 2.9419233012372e-5*std::pow(-7.60000038146973*x_72 - 9.99660015106201, 2) + 0.000162476794015129*std::pow(-2.52336001396179*x_72 - 3.5783998966217, 2) - 8.59418326280733e-7*std::pow(-6.59600019454956*x_75 - 9.96208000183105, 2) + 6.84401891725838e-6*std::pow(-6.40000009536743*x_78 - 9.99993991851807, 2) - 1.92048533079344e-5*std::pow(-7.19984006881714*x_81 - 9.79320049285889, 2) + 3.39151477035121e-5*std::pow(-4.73992013931274*x_82 - 7.30111980438232, 2) + 4.9259631725814e-5*std::pow(-5.49191999435425*x_83 - 7.52191972732544, 2) + 6.08298979876379e-5*std::pow(-4.27015972137451*x_84 - 6.41544008255005, 2) - 2.06649831977965e-5*std::pow(-3.90391993522644*x_85 - 6.36783981323242, 2) + 5.67461221003687e-5*std::pow(-3.28543996810913*x_85 - 7.1800799369812, 2) + 2.15549336779126e-5*std::pow(-6.69712018966675*x_86 - 9.7344799041748, 2) + 5.45955958756264e-5*std::pow(-4.22168016433716*x_86 - 6.42952013015747, 2) + 2.07040961545947e-6*std::pow(-4.28991985321045*x_87 - 6.95071983337402, 2) + 4.97103674006124e-5*std::pow(-3.91824007034302*x_87 - 5.3600001335144, 2) + 1.79059933587454e-6*std::pow(-4.93191957473755*x_88 - 5.71687984466553, 2) + 1.54767898131772e-5*std::pow(-5.10663986206055*x_89 - 7.55287981033325, 2) + 7.27178622153203e-5*std::pow(-4.09903955459595*x_89 - 5.94736003875732, 2) - 1.53746995921023e-5*std::pow(-6.60000038146973*x_90 - 9.96016025543213, 2) - 1.33428740741433e-6*std::pow(-5.74399995803833*x_90 - 7.7992000579834, 2) - 5.40528347278478e-5*std::pow(-4.90768003463745*x_90 - 7.15335988998413, 2) + 0.000254725636893406*std::exp(1.29391980171204*x_17) - 0.00114082201622472*std::exp(0.730479836463928*x_22) - 5.9449625716133e-5*std::exp(0.602479875087738*x_29) - 0.0383596458742572*std::sin(0.225279986858368*x_1 - 4.18847990036011) + 0.0511709007281061*std::sin(0.281839966773987*x_1 + 2.15455985069275) - 0.0249187036944915*std::sin(0.341919839382172*x_1 - 4.35288000106812) - 0.0868481419115453*std::sin(0.270319938659668*x_10 - 7.50264024734497) + 0.00381665365329011*std::sin(0.34623983502388*x_10 - 1.06567978858948) + 0.0155101625162266*std::sin(0.36847984790802*x_10 + 5.17600011825562) + 0.0325331750156744*std::sin(0.316399842500687*x_101 - 4.24911975860596) - 0.000921151230086582*std::sin(0.301919937133789*x_102 + 5.10527992248535) + 0.01350922215559*std::sin(0.397359818220139*x_102 + 1.99735975265503) + 0.00454746418727527*std::sin(0.300079941749573*x_103 + 5.10311985015869) + 0.00634774040821562*std::sin(0.416559875011444*x_103 + 5.21712017059326) + 0.0263014408339249*std::sin(0.394079834222794*x_104 - 7.39215993881226) - 0.0234543647542231*std::sin(0.398559838533401*x_104 + 5.20975971221924) + 0.00799864873875811*std::sin(0.40055987238884*x_104 + 5.20408010482788) - 0.0107728235251354*std::sin(0.428879857063293*x_104 + 5.22983980178833) + 0.053308708483055*std::sin(0.162960022687912*x_105 - 7.63632011413574) - 0.00204920240056703*std::sin(0.324799835681915*x_105 + 8.32863998413086) + 0.0197206203978958*std::sin(0.37391984462738*x_105 - 7.43215990066528) - 0.00966922720087858*std::sin(0.403519839048386*x_105 + 2.01263976097107) - 0.0017609248997916*std::sin(0.386079847812653*x_106 + 1.99143981933594) + 0.0125463958250318*std::sin(0.396559834480286*x_106 - 7.3874397277832) + 0.0292344367533207*std::sin(0.40055987238884*x_106 - 7.38775968551636) + 0.00814792660040312*std::sin(0.442479848861694*x_106 + 5.22079992294312) + 0.0120751647112656*std::sin(0.35455983877182*x_107 + 5.15592002868652) - 0.00126937085141984*std::sin(0.369519859552383*x_107 + 5.18247985839844) - 0.0149242044480225*std::sin(0.392639845609665*x_107 - 7.40319967269897) + 0.00409025938400398*std::sin(0.570399820804596*x_107 + 2.1801598072052) - 0.085712491325888*std::sin(0.127280056476593*x_108 + 1.72391986846924) + 0.0230112401419651*std::sin(0.296719938516617*x_108 - 7.49255990982056) - 0.0403075102349661*std::sin(0.388879835605621*x_108 + 5.17456007003784) + 0.0227723442998826*std::sin(0.3504798412323*x_109 + 5.14728021621704) + 0.00735186139885572*std::sin(0.432159870862961*x_109 + 5.23464012145996) + 0.00976724236697446*std::sin(0.262559980154037*x_11 + 8.27199935913086) + 0.0197367926755625*std::sin(0.298159927129745*x_11 - 4.2611198425293) - 0.0182056304189621*std::sin(0.300399929285049*x_11 - 1.06567990779877) + 0.0160952551507166*std::sin(0.36959981918335*x_110 - 7.41879987716675) - 0.013139441504305*std::sin(0.400079846382141*x_110 - 4.20775985717773) - 0.0232831911083515*std::sin(0.253279983997345*x_111 - 4.3439998626709) - 0.0238215274086721*std::sin(0.355199843645096*x_111 - 4.24304008483887) + 0.00201860815233768*std::sin(0.357679843902588*x_111 - 4.2388801574707) + 0.0150916146994782*std::sin(0.388959854841232*x_111 + 5.20007991790771) - 0.00275212405956251*std::sin(0.762639880180359*x_111 - 1.20167982578278) + 0.031138987642077*std::sin(0.350879848003387*x_112 - 4.24528026580811) + 0.00209969825871682*std::sin(0.362399846315384*x_112 + 5.16552019119263) + 0.0215995094930642*std::sin(0.372479856014252*x_112 - 7.41504001617432) - 0.0223533526101938*std::sin(0.377519845962524*x_113 - 7.42136001586914) - 0.0206186767534337*std::sin(0.181760013103485*x_114 - 1.20503985881805) + 0.0178489735308207*std::sin(0.321759849786758*x_114 + 5.13535976409912) + 0.0137612961833079*std::sin(0.32423985004425*x_114 + 5.132080078125) + 0.0191893644122706*std::sin(0.389039844274521*x_114 - 7.40039968490601) + 0.0732017013287529*std::sin(0.189999997615814*x_115 - 7.61768007278442) + 0.00274754476335911*std::sin(0.230639979243279*x_115 + 1.83319985866547) - 0.0132141395086892*std::sin(0.33231982588768*x_115 + 5.14056015014648) + 0.0208106778230112*std::sin(0.3642398416996*x_115 - 7.42384004592896) + 0.00253938945987519*std::sin(0.491039872169495*x_115 - 4.1386399269104) + 0.0655801236580576*std::sin(0.260159969329834*x_116 - 4.30823993682861) - 0.0082398230238181*std::sin(0.453839868307114*x_116 + 8.24575996398926) + 0.0413058202972956*std::sin(0.240879982709885*x_117 - 7.5633602142334) + 0.0125292123345575*std::sin(0.355279833078384*x_117 - 7.42416000366211) - 0.0126755216998602*std::sin(0.363599836826324*x_117 - 7.42176008224487) - 0.0142299621179016*std::sin(0.413519859313965*x_117 + 5.20032024383545) + 0.000807130177472169*std::sin(0.322159856557846*x_118 + 1.92447984218597) - 0.00712286847932245*std::sin(0.345439821481705*x_118 + 5.1592001914978) + 0.00420926694324571*std::sin(0.450399875640869*x_118 + 5.2403998374939) + 0.0236501475444591*std::sin(0.299039930105209*x_119 + 5.09831953048706) + 0.0116946782785118*std::sin(0.367199838161469*x_119 + 8.1812801361084) + 0.0108465082230785*std::sin(0.369119822978973*x_119 + 1.97495973110199) + 0.0540194141133123*std::sin(0.249199971556664*x_12 + 5.06543970108032) - 0.0354103897000204*std::sin(0.283599942922592*x_12 + 8.31063938140869) - 0.0122246805258869*std::sin(0.318879842758179*x_12 - 4.26143980026245) + 0.00359612558541202*std::sin(0.342079848051071*x_12 + 8.34247970581055) + 0.0229953586128599*std::sin(0.302719920873642*x_120 - 7.48975992202759) - 0.00925130345590189*std::sin(0.482079833745956*x_120 + 2.02687978744507) - 0.00740756070690341*std::sin(0.417599856853485*x_13 - 7.16351985931396) - 0.0690312865117452*std::sin(0.23319998383522*x_14 + 8.24967956542969) + 0.0130654565252088*std::sin(0.351519852876663*x_14 - 1.0487197637558) + 0.0361854023357184*std::sin(0.254239976406097*x_15 - 1.0914398431778) + 0.0194817607942957*std::sin(0.417839854955673*x_15 + 2.22183990478516) + 0.0235990176229697*std::sin(0.313599914312363*x_16 - 4.26719999313354) + 0.0471514493821435*std::sin(0.321199834346771*x_16 - 4.25663995742798) + 0.0099199779501172*std::sin(0.373839825391769*x_16 + 2.15111970901489) + 0.00255466843511033*std::sin(0.402399867773056*x_16 + 5.189040184021) + 0.010406046769638*std::sin(0.237599983811378*x_18 - 4.33536005020142) + 0.00641960015075081*std::sin(0.238399982452393*x_19 - 4.33599996566772) + 0.0156176943166115*std::sin(0.254319965839386*x_19 - 4.31472015380859) + 0.0348360705249359*std::sin(0.311999946832657*x_21 - 4.27687978744507) + 0.0031666672513422*std::sin(0.333199828863144*x_21 - 4.25576019287109) - 0.0308673546739006*std::sin(0.364319831132889*x_21 + 8.36192035675049) + 0.0622285460274014*std::sin(0.222559988498688*x_23 - 4.36664009094238) - 0.0332435145015832*std::sin(0.341359853744507*x_23 - 4.26792001724243) + 0.000875595249279613*std::sin(0.477199852466583*x_23 - 7.31928014755249) - 0.0219961293943316*std::sin(0.359199821949005*x_24 + 2.12399983406067) + 0.00131006348373394*std::sin(0.382639855146408*x_24 + 5.38751983642578) - 0.0232429726064047*std::sin(0.437999874353409*x_24 + 8.44855976104736) - 0.0337408747310062*std::sin(0.319279849529266*x_26 - 4.28200006484985) + 0.0223734091100159*std::sin(0.327199846506119*x_26 - 4.26272010803223) - 0.00503143324025182*std::sin(0.350639849901199*x_27 + 8.32791996002197) + 0.0264159477777443*std::sin(0.366399854421616*x_27 + 5.17136001586914) - 0.0402618011713441*std::sin(0.366799861192703*x_27 - 4.24416017532349) + 0.00582152787984492*std::sin(0.444319844245911*x_27 - 0.939439833164215) + 0.014002672410827*std::sin(0.536719858646393*x_27 - 4.05399990081787) + 0.00251841070957318*std::sin(0.311599940061569*x_28 + 5.12759971618652) + 0.0169218837429521*std::sin(0.320399850606918*x_28 - 4.2739200592041) + 0.0270706968417387*std::sin(0.333199828863144*x_28 - 4.27544021606445) + 0.0461228029466324*std::sin(0.348239839076996*x_28 - 4.23992013931274) + 0.0322888492543786*std::sin(0.342559844255447*x_3 - 4.24079990386963) - 0.0041398943949617*std::sin(0.376959830522537*x_3 - 1.01671981811523) - 0.0128774448699009*std::sin(0.296799927949905*x_30 - 4.29607963562012) + 0.0310099759520568*std::sin(0.295999944210052*x_33 - 1.16031992435455) + 0.033858998326095*std::sin(0.352079838514328*x_34 + 1.99303984642029) + 0.0218542890002441*std::sin(0.356959849596024*x_34 + 1.98511981964111) - 0.0221971541416169*std::sin(0.360879838466644*x_34 + 1.99647974967957) + 0.00364610080769443*std::sin(0.307439923286438*x_35 - 1.14431989192963) - 0.0428942062300511*std::sin(0.312399834394455*x_35 - 7.41991996765137) + 0.0138920530263836*std::sin(0.316639840602875*x_35 + 1.94799983501434) + 0.0267328117956066*std::sin(0.331839829683304*x_35 + 1.95959985256195) + 0.0119408869738262*std::sin(0.333759844303131*x_35 + 1.97559976577759) + 0.0269695222287061*std::sin(0.345039844512939*x_36 - 7.4507999420166) - 0.0293197217202825*std::sin(0.358079850673676*x_36 + 5.17239999771118) - 0.0131339684205435*std::sin(0.361599832773209*x_36 - 4.23776006698608) + 0.0019588052218358*std::sin(0.305039942264557*x_37 + 5.12063980102539) - 0.022409762472671*std::sin(0.369439840316772*x_37 + 5.18287992477417) + 0.0356105842529197*std::sin(0.385359823703766*x_37 + 5.19280004501343) - 0.0421703749603959*std::sin(0.389999836683273*x_37 + 5.19632005691528) - 0.0204527649253615*std::sin(0.218799993395805*x_38 + 5.01575994491577) + 0.0265115493762808*std::sin(0.262399971485138*x_38 - 7.52008008956909) + 0.00157779495715886*std::sin(0.320239841938019*x_38 + 5.11552000045776) + 0.051598377969997*std::sin(0.344159841537476*x_38 + 5.13088035583496) + 0.0337959529257633*std::sin(0.367359846830368*x_38 + 5.17296028137207) - 0.0303082704413079*std::sin(0.352319836616516*x_39 - 7.42647981643677) + 0.0573026161794058*std::sin(0.2291199862957*x_40 + 5.04504013061523) - 0.0121090161602117*std::sin(0.309679925441742*x_40 - 7.48591995239258) + 0.0142136055465392*std::sin(0.317279845476151*x_40 - 7.46495962142944) + 0.0150474234225447*std::sin(0.333999842405319*x_41 + 5.14592027664185) + 0.00118822219276623*std::sin(0.341359823942184*x_41 + 1.95199990272522) - 0.00245926760499465*std::sin(0.317679852247238*x_42 + 8.32288074493408) + 0.0124327900525632*std::sin(0.355359852313995*x_43 + 5.16279983520508) + 0.0471519110748281*std::sin(0.360879838466644*x_43 + 5.16096019744873) - 0.02205692935162*std::sin(0.364639848470688*x_43 - 4.23912000656128) + 0.0125812749521633*std::sin(0.269999951124191*x_44 - 4.30319976806641) + 0.0368781322502302*std::sin(0.329999834299088*x_44 + 5.11872005462646) + 0.0311212033631989*std::sin(0.328879833221436*x_45 - 7.44984006881714) + 0.0205584138940919*std::sin(0.341919839382172*x_45 + 5.13479995727539) - 0.0127847849410175*std::sin(0.351679861545563*x_45 + 5.14408016204834) + 0.00139394355462966*std::sin(0.35471984744072*x_45 + 8.35632038116455) + 0.0501368044643266*std::sin(0.246319979429245*x_46 - 7.53096008300781) - 0.00647851136115954*std::sin(0.29479992389679*x_46 + 5.11055994033813) + 0.0109910766422283*std::sin(0.347519844770432*x_46 - 4.24232006072998) + 0.00234361436492818*std::sin(0.29215994477272*x_47 - 7.47575998306274) + 0.0143560218544122*std::sin(0.324559837579727*x_47 - 4.27048015594482) + 0.0311793590770546*std::sin(0.336879849433899*x_47 - 4.26936006546021) + 0.0324606240250189*std::sin(0.300879925489426*x_48 + 5.12215948104858) - 0.0105042628452528*std::sin(0.337039858102798*x_49 + 5.13264036178589) + 0.0176343572968605*std::sin(0.35455983877182*x_49 - 7.43215990066528) + 0.00120700805656772*std::sin(0.433759868144989*x_49 - 4.17463970184326) + 0.0626219080762871*std::sin(0.246479973196983*x_50 - 7.53216028213501) + 0.0407825903324771*std::sin(0.249039962887764*x_50 + 5.05631971359253) - 0.00711400537152006*std::sin(0.31879985332489*x_50 + 5.11704015731812) - 0.0170409913051079*std::sin(0.366719841957092*x_50 + 5.16960000991821) + 0.00186284095448251*std::sin(0.22647999227047*x_51 - 7.58319997787476) + 0.0193409783266848*std::sin(0.300319939851761*x_51 - 4.28999948501587) + 0.0268117915522249*std::sin(0.338239848613739*x_51 - 4.25888013839722) + 0.00249815009764958*std::sin(0.449919849634171*x_51 - 4.16607999801636) + 0.0163576262093648*std::sin(0.281759947538376*x_52 + 5.10095977783203) + 0.0302187221341033*std::sin(0.236559987068176*x_53 - 4.34311962127686) + 0.0343159110781289*std::sin(0.290879935026169*x_53 + 5.103919506073) + 0.0270883732418283*std::sin(0.305999934673309*x_53 + 5.12415981292725) + 0.0397661577646276*std::sin(0.26215997338295*x_54 - 7.52416038513184) - 0.0186272430912609*std::sin(0.324559837579727*x_54 - 4.27511978149414) + 0.00368710047959007*std::sin(0.350879848003387*x_54 + 2.13367986679077) + 0.0166605440200532*std::sin(0.239439979195595*x_55 + 5.03903961181641) - 0.00871130539376183*std::sin(0.378319829702377*x_55 - 1.00887978076935) - 0.021524327453062*std::sin(0.22503998875618*x_56 + 5.03327989578247) - 0.0306957845395598*std::sin(0.300399929285049*x_56 + 5.12975978851318) + 0.00898999464046355*std::sin(0.318239837884903*x_56 + 5.1159200668335) - 0.0166176967996581*std::sin(0.254079967737198*x_57 - 7.52976036071777) + 0.0349190808547535*std::sin(0.275119960308075*x_57 + 5.07976007461548) - 0.0109751424857625*std::sin(0.318639844655991*x_57 - 4.29200029373169) + 0.0293342487880014*std::sin(0.213919997215271*x_58 + 5.01063966751099) - 0.0314728626368513*std::sin(0.286479920148849*x_58 + 5.09591960906982) + 0.0109756941461037*std::sin(0.280559957027435*x_59 + 1.87903988361359) - 0.0211676923915272*std::sin(0.367759823799133*x_59 - 4.2294397354126) + 0.0132488531787088*std::sin(0.376079827547073*x_59 - 7.42407989501953) + 0.0395688371180558*std::sin(0.245839968323708*x_60 - 7.53416013717651) + 0.0133348738326256*std::sin(0.253439962863922*x_60 - 7.54631996154785) + 0.0569503296059103*std::sin(0.281599938869476*x_60 + 5.08191967010498) - 0.0181722657529046*std::sin(0.313439846038818*x_60 + 8.30096054077148) + 0.0153481545319548*std::sin(0.270399957895279*x_63 + 8.28127956390381) + 0.0782425694690687*std::sin(0.155440032482147*x_64 - 4.47199964523315) + 0.00228815782796963*std::sin(0.289519935846329*x_65 - 4.28743982315063) + 0.0247515645856262*std::sin(0.292959928512573*x_65 + 5.12455987930298) - 0.0359372809658609*std::sin(0.295599937438965*x_65 - 4.2902398109436) - 0.112266347402951*std::sin(0.162640020251274*x_66 + 4.94399976730347) - 0.0125249151961409*std::sin(0.230159983038902*x_66 + 5.02184009552002) - 0.0204511470254371*std::sin(0.262159943580627*x_66 - 7.51416015625) + 0.0496110217918948*std::sin(0.20168000459671*x_67 + 4.99440002441406) + 0.00456203540677833*std::sin(0.183040007948875*x_68 - 4.43607997894287) + 0.0826894017590453*std::sin(0.196959987282753*x_68 + 4.9846396446228) + 0.0226487787680946*std::sin(0.196959987282753*x_68 + 4.98943948745728) + 0.00369250173793304*std::sin(0.353599846363068*x_68 + 8.35048007965088) - 0.0627256082679524*std::sin(0.156880035996437*x_69 - 4.47191953659058) - 0.0411268415328889*std::sin(0.174560010433197*x_69 - 4.44608020782471) - 0.0398180464893064*std::sin(0.238479986786842*x_69 + 5.03991985321045) + 0.0348162227578997*std::sin(0.298639923334122*x_7 - 1.02047991752625) + 0.0319339133179883*std::sin(0.242239981889725*x_70 - 7.54864025115967) + 0.0202455141877163*std::sin(0.274159938097*x_70 + 1.88463997840881) + 0.004116545365411*std::sin(0.332239836454391*x_70 - 4.28344011306763) - 0.185464922269286*std::sin(0.128320053219795*x_71 - 4.51495981216431) + 0.0630298056640232*std::sin(0.138400033116341*x_73 + 4.90935945510864) - 0.00632842159020481*std::sin(0.15776002407074*x_73 + 4.92848014831543) - 0.0230060235008076*std::sin(0.275279968976974*x_73 + 5.07599973678589) + 0.00420235347487001*std::sin(0.470879852771759*x_73 + 2.04903984069824) + 0.0399235427928426*std::sin(0.195040002465248*x_74 + 4.98744010925293) - 0.0332983131295557*std::sin(0.274639964103699*x_74 - 4.31271982192993) + 0.0238234058614995*std::sin(0.305599927902222*x_74 + 5.12239980697632) + 0.0348717513400124*std::sin(0.312799841165543*x_74 + 5.11303997039795) - 0.00143812364258946*std::sin(0.326879858970642*x_74 - 4.27383995056152) + 0.0902936598597704*std::sin(0.19055999815464*x_75 + 4.97583961486816) - 0.0297395012496588*std::sin(0.202880010008812*x_75 - 4.40423965454102) - 0.0456404633359133*std::sin(0.246879979968071*x_75 + 5.0577597618103) - 0.0238699628779305*std::sin(0.285679936408997*x_75 - 7.48791980743408) - 0.0321487314780521*std::sin(0.191040009260178*x_76 + 4.97191953659058) - 0.0361520768585568*std::sin(0.178640007972717*x_77 - 7.62040042877197) - 0.0210415811379681*std::sin(0.227039992809296*x_77 - 7.55208015441895) + 0.00505309624928593*std::sin(0.321919828653336*x_77 - 4.29168033599854) + 0.00096628518938316*std::sin(0.332159847021103*x_77 - 1.0759197473526) - 0.0700140044091742*std::sin(0.221759989857674*x_78 + 5.01408004760742) - 0.00137674981619769*std::sin(0.377519845962524*x_78 + 5.1831202507019) + 0.00259775794415688*std::sin(0.286319941282272*x_79 + 5.09559965133667) + 0.00617539810317498*std::sin(0.487999856472015*x_79 - 7.32823991775513) + 0.0603516471033797*std::sin(0.202159985899925*x_8 - 4.39463996887207) + 0.0248487412128076*std::sin(0.273039966821671*x_8 - 4.31079959869385) - 0.00405023613908598*std::sin(0.169440016150475*x_80 - 7.63960027694702) - 0.0477732938742575*std::sin(0.177920013666153*x_80 - 7.6255202293396) - 0.0087649499650167*std::sin(0.249199971556664*x_80 + 5.05807971954346) + 0.0186815182483474*std::sin(0.313839852809906*x_80 - 4.29152011871338) - 0.0227652527504606*std::sin(0.193200007081032*x_81 - 7.60736036300659) + 0.0254821829738319*std::sin(0.360079854726791*x_81 - 4.23920011520386) - 0.000922222377177763*std::sin(0.36831983923912*x_81 - 7.42639970779419) - 0.0934885400956007*std::sin(0.193039998412132*x_82 + 4.98015975952148) - 0.0012767234420021*std::sin(0.209600001573563*x_82 + 8.20239925384521) - 0.106515631768019*std::sin(0.155760034918785*x_83 + 4.93103981018066) - 0.0443901237840719*std::sin(0.249119967222214*x_84 + 5.05751991271973) + 0.0154030115832417*std::sin(0.302159935235977*x_84 + 5.14359951019287) - 0.0198816840266352*std::sin(0.322719842195511*x_84 + 5.12712001800537) + 0.00167008241560458*std::sin(0.390079826116562*x_84 + 5.18688011169434) - 0.0874426110741426*std::sin(0.164800018072128*x_85 - 7.63064002990723) - 0.0414442096610568*std::sin(0.238879978656769*x_85 + 5.03191947937012) - 0.00146368821620127*std::sin(0.346639841794968*x_85 - 4.24584007263184) - 0.0139078334567455*std::sin(0.391279846429825*x_86 - 4.19704008102417) - 0.165119791770264*std::sin(0.152880027890205*x_87 - 7.64616012573242) - 0.0342123613025954*std::sin(0.259839981794357*x_87 + 5.06343984603882) + 0.0176802504389042*std::sin(0.345679849386215*x_88 - 4.25648021697998) - 0.00342973323490431*std::sin(0.572799861431122*x_88 - 0.833039879798889) + 0.010578320300391*std::sin(0.180400013923645*x_89 + 4.9684796333313) + 0.011205077756857*std::sin(0.341119825839996*x_89 - 4.27016019821167) + 0.115419718617459*std::sin(0.178000003099442*x_9 - 4.42439985275269) - 0.0871933934831259*std::sin(0.240079984068871*x_9 - 4.34311962127686) - 0.0030851179718633*std::sin(0.400879859924316*x_9 - 0.971039831638336) - 0.00226488003135333*std::sin(0.627359867095947*x_9 - 6.96623992919922) - 0.00348010956093155*std::sin(0.374399840831757*x_92 + 2.0020797252655) + 0.0324012162830679*std::sin(0.335999846458435*x_93 + 1.99351978302002) + 0.0335744275160643*std::sin(0.340079843997955*x_93 - 7.4270396232605) + 0.0281835063227912*std::sin(0.358159840106964*x_93 - 7.40423965454102) - 0.00327179631929295*std::sin(0.361279845237732*x_93 + 2.00159978866577) + 0.0178784854352392*std::sin(0.36151984333992*x_93 - 7.41088008880615) + 0.00191973163824874*std::sin(0.380799859762192*x_94 + 1.97039985656738) - 0.00118211948779721*std::sin(0.384719848632813*x_94 + 2.0019998550415) + 0.0312348775530855*std::sin(0.396719843149185*x_94 - 7.39343976974487) + 0.00541618871056988*std::sin(0.411759853363037*x_94 - 4.18368005752563) + 0.00464451655237819*std::sin(0.353599846363068*x_95 + 1.95167982578278) + 0.0102777941708937*std::sin(0.357599824666977*x_95 - 7.42639970779419) - 0.00147519117005122*std::sin(0.358639866113663*x_95 - 7.41207981109619) + 0.0183104615276679*std::sin(0.364079833030701*x_95 + 5.16887998580933) - 0.0132166425268997*std::sin(0.374639838933945*x_95 - 7.41559982299805) + 0.0172722823290822*std::sin(0.383999854326248*x_96 - 7.40655994415283) - 0.0315176869744411*std::sin(0.393039852380753*x_96 + 5.19248008728027) + 0.03066355251827*std::sin(0.395359843969345*x_96 - 7.38895988464355) - 0.000575227260245188*std::sin(0.414799869060516*x_96 + 8.39535999298096) + 0.00746093358878338*std::sin(0.415759861469269*x_96 - 7.37639951705933) - 0.0103021602394945*std::sin(0.33519983291626*x_97 - 7.44375991821289) + 0.00720026396430553*std::sin(0.343839854001999*x_98 + 1.95423984527588) - 0.0110392913200726*std::sin(0.362719833850861*x_98 - 7.41815996170044) - 0.00989145314109032*std::sin(0.410319864749908*x_98 - 7.4031195640564) + 0.00171979894640537*std::sin(0.41839987039566*x_98 + 2.01895976066589) + 0.00175210524944362*std::sin(0.310559868812561*x_99 - 7.46631956100464) - 0.00410655794077569*std::sin(0.389679849147797*x_99 - 7.41063976287842) + 0.0145267952961857*std::sin(0.397759854793549*x_99 + 1.99927973747253) - 0.0209471413762626*std::sin(0.409279853105545*x_99 - 7.38895988464355) + 0.329059647587244);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00358269096874295*x_1 + 0.0049770419510194*x_10 + 0.00194050746329868*x_100 - 0.000926160563874998*x_101 + 0.00135499045451843*x_102 - 0.00131912925877435*x_103 + 0.000111895352338957*x_104 - 0.00210178786058762*x_105 - 0.000572914399498756*x_107 + 0.000216327840857686*x_108 - 0.00297892971306979*x_109 - 0.00191327291329672*x_11 + 0.00250300170006636*x_110 + 0.00180300422874992*x_112 + 0.00211398643295519*x_113 - 0.000197906560422399*x_114 - 0.00050399814380942*x_116 - 0.000225545883042977*x_117 + 2.49102957884484e-5*x_118 - 0.00193340617863167*x_119 + 0.00166383489962437*x_12 - 0.00193917601753801*x_120 + 0.000509153740930213*x_13 + 0.000787909369101767*x_14 - 0.00174026889956677*x_15 + 0.000278600207877219*x_16 + 0.00152196585376742*x_17 - 0.00191773288933684*x_18 + 0.000188815290926341*x_19 + 0.0105362480852688*x_2 - 0.00343445402834955*x_20 - 0.000539531232592058*x_21 - 0.00363742286669314*x_22 + 0.000191866039419631*x_23 - 0.00169597826024868*x_24 - 0.00280717175086426*x_25 - 0.00186707410437233*x_26 - 0.00406342467997613*x_29 + 0.000129801044606529*x_3 - 0.00142820574382638*x_30 - 0.0028910196935159*x_31 + 0.000930018460218835*x_32 + 0.000174792056107533*x_33 + 0.0013159925673236*x_34 + 0.000225304948642763*x_36 + 0.00246634920524129*x_39 + 0.0034115245152726*x_4 + 0.00020687402284876*x_40 + 0.00125899808852676*x_41 + 0.00266637957093795*x_42 - 0.000271616245902359*x_43 + 6.96366935313101e-5*x_44 + 0.000163666429323642*x_45 + 0.000202192463968262*x_46 - 9.14792312033931e-5*x_47 + 0.00451480726612874*x_48 - 0.000316086860087566*x_49 - 0.00115431605133871*x_5 - 0.000408827509392995*x_50 - 0.00161502174430438*x_51 - 0.00847478129174123*x_52 + 0.000109530153026963*x_53 + 0.000660441145400723*x_54 - 0.00102190943332043*x_55 + 1.49307397282291e-5*x_56 - 0.000583257998817261*x_57 + 0.000215963529333774*x_58 + 0.00301389132511468*x_59 + 0.00224448141227869*x_6 + 0.000316942731738094*x_60 - 0.00110196174635205*x_61 + 0.0012168909217459*x_62 + 0.000364411625171926*x_63 + 0.00102730269231127*x_64 - 0.000223850594805202*x_65 + 0.000267564139260727*x_66 + 1.73300203418765e-5*x_67 + 0.000219270435485097*x_69 - 0.000200582635005355*x_70 - 0.00040504760367219*x_71 - 6.06217822527162e-5*x_72 - 3.38444432724215e-5*x_73 + 0.00158641618343712*x_76 + 0.000570871023483699*x_77 + 0.000698709112154885*x_78 + 0.000244110925611911*x_79 + 0.00175421808485517*x_8 + 0.000327175217595971*x_80 + 0.000165120635103331*x_81 - 0.00307255242973109*x_82 + 0.00191035142656507*x_83 - 0.000239941244889182*x_86 + 0.00157640053843674*x_88 + 0.00205769891888908*x_9 + 0.000899553378197984*x_90 + 0.00640108660435392*x_91 - 0.00112405270287837*x_92 + 0.00122759500084881*x_94 + 0.00234048633586466*x_97 - 0.00077914477057675*x_98 + 0.000108696818046169*x_99 + 8.84105190250665e-5*std::pow(-3.28623986244202*x_14 - 4.83031988143921, 2) + 6.68077899634446e-5*std::pow(-5.59087991714478*x_17 - 8.77711963653564, 2) - 4.61146945135473e-5*std::pow(-4.67167949676514*x_17 - 6.90744018554688, 2) - 0.000151569475691916*std::pow(-1.91071999073029*x_18 - 2.75584006309509, 2) - 1.78071953297383e-5*std::pow(-6.07679986953735*x_22 - 9.73752021789551, 2) + 5.53923673588398e-5*std::pow(-4.91200017929077*x_4 - 8.39608001708984, 2) + 3.63050852216085e-5*std::pow(-3.57223987579346*x_47 - 6.35407972335815, 2) + 0.000134022703944989*std::pow(-3.41503977775574*x_5 - 5.42375993728638, 2) - 2.65025152409094e-5*std::pow(-3.721519947052*x_56 - 5.28943967819214, 2) - 8.74612707746331e-6*std::pow(-5.77103996276855*x_58 - 7.56695985794067, 2) - 2.24105129811521e-5*std::pow(-5.90503978729248*x_6 - 9.16919994354248, 2) - 8.90404331772732e-5*std::pow(-2.89567995071411*x_6 - 4.63944005966187, 2) + 2.09258809655397e-5*std::pow(-5.1267204284668*x_66 - 7.49520015716553, 2) + 7.94283704171438e-6*std::pow(-6.9987998008728*x_67 - 9.77744007110596, 2) + 1.82587945319935e-5*std::pow(-6.21640014648438*x_67 - 8.61551952362061, 2) - 7.52549981278981e-6*std::pow(-5.79999971389771*x_67 - 10.0, 2) + 4.82708050856726e-5*std::pow(-3.71591997146606*x_68 - 4.97343969345093, 2) + 9.933633131202e-6*std::pow(-5.51319980621338*x_7 - 8.79199981689453, 2) + 3.51059364826434e-5*std::pow(-5.43391990661621*x_7 - 8.85800075531006, 2) + 3.78210735730234e-5*std::pow(-5.27688026428223*x_7 - 8.52688026428223, 2) + 3.10551600328485e-5*std::pow(-7.60000038146973*x_72 - 9.99660015106201, 2) - 0.000110049135859972*std::pow(-2.52336001396179*x_72 - 3.5783998966217, 2) + 3.90119404314748e-6*std::pow(-6.59600019454956*x_75 - 9.96208000183105, 2) - 2.02727852433974e-5*std::pow(-7.19984006881714*x_81 - 9.79320049285889, 2) - 2.95620870131307e-5*std::pow(-4.73992013931274*x_82 - 7.30111980438232, 2) + 5.1998831708529e-5*std::pow(-5.49191999435425*x_83 - 7.52191972732544, 2) + 6.4212490379797e-5*std::pow(-4.27015972137451*x_84 - 6.41544008255005, 2) + 5.99016263384367e-5*std::pow(-3.28543996810913*x_85 - 7.1800799369812, 2) - 1.45996346072192e-5*std::pow(-6.69712018966675*x_86 - 9.7344799041748, 2) - 4.75881682697745e-5*std::pow(-4.22168016433716*x_86 - 6.42952013015747, 2) - 9.39829814155876e-6*std::pow(-4.28991985321045*x_87 - 6.95071983337402, 2) - 4.33299662852249e-5*std::pow(-3.91824007034302*x_87 - 5.3600001335144, 2) - 8.12814347700533e-6*std::pow(-4.93191957473755*x_88 - 5.71687984466553, 2) - 1.34903203471438e-5*std::pow(-5.10663986206055*x_89 - 7.55287981033325, 2) + 7.67615133743868e-5*std::pow(-4.09903955459595*x_89 - 5.94736003875732, 2) + 6.05678739500273e-6*std::pow(-5.74399995803833*x_90 - 7.7992000579834, 2) - 5.70585722610951e-5*std::pow(-4.90768003463745*x_90 - 7.15335988998413, 2) + 0.000269862206353935*std::exp(0.602479875087738*x_29) - 0.00215859376509108*std::exp(0.0213209878919575*x_1 + 0.03105186464941*x_100 - 0.0107673894207144*x_101 - 0.00862145746985749*x_102 + 0.00125111615785473*x_106 + 0.0245336370268067*x_110 + 0.00240695608221592*x_112 + 0.00680036340008752*x_113 + 0.00946246983876586*x_13 + 0.0165366781549921*x_14 + 0.00302791069221905*x_18 - 0.0190014790617942*x_2 + 0.0154537657636141*x_20 - 0.00113946733317195*x_21 - 0.0576468119252831*x_25 + 0.00374616363078888*x_26 + 0.00120909472000813*x_28 + 0.00206688593656701*x_29 + 0.036048353041968*x_3 + 0.0170865869082116*x_30 + 0.0109170562128666*x_31 + 0.0505310419681783*x_32 - 0.0273643293514628*x_33 + 0.00161440874419693*x_36 + 0.00809990162236688*x_37 + 0.0100133809261456*x_39 + 0.0534640854484763*x_4 + 0.00819010224259358*x_42 + 0.000129368781045491*x_46 - 0.0334024605372238*x_48 + 0.026023099106019*x_5 + 0.00342514893762062*x_53 - 0.00685827251045656*x_6 - 0.000780279553151147*x_61 + 0.009972975554082*x_62 + 0.0193681516425076*x_63 + 0.00663429297971285*x_64 + 0.00606084214023494*x_72 - 0.00101750398945781*x_79 - 0.00713299441583022*x_82 - 0.0081389125288947*x_83 + 0.00948394275328576*x_86 + 0.00867779889547101*x_87 - 0.011372411203896*x_89 + 0.0381463402666017*x_91 - 0.00550172351888401*x_92 + 0.000501911807622324*std::pow(-6.36255979537964*x_23 - 8.93599987030029, 2) + 0.000703010228827378*std::pow(-5.72896003723145*x_7 - 8.99792003631592, 2) - 0.000275260530337648*std::pow(-6.60000038146973*x_71 - 9.96463966369629, 2) - 0.000127788364857433*std::pow(-6.40000009536743*x_78 - 9.99993991851807, 2) + 0.000385847035868594*std::pow(-3.90391993522644*x_85 - 6.36783981323242, 2) + 0.000287069300187737*std::pow(-6.60000038146973*x_90 - 9.96016025543213, 2) - 0.00475611961617955*std::exp(1.29391980171204*x_17) + 0.021300902555821*std::exp(0.730479836463928*x_22) - 0.289598601433383*std::sin(0.36847984790802*x_10 + 5.17600011825562) - 0.0849081540780467*std::sin(0.300079941749573*x_103 + 5.10311985015869) - 0.149347080385382*std::sin(0.40055987238884*x_104 + 5.20408010482788) + 0.18053935098272*std::sin(0.403519839048386*x_105 + 2.01263976097107) - 0.225461906592002*std::sin(0.35455983877182*x_107 + 5.15592002868652) + 1.60038410863712*std::sin(0.127280056476593*x_108 + 1.72391986846924) - 0.137270565463982*std::sin(0.432159870862961*x_109 + 5.23464012145996) - 0.182369444960841*std::sin(0.262559980154037*x_11 + 8.27199935913086) - 0.281783669627444*std::sin(0.388959854841232*x_111 + 5.20007991790771) - 0.256944575817769*std::sin(0.32423985004425*x_114 + 5.132080078125) - 0.0474143088639565*std::sin(0.491039872169495*x_115 - 4.1386399269104) + 0.153850175409822*std::sin(0.453839868307114*x_116 + 8.24575996398926) + 0.265695290006342*std::sin(0.413519859313965*x_117 + 5.20032024383545) + 0.132994915278783*std::sin(0.345439821481705*x_118 + 5.1592001914978) - 0.202520999283728*std::sin(0.369119822978973*x_119 + 1.97495973110199) + 0.228253596928013*std::sin(0.318879842758179*x_12 - 4.26143980026245) + 0.17273607155709*std::sin(0.482079833745956*x_120 + 2.02687978744507) - 0.363754452836019*std::sin(0.417839854955673*x_15 + 2.22183990478516) - 0.185221253329772*std::sin(0.373839825391769*x_16 + 2.15111970901489) - 0.29160638561801*std::sin(0.254319965839386*x_19 - 4.31472015380859) + 0.410701583744327*std::sin(0.359199821949005*x_24 + 2.12399983406067) - 0.108696883765386*std::sin(0.444319844245911*x_27 - 0.939439833164215) + 0.414455025115842*std::sin(0.360879838466644*x_34 + 1.99647974967957) - 0.259386007288455*std::sin(0.316639840602875*x_35 + 1.94799983501434) + 0.381884594157782*std::sin(0.218799993395805*x_38 + 5.01575994491577) - 0.265389887649285*std::sin(0.317279845476151*x_40 - 7.46495962142944) - 0.280958550484939*std::sin(0.333999842405319*x_41 + 5.14592027664185) - 0.232139322032914*std::sin(0.355359852313995*x_43 + 5.16279983520508) - 0.234911763599094*std::sin(0.269999951124191*x_44 - 4.30319976806641) + 0.238711608255024*std::sin(0.351679861545563*x_45 + 5.14408016204834) - 0.268049019269483*std::sin(0.324559837579727*x_47 - 4.27048015594482) + 0.196130751427738*std::sin(0.337039858102798*x_49 + 5.13264036178589) + 0.132829427417438*std::sin(0.31879985332489*x_50 + 5.11704015731812) - 0.0466443065114959*std::sin(0.449919849634171*x_51 - 4.16607999801636) - 0.305422052673279*std::sin(0.281759947538376*x_52 + 5.10095977783203) - 0.068843839715834*std::sin(0.350879848003387*x_54 + 2.13367986679077) - 0.311077994333004*std::sin(0.239439979195595*x_55 + 5.03903961181641) + 0.401892315485384*std::sin(0.22503998875618*x_56 + 5.03327989578247) + 0.204922798912243*std::sin(0.318639844655991*x_57 - 4.29200029373169) - 0.547715564825097*std::sin(0.213919997215271*x_58 + 5.01063966751099) - 0.247376476367428*std::sin(0.376079827547073*x_59 - 7.42407989501953) - 0.248982614345842*std::sin(0.253439962863922*x_60 - 7.54631996154785) - 0.462149798868083*std::sin(0.292959928512573*x_65 + 5.12455987930298) + 0.233859440226972*std::sin(0.230159983038902*x_66 + 5.02184009552002) - 0.926314118990234*std::sin(0.20168000459671*x_67 + 4.99440002441406) - 0.0689446895206292*std::sin(0.353599846363068*x_68 + 8.35048007965088) + 0.767901417979118*std::sin(0.174560010433197*x_69 - 4.44608020782471) - 0.378014903965607*std::sin(0.274159938097*x_70 + 1.88463997840881) - 1.17686346289554*std::sin(0.138400033116341*x_73 + 4.90935945510864) - 0.745433978849491*std::sin(0.195040002465248*x_74 + 4.98744010925293) + 0.445688938364341*std::sin(0.285679936408997*x_75 - 7.48791980743408) + 0.600266287613749*std::sin(0.191040009260178*x_76 + 4.97191953659058) - 0.0943490827494884*std::sin(0.321919828653336*x_77 - 4.29168033599854) - 0.463964236034315*std::sin(0.273039966821671*x_8 - 4.31079959869385) + 0.163655103474696*std::sin(0.249199971556664*x_80 + 5.05807971954346) + 0.425062300341054*std::sin(0.193200007081032*x_81 - 7.60736036300659) + 0.371221634991272*std::sin(0.322719842195511*x_84 + 5.12712001800537) + 0.064038397217228*std::sin(0.572799861431122*x_88 - 0.833039879798889) + 0.0422887954144979*std::sin(0.627359867095947*x_9 - 6.96623992919922) - 0.333818834739844*std::sin(0.36151984333992*x_93 - 7.41088008880615) - 0.0358443437960512*std::sin(0.380799859762192*x_94 + 1.97039985656738) - 0.0867202710800576*std::sin(0.353599846363068*x_95 + 1.95167982578278) - 0.139307111091746*std::sin(0.415759861469269*x_96 - 7.37639951705933) + 0.192357184779908*std::sin(0.33519983291626*x_97 - 7.44375991821289) - 0.134440008080674*std::sin(0.343839854001999*x_98 + 1.95423984527588) + 0.0766757559831888*std::sin(0.389679849147797*x_99 - 7.41063976287842)) + 0.0334361270969857*std::sin(0.225279986858368*x_1 - 4.18847990036011) + 0.0540163814083136*std::sin(0.281839966773987*x_1 + 2.15455985069275) + 0.0168779906383071*std::sin(0.341919839382172*x_1 - 4.35288000106812) + 0.0588241725616513*std::sin(0.270319938659668*x_10 - 7.50264024734497) - 0.0173250977337301*std::sin(0.34623983502388*x_10 - 1.06567978858948) + 0.0343422602507535*std::sin(0.316399842500687*x_101 - 4.24911975860596) + 0.00418142083053263*std::sin(0.301919937133789*x_102 + 5.10527992248535) - 0.0117752929851433*std::sin(0.397359818220139*x_102 + 1.99735975265503) - 0.00553299829105576*std::sin(0.416559875011444*x_103 + 5.21712017059326) - 0.0229256109777367*std::sin(0.394079834222794*x_104 - 7.39215993881226) - 0.0247586009670913*std::sin(0.398559838533401*x_104 + 5.20975971221924) + 0.00729667228418317*std::sin(0.428879857063293*x_104 + 5.22983980178833) + 0.0562730670915019*std::sin(0.162960022687912*x_105 - 7.63632011413574) + 0.00930203133192696*std::sin(0.324799835681915*x_105 + 8.32863998413086) - 0.0133572135428084*std::sin(0.37391984462738*x_105 - 7.43215990066528) + 0.00799344105125942*std::sin(0.386079847812653*x_106 + 1.99143981933594) + 0.0132440682603102*std::sin(0.396559834480286*x_106 - 7.3874397277832) - 0.0254821524186385*std::sin(0.40055987238884*x_106 - 7.38775968551636) - 0.0055187713843083*std::sin(0.442479848861694*x_106 + 5.22079992294312) + 0.00576210892026815*std::sin(0.369519859552383*x_107 + 5.18247985839844) + 0.0130086601524223*std::sin(0.392639845609665*x_107 - 7.40319967269897) + 0.00431770806848312*std::sin(0.570399820804596*x_107 + 2.1801598072052) - 0.0155860232720604*std::sin(0.296719938516617*x_108 - 7.49255990982056) - 0.042548906028452*std::sin(0.388879835605621*x_108 + 5.17456007003784) - 0.0198494793409491*std::sin(0.3504798412323*x_109 + 5.14728021621704) + 0.0208343043755418*std::sin(0.298159927129745*x_11 - 4.2611198425293) + 0.0158689101188412*std::sin(0.300399929285049*x_11 - 1.06567990779877) - 0.0109016732605962*std::sin(0.36959981918335*x_110 - 7.41879987716675) + 0.0114529742417717*std::sin(0.400079846382141*x_110 - 4.20775985717773) + 0.0157702216926935*std::sin(0.253279983997345*x_111 - 4.3439998626709) + 0.0207639982050828*std::sin(0.355199843645096*x_111 - 4.24304008483887) - 0.00916315356390978*std::sin(0.357679843902588*x_111 - 4.2388801574707) - 0.00290516251949953*std::sin(0.762639880180359*x_111 - 1.20167982578278) - 0.0210911269042264*std::sin(0.350879848003387*x_112 - 4.24528026580811) - 0.00953124932157598*std::sin(0.362399846315384*x_112 + 5.16552019119263) - 0.0188271796619298*std::sin(0.372479856014252*x_112 - 7.41504001617432) + 0.0194842658706543*std::sin(0.377519845962524*x_113 - 7.42136001586914) + 0.0139654870287519*std::sin(0.181760013103485*x_114 - 1.20503985881805) - 0.0155580306836921*std::sin(0.321759849786758*x_114 + 5.13535976409912) + 0.0202564350505364*std::sin(0.389039844274521*x_114 - 7.40039968490601) + 0.0772722575223217*std::sin(0.189999997615814*x_115 - 7.61768007278442) - 0.0124720464252659*std::sin(0.230639979243279*x_115 + 1.83319985866547) + 0.0115180846439028*std::sin(0.33231982588768*x_115 + 5.14056015014648) - 0.0140955336112148*std::sin(0.3642398416996*x_115 - 7.42384004592896) + 0.0692268637431334*std::sin(0.260159969329834*x_116 - 4.30823993682861) + 0.0436027295164745*std::sin(0.240879982709885*x_117 - 7.5633602142334) - 0.0109210689122791*std::sin(0.355279833078384*x_117 - 7.42416000366211) + 0.00858541195436228*std::sin(0.363599836826324*x_117 - 7.42176008224487) - 0.00366384023252773*std::sin(0.322159856557846*x_118 + 1.92447984218597) - 0.00285102985023821*std::sin(0.450399875640869*x_118 + 5.2403998374939) + 0.0249652707290087*std::sin(0.299039930105209*x_119 + 5.09831953048706) - 0.0079210649527635*std::sin(0.367199838161469*x_119 + 8.1812801361084) + 0.0570232932131213*std::sin(0.249199971556664*x_12 + 5.06543970108032) + 0.0308654124296344*std::sin(0.283599942922592*x_12 + 8.31063938140869) - 0.0163240453260208*std::sin(0.342079848051071*x_12 + 8.34247970581055) - 0.0155752663601903*std::sin(0.302719920873642*x_120 - 7.48975992202759) + 0.00645678904561722*std::sin(0.417599856853485*x_13 - 7.16351985931396) - 0.0728699367857114*std::sin(0.23319998383522*x_14 + 8.24967956542969) - 0.0113884853470504*std::sin(0.351519852876663*x_14 - 1.0487197637558) - 0.0245091754913655*std::sin(0.254239976406097*x_15 - 1.0914398431778) - 0.0205700478881415*std::sin(0.313599914312363*x_16 - 4.26719999313354) + 0.0497734188286766*std::sin(0.321199834346771*x_16 - 4.25663995742798) - 0.0115965147315392*std::sin(0.402399867773056*x_16 + 5.189040184021) - 0.00907041487054733*std::sin(0.237599983811378*x_18 - 4.33536005020142) - 0.0291407631204235*std::sin(0.238399982452393*x_19 - 4.33599996566772) + 0.0367732137888341*std::sin(0.311999946832657*x_21 - 4.27687978744507) - 0.0143745869034807*std::sin(0.333199828863144*x_21 - 4.25576019287109) + 0.0209071438708333*std::sin(0.364319831132889*x_21 + 8.36192035675049) - 0.0542414176828765*std::sin(0.222559988498688*x_23 - 4.36664009094238) + 0.0225165696185945*std::sin(0.341359853744507*x_23 - 4.26792001724243) - 0.00397462663552982*std::sin(0.477199852466583*x_23 - 7.31928014755249) - 0.00594682671127777*std::sin(0.382639855146408*x_24 + 5.38751983642578) + 0.0157429808093928*std::sin(0.437999874353409*x_24 + 8.44855976104736) + 0.0228534427320191*std::sin(0.319279849529266*x_26 - 4.28200006484985) - 0.0195017480882788*std::sin(0.327199846506119*x_26 - 4.26272010803223) + 0.0228393982128708*std::sin(0.350639849901199*x_27 + 8.32791996002197) - 0.0230254207814972*std::sin(0.366399854421616*x_27 + 5.17136001586914) + 0.0272702108256757*std::sin(0.366799861192703*x_27 - 4.24416017532349) + 0.0147813245988741*std::sin(0.536719858646393*x_27 - 4.05399990081787) - 0.0114319285008781*std::sin(0.311599940061569*x_28 + 5.12759971618652) + 0.0178628656795245*std::sin(0.320399850606918*x_28 - 4.2739200592041) - 0.0183355833220295*std::sin(0.333199828863144*x_28 - 4.27544021606445) - 0.040202871174777*std::sin(0.348239839076996*x_28 - 4.23992013931274) + 0.0340843481694291*std::sin(0.342559844255447*x_3 - 4.24079990386963) + 0.0187923981360488*std::sin(0.376959830522537*x_3 - 1.01671981811523) + 0.0112246052730999*std::sin(0.296799927949905*x_30 - 4.29607963562012) - 0.0210037444254631*std::sin(0.295999944210052*x_33 - 1.16031992435455) + 0.0357418091466434*std::sin(0.352079838514328*x_34 + 1.99303984642029) - 0.019049257832612*std::sin(0.356959849596024*x_34 + 1.98511981964111) - 0.0165508999712049*std::sin(0.307439923286438*x_35 - 1.14431989192963) - 0.0452794414591313*std::sin(0.312399834394455*x_35 - 7.41991996765137) - 0.0181067262869543*std::sin(0.331839829683304*x_35 + 1.95959985256195) - 0.0104082560046659*std::sin(0.333759844303131*x_35 + 1.97559976577759) + 0.0284692272048599*std::sin(0.345039844512939*x_36 - 7.4507999420166) + 0.0198588977492473*std::sin(0.358079850673676*x_36 + 5.17239999771118) + 0.011448203636619*std::sin(0.361599832773209*x_36 - 4.23776006698608) - 0.00889168758616373*std::sin(0.305039942264557*x_37 + 5.12063980102539) - 0.0236559110699537*std::sin(0.369439840316772*x_37 + 5.18287992477417) - 0.0310399117077771*std::sin(0.385359823703766*x_37 + 5.19280004501343) + 0.0285629301797429*std::sin(0.389999836683273*x_37 + 5.19632005691528) - 0.0179568603433733*std::sin(0.262399971485138*x_38 - 7.52008008956909) - 0.00716215153895338*std::sin(0.320239841938019*x_38 + 5.11552000045776) + 0.0544676295476427*std::sin(0.344159841537476*x_38 + 5.13088035583496) - 0.0294581910660417*std::sin(0.367359846830368*x_38 + 5.17296028137207) - 0.0319936345205819*std::sin(0.352319836616516*x_39 - 7.42647981643677) + 0.0604890656056182*std::sin(0.2291199862957*x_40 + 5.04504013061523) + 0.00820170518887548*std::sin(0.309679925441742*x_40 - 7.48591995239258) - 0.00539374737378017*std::sin(0.341359823942184*x_41 + 1.95199990272522) + 0.011163457698919*std::sin(0.317679852247238*x_42 + 8.32288074493408) + 0.0497739061948904*std::sin(0.360879838466644*x_43 + 5.16096019744873) + 0.0149396474098585*std::sin(0.364639848470688*x_43 - 4.23912000656128) + 0.0389288292547199*std::sin(0.329999834299088*x_44 + 5.11872005462646) + 0.032851772527602*std::sin(0.328879833221436*x_45 - 7.44984006881714) - 0.0179197102634515*std::sin(0.341919839382172*x_45 + 5.13479995727539) - 0.00632758707315333*std::sin(0.35471984744072*x_45 + 8.35632038116455) + 0.0529247817412679*std::sin(0.246319979429245*x_46 - 7.53096008300781) + 0.00438803941988315*std::sin(0.29479992389679*x_46 + 5.11055994033813) - 0.00958035527092501*std::sin(0.347519844770432*x_46 - 4.24232006072998) - 0.0106384680432171*std::sin(0.29215994477272*x_47 - 7.47575998306274) + 0.0329131621294265*std::sin(0.336879849433899*x_47 - 4.26936006546021) + 0.0342656748882323*std::sin(0.300879925489426*x_48 + 5.12215948104858) - 0.0119441412770909*std::sin(0.35455983877182*x_49 - 7.43215990066528) - 0.00547902284175269*std::sin(0.433759868144989*x_49 - 4.17463970184326) + 0.0661041494879755*std::sin(0.246479973196983*x_50 - 7.53216028213501) - 0.0276229528741346*std::sin(0.249039962887764*x_50 + 5.05631971359253) + 0.0148537542031532*std::sin(0.366719841957092*x_50 + 5.16960000991821) - 0.0084560729190041*std::sin(0.22647999227047*x_51 - 7.58319997787476) - 0.0131000735485951*std::sin(0.300319939851761*x_51 - 4.28999948501587) - 0.0233704574066389*std::sin(0.338239848613739*x_51 - 4.25888013839722) + 0.0318991066649529*std::sin(0.236559987068176*x_53 - 4.34311962127686) - 0.0232429276025972*std::sin(0.290879935026169*x_53 + 5.103919506073) - 0.0236115394165352*std::sin(0.305999934673309*x_53 + 5.12415981292725) - 0.0269345005543445*std::sin(0.26215997338295*x_54 - 7.52416038513184) + 0.0162364081646494*std::sin(0.324559837579727*x_54 - 4.27511978149414) - 0.00919571842625946*std::sin(0.378319829702377*x_55 - 1.00887978076935) + 0.026755933998212*std::sin(0.300399929285049*x_56 + 5.12975978851318) + 0.00948990485702453*std::sin(0.318239837884903*x_56 + 5.1159200668335) + 0.0112555345756953*std::sin(0.254079967737198*x_57 - 7.52976036071777) - 0.0304371638204563*std::sin(0.275119960308075*x_57 + 5.07976007461548) - 0.0332229866587018*std::sin(0.286479920148849*x_58 + 5.09591960906982) - 0.00956694714152836*std::sin(0.280559957027435*x_59 + 1.87903988361359) + 0.0143373474960392*std::sin(0.367759823799133*x_59 - 4.2294397354126) - 0.0268008509044102*std::sin(0.245839968323708*x_60 - 7.53416013717651) + 0.0601171892921628*std::sin(0.281599938869476*x_60 + 5.08191967010498) + 0.0158398278583192*std::sin(0.313439846038818*x_60 + 8.30096054077148) - 0.0133781955995326*std::sin(0.270399957895279*x_63 + 8.28127956390381) - 0.068200016906782*std::sin(0.155440032482147*x_64 - 4.47199964523315) - 0.0103867318339457*std::sin(0.289519935846329*x_65 - 4.28743982315063) + 0.0313246764016921*std::sin(0.295599937438965*x_65 - 4.2902398109436) - 0.118509186947049*std::sin(0.162640020251274*x_66 + 4.94399976730347) + 0.0178262112602179*std::sin(0.262159943580627*x_66 - 7.51416015625) - 0.0207086407274702*std::sin(0.183040007948875*x_68 - 4.43607997894287) - 0.0560073656273258*std::sin(0.196959987282753*x_68 + 4.9846396446228) + 0.0239082184398202*std::sin(0.196959987282753*x_68 + 4.98943948745728) - 0.0662136161775472*std::sin(0.156880035996437*x_69 - 4.47191953659058) + 0.0347073397792652*std::sin(0.238479986786842*x_69 + 5.03991985321045) + 0.0367522623391024*std::sin(0.298639923334122*x_7 - 1.02047991752625) - 0.0216295476937134*std::sin(0.242239981889725*x_70 - 7.54864025115967) - 0.00358818051891244*std::sin(0.332239836454391*x_70 - 4.28344011306763) - 0.195778144152511*std::sin(0.128320053219795*x_71 - 4.51495981216431) + 0.0287268724150621*std::sin(0.15776002407074*x_73 + 4.92848014831543) + 0.0155824899253142*std::sin(0.275279968976974*x_73 + 5.07599973678589) + 0.00443603542015532*std::sin(0.470879852771759*x_73 + 2.04903984069824) + 0.0225536859445981*std::sin(0.274639964103699*x_74 - 4.31271982192993) - 0.0207656355556384*std::sin(0.305599927902222*x_74 + 5.12239980697632) + 0.0368108787212216*std::sin(0.312799841165543*x_74 + 5.11303997039795) + 0.00652813561942465*std::sin(0.326879858970642*x_74 - 4.27383995056152) + 0.0953146554064657*std::sin(0.19055999815464*x_75 + 4.97583961486816) + 0.025922391120192*std::sin(0.202880010008812*x_75 - 4.40423965454102) + 0.0309132979931788*std::sin(0.246879979968071*x_75 + 5.0577597618103) + 0.0244866034066196*std::sin(0.178640007972717*x_77 - 7.62040042877197) + 0.0183408622581363*std::sin(0.227039992809296*x_77 - 7.55208015441895) - 0.00438629932540191*std::sin(0.332159847021103*x_77 - 1.0759197473526) - 0.0739073010691027*std::sin(0.221759989857674*x_78 + 5.01408004760742) + 0.00624953880736816*std::sin(0.377519845962524*x_78 + 5.1831202507019) - 0.011792112766715*std::sin(0.286319941282272*x_79 + 5.09559965133667) + 0.00651879592782032*std::sin(0.487999856472015*x_79 - 7.32823991775513) - 0.0526054215848547*std::sin(0.202159985899925*x_8 - 4.39463996887207) + 0.0183854086141299*std::sin(0.169440016150475*x_80 - 7.63960027694702) + 0.0323579114169191*std::sin(0.177920013666153*x_80 - 7.6255202293396) - 0.016283717022935*std::sin(0.313839852809906*x_80 - 4.29152011871338) - 0.0222115061076065*std::sin(0.360079854726791*x_81 - 4.23920011520386) + 0.00418628313393444*std::sin(0.36831983923912*x_81 - 7.42639970779419) + 0.0633218615168715*std::sin(0.193039998412132*x_82 + 4.98015975952148) + 0.00579548484640801*std::sin(0.209600001573563*x_82 + 8.20239925384521) + 0.0928441887416191*std::sin(0.155760034918785*x_83 + 4.93103981018066) + 0.0300664152857389*std::sin(0.249119967222214*x_84 + 5.05751991271973) - 0.0134260116650148*std::sin(0.302159935235977*x_84 + 5.14359951019287) - 0.00758107591156218*std::sin(0.390079826116562*x_84 + 5.18688011169434) + 0.0592268197091149*std::sin(0.164800018072128*x_85 - 7.63064002990723) + 0.0361247824394325*std::sin(0.238879978656769*x_85 + 5.03191947937012) + 0.00664418197221953*std::sin(0.346639841794968*x_85 - 4.24584007263184) - 0.0146812118972579*std::sin(0.391279846429825*x_86 - 4.19704008102417) - 0.174301673869598*std::sin(0.152880027890205*x_87 - 7.64616012573242) + 0.0231727910431886*std::sin(0.259839981794357*x_87 + 5.06343984603882) - 0.0154109634567419*std::sin(0.345679849386215*x_88 - 4.25648021697998) - 0.0480186178027942*std::sin(0.180400013923645*x_89 + 4.9684796333313) - 0.0075894476614986*std::sin(0.341119825839996*x_89 - 4.27016019821167) - 0.0781763351009363*std::sin(0.178000003099442*x_9 - 4.42439985275269) - 0.0920419912812431*std::sin(0.240079984068871*x_9 - 4.34311962127686) + 0.0140044068018964*std::sin(0.400879859924316*x_9 - 0.971039831638336) + 0.0157974088676483*std::sin(0.374399840831757*x_92 + 2.0020797252655) - 0.0219460623554135*std::sin(0.335999846458435*x_93 + 1.99351978302002) + 0.035441414094112*std::sin(0.340079843997955*x_93 - 7.4270396232605) - 0.0245661105041626*std::sin(0.358159840106964*x_93 - 7.40423965454102) + 0.0148518037385301*std::sin(0.361279845237732*x_93 + 2.00159978866577) + 0.0053660451063928*std::sin(0.384719848632813*x_94 + 2.0019998550415) - 0.0272258336051173*std::sin(0.396719843149185*x_94 - 7.39343976974487) - 0.00366850472934155*std::sin(0.411759853363037*x_94 - 4.18368005752563) + 0.0108493155694287*std::sin(0.357599824666977*x_95 - 7.42639970779419) + 0.00669639781829331*std::sin(0.358639866113663*x_95 - 7.41207981109619) - 0.0159602859956127*std::sin(0.364079833030701*x_95 + 5.16887998580933) + 0.0089519250910382*std::sin(0.374639838933945*x_95 - 7.41559982299805) - 0.0116988998716209*std::sin(0.383999854326248*x_96 - 7.40655994415283) - 0.0332703035611048*std::sin(0.393039852380753*x_96 + 5.19248008728027) - 0.0267278390057824*std::sin(0.395359843969345*x_96 - 7.38895988464355) + 0.00261115348893728*std::sin(0.414799869060516*x_96 + 8.39535999298096) + 0.00747715683119257*std::sin(0.362719833850861*x_98 - 7.41815996170044) + 0.00862187011536843*std::sin(0.410319864749908*x_98 - 7.4031195640564) - 0.00780675626753663*std::sin(0.41839987039566*x_98 + 2.01895976066589) - 0.0079534056385296*std::sin(0.310559868812561*x_99 - 7.46631956100464) - 0.0126622590684843*std::sin(0.397759854793549*x_99 + 1.99927973747253) - 0.0221119574190451*std::sin(0.409279853105545*x_99 - 7.38895988464355) + 0.789979596242449);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00552841827151007*x_1 + 0.00510818297233497*x_10 + 0.00106073230910007*x_100 - 0.00314176961288492*x_101 + 8.05095164266278e-5*x_102 - 0.000887461011379891*x_103 - 0.00018340977861405*x_104 - 0.00250296650240673*x_105 + 2.01881560949303e-5*x_106 + 0.000988288104218315*x_107 - 0.0003367229156714*x_108 - 0.00269104246126394*x_109 + 0.00325593935050156*x_11 + 0.000789098555690948*x_110 + 0.00129030009252453*x_112 - 0.00498623849872941*x_113 + 0.00032439236907164*x_114 - 0.00329231443500601*x_116 + 0.000369696503130099*x_117 + 4.64143669268473e-5*x_118 - 0.00336762557178052*x_119 - 0.00287014646537194*x_12 - 0.00130911777545911*x_120 - 0.00249596927365725*x_13 - 0.00102463931499883*x_14 - 0.000439386317442627*x_15 - 0.000480590593496513*x_16 - 0.00201650891708034*x_17 - 0.000313355053033219*x_18 - 6.01330595764338e-5*x_19 + 0.00557364271789206*x_2 + 0.00618632455283329*x_20 - 0.000660900804468896*x_21 + 0.00340634600099233*x_22 + 0.000133173785232853*x_23 - 0.00154953928557683*x_24 - 0.000189111292897208*x_25 - 5.46637444043295e-5*x_26 + 1.95100932777773e-5*x_28 + 0.00436979159734817*x_29 - 0.000853465392599918*x_3 + 0.00372923408485827*x_30 + 0.0130245518922779*x_31 + 0.00307696785496051*x_32 - 0.00308816086810977*x_33 - 0.00226888980319058*x_34 - 0.000343251295422163*x_36 + 0.000130700956325519*x_37 + 0.000450565671969624*x_39 - 0.00109562009427308*x_4 - 0.000252873762121634*x_40 + 0.000463380508483569*x_41 + 0.00107866427130288*x_42 - 0.000403594968324441*x_43 + 0.000320570288917345*x_44 - 0.000282327665881601*x_45 - 0.000329329964537983*x_46 + 0.000157803392724024*x_47 - 0.00297873345960422*x_48 - 0.000390202794787325*x_49 + 0.00295045813891316*x_5 + 0.000670116867427717*x_50 - 0.0011209829502551*x_51 - 0.00501908025017622*x_52 - 0.000124264333560225*x_53 + 0.000815746710401396*x_54 + 0.000639295275795526*x_55 - 2.44732565817668e-5*x_56 - 0.0002851500567362*x_57 + 0.00166930522363739*x_58 + 0.00210222539519963*x_59 + 0.000610158675811998*x_6 - 0.000519506798506925*x_60 - 0.00222441248744939*x_61 + 0.00300188719043155*x_62 + 6.84410428618328e-5*x_63 - 0.0020856199567954*x_64 - 0.00121841047406007*x_65 - 0.000438569417952343*x_66 + 1.20287280337424e-5*x_67 - 0.000402671571332402*x_69 - 0.000638787395521628*x_70 + 8.86815678432195e-5*x_71 - 7.73186948217328e-5*x_72 - 4.03044995129966e-5*x_73 + 0.00498873921118933*x_76 + 0.000396240289876431*x_77 + 0.000538089078425576*x_78 + 0.000376014278618684*x_79 + 0.00432691345196477*x_8 + 0.00022709158063321*x_80 - 0.000284836198176145*x_81 - 0.00224775054072654*x_82 - 0.00340296835919866*x_83 + 0.000546326217019512*x_86 + 0.000140025974057098*x_87 - 0.000503181674197573*x_88 - 0.000183506552224263*x_89 + 0.00245046208639628*x_9 + 8.5298129365092e-5*x_90 + 0.0106575306305003*x_91 - 0.000287289246071219*x_92 + 0.000852070921412038*x_94 + 0.00673668475631333*x_97 - 0.000540802628000004*x_98 - 0.000187504053546912*x_99 - 0.000152509806555194*std::pow(-3.28623986244202*x_14 - 4.83031988143921, 2) + 4.63711363375494e-5*std::pow(-5.59087991714478*x_17 - 8.77711963653564, 2) + 7.55874639543861e-5*std::pow(-4.67167949676514*x_17 - 6.90744018554688, 2) + 0.000248440381125852*std::pow(-1.91071999073029*x_18 - 2.75584006309509, 2) + 2.91881091117255e-5*std::pow(-6.07679986953735*x_22 - 9.73752021789551, 2) + 8.09890740724065e-6*std::pow(-6.36255979537964*x_23 - 8.93599987030029, 2) - 9.07946721809984e-5*std::pow(-4.91200017929077*x_4 - 8.39608001708984, 2) + 4.32348163583465e-5*std::pow(-3.57223987579346*x_47 - 6.35407972335815, 2) + 0.000159604280159129*std::pow(-3.41503977775574*x_5 - 5.42375993728638, 2) + 4.57173367738197e-5*std::pow(-3.721519947052*x_56 - 5.28943967819214, 2) + 1.43359415514294e-5*std::pow(-5.77103996276855*x_58 - 7.56695985794067, 2) - 2.66881184088162e-5*std::pow(-5.90503978729248*x_6 - 9.16919994354248, 2) + 0.000145947850338526*std::pow(-2.89567995071411*x_6 - 4.63944005966187, 2) - 3.60975378636408e-5*std::pow(-5.1267204284668*x_66 - 7.49520015716553, 2) - 1.30192537307121e-5*std::pow(-6.9987998008728*x_67 - 9.77744007110596, 2) - 3.14967636511199e-5*std::pow(-6.21640014648438*x_67 - 8.61551952362061, 2) - 8.96192917396277e-6*std::pow(-5.79999971389771*x_67 - 10.0, 2) + 5.74844923406607e-5*std::pow(-3.71591997146606*x_68 - 4.97343969345093, 2) + 1.13438549624644e-5*std::pow(-5.72896003723145*x_7 - 8.99792003631592, 2) + 1.18297148065385e-5*std::pow(-5.51319980621338*x_7 - 8.79199981689453, 2) - 6.05584000744173e-5*std::pow(-5.43391990661621*x_7 - 8.85800075531006, 2) - 6.19932337311103e-5*std::pow(-5.27688026428223*x_7 - 8.52688026428223, 2) - 4.44163598906617e-6*std::pow(-6.60000038146973*x_71 - 9.96463966369629, 2) + 2.15553165380204e-5*std::pow(-7.60000038146973*x_72 - 9.99660015106201, 2) + 0.000189836827185825*std::pow(-2.52336001396179*x_72 - 3.5783998966217, 2) - 6.39452060186254e-6*std::pow(-6.59600019454956*x_75 - 9.96208000183105, 2) - 2.06200794439529e-6*std::pow(-6.40000009536743*x_78 - 9.99993991851807, 2) - 1.40712945148735e-5*std::pow(-7.19984006881714*x_81 - 9.79320049285889, 2) - 3.52047487392054e-5*std::pow(-4.73992013931274*x_82 - 7.30111980438232, 2) + 3.60922718124466e-5*std::pow(-5.49191999435425*x_83 - 7.52191972732544, 2) + 4.45697447498923e-5*std::pow(-4.27015972137451*x_84 - 6.41544008255005, 2) + 6.22607272712231e-6*std::pow(-3.90391993522644*x_85 - 6.36783981323242, 2) + 4.15775837413642e-5*std::pow(-3.28543996810913*x_85 - 7.1800799369812, 2) + 2.51846440251326e-5*std::pow(-6.69712018966675*x_86 - 9.7344799041748, 2) - 5.66715572602265e-5*std::pow(-4.22168016433716*x_86 - 6.42952013015747, 2) + 1.54049274206718e-5*std::pow(-4.28991985321045*x_87 - 6.95071983337402, 2) - 5.16005712070338e-5*std::pow(-3.91824007034302*x_87 - 5.3600001335144, 2) + 1.33229929974648e-5*std::pow(-4.93191957473755*x_88 - 5.71687984466553, 2) - 1.60652844984064e-5*std::pow(-5.10663986206055*x_89 - 7.55287981033325, 2) + 5.32799933077862e-5*std::pow(-4.09903955459595*x_89 - 5.94736003875732, 2) + 4.63218367524702e-6*std::pow(-6.60000038146973*x_90 - 9.96016025543213, 2) - 9.92779424711691e-6*std::pow(-5.74399995803833*x_90 - 7.7992000579834, 2) - 3.96042263184114e-5*std::pow(-4.90768003463745*x_90 - 7.15335988998413, 2) - 7.6745300278299e-5*std::exp(1.29391980171204*x_17) + 0.000343713845481122*std::exp(0.730479836463928*x_22) - 0.000442336222989328*std::exp(0.602479875087738*x_29) + 0.0398182460101236*std::sin(0.225279986858368*x_1 - 4.18847990036011) + 0.0374926485087523*std::sin(0.281839966773987*x_1 + 2.15455985069275) - 0.029114850989154*std::sin(0.341919839382172*x_1 - 4.35288000106812) - 0.101472802977248*std::sin(0.270319938659668*x_10 - 7.50264024734497) + 0.0283978938659092*std::sin(0.34623983502388*x_10 - 1.06567978858948) - 0.00467299677484423*std::sin(0.36847984790802*x_10 + 5.17600011825562) + 0.0238368853856513*std::sin(0.316399842500687*x_101 - 4.24911975860596) - 0.00685384560474868*std::sin(0.301919937133789*x_102 + 5.10527992248535) - 0.0140229013833958*std::sin(0.397359818220139*x_102 + 1.99735975265503) - 0.00137008786714034*std::sin(0.300079941749573*x_103 + 5.10311985015869) - 0.00658910903430299*std::sin(0.416559875011444*x_103 + 5.21712017059326) - 0.0273015357070527*std::sin(0.394079834222794*x_104 - 7.39215993881226) - 0.0171848890915292*std::sin(0.398559838533401*x_104 + 5.20975971221924) - 0.00240988189003335*std::sin(0.40055987238884*x_104 + 5.20408010482788) - 0.0125868967949607*std::sin(0.428879857063293*x_104 + 5.22983980178833) + 0.0390590089517992*std::sin(0.162960022687912*x_105 - 7.63632011413574) - 0.0152471346806394*std::sin(0.324799835681915*x_105 + 8.32863998413086) + 0.0230414443438858*std::sin(0.37391984462738*x_105 - 7.43215990066528) + 0.00291320400270921*std::sin(0.403519839048386*x_105 + 2.01263976097107) - 0.0131021997154526*std::sin(0.386079847812653*x_106 + 1.99143981933594) + 0.00919267790924825*std::sin(0.396559834480286*x_106 - 7.3874397277832) - 0.0303460568543025*std::sin(0.40055987238884*x_106 - 7.38775968551636) + 0.00951998433585221*std::sin(0.442479848861694*x_106 + 5.22079992294312) - 0.0036380795940999*std::sin(0.35455983877182*x_107 + 5.15592002868652) - 0.00944478121142197*std::sin(0.369519859552383*x_107 + 5.18247985839844) + 0.0154916874406168*std::sin(0.392639845609665*x_107 - 7.40319967269897) + 0.00299691143231832*std::sin(0.570399820804596*x_107 + 2.1801598072052) + 0.0258239844431484*std::sin(0.127280056476593*x_108 + 1.72391986846924) + 0.0268861830062636*std::sin(0.296719938516617*x_108 - 7.49255990982056) - 0.0295330997109547*std::sin(0.388879835605621*x_108 + 5.17456007003784) - 0.0236382476139718*std::sin(0.3504798412323*x_109 + 5.14728021621704) - 0.00221501383818592*std::sin(0.432159870862961*x_109 + 5.23464012145996) - 0.00294273461237063*std::sin(0.262559980154037*x_11 + 8.27199935913086) + 0.0144610436780633*std::sin(0.298159927129745*x_11 - 4.2611198425293) + 0.0188978874614196*std::sin(0.300399929285049*x_11 - 1.06567990779877) + 0.0188055912173761*std::sin(0.36959981918335*x_110 - 7.41879987716675) + 0.0136390600676831*std::sin(0.400079846382141*x_110 - 4.20775985717773) - 0.0272039287429508*std::sin(0.253279983997345*x_111 - 4.3439998626709) + 0.0247273252157929*std::sin(0.355199843645096*x_111 - 4.24304008483887) + 0.0150194975165034*std::sin(0.357679843902588*x_111 - 4.2388801574707) - 0.0045468941246794*std::sin(0.388959854841232*x_111 + 5.20007991790771) - 0.00201646675257727*std::sin(0.762639880180359*x_111 - 1.20167982578278) + 0.0363825902128526*std::sin(0.350879848003387*x_112 - 4.24528026580811) + 0.0156228502028403*std::sin(0.362399846315384*x_112 + 5.16552019119263) - 0.0224208165401758*std::sin(0.372479856014252*x_112 - 7.41504001617432) + 0.0232033240427032*std::sin(0.377519845962524*x_113 - 7.42136001586914) - 0.0240907275366199*std::sin(0.181760013103485*x_114 - 1.20503985881805) - 0.0185276689312546*std::sin(0.321759849786758*x_114 + 5.13535976409912) - 0.00414608761287943*std::sin(0.32423985004425*x_114 + 5.132080078125) + 0.0140599458828844*std::sin(0.389039844274521*x_114 - 7.40039968490601) + 0.0536344996689524*std::sin(0.189999997615814*x_115 - 7.61768007278442) + 0.0204431661003472*std::sin(0.230639979243279*x_115 + 1.83319985866547) + 0.0137165984142252*std::sin(0.33231982588768*x_115 + 5.14056015014648) + 0.0243150603349485*std::sin(0.3642398416996*x_115 - 7.42384004592896) - 0.000765082812230723*std::sin(0.491039872169495*x_115 - 4.1386399269104) + 0.0480502099921325*std::sin(0.260159969329834*x_116 - 4.30823993682861) + 0.00248254435601858*std::sin(0.453839868307114*x_116 + 8.24575996398926) + 0.0302645562172325*std::sin(0.240879982709885*x_117 - 7.5633602142334) - 0.0130056273377978*std::sin(0.355279833078384*x_117 - 7.42416000366211) - 0.0148099969414862*std::sin(0.363599836826324*x_117 - 7.42176008224487) + 0.00428729015660162*std::sin(0.413519859313965*x_117 + 5.20032024383545) + 0.00600546950233968*std::sin(0.322159856557846*x_118 + 1.92447984218597) + 0.00214602144862704*std::sin(0.345439821481705*x_118 + 5.1592001914978) + 0.00491808006261827*std::sin(0.450399875640869*x_118 + 5.2403998374939) + 0.0173283381071599*std::sin(0.299039930105209*x_119 + 5.09831953048706) + 0.0136639858806233*std::sin(0.367199838161469*x_119 + 8.1812801361084) - 0.00326790244085066*std::sin(0.369119822978973*x_119 + 1.97495973110199) + 0.03957973921078*std::sin(0.249199971556664*x_12 + 5.06543970108032) + 0.0367568463226085*std::sin(0.283599942922592*x_12 + 8.31063938140869) + 0.00368312663463107*std::sin(0.318879842758179*x_12 - 4.26143980026245) + 0.0267570500181428*std::sin(0.342079848051071*x_12 + 8.34247970581055) + 0.0268676271311649*std::sin(0.302719920873642*x_120 - 7.48975992202759) + 0.00278728937671069*std::sin(0.482079833745956*x_120 + 2.02687978744507) + 0.00768922829812532*std::sin(0.417599856853485*x_13 - 7.16351985931396) - 0.0505788587745196*std::sin(0.23319998383522*x_14 + 8.24967956542969) - 0.0135622618587433*std::sin(0.351519852876663*x_14 - 1.0487197637558) + 0.0422787882509283*std::sin(0.254239976406097*x_15 - 1.0914398431778) - 0.00586958423322691*std::sin(0.417839854955673*x_15 + 2.22183990478516) - 0.0244963546428163*std::sin(0.313599914312363*x_16 - 4.26719999313354) + 0.0345476177516636*std::sin(0.321199834346771*x_16 - 4.25663995742798) - 0.00298875172448556*std::sin(0.373839825391769*x_16 + 2.15111970901489) + 0.0190080656179826*std::sin(0.402399867773056*x_16 + 5.189040184021) - 0.0108017298080523*std::sin(0.237599983811378*x_18 - 4.33536005020142) + 0.0477651734485898*std::sin(0.238399982452393*x_19 - 4.33599996566772) - 0.00470539461438112*std::sin(0.254319965839386*x_19 - 4.31472015380859) + 0.0255242047537409*std::sin(0.311999946832657*x_21 - 4.27687978744507) + 0.0235616560163235*std::sin(0.333199828863144*x_21 - 4.25576019287109) - 0.0360652160232015*std::sin(0.364319831132889*x_21 + 8.36192035675049) - 0.0645947452876308*std::sin(0.222559988498688*x_23 - 4.36664009094238) - 0.0388415056792595*std::sin(0.341359853744507*x_23 - 4.26792001724243) + 0.00651488534651344*std::sin(0.477199852466583*x_23 - 7.31928014755249) + 0.00662712860753279*std::sin(0.359199821949005*x_24 + 2.12399983406067) + 0.00974755562025106*std::sin(0.382639855146408*x_24 + 5.38751983642578) - 0.0271569377073999*std::sin(0.437999874353409*x_24 + 8.44855976104736) - 0.0394226181297753*std::sin(0.319279849529266*x_26 - 4.28200006484985) - 0.0232241431776513*std::sin(0.327199846506119*x_26 - 4.26272010803223) - 0.0374364875961193*std::sin(0.350639849901199*x_27 + 8.32791996002197) - 0.0274203967015941*std::sin(0.366399854421616*x_27 + 5.17136001586914) - 0.0470416260825703*std::sin(0.366799861192703*x_27 - 4.24416017532349) - 0.00175394558108082*std::sin(0.444319844245911*x_27 - 0.939439833164215) + 0.0102596840667684*std::sin(0.536719858646393*x_27 - 4.05399990081787) + 0.0187382892287271*std::sin(0.311599940061569*x_28 + 5.12759971618652) + 0.0123985747808421*std::sin(0.320399850606918*x_28 - 4.2739200592041) + 0.0316292257567963*std::sin(0.333199828863144*x_28 - 4.27544021606445) - 0.047876591990072*std::sin(0.348239839076996*x_28 - 4.23992013931274) + 0.0236578691916904*std::sin(0.342559844255447*x_3 - 4.24079990386963) - 0.0308029735794468*std::sin(0.376959830522537*x_3 - 1.01671981811523) + 0.0133671011847276*std::sin(0.296799927949905*x_30 - 4.29607963562012) + 0.0362318537950659*std::sin(0.295999944210052*x_33 - 1.16031992435455) + 0.0248083091177922*std::sin(0.352079838514328*x_34 + 1.99303984642029) - 0.0226852838694227*std::sin(0.356959849596024*x_34 + 1.98511981964111) + 0.00668769457482974*std::sin(0.360879838466644*x_34 + 1.99647974967957) + 0.0271288917379378*std::sin(0.307439923286438*x_35 - 1.14431989192963) - 0.03142835819503*std::sin(0.312399834394455*x_35 - 7.41991996765137) - 0.00418548283554988*std::sin(0.316639840602875*x_35 + 1.94799983501434) + 0.0312344430710592*std::sin(0.331839829683304*x_35 + 1.95959985256195) - 0.0123949312947639*std::sin(0.333759844303131*x_35 + 1.97559976577759) + 0.0197604263943408*std::sin(0.345039844512939*x_36 - 7.4507999420166) - 0.0342569717668818*std::sin(0.358079850673676*x_36 + 5.17239999771118) + 0.0136333788735353*std::sin(0.361599832773209*x_36 - 4.23776006698608) + 0.0145745325216319*std::sin(0.305039942264557*x_37 + 5.12063980102539) - 0.0164195145208963*std::sin(0.369439840316772*x_37 + 5.18287992477417) - 0.03696465314083*std::sin(0.385359823703766*x_37 + 5.19280004501343) - 0.0492715912585811*std::sin(0.389999836683273*x_37 + 5.19632005691528) + 0.00616213430599912*std::sin(0.218799993395805*x_38 + 5.01575994491577) + 0.0309759215023953*std::sin(0.262399971485138*x_38 - 7.52008008956909) + 0.0117396174255789*std::sin(0.320239841938019*x_38 + 5.11552000045776) + 0.0378058588245305*std::sin(0.344159841537476*x_38 + 5.13088035583496) - 0.0350810216589533*std::sin(0.367359846830368*x_38 + 5.17296028137207) - 0.0222067095633519*std::sin(0.352319836616516*x_39 - 7.42647981643677) + 0.0419853240118238*std::sin(0.2291199862957*x_40 + 5.04504013061523) - 0.014148095561157*std::sin(0.309679925441742*x_40 - 7.48591995239258) - 0.00428236214858468*std::sin(0.317279845476151*x_40 - 7.46495962142944) - 0.00453357990605851*std::sin(0.333999842405319*x_41 + 5.14592027664185) + 0.00884099286562338*std::sin(0.341359823942184*x_41 + 1.95199990272522) - 0.0182982336828765*std::sin(0.317679852247238*x_42 + 8.32288074493408) - 0.00374582714766277*std::sin(0.355359852313995*x_43 + 5.16279983520508) + 0.0345479560314534*std::sin(0.360879838466644*x_43 + 5.16096019744873) - 0.0257711724985387*std::sin(0.364639848470688*x_43 - 4.23912000656128) - 0.0037905635878012*std::sin(0.269999951124191*x_44 - 4.30319976806641) + 0.0270204125869085*std::sin(0.329999834299088*x_44 + 5.11872005462646) + 0.0228023412186085*std::sin(0.328879833221436*x_45 - 7.44984006881714) - 0.0213401339703776*std::sin(0.341919839382172*x_45 + 5.13479995727539) + 0.00385187832390208*std::sin(0.351679861545563*x_45 + 5.14408016204834) + 0.0103716670977775*std::sin(0.35471984744072*x_45 + 8.35632038116455) + 0.0367349716418137*std::sin(0.246319979429245*x_46 - 7.53096008300781) - 0.007569450450723*std::sin(0.29479992389679*x_46 + 5.11055994033813) - 0.0114090050541908*std::sin(0.347519844770432*x_46 - 4.24232006072998) + 0.0174377132545099*std::sin(0.29215994477272*x_47 - 7.47575998306274) - 0.00432527020623265*std::sin(0.324559837579727*x_47 - 4.27048015594482) + 0.0228449516027788*std::sin(0.336879849433899*x_47 - 4.26936006546021) + 0.0237837276582534*std::sin(0.300879925489426*x_48 + 5.12215948104858) + 0.00316478865689696*std::sin(0.337039858102798*x_49 + 5.13264036178589) + 0.0206038681338425*std::sin(0.35455983877182*x_49 - 7.43215990066528) + 0.00898076949061377*std::sin(0.433759868144989*x_49 - 4.17463970184326) + 0.0458827410704938*std::sin(0.246479973196983*x_50 - 7.53216028213501) + 0.0476501127441981*std::sin(0.249039962887764*x_50 + 5.05631971359253) + 0.00214335111721482*std::sin(0.31879985332489*x_50 + 5.11704015731812) + 0.0176889637163863*std::sin(0.366719841957092*x_50 + 5.16960000991821) + 0.013860508319601*std::sin(0.22647999227047*x_51 - 7.58319997787476) + 0.0225978730221977*std::sin(0.300319939851761*x_51 - 4.28999948501587) - 0.0278312921735052*std::sin(0.338239848613739*x_51 - 4.25888013839722) - 0.000752657964555833*std::sin(0.449919849634171*x_51 - 4.16607999801636) - 0.00492832582769516*std::sin(0.281759947538376*x_52 + 5.10095977783203) + 0.0221410979919548*std::sin(0.236559987068176*x_53 - 4.34311962127686) + 0.0400944868499578*std::sin(0.290879935026169*x_53 + 5.103919506073) - 0.0281183906987268*std::sin(0.305999934673309*x_53 + 5.12415981292725) + 0.0464625195565154*std::sin(0.26215997338295*x_54 - 7.52416038513184) + 0.0193355316764265*std::sin(0.324559837579727*x_54 - 4.27511978149414) - 0.00111087221888393*std::sin(0.350879848003387*x_54 + 2.13367986679077) - 0.00501959076130943*std::sin(0.239439979195595*x_55 + 5.03903961181641) - 0.00638272741994782*std::sin(0.378319829702377*x_55 - 1.00887978076935) + 0.00648498122850876*std::sin(0.22503998875618*x_56 + 5.03327989578247) + 0.0318629714225329*std::sin(0.300399929285049*x_56 + 5.12975978851318) + 0.00658692155804352*std::sin(0.318239837884903*x_56 + 5.1159200668335) - 0.0194160086349893*std::sin(0.254079967737198*x_57 - 7.52976036071777) - 0.0362468557838034*std::sin(0.275119960308075*x_57 + 5.07976007461548) + 0.0033066581594982*std::sin(0.318639844655991*x_57 - 4.29200029373169) - 0.00883800217021569*std::sin(0.213919997215271*x_58 + 5.01063966751099) - 0.0230600001097808*std::sin(0.286479920148849*x_58 + 5.09591960906982) - 0.011393037648836*std::sin(0.280559957027435*x_59 + 1.87903988361359) - 0.0247321938299625*std::sin(0.367759823799133*x_59 - 4.2294397354126) - 0.00399169564533701*std::sin(0.376079827547073*x_59 - 7.42407989501953) + 0.046231971399097*std::sin(0.245839968323708*x_60 - 7.53416013717651) - 0.00401761247489327*std::sin(0.253439962863922*x_60 - 7.54631996154785) + 0.041727205501372*std::sin(0.281599938869476*x_60 + 5.08191967010498) + 0.0188632541260265*std::sin(0.313439846038818*x_60 + 8.30096054077148) - 0.0159317579457868*std::sin(0.270399957895279*x_63 + 8.28127956390381) - 0.0812176913675402*std::sin(0.155440032482147*x_64 - 4.47199964523315) + 0.0170250876945872*std::sin(0.289519935846329*x_65 - 4.28743982315063) - 0.00745730300117574*std::sin(0.292959928512573*x_65 + 5.12455987930298) + 0.0373037722799699*std::sin(0.295599937438965*x_65 - 4.2902398109436) - 0.0822569593782506*std::sin(0.162640020251274*x_66 + 4.94399976730347) + 0.00377358317525889*std::sin(0.230159983038902*x_66 + 5.02184009552002) + 0.0212287883500653*std::sin(0.262159943580627*x_66 - 7.51416015625) - 0.0149471125520258*std::sin(0.20168000459671*x_67 + 4.99440002441406) + 0.0339439228871426*std::sin(0.183040007948875*x_68 - 4.43607997894287) + 0.0966137580876285*std::sin(0.196959987282753*x_68 + 4.9846396446228) + 0.0165946404972749*std::sin(0.196959987282753*x_68 + 4.98943948745728) - 0.00111249954308446*std::sin(0.353599846363068*x_68 + 8.35048007965088) - 0.0459587216528379*std::sin(0.156880035996437*x_69 - 4.47191953659058) + 0.0123909467513094*std::sin(0.174560010433197*x_69 - 4.44608020782471) + 0.0413321013429309*std::sin(0.238479986786842*x_69 + 5.03991985321045) + 0.0255096623997353*std::sin(0.298639923334122*x_7 - 1.02047991752625) + 0.0373113761916645*std::sin(0.242239981889725*x_70 - 7.54864025115967) - 0.00609969253418745*std::sin(0.274159938097*x_70 + 1.88463997840881) - 0.00427307427730374*std::sin(0.332239836454391*x_70 - 4.28344011306763) - 0.135889168304714*std::sin(0.128320053219795*x_71 - 4.51495981216431) - 0.0189900059576356*std::sin(0.138400033116341*x_73 + 4.90935945510864) - 0.0470867574013281*std::sin(0.15776002407074*x_73 + 4.92848014831543) - 0.0268800879167346*std::sin(0.275279968976974*x_73 + 5.07599973678589) + 0.0030790421802424*std::sin(0.470879852771759*x_73 + 2.04903984069824) - 0.0120284095357562*std::sin(0.195040002465248*x_74 + 4.98744010925293) - 0.0389055320390329*std::sin(0.274639964103699*x_74 - 4.31271982192993) - 0.0247292750955454*std::sin(0.305599927902222*x_74 + 5.12239980697632) + 0.0255503478983628*std::sin(0.312799841165543*x_74 + 5.11303997039795) - 0.0107003899955933*std::sin(0.326879858970642*x_74 - 4.27383995056152) + 0.0661576873481099*std::sin(0.19055999815464*x_75 + 4.97583961486816) + 0.030870326093703*std::sin(0.202880010008812*x_75 - 4.40423965454102) - 0.0533260199002571*std::sin(0.246879979968071*x_75 + 5.0577597618103) + 0.00719168863817668*std::sin(0.285679936408997*x_75 - 7.48791980743408) + 0.0096859667559963*std::sin(0.191040009260178*x_76 + 4.97191953659058) - 0.0422398509806112*std::sin(0.178640007972717*x_77 - 7.62040042877197) + 0.0218416733287899*std::sin(0.227039992809296*x_77 - 7.55208015441895) - 0.00152242779217734*std::sin(0.321919828653336*x_77 - 4.29168033599854) + 0.00718966580282917*std::sin(0.332159847021103*x_77 - 1.0759197473526) - 0.0512988909839844*std::sin(0.221759989857674*x_78 + 5.01408004760742) - 0.0102437367159551*std::sin(0.377519845962524*x_78 + 5.1831202507019) + 0.019328674039861*std::sin(0.286319941282272*x_79 + 5.09559965133667) + 0.00452468155122359*std::sin(0.487999856472015*x_79 - 7.32823991775513) - 0.0626464785247465*std::sin(0.202159985899925*x_8 - 4.39463996887207) - 0.00748658097069628*std::sin(0.273039966821671*x_8 - 4.31079959869385) - 0.0301358693918908*std::sin(0.169440016150475*x_80 - 7.63960027694702) - 0.0558180052005494*std::sin(0.177920013666153*x_80 - 7.6255202293396) + 0.0026407578176788*std::sin(0.249199971556664*x_80 + 5.05807971954346) - 0.0193918706104248*std::sin(0.313839852809906*x_80 - 4.29152011871338) + 0.00685885480375337*std::sin(0.193200007081032*x_81 - 7.60736036300659) - 0.0264511261092727*std::sin(0.360079854726791*x_81 - 4.23920011520386) - 0.00686181549779463*std::sin(0.36831983923912*x_81 - 7.42639970779419) - 0.109231400936746*std::sin(0.193039998412132*x_82 + 4.98015975952148) - 0.00949948832030891*std::sin(0.209600001573563*x_82 + 8.20239925384521) + 0.110565818140385*std::sin(0.155760034918785*x_83 + 4.93103981018066) - 0.0518651313169656*std::sin(0.249119967222214*x_84 + 5.05751991271973) - 0.0159887009001273*std::sin(0.302159935235977*x_84 + 5.14359951019287) + 0.00599007555451078*std::sin(0.322719842195511*x_84 + 5.12712001800537) + 0.0124262842515921*std::sin(0.390079826116562*x_84 + 5.18688011169434) - 0.102167376872377*std::sin(0.164800018072128*x_85 - 7.63064002990723) + 0.0430200982925798*std::sin(0.238879978656769*x_85 + 5.03191947937012) - 0.0108906037572034*std::sin(0.346639841794968*x_85 - 4.24584007263184) - 0.0101901960663675*std::sin(0.391279846429825*x_86 - 4.19704008102417) - 0.120982398718664*std::sin(0.152880027890205*x_87 - 7.64616012573242) - 0.0399734999671094*std::sin(0.259839981794357*x_87 + 5.06343984603882) - 0.018352530255482*std::sin(0.345679849386215*x_88 - 4.25648021697998) + 0.00103333103882802*std::sin(0.572799861431122*x_88 - 0.833039879798889) + 0.0787082204619584*std::sin(0.180400013923645*x_89 + 4.9684796333313) + 0.0130919398220901*std::sin(0.341119825839996*x_89 - 4.27016019821167) + 0.134855646985371*std::sin(0.178000003099442*x_9 - 4.42439985275269) - 0.0638861385598512*std::sin(0.240079984068871*x_9 - 4.34311962127686) - 0.0229548868426295*std::sin(0.400879859924316*x_9 - 0.971039831638336) + 0.000682376930019306*std::sin(0.627359867095947*x_9 - 6.96623992919922) - 0.0258938302845154*std::sin(0.374399840831757*x_92 + 2.0020797252655) + 0.0378573699304194*std::sin(0.335999846458435*x_93 + 1.99351978302002) + 0.0245998055893313*std::sin(0.340079843997955*x_93 - 7.4270396232605) - 0.0292551654899891*std::sin(0.358159840106964*x_93 - 7.40423965454102) - 0.0243438711149646*std::sin(0.361279845237732*x_93 + 2.00159978866577) - 0.00538653961172664*std::sin(0.36151984333992*x_93 - 7.41088008880615) - 0.000578388507839136*std::sin(0.380799859762192*x_94 + 1.97039985656738) - 0.00879558555761264*std::sin(0.384719848632813*x_94 + 2.0019998550415) - 0.0324225630909563*std::sin(0.396719843149185*x_94 - 7.39343976974487) + 0.00632823958945503*std::sin(0.411759853363037*x_94 - 4.18368005752563) - 0.00139932839822069*std::sin(0.353599846363068*x_95 + 1.95167982578278) + 0.00753048546755337*std::sin(0.357599824666977*x_95 - 7.42639970779419) - 0.0109761917335434*std::sin(0.358639866113663*x_95 - 7.41207981109619) - 0.0190067047036237*std::sin(0.364079833030701*x_95 + 5.16887998580933) - 0.0154422389890476*std::sin(0.374639838933945*x_95 - 7.41559982299805) + 0.0201808221013115*std::sin(0.383999854326248*x_96 - 7.40655994415283) - 0.0230928426650217*std::sin(0.393039852380753*x_96 + 5.19248008728027) - 0.0318295137999748*std::sin(0.395359843969345*x_96 - 7.38895988464355) - 0.00427999084253792*std::sin(0.414799869060516*x_96 + 8.39535999298096) - 0.00224787577572036*std::sin(0.415759861469269*x_96 - 7.37639951705933) + 0.00310389794579654*std::sin(0.33519983291626*x_97 - 7.44375991821289) - 0.00216933963445101*std::sin(0.343839854001999*x_98 + 1.95423984527588) - 0.0128982360298633*std::sin(0.362719833850861*x_98 - 7.41815996170044) + 0.0102675690974994*std::sin(0.410319864749908*x_98 - 7.4031195640564) + 0.0127962011718358*std::sin(0.41839987039566*x_98 + 2.01895976066589) + 0.0130365769167214*std::sin(0.310559868812561*x_99 - 7.46631956100464) + 0.00123724893229709*std::sin(0.389679849147797*x_99 - 7.41063976287842) - 0.015079167068912*std::sin(0.397759854793549*x_99 + 1.99927973747253) - 0.0153478597739826*std::sin(0.409279853105545*x_99 - 7.38895988464355) + 0.313249907469974);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00609634229247717*x_1 - 0.00061373699140556*x_10 + 0.00275340843020001*x_100 + 0.000407298643472775*x_101 + 0.000236546049822616*x_102 - 0.00108638142812033*x_103 + 0.000117306359030729*x_104 + 0.00124319239195986*x_105 + 0.00013733476443335*x_106 - 0.000603519044381908*x_107 + 0.000216437534837306*x_108 - 0.00238929007737168*x_109 - 0.00201285685017771*x_11 + 0.00488120888145081*x_110 + 0.00174655210380949*x_112 + 0.00311373739221991*x_113 - 0.00020747687501015*x_114 + 0.0018268818688189*x_116 - 0.000236452772890825*x_117 - 6.23966042903859e-5*x_118 + 0.00176081874545886*x_119 + 0.00175271567534191*x_12 + 4.87351720446938e-6*x_120 + 0.00174399217507372*x_13 + 0.00264123866243321*x_14 - 0.00111173292288336*x_15 + 0.000293482815879243*x_16 + 0.00125976975204131*x_17 - 0.0013369175172549*x_18 + 0.000645290808317643*x_19 + 0.00258699950473218*x_2 - 0.00674388603804461*x_20 + 0.000194049745000199*x_21 - 0.000568805862122494*x_22 + 0.000157742781462334*x_23 - 0.000334738202872908*x_24 - 0.00673789406711906*x_25 - 0.00123828186900307*x_26 + 0.000132722079806441*x_28 - 0.00414362380098709*x_29 + 0.0047770372176368*x_3 + 0.000274530907660245*x_30 + 0.000953568144152371*x_31 + 0.00386154927306984*x_32 - 0.00172788091426182*x_33 + 0.00138621986421922*x_34 + 0.000413413504684747*x_36 + 0.000889124542319456*x_37 + 0.00120720094997042*x_39 + 0.0106410193767297*x_4 + 0.000166919019420756*x_40 + 0.000983075795003754*x_41 - 0.000896393594017578*x_42 + 0.00020709299466756*x_43 - 0.000174212532404969*x_44 + 0.000172409363613871*x_45 + 0.000226170819780333*x_46 - 9.63659811046228e-5*x_47 - 0.00194754539660231*x_48 + 0.000226184039688094*x_49 + 0.00159032411645025*x_5 - 0.000428597485025269*x_50 - 0.00132779111321281*x_51 - 0.00683781405485034*x_52 + 0.000490804681469309*x_53 + 0.000508338092164503*x_54 - 0.000433593413924427*x_55 + 1.56527566028694e-5*x_56 - 0.000491129763537536*x_57 - 0.000924344878993427*x_58 + 0.00247687494814622*x_59 + 0.00117249437406288*x_6 + 0.000332269366906534*x_60 - 0.000256590309701176*x_61 + 0.00122340524327337*x_62 + 0.00247538071260872*x_63 + 0.00185051266888245*x_64 - 8.24121616394485e-5*x_65 + 0.000280502937144238*x_66 + 1.42478868057914e-5*x_67 + 0.000232422943492988*x_69 - 0.000116476077881345*x_70 - 8.09073106050546e-5*x_71 + 0.00076079455676143*x_72 + 2.00187446009076e-5*x_73 + 0.000482819282360436*x_76 + 0.000469341960531211*x_77 - 0.000247438169818372*x_78 - 0.00031346737220107*x_79 + 0.00114162751009522*x_8 + 0.000268987304919853*x_80 + 0.000173941251943541*x_81 - 0.00330908819247475*x_82 + 0.00111759449488149*x_83 + 0.000789506191878893*x_86 + 0.000952560207641306*x_87 + 0.00144874677534618*x_88 - 0.00124834724891116*x_89 - 0.00121711410027449*x_9 + 2.41183110570901e-5*x_90 + 0.00463642104559397*x_91 + 0.000499406994239255*x_92 + 0.00100926797951787*x_94 - 0.00341256334691294*x_97 - 0.0006405743488758*x_98 + 0.000114503318143116*x_99 + 9.31333406910337e-5*std::pow(-3.28623986244202*x_14 - 4.83031988143921, 2) + 5.49260653113106e-5*std::pow(-5.59087991714478*x_17 - 8.77711963653564, 2) - 4.83446970595507e-5*std::pow(-4.67167949676514*x_17 - 6.90744018554688, 2) - 0.000158899033444708*std::pow(-1.91071999073029*x_18 - 2.75584006309509, 2) - 1.86683111051195e-5*std::pow(-6.07679986953735*x_22 - 9.73752021789551, 2) + 5.5094756336871e-5*std::pow(-6.36255979537964*x_23 - 8.93599987030029, 2) + 5.80710172239729e-5*std::pow(-4.91200017929077*x_4 - 8.39608001708984, 2) - 2.14741966034286e-5*std::pow(-3.57223987579346*x_47 - 6.35407972335815, 2) - 7.92734647576265e-5*std::pow(-3.41503977775574*x_5 - 5.42375993728638, 2) - 2.79182591429094e-5*std::pow(-3.721519947052*x_56 - 5.28943967819214, 2) - 9.16907004295737e-6*std::pow(-5.77103996276855*x_58 - 7.56695985794067, 2) + 1.32556571291152e-5*std::pow(-5.90503978729248*x_6 - 9.16919994354248, 2) - 9.33462275618425e-5*std::pow(-2.89567995071411*x_6 - 4.63944005966187, 2) + 2.20437253701799e-5*std::pow(-5.1267204284668*x_66 - 7.49520015716553, 2) + 8.32693471410186e-6*std::pow(-6.9987998008728*x_67 - 9.77744007110596, 2) + 1.92341652385685e-5*std::pow(-6.21640014648438*x_67 - 8.61551952362061, 2) + 4.45127897462497e-6*std::pow(-5.79999971389771*x_67 - 10.0, 2) - 2.85518337799838e-5*std::pow(-3.71591997146606*x_68 - 4.97343969345093, 2) + 7.71692888498796e-5*std::pow(-5.72896003723145*x_7 - 8.99792003631592, 2) - 5.87567249997253e-6*std::pow(-5.51319980621338*x_7 - 8.79199981689453, 2) + 3.69812685048125e-5*std::pow(-5.43391990661621*x_7 - 8.85800075531006, 2) + 3.96500153290106e-5*std::pow(-5.27688026428223*x_7 - 8.52688026428223, 2) - 3.02152920449367e-5*std::pow(-6.60000038146973*x_71 - 9.96463966369629, 2) + 2.55320187833001e-5*std::pow(-7.60000038146973*x_72 - 9.99660015106201, 2) - 0.000115927875730429*std::pow(-2.52336001396179*x_72 - 3.5783998966217, 2) + 4.08984698209553e-6*std::pow(-6.59600019454956*x_75 - 9.96208000183105, 2) - 1.40273026407962e-5*std::pow(-6.40000009536743*x_78 - 9.99993991851807, 2) - 1.66672827664303e-5*std::pow(-7.19984006881714*x_81 - 9.79320049285889, 2) + 1.7485761695714e-5*std::pow(-4.73992013931274*x_82 - 7.30111980438232, 2) + 4.27508712396756e-5*std::pow(-5.49191999435425*x_83 - 7.52191972732544, 2) + 5.27923381739237e-5*std::pow(-4.27015972137451*x_84 - 6.41544008255005, 2) + 4.23543501102098e-5*std::pow(-3.90391993522644*x_85 - 6.36783981323242, 2) + 4.9248158670104e-5*std::pow(-3.28543996810913*x_85 - 7.1800799369812, 2) - 1.53795358157918e-5*std::pow(-6.69712018966675*x_86 - 9.7344799041748, 2) + 2.81480590166455e-5*std::pow(-4.22168016433716*x_86 - 6.42952013015747, 2) - 9.85277862776512e-6*std::pow(-4.28991985321045*x_87 - 6.95071983337402, 2) + 2.56293631911113e-5*std::pow(-3.91824007034302*x_87 - 5.3600001335144, 2) - 8.52120215036763e-6*std::pow(-4.93191957473755*x_88 - 5.71687984466553, 2) + 7.97942738901428e-6*std::pow(-5.10663986206055*x_89 - 7.55287981033325, 2) + 6.31095250913645e-5*std::pow(-4.09903955459595*x_89 - 5.94736003875732, 2) + 3.15115382930792e-5*std::pow(-6.60000038146973*x_90 - 9.96016025543213, 2) + 6.34967996328136e-6*std::pow(-5.74399995803833*x_90 - 7.7992000579834, 2) - 4.69107400244476e-5*std::pow(-4.90768003463745*x_90 - 7.15335988998413, 2) - 0.000522078276268809*std::exp(1.29391980171204*x_17) + 0.00233819571136982*std::exp(0.730479836463928*x_22) + 0.000282912133575346*std::exp(0.602479875087738*x_29) - 0.0197772285219852*std::sin(0.225279986858368*x_1 - 4.18847990036011) + 0.0444096009572703*std::sin(0.281839966773987*x_1 + 2.15455985069275) + 0.017779599866978*std::sin(0.341919839382172*x_1 - 4.35288000106812) + 0.0619665144426892*std::sin(0.270319938659668*x_10 - 7.50264024734497) - 0.0181629003574605*std::sin(0.34623983502388*x_10 - 1.06567978858948) - 0.0317891791728416*std::sin(0.36847984790802*x_10 + 5.17600011825562) + 0.0282345102345555*std::sin(0.316399842500687*x_101 - 4.24911975860596) + 0.00438362490444794*std::sin(0.301919937133789*x_102 + 5.10527992248535) + 0.00696500104826744*std::sin(0.397359818220139*x_102 + 1.99735975265503) - 0.00932035068492264*std::sin(0.300079941749573*x_103 + 5.10311985015869) + 0.00327272866551067*std::sin(0.416559875011444*x_103 + 5.21712017059326) + 0.013560333886687*std::sin(0.394079834222794*x_104 - 7.39215993881226) - 0.0203552989027063*std::sin(0.398559838533401*x_104 + 5.20975971221924) - 0.0163937984293194*std::sin(0.40055987238884*x_104 + 5.20408010482788) + 0.00768645488395993*std::sin(0.428879857063293*x_104 + 5.22983980178833) + 0.0462649364696368*std::sin(0.162960022687912*x_105 - 7.63632011413574) + 0.00975185657249331*std::sin(0.324799835681915*x_105 + 8.32863998413086) - 0.0140707455773737*std::sin(0.37391984462738*x_105 - 7.43215990066528) + 0.0198177675849668*std::sin(0.403519839048386*x_105 + 2.01263976097107) + 0.00837998581933545*std::sin(0.386079847812653*x_106 + 1.99143981933594) + 0.0108886188070477*std::sin(0.396559834480286*x_106 - 7.3874397277832) + 0.0150725097483226*std::sin(0.40055987238884*x_106 - 7.38775968551636) - 0.00581357989070267*std::sin(0.442479848861694*x_106 + 5.22079992294312) - 0.0247489073145691*std::sin(0.35455983877182*x_107 + 5.15592002868652) + 0.0060407515025967*std::sin(0.369519859552383*x_107 + 5.18247985839844) - 0.00769452885057645*std::sin(0.392639845609665*x_107 - 7.40319967269897) + 0.00354980632489776*std::sin(0.570399820804596*x_107 + 2.1801598072052) + 0.175673835864627*std::sin(0.127280056476593*x_108 + 1.72391986846924) - 0.0164186166015339*std::sin(0.296719938516617*x_108 - 7.49255990982056) - 0.0349816090716718*std::sin(0.388879835605621*x_108 + 5.17456007003784) + 0.0117408241639255*std::sin(0.3504798412323*x_109 + 5.14728021621704) - 0.0150681618595303*std::sin(0.432159870862961*x_109 + 5.23464012145996) - 0.0200186566261627*std::sin(0.262559980154037*x_11 + 8.27199935913086) + 0.0171289360637867*std::sin(0.298159927129745*x_11 - 4.2611198425293) - 0.00938634611911911*std::sin(0.300399929285049*x_11 - 1.06567990779877) - 0.0114840322291692*std::sin(0.36959981918335*x_110 - 7.41879987716675) - 0.00677435183144607*std::sin(0.400079846382141*x_110 - 4.20775985717773) + 0.0166126547595805*std::sin(0.253279983997345*x_111 - 4.3439998626709) - 0.0122817554898287*std::sin(0.355199843645096*x_111 - 4.24304008483887) - 0.00960626298906136*std::sin(0.357679843902588*x_111 - 4.2388801574707) - 0.0309313357089129*std::sin(0.388959854841232*x_111 + 5.20007991790771) - 0.00238848113929999*std::sin(0.762639880180359*x_111 - 1.20167982578278) - 0.0222177986193274*std::sin(0.350879848003387*x_112 - 4.24528026580811) - 0.00999215902677773*std::sin(0.362399846315384*x_112 + 5.16552019119263) + 0.0111361412617679*std::sin(0.372479856014252*x_112 - 7.41504001617432) - 0.0115248030248631*std::sin(0.377519845962524*x_113 - 7.42136001586914) + 0.014711512563298*std::sin(0.181760013103485*x_114 - 1.20503985881805) + 0.00920246317077716*std::sin(0.321759849786758*x_114 + 5.13535976409912) - 0.0282047534681889*std::sin(0.32423985004425*x_114 + 5.132080078125) + 0.0166538404453863*std::sin(0.389039844274521*x_114 - 7.40039968490601) + 0.0635294337044497*std::sin(0.189999997615814*x_115 - 7.61768007278442) - 0.0130751664410354*std::sin(0.230639979243279*x_115 + 1.83319985866547) - 0.00681286416567574*std::sin(0.33231982588768*x_115 + 5.14056015014648) - 0.0148485061337892*std::sin(0.3642398416996*x_115 - 7.42384004592896) - 0.00520465897408515*std::sin(0.491039872169495*x_115 - 4.1386399269104) + 0.0569149082963693*std::sin(0.260159969329834*x_116 - 4.30823993682861) + 0.0168881022479695*std::sin(0.453839868307114*x_116 + 8.24575996398926) + 0.0358480106958145*std::sin(0.240879982709885*x_117 - 7.5633602142334) + 0.00645973365742956*std::sin(0.355279833078384*x_117 - 7.42416000366211) + 0.00904403803230466*std::sin(0.363599836826324*x_117 - 7.42176008224487) + 0.0291653175726217*std::sin(0.413519859313965*x_117 + 5.20032024383545) - 0.00384101527690076*std::sin(0.322159856557846*x_118 + 1.92447984218597) + 0.0145988246143055*std::sin(0.345439821481705*x_118 + 5.1592001914978) - 0.00300332966360326*std::sin(0.450399875640869*x_118 + 5.2403998374939) + 0.0205252125736593*std::sin(0.299039930105209*x_119 + 5.09831953048706) - 0.0083442021268122*std::sin(0.367199838161469*x_119 + 8.1812801361084) - 0.0222306886173768*std::sin(0.369119822978973*x_119 + 1.97495973110199) + 0.0468817353336145*std::sin(0.249199971556664*x_12 + 5.06543970108032) - 0.0182566692989163*std::sin(0.283599942922592*x_12 + 8.31063938140869) + 0.0250553505910466*std::sin(0.318879842758179*x_12 - 4.26143980026245) - 0.0171134393146854*std::sin(0.342079848051071*x_12 + 8.34247970581055) - 0.0164072850637369*std::sin(0.302719920873642*x_120 - 7.48975992202759) + 0.0189612032004383*std::sin(0.482079833745956*x_120 + 2.02687978744507) - 0.00381914424786758*std::sin(0.417599856853485*x_13 - 7.16351985931396) - 0.0599100630227867*std::sin(0.23319998383522*x_14 + 8.24967956542969) + 0.00673620711437603*std::sin(0.351519852876663*x_14 - 1.0487197637558) - 0.0258184367229707*std::sin(0.254239976406097*x_15 - 1.0914398431778) - 0.0399292517950338*std::sin(0.417839854955673*x_15 + 2.22183990478516) + 0.0121670352733116*std::sin(0.313599914312363*x_16 - 4.26719999313354) + 0.040921246681667*std::sin(0.321199834346771*x_16 - 4.25663995742798) - 0.0203316990468023*std::sin(0.373839825391769*x_16 + 2.15111970901489) - 0.0121572960106715*std::sin(0.402399867773056*x_16 + 5.189040184021) + 0.00536508511179212*std::sin(0.237599983811378*x_18 - 4.33536005020142) - 0.0305499446543473*std::sin(0.238399982452393*x_19 - 4.33599996566772) - 0.0320095732316168*std::sin(0.254319965839386*x_19 - 4.31472015380859) + 0.0302331201702298*std::sin(0.311999946832657*x_21 - 4.27687978744507) - 0.0150697094827508*std::sin(0.333199828863144*x_21 - 4.25576019287109) + 0.0220239873543408*std::sin(0.364319831132889*x_21 + 8.36192035675049) + 0.0320834081578606*std::sin(0.222559988498688*x_23 - 4.36664009094238) + 0.0237193873829355*std::sin(0.341359853744507*x_23 - 4.26792001724243) - 0.00416683060890842*std::sin(0.477199852466583*x_23 - 7.31928014755249) + 0.0450826287406001*std::sin(0.359199821949005*x_24 + 2.12399983406067) - 0.00623440182907226*std::sin(0.382639855146408*x_24 + 5.38751983642578) + 0.0165839586893262*std::sin(0.437999874353409*x_24 + 8.44855976104736) + 0.0240742559979849*std::sin(0.319279849529266*x_26 - 4.28200006484985) + 0.01153514363076*std::sin(0.327199846506119*x_26 - 4.26272010803223) + 0.0239438599620195*std::sin(0.350639849901199*x_27 + 8.32791996002197) + 0.0136193706672322*std::sin(0.366399854421616*x_27 + 5.17136001586914) + 0.0287269644330884*std::sin(0.366799861192703*x_27 - 4.24416017532349) - 0.0119316346710405*std::sin(0.444319844245911*x_27 - 0.939439833164215) + 0.0121524750444474*std::sin(0.536719858646393*x_27 - 4.05399990081787) - 0.011984750761366*std::sin(0.311599940061569*x_28 + 5.12759971618652) + 0.0146859659254944*std::sin(0.320399850606918*x_28 - 4.2739200592041) - 0.0193150560264809*std::sin(0.333199828863144*x_28 - 4.27544021606445) + 0.0237797089404883*std::sin(0.348239839076996*x_28 - 4.23992013931274) + 0.0280224676594134*std::sin(0.342559844255447*x_3 - 4.24079990386963) + 0.0197011560955445*std::sin(0.376959830522537*x_3 - 1.01671981811523) - 0.00663927323015795*std::sin(0.296799927949905*x_30 - 4.29607963562012) - 0.0221257482360152*std::sin(0.295999944210052*x_33 - 1.16031992435455) + 0.0293851502138765*std::sin(0.352079838514328*x_34 + 1.99303984642029) + 0.011267498901323*std::sin(0.356959849596024*x_34 + 1.98511981964111) + 0.0454946432312892*std::sin(0.360879838466644*x_34 + 1.99647974967957) - 0.0173512641385006*std::sin(0.307439923286438*x_35 - 1.14431989192963) - 0.0372265204432708*std::sin(0.312399834394455*x_35 - 7.41991996765137) - 0.0284727489007487*std::sin(0.316639840602875*x_35 + 1.94799983501434) - 0.0190739736252888*std::sin(0.331839829683304*x_35 + 1.95959985256195) + 0.00615640851353738*std::sin(0.333759844303131*x_35 + 1.97559976577759) + 0.0234059925297976*std::sin(0.345039844512939*x_36 - 7.4507999420166) + 0.0209197447342738*std::sin(0.358079850673676*x_36 + 5.17239999771118) - 0.00677153005283459*std::sin(0.361599832773209*x_36 - 4.23776006698608) - 0.00932166952932908*std::sin(0.305039942264557*x_37 + 5.12063980102539) - 0.0194487217304717*std::sin(0.369439840316772*x_37 + 5.18287992477417) + 0.0183598843659825*std::sin(0.385359823703766*x_37 + 5.19280004501343) + 0.0300887398569618*std::sin(0.389999836683273*x_37 + 5.19632005691528) + 0.0419193936950769*std::sin(0.218799993395805*x_38 + 5.01575994491577) - 0.0189161019587108*std::sin(0.262399971485138*x_38 - 7.52008008956909) - 0.00750849702243123*std::sin(0.320239841938019*x_38 + 5.11552000045776) + 0.044780594890552*std::sin(0.344159841537476*x_38 + 5.13088035583496) + 0.0174243079907999*std::sin(0.367359846830368*x_38 + 5.17296028137207) - 0.0263035861564231*std::sin(0.352319836616516*x_39 - 7.42647981643677) + 0.0497311222223079*std::sin(0.2291199862957*x_40 + 5.04504013061523) + 0.00863983394765942*std::sin(0.309679925441742*x_40 - 7.48591995239258) - 0.0291317936184305*std::sin(0.317279845476151*x_40 - 7.46495962142944) - 0.0308407625496152*std::sin(0.333999842405319*x_41 + 5.14592027664185) - 0.00565457682311102*std::sin(0.341359823942184*x_41 + 1.95199990272522) + 0.0117032973173616*std::sin(0.317679852247238*x_42 + 8.32288074493408) - 0.0254818858400593*std::sin(0.355359852313995*x_43 + 5.16279983520508) + 0.0409216473700972*std::sin(0.360879838466644*x_43 + 5.16096019744873) + 0.0157377118398297*std::sin(0.364639848470688*x_43 - 4.23912000656128) - 0.0257862161830143*std::sin(0.269999951124191*x_44 - 4.30319976806641) + 0.0320053607417275*std::sin(0.329999834299088*x_44 + 5.11872005462646) + 0.0270091048428741*std::sin(0.328879833221436*x_45 - 7.44984006881714) + 0.0105993796440615*std::sin(0.341919839382172*x_45 + 5.13479995727539) + 0.0262033243527307*std::sin(0.351679861545563*x_45 + 5.14408016204834) - 0.00663357490267359*std::sin(0.35471984744072*x_45 + 8.35632038116455) + 0.0435121416244774*std::sin(0.246319979429245*x_46 - 7.53096008300781) + 0.00462244509775805*std::sin(0.29479992389679*x_46 + 5.11055994033813) + 0.00566671118832929*std::sin(0.347519844770432*x_46 - 4.24232006072998) - 0.0111529203468094*std::sin(0.29215994477272*x_47 - 7.47575998306274) - 0.0294236859518198*std::sin(0.324559837579727*x_47 - 4.27048015594482) + 0.0270595763414986*std::sin(0.336879849433899*x_47 - 4.26936006546021) + 0.0281715455319957*std::sin(0.300879925489426*x_48 + 5.12215948104858) + 0.0215292324188749*std::sin(0.337039858102798*x_49 + 5.13264036178589) - 0.0125821880822321*std::sin(0.35455983877182*x_49 - 7.43215990066528) - 0.00574397602024832*std::sin(0.433759868144989*x_49 - 4.17463970184326) + 0.0543475668647606*std::sin(0.246479973196983*x_50 - 7.53216028213501) - 0.0290985496894294*std::sin(0.249039962887764*x_50 + 5.05631971359253) + 0.0145806590456557*std::sin(0.31879985332489*x_50 + 5.11704015731812) - 0.00878588870155485*std::sin(0.366719841957092*x_50 + 5.16960000991821) - 0.00886498952004609*std::sin(0.22647999227047*x_51 - 7.58319997787476) - 0.0137998693632031*std::sin(0.300319939851761*x_51 - 4.28999948501587) + 0.0138234573476091*std::sin(0.338239848613739*x_51 - 4.25888013839722) - 0.00512013597354327*std::sin(0.449919849634171*x_51 - 4.16607999801636) - 0.0335261161749821*std::sin(0.281759947538376*x_52 + 5.10095977783203) + 0.026225870022199*std::sin(0.236559987068176*x_53 - 4.34311962127686) - 0.0244845468496342*std::sin(0.290879935026169*x_53 + 5.103919506073) + 0.0139660556212796*std::sin(0.305999934673309*x_53 + 5.12415981292725) - 0.0283733207782592*std::sin(0.26215997338295*x_54 - 7.52416038513184) - 0.00960371856815454*std::sin(0.324559837579727*x_54 - 4.27511978149414) - 0.00755697418717148*std::sin(0.350879848003387*x_54 + 2.13367986679077) - 0.0341469677326976*std::sin(0.239439979195595*x_55 + 5.03903961181641) - 0.00756026551905875*std::sin(0.378319829702377*x_55 - 1.00887978076935) + 0.0441156371678539*std::sin(0.22503998875618*x_56 + 5.03327989578247) - 0.0158259423846219*std::sin(0.300399929285049*x_56 + 5.12975978851318) + 0.00780213107274262*std::sin(0.318239837884903*x_56 + 5.1159200668335) + 0.0118567965425102*std::sin(0.254079967737198*x_57 - 7.52976036071777) + 0.0180033633288985*std::sin(0.275119960308075*x_57 + 5.07976007461548) + 0.0224943336707377*std::sin(0.318639844655991*x_57 - 4.29200029373169) - 0.0601226253849308*std::sin(0.213919997215271*x_58 + 5.01063966751099) - 0.0273142987674213*std::sin(0.286479920148849*x_58 + 5.09591960906982) + 0.00565878037629593*std::sin(0.280559957027435*x_59 + 1.87903988361359) + 0.0151032375296402*std::sin(0.367759823799133*x_59 - 4.2294397354126) - 0.0271544651509629*std::sin(0.376079827547073*x_59 - 7.42407989501953) - 0.0282325316672143*std::sin(0.245839968323708*x_60 - 7.53416013717651) - 0.0273307705879345*std::sin(0.253439962863922*x_60 - 7.54631996154785) + 0.0494253838841327*std::sin(0.281599938869476*x_60 + 5.08191967010498) - 0.00936914417133935*std::sin(0.313439846038818*x_60 + 8.30096054077148) + 0.00791310640781793*std::sin(0.270399957895279*x_63 + 8.28127956390381) + 0.0403398191320512*std::sin(0.155440032482147*x_64 - 4.47199964523315) - 0.0108890107426252*std::sin(0.289519935846329*x_65 - 4.28743982315063) - 0.0507300887787253*std::sin(0.292959928512573*x_65 + 5.12455987930298) - 0.0185283206328448*std::sin(0.295599937438965*x_65 - 4.2902398109436) - 0.0974324004102761*std::sin(0.162640020251274*x_66 + 4.94399976730347) + 0.0256707028619603*std::sin(0.230159983038902*x_66 + 5.02184009552002) - 0.0105440756566061*std::sin(0.262159943580627*x_66 - 7.51416015625) - 0.101681311142959*std::sin(0.20168000459671*x_67 + 4.99440002441406) - 0.0217100638537356*std::sin(0.183040007948875*x_68 - 4.43607997894287) - 0.0589992358567437*std::sin(0.196959987282753*x_68 + 4.9846396446228) + 0.0196561563886664*std::sin(0.196959987282753*x_68 + 4.98943948745728) - 0.00756804444959095*std::sin(0.353599846363068*x_68 + 8.35048007965088) - 0.0544375649704323*std::sin(0.156880035996437*x_69 - 4.47191953659058) + 0.0842923813940884*std::sin(0.174560010433197*x_69 - 4.44608020782471) - 0.0205291416740247*std::sin(0.238479986786842*x_69 + 5.03991985321045) + 0.0302158949230399*std::sin(0.298639923334122*x_7 - 1.02047991752625) - 0.0227849814316827*std::sin(0.242239981889725*x_70 - 7.54864025115967) - 0.0414946185951503*std::sin(0.274159938097*x_70 + 1.88463997840881) + 0.00212238295107641*std::sin(0.332239836454391*x_70 - 4.28344011306763) - 0.160959120757204*std::sin(0.128320053219795*x_71 - 4.51495981216431) - 0.129184061313787*std::sin(0.138400033116341*x_73 + 4.90935945510864) + 0.0301160391286242*std::sin(0.15776002407074*x_73 + 4.92848014831543) + 0.0164148945061325*std::sin(0.275279968976974*x_73 + 5.07599973678589) + 0.00364708922932579*std::sin(0.470879852771759*x_73 + 2.04903984069824) - 0.0818261352019053*std::sin(0.195040002465248*x_74 + 4.98744010925293) + 0.0237584864344173*std::sin(0.274639964103699*x_74 - 4.31271982192993) + 0.0122827239708975*std::sin(0.305599927902222*x_74 + 5.12239980697632) + 0.0302640864173903*std::sin(0.312799841165543*x_74 + 5.11303997039795) + 0.00684382152400536*std::sin(0.326879858970642*x_74 - 4.27383995056152) + 0.0783630021415944*std::sin(0.19055999815464*x_75 + 4.97583961486816) - 0.0153329077716819*std::sin(0.202880010008812*x_75 - 4.40423965454102) + 0.03256466250431*std::sin(0.246879979968071*x_75 + 5.0577597618103) + 0.0489231834922267*std::sin(0.285679936408997*x_75 - 7.48791980743408) + 0.0658911074636506*std::sin(0.191040009260178*x_76 + 4.97191953659058) + 0.0257946588548852*std::sin(0.178640007972717*x_77 - 7.62040042877197) - 0.0108484880176842*std::sin(0.227039992809296*x_77 - 7.55208015441895) - 0.0103566794917919*std::sin(0.321919828653336*x_77 - 4.29168033599854) - 0.0045984108609192*std::sin(0.332159847021103*x_77 - 1.0759197473526) - 0.0607629327017919*std::sin(0.221759989857674*x_78 + 5.01408004760742) + 0.00655175239890965*std::sin(0.377519845962524*x_78 + 5.1831202507019) - 0.0123623527253643*std::sin(0.286319941282272*x_79 + 5.09559965133667) + 0.00535943205243701*std::sin(0.487999856472015*x_79 - 7.32823991775513) + 0.0311157282409312*std::sin(0.202159985899925*x_8 - 4.39463996887207) - 0.0509292591748865*std::sin(0.273039966821671*x_8 - 4.31079959869385) + 0.0192744854789192*std::sin(0.169440016150475*x_80 - 7.63960027694702) + 0.0340864460617836*std::sin(0.177920013666153*x_80 - 7.6255202293396) + 0.0179643871937129*std::sin(0.249199971556664*x_80 + 5.05807971954346) + 0.0096317014173259*std::sin(0.313839852809906*x_80 - 4.29152011871338) + 0.0466590016605113*std::sin(0.193200007081032*x_81 - 7.60736036300659) + 0.0131379459957611*std::sin(0.360079854726791*x_81 - 4.23920011520386) + 0.00438872233786806*std::sin(0.36831983923912*x_81 - 7.42639970779419) + 0.0667044664693033*std::sin(0.193039998412132*x_82 + 4.98015975952148) + 0.00607574141319535*std::sin(0.209600001573563*x_82 + 8.20239925384521) - 0.0549166693964044*std::sin(0.155760034918785*x_83 + 4.93103981018066) + 0.0316725399765033*std::sin(0.249119967222214*x_84 + 5.05751991271973) + 0.00794138926639542*std::sin(0.302159935235977*x_84 + 5.14359951019287) + 0.0407489228510219*std::sin(0.322719842195511*x_84 + 5.12712001800537) - 0.00794767963218885*std::sin(0.390079826116562*x_84 + 5.18688011169434) + 0.0623906706898929*std::sin(0.164800018072128*x_85 - 7.63064002990723) - 0.0213675488054973*std::sin(0.238879978656769*x_85 + 5.03191947937012) + 0.00696547961650528*std::sin(0.346639841794968*x_85 - 4.24584007263184) - 0.0120701673256847*std::sin(0.391279846429825*x_86 - 4.19704008102417) - 0.143302227600565*std::sin(0.152880027890205*x_87 - 7.64616012573242) + 0.0244106636493733*std::sin(0.259839981794357*x_87 + 5.06343984603882) + 0.00911547396454965*std::sin(0.345679849386215*x_88 - 4.25648021697998) + 0.00702948174819949*std::sin(0.572799861431122*x_88 - 0.833039879798889) - 0.0503406897819187*std::sin(0.180400013923645*x_89 + 4.9684796333313) - 0.00799487009588435*std::sin(0.341119825839996*x_89 - 4.27016019821167) - 0.0823524545633267*std::sin(0.178000003099442*x_9 - 4.42439985275269) - 0.0756723793327526*std::sin(0.240079984068871*x_9 - 4.34311962127686) + 0.0146816283069488*std::sin(0.400879859924316*x_9 - 0.971039831638336) + 0.00464203241238496*std::sin(0.627359867095947*x_9 - 6.96623992919922) + 0.0165613359058024*std::sin(0.374399840831757*x_92 + 2.0020797252655) - 0.0231184040622349*std::sin(0.335999846458435*x_93 + 1.99351978302002) + 0.0291381802380166*std::sin(0.340079843997955*x_93 - 7.4270396232605) + 0.0145306775491041*std::sin(0.358159840106964*x_93 - 7.40423965454102) + 0.0155700034468668*std::sin(0.361279845237732*x_93 + 2.00159978866577) - 0.0366432251270909*std::sin(0.36151984333992*x_93 - 7.41088008880615) - 0.00393462627797848*std::sin(0.380799859762192*x_94 + 1.97039985656738) + 0.0056255349365967*std::sin(0.384719848632813*x_94 + 2.0019998550415) + 0.016103884620013*std::sin(0.396719843149185*x_94 - 7.39343976974487) - 0.00386447341958898*std::sin(0.411759853363037*x_94 - 4.18368005752563) - 0.00951926639713242*std::sin(0.353599846363068*x_95 + 1.95167982578278) + 0.00891977142000249*std::sin(0.357599824666977*x_95 - 7.42639970779419) + 0.00702022050304424*std::sin(0.358639866113663*x_95 - 7.41207981109619) + 0.00944039429255334*std::sin(0.364079833030701*x_95 + 5.16887998580933) + 0.00943013001776285*std::sin(0.374639838933945*x_95 - 7.41559982299805) - 0.0123238460702289*std::sin(0.383999854326248*x_96 - 7.40655994415283) - 0.0273532003876236*std::sin(0.393039852380753*x_96 + 5.19248008728027) + 0.0158093243988129*std::sin(0.395359843969345*x_96 - 7.38895988464355) + 0.00273742297829983*std::sin(0.414799869060516*x_96 + 8.39535999298096) - 0.0152917130560285*std::sin(0.415759861469269*x_96 - 7.37639951705933) + 0.0211150087807262*std::sin(0.33519983291626*x_97 - 7.44375991821289) - 0.0147574521552305*std::sin(0.343839854001999*x_98 + 1.95423984527588) + 0.00787658077612132*std::sin(0.362719833850861*x_98 - 7.41815996170044) - 0.00509977411749605*std::sin(0.410319864749908*x_98 - 7.4031195640564) - 0.0081842733808186*std::sin(0.41839987039566*x_98 + 2.01895976066589) - 0.00833801438440579*std::sin(0.310559868812561*x_99 - 7.46631956100464) + 0.00841668203195161*std::sin(0.389679849147797*x_99 - 7.41063976287842) + 0.00748963510264226*std::sin(0.397759854793549*x_99 + 1.99927973747253) - 0.0181793592936384*std::sin(0.409279853105545*x_99 - 7.38895988464355) - 0.0825397163241523);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00255265916960387*x_1 + 0.00398407451854686*x_10 + 0.00511980922242501*x_100 - 0.00222840003251554*x_101 - 5.71695862240565e-5*x_102 - 0.00118079941074743*x_103 - 0.00165049769764554*x_105 + 0.000149790110513225*x_106 - 0.000185443624369562*x_107 + 4.95703761952872e-6*x_108 - 0.00263333180991569*x_109 - 0.000451642832094035*x_11 + 0.00453895914768243*x_110 + 0.001786833369743*x_112 + 0.000999716920906478*x_113 - 0.000900422459257665*x_116 + 1.80134238959454e-5*x_118 - 0.00181384282548829*x_119 + 0.000538557896971796*x_12 - 0.00133709131664123*x_120 + 0.000958877643907042*x_13 + 0.00197985681250031*x_14 - 0.00110848814452684*x_15 + 9.01786241436178e-5*x_16 + 0.000589030149941212*x_17 - 0.00102823999951001*x_18 + 0.00016868157791456*x_19 + 0.00545246104769823*x_2 + 0.000139506873198153*x_20 - 0.000560107490910015*x_21 - 0.00145066648522458*x_22 + 0.000159479371021861*x_23 - 0.00137528092469152*x_24 - 0.00892499793301701*x_25 - 0.000682741387250902*x_26 + 0.000144759086191902*x_28 - 0.00166657659780506*x_29 + 0.00416616650918794*x_3 + 0.002000565301335*x_30 + 0.0028894790356908*x_31 + 0.00697670859376595*x_32 - 0.00397597017299039*x_33 + 0.000421361578632609*x_34 + 0.000193285381767768*x_36 + 0.000969762201170023*x_37 + 0.00214903155541295*x_39 + 0.00849981200775815*x_4 + 2.392407751889e-5*x_40 + 0.000950334703513835*x_41 + 0.00255942468389908*x_42 - 0.000235531578745707*x_43 + 8.42572921409936e-5*x_44 + 5.29763187449206e-5*x_45 + 1.54887009396415e-5*x_46 - 2.96104273234193e-5*x_47 - 0.00153699259290202*x_48 - 0.000246943549222603*x_49 + 0.00271275933191146*x_5 - 0.00134240875950421*x_51 - 0.00668541101429149*x_52 + 0.000410076582153789*x_53 + 0.000676259696312709*x_54 - 0.000579419418803325*x_55 - 0.000442166512592465*x_57 + 0.00039313680693284*x_58 + 0.0025088173437953*x_59 + 0.0008688972667821*x_6 - 0.00164870930608088*x_61 + 0.00254794481704077*x_62 + 0.00227607561161091*x_63 + 0.00105138085895221*x_64 - 0.00040908398521422*x_65 + 1.44047417264597e-5*x_67 + 0.000163015341604279*x_69 - 0.000344692652392867*x_70 - 0.000240472408061052*x_71 + 0.000649470206340963*x_72 - 2.65774566247658e-5*x_73 + 0.00246771916298432*x_76 + 0.000474508944027702*x_77 + 0.000502144981395618*x_78 + 8.59790868163003e-5*x_79 + 0.00247398661095046*x_8 + 0.000271948584929238*x_80 + 5.34470229035184e-5*x_81 - 0.00340790974823918*x_82 - 0.000445590815753178*x_83 + 0.00113546677836185*x_86 + 0.00103895105774429*x_87 + 0.000975190132328998*x_88 - 0.00136156400853646*x_89 + 0.00161587541338478*x_9 + 0.000550322589420408*x_90 + 0.0100896800843105*x_91 - 0.00124204365176105*x_92 + 0.0010203790060875*x_94 + 0.00267664519596913*x_97 - 0.000647626428952277*x_98 + 3.51834967205502e-5*x_99 + 2.86171321487932e-5*std::pow(-3.28623986244202*x_14 - 4.83031988143921, 2) + 5.55307461130645e-5*std::pow(-5.59087991714478*x_17 - 8.77711963653564, 2) + 6.00914828408522e-5*std::pow(-6.36255979537964*x_23 - 8.93599987030029, 2) + 2.85097562388323e-5*std::pow(-3.57223987579346*x_47 - 6.35407972335815, 2) + 0.000105245714109125*std::pow(-3.41503977775574*x_5 - 5.42375993728638, 2) - 8.57845864143698e-6*std::pow(-3.721519947052*x_56 - 5.28943967819214, 2) - 1.75985886930119e-5*std::pow(-5.90503978729248*x_6 - 9.16919994354248, 2) + 6.77338746027475e-6*std::pow(-5.1267204284668*x_66 - 7.49520015716553, 2) + 5.91009239354852e-6*std::pow(-6.21640014648438*x_67 - 8.61551952362061, 2) - 5.90964499679282e-6*std::pow(-5.79999971389771*x_67 - 10.0, 2) + 3.79062293352121e-5*std::pow(-3.71591997146606*x_68 - 4.97343969345093, 2) + 8.41680280498843e-5*std::pow(-5.72896003723145*x_7 - 8.99792003631592, 2) + 7.80071049022069e-6*std::pow(-5.51319980621338*x_7 - 8.79199981689453, 2) + 1.13632544476536e-5*std::pow(-5.43391990661621*x_7 - 8.85800075531006, 2) - 3.2955617270505e-5*std::pow(-6.60000038146973*x_71 - 9.96463966369629, 2) + 2.58131006612897e-5*std::pow(-7.60000038146973*x_72 - 9.99660015106201, 2) - 3.56212213036826e-5*std::pow(-2.52336001396179*x_72 - 3.5783998966217, 2) - 1.52994853228662e-5*std::pow(-6.40000009536743*x_78 - 9.99993991851807, 2) - 1.68507728061618e-5*std::pow(-7.19984006881714*x_81 - 9.79320049285889, 2) - 2.32145962338597e-5*std::pow(-4.73992013931274*x_82 - 7.30111980438232, 2) + 4.32215153855901e-5*std::pow(-5.49191999435425*x_83 - 7.52191972732544, 2) + 5.33735287833828e-5*std::pow(-4.27015972137451*x_84 - 6.41544008255005, 2) + 4.61956068436196e-5*std::pow(-3.90391993522644*x_85 - 6.36783981323242, 2) + 4.97903314236183e-5*std::pow(-3.28543996810913*x_85 - 7.1800799369812, 2) - 4.72567831844117e-6*std::pow(-6.69712018966675*x_86 - 9.7344799041748, 2) - 3.73701664365269e-5*std::pow(-4.22168016433716*x_86 - 6.42952013015747, 2) - 3.40262739802998e-5*std::pow(-3.91824007034302*x_87 - 5.3600001335144, 2) - 1.05937155176244e-5*std::pow(-5.10663986206055*x_89 - 7.55287981033325, 2) + 6.38042975644019e-5*std::pow(-4.09903955459595*x_89 - 5.94736003875732, 2) + 3.4369424397657e-5*std::pow(-6.60000038146973*x_90 - 9.96016025543213, 2) - 4.74271801467843e-5*std::pow(-4.90768003463745*x_90 - 7.15335988998413, 2) - 0.000569427289743605*std::exp(1.29391980171204*x_17) + 0.00255025444906638*std::exp(0.730479836463928*x_22) + 0.0262568129860306*std::sin(0.225279986858368*x_1 - 4.18847990036011) + 0.0448985060510579*std::sin(0.281839966773987*x_1 + 2.15455985069275) + 0.00546314730225242*std::sin(0.341919839382172*x_1 - 4.35288000106812) + 0.0190404845294813*std::sin(0.270319938659668*x_10 - 7.50264024734497) - 0.0346722454512642*std::sin(0.36847984790802*x_10 + 5.17600011825562) + 0.0285453438285694*std::sin(0.316399842500687*x_101 - 4.24911975860596) - 0.0092469341580682*std::sin(0.397359818220139*x_102 + 1.99735975265503) - 0.0101656442553125*std::sin(0.300079941749573*x_103 + 5.10311985015869) - 0.00434496797308128*std::sin(0.416559875011444*x_103 + 5.21712017059326) - 0.0180030862511941*std::sin(0.394079834222794*x_104 - 7.39215993881226) - 0.0205793902952112*std::sin(0.398559838533401*x_104 + 5.20975971221924) - 0.0178806064771097*std::sin(0.40055987238884*x_104 + 5.20408010482788) + 0.0023618211645574*std::sin(0.428879857063293*x_104 + 5.22983980178833) + 0.0467742669435928*std::sin(0.162960022687912*x_105 - 7.63632011413574) - 0.00432352563144464*std::sin(0.37391984462738*x_105 - 7.43215990066528) + 0.0216151067715868*std::sin(0.403519839048386*x_105 + 2.01263976097107) + 0.0110084915616846*std::sin(0.396559834480286*x_106 - 7.3874397277832) - 0.0200106940794*std::sin(0.40055987238884*x_106 - 7.38775968551636) - 0.00178634184874485*std::sin(0.442479848861694*x_106 + 5.22079992294312) - 0.0269934679469305*std::sin(0.35455983877182*x_107 + 5.15592002868652) + 0.0102154760875931*std::sin(0.392639845609665*x_107 - 7.40319967269897) + 0.00358888612649003*std::sin(0.570399820804596*x_107 + 2.1801598072052) + 0.191606279713795*std::sin(0.127280056476593*x_108 + 1.72391986846924) - 0.00504495723551019*std::sin(0.296719938516617*x_108 - 7.49255990982056) - 0.035366721445919*std::sin(0.388879835605621*x_108 + 5.17456007003784) - 0.0155874532182995*std::sin(0.3504798412323*x_109 + 5.14728021621704) - 0.0164347435223918*std::sin(0.432159870862961*x_109 + 5.23464012145996) - 0.0218342151073807*std::sin(0.262559980154037*x_11 + 8.27199935913086) + 0.0173175084425569*std::sin(0.298159927129745*x_11 - 4.2611198425293) + 0.0124615809741944*std::sin(0.300399929285049*x_11 - 1.06567990779877) - 0.00352870481682157*std::sin(0.36959981918335*x_110 - 7.41879987716675) + 0.00899382281709102*std::sin(0.400079846382141*x_110 - 4.20775985717773) + 0.005104579445661*std::sin(0.253279983997345*x_111 - 4.3439998626709) + 0.0163056090836036*std::sin(0.355199843645096*x_111 - 4.24304008483887) - 0.0337366013134152*std::sin(0.388959854841232*x_111 + 5.20007991790771) - 0.00241477591723648*std::sin(0.762639880180359*x_111 - 1.20167982578278) - 0.00682687504203079*std::sin(0.350879848003387*x_112 - 4.24528026580811) - 0.0147846589410248*std::sin(0.372479856014252*x_112 - 7.41504001617432) + 0.015300657389294*std::sin(0.377519845962524*x_113 - 7.42136001586914) + 0.00452041445103088*std::sin(0.181760013103485*x_114 - 1.20503985881805) - 0.0122174527243454*std::sin(0.321759849786758*x_114 + 5.13535976409912) - 0.0307627362702371*std::sin(0.32423985004425*x_114 + 5.132080078125) + 0.0168371824986669*std::sin(0.389039844274521*x_114 - 7.40039968490601) + 0.0642288289494877*std::sin(0.189999997615814*x_115 - 7.61768007278442) + 0.00904495289107483*std::sin(0.33231982588768*x_115 + 5.14056015014648) - 0.00456250853979859*std::sin(0.3642398416996*x_115 - 7.42384004592896) - 0.00567668678887358*std::sin(0.491039872169495*x_115 - 4.1386399269104) + 0.0575414842614477*std::sin(0.260159969329834*x_116 - 4.30823993682861) + 0.0184197403513928*std::sin(0.453839868307114*x_116 + 8.24575996398926) + 0.0362426612815786*std::sin(0.240879982709885*x_117 - 7.5633602142334) - 0.00857612675072991*std::sin(0.355279833078384*x_117 - 7.42416000366211) + 0.00277896647547285*std::sin(0.363599836826324*x_117 - 7.42176008224487) + 0.0318104171247658*std::sin(0.413519859313965*x_117 + 5.20032024383545) + 0.0159228405230292*std::sin(0.345439821481705*x_118 + 5.1592001914978) - 0.000922834736003403*std::sin(0.450399875640869*x_118 + 5.2403998374939) + 0.0207511745449905*std::sin(0.299039930105209*x_119 + 5.09831953048706) - 0.00256392751690711*std::sin(0.367199838161469*x_119 + 8.1812801361084) - 0.0242468636293327*std::sin(0.369119822978973*x_119 + 1.97495973110199) + 0.0473978561434426*std::sin(0.249199971556664*x_12 + 5.06543970108032) + 0.0242380751679424*std::sin(0.283599942922592*x_12 + 8.31063938140869) + 0.0273277035823065*std::sin(0.318879842758179*x_12 - 4.26143980026245) - 0.00504147538774033*std::sin(0.302719920873642*x_120 - 7.48975992202759) + 0.0206808577170986*std::sin(0.482079833745956*x_120 + 2.02687978744507) + 0.00507040489376253*std::sin(0.417599856853485*x_13 - 7.16351985931396) - 0.060569612632547*std::sin(0.23319998383522*x_14 + 8.24967956542969) - 0.00894318080213934*std::sin(0.351519852876663*x_14 - 1.0487197637558) - 0.00793324506663639*std::sin(0.254239976406097*x_15 - 1.0914398431778) - 0.0435505683048749*std::sin(0.417839854955673*x_15 + 2.22183990478516) - 0.0161533032502833*std::sin(0.313599914312363*x_16 - 4.26719999313354) + 0.0413717484991919*std::sin(0.321199834346771*x_16 - 4.25663995742798) - 0.0221756483852285*std::sin(0.373839825391769*x_16 + 2.15111970901489) - 0.007122840102589*std::sin(0.237599983811378*x_18 - 4.33536005020142) - 0.0349126277794868*std::sin(0.254319965839386*x_19 - 4.31472015380859) + 0.0305659564518829*std::sin(0.311999946832657*x_21 - 4.27687978744507) + 0.00676732254943369*std::sin(0.364319831132889*x_21 + 8.36192035675049) - 0.0425948482629394*std::sin(0.222559988498688*x_23 - 4.36664009094238) + 0.00728826903651737*std::sin(0.341359853744507*x_23 - 4.26792001724243) + 0.0491713221276792*std::sin(0.359199821949005*x_24 + 2.12399983406067) + 0.00509576198857715*std::sin(0.437999874353409*x_24 + 8.44855976104736) + 0.00739730970849344*std::sin(0.319279849529266*x_26 - 4.28200006484985) - 0.0153143858727819*std::sin(0.327199846506119*x_26 - 4.26272010803223) - 0.0180814651658307*std::sin(0.366399854421616*x_27 + 5.17136001586914) + 0.00882694995493186*std::sin(0.366799861192703*x_27 - 4.24416017532349) - 0.013013754262097*std::sin(0.444319844245911*x_27 - 0.939439833164215) + 0.0122862615866204*std::sin(0.536719858646393*x_27 - 4.05399990081787) + 0.0148476436571874*std::sin(0.320399850606918*x_28 - 4.2739200592041) - 0.00593494774985949*std::sin(0.333199828863144*x_28 - 4.27544021606445) - 0.0315706202119552*std::sin(0.348239839076996*x_28 - 4.23992013931274) + 0.0283309668776876*std::sin(0.342559844255447*x_3 - 4.24079990386963) + 0.00881448861116352*std::sin(0.296799927949905*x_30 - 4.29607963562012) - 0.00679859067078363*std::sin(0.295999944210052*x_33 - 1.16031992435455) + 0.0297086511981592*std::sin(0.352079838514328*x_34 + 1.99303984642029) - 0.0149590530919672*std::sin(0.356959849596024*x_34 + 1.98511981964111) + 0.049620703581443*std::sin(0.360879838466644*x_34 + 1.99647974967957) - 0.0376363470365387*std::sin(0.312399834394455*x_35 - 7.41991996765137) - 0.0310550370989879*std::sin(0.316639840602875*x_35 + 1.94799983501434) - 0.00586087022958079*std::sin(0.331839829683304*x_35 + 1.95959985256195) - 0.00817342363344105*std::sin(0.333759844303131*x_35 + 1.97559976577759) + 0.0236636689944879*std::sin(0.345039844512939*x_36 - 7.4507999420166) + 0.00642802132016048*std::sin(0.358079850673676*x_36 + 5.17239999771118) + 0.00899007654327883*std::sin(0.361599832773209*x_36 - 4.23776006698608) - 0.0196628326190346*std::sin(0.369439840316772*x_37 + 5.18287992477417) - 0.0243751064365191*std::sin(0.385359823703766*x_37 + 5.19280004501343) + 0.00924538342862466*std::sin(0.389999836683273*x_37 + 5.19632005691528) + 0.0457212027860599*std::sin(0.218799993395805*x_38 + 5.01575994491577) - 0.00581236091689545*std::sin(0.262399971485138*x_38 - 7.52008008956909) + 0.045273584254854*std::sin(0.344159841537476*x_38 + 5.13088035583496) - 0.0231330085414571*std::sin(0.367359846830368*x_38 + 5.17296028137207) - 0.0265931622160939*std::sin(0.352319836616516*x_39 - 7.42647981643677) + 0.0502786119193592*std::sin(0.2291199862957*x_40 + 5.04504013061523) + 0.00265476646697376*std::sin(0.309679925441742*x_40 - 7.48591995239258) - 0.0317738527717859*std::sin(0.317279845476151*x_40 - 7.46495962142944) - 0.0336378137733724*std::sin(0.333999842405319*x_41 + 5.14592027664185) - 0.0277929227302113*std::sin(0.355359852313995*x_43 + 5.16279983520508) + 0.0413721535987992*std::sin(0.360879838466644*x_43 + 5.16096019744873) + 0.00483573525977246*std::sin(0.364639848470688*x_43 - 4.23912000656128) - 0.0281248538031035*std::sin(0.269999951124191*x_44 - 4.30319976806641) + 0.0323577076117252*std::sin(0.329999834299088*x_44 + 5.11872005462646) + 0.0273064479545366*std::sin(0.328879833221436*x_45 - 7.44984006881714) - 0.0140720388993173*std::sin(0.341919839382172*x_45 + 5.13479995727539) + 0.0285797908985693*std::sin(0.351679861545563*x_45 + 5.14408016204834) + 0.0439911665925758*std::sin(0.246319979429245*x_46 - 7.53096008300781) + 0.00142034121434472*std::sin(0.29479992389679*x_46 + 5.11055994033813) - 0.00752328748956957*std::sin(0.347519844770432*x_46 - 4.24232006072998) - 0.0320922177906997*std::sin(0.324559837579727*x_47 - 4.27048015594482) + 0.0273574750936586*std::sin(0.336879849433899*x_47 - 4.26936006546021) + 0.0284816859478871*std::sin(0.300879925489426*x_48 + 5.12215948104858) + 0.0234817900376073*std::sin(0.337039858102798*x_49 + 5.13264036178589) - 0.0038661357618934*std::sin(0.35455983877182*x_49 - 7.43215990066528) + 0.0549458789797627*std::sin(0.246479973196983*x_50 - 7.53216028213501) - 0.00894112715835176*std::sin(0.249039962887764*x_50 + 5.05631971359253) + 0.0159030274586036*std::sin(0.31879985332489*x_50 + 5.11704015731812) + 0.0116643965708522*std::sin(0.366719841957092*x_50 + 5.16960000991821) - 0.00424029335007938*std::sin(0.300319939851761*x_51 - 4.28999948501587) - 0.0183524164669009*std::sin(0.338239848613739*x_51 - 4.25888013839722) - 0.00558449811658572*std::sin(0.449919849634171*x_51 - 4.16607999801636) - 0.0365667110410851*std::sin(0.281759947538376*x_52 + 5.10095977783203) + 0.0265145905053036*std::sin(0.236559987068176*x_53 - 4.34311962127686) - 0.00752338000119391*std::sin(0.290879935026169*x_53 + 5.103919506073) - 0.0185417340044788*std::sin(0.305999934673309*x_53 + 5.12415981292725) - 0.00871828567714757*std::sin(0.26215997338295*x_54 - 7.52416038513184) + 0.0127501708408834*std::sin(0.324559837579727*x_54 - 4.27511978149414) - 0.00824234128417905*std::sin(0.350879848003387*x_54 + 2.13367986679077) - 0.037243869689343*std::sin(0.239439979195595*x_55 + 5.03903961181641) - 0.00764349644757376*std::sin(0.378319829702377*x_55 - 1.00887978076935) + 0.0481166308763805*std::sin(0.22503998875618*x_56 + 5.03327989578247) + 0.0210109727487237*std::sin(0.300399929285049*x_56 + 5.12975978851318) + 0.00788802469803172*std::sin(0.318239837884903*x_56 + 5.1159200668335) + 0.00364324430972586*std::sin(0.254079967737198*x_57 - 7.52976036071777) - 0.0239017789333306*std::sin(0.275119960308075*x_57 + 5.07976007461548) + 0.024534419528541*std::sin(0.318639844655991*x_57 - 4.29200029373169) - 0.0655753460379263*std::sin(0.213919997215271*x_58 + 5.01063966751099) - 0.0276150017576031*std::sin(0.286479920148849*x_58 + 5.09591960906982) - 0.00751275831718549*std::sin(0.280559957027435*x_59 + 1.87903988361359) + 0.00464077999407508*std::sin(0.367759823799133*x_59 - 4.2294397354126) - 0.0296171938159492*std::sin(0.376079827547073*x_59 - 7.42407989501953) - 0.00867502533057362*std::sin(0.245839968323708*x_60 - 7.53416013717651) - 0.0298094889787729*std::sin(0.253439962863922*x_60 - 7.54631996154785) + 0.0499695077092176*std::sin(0.281599938869476*x_60 + 5.08191967010498) + 0.0124387431774148*std::sin(0.313439846038818*x_60 + 8.30096054077148) - 0.0105056658903277*std::sin(0.270399957895279*x_63 + 8.28127956390381) - 0.0535562950927692*std::sin(0.155440032482147*x_64 - 4.47199964523315) - 0.0553309690802928*std::sin(0.292959928512573*x_65 + 5.12455987930298) + 0.02459872723122*std::sin(0.295599937438965*x_65 - 4.2902398109436) - 0.09850503326069*std::sin(0.162640020251274*x_66 + 4.94399976730347) + 0.0279988641951713*std::sin(0.230159983038902*x_66 + 5.02184009552002) + 0.0139986157473128*std::sin(0.262159943580627*x_66 - 7.51416015625) - 0.110903127085678*std::sin(0.20168000459671*x_67 + 4.99440002441406) - 0.0181287272276791*std::sin(0.196959987282753*x_68 + 4.9846396446228) + 0.0198725509244325*std::sin(0.196959987282753*x_68 + 4.98943948745728) - 0.00825441554547818*std::sin(0.353599846363068*x_68 + 8.35048007965088) - 0.0550368678741681*std::sin(0.156880035996437*x_69 - 4.47191953659058) + 0.0919371375233329*std::sin(0.174560010433197*x_69 - 4.44608020782471) + 0.0272550743446882*std::sin(0.238479986786842*x_69 + 5.03991985321045) + 0.0305485415720255*std::sin(0.298639923334122*x_7 - 1.02047991752625) - 0.0070011536126615*std::sin(0.242239981889725*x_70 - 7.54864025115967) - 0.0452579034210099*std::sin(0.274159938097*x_70 + 1.88463997840881) - 0.0028177361741664*std::sin(0.332239836454391*x_70 - 4.28344011306763) - 0.162731118981315*std::sin(0.128320053219795*x_71 - 4.51495981216431) - 0.140900193047118*std::sin(0.138400033116341*x_73 + 4.90935945510864) + 0.00504381354523578*std::sin(0.275279968976974*x_73 + 5.07599973678589) + 0.00368724001796789*std::sin(0.470879852771759*x_73 + 2.04903984069824) - 0.0892472192699018*std::sin(0.195040002465248*x_74 + 4.98744010925293) + 0.00730028302328994*std::sin(0.274639964103699*x_74 - 4.31271982192993) - 0.016306894866709*std::sin(0.305599927902222*x_74 + 5.12239980697632) + 0.0305972636063168*std::sin(0.312799841165543*x_74 + 5.11303997039795) + 0.0792257000737011*std::sin(0.19055999815464*x_75 + 4.97583961486816) + 0.0203564059264203*std::sin(0.202880010008812*x_75 - 4.40423965454102) + 0.0100061615244562*std::sin(0.246879979968071*x_75 + 5.0577597618103) + 0.0533601895499364*std::sin(0.285679936408997*x_75 - 7.48791980743408) + 0.0718669909220906*std::sin(0.191040009260178*x_76 + 4.97191953659058) + 0.00792593882820265*std::sin(0.178640007972717*x_77 - 7.62040042877197) + 0.0144027622851645*std::sin(0.227039992809296*x_77 - 7.55208015441895) - 0.0112959611648691*std::sin(0.321919828653336*x_77 - 4.29168033599854) - 0.0614318715499469*std::sin(0.221759989857674*x_78 + 5.01408004760742) + 0.00541843401538566*std::sin(0.487999856472015*x_79 - 7.32823991775513) - 0.0413101287896872*std::sin(0.202159985899925*x_8 - 4.39463996887207) - 0.0555482029014235*std::sin(0.273039966821671*x_8 - 4.31079959869385) + 0.010473760784216*std::sin(0.177920013666153*x_80 - 7.6255202293396) + 0.0195936371548119*std::sin(0.249199971556664*x_80 + 5.05807971954346) - 0.0127873216700146*std::sin(0.313839852809906*x_80 - 4.29152011871338) + 0.0508906615451808*std::sin(0.193200007081032*x_81 - 7.60736036300659) - 0.0174423120331444*std::sin(0.360079854726791*x_81 - 4.23920011520386) + 0.0204963176205551*std::sin(0.193039998412132*x_82 + 4.98015975952148) + 0.0729089374961788*std::sin(0.155760034918785*x_83 + 4.93103981018066) + 0.00973203855107489*std::sin(0.249119967222214*x_84 + 5.05751991271973) - 0.0105432150205081*std::sin(0.302159935235977*x_84 + 5.14359951019287) + 0.0444445780522796*std::sin(0.322719842195511*x_84 + 5.12712001800537) + 0.0191708152498002*std::sin(0.164800018072128*x_85 - 7.63064002990723) + 0.0283681675787963*std::sin(0.238879978656769*x_85 + 5.03191947937012) - 0.0122030477425584*std::sin(0.391279846429825*x_86 - 4.19704008102417) - 0.144879841168686*std::sin(0.152880027890205*x_87 - 7.64616012573242) + 0.00750067787014445*std::sin(0.259839981794357*x_87 + 5.06343984603882) - 0.01210196337167*std::sin(0.345679849386215*x_88 - 4.25648021697998) + 0.00766700880332821*std::sin(0.572799861431122*x_88 - 0.833039879798889) - 0.00245658807413943*std::sin(0.341119825839996*x_89 - 4.27016019821167) - 0.0253044834162499*std::sin(0.178000003099442*x_9 - 4.42439985275269) - 0.0765054562106649*std::sin(0.240079984068871*x_9 - 4.34311962127686) + 0.00506303375497154*std::sin(0.627359867095947*x_9 - 6.96623992919922) - 0.0071036045653398*std::sin(0.335999846458435*x_93 + 1.99351978302002) + 0.0294589623309648*std::sin(0.340079843997955*x_93 - 7.4270396232605) - 0.0192913421889734*std::sin(0.358159840106964*x_93 - 7.40423965454102) - 0.0399665209606246*std::sin(0.36151984333992*x_93 - 7.41088008880615) - 0.00429147060788576*std::sin(0.380799859762192*x_94 + 1.97039985656738) - 0.0213799767923121*std::sin(0.396719843149185*x_94 - 7.39343976974487) - 0.00118743884535137*std::sin(0.411759853363037*x_94 - 4.18368005752563) - 0.0103826002943581*std::sin(0.353599846363068*x_95 + 1.95167982578278) + 0.00901796914276196*std::sin(0.357599824666977*x_95 - 7.42639970779419) - 0.0125333368716661*std::sin(0.364079833030701*x_95 + 5.16887998580933) + 0.00289760116942312*std::sin(0.374639838933945*x_95 - 7.41559982299805) - 0.00378675487163191*std::sin(0.383999854326248*x_96 - 7.40655994415283) - 0.0276543316455642*std::sin(0.393039852380753*x_96 + 5.19248008728027) - 0.0209889102365216*std::sin(0.395359843969345*x_96 - 7.38895988464355) - 0.0166785693196472*std::sin(0.415759861469269*x_96 - 7.37639951705933) + 0.0230299990814609*std::sin(0.33519983291626*x_97 - 7.44375991821289) - 0.0160958545226791*std::sin(0.343839854001999*x_98 + 1.95423984527588) + 0.00242024125064601*std::sin(0.362719833850861*x_98 - 7.41815996170044) + 0.00677060565514729*std::sin(0.410319864749908*x_98 - 7.4031195640564) + 0.00918001888977322*std::sin(0.389679849147797*x_99 - 7.41063976287842) - 0.00994345330060173*std::sin(0.397759854793549*x_99 + 1.99927973747253) - 0.0183794957769409*std::sin(0.409279853105545*x_99 - 7.38895988464355) + 0.367051482200623*std::sin(0.0644844259929998*x_1 - 0.0110463932860528*x_100 - 0.00444397190176924*x_101 + 0.0047533352649811*x_103 + 0.00201399105583304*x_104 + 0.00378004235238695*x_108 + 0.00139374961160309*x_109 - 0.00932262258511509*x_11 + 0.010368698569681*x_110 + 0.0102538179287507*x_113 - 0.00356209649685891*x_114 + 0.00418741255597878*x_116 - 0.0040595733570104*x_117 + 0.00677459373251463*x_119 - 0.00478245560957561*x_120 - 0.00171649128109434*x_13 + 0.0141814864425387*x_14 - 0.00703306443797206*x_15 + 0.0145335902089888*x_2 + 0.00377762606887395*x_20 + 0.0258356785502355*x_25 - 0.00910906933751139*x_26 - 0.0110348956193088*x_30 - 0.0251820224874874*x_31 - 0.00352841404433677*x_32 + 0.0189279713670644*x_33 + 0.000256070952650241*x_34 + 0.00405523680757443*x_36 + 0.0302786304115326*x_39 + 0.00317515482155426*x_40 + 0.000509655550299102*x_43 + 0.000429415385188513*x_44 + 0.00363923796187154*x_46 - 0.00822229139366087*x_48 + 0.00749939059895019*x_5 - 0.00735843741571854*x_50 - 0.00812508422575742*x_52 + 0.00197142011646829*x_53 - 0.00275655847658883*x_54 + 0.00377741923548807*x_55 + 0.000268736597553527*x_56 - 0.000923296234587207*x_57 - 7.93807614046015e-5*x_59 + 0.00570461429888699*x_60 + 0.0211193364552489*x_61 + 8.07343027507732e-5*x_62 + 0.0127157617972001*x_63 - 0.000674056860755677*x_64 + 0.00481585492219911*x_66 - 0.00511804351321949*x_69 + 0.00385372823958478*x_70 + 0.000682739272178403*x_71 + 0.000654602198933319*x_72 - 0.0201494106606936*x_76 - 0.0191500601434171*x_8 + 0.00497728718859919*x_83 - 0.00431867375213594*x_86 + 0.0264390595778824*x_91 - 0.0100783580099103*x_97 - 0.000830012867839396*std::pow(-4.67167949676514*x_17 - 6.90744018554688, 2) - 0.00272808085411913*std::pow(-1.91071999073029*x_18 - 2.75584006309509, 2) - 0.000320509577689393*std::pow(-6.07679986953735*x_22 - 9.73752021789551, 2) + 0.00099700059108962*std::pow(-4.91200017929077*x_4 - 8.39608001708984, 2) - 0.000157420494587045*std::pow(-5.77103996276855*x_58 - 7.56695985794067, 2) - 0.00160262810097157*std::pow(-2.89567995071411*x_6 - 4.63944005966187, 2) + 0.000142962173366183*std::pow(-6.9987998008728*x_67 - 9.77744007110596, 2) + 0.000680736977058099*std::pow(-5.27688026428223*x_7 - 8.52688026428223, 2) + 7.02171247128082e-5*std::pow(-6.59600019454956*x_75 - 9.96208000183105, 2) - 0.000169158843522062*std::pow(-4.28991985321045*x_87 - 6.95071983337402, 2) - 0.000146297481718703*std::pow(-4.93191957473755*x_88 - 5.71687984466553, 2) + 0.000109015391485307*std::pow(-5.74399995803833*x_90 - 7.7992000579834, 2) + 0.00485721755679189*std::exp(0.602479875087738*x_29) - 0.311832360753179*std::sin(0.34623983502388*x_10 - 1.06567978858948) + 0.0752608931232146*std::sin(0.301919937133789*x_102 + 5.10527992248535) + 0.167426148736092*std::sin(0.324799835681915*x_105 + 8.32863998413086) + 0.143872988878022*std::sin(0.386079847812653*x_106 + 1.99143981933594) + 0.103711508883784*std::sin(0.369519859552383*x_107 + 5.18247985839844) - 0.164926504409548*std::sin(0.357679843902588*x_111 - 4.2388801574707) - 0.17155181590045*std::sin(0.362399846315384*x_112 + 5.16552019119263) - 0.224482871034088*std::sin(0.230639979243279*x_115 + 1.83319985866547) - 0.0659450218804403*std::sin(0.322159856557846*x_118 + 1.92447984218597) - 0.29381453826633*std::sin(0.342079848051071*x_12 + 8.34247970581055) - 0.208724280856702*std::sin(0.402399867773056*x_16 + 5.189040184021) - 0.524501108025461*std::sin(0.238399982452393*x_19 - 4.33599996566772) - 0.258726469417674*std::sin(0.333199828863144*x_21 - 4.25576019287109) - 0.0715388291551577*std::sin(0.477199852466583*x_23 - 7.31928014755249) - 0.107036222298329*std::sin(0.382639855146408*x_24 + 5.38751983642578) + 0.41108359516123*std::sin(0.350639849901199*x_27 + 8.32791996002197) - 0.205761912987654*std::sin(0.311599940061569*x_28 + 5.12759971618652) + 0.338242125097441*std::sin(0.376959830522537*x_3 - 1.01671981811523) - 0.297897667876494*std::sin(0.307439923286438*x_35 - 1.14431989192963) - 0.160040420763399*std::sin(0.305039942264557*x_37 + 5.12063980102539) - 0.128910708429406*std::sin(0.320239841938019*x_38 + 5.11552000045776) - 0.0970814134916864*std::sin(0.341359823942184*x_41 + 1.95199990272522) + 0.200929739152049*std::sin(0.317679852247238*x_42 + 8.32288074493408) - 0.113889482484777*std::sin(0.35471984744072*x_45 + 8.35632038116455) - 0.191480513166455*std::sin(0.29215994477272*x_47 - 7.47575998306274) - 0.0986162764345044*std::sin(0.433759868144989*x_49 - 4.17463970184326) - 0.152199844500753*std::sin(0.22647999227047*x_51 - 7.58319997787476) - 0.186949543261949*std::sin(0.289519935846329*x_65 - 4.28743982315063) - 0.372732346176852*std::sin(0.183040007948875*x_68 - 4.43607997894287) + 0.517051538751438*std::sin(0.15776002407074*x_73 + 4.92848014831543) + 0.117499131768755*std::sin(0.326879858970642*x_74 - 4.27383995056152) - 0.0789484766338266*std::sin(0.332159847021103*x_77 - 1.0759197473526) + 0.112484701089224*std::sin(0.377519845962524*x_78 + 5.1831202507019) - 0.212244826483916*std::sin(0.286319941282272*x_79 + 5.09559965133667) + 0.330916769398311*std::sin(0.169440016150475*x_80 - 7.63960027694702) + 0.0753484091402545*std::sin(0.36831983923912*x_81 - 7.42639970779419) + 0.104312238184159*std::sin(0.209600001573563*x_82 + 8.20239925384521) - 0.136450878077818*std::sin(0.390079826116562*x_84 + 5.18688011169434) + 0.119587836185029*std::sin(0.346639841794968*x_85 - 4.24584007263184) - 0.86428135527326*std::sin(0.180400013923645*x_89 + 4.9684796333313) + 0.252063642070031*std::sin(0.400879859924316*x_9 - 0.971039831638336) + 0.284335671676548*std::sin(0.374399840831757*x_92 + 2.0020797252655) + 0.267315838121487*std::sin(0.361279845237732*x_93 + 2.00159978866577) + 0.0965828036962102*std::sin(0.384719848632813*x_94 + 2.0019998550415) + 0.120527662949654*std::sin(0.358639866113663*x_95 - 7.41207981109619) + 0.0469978391613324*std::sin(0.414799869060516*x_96 + 8.39535999298096) - 0.140512871797029*std::sin(0.41839987039566*x_98 + 2.01895976066589) - 0.143152396275479*std::sin(0.310559868812561*x_99 - 7.46631956100464) - 1.72097843156513) + 0.314539349579118);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000651984692914234*x_1 - 0.000941874372574632*x_10 + 0.00263510004508658*x_100 - 0.000746151821241807*x_101 - 0.00124204120011604*x_102 + 0.000691747134040121*x_103 - 2.83791605065795e-5*x_104 + 9.15781131428582e-5*x_106 + 1.34421980390983e-5*x_107 - 5.32646003215172e-5*x_108 + 0.00182707991654388*x_109 + 0.000164103235438746*x_11 + 0.000548616986564385*x_110 - 0.000854076173600854*x_112 + 0.00065641034317119*x_113 + 5.01935239143702e-5*x_114 - 7.53692687968073e-5*x_116 + 5.72034734479885e-5*x_117 + 1.92657074225614e-5*x_118 - 9.54608424625686e-5*x_119 - 3.90382895676592e-5*x_12 + 0.000352930423029031*x_120 + 0.00110177346615547*x_13 + 0.00101060598134913*x_14 + 0.000705549871426061*x_15 - 6.53675168802886e-6*x_16 - 3.08100176807635e-5*x_17 + 0.00109799102532001*x_18 - 0.000300771791507934*x_19 - 0.00518979427011887*x_2 + 0.00357864123809781*x_20 - 8.34057395108217e-5*x_21 - 0.000761208925342761*x_22 - 0.000109634578663209*x_23 + 0.00054079453179253*x_24 - 0.00460377912453328*x_25 + 0.00118024667502977*x_26 + 8.8502264457361e-5*x_28 + 0.00102509306163686*x_29 + 0.00262584425791555*x_3 + 0.00118917107311961*x_30 - 0.00239948195115071*x_31 + 0.00399136804188054*x_32 - 0.00213016461630187*x_33 - 3.41514115301705e-5*x_34 + 6.1027721027373e-5*x_36 + 0.000592889559104604*x_37 + 0.000323293768826977*x_39 + 0.00216603431303027*x_4 - 4.47411263586059e-5*x_40 - 0.000580744128013426*x_41 + 0.00132028402948527*x_42 - 7.18155953231122e-6*x_43 - 3.59541943130445e-6*x_44 - 3.8400790017589e-6*x_45 - 4.18111011811674e-5*x_46 + 2.14636242931985e-6*x_47 - 0.00240240078399374*x_48 - 1.58535866927821e-5*x_49 + 0.00172194624800872*x_5 + 0.000103687787437527*x_50 + 0.000922842984638251*x_51 + 0.00463520075910806*x_52 + 0.000222931781908958*x_53 - 0.000426054102408813*x_54 - 3.35120883853844e-5*x_55 - 3.78676906924448e-6*x_56 + 0.000316978886914713*x_57 + 1.13626691296317e-5*x_58 - 0.00172357555872106*x_59 - 0.00159492782216196*x_6 - 8.03837556017741e-5*x_60 + 0.000356194466252965*x_61 - 7.75724675436286e-5*x_62 + 0.00117318754629713*x_63 + 0.00056465769677461*x_64 + 0.000368697173792736*x_65 - 6.78602416915695e-5*x_66 - 9.90258351167109e-6*x_67 + 6.03019373765268e-5*x_69 + 0.000182657103648479*x_70 - 4.16178829512955e-6*x_71 + 0.000434412251674089*x_72 - 0.0013277792824907*x_76 - 0.000326202616784025*x_77 - 2.36556916867567e-6*x_78 - 7.36598208359967e-5*x_79 - 0.00148248746900981*x_8 - 0.000186951881837344*x_80 - 3.87419879713719e-6*x_81 + 0.00123357894505274*x_82 - 0.000704214044535141*x_83 + 0.000755051857625853*x_86 + 0.000635189981434713*x_87 - 0.000538960038253361*x_88 - 0.000832427871224431*x_89 - 7.93354029409031e-6*x_90 - 0.000299031276657275*x_91 - 0.000935022689446262*x_92 - 0.000701462651203039*x_94 + 4.88603203250141e-5*x_97 + 0.000445212758329784*x_98 - 2.55033588905216e-6*x_99 - 2.07436173102679e-6*std::pow(-3.28623986244202*x_14 - 4.83031988143921, 2) - 3.81747803113979e-5*std::pow(-5.59087991714478*x_17 - 8.77711963653564, 2) + 1.16957164882729e-5*std::pow(-4.67167949676514*x_17 - 6.90744018554688, 2) + 3.84414043000553e-5*std::pow(-1.91071999073029*x_18 - 2.75584006309509, 2) + 4.51630245467055e-6*std::pow(-6.07679986953735*x_22 - 9.73752021789551, 2) + 3.67385042688504e-5*std::pow(-6.36255979537964*x_23 - 8.93599987030029, 2) - 1.40487415362348e-5*std::pow(-4.91200017929077*x_4 - 8.39608001708984, 2) + 6.21824235373051e-7*std::pow(-3.721519947052*x_56 - 5.28943967819214, 2) + 2.21821316930477e-6*std::pow(-5.77103996276855*x_58 - 7.56695985794067, 2) + 2.25826425485364e-5*std::pow(-2.89567995071411*x_6 - 4.63944005966187, 2) - 4.90980565905629e-7*std::pow(-5.1267204284668*x_66 - 7.49520015716553, 2) - 2.01448087496606e-6*std::pow(-6.9987998008728*x_67 - 9.77744007110596, 2) - 4.28403147606338e-7*std::pow(-6.21640014648438*x_67 - 8.61551952362061, 2) + 5.14583317239962e-5*std::pow(-5.72896003723145*x_7 - 8.99792003631592, 2) - 8.23684918655502e-7*std::pow(-5.43391990661621*x_7 - 8.85800075531006, 2) - 9.59226898190208e-6*std::pow(-5.27688026428223*x_7 - 8.52688026428223, 2) - 2.01482810630852e-5*std::pow(-6.60000038146973*x_71 - 9.96463966369629, 2) - 1.77452945597809e-5*std::pow(-7.60000038146973*x_72 - 9.99660015106201, 2) + 2.58206510354012e-6*std::pow(-2.52336001396179*x_72 - 3.5783998966217, 2) - 9.89429941490509e-7*std::pow(-6.59600019454956*x_75 - 9.96208000183105, 2) - 9.3537416664182e-6*std::pow(-6.40000009536743*x_78 - 9.99993991851807, 2) + 1.15841150169809e-5*std::pow(-7.19984006881714*x_81 - 9.79320049285889, 2) - 2.97127622094461e-5*std::pow(-5.49191999435425*x_83 - 7.52191972732544, 2) - 3.66917946969626e-5*std::pow(-4.27015972137451*x_84 - 6.41544008255005, 2) + 2.82428959811368e-5*std::pow(-3.90391993522644*x_85 - 6.36783981323242, 2) - 3.42285147737488e-5*std::pow(-3.28543996810913*x_85 - 7.1800799369812, 2) + 3.42548869186067e-7*std::pow(-6.69712018966675*x_86 - 9.7344799041748, 2) + 2.38361831722947e-6*std::pow(-4.28991985321045*x_87 - 6.95071983337402, 2) + 2.06147872572659e-6*std::pow(-4.93191957473755*x_88 - 5.71687984466553, 2) - 4.38624584205085e-5*std::pow(-4.09903955459595*x_89 - 5.94736003875732, 2) + 2.10126491352422e-5*std::pow(-6.60000038146973*x_90 - 9.96016025543213, 2) - 1.53613656013456e-6*std::pow(-5.74399995803833*x_90 - 7.7992000579834, 2) + 3.26039592409984e-5*std::pow(-4.90768003463745*x_90 - 7.15335988998413, 2) - 0.000348134309989491*std::exp(1.29391980171204*x_17) + 0.00155916495207512*std::exp(0.730479836463928*x_22) - 6.84430828331346e-5*std::exp(0.602479875087738*x_29) - 0.658009512143418*std::exp(0.0480619225658123*x_10 + 0.0245604548009443*x_100 - 0.022502735887268*x_101 - 0.0303468413752794*x_105 + 9.11424684479852e-5*x_108 - 0.0207064827776027*x_116 + 0.000846480129395432*x_118 - 0.0333501831497877*x_119 - 0.0169473851126655*x_120 - 0.00416128831976795*x_15 + 0.00301513376504725*x_17 - 0.00498613332338866*x_19 + 0.0436399408208543*x_2 + 0.0509605779627183*x_20 - 0.00779006722776607*x_21 - 0.0315871600714871*x_22 - 0.0108225935060721*x_24 - 0.0227282233314855*x_25 + 0.00365215504474503*x_29 - 0.00599766078774991*x_3 - 0.0375891690996755*x_31 + 0.0242525874116152*x_32 - 0.00913421506711896*x_33 + 0.0217823689870531*x_39 - 0.0164228516008834*x_4 + 0.000439879550605447*x_40 + 0.0009644351584234*x_41 + 0.0430576102522205*x_42 - 0.0043305964432797*x_43 + 0.00217203391560104*x_44 + 0.0266777964041139*x_48 - 0.00496443920126648*x_49 - 0.00225835814603294*x_52 - 0.00565257257973237*x_55 + 0.0101105780190941*x_58 - 0.0062674400903977*x_61 + 0.00719691993286695*x_62 - 0.00303682593259633*x_71 - 0.00140041033199095*x_72 - 0.000488665850004324*x_73 + 0.00471653304377704*x_76 + 0.00863264421814436*x_78 + 0.00402833742698418*x_79 + 0.0297102594703123*x_9 + 0.00810612761550814*x_90 + 0.0452652509937958*x_91 - 0.0220156678333721*x_92 + 0.0512196640764232*x_97 + 0.00052419403641818*std::pow(-3.57223987579346*x_47 - 6.35407972335815, 2) + 0.00193509811983*std::pow(-3.41503977775574*x_5 - 5.42375993728638, 2) - 0.000323576082691582*std::pow(-5.90503978729248*x_6 - 9.16919994354248, 2) - 0.000108657564053385*std::pow(-5.79999971389771*x_67 - 10.0, 2) + 0.000696962092350456*std::pow(-3.71591997146606*x_68 - 4.97343969345093, 2) + 0.000143427600171088*std::pow(-5.51319980621338*x_7 - 8.79199981689453, 2) - 0.000426834687806632*std::pow(-4.73992013931274*x_82 - 7.30111980438232, 2) - 0.000687105783082786*std::pow(-4.22168016433716*x_86 - 6.42952013015747, 2) - 0.000625623374419099*std::pow(-3.91824007034302*x_87 - 5.3600001335144, 2) - 0.000194781128653974*std::pow(-5.10663986206055*x_89 - 7.55287981033325, 2) + 0.482770342451317*std::sin(0.225279986858368*x_1 - 4.18847990036011) - 0.17001856137264*std::sin(0.397359818220139*x_102 + 1.99735975265503) - 0.0798886627032935*std::sin(0.416559875011444*x_103 + 5.21712017059326) - 0.331013368579562*std::sin(0.394079834222794*x_104 - 7.39215993881226) - 0.367926207896602*std::sin(0.40055987238884*x_106 - 7.38775968551636) + 0.187826637289696*std::sin(0.392639845609665*x_107 - 7.40319967269897) - 0.286598382375878*std::sin(0.3504798412323*x_109 + 5.14728021621704) + 0.229124597779531*std::sin(0.300399929285049*x_11 - 1.06567990779877) + 0.165364734999009*std::sin(0.400079846382141*x_110 - 4.20775985717773) + 0.299802740163351*std::sin(0.355199843645096*x_111 - 4.24304008483887) - 0.271837822198066*std::sin(0.372479856014252*x_112 - 7.41504001617432) + 0.281325216868083*std::sin(0.377519845962524*x_113 - 7.42136001586914) - 0.224635938822928*std::sin(0.321759849786758*x_114 + 5.13535976409912) + 0.166304837034236*std::sin(0.33231982588768*x_115 + 5.14056015014648) - 0.157684775016623*std::sin(0.355279833078384*x_117 - 7.42416000366211) + 0.445652861808242*std::sin(0.283599942922592*x_12 + 8.31063938140869) + 0.0932268934630756*std::sin(0.417599856853485*x_13 - 7.16351985931396) - 0.164433606650963*std::sin(0.351519852876663*x_14 - 1.0487197637558) - 0.297002372146544*std::sin(0.313599914312363*x_16 - 4.26719999313354) - 0.130963950475724*std::sin(0.237599983811378*x_18 - 4.33536005020142) - 0.783169286139241*std::sin(0.222559988498688*x_23 - 4.36664009094238) - 0.281577635342416*std::sin(0.327199846506119*x_26 - 4.26272010803223) - 0.332454480853173*std::sin(0.366399854421616*x_27 + 5.17136001586914) - 0.580472547800639*std::sin(0.348239839076996*x_28 - 4.23992013931274) + 0.162067410374924*std::sin(0.296799927949905*x_30 - 4.29607963562012) - 0.275044316604557*std::sin(0.356959849596024*x_34 + 1.98511981964111) - 0.150280482578573*std::sin(0.333759844303131*x_35 + 1.97559976577759) + 0.165295854213966*std::sin(0.361599832773209*x_36 - 4.23776006698608) - 0.448172384360063*std::sin(0.385359823703766*x_37 + 5.19280004501343) - 0.425334577407781*std::sin(0.367359846830368*x_38 + 5.17296028137207) - 0.258735248715297*std::sin(0.341919839382172*x_45 + 5.13479995727539) - 0.13832676797567*std::sin(0.347519844770432*x_46 - 4.24232006072998) + 0.214467183431374*std::sin(0.366719841957092*x_50 + 5.16960000991821) - 0.337436321279689*std::sin(0.338239848613739*x_51 - 4.25888013839722) - 0.340917204222229*std::sin(0.305999934673309*x_53 + 5.12415981292725) + 0.23443074932365*std::sin(0.324559837579727*x_54 - 4.27511978149414) + 0.386317810715767*std::sin(0.300399929285049*x_56 + 5.12975978851318) - 0.439469558128735*std::sin(0.275119960308075*x_57 + 5.07976007461548) - 0.13813317356799*std::sin(0.280559957027435*x_59 + 1.87903988361359) + 0.228704691107005*std::sin(0.313439846038818*x_60 + 8.30096054077148) - 0.193162206024432*std::sin(0.270399957895279*x_63 + 8.28127956390381) - 0.984711698869006*std::sin(0.155440032482147*x_64 - 4.47199964523315) + 0.452283983421779*std::sin(0.295599937438965*x_65 - 4.2902398109436) + 0.257385255467604*std::sin(0.262159943580627*x_66 - 7.51416015625) + 0.501124854030138*std::sin(0.238479986786842*x_69 + 5.03991985321045) - 0.0518082471952521*std::sin(0.332239836454391*x_70 - 4.28344011306763) - 0.299826381187508*std::sin(0.305599927902222*x_74 + 5.12239980697632) + 0.374282631536602*std::sin(0.202880010008812*x_75 - 4.40423965454102) + 0.264816087327624*std::sin(0.227039992809296*x_77 - 7.55208015441895) - 0.759547818431571*std::sin(0.202159985899925*x_8 - 4.39463996887207) - 0.235113822265959*std::sin(0.313839852809906*x_80 - 4.29152011871338) - 0.320702705155568*std::sin(0.360079854726791*x_81 - 4.23920011520386) + 1.34053865339706*std::sin(0.155760034918785*x_83 + 4.93103981018066) - 0.193852602320646*std::sin(0.302159935235977*x_84 + 5.14359951019287) + 0.521590719483669*std::sin(0.238879978656769*x_85 + 5.03191947937012) - 0.222512496256982*std::sin(0.345679849386215*x_88 - 4.25648021697998) - 0.354699859418247*std::sin(0.358159840106964*x_93 - 7.40423965454102) - 0.393102495840495*std::sin(0.396719843149185*x_94 - 7.39343976974487) - 0.230443936086651*std::sin(0.364079833030701*x_95 + 5.16887998580933) - 0.385912158796899*std::sin(0.395359843969345*x_96 - 7.38895988464355) + 0.124487599179584*std::sin(0.410319864749908*x_98 - 7.4031195640564) - 0.182825096009715*std::sin(0.397759854793549*x_99 + 1.99927973747253)) - 0.0308656145429651*std::sin(0.281839966773987*x_1 + 2.15455985069275) - 0.000396005568826104*std::sin(0.341919839382172*x_1 - 4.35288000106812) - 0.00138018206166858*std::sin(0.270319938659668*x_10 - 7.50264024734497) + 0.00439403173679918*std::sin(0.34623983502388*x_10 - 1.06567978858948) - 0.0211977867295351*std::sin(0.36847984790802*x_10 + 5.17600011825562) - 0.0196235834352059*std::sin(0.316399842500687*x_101 - 4.24911975860596) - 0.00106050171356337*std::sin(0.301919937133789*x_102 + 5.10527992248535) - 0.00621503326617054*std::sin(0.300079941749573*x_103 + 5.10311985015869) + 0.0141473644503648*std::sin(0.398559838533401*x_104 + 5.20975971221924) - 0.0109317777883548*std::sin(0.40055987238884*x_104 + 5.20408010482788) - 0.000171200643510101*std::sin(0.428879857063293*x_104 + 5.22983980178833) - 0.0321551120736382*std::sin(0.162960022687912*x_105 - 7.63632011413574) - 0.00235920290421284*std::sin(0.324799835681915*x_105 + 8.32863998413086) + 0.000313398144382556*std::sin(0.37391984462738*x_105 - 7.43215990066528) + 0.0132149625014702*std::sin(0.403519839048386*x_105 + 2.01263976097107) - 0.00202731518201399*std::sin(0.386079847812653*x_106 + 1.99143981933594) - 0.00756782100625008*std::sin(0.396559834480286*x_106 - 7.3874397277832) + 0.000129486041798364*std::sin(0.442479848861694*x_106 + 5.22079992294312) - 0.016503164683518*std::sin(0.35455983877182*x_107 + 5.15592002868652) - 0.00146139951737523*std::sin(0.369519859552383*x_107 + 5.18247985839844) - 0.00246719068320151*std::sin(0.570399820804596*x_107 + 2.1801598072052) + 0.117143525045753*std::sin(0.127280056476593*x_108 + 1.72391986846924) + 0.000365692347143539*std::sin(0.296719938516617*x_108 - 7.49255990982056) + 0.0243129602253756*std::sin(0.388879835605621*x_108 + 5.17456007003784) - 0.0100478115451726*std::sin(0.432159870862961*x_109 + 5.23464012145996) - 0.0133489201298952*std::sin(0.262559980154037*x_11 + 8.27199935913086) - 0.0119049738497905*std::sin(0.298159927129745*x_11 - 4.2611198425293) + 0.000255784199270758*std::sin(0.36959981918335*x_110 - 7.41879987716675) - 0.000370014164941809*std::sin(0.253279983997345*x_111 - 4.3439998626709) + 0.00232398040044507*std::sin(0.357679843902588*x_111 - 4.2388801574707) - 0.0206257561433782*std::sin(0.388959854841232*x_111 + 5.20007991790771) + 0.00166004504881071*std::sin(0.762639880180359*x_111 - 1.20167982578278) + 0.000494857704680506*std::sin(0.350879848003387*x_112 - 4.24528026580811) + 0.00241733770591166*std::sin(0.362399846315384*x_112 + 5.16552019119263) - 0.000327669966956991*std::sin(0.181760013103485*x_114 - 1.20503985881805) - 0.0188076057430437*std::sin(0.32423985004425*x_114 + 5.132080078125) - 0.0115747723187588*std::sin(0.389039844274521*x_114 - 7.40039968490601) - 0.0441543038123919*std::sin(0.189999997615814*x_115 - 7.61768007278442) + 0.00316318953334135*std::sin(0.230639979243279*x_115 + 1.83319985866547) + 0.000330721228920914*std::sin(0.3642398416996*x_115 - 7.42384004592896) - 0.00347059137113151*std::sin(0.491039872169495*x_115 - 4.1386399269104) - 0.0395570683671354*std::sin(0.260159969329834*x_116 - 4.30823993682861) + 0.0112613914241888*std::sin(0.453839868307114*x_116 + 8.24575996398926) - 0.0249151277295583*std::sin(0.240879982709885*x_117 - 7.5633602142334) - 0.000201438134281054*std::sin(0.363599836826324*x_117 - 7.42176008224487) + 0.0194481329147302*std::sin(0.413519859313965*x_117 + 5.20032024383545) + 0.000929231713882077*std::sin(0.322159856557846*x_118 + 1.92447984218597) + 0.00973484621900263*std::sin(0.345439821481705*x_118 + 5.1592001914978) + 6.68932529812702e-5*std::sin(0.450399875640869*x_118 + 5.2403998374939) - 0.0142654580553549*std::sin(0.299039930105209*x_119 + 5.09831953048706) + 0.000185850667863758*std::sin(0.367199838161469*x_119 + 8.1812801361084) - 0.0148239560889465*std::sin(0.369119822978973*x_119 + 1.97495973110199) - 0.0325838003657126*std::sin(0.249199971556664*x_12 + 5.06543970108032) + 0.0167075084063978*std::sin(0.318879842758179*x_12 - 4.26143980026245) + 0.00414014248796046*std::sin(0.342079848051071*x_12 + 8.34247970581055) + 0.000365439959457397*std::sin(0.302719920873642*x_120 - 7.48975992202759) + 0.0126437848361197*std::sin(0.482079833745956*x_120 + 2.02687978744507) + 0.0416387644258568*std::sin(0.23319998383522*x_14 + 8.24967956542969) + 0.000575054826721396*std::sin(0.254239976406097*x_15 - 1.0914398431778) - 0.0266257822895957*std::sin(0.417839854955673*x_15 + 2.22183990478516) - 0.0284411343373521*std::sin(0.321199834346771*x_16 - 4.25663995742798) - 0.0135576643202984*std::sin(0.373839825391769*x_16 + 2.15111970901489) + 0.00294113514104096*std::sin(0.402399867773056*x_16 + 5.189040184021) + 0.00739074837865978*std::sin(0.238399982452393*x_19 - 4.33599996566772) - 0.0213447507712604*std::sin(0.254319965839386*x_19 - 4.31472015380859) - 0.0210126597287672*std::sin(0.311999946832657*x_21 - 4.27687978744507) + 0.00364571629136047*std::sin(0.333199828863144*x_21 - 4.25576019287109) - 0.000490540940478267*std::sin(0.364319831132889*x_21 + 8.36192035675049) - 0.000528302636901952*std::sin(0.341359853744507*x_23 - 4.26792001724243) + 0.00100805408701641*std::sin(0.477199852466583*x_23 - 7.31928014755249) + 0.030062177574767*std::sin(0.359199821949005*x_24 + 2.12399983406067) + 0.00150824807479881*std::sin(0.382639855146408*x_24 + 5.38751983642578) - 0.000369375016495884*std::sin(0.437999874353409*x_24 + 8.44855976104736) - 0.000536206636362714*std::sin(0.319279849529266*x_26 - 4.28200006484985) - 0.0057925814987678*std::sin(0.350639849901199*x_27 + 8.32791996002197) - 0.000639836552908094*std::sin(0.366799861192703*x_27 - 4.24416017532349) - 0.00795630002637892*std::sin(0.444319844245911*x_27 - 0.939439833164215) - 0.00844622789621146*std::sin(0.536719858646393*x_27 - 4.05399990081787) + 0.00289939239695489*std::sin(0.311599940061569*x_28 + 5.12759971618652) - 0.0102070577910298*std::sin(0.320399850606918*x_28 - 4.2739200592041) + 0.000430204830586814*std::sin(0.333199828863144*x_28 - 4.27544021606445) - 0.0194762093482978*std::sin(0.342559844255447*x_3 - 4.24079990386963) - 0.00476617189059779*std::sin(0.376959830522537*x_3 - 1.01671981811523) + 0.00049280746369213*std::sin(0.295999944210052*x_33 - 1.16031992435455) - 0.0204233026246132*std::sin(0.352079838514328*x_34 + 1.99303984642029) + 0.030336918714059*std::sin(0.360879838466644*x_34 + 1.99647974967957) + 0.0041976778927183*std::sin(0.307439923286438*x_35 - 1.14431989192963) + 0.0258732212406809*std::sin(0.312399834394455*x_35 - 7.41991996765137) - 0.0189863115219191*std::sin(0.316639840602875*x_35 + 1.94799983501434) + 0.000424835194929526*std::sin(0.331839829683304*x_35 + 1.95959985256195) - 0.0162676612229722*std::sin(0.345039844512939*x_36 - 7.4507999420166) - 0.000465946111002163*std::sin(0.358079850673676*x_36 + 5.17239999771118) + 0.00225513056536708*std::sin(0.305039942264557*x_37 + 5.12063980102539) + 0.0135172740881801*std::sin(0.369439840316772*x_37 + 5.18287992477417) - 0.000670167418359459*std::sin(0.389999836683273*x_37 + 5.19632005691528) + 0.0279528566166569*std::sin(0.218799993395805*x_38 + 5.01575994491577) + 0.000421318914496193*std::sin(0.262399971485138*x_38 - 7.52008008956909) + 0.00181648159505941*std::sin(0.320239841938019*x_38 + 5.11552000045776) - 0.0311234631949597*std::sin(0.344159841537476*x_38 + 5.13088035583496) + 0.0182815502481771*std::sin(0.352319836616516*x_39 - 7.42647981643677) - 0.034564184685644*std::sin(0.2291199862957*x_40 + 5.04504013061523) - 0.000192435284404828*std::sin(0.309679925441742*x_40 - 7.48591995239258) - 0.019425778338432*std::sin(0.317279845476151*x_40 - 7.46495962142944) - 0.0205653597895191*std::sin(0.333999842405319*x_41 + 5.14592027664185) + 0.00136797480192711*std::sin(0.341359823942184*x_41 + 1.95199990272522) - 0.00283130220535292*std::sin(0.317679852247238*x_42 + 8.32288074493408) - 0.0169919323354347*std::sin(0.355359852313995*x_43 + 5.16279983520508) - 0.0284414128243092*std::sin(0.360879838466644*x_43 + 5.16096019744873) - 0.000350526534667866*std::sin(0.364639848470688*x_43 - 4.23912000656128) - 0.01719486710359*std::sin(0.269999951124191*x_44 - 4.30319976806641) - 0.0222444045131864*std::sin(0.329999834299088*x_44 + 5.11872005462646) - 0.0187719006985179*std::sin(0.328879833221436*x_45 - 7.44984006881714) + 0.0174730048301643*std::sin(0.351679861545563*x_45 + 5.14408016204834) + 0.00160481740675352*std::sin(0.35471984744072*x_45 + 8.35632038116455) - 0.0302418612725716*std::sin(0.246319979429245*x_46 - 7.53096008300781) - 0.000102955860311847*std::sin(0.29479992389679*x_46 + 5.11055994033813) + 0.00269815310316032*std::sin(0.29215994477272*x_47 - 7.47575998306274) - 0.0196204191436422*std::sin(0.324559837579727*x_47 - 4.27048015594482) - 0.0188069794605057*std::sin(0.336879849433899*x_47 - 4.26936006546021) - 0.0195798216315163*std::sin(0.300879925489426*x_48 + 5.12215948104858) + 0.0143562082803256*std::sin(0.337039858102798*x_49 + 5.13264036178589) + 0.000280243458000174*std::sin(0.35455983877182*x_49 - 7.43215990066528) + 0.00138960256521021*std::sin(0.433759868144989*x_49 - 4.17463970184326) - 0.0377727116217446*std::sin(0.246479973196983*x_50 - 7.53216028213501) + 0.000648112882628991*std::sin(0.249039962887764*x_50 + 5.05631971359253) + 0.00972273298235799*std::sin(0.31879985332489*x_50 + 5.11704015731812) + 0.00214464895643578*std::sin(0.22647999227047*x_51 - 7.58319997787476) + 0.000307364910222248*std::sin(0.300319939851761*x_51 - 4.28999948501587) - 0.00341422940816653*std::sin(0.449919849634171*x_51 - 4.16607999801636) - 0.0223560179607922*std::sin(0.281759947538376*x_52 + 5.10095977783203) - 0.0182275358866196*std::sin(0.236559987068176*x_53 - 4.34311962127686) + 0.000545345056985628*std::sin(0.290879935026169*x_53 + 5.103919506073) + 0.000631959837023589*std::sin(0.26215997338295*x_54 - 7.52416038513184) - 0.00503917154542695*std::sin(0.350879848003387*x_54 + 2.13367986679077) - 0.0227700166626648*std::sin(0.239439979195595*x_55 + 5.03903961181641) + 0.00525454488046994*std::sin(0.378319829702377*x_55 - 1.00887978076935) + 0.0294173644131285*std::sin(0.22503998875618*x_56 + 5.03327989578247) - 0.00542264656997645*std::sin(0.318239837884903*x_56 + 5.1159200668335) - 0.000264086790164091*std::sin(0.254079967737198*x_57 - 7.52976036071777) + 0.0149997609306838*std::sin(0.318639844655991*x_57 - 4.29200029373169) - 0.0400912078792618*std::sin(0.213919997215271*x_58 + 5.01063966751099) + 0.018984016948898*std::sin(0.286479920148849*x_58 + 5.09591960906982) - 0.000336394869051546*std::sin(0.367759823799133*x_59 - 4.2294397354126) - 0.0181072483153786*std::sin(0.376079827547073*x_59 - 7.42407989501953) + 0.000628824036869423*std::sin(0.245839968323708*x_60 - 7.53416013717651) - 0.0182248130071834*std::sin(0.253439962863922*x_60 - 7.54631996154785) - 0.0343516900562462*std::sin(0.281599938869476*x_60 + 5.08191967010498) + 0.00263430717802672*std::sin(0.289519935846329*x_65 - 4.28743982315063) - 0.0338280393103234*std::sin(0.292959928512573*x_65 + 5.12455987930298) + 0.0677175847167141*std::sin(0.162640020251274*x_66 + 4.94399976730347) + 0.0171178400520009*std::sin(0.230159983038902*x_66 + 5.02184009552002) - 0.0678035357965257*std::sin(0.20168000459671*x_67 + 4.99440002441406) + 0.00525217381055923*std::sin(0.183040007948875*x_68 - 4.43607997894287) + 0.00131409177543692*std::sin(0.196959987282753*x_68 + 4.9846396446228) - 0.0136614455750811*std::sin(0.196959987282753*x_68 + 4.98943948745728) - 0.00504655346178699*std::sin(0.353599846363068*x_68 + 8.35048007965088) + 0.037835262213945*std::sin(0.156880035996437*x_69 - 4.47191953659058) + 0.056208180588791*std::sin(0.174560010433197*x_69 - 4.44608020782471) - 0.0210006878166422*std::sin(0.298639923334122*x_7 - 1.02047991752625) + 0.000507490584718056*std::sin(0.242239981889725*x_70 - 7.54864025115967) - 0.0276696063972252*std::sin(0.274159938097*x_70 + 1.88463997840881) + 0.111870002688081*std::sin(0.128320053219795*x_71 - 4.51495981216431) - 0.0861430289123145*std::sin(0.138400033116341*x_73 + 4.90935945510864) - 0.00728577645163951*std::sin(0.15776002407074*x_73 + 4.92848014831543) - 0.00036560944479941*std::sin(0.275279968976974*x_73 + 5.07599973678589) - 0.00253480436503992*std::sin(0.470879852771759*x_73 + 2.04903984069824) - 0.0545636285064558*std::sin(0.195040002465248*x_74 + 4.98744010925293) - 0.000529173491265294*std::sin(0.274639964103699*x_74 - 4.31271982192993) - 0.0210341819273031*std::sin(0.312799841165543*x_74 + 5.11303997039795) - 0.00165568099728723*std::sin(0.326879858970642*x_74 - 4.27383995056152) - 0.0544639484795019*std::sin(0.19055999815464*x_75 + 4.97583961486816) - 0.000725313718819999*std::sin(0.246879979968071*x_75 + 5.0577597618103) + 0.0326231515497614*std::sin(0.285679936408997*x_75 - 7.48791980743408) + 0.0439377700126532*std::sin(0.191040009260178*x_76 + 4.97191953659058) - 0.000574525221542026*std::sin(0.178640007972717*x_77 - 7.62040042877197) - 0.00690608215768947*std::sin(0.321919828653336*x_77 - 4.29168033599854) + 0.0011124634757698*std::sin(0.332159847021103*x_77 - 1.0759197473526) + 0.0422315269411716*std::sin(0.221759989857674*x_78 + 5.01408004760742) - 0.0015850226233628*std::sin(0.377519845962524*x_78 + 5.1831202507019) + 0.00299074317139246*std::sin(0.286319941282272*x_79 + 5.09559965133667) - 0.0037249189439666*std::sin(0.487999856472015*x_79 - 7.32823991775513) - 0.0339608509050395*std::sin(0.273039966821671*x_8 - 4.31079959869385) - 0.00466295025783467*std::sin(0.169440016150475*x_80 - 7.63960027694702) - 0.000759208450299688*std::sin(0.177920013666153*x_80 - 7.6255202293396) + 0.0119790840269462*std::sin(0.249199971556664*x_80 + 5.05807971954346) + 0.0311133408269167*std::sin(0.193200007081032*x_81 - 7.60736036300659) - 0.00106173490230434*std::sin(0.36831983923912*x_81 - 7.42639970779419) - 0.00148571061132142*std::sin(0.193039998412132*x_82 + 4.98015975952148) - 0.00146986439768688*std::sin(0.209600001573563*x_82 + 8.20239925384521) - 0.000705443446613096*std::sin(0.249119967222214*x_84 + 5.05751991271973) + 0.0271723585990606*std::sin(0.322719842195511*x_84 + 5.12712001800537) + 0.00192273017251926*std::sin(0.390079826116562*x_84 + 5.18688011169434) - 0.00138962930666856*std::sin(0.164800018072128*x_85 - 7.63064002990723) - 0.00168511294422095*std::sin(0.346639841794968*x_85 - 4.24584007263184) + 0.00838902228601732*std::sin(0.391279846429825*x_86 - 4.19704008102417) + 0.0995980874613826*std::sin(0.152880027890205*x_87 - 7.64616012573242) - 0.000543699454218136*std::sin(0.259839981794357*x_87 + 5.06343984603882) + 0.0046874269419575*std::sin(0.572799861431122*x_88 - 0.833039879798889) + 0.0121785939580544*std::sin(0.180400013923645*x_89 + 4.9684796333313) + 0.000178069984909599*std::sin(0.341119825839996*x_89 - 4.27016019821167) + 0.00183423872626888*std::sin(0.178000003099442*x_9 - 4.42439985275269) + 0.0525939085622748*std::sin(0.240079984068871*x_9 - 4.34311962127686) - 0.00355183034972297*std::sin(0.400879859924316*x_9 - 0.971039831638336) + 0.0030954184923841*std::sin(0.627359867095947*x_9 - 6.96623992919922) - 0.0040065757198297*std::sin(0.374399840831757*x_92 + 2.0020797252655) + 0.000514916917113563*std::sin(0.335999846458435*x_93 + 1.99351978302002) - 0.0202516532534352*std::sin(0.340079843997955*x_93 - 7.4270396232605) - 0.00376674913924215*std::sin(0.361279845237732*x_93 + 2.00159978866577) - 0.0244345809340688*std::sin(0.36151984333992*x_93 - 7.41088008880615) - 0.00262370312386888*std::sin(0.380799859762192*x_94 + 1.97039985656738) - 0.00136094888819478*std::sin(0.384719848632813*x_94 + 2.0019998550415) + 8.60735340607981e-5*std::sin(0.411759853363037*x_94 - 4.18368005752563) - 0.00634767503152253*std::sin(0.353599846363068*x_95 + 1.95167982578278) - 0.00619943031521615*std::sin(0.357599824666977*x_95 - 7.42639970779419) - 0.00169835604901252*std::sin(0.358639866113663*x_95 - 7.41207981109619) - 0.000210037572820981*std::sin(0.374639838933945*x_95 - 7.41559982299805) + 0.000274489398506123*std::sin(0.383999854326248*x_96 - 7.40655994415283) + 0.0190110543999982*std::sin(0.393039852380753*x_96 + 5.19248008728027) - 0.000662246844224529*std::sin(0.414799869060516*x_96 + 8.39535999298096) - 0.0101968808420153*std::sin(0.415759861469269*x_96 - 7.37639951705933) + 0.0140799940285493*std::sin(0.33519983291626*x_97 - 7.44375991821289) - 0.00984062286594517*std::sin(0.343839854001999*x_98 + 1.95423984527588) - 0.000175435323291268*std::sin(0.362719833850861*x_98 - 7.41815996170044) + 0.00197996775130609*std::sin(0.41839987039566*x_98 + 2.01895976066589) + 0.00201716130716524*std::sin(0.310559868812561*x_99 - 7.46631956100464) + 0.00561244534542889*std::sin(0.389679849147797*x_99 - 7.41063976287842) + 0.0126350402728321*std::sin(0.409279853105545*x_99 - 7.38895988464355) - 0.337673279167194);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00211664115701476*x_1 + 0.000968329409170377*x_10 + 0.00534587616389406*x_100 - 0.00174319373207984*x_101 - 0.0015140631377886*x_102 + 0.000376434847599702*x_103 - 0.000139326619182821*x_104 - 0.00116881279900659*x_105 + 0.00013756654521983*x_106 - 0.000257990558854669*x_108 + 0.0016384637148617*x_109 + 0.000644933095874274*x_11 + 0.000948307874147611*x_110 - 0.000700964167667632*x_112 + 0.000370073480780004*x_113 + 0.000246423568105193*x_114 - 0.00108719558731377*x_116 + 0.000280838700608313*x_117 + 5.06592972599429e-5*x_118 - 0.00175314900532129*x_119 - 5.42573600224607e-5*x_120 + 0.00154931359808697*x_13 + 0.000837225141929311*x_14 + 0.000894669419335572*x_15 + 0.00011612829459658*x_17 + 0.00114550153207736*x_18 - 0.000473764817761886*x_19 - 0.00477304080825845*x_2 + 0.00568029637928881*x_20 - 0.000425325710930603*x_21 - 0.00199383077398919*x_22 - 0.000102756224068629*x_23 + 9.00319812633843e-5*x_24 - 0.00908212050158319*x_25 + 0.00177096059291283*x_26 + 0.000132946075734695*x_28 + 0.00112299271173323*x_29 + 0.00373269788440419*x_3 + 0.00241134590635394*x_30 - 0.00195289256618941*x_31 + 0.00695906241147803*x_32 - 0.00453929153340722*x_33 - 1.77148254955508e-5*x_34 - 0.00010302629955823*x_36 + 0.00089062512366569*x_37 - 0.000154683573878696*x_39 + 0.00364255458368597*x_4 - 0.000202713167504972*x_40 - 0.000503130368865265*x_41 + 0.00325617005617134*x_42 - 0.000202051168392492*x_43 + 5.3949504123185e-5*x_44 - 0.000237535414188496*x_46 - 0.00207645745783119*x_48 - 0.000206065013329921*x_49 + 0.00223109103786229*x_5 + 0.000509052016209864*x_50 + 0.000864944816369988*x_51 + 0.00471321387696917*x_52 + 0.000240230849127705*x_53 - 0.000245032704181871*x_54 - 0.00047902907395836*x_55 - 1.85910267473061e-5*x_56 + 0.000348771092149664*x_57 + 0.000389410312853789*x_58 - 0.00161099716429075*x_59 - 0.00177084566179091*x_6 - 0.00039464158577266*x_60 - 0.00113560297079032*x_61 + 0.000596359086320873*x_62 + 0.00117826260273061*x_63 + 0.000868498379834806*x_64 + 0.000355228967986579*x_65 - 0.000333157777856872*x_66 - 9.28130615897603e-6*x_67 + 0.000354062992217457*x_69 - 4.4505068402549e-5*x_70 - 0.000164195239667798*x_71 + 0.000567198266017212*x_72 - 1.88210328995806e-5*x_73 + 5.48724367933975e-5*x_76 - 0.000305737018290569*x_77 + 0.000332487487796888*x_78 + 4.32722674470484e-5*x_79 - 0.00032330127297403*x_8 - 0.000175222723472522*x_80 + 0.000861234564360111*x_82 - 0.00123924012929826*x_83 + 0.0013415705425381*x_86 + 0.000954167849777717*x_87 - 0.000490625603841492*x_88 - 0.0012504540927853*x_89 + 0.00114429475876179*x_9 + 0.000312208627916862*x_90 + 0.00149273328987534*x_91 - 0.00196396801042369*x_92 - 0.000657453645023969*x_94 + 0.00256406183341838*x_97 + 0.000417280592591904*x_98 - 3.57797359854775e-5*std::pow(-5.59087991714478*x_17 - 8.77711963653564, 2) + 5.74197618303066e-5*std::pow(-4.67167949676514*x_17 - 6.90744018554688, 2) + 0.000188726896855351*std::pow(-1.91071999073029*x_18 - 2.75584006309509, 2) + 2.21726485556343e-5*std::pow(-6.07679986953735*x_22 - 9.73752021789551, 2) + 5.51877401200188e-5*std::pow(-6.36255979537964*x_23 - 8.93599987030029, 2) - 6.89718662242692e-5*std::pow(-4.91200017929077*x_4 - 8.39608001708984, 2) + 2.01894059204325e-5*std::pow(-3.57223987579346*x_47 - 6.35407972335815, 2) + 7.45305721218593e-5*std::pow(-3.41503977775574*x_5 - 5.42375993728638, 2) + 1.08902496053184e-5*std::pow(-5.77103996276855*x_58 - 7.56695985794067, 2) - 1.24625776444206e-5*std::pow(-5.90503978729248*x_6 - 9.16919994354248, 2) + 0.000110868791829563*std::pow(-2.89567995071411*x_6 - 4.63944005966187, 2) - 9.89003214708911e-6*std::pow(-6.9987998008728*x_67 - 9.77744007110596, 2) - 4.18496113002157e-6*std::pow(-5.79999971389771*x_67 - 10.0, 2) + 2.68435915253181e-5*std::pow(-3.71591997146606*x_68 - 4.97343969345093, 2) + 7.7299527966942e-5*std::pow(-5.72896003723145*x_7 - 8.99792003631592, 2) + 5.52413388720338e-6*std::pow(-5.51319980621338*x_7 - 8.79199981689453, 2) - 4.70929507316051e-5*std::pow(-5.27688026428223*x_7 - 8.52688026428223, 2) - 3.0266286592332e-5*std::pow(-6.60000038146973*x_71 - 9.96463966369629, 2) - 1.66319740193481e-5*std::pow(-7.60000038146973*x_72 - 9.99660015106201, 2) - 4.85757598904904e-6*std::pow(-6.59600019454956*x_75 - 9.96208000183105, 2) - 1.4050976611853e-5*std::pow(-6.40000009536743*x_78 - 9.99993991851807, 2) + 1.08573402008349e-5*std::pow(-7.19984006881714*x_81 - 9.79320049285889, 2) - 1.64395971231051e-5*std::pow(-4.73992013931274*x_82 - 7.30111980438232, 2) - 2.78486157243409e-5*std::pow(-5.49191999435425*x_83 - 7.52191972732544, 2) - 3.4389791280572e-5*std::pow(-4.27015972137451*x_84 - 6.41544008255005, 2) + 4.24258318258549e-5*std::pow(-3.90391993522644*x_85 - 6.36783981323242, 2) - 3.20810548689416e-5*std::pow(-3.28543996810913*x_85 - 7.1800799369812, 2) - 2.6463974408645e-5*std::pow(-4.22168016433716*x_86 - 6.42952013015747, 2) + 1.17023011122839e-5*std::pow(-4.28991985321045*x_87 - 6.95071983337402, 2) - 2.40959709228387e-5*std::pow(-3.91824007034302*x_87 - 5.3600001335144, 2) + 1.0120766655737e-5*std::pow(-4.93191957473755*x_88 - 5.71687984466553, 2) - 7.50202214986262e-6*std::pow(-5.10663986206055*x_89 - 7.55287981033325, 2) - 4.11105753368593e-5*std::pow(-4.09903955459595*x_89 - 5.94736003875732, 2) + 3.15647205238051e-5*std::pow(-6.60000038146973*x_90 - 9.96016025543213, 2) - 7.54161538629928e-6*std::pow(-5.74399995803833*x_90 - 7.7992000579834, 2) + 3.05584221888997e-5*std::pow(-4.90768003463745*x_90 - 7.15335988998413, 2) - 0.000522959391214302*std::exp(1.29391980171204*x_17) + 0.00234214189967227*std::exp(0.730479836463928*x_22) - 0.000336019218587513*std::exp(0.602479875087738*x_29) + 0.018593966609571*std::sin(0.225279986858368*x_1 - 4.18847990036011) - 0.0289291393524294*std::sin(0.281839966773987*x_1 + 2.15455985069275) + 0.0215723642117009*std::sin(0.34623983502388*x_10 - 1.06567978858948) - 0.031842829979909*std::sin(0.36847984790802*x_10 + 5.17600011825562) - 0.0183924210872544*std::sin(0.316399842500687*x_101 - 4.24911975860596) - 0.00520650067693568*std::sin(0.301919937133789*x_102 + 5.10527992248535) - 0.00654828844107991*std::sin(0.397359818220139*x_102 + 1.99735975265503) - 0.00933608070216147*std::sin(0.300079941749573*x_103 + 5.10311985015869) - 0.00307692290965058*std::sin(0.416559875011444*x_103 + 5.21712017059326) - 0.0127490257405583*std::sin(0.394079834222794*x_104 - 7.39215993881226) + 0.0132597741439588*std::sin(0.398559838533401*x_104 + 5.20975971221924) - 0.0164214663509053*std::sin(0.40055987238884*x_104 + 5.20408010482788) - 0.0301377352061594*std::sin(0.162960022687912*x_105 - 7.63632011413574) - 0.0115824343899835*std::sin(0.324799835681915*x_105 + 8.32863998413086) + 0.0198512141618484*std::sin(0.403519839048386*x_105 + 2.01263976097107) - 0.00995304178439422*std::sin(0.386079847812653*x_106 + 1.99143981933594) - 0.00709302412169044*std::sin(0.396559834480286*x_106 - 7.3874397277832) - 0.0141707288597691*std::sin(0.40055987238884*x_106 - 7.38775968551636) - 0.024790676208451*std::sin(0.35455983877182*x_107 + 5.15592002868652) - 0.00717469616425377*std::sin(0.369519859552383*x_107 + 5.18247985839844) + 0.00723416895167868*std::sin(0.392639845609665*x_107 - 7.40319967269897) - 0.00231240181477674*std::sin(0.570399820804596*x_107 + 2.1801598072052) + 0.17597032175448*std::sin(0.127280056476593*x_108 + 1.72391986846924) + 0.0227875914620423*std::sin(0.388879835605621*x_108 + 5.17456007003784) - 0.0110383763948621*std::sin(0.3504798412323*x_109 + 5.14728021621704) - 0.0150935924955461*std::sin(0.432159870862961*x_109 + 5.23464012145996) - 0.0200524422448023*std::sin(0.262559980154037*x_11 + 8.27199935913086) - 0.0111580686983637*std::sin(0.298159927129745*x_11 - 4.2611198425293) + 0.00882476562025679*std::sin(0.300399929285049*x_11 - 1.06567990779877) + 0.00636904567368323*std::sin(0.400079846382141*x_110 - 4.20775985717773) + 0.0115469440640243*std::sin(0.355199843645096*x_111 - 4.24304008483887) + 0.0114095105866885*std::sin(0.357679843902588*x_111 - 4.2388801574707) - 0.030983538727916*std::sin(0.388959854841232*x_111 + 5.20007991790771) + 0.00155589562234396*std::sin(0.762639880180359*x_111 - 1.20167982578278) + 0.0118678454181104*std::sin(0.362399846315384*x_112 + 5.16552019119263) - 0.0104698713750815*std::sin(0.372479856014252*x_112 - 7.41504001617432) + 0.0108352796949265*std::sin(0.377519845962524*x_113 - 7.42136001586914) - 0.00865188429880475*std::sin(0.321759849786758*x_114 + 5.13535976409912) - 0.0282523548163859*std::sin(0.32423985004425*x_114 + 5.132080078125) - 0.0108485836533695*std::sin(0.389039844274521*x_114 - 7.40039968490601) - 0.0413841106652879*std::sin(0.189999997615814*x_115 - 7.61768007278442) + 0.015529582117581*std::sin(0.230639979243279*x_115 + 1.83319985866547) + 0.0064052538337865*std::sin(0.33231982588768*x_115 + 5.14056015014648) - 0.00521344291131586*std::sin(0.491039872169495*x_115 - 4.1386399269104) - 0.037075300787337*std::sin(0.260159969329834*x_116 - 4.30823993682861) + 0.0169166044093658*std::sin(0.453839868307114*x_116 + 8.24575996398926) - 0.0233519796299098*std::sin(0.240879982709885*x_117 - 7.5633602142334) - 0.00607325095118588*std::sin(0.355279833078384*x_117 - 7.42416000366211) + 0.0292145400711845*std::sin(0.413519859313965*x_117 + 5.20032024383545) + 0.0045620346346268*std::sin(0.322159856557846*x_118 + 1.92447984218597) + 0.0146234631467612*std::sin(0.345439821481705*x_118 + 5.1592001914978) - 0.0133704586842143*std::sin(0.299039930105209*x_119 + 5.09831953048706) - 0.0222682074969773*std::sin(0.369119822978973*x_119 + 1.97495973110199) - 0.0305395280595921*std::sin(0.249199971556664*x_12 + 5.06543970108032) + 0.0171643817013424*std::sin(0.283599942922592*x_12 + 8.31063938140869) + 0.0250976366712646*std::sin(0.318879842758179*x_12 - 4.26143980026245) + 0.020325902721786*std::sin(0.342079848051071*x_12 + 8.34247970581055) + 0.0189932041479664*std::sin(0.482079833745956*x_120 + 2.02687978744507) + 0.00359064671488443*std::sin(0.417599856853485*x_13 - 7.16351985931396) + 0.0390263934924029*std::sin(0.23319998383522*x_14 + 8.24967956542969) - 0.00633318313638466*std::sin(0.351519852876663*x_14 - 1.0487197637558) - 0.0399966406562797*std::sin(0.417839854955673*x_15 + 2.22183990478516) - 0.0114390875019691*std::sin(0.313599914312363*x_16 - 4.26719999313354) - 0.0266567684061858*std::sin(0.321199834346771*x_16 - 4.25663995742798) - 0.020366012989197*std::sin(0.373839825391769*x_16 + 2.15111970901489) + 0.0144394128806602*std::sin(0.402399867773056*x_16 + 5.189040184021) - 0.00504409469280661*std::sin(0.237599983811378*x_18 - 4.33536005020142) + 0.0362846527680356*std::sin(0.238399982452393*x_19 - 4.33599996566772) - 0.0320635959991887*std::sin(0.254319965839386*x_19 - 4.31472015380859) - 0.0196943482402567*std::sin(0.311999946832657*x_21 - 4.27687978744507) + 0.0178985324550818*std::sin(0.333199828863144*x_21 - 4.25576019287109) - 0.0301638735349262*std::sin(0.222559988498688*x_23 - 4.36664009094238) + 0.00494901066100458*std::sin(0.477199852466583*x_23 - 7.31928014755249) + 0.0451587149900594*std::sin(0.359199821949005*x_24 + 2.12399983406067) + 0.00740469772183704*std::sin(0.382639855146408*x_24 + 5.38751983642578) - 0.0108450016274286*std::sin(0.327199846506119*x_26 - 4.26272010803223) - 0.0284385014270301*std::sin(0.350639849901199*x_27 + 8.32791996002197) - 0.0128045303793894*std::sin(0.366399854421616*x_27 + 5.17136001586914) - 0.0119517717694618*std::sin(0.444319844245911*x_27 - 0.939439833164215) - 0.00791632071578396*std::sin(0.536719858646393*x_27 - 4.05399990081787) + 0.0142344781572537*std::sin(0.311599940061569*x_28 + 5.12759971618652) - 0.00956667805217248*std::sin(0.320399850606918*x_28 - 4.2739200592041) - 0.0223569805816439*std::sin(0.348239839076996*x_28 - 4.23992013931274) - 0.0182542930907692*std::sin(0.342559844255447*x_3 - 4.24079990386963) - 0.0233993748971972*std::sin(0.376959830522537*x_3 - 1.01671981811523) + 0.00624204875906362*std::sin(0.296799927949905*x_30 - 4.29607963562012) - 0.0191419667618098*std::sin(0.352079838514328*x_34 + 1.99303984642029) - 0.0105933699512892*std::sin(0.356959849596024*x_34 + 1.98511981964111) + 0.0455714248403181*std::sin(0.360879838466644*x_34 + 1.99647974967957) + 0.0206083710289921*std::sin(0.307439923286438*x_35 - 1.14431989192963) + 0.0242499633929527*std::sin(0.312399834394455*x_35 - 7.41991996765137) - 0.0285208025466024*std::sin(0.316639840602875*x_35 + 1.94799983501434) - 0.00578807360234225*std::sin(0.333759844303131*x_35 + 1.97559976577759) - 0.0152470457959741*std::sin(0.345039844512939*x_36 - 7.4507999420166) + 0.00636639272070637*std::sin(0.361599832773209*x_36 - 4.23776006698608) + 0.0110714944304147*std::sin(0.305039942264557*x_37 + 5.12063980102539) + 0.0126692149679253*std::sin(0.369439840316772*x_37 + 5.18287992477417) - 0.0172614214614129*std::sin(0.385359823703766*x_37 + 5.19280004501343) + 0.0419901413319154*std::sin(0.218799993395805*x_38 + 5.01575994491577) + 0.00891796074759754*std::sin(0.320239841938019*x_38 + 5.11552000045776) - 0.029170810859569*std::sin(0.344159841537476*x_38 + 5.13088035583496) - 0.0163818201633083*std::sin(0.367359846830368*x_38 + 5.17296028137207) + 0.0171345856072869*std::sin(0.352319836616516*x_39 - 7.42647981643677) - 0.032395665214513*std::sin(0.2291199862957*x_40 + 5.04504013061523) - 0.0291809595383949*std::sin(0.317279845476151*x_40 - 7.46495962142944) - 0.0308928127077008*std::sin(0.333999842405319*x_41 + 5.14592027664185) + 0.00671603038559249*std::sin(0.341359823942184*x_41 + 1.95199990272522) - 0.0139001914473556*std::sin(0.317679852247238*x_42 + 8.32288074493408) - 0.0255248917866263*std::sin(0.355359852313995*x_43 + 5.16279983520508) - 0.0266570294211732*std::sin(0.360879838466644*x_43 + 5.16096019744873) - 0.0258297357499056*std::sin(0.269999951124191*x_44 - 4.30319976806641) - 0.0208488146924146*std::sin(0.329999834299088*x_44 + 5.11872005462646) - 0.0175941720020334*std::sin(0.328879833221436*x_45 - 7.44984006881714) - 0.00996522394251342*std::sin(0.341919839382172*x_45 + 5.13479995727539) + 0.0262475478758273*std::sin(0.351679861545563*x_45 + 5.14408016204834) + 0.00787880189891*std::sin(0.35471984744072*x_45 + 8.35632038116455) - 0.0283445196859189*std::sin(0.246319979429245*x_46 - 7.53096008300781) - 0.00532767462866433*std::sin(0.347519844770432*x_46 - 4.24232006072998) + 0.013246500008829*std::sin(0.29215994477272*x_47 - 7.47575998306274) - 0.0294733445003978*std::sin(0.324559837579727*x_47 - 4.27048015594482) - 0.017627049960528*std::sin(0.336879849433899*x_47 - 4.26936006546021) - 0.0183514048516797*std::sin(0.300879925489426*x_48 + 5.12215948104858) + 0.0215655674462291*std::sin(0.337039858102798*x_49 + 5.13264036178589) + 0.00682221122691871*std::sin(0.433759868144989*x_49 - 4.17463970184326) - 0.0354028926494721*std::sin(0.246479973196983*x_50 - 7.53216028213501) + 0.0146052669199616*std::sin(0.31879985332489*x_50 + 5.11704015731812) + 0.00826023327639234*std::sin(0.366719841957092*x_50 + 5.16960000991821) + 0.0105290883556928*std::sin(0.22647999227047*x_51 - 7.58319997787476) - 0.0129964066534673*std::sin(0.338239848613739*x_51 - 4.25888013839722) - 0.00512877726074926*std::sin(0.449919849634171*x_51 - 4.16607999801636) - 0.0335826984220682*std::sin(0.281759947538376*x_52 + 5.10095977783203) - 0.0170839600482087*std::sin(0.236559987068176*x_53 - 4.34311962127686) - 0.0131304733421474*std::sin(0.305999934673309*x_53 + 5.12415981292725) + 0.00902913278195047*std::sin(0.324559837579727*x_54 - 4.27511978149414) - 0.00756972814228068*std::sin(0.350879848003387*x_54 + 2.13367986679077) - 0.0342045977950469*std::sin(0.239439979195595*x_55 + 5.03903961181641) + 0.00492488043188355*std::sin(0.378319829702377*x_55 - 1.00887978076935) + 0.0441900914192668*std::sin(0.22503998875618*x_56 + 5.03327989578247) + 0.0148790839898287*std::sin(0.300399929285049*x_56 + 5.12975978851318) - 0.00508243560365385*std::sin(0.318239837884903*x_56 + 5.1159200668335) - 0.0169262309036571*std::sin(0.275119960308075*x_57 + 5.07976007461548) + 0.0225322975058312*std::sin(0.318639844655991*x_57 - 4.29200029373169) - 0.0602240947357867*std::sin(0.213919997215271*x_58 + 5.01063966751099) + 0.0177929803088506*std::sin(0.286479920148849*x_58 + 5.09591960906982) - 0.00532021831323717*std::sin(0.280559957027435*x_59 + 1.87903988361359) - 0.0272002939206493*std::sin(0.376079827547073*x_59 - 7.42407989501953) - 0.0273768969094681*std::sin(0.253439962863922*x_60 - 7.54631996154785) - 0.0321965022677673*std::sin(0.281599938869476*x_60 + 5.08191967010498) + 0.00880859285660182*std::sin(0.313439846038818*x_60 + 8.30096054077148) - 0.00743966912054367*std::sin(0.270399957895279*x_63 + 8.28127956390381) - 0.0379263074774949*std::sin(0.155440032482147*x_64 - 4.47199964523315) + 0.012933050395145*std::sin(0.289519935846329*x_65 - 4.28743982315063) - 0.0508157062836876*std::sin(0.292959928512573*x_65 + 5.12455987930298) + 0.0174197802687856*std::sin(0.295599937438965*x_65 - 4.2902398109436) + 0.0634690568740437*std::sin(0.162640020251274*x_66 + 4.94399976730347) + 0.0257140274762589*std::sin(0.230159983038902*x_66 + 5.02184009552002) + 0.00991322876558664*std::sin(0.262159943580627*x_66 - 7.51416015625) - 0.101852919361492*std::sin(0.20168000459671*x_67 + 4.99440002441406) + 0.025785386435801*std::sin(0.183040007948875*x_68 - 4.43607997894287) - 0.0128043412920553*std::sin(0.196959987282753*x_68 + 4.98943948745728) - 0.00758081708805496*std::sin(0.353599846363068*x_68 + 8.35048007965088) + 0.035461518885338*std::sin(0.156880035996437*x_69 - 4.47191953659058) + 0.0844346422013535*std::sin(0.174560010433197*x_69 - 4.44608020782471) + 0.0193008931653711*std::sin(0.238479986786842*x_69 + 5.03991985321045) - 0.0196831274329179*std::sin(0.298639923334122*x_7 - 1.02047991752625) - 0.041564649336255*std::sin(0.274159938097*x_70 + 1.88463997840881) - 0.00199540181685054*std::sin(0.332239836454391*x_70 - 4.28344011306763) + 0.104851400013928*std::sin(0.128320053219795*x_71 - 4.51495981216431) - 0.129402086104929*std::sin(0.138400033116341*x_73 + 4.90935945510864) - 0.0357692963078807*std::sin(0.15776002407074*x_73 + 4.92848014831543) - 0.00237577348752641*std::sin(0.470879852771759*x_73 + 2.04903984069824) - 0.0819642337092281*std::sin(0.195040002465248*x_74 + 4.98744010925293) - 0.0115478546013443*std::sin(0.305599927902222*x_74 + 5.12239980697632) - 0.0197145201593918*std::sin(0.312799841165543*x_74 + 5.11303997039795) - 0.00812851513855707*std::sin(0.326879858970642*x_74 - 4.27383995056152) - 0.0510469394041646*std::sin(0.19055999815464*x_75 + 4.97583961486816) + 0.0144155473967122*std::sin(0.202880010008812*x_75 - 4.40423965454102) + 0.0490057514712359*std::sin(0.285679936408997*x_75 - 7.48791980743408) + 0.0660023123197045*std::sin(0.191040009260178*x_76 + 4.97191953659058) + 0.0101994282839435*std::sin(0.227039992809296*x_77 - 7.55208015441895) - 0.0103741585279838*std::sin(0.321919828653336*x_77 - 4.29168033599854) + 0.00546160535677021*std::sin(0.332159847021103*x_77 - 1.0759197473526) + 0.0395819667302066*std::sin(0.221759989857674*x_78 + 5.01408004760742) - 0.00778162001621669*std::sin(0.377519845962524*x_78 + 5.1831202507019) + 0.0146829619860536*std::sin(0.286319941282272*x_79 + 5.09559965133667) - 0.00349122156814707*std::sin(0.487999856472015*x_79 - 7.32823991775513) - 0.0292540894342806*std::sin(0.202159985899925*x_8 - 4.39463996887207) - 0.0510152128210381*std::sin(0.273039966821671*x_8 - 4.31079959869385) - 0.0228926114530819*std::sin(0.169440016150475*x_80 - 7.63960027694702) + 0.017994705808301*std::sin(0.249199971556664*x_80 + 5.05807971954346) - 0.0090554414309381*std::sin(0.313839852809906*x_80 - 4.29152011871338) + 0.0467377483649302*std::sin(0.193200007081032*x_81 - 7.60736036300659) - 0.0123519091106203*std::sin(0.360079854726791*x_81 - 4.23920011520386) - 0.00521255497928385*std::sin(0.36831983923912*x_81 - 7.42639970779419) - 0.00721625423484347*std::sin(0.209600001573563*x_82 + 8.20239925384521) + 0.0516310319178683*std::sin(0.155760034918785*x_83 + 4.93103981018066) - 0.00746625982952135*std::sin(0.302159935235977*x_84 + 5.14359951019287) + 0.0408176950765077*std::sin(0.322719842195511*x_84 + 5.12712001800537) + 0.00943958488397866*std::sin(0.390079826116562*x_84 + 5.18688011169434) + 0.0200891388081061*std::sin(0.238879978656769*x_85 + 5.03191947937012) - 0.00827301038045444*std::sin(0.346639841794968*x_85 - 4.24584007263184) + 0.0078627041235485*std::sin(0.391279846429825*x_86 - 4.19704008102417) + 0.0933494114427891*std::sin(0.152880027890205*x_87 - 7.64616012573242) - 0.00857009961425256*std::sin(0.345679849386215*x_88 - 4.25648021697998) + 0.00704134545084515*std::sin(0.572799861431122*x_88 - 0.833039879798889) + 0.0597904339764619*std::sin(0.180400013923645*x_89 + 4.9684796333313) + 0.0492942237637628*std::sin(0.240079984068871*x_9 - 4.34311962127686) - 0.0174376023005722*std::sin(0.400879859924316*x_9 - 0.971039831638336) + 0.00464986680106179*std::sin(0.627359867095947*x_9 - 6.96623992919922) - 0.0196701607651301*std::sin(0.374399840831757*x_92 + 2.0020797252655) - 0.0189810864860696*std::sin(0.340079843997955*x_93 - 7.4270396232605) - 0.0136613142161015*std::sin(0.358159840106964*x_93 - 7.40423965454102) - 0.0184927395142199*std::sin(0.361279845237732*x_93 + 2.00159978866577) - 0.0367050681394861*std::sin(0.36151984333992*x_93 - 7.41088008880615) - 0.00394126677266298*std::sin(0.380799859762192*x_94 + 1.97039985656738) - 0.00668153687734481*std::sin(0.384719848632813*x_94 + 2.0019998550415) - 0.015140397077176*std::sin(0.396719843149185*x_94 - 7.39343976974487) - 0.00953533212572889*std::sin(0.353599846363068*x_95 + 1.95167982578278) - 0.00581048477894114*std::sin(0.357599824666977*x_95 - 7.42639970779419) - 0.00833802699775944*std::sin(0.358639866113663*x_95 - 7.41207981109619) - 0.00887558011790126*std::sin(0.364079833030701*x_95 + 5.16887998580933) + 0.017818321459584*std::sin(0.393039852380753*x_96 + 5.19248008728027) - 0.0148634602499854*std::sin(0.395359843969345*x_96 - 7.38895988464355) - 0.00325128059545329*std::sin(0.414799869060516*x_96 + 8.39535999298096) - 0.0153175209808711*std::sin(0.415759861469269*x_96 - 7.37639951705933) + 0.021150644720118*std::sin(0.33519983291626*x_97 - 7.44375991821289) - 0.0147823584044318*std::sin(0.343839854001999*x_98 + 1.95423984527588) + 0.00479465712557573*std::sin(0.410319864749908*x_98 - 7.4031195640564) + 0.00972059102370326*std::sin(0.41839987039566*x_98 + 2.01895976066589) + 0.0099031916468627*std::sin(0.310559868812561*x_99 - 7.46631956100464) + 0.00843088692165286*std::sin(0.389679849147797*x_99 - 7.41063976287842) - 0.00704153389650079*std::sin(0.397759854793549*x_99 + 1.99927973747253) + 0.0118423315455946*std::sin(0.409279853105545*x_99 - 7.38895988464355) - 3.86403226852417*std::sin(0.00350506726436851*x_100 + 0.0024330396431281*x_101 + 0.000824581565406834*x_102 - 0.000737023693044541*x_103 - 0.00158534403317454*x_107 + 0.000506392339486518*x_109 - 0.00386106166453816*x_11 + 0.00598709827530248*x_113 + 0.00192998373329109*x_116 + 0.00460409222148165*x_12 + 0.0036884917442821*x_13 + 0.000770930487321945*x_16 + 0.00363366746644636*x_17 - 0.00110827393787647*x_18 + 2.24602430493073e-5*x_19 + 0.00120153576119367*x_2 - 0.00807246206862869*x_20 - 0.00802753465111321*x_22 - 0.00780192963271459*x_25 - 0.00804278146017568*x_29 + 0.00150863246099382*x_3 - 0.00344805054015254*x_30 - 0.0147375963504599*x_31 - 0.000370885003769547*x_32 + 0.00360218943501115*x_34 - 0.00200487096349495*x_39 + 0.00430233384475972*x_4 + 0.000507500952906377*x_41 + 0.00272889849389866*x_42 - 0.000289593511266065*x_44 + 0.000452890689056213*x_45 - 0.000253137385750082*x_47 + 0.00864447553166243*x_48 - 0.00492311675257426*x_5 + 0.000128475637985072*x_52 - 0.00232520967150101*x_55 - 0.001340088849547*x_58 + 0.000957494172696575*x_6 - 0.00172314007597346*x_61 - 0.00201226063908485*x_62 - 0.00131698032008583*x_63 + 0.00342371867497098*x_64 + 0.00121597621983699*x_65 + 0.00139360627795556*x_69 - 0.000643786796256217*x_71 - 0.00127351809366188*x_76 + 0.000278990158879789*x_78 - 9.65382504371432e-5*x_79 - 0.00071705744910102*x_8 + 0.000456914704612209*x_81 + 0.00452103149814455*x_83 + 0.00182717095545863*x_88 + 0.000935664742522239*x_90 - 0.00854350025611136*x_91 - 0.00153183261311709*x_92 - 0.00233740104888064*x_97 + 0.000300781149968159*x_99 + 0.000244645777674432*std::pow(-3.28623986244202*x_14 - 4.83031988143921, 2) - 7.33366178927472e-5*std::pow(-3.721519947052*x_56 - 5.28943967819214, 2) + 5.79051958838244e-5*std::pow(-5.1267204284668*x_66 - 7.49520015716553, 2) + 5.05249492587046e-5*std::pow(-6.21640014648438*x_67 - 8.61551952362061, 2) + 9.71436343377924e-5*std::pow(-5.43391990661621*x_7 - 8.85800075531006, 2) - 0.000304523225536419*std::pow(-2.52336001396179*x_72 - 3.5783998966217, 2) - 4.03994796279051e-5*std::pow(-6.69712018966675*x_86 - 9.7344799041748, 2) + 0.046704048237967*std::sin(0.341919839382172*x_1 - 4.35288000106812) + 0.162775714938626*std::sin(0.270319938659668*x_10 - 7.50264024734497) + 0.0201910370517489*std::sin(0.428879857063293*x_104 + 5.22983980178833) - 0.0369615056079167*std::sin(0.37391984462738*x_105 - 7.43215990066528) - 0.0152713063107197*std::sin(0.442479848861694*x_106 + 5.22079992294312) - 0.043128971827028*std::sin(0.296719938516617*x_108 - 7.49255990982056) - 0.0301666403749417*std::sin(0.36959981918335*x_110 - 7.41879987716675) + 0.0436386777574886*std::sin(0.253279983997345*x_111 - 4.3439998626709) - 0.0583624573231116*std::sin(0.350879848003387*x_112 - 4.24528026580811) + 0.0386446937810931*std::sin(0.181760013103485*x_114 - 1.20503985881805) - 0.0390045530789616*std::sin(0.3642398416996*x_115 - 7.42384004592896) + 0.0237571819212464*std::sin(0.363599836826324*x_117 - 7.42176008224487) - 0.00788924691966564*std::sin(0.450399875640869*x_118 + 5.2403998374939) - 0.0219188295323669*std::sin(0.367199838161469*x_119 + 8.1812801361084) - 0.0430992057641335*std::sin(0.302719920873642*x_120 - 7.48975992202759) - 0.0678207340525194*std::sin(0.254239976406097*x_15 - 1.0914398431778) + 0.0578533474029381*std::sin(0.364319831132889*x_21 + 8.36192035675049) + 0.0623068809644667*std::sin(0.341359853744507*x_23 - 4.26792001724243) + 0.0435632979593252*std::sin(0.437999874353409*x_24 + 8.44855976104736) + 0.0632390617244054*std::sin(0.319279849529266*x_26 - 4.28200006484985) + 0.0754609520265523*std::sin(0.366799861192703*x_27 - 4.24416017532349) - 0.0507374358888273*std::sin(0.333199828863144*x_28 - 4.27544021606445) - 0.0581206562941401*std::sin(0.295999944210052*x_33 - 1.16031992435455) - 0.0501041525653081*std::sin(0.331839829683304*x_35 + 1.95959985256195) + 0.0549526859156222*std::sin(0.358079850673676*x_36 + 5.17239999771118) + 0.079038109305777*std::sin(0.389999836683273*x_37 + 5.19632005691528) - 0.0496894499855858*std::sin(0.262399971485138*x_38 - 7.52008008956909) + 0.022695405097893*std::sin(0.309679925441742*x_40 - 7.48591995239258) + 0.0413403484005155*std::sin(0.364639848470688*x_43 - 4.23912000656128) + 0.0121423935543123*std::sin(0.29479992389679*x_46 + 5.11055994033813) - 0.0330513129388903*std::sin(0.35455983877182*x_49 - 7.43215990066528) - 0.0764370446195528*std::sin(0.249039962887764*x_50 + 5.05631971359253) - 0.0362499588988912*std::sin(0.300319939851761*x_51 - 4.28999948501587) - 0.0643168274711261*std::sin(0.290879935026169*x_53 + 5.103919506073) - 0.0745319890331348*std::sin(0.26215997338295*x_54 - 7.52416038513184) + 0.0311458301543475*std::sin(0.254079967737198*x_57 - 7.52976036071777) + 0.0396736900386547*std::sin(0.367759823799133*x_59 - 4.2294397354126) - 0.0741621594822552*std::sin(0.245839968323708*x_60 - 7.53416013717651) - 0.154981168196835*std::sin(0.196959987282753*x_68 + 4.9846396446228) - 0.0598523521253669*std::sin(0.242239981889725*x_70 - 7.54864025115967) + 0.0431191945022023*std::sin(0.275279968976974*x_73 + 5.07599973678589) + 0.0624095876620374*std::sin(0.274639964103699*x_74 - 4.31271982192993) + 0.085541945816181*std::sin(0.246879979968071*x_75 + 5.0577597618103) + 0.0677582735524873*std::sin(0.178640007972717*x_77 - 7.62040042877197) + 0.0895394178182363*std::sin(0.177920013666153*x_80 - 7.6255202293396) + 0.17522152596113*std::sin(0.193039998412132*x_82 + 4.98015975952148) + 0.0831984884895487*std::sin(0.249119967222214*x_84 + 5.05751991271973) + 0.163889902770638*std::sin(0.164800018072128*x_85 - 7.63064002990723) + 0.0641227486068785*std::sin(0.259839981794357*x_87 + 5.06343984603882) - 0.0210011924569778*std::sin(0.341119825839996*x_89 - 4.27016019821167) - 0.216326185021977*std::sin(0.178000003099442*x_9 - 4.42439985275269) - 0.0607281978551608*std::sin(0.335999846458435*x_93 + 1.99351978302002) - 0.0101513281712285*std::sin(0.411759853363037*x_94 - 4.18368005752563) + 0.024771381276015*std::sin(0.374639838933945*x_95 - 7.41559982299805) - 0.0323726914917957*std::sin(0.383999854326248*x_96 - 7.40655994415283) + 0.0206904661111893*std::sin(0.362719833850861*x_98 - 7.41815996170044) + 1.64285605161304) + 3.31125197024933);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00684223038633319*x_1 - 8.59005728653373e-5*x_10 + 0.00396543322261433*x_100 - 0.000788924360385514*x_101 - 0.00101807189030241*x_102 + 0.000707741394357073*x_103 + 0.000150343535045656*x_104 - 0.000438287062373766*x_105 + 0.000119032243214209*x_106 - 0.000581369669056226*x_107 + 0.000283494811050541*x_108 + 0.0018227121588137*x_109 - 0.00211183941574047*x_11 + 0.0021962884342523*x_110 - 0.000624237230457286*x_112 + 0.00390108256104832*x_113 - 0.000265908916507081*x_114 + 0.000721287456836423*x_116 - 0.000303045342481749*x_117 + 2.81807964198597e-5*x_118 + 2.4057300283256e-5*x_119 + 0.00168839035256421*x_12 - 0.000365293830222686*x_120 + 0.00246947485780434*x_13 + 0.00263195510874233*x_14 - 8.28691174355508e-5*x_15 + 0.000282711886442865*x_16 + 0.00137606724472672*x_17 + 0.000599653678533201*x_18 - 0.000312710945614171*x_19 - 0.00262015088139536*x_2 + 0.00154232937759587*x_20 - 0.000220918646349826*x_21 - 0.00408680584270952*x_22 - 9.07969110639505e-5*x_23 + 0.000291567653639165*x_24 - 0.00681675628572479*x_25 + 0.000320484307271638*x_26 + 0.000115034288285272*x_28 - 0.00203283147603695*x_29 + 0.00389628722155262*x_3 - 0.000666506434033803*x_30 - 0.00983490581468596*x_31 + 0.0049570104106055*x_32 - 0.00120685855246868*x_33 + 0.00134009300817933*x_34 + 0.000456317826338649*x_36 + 0.000770631450862207*x_37 + 0.00279234508057241*x_39 + 0.00501022823523433*x_4 + 0.000243376893915696*x_40 - 0.000277358345437419*x_41 + 0.00301791176699434*x_42 - 2.44994797624418e-5*x_43 - 4.27728590109213e-5*x_44 + 0.000166081875293669*x_45 + 0.00028397574710599*x_46 - 9.28293134485095e-5*x_47 - 0.000236371919714946*x_48 - 8.48289588223277e-5*x_49 + 0.001131801346855*x_5 - 0.000549304074756059*x_50 + 0.00076427796251757*x_51 + 0.00315281691774373*x_52 + 0.000473037183226471*x_53 - 0.000590793003320554*x_54 - 0.000652344743948667*x_55 + 2.00610672799772e-5*x_56 + 0.000182816451888623*x_57 - 0.000345407920666624*x_58 - 0.00143427890904752*x_59 - 0.00119978409389002*x_6 + 0.000425846915895025*x_60 + 0.00135654546939295*x_61 - 0.000361116316904819*x_62 + 0.00224562056955312*x_63 + 0.00191804392692615*x_64 + 0.000759802438649784*x_65 + 0.000359501424384905*x_66 - 8.20109864401992e-6*x_67 + 0.000128996862026826*x_69 + 0.000483924089511806*x_70 - 0.000228979825989209*x_71 + 0.000605273824075803*x_72 - 7.05760171980344e-6*x_73 - 0.00324676468176987*x_76 - 0.000270153726553301*x_77 + 0.000226987679207377*x_78 - 7.40285879791997e-5*x_79 - 0.00314877606656578*x_8 - 0.000154829375872083*x_80 + 0.000167557542746987*x_81 + 0.000775387225789307*x_82 + 0.00125514001709441*x_83 + 0.000579923216235315*x_86 + 0.000825613083329418*x_87 + 0.000236527263903748*x_88 - 0.00108198076402058*x_89 + 0.000429093169354125*x_9 + 0.000460195930502855*x_90 + 0.000812110853758589*x_91 - 0.00185475408026865*x_92 - 0.000580935711456683*x_94 - 0.000963322125198992*x_97 + 0.00036871526953905*x_98 + 0.000110301003413868*x_99 + 8.97153121507529e-5*std::pow(-3.28623986244202*x_14 - 4.83031988143921, 2) - 3.16155010133039e-5*std::pow(-5.59087991714478*x_17 - 8.77711963653564, 2) - 6.19600907972962e-5*std::pow(-4.67167949676514*x_17 - 6.90744018554688, 2) - 0.000203650020346785*std::pow(-1.91071999073029*x_18 - 2.75584006309509, 2) - 2.39258971812476e-5*std::pow(-6.07679986953735*x_22 - 9.73752021789551, 2) + 4.77523113916339e-5*std::pow(-6.36255979537964*x_23 - 8.93599987030029, 2) + 7.44256499416391e-5*std::pow(-4.91200017929077*x_4 - 8.39608001708984, 2) + 7.57072083695416e-6*std::pow(-3.57223987579346*x_47 - 6.35407972335815, 2) + 2.79478335111401e-5*std::pow(-3.41503977775574*x_5 - 5.42375993728638, 2) - 2.68936485594451e-5*std::pow(-3.721519947052*x_56 - 5.28943967819214, 2) - 1.17513697870235e-5*std::pow(-5.77103996276855*x_58 - 7.56695985794067, 2) - 4.67327749150296e-6*std::pow(-5.90503978729248*x_6 - 9.16919994354248, 2) - 0.000119635473735464*std::pow(-2.89567995071411*x_6 - 4.63944005966187, 2) + 2.12347123798766e-5*std::pow(-5.1267204284668*x_66 - 7.49520015716553, 2) + 1.06720625493501e-5*std::pow(-6.9987998008728*x_67 - 9.77744007110596, 2) + 1.852826415904e-5*std::pow(-6.21640014648438*x_67 - 8.61551952362061, 2) - 1.56929691511293e-6*std::pow(-5.79999971389771*x_67 - 10.0, 2) + 1.00659394585622e-5*std::pow(-3.71591997146606*x_68 - 4.97343969345093, 2) + 6.68849842714392e-5*std::pow(-5.72896003723145*x_7 - 8.99792003631592, 2) + 2.07146637651433e-6*std::pow(-5.51319980621338*x_7 - 8.79199981689453, 2) + 3.56240420779782e-5*std::pow(-5.43391990661621*x_7 - 8.85800075531006, 2) + 5.0816712055792e-5*std::pow(-5.27688026428223*x_7 - 8.52688026428223, 2) - 2.61885182992157e-5*std::pow(-6.60000038146973*x_71 - 9.96463966369629, 2) - 1.46962568889656e-5*std::pow(-7.60000038146973*x_72 - 9.99660015106201, 2) - 0.000111673279203335*std::pow(-2.52336001396179*x_72 - 3.5783998966217, 2) + 5.24167707671311e-6*std::pow(-6.59600019454956*x_75 - 9.96208000183105, 2) - 1.21578924787751e-5*std::pow(-6.40000009536743*x_78 - 9.99993991851807, 2) + 9.59370550583733e-6*std::pow(-7.19984006881714*x_81 - 9.79320049285889, 2) - 6.1645994429715e-6*std::pow(-4.73992013931274*x_82 - 7.30111980438232, 2) - 2.46074464889672e-5*std::pow(-5.49191999435425*x_83 - 7.52191972732544, 2) - 3.03873254268711e-5*std::pow(-4.27015972137451*x_84 - 6.41544008255005, 2) + 3.67098114181057e-5*std::pow(-3.90391993522644*x_85 - 6.36783981323242, 2) - 2.83472919735505e-5*std::pow(-3.28543996810913*x_85 - 7.1800799369812, 2) - 1.48151010820584e-5*std::pow(-6.69712018966675*x_86 - 9.7344799041748, 2) - 9.92358880066829e-6*std::pow(-4.22168016433716*x_86 - 6.42952013015747, 2) - 1.26276323053592e-5*std::pow(-4.28991985321045*x_87 - 6.95071983337402, 2) - 9.0356234289963e-6*std::pow(-3.91824007034302*x_87 - 5.3600001335144, 2) - 1.09210418319208e-5*std::pow(-4.93191957473755*x_88 - 5.71687984466553, 2) - 2.81314445967808e-6*std::pow(-5.10663986206055*x_89 - 7.55287981033325, 2) - 3.63259090773483e-5*std::pow(-4.09903955459595*x_89 - 5.94736003875732, 2) + 2.73120145917315e-5*std::pow(-6.60000038146973*x_90 - 9.96016025543213, 2) + 8.1379504058959e-6*std::pow(-5.74399995803833*x_90 - 7.7992000579834, 2) + 2.70018713405337e-5*std::pow(-4.90768003463745*x_90 - 7.15335988998413, 2) - 0.00045250121929501*std::exp(1.29391980171204*x_17) + 0.00202658577925668*std::exp(0.730479836463928*x_22) + 0.000362589126629396*std::exp(0.602479875087738*x_29) + 0.00697245530688172*std::sin(0.225279986858368*x_1 - 4.18847990036011) - 0.0255622130605426*std::sin(0.281839966773987*x_1 + 2.15455985069275) + 0.0171270818822349*std::sin(0.341919839382172*x_1 - 4.35288000106812) + 0.0596923201172705*std::sin(0.270319938659668*x_10 - 7.50264024734497) - 0.0232781468028286*std::sin(0.34623983502388*x_10 - 1.06567978858948) - 0.027552654438914*std::sin(0.36847984790802*x_10 + 5.17600011825562) - 0.0162518138131936*std::sin(0.316399842500687*x_101 - 4.24911975860596) + 0.00561819214145278*std::sin(0.301919937133789*x_102 + 5.10527992248535) - 0.00245550879221749*std::sin(0.397359818220139*x_102 + 1.99735975265503) - 0.00807823317094519*std::sin(0.300079941749573*x_103 + 5.10311985015869) - 0.00115379939744628*std::sin(0.416559875011444*x_103 + 5.21712017059326) - 0.00478069118057743*std::sin(0.394079834222794*x_104 - 7.39215993881226) + 0.0117165314762151*std::sin(0.398559838533401*x_104 + 5.20975971221924) - 0.0142090068009728*std::sin(0.40055987238884*x_104 + 5.20408010482788) + 0.00740435910631448*std::sin(0.428879857063293*x_104 + 5.22983980178833) - 0.0266301461345537*std::sin(0.162960022687912*x_105 - 7.63632011413574) + 0.0124982874115358*std::sin(0.324799835681915*x_105 + 8.32863998413086) - 0.013554343936354*std::sin(0.37391984462738*x_105 - 7.43215990066528) + 0.0171766656524995*std::sin(0.403519839048386*x_105 + 2.01263976097107) + 0.0107400545215228*std::sin(0.386079847812653*x_106 + 1.99143981933594) - 0.00626750044767554*std::sin(0.396559834480286*x_106 - 7.3874397277832) - 0.00531380827530477*std::sin(0.40055987238884*x_106 - 7.38775968551636) - 0.00560021932787753*std::sin(0.442479848861694*x_106 + 5.22079992294312) - 0.0214506353646778*std::sin(0.35455983877182*x_107 + 5.15592002868652) + 0.00774201793267526*std::sin(0.369519859552383*x_107 + 5.18247985839844) + 0.00271270357515043*std::sin(0.392639845609665*x_107 - 7.40319967269897) - 0.00204327225745638*std::sin(0.570399820804596*x_107 + 2.1801598072052) + 0.152261889721008*std::sin(0.127280056476593*x_108 + 1.72391986846924) - 0.0158160472131755*std::sin(0.296719938516617*x_108 - 7.49255990982056) + 0.0201354510064404*std::sin(0.388879835605621*x_108 + 5.17456007003784) - 0.0041392236358055*std::sin(0.3504798412323*x_109 + 5.14728021621704) - 0.0130600370172487*std::sin(0.432159870862961*x_109 + 5.23464012145996) - 0.0173507823323465*std::sin(0.262559980154037*x_11 + 8.27199935913086) - 0.00985943362977341*std::sin(0.298159927129745*x_11 - 4.2611198425293) + 0.00330915318785584*std::sin(0.300399929285049*x_11 - 1.06567990779877) - 0.0110625639383771*std::sin(0.36959981918335*x_110 - 7.41879987716675) + 0.00238829547453239*std::sin(0.400079846382141*x_110 - 4.20775985717773) + 0.0160029640980327*std::sin(0.253279983997345*x_111 - 4.3439998626709) + 0.0043299287940009*std::sin(0.355199843645096*x_111 - 4.24304008483887) - 0.0123116900761996*std::sin(0.357679843902588*x_111 - 4.2388801574707) - 0.0268091352559934*std::sin(0.388959854841232*x_111 + 5.20007991790771) + 0.00137481225811102*std::sin(0.762639880180359*x_111 - 1.20167982578278) - 0.0214023970754807*std::sin(0.350879848003387*x_112 - 4.24528026580811) - 0.01280626662729*std::sin(0.362399846315384*x_112 + 5.16552019119263) - 0.00392604288070409*std::sin(0.372479856014252*x_112 - 7.41504001617432) + 0.00406306545541231*std::sin(0.377519845962524*x_113 - 7.42136001586914) + 0.0141715945335253*std::sin(0.181760013103485*x_114 - 1.20503985881805) - 0.00324432531586222*std::sin(0.321759849786758*x_114 + 5.13535976409912) - 0.0244459229858845*std::sin(0.32423985004425*x_114 + 5.132080078125) - 0.00958596809169379*std::sin(0.389039844274521*x_114 - 7.40039968490601) - 0.0365676089170737*std::sin(0.189999997615814*x_115 - 7.61768007278442) - 0.0167575463111991*std::sin(0.230639979243279*x_115 + 1.83319985866547) + 0.00240187298509619*std::sin(0.33231982588768*x_115 + 5.14056015014648) - 0.0143035603885894*std::sin(0.3642398416996*x_115 - 7.42384004592896) - 0.00451103721192881*std::sin(0.491039872169495*x_115 - 4.1386399269104) - 0.0327602811291386*std::sin(0.260159969329834*x_116 - 4.30823993682861) + 0.0146374350478631*std::sin(0.453839868307114*x_116 + 8.24575996398926) - 0.0206341526933492*std::sin(0.240879982709885*x_117 - 7.5633602142334) - 0.00227737694241226*std::sin(0.355279833078384*x_117 - 7.42416000366211) + 0.00871211844384757*std::sin(0.363599836826324*x_117 - 7.42176008224487) + 0.0252784732915078*std::sin(0.413519859313965*x_117 + 5.20032024383545) - 0.00492276650358194*std::sin(0.322159856557846*x_118 + 1.92447984218597) + 0.0126532480636025*std::sin(0.345439821481705*x_118 + 5.1592001914978) - 0.0028931063383161*std::sin(0.450399875640869*x_118 + 5.2403998374939) - 0.011814333964082*std::sin(0.299039930105209*x_119 + 5.09831953048706) - 0.00803796677861469*std::sin(0.367199838161469*x_119 + 8.1812801361084) - 0.0192680181543338*std::sin(0.369119822978973*x_119 + 1.97495973110199) - 0.0269851762099572*std::sin(0.249199971556664*x_12 + 5.06543970108032) + 0.00643638266088236*std::sin(0.283599942922592*x_12 + 8.31063938140869) + 0.021716239130538*std::sin(0.318879842758179*x_12 - 4.26143980026245) - 0.0219331243814765*std::sin(0.342079848051071*x_12 + 8.34247970581055) - 0.0158051315470665*std::sin(0.302719920873642*x_120 - 7.48975992202759) + 0.0164342550868389*std::sin(0.482079833745956*x_120 + 2.02687978744507) + 0.0013464380284219*std::sin(0.417599856853485*x_13 - 7.16351985931396) + 0.0344842953426336*std::sin(0.23319998383522*x_14 + 8.24967956542969) - 0.00237484756727537*std::sin(0.351519852876663*x_14 - 1.0487197637558) - 0.0248708904100203*std::sin(0.254239976406097*x_15 - 1.0914398431778) - 0.0346079044926347*std::sin(0.417839854955673*x_15 + 2.22183990478516) - 0.00428948422000146*std::sin(0.313599914312363*x_16 - 4.26719999313354) - 0.0235543126673501*std::sin(0.321199834346771*x_16 - 4.25663995742798) - 0.0176221057784068*std::sin(0.373839825391769*x_16 + 2.15111970901489) - 0.0155811745752164*std::sin(0.402399867773056*x_16 + 5.189040184021) - 0.00189145896342367*std::sin(0.237599983811378*x_18 - 4.33536005020142) - 0.0391537740386313*std::sin(0.238399982452393*x_19 - 4.33599996566772) - 0.0277436767144124*std::sin(0.254319965839386*x_19 - 4.31472015380859) - 0.0174022157960841*std::sin(0.311999946832657*x_21 - 4.27687978744507) - 0.0193138156743431*std::sin(0.333199828863144*x_21 - 4.25576019287109) + 0.0212156987566232*std::sin(0.364319831132889*x_21 + 8.36192035675049) - 0.0113109948254101*std::sin(0.222559988498688*x_23 - 4.36664009094238) + 0.0228488769681764*std::sin(0.341359853744507*x_23 - 4.26792001724243) - 0.0053403417244894*std::sin(0.477199852466583*x_23 - 7.31928014755249) + 0.0390744940010533*std::sin(0.359199821949005*x_24 + 2.12399983406067) - 0.00799020630784643*std::sin(0.382639855146408*x_24 + 5.38751983642578) + 0.0159753211843214*std::sin(0.437999874353409*x_24 + 8.44855976104736) + 0.0231907217719323*std::sin(0.319279849529266*x_26 - 4.28200006484985) - 0.00406671103256598*std::sin(0.327199846506119*x_26 - 4.26272010803223) + 0.0306872072330296*std::sin(0.350639849901199*x_27 + 8.32791996002197) - 0.00480150457783156*std::sin(0.366399854421616*x_27 + 5.17136001586914) + 0.0276726740621066*std::sin(0.366799861192703*x_27 - 4.24416017532349) - 0.0103415129152943*std::sin(0.444319844245911*x_27 - 0.939439833164215) - 0.0069949774283715*std::sin(0.536719858646393*x_27 - 4.05399990081787) - 0.0153600351335846*std::sin(0.311599940061569*x_28 + 5.12759971618652) - 0.00845325744648238*std::sin(0.320399850606918*x_28 - 4.2739200592041) - 0.0186061862246915*std::sin(0.333199828863144*x_28 - 4.27544021606445) - 0.00838352844099956*std::sin(0.348239839076996*x_28 - 4.23992013931274) - 0.0161297618837267*std::sin(0.342559844255447*x_3 - 4.24079990386963) + 0.0252496239450628*std::sin(0.376959830522537*x_3 - 1.01671981811523) + 0.00234067355878466*std::sin(0.296799927949905*x_30 - 4.29607963562012) - 0.0213137249757667*std::sin(0.295999944210052*x_33 - 1.16031992435455) - 0.0169141233965578*std::sin(0.352079838514328*x_34 + 1.99303984642029) - 0.00397235297263622*std::sin(0.356959849596024*x_34 + 1.98511981964111) + 0.0394315995690851*std::sin(0.360879838466644*x_34 + 1.99647974967957) - 0.0222379281877614*std::sin(0.307439923286438*x_35 - 1.14431989192963) + 0.0214276243551283*std::sin(0.312399834394455*x_35 - 7.41991996765137) - 0.0246782028287952*std::sin(0.316639840602875*x_35 + 1.94799983501434) - 0.0183739516380599*std::sin(0.331839829683304*x_35 + 1.95959985256195) - 0.00217043976428892*std::sin(0.333759844303131*x_35 + 1.97559976577759) - 0.0134725139394032*std::sin(0.345039844512939*x_36 - 7.4507999420166) + 0.0201519822549448*std::sin(0.358079850673676*x_36 + 5.17239999771118) + 0.00238730065742581*std::sin(0.361599832773209*x_36 - 4.23776006698608) - 0.0119469461088601*std::sin(0.305039942264557*x_37 + 5.12063980102539) + 0.0111947047015322*std::sin(0.369439840316772*x_37 + 5.18287992477417) - 0.00647277109828731*std::sin(0.385359823703766*x_37 + 5.19280004501343) + 0.0289844718170838*std::sin(0.389999836683273*x_37 + 5.19632005691528) + 0.0363328213820628*std::sin(0.218799993395805*x_38 + 5.01575994491577) - 0.0182218739208674*std::sin(0.262399971485138*x_38 - 7.52008008956909) - 0.00962312695202129*std::sin(0.320239841938019*x_38 + 5.11552000045776) - 0.0257757575590811*std::sin(0.344159841537476*x_38 + 5.13088035583496) - 0.00614293395983874*std::sin(0.367359846830368*x_38 + 5.17296028137207) + 0.0151403718811563*std::sin(0.352319836616516*x_39 - 7.42647981643677) - 0.0286252863026099*std::sin(0.2291199862957*x_40 + 5.04504013061523) + 0.00832274880073706*std::sin(0.309679925441742*x_40 - 7.48591995239258) - 0.0252494170544708*std::sin(0.317279845476151*x_40 - 7.46495962142944) - 0.0267306327270038*std::sin(0.333999842405319*x_41 + 5.14592027664185) - 0.00724708426549196*std::sin(0.341359823942184*x_41 + 1.95199990272522) + 0.0149993155095843*std::sin(0.317679852247238*x_42 + 8.32288074493408) - 0.0220859302841902*std::sin(0.355359852313995*x_43 + 5.16279983520508) - 0.0235545433040323*std::sin(0.360879838466644*x_43 + 5.16096019744873) + 0.0151601319116522*std::sin(0.364639848470688*x_43 - 4.23912000656128) - 0.022349702705904*std::sin(0.269999951124191*x_44 - 4.30319976806641) - 0.018422319334658*std::sin(0.329999834299088*x_44 + 5.11872005462646) - 0.0155464691797699*std::sin(0.328879833221436*x_45 - 7.44984006881714) - 0.00373680775174016*std::sin(0.341919839382172*x_45 + 5.13479995727539) + 0.0227112231214315*std::sin(0.351679861545563*x_45 + 5.14408016204834) - 0.00850179912750374*std::sin(0.35471984744072*x_45 + 8.35632038116455) - 0.0250456345238407*std::sin(0.246319979429245*x_46 - 7.53096008300781) + 0.00445279962866195*std::sin(0.29479992389679*x_46 + 5.11055994033813) - 0.00199779713591875*std::sin(0.347519844770432*x_46 - 4.24232006072998) - 0.0142939349995741*std::sin(0.29215994477272*x_47 - 7.47575998306274) - 0.0255024090726515*std::sin(0.324559837579727*x_47 - 4.27048015594482) - 0.015575520627509*std::sin(0.336879849433899*x_47 - 4.26936006546021) - 0.0162155712641178*std::sin(0.300879925489426*x_48 + 5.12215948104858) + 0.0186600446003054*std::sin(0.337039858102798*x_49 + 5.13264036178589) - 0.0121204170596837*std::sin(0.35455983877182*x_49 - 7.43215990066528) - 0.00736166110036196*std::sin(0.433759868144989*x_49 - 4.17463970184326) - 0.0312825166984903*std::sin(0.246479973196983*x_50 - 7.53216028213501) - 0.0280306220001479*std::sin(0.249039962887764*x_50 + 5.05631971359253) + 0.0126375034093296*std::sin(0.31879985332489*x_50 + 5.11704015731812) + 0.0030974621259359*std::sin(0.366719841957092*x_50 + 5.16960000991821) - 0.0113616505839832*std::sin(0.22647999227047*x_51 - 7.58319997787476) - 0.0132934089808568*std::sin(0.300319939851761*x_51 - 4.28999948501587) - 0.00487345526880302*std::sin(0.338239848613739*x_51 - 4.25888013839722) - 0.004437778540687*std::sin(0.449919849634171*x_51 - 4.16607999801636) - 0.0290581108944562*std::sin(0.281759947538376*x_52 + 5.10095977783203) - 0.0150956383924859*std::sin(0.236559987068176*x_53 - 4.34311962127686) - 0.0235859547954146*std::sin(0.290879935026169*x_53 + 5.103919506073) - 0.00492372824253648*std::sin(0.305999934673309*x_53 + 5.12415981292725) - 0.0273320092620712*std::sin(0.26215997338295*x_54 - 7.52416038513184) + 0.00338578777212846*std::sin(0.324559837579727*x_54 - 4.27511978149414) - 0.00654986079542477*std::sin(0.350879848003387*x_54 + 2.13367986679077) - 0.029596221939557*std::sin(0.239439979195595*x_55 + 5.03903961181641) + 0.00435169679138528*std::sin(0.378319829702377*x_55 - 1.00887978076935) + 0.0382363728119419*std::sin(0.22503998875618*x_56 + 5.03327989578247) + 0.0055794306994732*std::sin(0.300399929285049*x_56 + 5.12975978851318) - 0.00449091485869514*std::sin(0.318239837884903*x_56 + 5.1159200668335) + 0.0114216476615842*std::sin(0.254079967737198*x_57 - 7.52976036071777) - 0.00634707972579458*std::sin(0.275119960308075*x_57 + 5.07976007461548) + 0.0194965273904574*std::sin(0.318639844655991*x_57 - 4.29200029373169) - 0.0521101193643435*std::sin(0.213919997215271*x_58 + 5.01063966751099) + 0.0157221391240138*std::sin(0.286479920148849*x_58 + 5.09591960906982) - 0.00199500113078646*std::sin(0.280559957027435*x_59 + 1.87903988361359) + 0.0145489430466558*std::sin(0.367759823799133*x_59 - 4.2294397354126) - 0.0235356059591876*std::sin(0.376079827547073*x_59 - 7.42407989501953) - 0.0271963871642156*std::sin(0.245839968323708*x_60 - 7.53416013717651) - 0.0236884152769171*std::sin(0.253439962863922*x_60 - 7.54631996154785) - 0.0284493029933086*std::sin(0.281599938869476*x_60 + 5.08191967010498) + 0.0033030886469141*std::sin(0.313439846038818*x_60 + 8.30096054077148) - 0.00278976301991841*std::sin(0.270399957895279*x_63 + 8.28127956390381) - 0.0142217897554883*std::sin(0.155440032482147*x_64 - 4.47199964523315) - 0.0139557001148382*std::sin(0.289519935846329*x_65 - 4.28743982315063) - 0.0439693204463041*std::sin(0.292959928512573*x_65 + 5.12455987930298) + 0.00653215324788678*std::sin(0.295599937438965*x_65 - 4.2902398109436) + 0.0560821922422576*std::sin(0.162640020251274*x_66 + 4.94399976730347) + 0.0222495837754722*std::sin(0.230159983038902*x_66 + 5.02184009552002) + 0.00371731034944254*std::sin(0.262159943580627*x_66 - 7.51416015625) - 0.0881303041385578*std::sin(0.20168000459671*x_67 + 4.99440002441406) - 0.0278243035825749*std::sin(0.183040007948875*x_68 - 4.43607997894287) - 0.0568339417685383*std::sin(0.196959987282753*x_68 + 4.9846396446228) - 0.0113141043091535*std::sin(0.196959987282753*x_68 + 4.98943948745728) - 0.00655945573064891*std::sin(0.353599846363068*x_68 + 8.35048007965088) + 0.031334319702855*std::sin(0.156880035996437*x_69 - 4.47191953659058) + 0.0730587865687524*std::sin(0.174560010433197*x_69 - 4.44608020782471) + 0.0072375420373821*std::sin(0.238479986786842*x_69 + 5.03991985321045) - 0.0173923009256688*std::sin(0.298639923334122*x_7 - 1.02047991752625) - 0.0219487640658564*std::sin(0.242239981889725*x_70 - 7.54864025115967) - 0.0359646558034898*std::sin(0.274159938097*x_70 + 1.88463997840881) - 0.000748245400209525*std::sin(0.332239836454391*x_70 - 4.28344011306763) + 0.0926482393478854*std::sin(0.128320053219795*x_71 - 4.51495981216431) - 0.11196777938309*std::sin(0.138400033116341*x_73 + 4.90935945510864) + 0.0385976670112538*std::sin(0.15776002407074*x_73 + 4.92848014831543) + 0.0158124617200716*std::sin(0.275279968976974*x_73 + 5.07599973678589) - 0.00209926839965388*std::sin(0.470879852771759*x_73 + 2.04903984069824) - 0.0709212155190236*std::sin(0.195040002465248*x_74 + 4.98744010925293) + 0.0228865410698017*std::sin(0.274639964103699*x_74 - 4.31271982192993) - 0.00433027023167809*std::sin(0.305599927902222*x_74 + 5.12239980697632) - 0.0174200400005476*std::sin(0.312799841165543*x_74 + 5.11303997039795) + 0.00877125783838354*std::sin(0.326879858970642*x_74 - 4.27383995056152) - 0.0451058265246417*std::sin(0.19055999815464*x_75 + 4.97583961486816) + 0.00540561151142832*std::sin(0.202880010008812*x_75 - 4.40423965454102) + 0.0313695271744865*std::sin(0.246879979968071*x_75 + 5.0577597618103) + 0.0424032203374571*std::sin(0.285679936408997*x_75 - 7.48791980743408) + 0.0571098393158363*std::sin(0.191040009260178*x_76 + 4.97191953659058) + 0.0248479851986132*std::sin(0.178640007972717*x_77 - 7.62040042877197) + 0.00382463082562147*std::sin(0.227039992809296*x_77 - 7.55208015441895) - 0.00897645106281061*std::sin(0.321919828653336*x_77 - 4.29168033599854) - 0.00589346860762963*std::sin(0.332159847021103*x_77 - 1.0759197473526) + 0.0349752080276762*std::sin(0.221759989857674*x_78 + 5.01408004760742) + 0.0083969328221832*std::sin(0.377519845962524*x_78 + 5.1831202507019) - 0.0158439817378162*std::sin(0.286319941282272*x_79 + 5.09559965133667) - 0.00308489473120267*std::sin(0.487999856472015*x_79 - 7.32823991775513) - 0.0109698395940461*std::sin(0.202159985899925*x_8 - 4.39463996887207) - 0.0441419475239034*std::sin(0.273039966821671*x_8 - 4.31079959869385) + 0.0247027894057115*std::sin(0.169440016150475*x_80 - 7.63960027694702) + 0.0328354607045372*std::sin(0.177920013666153*x_80 - 7.6255202293396) + 0.0155702841480754*std::sin(0.249199971556664*x_80 + 5.05807971954346) - 0.00339565311625338*std::sin(0.313839852809906*x_80 - 4.29152011871338) + 0.0404407846527567*std::sin(0.193200007081032*x_81 - 7.60736036300659) - 0.00463177847077206*std::sin(0.360079854726791*x_81 - 4.23920011520386) + 0.00562472517313472*std::sin(0.36831983923912*x_81 - 7.42639970779419) + 0.0642563875271696*std::sin(0.193039998412132*x_82 + 4.98015975952148) + 0.00778686210731165*std::sin(0.209600001573563*x_82 + 8.20239925384521) + 0.0193608534453438*std::sin(0.155760034918785*x_83 + 4.93103981018066) + 0.0305101458781104*std::sin(0.249119967222214*x_84 + 5.05751991271973) - 0.00279973413225921*std::sin(0.302159935235977*x_84 + 5.14359951019287) + 0.0353183384813963*std::sin(0.322719842195511*x_84 + 5.12712001800537) - 0.0101859972569827*std::sin(0.390079826116562*x_84 + 5.18688011169434) + 0.060100909671089*std::sin(0.164800018072128*x_85 - 7.63064002990723) + 0.00753312219142975*std::sin(0.238879978656769*x_85 + 5.03191947937012) + 0.00892717869249988*std::sin(0.346639841794968*x_85 - 4.24584007263184) + 0.00694760101880721*std::sin(0.391279846429825*x_86 - 4.19704008102417) + 0.0824849130596913*std::sin(0.152880027890205*x_87 - 7.64616012573242) + 0.023514783136319*std::sin(0.259839981794357*x_87 + 5.06343984603882) - 0.00321365730027408*std::sin(0.345679849386215*x_88 - 4.25648021697998) + 0.00609266695562435*std::sin(0.572799861431122*x_88 - 0.833039879798889) - 0.0645182181169549*std::sin(0.180400013923645*x_89 + 4.9684796333313) - 0.00770145536426611*std::sin(0.341119825839996*x_89 - 4.27016019821167) - 0.0793300885881446*std::sin(0.178000003099442*x_9 - 4.42439985275269) + 0.0435571012034809*std::sin(0.240079984068871*x_9 - 4.34311962127686) + 0.018816438581261*std::sin(0.400879859924316*x_9 - 0.971039831638336) + 0.00402339155274415*std::sin(0.627359867095947*x_9 - 6.96623992919922) + 0.0212255312135691*std::sin(0.374399840831757*x_92 + 2.0020797252655) - 0.0222699499607912*std::sin(0.335999846458435*x_93 + 1.99351978302002) - 0.01677196721847*std::sin(0.340079843997955*x_93 - 7.4270396232605) - 0.00512278551452308*std::sin(0.358159840106964*x_93 - 7.40423965454102) + 0.0199550082213515*std::sin(0.361279845237732*x_93 + 2.00159978866577) - 0.0317598046166795*std::sin(0.36151984333992*x_93 - 7.41088008880615) - 0.00341026100718035*std::sin(0.380799859762192*x_94 + 1.97039985656738) + 0.00720986326640005*std::sin(0.384719848632813*x_94 + 2.0019998550415) - 0.00567741914168619*std::sin(0.396719843149185*x_94 - 7.39343976974487) - 0.00372264579541804*std::sin(0.411759853363037*x_94 - 4.18368005752563) - 0.00825063950616975*std::sin(0.353599846363068*x_95 + 1.95167982578278) - 0.00513422981910661*std::sin(0.357599824666977*x_95 - 7.42639970779419) + 0.00899733634176802*std::sin(0.358639866113663*x_95 - 7.41207981109619) - 0.00332820785333993*std::sin(0.364079833030701*x_95 + 5.16887998580933) + 0.00908404070860555*std::sin(0.374639838933945*x_95 - 7.41559982299805) - 0.0118715562964323*std::sin(0.383999854326248*x_96 - 7.40655994415283) + 0.0157445309375536*std::sin(0.393039852380753*x_96 + 5.19248008728027) - 0.00557357203412915*std::sin(0.395359843969345*x_96 - 7.38895988464355) + 0.00350836775493984*std::sin(0.414799869060516*x_96 + 8.39535999298096) - 0.0132537956806301*std::sin(0.415759861469269*x_96 - 7.37639951705933) + 0.0183010242965635*std::sin(0.33519983291626*x_97 - 7.44375991821289) - 0.0127907354078286*std::sin(0.343839854001999*x_98 + 1.95423984527588) + 0.00758750730691202*std::sin(0.362719833850861*x_98 - 7.41815996170044) + 0.00179792366103803*std::sin(0.410319864749908*x_98 - 7.4031195640564) - 0.0104892232784244*std::sin(0.41839987039566*x_98 + 2.01895976066589) - 0.010686262604781*std::sin(0.310559868812561*x_99 - 7.46631956100464) + 0.0072949958942853*std::sin(0.389679849147797*x_99 - 7.41063976287842) - 0.00264046835278131*std::sin(0.397759854793549*x_99 + 1.99927973747253) + 0.010464058346646*std::sin(0.409279853105545*x_99 - 7.38895988464355) - 0.409043980489019);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0132385291708814*x_1 - 0.00086220789442887*x_10 + 0.000968467175345095*x_100 + 0.00111736755075963*x_101 - 0.000345622893833369*x_102 - 1.55963617297824e-5*x_103 - 0.000384149992388334*x_104 - 0.000134842821385274*x_105 - 5.50845206204083e-5*x_106 + 6.79999677892899e-5*x_107 - 0.000720602808880841*x_108 + 0.00182657677588817*x_109 + 0.00194381527315822*x_11 - 0.00431549788539178*x_110 - 0.00128268814646934*x_112 - 0.00210783005648575*x_113 + 0.000679436653003834*x_114 - 0.000973499367946953*x_116 + 0.00077432571990762*x_117 + 2.57656479713875e-5*x_118 - 0.0014403783478119*x_119 - 0.00019748276475533*x_12 + 0.00116303655580546*x_120 + 0.000227983401227896*x_13 - 0.00343306801598461*x_14 + 0.00201565701774205*x_15 - 3.30674271380074e-5*x_16 - 0.000142461042154302*x_17 + 0.000904424728065727*x_18 - 0.000366428947598475*x_19 - 0.00588660632914778*x_2 + 0.00194974748882916*x_20 + 1.5554513308013e-5*x_21 - 0.000743189537715733*x_22 - 0.000125219587773552*x_23 + 0.000569581719696596*x_24 - 0.0022547343259468*x_25 + 0.00246076576274193*x_26 - 5.32343880447653e-5*x_28 + 0.00119033286263922*x_29 - 0.00167850731891739*x_3 + 0.00121915467362059*x_30 + 0.000586414073838447*x_31 - 0.00115424955194602*x_32 - 0.00228673961520958*x_33 - 0.000203351414709419*x_34 - 0.000844578240082547*x_36 - 0.000356624918589178*x_37 - 0.00603345602647776*x_39 - 0.00456556124093024*x_4 - 0.000603676584754076*x_40 - 0.000675867296865022*x_41 + 0.000563358389324001*x_42 - 0.000116454562988741*x_43 - 5.9834285241374e-5*x_44 - 1.94257849548428e-5*x_45 - 0.000699846555126506*x_46 + 1.08577909381613e-5*x_47 + 0.00278673235545087*x_48 - 4.01661742319566e-5*x_49 - 0.00250087198844775*x_5 + 0.00140355324272733*x_50 + 0.00105402893434838*x_51 + 0.00669883052136189*x_52 - 0.000526833476546266*x_53 - 5.19599146982534e-6*x_54 - 0.000645889099971437*x_55 - 5.12589972063969e-5*x_56 + 0.000523289262030908*x_57 + 0.000102405498414602*x_58 - 0.00195472538070782*x_59 - 0.000978124184221101*x_6 - 0.00108810192237392*x_60 - 0.0031526286868128*x_61 - 0.00127675473567899*x_62 - 0.00330903905564295*x_63 - 0.000197788252948874*x_64 + 0.000380728250311216*x_65 - 0.000918579368238999*x_66 - 1.13102767424666e-5*x_67 + 0.00091644323721308*x_69 - 0.000464417826681333*x_70 - 0.000116106073115383*x_71 - 0.000397930417276178*x_72 - 2.17133246634666e-6*x_73 + 0.00206574574834746*x_76 - 0.000372573668840638*x_77 + 2.63915056510418e-5*x_78 + 6.68392470255673e-5*x_79 + 0.00167507540194415*x_8 - 0.000213527865593174*x_80 - 1.95983865621062e-5*x_81 + 0.00231932642819689*x_82 - 0.000784948614735026*x_83 + 0.000406184801329979*x_86 - 0.000382068754524736*x_87 - 0.000676253054613261*x_88 + 0.000500707960273592*x_89 + 0.000132014240346244*x_9 - 4.11467506400056e-6*x_90 - 0.00934282714765771*x_91 - 0.000412705469303652*x_92 - 0.000801178470270923*x_94 + 0.0021211670962947*x_97 + 0.000508501594563883*x_98 - 1.29013690917955e-5*x_99 - 1.04935614311645e-5*std::pow(-3.28623986244202*x_14 - 4.83031988143921, 2) - 4.36014833296685e-5*std::pow(-5.59087991714478*x_17 - 8.77711963653564, 2) + 0.000158317205997143*std::pow(-4.67167949676514*x_17 - 6.90744018554688, 2) + 0.000520355955062147*std::pow(-1.91071999073029*x_18 - 2.75584006309509, 2) + 6.11342098432712e-5*std::pow(-6.07679986953735*x_22 - 9.73752021789551, 2) - 2.20983248781674e-5*std::pow(-6.36255979537964*x_23 - 8.93599987030029, 2) - 0.000190168555301664*std::pow(-4.91200017929077*x_4 - 8.39608001708984, 2) + 2.32919801932143e-6*std::pow(-3.57223987579346*x_47 - 6.35407972335815, 2) + 8.59839371446986e-6*std::pow(-3.41503977775574*x_5 - 5.42375993728638, 2) + 3.14561858506913e-6*std::pow(-3.721519947052*x_56 - 5.28943967819214, 2) + 3.00264897513995e-5*std::pow(-5.77103996276855*x_58 - 7.56695985794067, 2) - 1.43777440898578e-6*std::pow(-5.90503978729248*x_6 - 9.16919994354248, 2) + 0.000305686349006605*std::pow(-2.89567995071411*x_6 - 4.63944005966187, 2) - 2.48372048750069e-6*std::pow(-5.1267204284668*x_66 - 7.49520015716553, 2) - 2.72686999534479e-5*std::pow(-6.9987998008728*x_67 - 9.77744007110596, 2) - 2.16716047132538e-6*std::pow(-6.21640014648438*x_67 - 8.61551952362061, 2) - 4.82807825718063e-7*std::pow(-5.79999971389771*x_67 - 10.0, 2) + 3.09687369993227e-6*std::pow(-3.71591997146606*x_68 - 4.97343969345093, 2) - 3.09523469927851e-5*std::pow(-5.72896003723145*x_7 - 8.99792003631592, 2) + 6.37304622000728e-7*std::pow(-5.51319980621338*x_7 - 8.79199981689453, 2) - 4.16677003077803e-6*std::pow(-5.43391990661621*x_7 - 8.85800075531006, 2) - 0.000129844223388152*std::pow(-5.27688026428223*x_7 - 8.52688026428223, 2) + 1.21192538871593e-5*std::pow(-6.60000038146973*x_71 - 9.96463966369629, 2) - 2.02678616253184e-5*std::pow(-7.60000038146973*x_72 - 9.99660015106201, 2) + 1.30618774816351e-5*std::pow(-2.52336001396179*x_72 - 3.5783998966217, 2) - 1.33932610305456e-5*std::pow(-6.59600019454956*x_75 - 9.96208000183105, 2) + 5.62630477981154e-6*std::pow(-6.40000009536743*x_78 - 9.99993991851807, 2) + 1.32308449107447e-5*std::pow(-7.19984006881714*x_81 - 9.79320049285889, 2) - 1.89659255990423e-6*std::pow(-4.73992013931274*x_82 - 7.30111980438232, 2) - 3.39365543320956e-5*std::pow(-5.49191999435425*x_83 - 7.52191972732544, 2) - 4.19076851723904e-5*std::pow(-4.27015972137451*x_84 - 6.41544008255005, 2) - 1.69881900015354e-5*std::pow(-3.90391993522644*x_85 - 6.36783981323242, 2) - 3.90942398131189e-5*std::pow(-3.28543996810913*x_85 - 7.1800799369812, 2) + 1.73284994040103e-6*std::pow(-6.69712018966675*x_86 - 9.7344799041748, 2) - 3.05307828367584e-6*std::pow(-4.22168016433716*x_86 - 6.42952013015747, 2) + 3.22654702279902e-5*std::pow(-4.28991985321045*x_87 - 6.95071983337402, 2) - 2.77988802485281e-6*std::pow(-3.91824007034302*x_87 - 5.3600001335144, 2) + 2.79048788850884e-5*std::pow(-4.93191957473755*x_88 - 5.71687984466553, 2) - 8.65488325968096e-7*std::pow(-5.10663986206055*x_89 - 7.55287981033325, 2) - 5.00976884220357e-5*std::pow(-4.09903955459595*x_89 - 5.94736003875732, 2) - 1.26391739778919e-5*std::pow(-6.60000038146973*x_90 - 9.96016025543213, 2) - 2.07936682181392e-5*std::pow(-5.74399995803833*x_90 - 7.7992000579834, 2) + 3.72387469877106e-5*std::pow(-4.90768003463745*x_90 - 7.15335988998413, 2) + 0.000209403873034298*std::exp(1.29391980171204*x_17) - 0.000937842580565306*std::exp(0.730479836463928*x_22) - 0.000926468904648784*std::exp(0.602479875087738*x_29) + 0.00214513643289082*std::sin(0.225279986858368*x_1 - 4.18847990036011) - 0.0352532893962261*std::sin(0.281839966773987*x_1 + 2.15455985069275) - 0.00200327103098987*std::sin(0.341919839382172*x_1 - 4.35288000106812) - 0.00698191883974913*std::sin(0.270319938659668*x_10 - 7.50264024734497) + 0.059479111718409*std::sin(0.34623983502388*x_10 - 1.06567978858948) + 0.0127505348181674*std::sin(0.36847984790802*x_10 + 5.17600011825562) - 0.022413157038209*std::sin(0.316399842500687*x_101 - 4.24911975860596) - 0.0143553127689852*std::sin(0.301919937133789*x_102 + 5.10527992248535) - 0.000755458606707829*std::sin(0.397359818220139*x_102 + 1.99735975265503) + 0.00373836188973274*std::sin(0.300079941749573*x_103 + 5.10311985015869) - 0.000354976405695514*std::sin(0.416559875011444*x_103 + 5.21712017059326) - 0.00147082116334754*std::sin(0.394079834222794*x_104 - 7.39215993881226) + 0.0161584708598088*std::sin(0.398559838533401*x_104 + 5.20975971221924) + 0.00657549842789387*std::sin(0.40055987238884*x_104 + 5.20408010482788) - 0.000866051683685318*std::sin(0.428879857063293*x_104 + 5.22983980178833) - 0.0367260943378306*std::sin(0.162960022687912*x_105 - 7.63632011413574) - 0.031934974873051*std::sin(0.324799835681915*x_105 + 8.32863998413086) + 0.00158538534109163*std::sin(0.37391984462738*x_105 - 7.43215990066528) - 0.00794884115241161*std::sin(0.403519839048386*x_105 + 2.01263976097107) - 0.027442429509459*std::sin(0.386079847812653*x_106 + 1.99143981933594) - 0.00864361808383239*std::sin(0.396559834480286*x_106 - 7.3874397277832) - 0.0016348392678118*std::sin(0.40055987238884*x_106 - 7.38775968551636) + 0.000655030274501303*std::sin(0.442479848861694*x_106 + 5.22079992294312) + 0.0099267050184047*std::sin(0.35455983877182*x_107 + 5.15592002868652) - 0.0197820021260268*std::sin(0.369519859552383*x_107 + 5.18247985839844) + 0.00083458681548593*std::sin(0.392639845609665*x_107 - 7.40319967269897) - 0.00281791204997729*std::sin(0.570399820804596*x_107 + 2.1801598072052) - 0.0704621955997719*std::sin(0.127280056476593*x_108 + 1.72391986846924) + 0.0018499257155877*std::sin(0.296719938516617*x_108 - 7.49255990982056) + 0.0277691481473986*std::sin(0.388879835605621*x_108 + 5.17456007003784) - 0.00127346810187303*std::sin(0.3504798412323*x_109 + 5.14728021621704) + 0.00604378997617728*std::sin(0.432159870862961*x_109 + 5.23464012145996) + 0.00802941708362487*std::sin(0.262559980154037*x_11 + 8.27199935913086) - 0.0135973151546022*std::sin(0.298159927129745*x_11 - 4.2611198425293) + 0.00101808971916681*std::sin(0.300399929285049*x_11 - 1.06567990779877) + 0.0012939340174003*std::sin(0.36959981918335*x_110 - 7.41879987716675) + 0.000734779845755505*std::sin(0.400079846382141*x_110 - 4.20775985717773) - 0.00187178846974582*std::sin(0.253279983997345*x_111 - 4.3439998626709) + 0.0013321402001196*std::sin(0.355199843645096*x_111 - 4.24304008483887) + 0.0314581910530663*std::sin(0.357679843902588*x_111 - 4.2388801574707) + 0.0124064566368502*std::sin(0.388959854841232*x_111 + 5.20007991790771) + 0.00189602732305988*std::sin(0.762639880180359*x_111 - 1.20167982578278) + 0.00250333374651083*std::sin(0.350879848003387*x_112 - 4.24528026580811) + 0.0327219073696949*std::sin(0.362399846315384*x_112 + 5.16552019119263) - 0.00120788119103147*std::sin(0.372479856014252*x_112 - 7.41504001617432) + 0.00125003737621992*std::sin(0.377519845962524*x_113 - 7.42136001586914) - 0.0016575821256155*std::sin(0.181760013103485*x_114 - 1.20503985881805) - 0.000998144861299737*std::sin(0.321759849786758*x_114 + 5.13535976409912) + 0.0113128335015712*std::sin(0.32423985004425*x_114 + 5.132080078125) - 0.0132201741093029*std::sin(0.389039844274521*x_114 - 7.40039968490601) - 0.0504310208442591*std::sin(0.189999997615814*x_115 - 7.61768007278442) + 0.0428180120012436*std::sin(0.230639979243279*x_115 + 1.83319985866547) + 0.000738957084804945*std::sin(0.33231982588768*x_115 + 5.14056015014648) + 0.00167301752648223*std::sin(0.3642398416996*x_115 - 7.42384004592896) + 0.00208757153196505*std::sin(0.491039872169495*x_115 - 4.1386399269104) - 0.0451802693535147*std::sin(0.260159969329834*x_116 - 4.30823993682861) - 0.00677376205767124*std::sin(0.453839868307114*x_116 + 8.24575996398926) - 0.0284569162545395*std::sin(0.240879982709885*x_117 - 7.5633602142334) - 0.000700654795990208*std::sin(0.355279833078384*x_117 - 7.42416000366211) - 0.00101901389957242*std::sin(0.363599836826324*x_117 - 7.42176008224487) - 0.0116981125926751*std::sin(0.413519859313965*x_117 + 5.20032024383545) + 0.0125783972972717*std::sin(0.322159856557846*x_118 + 1.92447984218597) - 0.00585554035657671*std::sin(0.345439821481705*x_118 + 5.1592001914978) + 0.000338392503578405*std::sin(0.450399875640869*x_118 + 5.2403998374939) - 0.0162933519595116*std::sin(0.299039930105209*x_119 + 5.09831953048706) + 0.00094016167531492*std::sin(0.367199838161469*x_119 + 8.1812801361084) + 0.00891665581254968*std::sin(0.369119822978973*x_119 + 1.97495973110199) - 0.0372157224448697*std::sin(0.249199971556664*x_12 + 5.06543970108032) + 0.00198020902740793*std::sin(0.283599942922592*x_12 + 8.31063938140869) - 0.0100496184049151*std::sin(0.318879842758179*x_12 - 4.26143980026245) + 0.0560423802835147*std::sin(0.342079848051071*x_12 + 8.34247970581055) + 0.00184864896349119*std::sin(0.302719920873642*x_120 - 7.48975992202759) - 0.00760527600561902*std::sin(0.482079833745956*x_120 + 2.02687978744507) + 0.00041424335363567*std::sin(0.417599856853485*x_13 - 7.16351985931396) + 0.0475578871226648*std::sin(0.23319998383522*x_14 + 8.24967956542969) - 0.00073064248028904*std::sin(0.351519852876663*x_14 - 1.0487197637558) + 0.00290902645388743*std::sin(0.254239976406097*x_15 - 1.0914398431778) + 0.0160154910734817*std::sin(0.417839854955673*x_15 + 2.22183990478516) - 0.00131969707565621*std::sin(0.313599914312363*x_16 - 4.26719999313354) - 0.0324841592949957*std::sin(0.321199834346771*x_16 - 4.25663995742798) + 0.00815497736507242*std::sin(0.373839825391769*x_16 + 2.15111970901489) + 0.0398122080384302*std::sin(0.402399867773056*x_16 + 5.189040184021) - 0.000581923777948549*std::sin(0.237599983811378*x_18 - 4.33536005020142) + 0.100043689902244*std::sin(0.238399982452393*x_19 - 4.33599996566772) + 0.0128389341475383*std::sin(0.254319965839386*x_19 - 4.31472015380859) - 0.0239996962759808*std::sin(0.311999946832657*x_21 - 4.27687978744507) + 0.0493496587135287*std::sin(0.333199828863144*x_21 - 4.25576019287109) - 0.00248149655694909*std::sin(0.364319831132889*x_21 + 8.36192035675049) - 0.00347992579719786*std::sin(0.222559988498688*x_23 - 4.36664009094238) - 0.00267252142751049*std::sin(0.341359853744507*x_23 - 4.26792001724243) + 0.0136453638142186*std::sin(0.477199852466583*x_23 - 7.31928014755249) - 0.0180824935531091*std::sin(0.359199821949005*x_24 + 2.12399983406067) + 0.0204161601721571*std::sin(0.382639855146408*x_24 + 5.38751983642578) - 0.0018685552132792*std::sin(0.437999874353409*x_24 + 8.44855976104736) - 0.00271250534287724*std::sin(0.319279849529266*x_26 - 4.28200006484985) - 0.00125115896969411*std::sin(0.327199846506119*x_26 - 4.26272010803223) - 0.0784103581268569*std::sin(0.350639849901199*x_27 + 8.32791996002197) - 0.00147722458578296*std::sin(0.366399854421616*x_27 + 5.17136001586914) - 0.00323673738934732*std::sin(0.366799861192703*x_27 - 4.24416017532349) + 0.00478573927573221*std::sin(0.444319844245911*x_27 - 0.939439833164215) - 0.00964689414873437*std::sin(0.536719858646393*x_27 - 4.05399990081787) + 0.0392471640224449*std::sin(0.311599940061569*x_28 + 5.12759971618652) - 0.0116580333007881*std::sin(0.320399850606918*x_28 - 4.2739200592041) + 0.00217627463437242*std::sin(0.333199828863144*x_28 - 4.27544021606445) - 0.00257926533816786*std::sin(0.348239839076996*x_28 - 4.23992013931274) - 0.0222448331148979*std::sin(0.342559844255447*x_3 - 4.24079990386963) - 0.0645165277200553*std::sin(0.376959830522537*x_3 - 1.01671981811523) + 0.000720128549766031*std::sin(0.296799927949905*x_30 - 4.29607963562012) + 0.00249296220453797*std::sin(0.295999944210052*x_33 - 1.16031992435455) - 0.023326559620252*std::sin(0.352079838514328*x_34 + 1.99303984642029) - 0.00122212889303052*std::sin(0.356959849596024*x_34 + 1.98511981964111) - 0.0182477512051094*std::sin(0.360879838466644*x_34 + 1.99647974967957) + 0.0568211991388032*std::sin(0.307439923286438*x_35 - 1.14431989192963) + 0.0295512067236062*std::sin(0.312399834394455*x_35 - 7.41991996765137) + 0.011420325584817*std::sin(0.316639840602875*x_35 + 1.94799983501434) + 0.00214911129020253*std::sin(0.331839829683304*x_35 + 1.95959985256195) - 0.000667754644361195*std::sin(0.333759844303131*x_35 + 1.97559976577759) - 0.0185801765940835*std::sin(0.345039844512939*x_36 - 7.4507999420166) - 0.00235707883841127*std::sin(0.358079850673676*x_36 + 5.17239999771118) + 0.0007344737816324*std::sin(0.361599832773209*x_36 - 4.23776006698608) + 0.0305262162113504*std::sin(0.305039942264557*x_37 + 5.12063980102539) + 0.0154388105448344*std::sin(0.369439840316772*x_37 + 5.18287992477417) - 0.00199140424621935*std::sin(0.385359823703766*x_37 + 5.19280004501343) - 0.00339017195917847*std::sin(0.389999836683273*x_37 + 5.19632005691528) - 0.0168137304193806*std::sin(0.218799993395805*x_38 + 5.01575994491577) + 0.00213132350315243*std::sin(0.262399971485138*x_38 - 7.52008008956909) + 0.0245885141934992*std::sin(0.320239841938019*x_38 + 5.11552000045776) - 0.0355477923012805*std::sin(0.344159841537476*x_38 + 5.13088035583496) - 0.00188992698584765*std::sin(0.367359846830368*x_38 + 5.17296028137207) + 0.0208803482792643*std::sin(0.352319836616516*x_39 - 7.42647981643677) - 0.0394776265922538*std::sin(0.2291199862957*x_40 + 5.04504013061523) - 0.000973471236102167*std::sin(0.309679925441742*x_40 - 7.48591995239258) + 0.0116846662453242*std::sin(0.317279845476151*x_40 - 7.46495962142944) + 0.012370128041672*std::sin(0.333999842405319*x_41 + 5.14592027664185) + 0.018517373324905*std::sin(0.341359823942184*x_41 + 1.95199990272522) - 0.0383254719738181*std::sin(0.317679852247238*x_42 + 8.32288074493408) + 0.0102207002851405*std::sin(0.355359852313995*x_43 + 5.16279983520508) - 0.0324844773700264*std::sin(0.360879838466644*x_43 + 5.16096019744873) - 0.00177320650963309*std::sin(0.364639848470688*x_43 - 4.23912000656128) + 0.0103427661809906*std::sin(0.269999951124191*x_44 - 4.30319976806641) - 0.0254065386794254*std::sin(0.329999834299088*x_44 + 5.11872005462646) - 0.0214404040755736*std::sin(0.328879833221436*x_45 - 7.44984006881714) - 0.00114966136004558*std::sin(0.341919839382172*x_45 + 5.13479995727539) - 0.0105100668908326*std::sin(0.351679861545563*x_45 + 5.14408016204834) + 0.0217233555744575*std::sin(0.35471984744072*x_45 + 8.35632038116455) - 0.0345408670168687*std::sin(0.246319979429245*x_46 - 7.53096008300781) - 0.000520822202184564*std::sin(0.29479992389679*x_46 + 5.11055994033813) - 0.000614639640293495*std::sin(0.347519844770432*x_46 - 4.24232006072998) + 0.0365231203298382*std::sin(0.29215994477272*x_47 - 7.47575998306274) + 0.0118017432966001*std::sin(0.324559837579727*x_47 - 4.27048015594482) - 0.0214804694287611*std::sin(0.336879849433899*x_47 - 4.26936006546021) - 0.0223631743130044*std::sin(0.300879925489426*x_48 + 5.12215948104858) - 0.00863530404710182*std::sin(0.337039858102798*x_49 + 5.13264036178589) + 0.00141766592500295*std::sin(0.35455983877182*x_49 - 7.43215990066528) + 0.018810134102612*std::sin(0.433759868144989*x_49 - 4.17463970184326) - 0.0431422589117072*std::sin(0.246479973196983*x_50 - 7.53216028213501) + 0.00327860480960089*std::sin(0.249039962887764*x_50 + 5.05631971359253) - 0.00584825420696265*std::sin(0.31879985332489*x_50 + 5.11704015731812) + 0.000952961125370936*std::sin(0.366719841957092*x_50 + 5.16960000991821) + 0.0290306994845547*std::sin(0.22647999227047*x_51 - 7.58319997787476) + 0.00155486505509577*std::sin(0.300319939851761*x_51 - 4.28999948501587) - 0.00149936084077225*std::sin(0.338239848613739*x_51 - 4.25888013839722) + 0.00205366963548998*std::sin(0.449919849634171*x_51 - 4.16607999801636) + 0.0134472145154424*std::sin(0.281759947538376*x_52 + 5.10095977783203) - 0.0208186555526578*std::sin(0.236559987068176*x_53 - 4.34311962127686) + 0.00275873381728267*std::sin(0.290879935026169*x_53 + 5.103919506073) - 0.00151482775777622*std::sin(0.305999934673309*x_53 + 5.12415981292725) + 0.00319689149324656*std::sin(0.26215997338295*x_54 - 7.52416038513184) + 0.00104166701461113*std::sin(0.324559837579727*x_54 - 4.27511978149414) + 0.00303107739805505*std::sin(0.350879848003387*x_54 + 2.13367986679077) + 0.0136962360255772*std::sin(0.239439979195595*x_55 + 5.03903961181641) + 0.00600150018263236*std::sin(0.378319829702377*x_55 - 1.00887978076935) - 0.0176946364256841*std::sin(0.22503998875618*x_56 + 5.03327989578247) + 0.00171656031361243*std::sin(0.300399929285049*x_56 + 5.12975978851318) - 0.00619349822303808*std::sin(0.318239837884903*x_56 + 5.1159200668335) - 0.00133593428489168*std::sin(0.254079967737198*x_57 - 7.52976036071777) - 0.00195273420380716*std::sin(0.275119960308075*x_57 + 5.07976007461548) - 0.00902240297306106*std::sin(0.318639844655991*x_57 - 4.29200029373169) + 0.0241149865544538*std::sin(0.213919997215271*x_58 + 5.01063966751099) + 0.0216826735288475*std::sin(0.286479920148849*x_58 + 5.09591960906982) - 0.000613779425030458*std::sin(0.280559957027435*x_59 + 1.87903988361359) - 0.00170171873628503*std::sin(0.367759823799133*x_59 - 4.2294397354126) + 0.0108915663249293*std::sin(0.376079827547073*x_59 - 7.42407989501953) + 0.0031810284395364*std::sin(0.245839968323708*x_60 - 7.53416013717651) + 0.010962281853648*std::sin(0.253439962863922*x_60 - 7.54631996154785) - 0.0392349249718186*std::sin(0.281599938869476*x_60 + 5.08191967010498) + 0.00101622391047385*std::sin(0.313439846038818*x_60 + 8.30096054077148) - 0.000858294822951675*std::sin(0.270399957895279*x_63 + 8.28127956390381) - 0.00437545713850625*std::sin(0.155440032482147*x_64 - 4.47199964523315) + 0.0356588801191945*std::sin(0.289519935846329*x_65 - 4.28743982315063) + 0.0203476711300074*std::sin(0.292959928512573*x_65 + 5.12455987930298) + 0.00200967368029424*std::sin(0.295599937438965*x_65 - 4.2902398109436) + 0.0773439196523591*std::sin(0.162640020251274*x_66 + 4.94399976730347) - 0.0102964341692689*std::sin(0.230159983038902*x_66 + 5.02184009552002) + 0.00114366281488831*std::sin(0.262159943580627*x_66 - 7.51416015625) + 0.0407840382111168*std::sin(0.20168000459671*x_67 + 4.99440002441406) + 0.0710952154092353*std::sin(0.183040007948875*x_68 - 4.43607997894287) + 0.0066475882993222*std::sin(0.196959987282753*x_68 + 4.9846396446228) - 0.0156034766052924*std::sin(0.196959987282753*x_68 + 4.98943948745728) + 0.00303551764376439*std::sin(0.353599846363068*x_68 + 8.35048007965088) + 0.043213701329472*std::sin(0.156880035996437*x_69 - 4.47191953659058) - 0.0338093958962546*std::sin(0.174560010433197*x_69 - 4.44608020782471) + 0.00222669266788182*std::sin(0.238479986786842*x_69 + 5.03991985321045) - 0.023986022506998*std::sin(0.298639923334122*x_7 - 1.02047991752625) + 0.00256723962210801*std::sin(0.242239981889725*x_70 - 7.54864025115967) + 0.0166433545291427*std::sin(0.274159938097*x_70 + 1.88463997840881) - 0.000230204196095488*std::sin(0.332239836454391*x_70 - 4.28344011306763) + 0.127772786575486*std::sin(0.128320053219795*x_71 - 4.51495981216431) + 0.0518153005076942*std::sin(0.138400033116341*x_73 + 4.90935945510864) - 0.0986227541083019*std::sin(0.15776002407074*x_73 + 4.92848014831543) - 0.00184950633798933*std::sin(0.275279968976974*x_73 + 5.07599973678589) - 0.00289513729652716*std::sin(0.470879852771759*x_73 + 2.04903984069824) + 0.032820192690578*std::sin(0.195040002465248*x_74 + 4.98744010925293) - 0.00267692681333237*std::sin(0.274639964103699*x_74 - 4.31271982192993) - 0.00133224524638647*std::sin(0.305599927902222*x_74 + 5.12239980697632) - 0.0240242779441141*std::sin(0.312799841165543*x_74 + 5.11303997039795) - 0.0224118624776776*std::sin(0.326879858970642*x_74 - 4.27383995056152) - 0.0622062241701467*std::sin(0.19055999815464*x_75 + 4.97583961486816) + 0.00166308333074205*std::sin(0.202880010008812*x_75 - 4.40423965454102) - 0.003669140223454*std::sin(0.246879979968071*x_75 + 5.0577597618103) - 0.0196229273848681*std::sin(0.285679936408997*x_75 - 7.48791980743408) - 0.0264287056722953*std::sin(0.191040009260178*x_76 + 4.97191953659058) - 0.00290634734329603*std::sin(0.178640007972717*x_77 - 7.62040042877197) + 0.00117668089149318*std::sin(0.227039992809296*x_77 - 7.55208015441895) + 0.00415402995285612*std::sin(0.321919828653336*x_77 - 4.29168033599854) + 0.0150586848983848*std::sin(0.332159847021103*x_77 - 1.0759197473526) + 0.048234913282845*std::sin(0.221759989857674*x_78 + 5.01408004760742) - 0.0214554066375216*std::sin(0.377519845962524*x_78 + 5.1831202507019) + 0.0404837192509452*std::sin(0.286319941282272*x_79 + 5.09559965133667) - 0.00425443158847032*std::sin(0.487999856472015*x_79 - 7.32823991775513) - 0.0033749664272399*std::sin(0.202159985899925*x_8 - 4.39463996887207) + 0.0204275577183711*std::sin(0.273039966821671*x_8 - 4.31079959869385) - 0.0631192845059344*std::sin(0.169440016150475*x_80 - 7.63960027694702) - 0.00384060330130344*std::sin(0.177920013666153*x_80 - 7.6255202293396) - 0.00720545639618675*std::sin(0.249199971556664*x_80 + 5.05807971954346) - 0.00104470217341444*std::sin(0.313839852809906*x_80 - 4.29152011871338) - 0.0187147715270845*std::sin(0.193200007081032*x_81 - 7.60736036300659) - 0.00142500687482729*std::sin(0.360079854726791*x_81 - 4.23920011520386) - 0.0143720056322342*std::sin(0.36831983923912*x_81 - 7.42639970779419) - 0.00751575549030076*std::sin(0.193039998412132*x_82 + 4.98015975952148) - 0.0198965856319953*std::sin(0.209600001573563*x_82 + 8.20239925384521) + 0.00595653471689889*std::sin(0.155760034918785*x_83 + 4.93103981018066) - 0.00356862259485608*std::sin(0.249119967222214*x_84 + 5.05751991271973) - 0.000861362522265228*std::sin(0.302159935235977*x_84 + 5.14359951019287) - 0.0163442584279954*std::sin(0.322719842195511*x_84 + 5.12712001800537) + 0.0260267311630607*std::sin(0.390079826116562*x_84 + 5.18688011169434) - 0.00702970956220598*std::sin(0.164800018072128*x_85 - 7.63064002990723) + 0.00231763046947107*std::sin(0.238879978656769*x_85 + 5.03191947937012) - 0.0228102633460873*std::sin(0.346639841794968*x_85 - 4.24584007263184) + 0.00958155652428971*std::sin(0.391279846429825*x_86 - 4.19704008102417) + 0.113756367808559*std::sin(0.152880027890205*x_87 - 7.64616012573242) - 0.00275040921628676*std::sin(0.259839981794357*x_87 + 5.06343984603882) - 0.000988709579943736*std::sin(0.345679849386215*x_88 - 4.25648021697998) - 0.0028195019222347*std::sin(0.572799861431122*x_88 - 0.833039879798889) + 0.164853600063418*std::sin(0.180400013923645*x_89 + 4.9684796333313) + 0.000900801580431437*std::sin(0.341119825839996*x_89 - 4.27016019821167) + 0.00927885260590304*std::sin(0.178000003099442*x_9 - 4.42439985275269) + 0.0600703503390025*std::sin(0.240079984068871*x_9 - 4.34311962127686) - 0.0480787865974541*std::sin(0.400879859924316*x_9 - 0.971039831638336) - 0.00186190387550939*std::sin(0.627359867095947*x_9 - 6.96623992919922) - 0.0542343749709942*std::sin(0.374399840831757*x_92 + 2.0020797252655) + 0.00260480716591433*std::sin(0.335999846458435*x_93 + 1.99351978302002) - 0.0231305095805422*std::sin(0.340079843997955*x_93 - 7.4270396232605) - 0.00157606945637109*std::sin(0.358159840106964*x_93 - 7.40423965454102) - 0.0509880006081632*std::sin(0.361279845237732*x_93 + 2.00159978866577) + 0.014697476625382*std::sin(0.36151984333992*x_93 - 7.41088008880615) + 0.00157816561041317*std::sin(0.380799859762192*x_94 + 1.97039985656738) - 0.0184222681611645*std::sin(0.384719848632813*x_94 + 2.0019998550415) - 0.00174670730891634*std::sin(0.396719843149185*x_94 - 7.39343976974487) + 0.000435419678137493*std::sin(0.411759853363037*x_94 - 4.18368005752563) + 0.00381814632520436*std::sin(0.353599846363068*x_95 + 1.95167982578278) - 0.00708070499260039*std::sin(0.357599824666977*x_95 - 7.42639970779419) - 0.0229895265277343*std::sin(0.358639866113663*x_95 - 7.41207981109619) - 0.0010239520524981*std::sin(0.364079833030701*x_95 + 5.16887998580933) - 0.00106251582849953*std::sin(0.374639838933945*x_95 - 7.41559982299805) + 0.00138855789824162*std::sin(0.383999854326248*x_96 - 7.40655994415283) + 0.0217135544655237*std::sin(0.393039852380753*x_96 + 5.19248008728027) - 0.00171475784433518*std::sin(0.395359843969345*x_96 - 7.38895988464355) - 0.0089643990740695*std::sin(0.414799869060516*x_96 + 8.39535999298096) + 0.00613345562306599*std::sin(0.415759861469269*x_96 - 7.37639951705933) - 0.00846916031334868*std::sin(0.33519983291626*x_97 - 7.44375991821289) + 0.00591916533955244*std::sin(0.343839854001999*x_98 + 1.95423984527588) - 0.000887473633271227*std::sin(0.362719833850861*x_98 - 7.41815996170044) + 0.00055314682978929*std::sin(0.410319864749908*x_98 - 7.4031195640564) + 0.026801518544463*std::sin(0.41839987039566*x_98 + 2.01895976066589) + 0.0273049831975797*std::sin(0.310559868812561*x_99 - 7.46631956100464) - 0.00337590337637681*std::sin(0.389679849147797*x_99 - 7.41063976287842) - 0.000812363021940915*std::sin(0.397759854793549*x_99 + 1.99927973747253) + 0.0144311635412632*std::sin(0.409279853105545*x_99 - 7.38895988464355) + 0.167350372837326);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000942778514727346*x_10 - 0.000165861917529392*x_100 + 0.00209308052293295*x_101 + 0.00125305110178003*x_102 - 0.00144431313418013*x_103 + 0.00150238205022796*x_105 - 0.000637930516505704*x_107 - 4.51219311151325e-6*x_108 - 0.00261954948296583*x_109 - 0.0015536621770273*x_11 + 0.00167944212809109*x_110 + 0.0015714353321083*x_112 + 0.00186937384630726*x_113 + 0.0018017274476358*x_116 - 7.12923680037606e-5*x_118 + 0.00165106858787852*x_119 + 0.00185265208524384*x_12 + 0.000403484296678214*x_120 + 0.000849344391208537*x_13 - 0.000718989919068717*x_15 + 0.00031021663038179*x_16 + 0.00131289013770897*x_17 - 0.00176831944724686*x_18 + 0.000714358010473741*x_19 + 0.00378955657167152*x_2 - 0.0094810793912738*x_20 + 0.000385663108339132*x_21 - 0.000401554683219554*x_22 + 0.000167223719483307*x_23 - 0.000289070026523338*x_24 - 0.00188259893521911*x_25 - 0.0011861852998619*x_26 - 0.00464594181819406*x_29 + 0.000903988741932399*x_3 - 0.00101187331444427*x_30 + 0.00154119922165853*x_31 - 0.00171564280196397*x_32 + 0.000239370026289154*x_33 + 0.00144949393869202*x_34 - 0.0018851254389986*x_39 + 0.00515388510370392*x_4 - 2.17771310338185e-5*x_40 + 0.00103570370389128*x_41 - 0.002168270519173*x_42 + 0.000214394977147916*x_43 - 0.000224061203861458*x_44 + 0.000182239807350665*x_45 - 0.00010186058032785*x_47 + 0.00215773342085608*x_48 + 0.000269955851467042*x_49 - 0.00179960911531019*x_5 - 0.00140759638311148*x_51 - 0.00673352003059412*x_52 + 0.000709098995245979*x_54 - 0.000655804793095941*x_55 - 0.00046363820218816*x_57 - 0.00103978638561816*x_58 + 0.00263064598916791*x_59 + 0.00203992012324761*x_6 - 0.00144513654332212*x_61 + 9.00384259407663e-5*x_62 - 0.000413267340538363*x_63 + 0.00122731903147599*x_64 - 8.87938534521412e-5*x_65 + 1.51042387128852e-5*x_67 + 0.000560776685752917*x_69 - 0.00036143099287619*x_70 - 0.00010871072633015*x_71 + 6.93301592649728e-5*x_72 + 2.41923959244053e-5*x_73 + 0.00172881995038036*x_76 + 0.000497551188219393*x_77 - 0.000315113052640392*x_78 - 0.000238277296292661*x_79 + 0.00239353531546708*x_8 + 0.000285154459719152*x_80 + 0.000183859040948134*x_81 - 0.0026779290757306*x_82 + 0.00181922907482403*x_83 + 0.0015336755577639*x_88 - 0.00147086676942178*x_9 - 2.48058642973924e-5*x_90 - 0.00142153904651557*x_91 + 0.00130527027193647*x_92 + 0.00106992880387798*x_94 - 0.0033039706980892*x_97 - 0.000679075290999522*x_98 + 0.000121032072748365*x_99 + 9.84436210986184e-5*std::pow(-3.28623986244202*x_14 - 4.83031988143921, 2) + 5.82273296615704e-5*std::pow(-5.59087991714478*x_17 - 8.77711963653564, 2) - 2.59512909898012e-5*std::pow(-3.57223987579346*x_47 - 6.35407972335815, 2) - 9.58009647432607e-5*std::pow(-3.41503977775574*x_5 - 5.42375993728638, 2) - 2.95101035183011e-5*std::pow(-3.721519947052*x_56 - 5.28943967819214, 2) + 1.60192915139734e-5*std::pow(-5.90503978729248*x_6 - 9.16919994354248, 2) + 2.33006153525953e-5*std::pow(-5.1267204284668*x_66 - 7.49520015716553, 2) + 2.03308596131584e-5*std::pow(-6.21640014648438*x_67 - 8.61551952362061, 2) + 5.37931351195847e-6*std::pow(-5.79999971389771*x_67 - 10.0, 2) - 3.45045246814259e-5*std::pow(-3.71591997146606*x_68 - 4.97343969345093, 2) - 7.10067480630284e-6*std::pow(-5.51319980621338*x_7 - 8.79199981689453, 2) + 3.90898678971635e-5*std::pow(-5.43391990661621*x_7 - 8.85800075531006, 2) + 2.70665897182787e-5*std::pow(-7.60000038146973*x_72 - 9.99660015106201, 2) - 0.000122537855815075*std::pow(-2.52336001396179*x_72 - 3.5783998966217, 2) - 1.76690495250841e-5*std::pow(-7.19984006881714*x_81 - 9.79320049285889, 2) + 2.11313185924423e-5*std::pow(-4.73992013931274*x_82 - 7.30111980438232, 2) + 4.53203603586609e-5*std::pow(-5.49191999435425*x_83 - 7.52191972732544, 2) + 5.59653574497928e-5*std::pow(-4.27015972137451*x_84 - 6.41544008255005, 2) + 5.22081593475978e-5*std::pow(-3.28543996810913*x_85 - 7.1800799369812, 2) - 1.625644678145e-5*std::pow(-6.69712018966675*x_86 - 9.7344799041748, 2) + 3.40165680620822e-5*std::pow(-4.22168016433716*x_86 - 6.42952013015747, 2) + 3.09727564825236e-5*std::pow(-3.91824007034302*x_87 - 5.3600001335144, 2) + 9.64303558957063e-6*std::pow(-5.10663986206055*x_89 - 7.55287981033325, 2) + 6.69026463383554e-5*std::pow(-4.09903955459595*x_89 - 5.94736003875732, 2) - 4.97302529971914e-5*std::pow(-4.90768003463745*x_90 - 7.15335988998413, 2) - 0.00150730344466865*std::pow(-0.128313399611321*x_1 - 0.186875502093378*x_100 + 0.0648000152953508*x_101 + 0.0518854249703468*x_102 - 0.00752943383001262*x_106 - 0.147647678789181*x_110 - 0.0144854787774994*x_112 - 0.0409257653012775*x_113 - 0.056946783136143*x_13 - 0.0995205945942916*x_14 - 0.0182224912188355*x_18 + 0.114354193549439*x_2 - 0.093003440177101*x_20 + 0.00685751185668511*x_21 + 0.346928503143031*x_25 - 0.0225450618612344*x_26 - 0.00727654153562286*x_28 - 0.0124388777140004*x_29 - 0.21694523502585*x_3 - 0.102830040758755*x_30 - 0.065700735984621*x_31 - 0.30410456652832*x_32 + 0.164683275698239*x_33 - 0.00971579156556299*x_36 - 0.04874661150552*x_37 - 0.0602622615212663*x_39 - 0.321756130427328*x_4 - 0.0492894544679094*x_42 - 0.000778563741213002*x_46 + 0.201021795454933*x_48 - 0.156611519674244*x_5 - 0.020613139812672*x_53 + 0.0412742723619058*x_6 + 0.00469585755685329*x_61 - 0.060019094990789*x_62 - 0.116560892676797*x_63 - 0.0399263247349615*x_64 - 0.0364751982160475*x_72 + 0.00612351532053828*x_79 + 0.0429275963919566*x_82 + 0.0489813859007718*x_83 - 0.057076010856527*x_86 - 0.0522244974324697*x_87 + 0.0684411412240525*x_89 - 0.229571285680633*x_91 + 0.0331103254692929*x_92 - 0.00302059222900158*std::pow(-6.36255979537964*x_23 - 8.93599987030029, 2) - 0.00423083737392863*std::pow(-5.72896003723145*x_7 - 8.99792003631592, 2) + 0.00165656556841635*std::pow(-6.60000038146973*x_71 - 9.96463966369629, 2) + 0.000769052522740475*std::pow(-6.40000009536743*x_78 - 9.99993991851807, 2) - 0.00232209432101062*std::pow(-3.90391993522644*x_85 - 6.36783981323242, 2) - 0.00172763279158494*std::pow(-6.60000038146973*x_90 - 9.96016025543213, 2) + 0.0286231519853867*std::exp(1.29391980171204*x_17) - 0.128192522578086*std::exp(0.730479836463928*x_22) + 1.7428545647558*std::sin(0.36847984790802*x_10 + 5.17600011825562) + 0.510991984033989*std::sin(0.300079941749573*x_103 + 5.10311985015869) + 0.898796608458383*std::sin(0.40055987238884*x_104 + 5.20408010482788) - 1.08651709787578*std::sin(0.403519839048386*x_105 + 2.01263976097107) + 1.35686882166387*std::sin(0.35455983877182*x_107 + 5.15592002868652) - 9.63138887859049*std::sin(0.127280056476593*x_108 + 1.72391986846924) + 0.826118049056067*std::sin(0.432159870862961*x_109 + 5.23464012145996) + 1.0975309205528*std::sin(0.262559980154037*x_11 + 8.27199935913086) + 1.69582295098481*std::sin(0.388959854841232*x_111 + 5.20007991790771) + 1.54633698034711*std::sin(0.32423985004425*x_114 + 5.132080078125) + 0.285347526643001*std::sin(0.491039872169495*x_115 - 4.1386399269104) - 0.925897014606853*std::sin(0.453839868307114*x_116 + 8.24575996398926) - 1.59900029464814*std::sin(0.413519859313965*x_117 + 5.20032024383545) - 0.800386445361536*std::sin(0.345439821481705*x_118 + 5.1592001914978) + 1.21880646630728*std::sin(0.369119822978973*x_119 + 1.97495973110199) - 1.37366969784703*std::sin(0.318879842758179*x_12 - 4.26143980026245) - 1.03955561014859*std::sin(0.482079833745956*x_120 + 2.02687978744507) + 2.1891373281419*std::sin(0.417839854955673*x_15 + 2.22183990478516) + 1.11469359747527*std::sin(0.373839825391769*x_16 + 2.15111970901489) + 1.75493775788554*std::sin(0.254319965839386*x_19 - 4.31472015380859) - 2.47167329689572*std::sin(0.359199821949005*x_24 + 2.12399983406067) + 0.654156681377525*std::sin(0.444319844245911*x_27 - 0.939439833164215) - 2.49426215746172*std::sin(0.360879838466644*x_34 + 1.99647974967957) + 1.56102993798628*std::sin(0.316639840602875*x_35 + 1.94799983501434) - 2.29824766018737*std::sin(0.218799993395805*x_38 + 5.01575994491577) + 1.59716233034359*std::sin(0.317279845476151*x_40 - 7.46495962142944) + 1.69085724100947*std::sin(0.333999842405319*x_41 + 5.14592027664185) + 1.39705466484254*std::sin(0.355359852313995*x_43 + 5.16279983520508) + 1.41373969859345*std::sin(0.269999951124191*x_44 - 4.30319976806641) - 1.43660782216578*std::sin(0.351679861545563*x_45 + 5.14408016204834) + 1.61316544520537*std::sin(0.324559837579727*x_47 - 4.27048015594482) - 1.18034884741476*std::sin(0.337039858102798*x_49 + 5.13264036178589) - 0.799390510736405*std::sin(0.31879985332489*x_50 + 5.11704015731812) + 0.280713519060726*std::sin(0.449919849634171*x_51 - 4.16607999801636) + 1.83808283618787*std::sin(0.281759947538376*x_52 + 5.10095977783203) + 0.414314156595326*std::sin(0.350879848003387*x_54 + 2.13367986679077) + 1.87212127315149*std::sin(0.239439979195595*x_55 + 5.03903961181641) - 2.418657594053*std::sin(0.22503998875618*x_56 + 5.03327989578247) - 1.2332609126529*std::sin(0.318639844655991*x_57 - 4.29200029373169) + 3.29624717667295*std::sin(0.213919997215271*x_58 + 5.01063966751099) + 1.48875449990512*std::sin(0.376079827547073*x_59 - 7.42407989501953) + 1.49842051656905*std::sin(0.253439962863922*x_60 - 7.54631996154785) + 2.78129757040107*std::sin(0.292959928512573*x_65 + 5.12455987930298) - 1.40740663419458*std::sin(0.230159983038902*x_66 + 5.02184009552002) + 5.57471887878316*std::sin(0.20168000459671*x_67 + 4.99440002441406) + 0.414921088195728*std::sin(0.353599846363068*x_68 + 8.35048007965088) - 4.62136379451826*std::sin(0.174560010433197*x_69 - 4.44608020782471) + 2.27495919407517*std::sin(0.274159938097*x_70 + 1.88463997840881) + 7.08256824532225*std::sin(0.138400033116341*x_73 + 4.90935945510864) + 4.48615085270282*std::sin(0.195040002465248*x_74 + 4.98744010925293) - 2.6822332595696*std::sin(0.285679936408997*x_75 - 7.48791980743408) - 3.61250653234697*std::sin(0.191040009260178*x_76 + 4.97191953659058) + 0.567809128692545*std::sin(0.321919828653336*x_77 - 4.29168033599854) + 2.79221716767114*std::sin(0.273039966821671*x_8 - 4.31079959869385) - 0.984904770688502*std::sin(0.249199971556664*x_80 + 5.05807971954346) - 2.55809857778412*std::sin(0.193200007081032*x_81 - 7.60736036300659) - 2.23407612425738*std::sin(0.322719842195511*x_84 + 5.12712001800537) - 0.385394170956882*std::sin(0.572799861431122*x_88 - 0.833039879798889) - 0.254501298560781*std::sin(0.627359867095947*x_9 - 6.96623992919922) + 2.00897959122787*std::sin(0.36151984333992*x_93 - 7.41088008880615) + 0.215717472033423*std::sin(0.380799859762192*x_94 + 1.97039985656738) + 0.521897618153748*std::sin(0.353599846363068*x_95 + 1.95167982578278) + 0.838374333534354*std::sin(0.415759861469269*x_96 - 7.37639951705933) - 1.1576388694486*std::sin(0.33519983291626*x_97 - 7.44375991821289) + 0.80908326424742*std::sin(0.343839854001999*x_98 + 1.95423984527588) - 0.461447985798173*std::sin(0.389679849147797*x_99 - 7.41063976287842) + 17.8962244818125, 2) - 0.0239005268427079*std::sin(0.225279986858368*x_1 - 4.18847990036011) + 0.0470787860084578*std::sin(0.281839966773987*x_1 + 2.15455985069275) + 0.0187933577771718*std::sin(0.341919839382172*x_1 - 4.35288000106812) + 0.0654997235505098*std::sin(0.270319938659668*x_10 - 7.50264024734497) + 0.0299315111312352*std::sin(0.316399842500687*x_101 - 4.24911975860596) + 0.00841711437619042*std::sin(0.397359818220139*x_102 + 1.99735975265503) + 0.00395505058921602*std::sin(0.416559875011444*x_103 + 5.21712017059326) + 0.016387489465198*std::sin(0.394079834222794*x_104 - 7.39215993881226) - 0.0215787293855839*std::sin(0.398559838533401*x_104 + 5.20975971221924) + 0.00812472146466259*std::sin(0.428879857063293*x_104 + 5.22983980178833) + 0.0490456342051943*std::sin(0.162960022687912*x_105 - 7.63632011413574) - 0.0148730318907952*std::sin(0.37391984462738*x_105 - 7.43215990066528) + 0.0115430659968753*std::sin(0.396559834480286*x_106 - 7.3874397277832) + 0.018214934586325*std::sin(0.40055987238884*x_106 - 7.38775968551636) - 0.00614505881288524*std::sin(0.442479848861694*x_106 + 5.22079992294312) - 0.0092987393623307*std::sin(0.392639845609665*x_107 - 7.40319967269897) + 0.00376316311651011*std::sin(0.570399820804596*x_107 + 2.1801598072052) - 0.0173547739154652*std::sin(0.296719938516617*x_108 - 7.49255990982056) - 0.0370841361376193*std::sin(0.388879835605621*x_108 + 5.17456007003784) + 0.0141886353173032*std::sin(0.3504798412323*x_109 + 5.14728021621704) + 0.0181584499323801*std::sin(0.298159927129745*x_11 - 4.2611198425293) - 0.0113432788181402*std::sin(0.300399929285049*x_11 - 1.06567990779877) - 0.0121388292212468*std::sin(0.36959981918335*x_110 - 7.41879987716675) - 0.00818671724450359*std::sin(0.400079846382141*x_110 - 4.20775985717773) + 0.0175598757486829*std::sin(0.253279983997345*x_111 - 4.3439998626709) - 0.0148423438822034*std::sin(0.355199843645096*x_111 - 4.24304008483887) - 0.0025320378931244*std::sin(0.762639880180359*x_111 - 1.20167982578278) - 0.0234846139169691*std::sin(0.350879848003387*x_112 - 4.24528026580811) + 0.0134578837907038*std::sin(0.372479856014252*x_112 - 7.41504001617432) - 0.0139275765432179*std::sin(0.377519845962524*x_113 - 7.42136001586914) + 0.0155503341534092*std::sin(0.181760013103485*x_114 - 1.20503985881805) + 0.0111210586350707*std::sin(0.321759849786758*x_114 + 5.13535976409912) + 0.0176547992696833*std::sin(0.389039844274521*x_114 - 7.40039968490601) + 0.0673477930479053*std::sin(0.189999997615814*x_115 - 7.61768007278442) - 0.0082332589061428*std::sin(0.33231982588768*x_115 + 5.14056015014648) - 0.0156951388285805*std::sin(0.3642398416996*x_115 - 7.42384004592896) + 0.0603357096352632*std::sin(0.260159969329834*x_116 - 4.30823993682861) + 0.0380026117775973*std::sin(0.240879982709885*x_117 - 7.5633602142334) + 0.00780650521909638*std::sin(0.355279833078384*x_117 - 7.42416000366211) + 0.00955971134126201*std::sin(0.363599836826324*x_117 - 7.42176008224487) - 0.00317457363006913*std::sin(0.450399875640869*x_118 + 5.2403998374939) + 0.0217588555110676*std::sin(0.299039930105209*x_119 + 5.09831953048706) - 0.00881997216514824*std::sin(0.367199838161469*x_119 + 8.1812801361084) + 0.0496995050146935*std::sin(0.249199971556664*x_12 + 5.06543970108032) - 0.022062950536883*std::sin(0.283599942922592*x_12 + 8.31063938140869) - 0.0173427962756096*std::sin(0.302719920873642*x_120 - 7.48975992202759) - 0.00461538680765419*std::sin(0.417599856853485*x_13 - 7.16351985931396) - 0.063510884493576*std::sin(0.23319998383522*x_14 + 8.24967956542969) + 0.0081406198434837*std::sin(0.351519852876663*x_14 - 1.0487197637558) - 0.0272905533427245*std::sin(0.254239976406097*x_15 - 1.0914398431778) + 0.0147037059728917*std::sin(0.313599914312363*x_16 - 4.26719999313354) + 0.0433807684419223*std::sin(0.321199834346771*x_16 - 4.25663995742798) + 0.00648363650069858*std::sin(0.237599983811378*x_18 - 4.33536005020142) + 0.0320502450862311*std::sin(0.311999946832657*x_21 - 4.27687978744507) + 0.0232797519138087*std::sin(0.364319831132889*x_21 + 8.36192035675049) + 0.038772386991943*std::sin(0.222559988498688*x_23 - 4.36664009094238) + 0.0250718203265509*std::sin(0.341359853744507*x_23 - 4.26792001724243) + 0.0175295434847892*std::sin(0.437999874353409*x_24 + 8.44855976104736) + 0.0254469228539649*std::sin(0.319279849529266*x_26 - 4.28200006484985) + 0.0139400730327304*std::sin(0.327199846506119*x_26 - 4.26272010803223) + 0.0164588346567934*std::sin(0.366399854421616*x_27 + 5.17136001586914) + 0.0303649195978718*std::sin(0.366799861192703*x_27 - 4.24416017532349) + 0.0128828847762254*std::sin(0.536719858646393*x_27 - 4.05399990081787) + 0.0155686480452525*std::sin(0.320399850606918*x_28 - 4.2739200592041) - 0.0204163626351323*std::sin(0.333199828863144*x_28 - 4.27544021606445) + 0.0287374730595909*std::sin(0.348239839076996*x_28 - 4.23992013931274) + 0.0297067239950166*std::sin(0.342559844255447*x_3 - 4.24079990386963) - 0.00802347648848091*std::sin(0.296799927949905*x_30 - 4.29607963562012) - 0.0233873150013548*std::sin(0.295999944210052*x_33 - 1.16031992435455) + 0.0311513089270171*std::sin(0.352079838514328*x_34 + 1.99303984642029) + 0.013616627812228*std::sin(0.356959849596024*x_34 + 1.98511981964111) - 0.0394639751767756*std::sin(0.312399834394455*x_35 - 7.41991996765137) - 0.0201615341883011*std::sin(0.331839829683304*x_35 + 1.95959985256195) + 0.00743994067565672*std::sin(0.333759844303131*x_35 + 1.97559976577759) + 0.024812781242645*std::sin(0.345039844512939*x_36 - 7.4507999420166) + 0.0221125475454886*std::sin(0.358079850673676*x_36 + 5.17239999771118) - 0.00818330716126707*std::sin(0.361599832773209*x_36 - 4.23776006698608) - 0.0206176634950606*std::sin(0.369439840316772*x_37 + 5.18287992477417) + 0.0221876846207433*std::sin(0.385359823703766*x_37 + 5.19280004501343) + 0.0318043407853275*std::sin(0.389999836683273*x_37 + 5.19632005691528) - 0.019994660988956*std::sin(0.262399971485138*x_38 - 7.52008008956909) + 0.0474720780808682*std::sin(0.344159841537476*x_38 + 5.13088035583496) + 0.0210570525787665*std::sin(0.367359846830368*x_38 + 5.17296028137207) - 0.0278845312099241*std::sin(0.352319836616516*x_39 - 7.42647981643677) + 0.0527201508366898*std::sin(0.2291199862957*x_40 + 5.04504013061523) + 0.00913246033254607*std::sin(0.309679925441742*x_40 - 7.48591995239258) + 0.0433811932132432*std::sin(0.360879838466644*x_43 + 5.16096019744873) + 0.0166350452998255*std::sin(0.364639848470688*x_43 - 4.23912000656128) + 0.0339290040217443*std::sin(0.329999834299088*x_44 + 5.11872005462646) + 0.0286324542389185*std::sin(0.328879833221436*x_45 - 7.44984006881714) + 0.0128092142646444*std::sin(0.341919839382172*x_45 + 5.13479995727539) + 0.046127385974026*std::sin(0.246319979429245*x_46 - 7.53096008300781) + 0.00488600785042675*std::sin(0.29479992389679*x_46 + 5.11055994033813) + 0.00684814774304598*std::sin(0.347519844770432*x_46 - 4.24232006072998) + 0.0286859592655805*std::sin(0.336879849433899*x_47 - 4.26936006546021) + 0.0298647620118105*std::sin(0.300879925489426*x_48 + 5.12215948104858) - 0.0132995997670473*std::sin(0.35455983877182*x_49 - 7.43215990066528) + 0.0576140612695044*std::sin(0.246479973196983*x_50 - 7.53216028213501) - 0.0307576919166746*std::sin(0.249039962887764*x_50 + 5.05631971359253) - 0.010617633735441*std::sin(0.366719841957092*x_50 + 5.16960000991821) - 0.0145867108462092*std::sin(0.300319939851761*x_51 - 4.28999948501587) + 0.0167054707907271*std::sin(0.338239848613739*x_51 - 4.25888013839722) + 0.0278021440419767*std::sin(0.236559987068176*x_53 - 4.34311962127686) - 0.0258806076852005*std::sin(0.290879935026169*x_53 + 5.103919506073) + 0.0168777989743145*std::sin(0.305999934673309*x_53 + 5.12415981292725) - 0.029991111875507*std::sin(0.26215997338295*x_54 - 7.52416038513184) - 0.0116059706329848*std::sin(0.324559837579727*x_54 - 4.27511978149414) - 0.00801466608270931*std::sin(0.378319829702377*x_55 - 1.00887978076935) - 0.0191254482575416*std::sin(0.300399929285049*x_56 + 5.12975978851318) + 0.00827106867132198*std::sin(0.318239837884903*x_56 + 5.1159200668335) + 0.012532847824567*std::sin(0.254079967737198*x_57 - 7.52976036071777) + 0.0217568335231114*std::sin(0.275119960308075*x_57 + 5.07976007461548) - 0.0289559914731004*std::sin(0.286479920148849*x_58 + 5.09591960906982) + 0.00683856345848978*std::sin(0.280559957027435*x_59 + 1.87903988361359) + 0.0159643945089739*std::sin(0.367759823799133*x_59 - 4.2294397354126) - 0.0298422952455045*std::sin(0.245839968323708*x_60 - 7.53416013717651) + 0.0523960364675609*std::sin(0.281599938869476*x_60 + 5.08191967010498) - 0.0113224904850227*std::sin(0.313439846038818*x_60 + 8.30096054077148) + 0.00956288753497562*std::sin(0.270399957895279*x_63 + 8.28127956390381) + 0.0487501536893196*std::sin(0.155440032482147*x_64 - 4.47199964523315) - 0.0223912376874914*std::sin(0.295599937438965*x_65 - 4.2902398109436) - 0.103288456332207*std::sin(0.162640020251274*x_66 + 4.94399976730347) - 0.0127423801055903*std::sin(0.262159943580627*x_66 - 7.51416015625) - 0.0623632565598332*std::sin(0.196959987282753*x_68 + 4.9846396446228) + 0.0208375657610882*std::sin(0.196959987282753*x_68 + 4.98943948745728) - 0.057709468601855*std::sin(0.156880035996437*x_69 - 4.47191953659058) - 0.024809204236698*std::sin(0.238479986786842*x_69 + 5.03991985321045) + 0.0320319845365095*std::sin(0.298639923334122*x_7 - 1.02047991752625) - 0.0240841363807706*std::sin(0.242239981889725*x_70 - 7.54864025115967) + 0.00256487255715928*std::sin(0.332239836454391*x_70 - 4.28344011306763) - 0.170633372939537*std::sin(0.128320053219795*x_71 - 4.51495981216431) + 0.0173508395934849*std::sin(0.275279968976974*x_73 + 5.07599973678589) + 0.00386629309158589*std::sin(0.470879852771759*x_73 + 2.04903984069824) + 0.0251131487292565*std::sin(0.274639964103699*x_74 - 4.31271982192993) + 0.0148435142791453*std::sin(0.305599927902222*x_74 + 5.12239980697632) + 0.0320830725220137*std::sin(0.312799841165543*x_74 + 5.11303997039795) + 0.0830729150742455*std::sin(0.19055999815464*x_75 + 4.97583961486816) - 0.0185296222555385*std::sin(0.202880010008812*x_75 - 4.40423965454102) + 0.0344214356855698*std::sin(0.246879979968071*x_75 + 5.0577597618103) + 0.0272654197072404*std::sin(0.178640007972717*x_77 - 7.62040042877197) - 0.0131102585370455*std::sin(0.227039992809296*x_77 - 7.55208015441895) - 0.0644150148673125*std::sin(0.221759989857674*x_78 + 5.01408004760742) + 0.00568155419739806*std::sin(0.487999856472015*x_79 - 7.32823991775513) + 0.0376029582317903*std::sin(0.202159985899925*x_8 - 4.39463996887207) + 0.0360299883565518*std::sin(0.177920013666153*x_80 - 7.6255202293396) + 0.0116397875470692*std::sin(0.313839852809906*x_80 - 4.29152011871338) + 0.0158770391200504*std::sin(0.360079854726791*x_81 - 4.23920011520386) + 0.0705078243083122*std::sin(0.193039998412132*x_82 + 4.98015975952148) - 0.0663660901506907*std::sin(0.155760034918785*x_83 + 4.93103981018066) + 0.0334784460811027*std::sin(0.249119967222214*x_84 + 5.05751991271973) + 0.00959706700657694*std::sin(0.302159935235977*x_84 + 5.14359951019287) + 0.0659480643549577*std::sin(0.164800018072128*x_85 - 7.63064002990723) - 0.0258224084947469*std::sin(0.238879978656769*x_85 + 5.03191947937012) - 0.0127956300521354*std::sin(0.391279846429825*x_86 - 4.19704008102417) - 0.151915233695381*std::sin(0.152880027890205*x_87 - 7.64616012573242) + 0.0258025118097807*std::sin(0.259839981794357*x_87 + 5.06343984603882) + 0.011015933295787*std::sin(0.345679849386215*x_88 - 4.25648021697998) - 0.00845072190702255*std::sin(0.341119825839996*x_89 - 4.27016019821167) - 0.0870480299903364*std::sin(0.178000003099442*x_9 - 4.42439985275269) - 0.0802205756540192*std::sin(0.240079984068871*x_9 - 4.34311962127686) - 0.0244365701157171*std::sin(0.335999846458435*x_93 + 1.99351978302002) + 0.0308894951211418*std::sin(0.340079843997955*x_93 - 7.4270396232605) + 0.0175601373275853*std::sin(0.358159840106964*x_93 - 7.40423965454102) + 0.0194613378818287*std::sin(0.396719843149185*x_94 - 7.39343976974487) - 0.00408481811391015*std::sin(0.411759853363037*x_94 - 4.18368005752563) + 0.00945588343229434*std::sin(0.357599824666977*x_95 - 7.42639970779419) + 0.0114085953420672*std::sin(0.364079833030701*x_95 + 5.16887998580933) + 0.00996781753442168*std::sin(0.374639838933945*x_95 - 7.41559982299805) - 0.0130265276002508*std::sin(0.383999854326248*x_96 - 7.40655994415283) - 0.0289972312278699*std::sin(0.393039852380753*x_96 + 5.19248008728027) + 0.0191053656349711*std::sin(0.395359843969345*x_96 - 7.38895988464355) + 0.00832568796226806*std::sin(0.362719833850861*x_98 - 7.41815996170044) - 0.00616301156916231*std::sin(0.410319864749908*x_98 - 7.4031195640564) + 0.00905112789761205*std::sin(0.397759854793549*x_99 + 1.99927973747253) - 0.019272007572857*std::sin(0.409279853105545*x_99 - 7.38895988464355) - 0.287882566452026*std::sin(0.074140053776218*x_1 - 0.0127004339365619*x_100 - 0.00510939363580503*x_101 + 0.00546507977291059*x_103 + 0.00231555763868462*x_104 + 0.004346050057308*x_108 + 0.00160244383916907*x_109 - 0.0107185530328028*x_11 + 0.0119212640526411*x_110 + 0.0117891816658437*x_113 - 0.0040954699024826*x_114 + 0.00481441816846101*x_116 - 0.00466743686343624*x_117 + 0.00778899301507606*x_119 - 0.00549856047590162*x_120 - 0.00197351149408633*x_13 + 0.016304962807464*x_14 - 0.00808616604107572*x_15 + 0.0167097891167228*x_2 + 0.00434327196962507*x_20 + 0.0297042048147794*x_25 - 0.010473023216609*x_26 - 0.0126872146573705*x_30 - 0.0289526730317632*x_31 - 0.00405674398063634*x_32 + 0.0217621664986396*x_33 + 0.000294413944261165*x_34 + 0.0046624509772562*x_36 + 0.0348124256735255*x_39 + 0.00365058920185482*x_40 + 0.000585969237139916*x_43 + 0.000493714245881135*x_44 + 0.00418416220727312*x_46 - 0.00945346285870526*x_48 + 0.00862231792767124*x_5 - 0.00846025900532218*x_50 - 0.00934170029674065*x_52 + 0.00226661230521528*x_53 - 0.00316931399395214*x_54 + 0.00434303416587453*x_55 + 0.000308976089768082*x_56 - 0.00106154674449775*x_57 - 9.126690404243e-5*x_59 + 0.00655879934385981*x_60 + 0.024281657414151*x_61 + 9.28231189989592e-5*x_62 + 0.0146197666945556*x_63 - 0.000774987311045921*x_64 + 0.00553696086166707*x_66 - 0.00588439790625273*x_69 + 0.00443076936053927*x_70 + 0.000784969790379118*x_71 + 0.000752619589669843*x_72 - 0.0231664989947356*x_76 - 0.0220175099178968*x_8 + 0.00572256531929871*x_83 - 0.00496533386619676*x_86 + 0.0303979335895713*x_91 - 0.0115874491138658*x_97 - 0.000954295517234596*std::pow(-4.67167949676514*x_17 - 6.90744018554688, 2) - 0.00313657225160413*std::pow(-1.91071999073029*x_18 - 2.75584006309509, 2) - 0.000368501339040594*std::pow(-6.07679986953735*x_22 - 9.73752021789551, 2) + 0.0011462872825499*std::pow(-4.91200017929077*x_4 - 8.39608001708984, 2) - 0.000180991979915109*std::pow(-5.77103996276855*x_58 - 7.56695985794067, 2) - 0.00184259891841496*std::pow(-2.89567995071411*x_6 - 4.63944005966187, 2) + 0.000164368730249448*std::pow(-6.9987998008728*x_67 - 9.77744007110596, 2) + 0.000782667679976347*std::pow(-5.27688026428223*x_7 - 8.52688026428223, 2) + 8.07311427845252e-5*std::pow(-6.59600019454956*x_75 - 9.96208000183105, 2) - 0.000194487980040483*std::pow(-4.28991985321045*x_87 - 6.95071983337402, 2) - 0.000168203453701013*std::pow(-4.93191957473755*x_88 - 5.71687984466553, 2) + 0.000125338899473705*std::pow(-5.74399995803833*x_90 - 7.7992000579834, 2) + 0.00558451696387023*std::exp(0.602479875087738*x_29) - 0.358524831994558*std::sin(0.34623983502388*x_10 - 1.06567978858948) + 0.0865301439452537*std::sin(0.301919937133789*x_102 + 5.10527992248535) + 0.192495838796587*std::sin(0.324799835681915*x_105 + 8.32863998413086) + 0.165415927460062*std::sin(0.386079847812653*x_106 + 1.99143981933594) + 0.11924083571266*std::sin(0.369519859552383*x_107 + 5.18247985839844) - 0.189621908201136*std::sin(0.357679843902588*x_111 - 4.2388801574707) - 0.197239266077176*std::sin(0.362399846315384*x_112 + 5.16552019119263) - 0.258095995645737*std::sin(0.230639979243279*x_115 + 1.83319985866547) - 0.0758193531725082*std::sin(0.322159856557846*x_118 + 1.92447984218597) - 0.337809096256283*std::sin(0.342079848051071*x_12 + 8.34247970581055) - 0.239977780197629*std::sin(0.402399867773056*x_16 + 5.189040184021) - 0.603037706483036*std::sin(0.238399982452393*x_19 - 4.33599996566772) - 0.297467086983758*std::sin(0.333199828863144*x_21 - 4.25576019287109) - 0.0822507537126382*std::sin(0.477199852466583*x_23 - 7.31928014755249) - 0.123063377784627*std::sin(0.382639855146408*x_24 + 5.38751983642578) + 0.472637530418325*std::sin(0.350639849901199*x_27 + 8.32791996002197) - 0.236571839775053*std::sin(0.311599940061569*x_28 + 5.12759971618652) + 0.388889083804962*std::sin(0.376959830522537*x_3 - 1.01671981811523) - 0.342503616587528*std::sin(0.307439923286438*x_35 - 1.14431989192963) - 0.184004202860626*std::sin(0.305039942264557*x_37 + 5.12063980102539) - 0.148213257823278*std::sin(0.320239841938019*x_38 + 5.11552000045776) - 0.111617977614102*std::sin(0.341359823942184*x_41 + 1.95199990272522) + 0.231016116474256*std::sin(0.317679852247238*x_42 + 8.32288074493408) - 0.130942816438866*std::sin(0.35471984744072*x_45 + 8.35632038116455) - 0.220152002978207*std::sin(0.29215994477272*x_47 - 7.47575998306274) - 0.113382664503492*std::sin(0.433759868144989*x_49 - 4.17463970184326) - 0.174989611557415*std::sin(0.22647999227047*x_51 - 7.58319997787476) - 0.214942584623223*std::sin(0.289519935846329*x_65 - 4.28743982315063) - 0.428543726088026*std::sin(0.183040007948875*x_68 - 4.43607997894287) + 0.594472669916755*std::sin(0.15776002407074*x_73 + 4.92848014831543) + 0.135092959483583*std::sin(0.326879858970642*x_74 - 4.27383995056152) - 0.0907698907611865*std::sin(0.332159847021103*x_77 - 1.0759197473526) + 0.129327688962637*std::sin(0.377519845962524*x_78 + 5.1831202507019) - 0.244025477577328*std::sin(0.286319941282272*x_79 + 5.09559965133667) + 0.38046686003387*std::sin(0.169440016150475*x_80 - 7.63960027694702) + 0.0866307642440267*std::sin(0.36831983923912*x_81 - 7.42639970779419) + 0.119931515701648*std::sin(0.209600001573563*x_82 + 8.20239925384521) - 0.156882460884429*std::sin(0.390079826116562*x_84 + 5.18688011169434) + 0.137494417748281*std::sin(0.346639841794968*x_85 - 4.24584007263184) - 0.993695224405009*std::sin(0.180400013923645*x_89 + 4.9684796333313) + 0.289806595783766*std::sin(0.400879859924316*x_9 - 0.971039831638336) + 0.326910903896156*std::sin(0.374399840831757*x_92 + 2.0020797252655) + 0.307342591771125*std::sin(0.361279845237732*x_93 + 2.00159978866577) + 0.111044708076835*std::sin(0.384719848632813*x_94 + 2.0019998550415) + 0.138574970235128*std::sin(0.358639866113663*x_95 - 7.41207981109619) + 0.0540350986944582*std::sin(0.414799869060516*x_96 + 8.39535999298096) - 0.161552680524961*std::sin(0.41839987039566*x_98 + 2.01895976066589) - 0.16458743634022*std::sin(0.310559868812561*x_99 - 7.46631956100464) + 7.63922738270468) + 0.698014910197107);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
