
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.218596503415265*x_1 - 57954.2973924251*x_10 - 21800.6090780853*x_100 - 1473398.41529249*x_101 + 22178.6596268187*x_102 - 12700.5052003373*x_103 - 43051.8888005093*x_104 - 24906.4716116183*x_105 - 10776.5518703799*x_106 - 197464.656981497*x_107 + 10050.6238381608*x_108 - 39294.1508611462*x_109 + 58973.2442377203*x_11 - 31780.9057253485*x_110 + 55477.1725310184*x_111 - 26266.2704693182*x_112 + 130533.247476169*x_113 + 3845.13544270442*x_114 + 48.0722378485093*x_115 - 23454.9667582503*x_116 - 28223.321462617*x_117 - 18371.4586408558*x_118 + 21341.2478859676*x_119 + 80253.9498977846*x_12 - 60330.2763841835*x_120 + 10056.900088369*x_13 - 58289.1616797634*x_14 - 19477.4175694868*x_15 + 38905.6721011883*x_16 + 138.074507556857*x_17 - 50453.9968706887*x_18 - 4947.67037614011*x_19 + 53915.7863785706*x_2 + 13604.2276840802*x_20 + 23349.0152025209*x_21 - 10779.1291792544*x_22 + 26487.1903141065*x_23 - 10920.5858812146*x_24 + 28560.4597213351*x_25 + 16130.0628614834*x_26 - 23313.0848429954*x_27 - 11.8172251937674*x_28 + 33952.9994501699*x_29 - 37551.9800409596*x_3 + 60998.9456178534*x_30 - 148984.967850939*x_31 + 28573.9786076333*x_32 - 40344.4856744909*x_33 + 51330.1905163335*x_34 + 264.576738585179*x_35 + 11.9269049772379*x_36 - 65362.6592951445*x_37 - 28494.5492403435*x_38 + 40375.9460328643*x_39 - 103276.955018918*x_4 + 46598.6263684446*x_40 - 9146.79490289713*x_41 + 28084.6104783787*x_42 - 40797.3145778636*x_43 - 22719.0891946418*x_44 - 50461.7147127093*x_45 + 29191.8866262176*x_46 - 50332.87730545*x_47 + 43120.8672006068*x_48 + 13216.0998521504*x_49 + 6343.79685415815*x_5 + 9.52543958115722*x_50 + 50917.9082209613*x_51 + 33286.7969356819*x_52 + 40205.4438912158*x_53 - 107874.136114354*x_54 + 35586.2825783015*x_55 - 44208.3010084888*x_56 + 35057.3084347581*x_57 - 23885.733895542*x_58 + 33302.1832095671*x_59 - 22999.675857219*x_6 - 51477.3048142861*x_60 + 59311.0788827043*x_61 - 12621.8189801853*x_62 - 32624.4590054622*x_63 - 72938.4203544475*x_64 - 46595.2306898837*x_65 - 59844.2118860819*x_66 - 38565.856335536*x_67 - 13390.7262617019*x_68 - 41902.4675561763*x_69 - 27105.7555170076*x_7 + 71870.9146721355*x_70 + 16622.702820849*x_71 - 90636.8213306878*x_72 + 7.80273034093424*x_73 + 10523.8474119067*x_74 + 6073.58834193725*x_75 + 40299.3771521837*x_76 + 70137.3003540108*x_77 + 74129.2841090212*x_78 + 40503.1602646148*x_79 - 500124.829750494*x_8 + 101.510583765597*x_80 + 33586.9567161221*x_81 + 76673.7561745141*x_82 + 10850.1440206358*x_83 - 69484.2772331218*x_84 - 45210.0342339378*x_85 - 76691.2108441289*x_86 - 13118.5553418231*x_87 - 43875.3580063686*x_88 - 91679.5671207718*x_89 + 290571.404132088*x_9 - 167326.136034872*x_90 + 132310.139865895*x_91 + 47746.4065576663*x_92 - 1500296.49291552*x_93 - 33860.8832551929*x_94 - 71647.0336111917*x_95 + 60014.278445854*x_96 + 72180.9344851596*x_97 - 19245.2179113749*x_98 - 56437.7395138617*x_99 - 0.0280080155950616*std::pow(-7.1832799911499*x_110 - 7.79856014251709, 2) - 2.80859615421517e-5*std::pow(-7.43791961669922*x_117 - 7.84168004989624, 2) + 0.163360302219471*std::pow(-6.70688009262085*x_13 - 9.36343955993652, 2) + 9.59667654195229e-7*std::pow(-4.98303985595703*x_13 - 7.76800012588501, 2) - 0.0287212664732777*std::pow(-3.44167971611023*x_14 - 5.26336002349854, 2) - 0.160868518328731*std::pow(-6.84879970550537*x_15 - 9.66967964172363, 2) - 1.94665141546565e-5*std::pow(-8.80000019073486*x_18 - 9.99954032897949, 2) + 7.46652242161718e-5*std::pow(-6.13807964324951*x_22 - 8.17304039001465, 2) - 6.01495401161305e-5*std::pow(-5.08871984481812*x_23 - 5.90208005905151, 2) - 0.00166345073202345*std::pow(-8.35967922210693*x_52 - 7.54143953323364, 2) - 0.00607093546130757*std::pow(-5.13479995727539*x_6 - 7.90055990219116, 2) - 0.00267106514979817*std::pow(-6.11504030227661*x_67 - 7.49976015090942, 2) + 0.000323922731534267*std::pow(-7.30751991271973*x_69 - 7.71600008010864, 2) + 0.00787531848123534*std::pow(-8.79600048065186*x_75 - 9.9973201751709, 2) - 0.0269039850504165*std::pow(-2.12663984298706*x_75 - 2.76263999938965, 2) + 0.113332687485378*std::pow(-7.26159954071045*x_76 - 9.62055969238281, 2) - 0.109533694635256*std::pow(-7.6144003868103*x_83 - 8.61336040496826, 2) + 0.00488088195467254*std::pow(-5.26496028900146*x_87 - 5.67144012451172, 2) - 0.272156764473537*std::exp(0.754719853401184*x_1) + 28.3517058186846*std::exp(0.757199883460999*x_1) + 5001.96897502409*std::exp(0.825519859790802*x_1) - 0.324609360804983*std::exp(0.861039876937866*x_1) + 0.000814369855899838*std::exp(0.9440798163414*x_1) + 5.73286190420193e-5*std::exp(1.0079197883606*x_1) - 0.193819095627742*std::exp(1.04303979873657*x_1) - 0.00143541316724003*std::exp(1.06415987014771*x_1) - 2.39021665512066*std::exp(1.10735988616943*x_1) - 0.0424212961501244*std::exp(1.13199985027313*x_1) - 4.67972756415127e-7*std::exp(1.1593599319458*x_1) - 0.000820462546735219*std::exp(1.20591986179352*x_1) - 0.0335475970951883*std::exp(1.00127983093262*x_108) + 0.543951637020478*std::exp(1.28079986572266*x_108) - 0.0207015985654692*std::exp(1.56919980049133*x_108) - 0.00110769882057425*std::exp(2.03247976303101*x_108) + 596.587362917235*std::exp(2.7753598690033*x_17) + 0.00285504803723934*std::exp(2.80999994277954*x_17) + 0.00668203003925367*std::exp(2.84888005256653*x_17) + 0.00725159398586907*std::exp(3.49399995803833*x_17) - 0.0114116638624386*std::exp(3.63927984237671*x_17) + 0.000112998531545587*std::exp(3.64759993553162*x_17) + 1.06245450982238e-7*std::exp(3.85743999481201*x_17) + 0.00574228336673819*std::exp(4.2695198059082*x_17) - 4.07883726283191*std::exp(0.929519832134247*x_29) + 0.256829276825072*std::exp(1.05495977401733*x_29) + 1.71549573434767*std::exp(1.27431988716125*x_29) - 0.00116308483473659*std::exp(1.46327984333038*x_29) + 0.0104553900146917*std::exp(1.66111981868744*x_29) - 1.64847671565174*std::exp(1.70815992355347*x_29) - 0.000971583519440418*std::exp(2.27495980262756*x_29) - 0.920589849675324*std::exp(1.40247988700867*x_38) - 0.000435983143759305*std::exp(1.75471985340118*x_38) - 0.00563528745046291*std::exp(2.47439980506897*x_38) - 0.102973887759584*std::exp(1.59183979034424*x_50) - 5.69558515184395e-6*std::exp(1.66439986228943*x_50) + 0.129239287607991*std::exp(1.66527986526489*x_50) + 0.721081990059435*std::exp(1.71759986877441*x_50) - 40500.1010329279*std::exp(1.88511991500854*x_50) - 0.0215501292465585*std::exp(1.92927980422974*x_50) - 0.067667469903647*std::exp(1.93591976165771*x_50) - 2.22218891861462*std::exp(1.9366397857666*x_50) - 83.57048744589*std::exp(1.95703983306885*x_50) - 0.174863291931464*std::exp(2.02871990203857*x_50) - 0.43646325760779*std::exp(0.751999855041504*x_66) - 24.5291234838829*std::exp(0.740719854831696*x_71) + 0.331025779485168*std::exp(0.757279872894287*x_71) - 1.3599016494842*std::exp(1.08503985404968*x_71) + 0.0453575490591725*std::exp(1.08831977844238*x_71) + 0.00083501012781997*std::exp(1.28671991825104*x_71) + 0.285092475031175*std::exp(1.29703986644745*x_71) + 26.8105954741929*std::exp(1.67023992538452*x_71) - 0.00848965726889746*std::exp(1.67927992343903*x_71) - 1.75738256694874e-5*std::exp(1.84575986862183*x_71) - 0.566123606072042*std::exp(1.87239992618561*x_71) - 0.0130792264481611*std::exp(1.95615983009338*x_71) + 0.1205265057353*std::exp(0.985039830207825*x_72) + 83148.8213334724*std::exp(0.735359847545624*x_73) + 0.968991308688868*std::exp(0.856079876422882*x_73) + 8.36485094983137e-5*std::exp(0.937839806079865*x_76) + 0.547149563132571*std::exp(1.32255983352661*x_76) - 0.000389381059897942*std::exp(1.70791983604431*x_76) + 0.0387529631136987*std::exp(2.26183986663818*x_76) - 0.0770072498178994*std::exp(1.01895976066589*x_77) + 0.802802689742452*std::exp(1.48071980476379*x_77) + 0.126794933386549*std::exp(1.26399981975555*x_78) - 0.0324864976988001*std::exp(1.60799980163574*x_78) + 0.442165206544244*std::exp(1.75887989997864*x_78) - 1.59815591797653*std::exp(1.92959976196289*x_78) - 5.03461964858851*std::exp(1.39375984668732*x_81) - 0.0677263791864555*std::exp(1.04471981525421*x_87) - 10.7695131666682*std::exp(0.913439810276031*x_88) - 14.7620042165798*std::sin(0.371119856834412*x_102 + 8.18839931488037) - 7.7268340257666*std::sin(0.247919961810112*x_104 - 1.35807979106903) - 0.219875034677362*std::sin(0.286159932613373*x_104 - 7.49079990386963) - 0.000326423721196426*std::sin(0.361919850111008*x_105 + 5.16847991943359) + 76.57164154626*std::sin(0.433759868144989*x_105 + 2.01007986068726) - 987.567057149088*std::sin(0.437199860811234*x_105 + 2.02327990531921) + 1.3004558093305*std::sin(0.437999874353409*x_105 + 2.02783989906311) - 25.8545612818013*std::sin(0.467039853334427*x_105 - 7.36383962631226) + 45.0574754688401*std::sin(0.49127984046936*x_105 - 7.34815979003906) - 0.0107943953121123*std::sin(0.5065598487854*x_105 + 2.05463981628418) + 4.03089273948554*std::sin(0.517359852790833*x_109 + 2.1580798625946) + 21.5700334246638*std::sin(0.396799832582474*x_111 - 7.40463972091675) + 431.863959734834*std::sin(0.186080008745193*x_112 - 7.60784006118774) - 0.393674194814537*std::sin(0.258879989385605*x_112 + 5.0434398651123) - 222624.883068645*std::sin(0.511919856071472*x_115 + 5.26783990859985) - 73.1671051030767*std::sin(0.466559857130051*x_117 - 7.35599946975708) - 80.9701173767167*std::sin(0.433039873838425*x_120 - 1.17831993103027) - 50.5972980165483*std::sin(0.340079843997955*x_14 - 1.2299998998642) - 21.1449365295024*std::sin(0.479199856519699*x_14 - 4.32376003265381) - 0.582340401545635*std::sin(0.410479873418808*x_15 + 5.20991992950439) - 3.92287873633928*std::sin(0.549839854240417*x_15 + 2.14871978759766) - 0.862257861944649*std::sin(0.475679844617844*x_17 - 4.10208034515381) - 1.42384777444819*std::sin(0.441199839115143*x_19 - 1.15015983581543) - 137.305375718743*std::sin(0.315679848194122*x_21 + 8.31968021392822) - 0.367451343716829*std::sin(0.457839846611023*x_21 - 1.17007982730865) + 45.7232659507814*std::sin(0.256719976663589*x_26 + 5.04903984069824) + 2.5998356903487*std::sin(0.300159931182861*x_28 + 5.10303974151611) + 17.4097425190192*std::sin(0.321759849786758*x_28 + 8.30416011810303) + 78.2273199759389*std::sin(0.32551982998848*x_28 - 4.27016019821167) - 472437.953329299*std::sin(0.338879853487015*x_28 - 4.24847984313965) - 742.452543712596*std::sin(0.342879861593246*x_28 - 4.26847982406616) - 5.40246043289977*std::sin(0.344799846410751*x_28 + 5.13168001174927) - 22.6775369278807*std::sin(0.369919836521149*x_28 - 4.22656011581421) - 19.7691157884591*std::sin(0.36303985118866*x_3 + 5.17160034179688) + 2.04992277688248*std::sin(0.380399852991104*x_34 + 1.99079978466034) - 1009.28127387187*std::sin(0.329919844865799*x_36 - 1.23263990879059) - 14.4073346834705*std::sin(0.330239832401276*x_36 - 7.44320011138916) + 3.62525401854225*std::sin(0.3503198325634*x_36 + 5.15304040908813) + 0.000491030553801884*std::sin(0.364159852266312*x_36 - 7.42759990692139) + 18.5902567312719*std::sin(0.365519851446152*x_36 + 1.96367979049683) - 6.89899423832474*std::sin(0.3781598508358*x_36 + 8.38055992126465) + 194921.442465999*std::sin(0.42663985490799*x_36 - 4.18807983398438) - 0.0292786528782137*std::sin(0.362399846315384*x_43 - 7.43351984024048) - 1.07664054552307*std::sin(0.452079862356186*x_45 - 7.34592008590698) - 988.897375219817*std::sin(0.34215983748436*x_46 + 8.32800006866455) - 1.52017026950977*std::sin(0.370959848165512*x_46 - 4.22959995269775) - 14.2132645469358*std::sin(0.40287983417511*x_46 - 4.18824005126953) + 28.69128988948*std::sin(0.407039850950241*x_46 - 7.38815975189209) + 0.210545569364974*std::sin(0.306159913539886*x_47 - 7.47959995269775) - 1.58126736869914*std::sin(0.690959870815277*x_47 + 5.23975992202759) - 90.7621859230888*std::sin(0.403599858283997*x_49 + 5.19695997238159) + 0.00189678906851552*std::sin(0.157360032200813*x_53 - 4.46767997741699) - 1840.77908869199*std::sin(0.233919993042946*x_53 - 4.36143970489502) - 185.051435369229*std::sin(0.290159940719604*x_53 + 5.1017599105835) - 0.965535790617453*std::sin(0.44191986322403*x_53 - 7.35687971115112) + 0.000941429719757592*std::sin(0.174800008535385*x_55 - 7.63616037368774) + 4.44970149782321*std::sin(0.417919874191284*x_55 + 5.20223999023438) - 21.9350923087413*std::sin(0.473199844360352*x_55 + 2.05047988891602) + 785.702725733913*std::sin(0.130960047245026*x_67 - 7.68008041381836) + 1.69691093088712*std::sin(0.179680004715919*x_67 + 1.78391993045807) - 0.0284226630638876*std::sin(0.655519843101501*x_67 + 5.42639970779419) + 0.00109036148884748*std::sin(0.304239928722382*x_68 + 5.14751958847046) - 0.0173953475403808*std::sin(0.352319836616516*x_69 - 4.24432039260864) - 0.0127048101335723*std::sin(0.40735986828804*x_72 + 5.19271993637085) - 135.412218225683*std::sin(0.241279974579811*x_73 + 1.85223984718323) - 0.423890056760214*std::sin(0.483999848365784*x_73 + 8.48151969909668) - 384.887556608412*std::sin(0.5933598279953*x_73 - 3.99767971038818) - 1.95039625553378*std::sin(0.821039855480194*x_73 - 0.78743988275528) + 137.203123330753*std::sin(0.147360026836395*x_75 + 1.74791991710663) - 1252.51762160521*std::sin(0.311999946832657*x_75 - 7.47160005569458) - 0.102616380041688*std::sin(0.400079846382141*x_75 - 4.18535995483398) + 0.0732357736578696*std::sin(0.495359867811203*x_78 - 7.31343984603882) - 25.663512193472*std::sin(0.183360010385513*x_80 - 4.43607997894287) - 3.60014684965949*std::sin(0.212880000472069*x_80 + 1.8199999332428) - 51.9400458630568*std::sin(0.231199979782104*x_80 + 5.04256010055542) + 0.369608755256791*std::sin(0.251519978046417*x_80 + 1.83783984184265) - 342649.938743356*std::sin(0.323599845170975*x_80 - 1.26775979995728) - 4874.20923198504*std::sin(0.173440024256706*x_85 + 1.78063988685608) + 0.52752762643027*std::sin(0.35999983549118*x_85 - 4.4215202331543) + 2.17667999280257*std::sin(0.33231982588768*x_86 - 4.28263998031616) - 2.01960637772047*std::sin(0.348239839076996*x_92 + 1.99207985401154) + 0.000934940303463862*std::sin(0.352559864521027*x_92 + 2.00831985473633) + 1010.59254715192*std::sin(0.364959836006165*x_92 + 1.97991979122162) + 17.7001009304787*std::sin(0.369199842214584*x_92 + 1.98607981204987) - 106.853289046471*std::sin(0.376879841089249*x_95 + 1.99391984939575) - 5.42341262226399*std::sin(0.135200038552284*x_96 - 7.67199993133545) - 90.3773356518826*std::sin(0.470319867134094*x_96 + 5.2292799949646) - 0.587868783839509*std::sin(0.399999856948853*x_97 + 5.1846399307251) - 0.0136744841868912*std::sin(0.513519823551178*x_98 + 5.15759992599487) - 3.94618157977262*std::sin(0.598479866981506*x_99 + 1.99935972690582) - 6300281.95931022 - 2.78904202774889*std::exp(-2.46007990837097*x_86) - 0.0193534212709364*std::exp(-2.28759980201721*x_86) + 4.5823161472059*std::exp(-2.11679983139038*x_23) - 0.0119743164565184*std::exp(-2.11087989807129*x_23) + 0.16168684970187*std::exp(-2.10407996177673*x_23) - 0.152031284189213*std::exp(-1.98967981338501*x_23));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.814096962367594*x_1 - 32423.6372560847*x_10 - 12278.6171018714*x_100 - 820560.863638433*x_101 + 12592.0269551541*x_102 - 7244.01187947499*x_103 - 24302.4959078501*x_104 - 13928.7671971713*x_105 - 5898.68622446883*x_106 - 110827.476528313*x_107 + 5567.47887270926*x_108 - 21905.2082272094*x_109 + 33080.0364943963*x_11 - 17670.5225648257*x_110 + 30871.0080113043*x_111 - 14569.3822465903*x_112 + 72941.8430009054*x_113 + 2118.88693237645*x_114 + 100.873015006162*x_115 - 12951.4115824008*x_116 - 15642.3272062226*x_117 - 10013.1822516897*x_118 + 11821.0630310637*x_119 + 44713.7780503196*x_12 - 33629.0857351417*x_120 + 5629.78443492842*x_13 - 32483.5233161663*x_14 - 10788.363996644*x_15 + 21562.1945217202*x_16 + 197.367270080341*x_17 - 28274.0338128864*x_18 - 2644.67029473421*x_19 + 30077.7529897926*x_2 + 7391.69234714836*x_20 + 12905.057165825*x_21 - 6049.27979740055*x_22 + 14792.997346305*x_23 - 6155.93378456299*x_24 + 15922.5601402124*x_25 + 9085.73017795926*x_26 - 13045.5340433001*x_27 + 9.80967668526659*x_28 + 18976.0287320689*x_29 - 20889.4723958712*x_3 + 34447.8241668141*x_30 - 84721.8236695234*x_31 + 15978.8345801696*x_32 - 22380.2404453491*x_33 + 28496.3965829618*x_34 + 70.2009314844427*x_35 - 10.3580217447412*x_36 - 36459.6774535442*x_37 - 15964.7313368882*x_38 + 22405.0801328154*x_39 - 57811.1118482692*x_4 + 26381.7876402329*x_40 - 4958.07337662407*x_41 + 15810.6060352223*x_42 - 22951.9016357269*x_43 - 12685.7899840319*x_44 - 28317.5772517388*x_45 + 16296.0398384985*x_46 - 28095.2852324981*x_47 + 23439.1634517275*x_48 + 7563.93810741158*x_49 + 3537.00931884455*x_5 + 10.5061799667347*x_50 + 28458.3310011804*x_51 + 18601.8354625905*x_52 + 22454.1803177243*x_53 - 60179.2753512218*x_54 + 19971.5909082359*x_55 - 24787.1123652526*x_56 + 19713.8343235179*x_57 - 13313.4333702995*x_58 + 18455.4766165793*x_59 - 12750.1332648328*x_6 - 28920.6791551121*x_60 + 33144.1469003963*x_61 - 7465.6820286655*x_62 - 18111.7339077411*x_63 - 40950.2944971435*x_64 - 26177.7622262056*x_65 - 33672.9322111202*x_66 - 21686.1946717742*x_67 - 7441.40794398389*x_68 - 23485.9399812269*x_69 - 14974.6523505053*x_7 + 39987.54885364*x_70 + 9282.24246455413*x_71 - 50643.5582574482*x_72 - 1.11983088358869*x_73 + 5781.56127364857*x_74 + 3391.35056962274*x_75 + 22554.7719614426*x_76 + 39194.3618106266*x_77 + 41381.2728164964*x_78 + 22651.292020129*x_79 - 280309.578191356*x_8 + 161.111713071668*x_80 + 18789.6300108116*x_81 + 42746.5752377156*x_82 + 6284.88365201188*x_83 - 39142.9098075684*x_84 - 25263.1443923278*x_85 - 42866.5137738382*x_86 - 7488.84106276889*x_87 - 24459.8751766226*x_88 - 51114.5215910607*x_89 + 162747.646901535*x_9 - 93660.6380706229*x_90 + 73994.6711198941*x_91 + 26666.8237367779*x_92 - 841973.069735474*x_93 - 19010.748528916*x_94 - 39898.0353869908*x_95 + 33544.7382801591*x_96 + 40411.9875129183*x_97 - 10663.9327144014*x_98 - 31614.257230907*x_99 + 0.0682698357219427*std::pow(-7.1832799911499*x_110 - 7.79856014251709, 2) - 1.9976865330191e-6*std::pow(-7.43791961669922*x_117 - 7.84168004989624, 2) - 0.0616755547524649*std::pow(-6.70688009262085*x_13 - 9.36343955993652, 2) + 1.20144736411142e-5*std::pow(-4.98303985595703*x_13 - 7.76800012588501, 2) + 0.00646067467770043*std::pow(-3.44167971611023*x_14 - 5.26336002349854, 2) + 0.0346397426777314*std::pow(-6.84879970550537*x_15 - 9.66967964172363, 2) - 1.38460608205347e-6*std::pow(-8.80000019073486*x_18 - 9.99954032897949, 2) + 3.9997177010227e-5*std::pow(-6.13807964324951*x_22 - 8.17304039001465, 2) - 4.27829134768803e-6*std::pow(-5.08871984481812*x_23 - 5.90208005905151, 2) - 0.00379894773133186*std::pow(-8.35967922210693*x_52 - 7.54143953323364, 2) - 0.0138646525886235*std::pow(-5.13479995727539*x_6 - 7.90055990219116, 2) + 0.00817959721012745*std::pow(-6.11504030227661*x_67 - 7.49976015090942, 2) + 0.000173521140086608*std::pow(-7.30751991271973*x_69 - 7.71600008010864, 2) - 0.00177150512279402*std::pow(-8.79600048065186*x_75 - 9.9973201751709, 2) + 0.082388017033701*std::pow(-2.12663984298706*x_75 - 2.76263999938965, 2) - 0.0244038744948649*std::pow(-7.26159954071045*x_76 - 9.62055969238281, 2) + 0.0413536905168095*std::pow(-7.6144003868103*x_83 - 8.61336040496826, 2) + 0.0111468377581865*std::pow(-5.26496028900146*x_87 - 5.67144012451172, 2) + 0.837133854529706*std::exp(0.754719853401184*x_1) + 45.8191287100997*std::exp(0.757199883460999*x_1) + 2795.48407522023*std::exp(0.825519859790802*x_1) + 0.791238767371599*std::exp(0.861039876937866*x_1) + 0.00113691622747416*std::exp(0.9440798163414*x_1) + 4.0776460526354e-6*std::exp(1.0079197883606*x_1) + 0.041734975048729*std::exp(1.04303979873657*x_1) - 0.000768931924274263*std::exp(1.06415987014771*x_1) + 0.902409803240292*std::exp(1.10735988616943*x_1) + 0.00954241325281861*std::exp(1.13199985027313*x_1) - 5.85874320357711e-6*std::exp(1.1593599319458*x_1) - 0.000672565109826479*std::exp(1.20591986179352*x_1) - 0.0468347486758837*std::exp(1.00127983093262*x_108) - 1.67315455655696*std::exp(1.28079986572266*x_108) - 0.016969906753418*std::exp(1.56919980049133*x_108) + 0.00339210377669567*std::exp(2.03247976303101*x_108) + 333.418795846236*std::exp(2.7753598690033*x_17) + 0.00398584306656223*std::exp(2.80999994277954*x_17) + 0.00547752031472658*std::exp(2.84888005256653*x_17) - 0.0016312020809061*std::exp(3.49399995803833*x_17) + 0.02781605196407*std::exp(3.63927984237671*x_17) + 6.05318247627478e-5*std::exp(3.64759993553162*x_17) + 1.33013045165603e-6*std::exp(3.85743999481201*x_17) - 0.00216795945757755*std::exp(4.2695198059082*x_17) - 5.05304578470406*std::exp(0.929519832134247*x_29) + 0.586540364407054*std::exp(1.05495977401733*x_29) - 4.18153908719827*std::exp(1.27431988716125*x_29) - 8.27274119714556e-5*std::exp(1.46327984333038*x_29) + 0.0145964422506035*std::exp(1.66111981868744*x_29) + 0.622371007845895*std::exp(1.70815992355347*x_29) - 0.000520464492208153*std::exp(2.27495980262756*x_29) - 1.14046782442934*std::exp(1.40247988700867*x_38) - 3.10104268142699e-5*std::exp(1.75471985340118*x_38) + 0.0137360730603443*std::exp(2.47439980506897*x_38) + 0.023163351439662*std::exp(1.59183979034424*x_50) - 7.13053705399031e-5*std::exp(1.66439986228943*x_50) + 0.295153495685501*std::exp(1.66527986526489*x_50) - 2.21799427597583*std::exp(1.71759986877441*x_50) - 22634.5641181861*std::exp(1.88511991500854*x_50) - 0.0115441203467408*std::exp(1.92927980422974*x_50) - 0.0944684335357296*std::exp(1.93591976165771*x_50) + 0.478502898651791*std::exp(1.9366397857666*x_50) - 135.058078873177*std::exp(1.95703983306885*x_50) + 0.426231132778434*std::exp(2.02871990203857*x_50) - 0.996784016730025*std::exp(0.751999855041504*x_66) + 5.28184466680855*std::exp(0.740719854831696*x_71) + 0.755988506168643*std::exp(0.757279872894287*x_71) + 4.18295577483141*std::exp(1.08503985404968*x_71) + 0.0633222524019492*std::exp(1.08831977844238*x_71) + 5.93922513486687e-5*std::exp(1.28671991825104*x_71) - 0.0641298229641285*std::exp(1.29703986644745*x_71) + 43.3285437103008*std::exp(1.67023992538452*x_71) - 0.00695930276910967*std::exp(1.67927992343903*x_71) - 0.000220013943740401*std::exp(1.84575986862183*x_71) - 0.701339209424027*std::exp(1.87239992618561*x_71) + 0.0400524877403634*std::exp(1.95615983009338*x_71) - 0.369088065910098*std::exp(0.985039830207825*x_72) + 46469.9415513537*std::exp(0.735359847545624*x_73) - 0.217968717249381*std::exp(0.856079876422882*x_73) + 0.00104723005729391*std::exp(0.937839806079865*x_76) + 0.677833317544555*std::exp(1.32255983352661*x_76) - 2.7695733272418e-5*std::exp(1.70791983604431*x_76) - 0.0944607595111881*std::exp(2.26183986663818*x_76) - 0.0631258424132858*std::exp(1.01895976066589*x_77) + 0.99454782967627*std::exp(1.48071980476379*x_77) + 0.289571139836089*std::exp(1.26399981975555*x_78) - 0.0453533810712543*std::exp(1.60799980163574*x_78) - 1.07778239091158*std::exp(1.75887989997864*x_78) + 0.603372737947768*std::exp(1.92959976196289*x_78) + 1.08410228998926*std::exp(1.39375984668732*x_81) - 0.0945506749388079*std::exp(1.04471981525421*x_87) + 2.31899422418687*std::exp(0.913439810276031*x_88) + 45.4068210074228*std::sin(0.371119856834412*x_102 + 8.18839931488037) + 1.73810444520302*std::sin(0.247919961810112*x_104 - 1.35807979106903) - 0.117784159552761*std::sin(0.286159932613373*x_104 - 7.49079990386963) - 0.00408663267643179*std::sin(0.361919850111008*x_105 + 5.16847991943359) - 28.9090948443995*std::sin(0.433759868144989*x_105 + 2.01007986068726) - 1596.00492438617*std::sin(0.437199860811234*x_105 + 2.02327990531921) - 3.982383099378*std::sin(0.437999874353409*x_105 + 2.02783989906311) - 32.0297853240836*std::sin(0.467039853334427*x_105 - 7.36383962631226) - 9.70220508129128*std::sin(0.49127984046936*x_105 - 7.34815979003906) - 0.000767779237849063*std::sin(0.5065598487854*x_105 + 2.05463981628418) - 0.906724871438052*std::sin(0.517359852790833*x_109 + 2.1580798625946) - 52.5771857495772*std::sin(0.396799832582474*x_111 - 7.40463972091675) - 92.9930641023936*std::sin(0.186080008745193*x_112 - 7.60784006118774) - 0.210886080094905*std::sin(0.258879989385605*x_112 + 5.0434398651123) - 124419.867151048*std::sin(0.511919856071472*x_115 + 5.26783990859985) + 15.7550384598305*std::sin(0.466559857130051*x_117 - 7.35599946975708) + 30.5697090402785*std::sin(0.433039873838425*x_120 - 1.17831993103027) + 19.1026606938687*std::sin(0.340079843997955*x_14 - 1.2299998998642) - 26.195291822958*std::sin(0.479199856519699*x_14 - 4.32376003265381) - 0.812987179761821*std::sin(0.410479873418808*x_15 + 5.20991992950439) + 0.88242777661414*std::sin(0.549839854240417*x_15 + 2.14871978759766) + 2.64049044348687*std::sin(0.475679844617844*x_17 - 4.10208034515381) + 4.36024605554927*std::sin(0.441199839115143*x_19 - 1.15015983581543) + 29.5659022198939*std::sin(0.315679848194122*x_21 + 8.31968021392822) + 1.12524547974835*std::sin(0.457839846611023*x_21 - 1.17007982730865) + 56.6440241146291*std::sin(0.256719976663589*x_26 + 5.04903984069824) + 5.93744059114496*std::sin(0.300159931182861*x_28 + 5.10303974151611) - 53.5510660170764*std::sin(0.321759849786758*x_28 + 8.30416011810303) - 16.8446521574701*std::sin(0.32551982998848*x_28 - 4.27016019821167) - 264034.579513827*std::sin(0.338879853487015*x_28 - 4.24847984313965) - 1199.87590443638*std::sin(0.342879861593246*x_28 - 4.26847982406616) + 1.21525070451153*std::sin(0.344799846410751*x_28 + 5.13168001174927) - 28.0939456509081*std::sin(0.369919836521149*x_28 - 4.22656011581421) + 48.1874298686173*std::sin(0.36303985118866*x_3 + 5.17160034179688) + 4.6815630500642*std::sin(0.380399852991104*x_34 + 1.99079978466034) - 1631.09722173233*std::sin(0.329919844865799*x_36 - 1.23263990879059) + 44.3158840472103*std::sin(0.330239832401276*x_36 - 7.44320011138916) + 8.27926566390709*std::sin(0.3503198325634*x_36 + 5.15304040908813) + 0.00614741324232888*std::sin(0.364159852266312*x_36 - 7.42759990692139) - 45.3139483861346*std::sin(0.365519851446152*x_36 + 1.96367979049683) + 1.55188690647106*std::sin(0.3781598508358*x_36 + 8.38055992126465) + 108937.058796937*std::sin(0.42663985490799*x_36 - 4.18807983398438) - 0.00208251978384172*std::sin(0.362399846315384*x_43 - 7.43351984024048) + 3.29699408609934*std::sin(0.452079862356186*x_45 - 7.34592008590698) - 1598.15484846121*std::sin(0.34215983748436*x_46 + 8.32800006866455) + 4.65521423030073*std::sin(0.370959848165512*x_46 - 4.22959995269775) - 17.608026964016*std::sin(0.40287983417511*x_46 - 4.18824005126953) - 69.9353240773976*std::sin(0.407039850950241*x_46 - 7.38815975189209) + 0.293936069342019*std::sin(0.306159913539886*x_47 - 7.47959995269775) + 4.86386017250682*std::sin(0.690959870815277*x_47 + 5.23975992202759) + 19.5437789687325*std::sin(0.403599858283997*x_49 + 5.19695997238159) + 0.0237466816421399*std::sin(0.157360032200813*x_53 - 4.46767997741699) - 2974.87899073974*std::sin(0.233919993042946*x_53 - 4.36143970489502) + 69.8648923825066*std::sin(0.290159940719604*x_53 + 5.1017599105835) + 2.95675822800858*std::sin(0.44191986322403*x_53 - 7.35687971115112) + 0.0117861454468571*std::sin(0.174800008535385*x_55 - 7.63616037368774) - 1.00093336124503*std::sin(0.417919874191284*x_55 + 5.20223999023438) - 27.1741720950213*std::sin(0.473199844360352*x_55 + 2.05047988891602) - 169.184999795911*std::sin(0.130960047245026*x_67 - 7.68008041381836) + 2.36900415692834*std::sin(0.179680004715919*x_67 + 1.78391993045807) - 0.0152256461773556*std::sin(0.655519843101501*x_67 + 5.42639970779419) + 0.0136506834525227*std::sin(0.304239928722382*x_68 + 5.14751958847046) - 0.00123728900883283*std::sin(0.352319836616516*x_69 - 4.24432039260864) - 0.00090366242474238*std::sin(0.40735986828804*x_72 + 5.19271993637085) + 29.1582495039411*std::sin(0.241279974579811*x_73 + 1.85223984718323) - 0.591779620407394*std::sin(0.483999848365784*x_73 + 8.48151969909668) - 622.015924118913*std::sin(0.5933598279953*x_73 - 3.99767971038818) + 4.75411160444589*std::sin(0.821039855480194*x_73 - 0.78743988275528) + 169.973357435041*std::sin(0.147360026836395*x_75 + 1.74791991710663) - 2024.19094226689*std::sin(0.311999946832657*x_75 - 7.47160005569458) - 0.0549702429713882*std::sin(0.400079846382141*x_75 - 4.18535995483398) + 0.0392314391770123*std::sin(0.495359867811203*x_78 - 7.31343984603882) + 5.77285139997169*std::sin(0.183360010385513*x_80 - 4.43607997894287) + 11.0247221524151*std::sin(0.212880000472069*x_80 + 1.8199999332428) - 64.3456487458471*std::sin(0.231199979782104*x_80 + 5.04256010055542) + 0.197994541149903*std::sin(0.251519978046417*x_80 + 1.83783984184265) - 191499.078046086*std::sin(0.323599845170975*x_80 - 1.26775979995728) - 7877.19869797383*std::sin(0.173440024256706*x_85 + 1.78063988685608) + 0.736464782659226*std::sin(0.35999983549118*x_85 - 4.4215202331543) - 6.66564258000724*std::sin(0.33231982588768*x_86 - 4.28263998031616) + 6.18463637774099*std::sin(0.348239839076996*x_92 + 1.99207985401154) + 0.0117049017781074*std::sin(0.352559864521027*x_92 + 2.00831985473633) + 1633.21636756352*std::sin(0.364959836006165*x_92 + 1.97991979122162) - 43.1441841598607*std::sin(0.369199842214584*x_92 + 1.98607981204987) + 23.0086686648991*std::sin(0.376879841089249*x_95 + 1.99391984939575) - 4.44578258988396*std::sin(0.135200038552284*x_96 - 7.67199993133545) + 19.4609093401529*std::sin(0.470319867134094*x_96 + 5.2292799949646) - 0.820705180982093*std::sin(0.399999856948853*x_97 + 5.1846399307251) - 0.000972632995496242*std::sin(0.513519823551178*x_98 + 5.15759992599487) - 4.88870599939123*std::sin(0.598479866981506*x_99 + 1.99935972690582) - 3489957.68419143 - 4.50736461730235*std::exp(-2.46007990837097*x_86) + 0.00435343472225856*std::exp(-2.28759980201721*x_86) + 7.40547093292805*std::exp(-2.11679983139038*x_23) - 0.00981581364648732*std::exp(-2.11087989807129*x_23) + 0.200304891242674*std::exp(-2.10407996177673*x_23) + 0.467636860647615*std::exp(-1.98967981338501*x_23));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.041138560658626*x_1 - 50503.1550664521*x_10 - 19054.4773955695*x_100 - 1281292.97823693*x_101 + 19480.2988814699*x_102 - 11178.584225182*x_103 - 37668.7728086611*x_104 - 21697.8680102797*x_105 - 9277.20111033337*x_106 - 172270.469212933*x_107 + 8722.21934948957*x_108 - 34181.4147003196*x_109 + 51455.8552478634*x_11 - 27613.9790180423*x_110 + 48231.412093941*x_111 - 22802.7151290626*x_112 + 113639.439044513*x_113 + 3342.51844848568*x_114 + 104.520124011676*x_115 - 20329.7373860618*x_116 - 24484.0314325388*x_117 - 15834.3977746641*x_118 + 18523.3552330833*x_119 + 69816.789082261*x_12 - 52482.2913841641*x_120 + 8764.16737624897*x_13 - 50701.6257190802*x_14 - 16889.4526925977*x_15 + 33764.5835585749*x_16 + 202.357453461086*x_17 - 43998.2973765893*x_18 - 4204.03135481614*x_19 + 46918.4408832972*x_2 + 11677.1650789735*x_20 + 20224.5430870304*x_21 - 9405.47279409615*x_22 + 23057.4405239143*x_23 - 9562.06997353379*x_24 + 24826.2418670295*x_25 + 14116.4238041174*x_26 - 20319.3889225247*x_27 + 3.76564537309708*x_28 + 29572.6087428068*x_29 - 32629.571897454*x_3 + 53371.5689893555*x_30 - 130831.833983585*x_31 + 24867.5469352109*x_32 - 35004.3934782425*x_33 + 44572.3953433254*x_34 + 164.523924727499*x_35 - 7.46939610952355*x_36 - 56871.03879688*x_37 - 24830.4118036956*x_38 + 35007.1053571434*x_39 - 90066.8060885813*x_4 + 40817.1247229513*x_40 - 7859.30044677669*x_41 + 24542.2624765921*x_42 - 35643.5341397507*x_43 - 19791.8039551898*x_44 - 44038.3804637928*x_45 + 25404.5494525495*x_46 - 43809.3386453482*x_47 + 37063.25389296*x_48 + 11614.8952004324*x_49 + 5516.02327803323*x_5 + 4.46823228123586*x_50 + 44348.2224289501*x_51 + 28988.4447495296*x_52 + 35006.2581920406*x_53 - 93892.6725464602*x_54 + 31070.1178776239*x_55 - 38567.4425864169*x_56 + 30621.4470979072*x_57 - 20779.9838428656*x_58 + 28893.8858364106*x_59 - 19941.1851667274*x_6 - 44961.0935925357*x_60 + 51640.4122161544*x_61 - 11310.9451567893*x_62 - 28338.4128821003*x_63 - 63669.5081156215*x_64 - 40678.7918870146*x_65 - 52310.3126917716*x_66 - 33674.5098295654*x_67 - 11651.1147838529*x_68 - 36564.142456439*x_69 - 23458.0041540554*x_7 + 62458.9140901068*x_70 + 14467.6657776012*x_71 - 78957.5139992995*x_72 - 1.46092490831812*x_73 + 9090.86146708967*x_74 + 5292.00308096705*x_75 + 35120.0952196053*x_76 + 61085.0543274298*x_77 + 64529.3626672175*x_78 + 35311.2501228026*x_79 - 436041.940853113*x_8 + 171.009918975751*x_80 + 29276.8230672165*x_81 + 66679.9264789706*x_82 + 9630.68134883714*x_83 - 60738.6709211775*x_84 - 39371.6753057633*x_85 - 66802.4617276076*x_86 - 11557.2263201921*x_87 - 38171.4578777302*x_88 - 79762.9876632238*x_89 + 253392.180398384*x_9 - 145888.321096384*x_90 + 115239.393443306*x_91 + 41565.9120713262*x_92 - 1309804.93147966*x_93 - 29560.6089995617*x_94 - 62286.8653148482*x_95 + 52274.8132117595*x_96 + 62923.479672435*x_97 - 16706.0630362493*x_98 - 49207.770520849*x_99 + 0.00567694724347213*std::pow(-7.1832799911499*x_110 - 7.79856014251709, 2) - 2.20276921624735e-5*std::pow(-7.43791961669922*x_117 - 7.84168004989624, 2) - 0.0546704981766794*std::pow(-6.70688009262085*x_13 - 9.36343955993652, 2) + 4.85109198679573e-5*std::pow(-4.98303985595703*x_13 - 7.76800012588501, 2) + 0.0179461862386627*std::pow(-3.44167971611023*x_14 - 5.26336002349854, 2) + 0.0288037057479884*std::pow(-6.84879970550537*x_15 - 9.66967964172363, 2) - 1.52674986979404e-5*std::pow(-8.80000019073486*x_18 - 9.99954032897949, 2) - 0.000409508474759215*std::pow(-6.13807964324951*x_22 - 8.17304039001465, 2) - 4.7175011309617e-5*std::pow(-5.08871984481812*x_23 - 5.90208005905151, 2) - 0.00181307074449802*std::pow(-8.35967922210693*x_52 - 7.54143953323364, 2) - 0.00661698916880047*std::pow(-5.13479995727539*x_6 - 7.90055990219116, 2) - 0.00945583621431456*std::pow(-6.11504030227661*x_67 - 7.49976015090942, 2) - 0.00177658481740293*std::pow(-7.30751991271973*x_69 - 7.71600008010864, 2) - 0.00492081128401937*std::pow(-8.79600048065186*x_75 - 9.9973201751709, 2) - 0.0952427821419212*std::pow(-2.12663984298706*x_75 - 2.76263999938965, 2) - 0.0202923568630552*std::pow(-7.26159954071045*x_76 - 9.62055969238281, 2) + 0.0366567738396847*std::pow(-7.6144003868103*x_83 - 8.61336040496826, 2) + 0.00531989562961122*std::pow(-5.26496028900146*x_87 - 5.67144012451172, 2) + 0.432190156526268*std::exp(0.754719853401184*x_1) + 46.648300197452*std::exp(0.757199883460999*x_1) + 4356.60298415553*std::exp(0.825519859790802*x_1) + 0.0657951010407187*std::exp(0.861039876937866*x_1) + 0.00090733045408763*std::exp(0.9440798163414*x_1) + 4.49625757146348e-5*std::exp(1.0079197883606*x_1) + 0.0347035470755973*std::exp(1.04303979873657*x_1) + 0.00787265909848357*std::exp(1.06415987014771*x_1) + 0.799914872280808*std::exp(1.10735988616943*x_1) + 0.0265065080575021*std::exp(1.13199985027313*x_1) - 2.36558862722938e-5*std::exp(1.1593599319458*x_1) - 0.00110635005760434*std::exp(1.20591986179352*x_1) - 0.037377066802519*std::exp(1.00127983093262*x_108) - 0.863805621739228*std::exp(1.28079986572266*x_108) - 0.0279150033801605*std::exp(1.56919980049133*x_108) - 0.00392136396333535*std::exp(2.03247976303101*x_108) + 519.614235628519*std::exp(2.7753598690033*x_17) + 0.00318095274929844*std::exp(2.80999994277954*x_17) + 0.0090103617139613*std::exp(2.84888005256653*x_17) - 0.00453108348542548*std::exp(3.49399995803833*x_17) + 0.00231303119235353*std::exp(3.63927984237671*x_17) - 0.000619751119601434*std::exp(3.64759993553162*x_17) + 5.37067654244999e-6*std::exp(3.85743999481201*x_17) - 0.0019217244830355*std::exp(4.2695198059082*x_17) - 0.363621780386523*std::exp(0.929519832134247*x_29) + 0.279929930702366*std::exp(1.05495977401733*x_29) - 0.347713987349049*std::exp(1.27431988716125*x_29) - 0.000912202156937663*std::exp(1.46327984333038*x_29) + 0.0116488763686021*std::exp(1.66111981868744*x_29) + 0.551682642924217*std::exp(1.70815992355347*x_29) + 0.00532874158383711*std::exp(2.27495980262756*x_29) - 0.082069104152562*std::exp(1.40247988700867*x_38) - 0.000341939600833821*std::exp(1.75471985340118*x_38) + 0.00114221692891799*std::exp(2.47439980506897*x_38) + 0.0643421685172562*std::exp(1.59183979034424*x_50) - 0.000287910167331763*std::exp(1.66439986228943*x_50) + 0.140863788082731*std::exp(1.66527986526489*x_50) - 1.14509201619482*std::exp(1.71759986877441*x_50) - 35274.6812104736*std::exp(1.88511991500854*x_50) + 0.118193719382292*std::exp(1.92927980422974*x_50) - 0.0753917347871338*std::exp(1.93591976165771*x_50) + 0.397885654652569*std::exp(1.9366397857666*x_50) - 137.502173976922*std::exp(1.95703983306885*x_50) + 0.0354430566401791*std::exp(2.02871990203857*x_50) - 0.475721191005394*std::exp(0.751999855041504*x_66) + 4.39196968074298*std::exp(0.740719854831696*x_71) + 0.360800079560609*std::exp(0.757279872894287*x_71) + 2.15954987518987*std::exp(1.08503985404968*x_71) + 0.0505351288312207*std::exp(1.08831977844238*x_71) + 0.000654894653350608*std::exp(1.28671991825104*x_71) - 0.178137083784624*std::exp(1.29703986644745*x_71) + 44.1126440204658*std::exp(1.67023992538452*x_71) - 0.0114478507835129*std::exp(1.67927992343903*x_71) - 0.000888351759173203*std::exp(1.84575986862183*x_71) - 0.0504690087625195*std::exp(1.87239992618561*x_71) - 0.0463017620940796*std::exp(1.95615983009338*x_71) + 0.426675814254385*std::exp(0.985039830207825*x_72) + 72420.7616958833*std::exp(0.735359847545624*x_73) - 0.605464195165466*std::exp(0.856079876422882*x_73) + 0.00422840774470998*std::exp(0.937839806079865*x_76) + 0.0487775033578663*std::exp(1.32255983352661*x_76) - 0.00030538979797636*std::exp(1.70791983604431*x_76) - 0.00785484163910134*std::exp(2.26183986663818*x_76) - 0.103840176021441*std::exp(1.01895976066589*x_77) + 0.0715685683278681*std::exp(1.48071980476379*x_77) + 0.138199575044876*std::exp(1.26399981975555*x_78) - 0.0361948425463262*std::exp(1.60799980163574*x_78) - 0.0896225061690279*std::exp(1.75887989997864*x_78) + 0.534842180215868*std::exp(1.92959976196289*x_78) + 0.901454830426471*std::exp(1.39375984668732*x_81) - 0.0754573685847669*std::exp(1.04471981525421*x_87) + 1.92829455709853*std::exp(0.913439810276031*x_88) + 23.4423455369429*std::sin(0.371119856834412*x_102 + 8.18839931488037) + 4.828032308069*std::sin(0.247919961810112*x_104 - 1.35807979106903) + 1.20592539610769*std::sin(0.286159932613373*x_104 - 7.49079990386963) - 0.0165006238490339*std::sin(0.361919850111008*x_105 + 5.16847991943359) - 25.625624663182*std::sin(0.433759868144989*x_105 + 2.01007986068726) - 1624.88722342218*std::sin(0.437199860811234*x_105 + 2.02327990531921) + 4.60374286936141*std::sin(0.437999874353409*x_105 + 2.02783989906311) - 2.30489254623358*std::sin(0.467039853334427*x_105 - 7.36383962631226) - 8.06759631178801*std::sin(0.49127984046936*x_105 - 7.34815979003906) - 0.0084659952502748*std::sin(0.5065598487854*x_105 + 2.05463981628418) - 2.5186616292908*std::sin(0.517359852790833*x_109 + 2.1580798625946) - 4.3720320483304*std::sin(0.396799832582474*x_111 - 7.40463972091675) - 77.3257723052055*std::sin(0.186080008745193*x_112 - 7.60784006118774) + 2.15914330617715*std::sin(0.258879989385605*x_112 + 5.0434398651123) - 193901.288625938*std::sin(0.511919856071472*x_115 + 5.26783990859985) + 13.1006600154952*std::sin(0.466559857130051*x_117 - 7.35599946975708) + 27.0976277239139*std::sin(0.433039873838425*x_120 - 1.17831993103027) + 16.9329968871036*std::sin(0.340079843997955*x_14 - 1.2299998998642) - 1.88503707590419*std::sin(0.479199856519699*x_14 - 4.32376003265381) - 0.648814757987505*std::sin(0.410479873418808*x_15 + 5.20991992950439) + 2.45117019681342*std::sin(0.549839854240417*x_15 + 2.14871978759766) - 3.05247856559011*std::sin(0.475679844617844*x_17 - 4.10208034515381) - 5.0405626947421*std::sin(0.441199839115143*x_19 - 1.15015983581543) + 24.5846961289088*std::sin(0.315679848194122*x_21 + 8.31968021392822) - 1.30081429244759*std::sin(0.457839846611023*x_21 - 1.17007982730865) + 4.07615560483683*std::sin(0.256719976663589*x_26 + 5.04903984069824) + 2.83367937500575*std::sin(0.300159931182861*x_28 + 5.10303974151611) - 27.6470046920644*std::sin(0.321759849786758*x_28 + 8.30416011810303) - 14.0066977022579*std::sin(0.32551982998848*x_28 - 4.27016019821167) - 411482.879558014*std::sin(0.338879853487015*x_28 - 4.24847984313965) - 1221.589606035*std::sin(0.342879861593246*x_28 - 4.26847982406616) + 3.37567151386*std::sin(0.344799846410751*x_28 + 5.13168001174927) - 2.02166593593684*std::sin(0.369919836521149*x_28 - 4.22656011581421) + 4.00700388787854*std::sin(0.36303985118866*x_3 + 5.17160034179688) + 2.23430423498313*std::sin(0.380399852991104*x_34 + 1.99079978466034) - 1660.61457283512*std::sin(0.329919844865799*x_36 - 1.23263990879059) + 22.8791235228728*std::sin(0.330239832401276*x_36 - 7.44320011138916) + 3.95132953195287*std::sin(0.3503198325634*x_36 + 5.15304040908813) + 0.0248214512014344*std::sin(0.364159852266312*x_36 - 7.42759990692139) - 3.7680608377211*std::sin(0.365519851446152*x_36 + 1.96367979049683) + 4.31076518076355*std::sin(0.3781598508358*x_36 + 8.38055992126465) + 169772.212135558*std::sin(0.42663985490799*x_36 - 4.18807983398438) - 0.0229631145640243*std::sin(0.362399846315384*x_43 - 7.43351984024048) - 3.81141458152966*std::sin(0.452079862356186*x_45 - 7.34592008590698) - 1627.07605386217*std::sin(0.34215983748436*x_46 + 8.32800006866455) - 5.38155390460653*std::sin(0.370959848165512*x_46 - 4.22959995269775) - 1.26708966958715*std::sin(0.40287983417511*x_46 - 4.18824005126953) - 5.81544017272194*std::sin(0.407039850950241*x_46 - 7.38815975189209) + 0.234579418275467*std::sin(0.306159913539886*x_47 - 7.47959995269775) + 2.51108287868557*std::sin(0.690959870815277*x_47 + 5.23975992202759) + 16.2510808424966*std::sin(0.403599858283997*x_49 + 5.19695997238159) + 0.0958821338897131*std::sin(0.157360032200813*x_53 - 4.46767997741699) - 3028.71425358491*std::sin(0.233919993042946*x_53 - 4.36143970489502) + 61.9296978671939*std::sin(0.290159940719604*x_53 + 5.1017599105835) - 3.4180927020171*std::sin(0.44191986322403*x_53 - 7.35687971115112) + 0.0475889976043553*std::sin(0.174800008535385*x_55 - 7.63616037368774) - 2.78034994942473*std::sin(0.417919874191284*x_55 + 5.20223999023438) - 1.95547819250566*std::sin(0.473199844360352*x_55 + 2.05047988891602) - 140.681037859662*std::sin(0.130960047245026*x_67 - 7.68008041381836) + 1.89061389528818*std::sin(0.179680004715919*x_67 + 1.78391993045807) + 0.155886780252469*std::sin(0.655519843101501*x_67 + 5.42639970779419) + 0.0551174550703637*std::sin(0.304239928722382*x_68 + 5.14751958847046) - 0.0136430921228625*std::sin(0.352319836616516*x_69 - 4.24432039260864) - 0.00996432492385888*std::sin(0.40735986828804*x_72 + 5.19271993637085) + 24.2457239550416*std::sin(0.241279974579811*x_73 + 1.85223984718323) - 0.472277252033725*std::sin(0.483999848365784*x_73 + 8.48151969909668) - 633.272311646962*std::sin(0.5933598279953*x_73 - 3.99767971038818) + 0.395325995479779*std::sin(0.821039855480194*x_73 - 0.78743988275528) + 12.2314377273002*std::sin(0.147360026836395*x_75 + 1.74791991710663) - 2060.82196213861*std::sin(0.311999946832657*x_75 - 7.47160005569458) + 0.562809229026358*std::sin(0.400079846382141*x_75 - 4.18535995483398) - 0.401668518152653*std::sin(0.495359867811203*x_78 - 7.31343984603882) + 16.0355801089325*std::sin(0.183360010385513*x_80 - 4.43607997894287) - 12.7448778104244*std::sin(0.212880000472069*x_80 + 1.8199999332428) - 4.63037153312892*std::sin(0.231199979782104*x_80 + 5.04256010055542) - 2.0271541298081*std::sin(0.251519978046417*x_80 + 1.83783984184265) - 298440.424781488*std::sin(0.323599845170975*x_80 - 1.26775979995728) - 8019.74939119835*std::sin(0.173440024256706*x_85 + 1.78063988685608) + 0.587745085804865*std::sin(0.35999983549118*x_85 - 4.4215202331543) + 7.70566360183004*std::sin(0.33231982588768*x_86 - 4.28263998031616) - 7.14960738660862*std::sin(0.348239839076996*x_92 + 1.99207985401154) + 0.0472609595044582*std::sin(0.352559864521027*x_92 + 2.00831985473633) + 1662.77206804898*std::sin(0.364959836006165*x_92 + 1.97991979122162) - 3.5876350770162*std::sin(0.369199842214584*x_92 + 1.98607981204987) + 19.1322126160816*std::sin(0.376879841089249*x_95 + 1.99391984939575) - 7.31318314398359*std::sin(0.135200038552284*x_96 - 7.67199993133545) + 16.1821729288537*std::sin(0.470319867134094*x_96 + 5.2292799949646) - 0.654974207015157*std::sin(0.399999856948853*x_97 + 5.1846399307251) - 0.010724835882773*std::sin(0.513519823551178*x_98 + 5.15759992599487) - 0.351795739643991*std::sin(0.598479866981506*x_99 + 1.99935972690582) - 5464236.73295442 - 4.58893269441299*std::exp(-2.46007990837097*x_86) + 0.0120927850729239*std::exp(-2.28759980201721*x_86) + 7.53948494674421*std::exp(-2.11679983139038*x_23) - 0.0161467281525003*std::exp(-2.11087989807129*x_23) + 0.0144141225464981*std::exp(-2.10407996177673*x_23) + 0.241428592222313*std::exp(-1.98967981338501*x_23));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.215499713835192*x_1 - 60936.59533253*x_10 - 22988.6682712963*x_100 - 1547240.43695273*x_101 + 23459.1594220635*x_102 - 13448.742074091*x_103 - 45422.7253119196*x_104 - 26181.1145268092*x_105 - 11221.8943702561*x_106 - 207842.597238576*x_107 + 10549.1471036855*x_108 - 41239.4693614919*x_109 + 62097.9474763111*x_11 - 33361.0019700054*x_110 + 58222.1521377552*x_111 - 27533.2811161988*x_112 + 137188.938598325*x_113 + 4031.55373514908*x_114 + 95.6194480623307*x_115 - 24524.9082809674*x_116 - 29586.6465733896*x_117 - 19146.0268955496*x_118 + 22384.5607033545*x_119 + 84278.3737748657*x_12 - 63364.1789995215*x_120 + 10577.134915115*x_13 - 61209.3420538533*x_14 - 20400.957077665*x_15 + 40774.0210930624*x_16 + 229.040760845531*x_17 - 53102.998784302*x_18 - 5098.49506461039*x_19 + 56652.6155485611*x_2 + 14143.3052296838*x_20 + 24447.6460326333*x_21 - 11350.4557680392*x_22 + 27840.1060995167*x_23 - 11528.3549770094*x_24 + 29962.3681998927*x_25 + 17019.9447604124*x_26 - 24523.4240416869*x_27 - 9.98329179601988*x_28 + 35696.7406797469*x_29 - 39411.4002080913*x_3 + 64379.8484543054*x_30 - 157470.475719921*x_31 + 30060.7123766088*x_32 - 42307.8858286704*x_33 + 53836.296929176*x_34 + 238.598405626267*x_35 + 11.3616065887717*x_36 - 68669.9742525133*x_37 - 29971.5080410567*x_38 + 42332.7779796406*x_39 - 108685.249620273*x_4 + 49199.5547920534*x_40 - 9523.22179593304*x_41 + 29604.2178652048*x_42 - 42982.1165312391*x_43 - 23885.6384888958*x_44 - 53137.2843308798*x_45 + 30677.8871102399*x_46 - 52859.0422193523*x_47 + 44892.1658427669*x_48 + 14023.8060669986*x_49 + 6654.17246012778*x_5 + 7.52610225910256*x_50 + 53542.7335341983*x_51 + 34993.7473125342*x_52 + 42258.1510065488*x_53 - 113335.818474732*x_54 + 37478.7514953289*x_55 - 46555.0075639026*x_56 + 36941.7318397567*x_57 - 25090.2043213576*x_58 + 34896.5056255259*x_59 - 24099.0069731575*x_6 - 54243.6580316445*x_60 + 62338.9671308434*x_61 - 13550.7693523044*x_62 - 34209.7967967984*x_63 - 76828.1777416422*x_64 - 49057.7887101009*x_65 - 63071.3344325384*x_66 - 40638.8795739483*x_67 - 14071.4784875719*x_68 - 44108.204875923*x_69 - 28355.6622545031*x_7 + 75410.5558757274*x_70 + 17470.1651999665*x_71 - 95253.7035793457*x_72 + 3.62721195956816*x_73 + 10989.5120990918*x_74 + 6397.94547305005*x_75 + 42387.9093351187*x_76 + 73723.3065433281*x_77 + 77894.6523957367*x_78 + 42601.498593397*x_79 - 526469.733755138*x_8 + 192.140868389711*x_80 + 35304.9411142215*x_81 + 80503.076885696*x_82 + 11586.2983049362*x_83 - 73252.2265551669*x_84 - 47516.5889669855*x_85 - 80640.3445814516*x_86 - 13918.0426388754*x_87 - 46078.4182964519*x_88 - 96292.057293888*x_89 + 305614.667465763*x_9 - 176052.310831239*x_90 + 139144.536144273*x_91 + 50194.1885691403*x_92 - 1580266.85990631*x_93 - 35657.4285925663*x_94 - 75205.7798057597*x_95 + 63083.6181843502*x_96 + 75947.2835452935*x_97 - 20173.5597040151*x_98 - 59370.2690530285*x_99 - 0.0609811350391943*std::pow(-7.1832799911499*x_110 - 7.79856014251709, 2) + 1.68398114252533e-6*std::pow(-7.43791961669922*x_117 - 7.84168004989624, 2) + 0.0795180784876897*std::pow(-6.70688009262085*x_13 - 9.36343955993652, 2) + 5.64712133945634e-5*std::pow(-4.98303985595703*x_13 - 7.76800012588501, 2) - 0.032102052127292*std::pow(-3.44167971611023*x_14 - 5.26336002349854, 2) + 0.0180820232599545*std::pow(-6.84879970550537*x_15 - 9.66967964172363, 2) + 1.16717537684959e-6*std::pow(-8.80000019073486*x_18 - 9.99954032897949, 2) - 0.000121864098422072*std::pow(-6.13807964324951*x_22 - 8.17304039001465, 2) + 3.60645268046518e-6*std::pow(-5.08871984481812*x_23 - 5.90208005905151, 2) - 0.00403850485355076*std::pow(-8.35967922210693*x_52 - 7.54143953323364, 2) - 0.0147389410783814*std::pow(-5.13479995727539*x_6 - 7.90055990219116, 2) - 0.0163052783515063*std::pow(-6.11504030227661*x_67 - 7.49976015090942, 2) - 0.000528687244312707*std::pow(-7.30751991271973*x_69 - 7.71600008010864, 2) + 0.00880232369414703*std::pow(-8.79600048065186*x_75 - 9.9973201751709, 2) - 0.164232970897378*std::pow(-2.12663984298706*x_75 - 2.76263999938965, 2) - 0.0127388771433581*std::pow(-7.26159954071045*x_76 - 9.62055969238281, 2) - 0.053317169524768*std::pow(-7.6144003868103*x_83 - 8.61336040496826, 2) + 0.0118497440796314*std::pow(-5.26496028900146*x_87 - 5.67144012451172, 2) - 0.069945604236955*std::exp(0.754719853401184*x_1) + 51.5111608822104*std::exp(0.757199883460999*x_1) + 5258.47587394795*std::exp(0.825519859790802*x_1) - 0.706763647679685*std::exp(0.861039876937866*x_1) - 0.00181988076891697*std::exp(0.9440798163414*x_1) - 3.43731558732254e-6*std::exp(1.0079197883606*x_1) + 0.0217857504487144*std::exp(1.04303979873657*x_1) + 0.00234279523466548*std::exp(1.06415987014771*x_1) - 1.16347382443697*std::exp(1.10735988616943*x_1) - 0.0474147148624388*std::exp(1.13199985027313*x_1) - 2.75376473040786e-5*std::exp(1.1593599319458*x_1) + 0.00115738829890961*std::exp(1.20591986179352*x_1) + 0.0749691634023558*std::exp(1.00127983093262*x_108) + 0.139798200499175*std::exp(1.28079986572266*x_108) + 0.0292027808505564*std::exp(1.56919980049133*x_108) - 0.00676184839612132*std::exp(2.03247976303101*x_108) + 627.181070147961*std::exp(2.7753598690033*x_17) - 0.00638020547993497*std::exp(2.80999994277954*x_17) - 0.0094260285386196*std::exp(2.84888005256653*x_17) + 0.00810518047165208*std::exp(3.49399995803833*x_17) - 0.0248463234624864*std::exp(3.63927984237671*x_17) - 0.000184429422323203*std::exp(3.64759993553162*x_17) + 6.25196598884119e-6*std::exp(3.85743999481201*x_17) + 0.002795142597382*std::exp(4.2695198059082*x_17) - 1.55833581466431*std::exp(0.929519832134247*x_29) + 0.623526901653596*std::exp(1.05495977401733*x_29) + 3.73510492667187*std::exp(1.27431988716125*x_29) + 6.97363672564357e-5*std::exp(1.46327984333038*x_29) - 0.0233647685770975*std::exp(1.66111981868744*x_29) - 0.802420778361536*std::exp(1.70815992355347*x_29) + 0.00158576031722015*std::exp(2.27495980262756*x_29) - 0.351714971920569*std::exp(1.40247988700867*x_38) + 2.61407248403337e-5*std::exp(1.75471985340118*x_38) - 0.0122695670400136*std::exp(2.47439980506897*x_38) - 0.11509496336743*std::exp(1.59183979034424*x_50) - 0.000335154157911479*std::exp(1.66439986228943*x_50) + 0.313765523815321*std::exp(1.66527986526489*x_50) + 0.185321557583396*std::exp(1.71759986877441*x_50) - 42576.9942271743*std::exp(1.88511991500854*x_50) + 0.0351728277666133*std::exp(1.92927980422974*x_50) + 0.15121719728052*std::exp(1.93591976165771*x_50) + 0.24977958479292*std::exp(1.9366397857666*x_50) - 151.836113543228*std::exp(1.95703983306885*x_50) - 0.380725367082087*std::exp(2.02871990203857*x_50) - 1.05964003039724*std::exp(0.751999855041504*x_66) + 2.7571347457525*std::exp(0.740719854831696*x_71) + 0.803660241548069*std::exp(0.757279872894287*x_71) - 0.349501298488772*std::exp(1.08503985404968*x_71) - 0.101360985625858*std::exp(1.08831977844238*x_71) - 5.00656282305361e-5*std::exp(1.28671991825104*x_71) + 0.318650763644582*std::exp(1.29703986644745*x_71) + 48.7111747579177*std::exp(1.67023992538452*x_71) + 0.0119759640752326*std::exp(1.67927992343903*x_71) - 0.00103412390237609*std::exp(1.84575986862183*x_71) - 0.216289749754925*std::exp(1.87239992618561*x_71) - 0.0798409682653242*std::exp(1.95615983009338*x_71) + 0.735743276384325*std::exp(0.985039830207825*x_72) + 87412.7914652184*std::exp(0.735359847545624*x_73) + 1.0830514570576*std::exp(0.856079876422882*x_73) + 0.00492225908559743*std::exp(0.937839806079865*x_76) + 0.20904064204205*std::exp(1.32255983352661*x_76) + 2.33465520181877e-5*std::exp(1.70791983604431*x_76) + 0.084375834081657*std::exp(2.26183986663818*x_76) + 0.108630540449531*std::exp(1.01895976066589*x_77) + 0.306713924317226*std::exp(1.48071980476379*x_77) + 0.307831151250476*std::exp(1.26399981975555*x_78) + 0.0725979135686269*std::exp(1.60799980163574*x_78) + 0.962714979873908*std::exp(1.75887989997864*x_78) - 0.777926374979956*std::exp(1.92959976196289*x_78) + 0.565903823424116*std::exp(1.39375984668732*x_81) + 0.151348842466203*std::exp(1.04471981525421*x_87) + 1.21052017884658*std::exp(0.913439810276031*x_88) - 3.79390645194693*std::sin(0.371119856834412*x_102 + 8.18839931488037) - 8.63636110562451*std::sin(0.247919961810112*x_104 - 1.35807979106903) + 0.358866837242752*std::sin(0.286159932613373*x_104 - 7.49079990386963) - 0.0192082577089556*std::sin(0.361919850111008*x_105 + 5.16847991943359) + 37.2723955556015*std::sin(0.433759868144989*x_105 + 2.01007986068726) - 1794.27389265772*std::sin(0.437199860811234*x_105 + 2.02327990531921) + 7.93851619701956*std::sin(0.437999874353409*x_105 + 2.02783989906311) - 9.87783680045404*std::sin(0.467039853334427*x_105 - 7.36383962631226) - 5.0645727823359*std::sin(0.49127984046936*x_105 - 7.34815979003906) + 0.000647211530332689*std::sin(0.5065598487854*x_105 + 2.05463981628418) + 4.5053698785491*std::sin(0.517359852790833*x_109 + 2.1580798625946) + 46.9638813433567*std::sin(0.396799832582474*x_111 - 7.40463972091675) - 48.5425877367991*std::sin(0.186080008745193*x_112 - 7.60784006118774) + 0.642531397002323*std::sin(0.258879989385605*x_112 + 5.0434398651123) - 234041.350996447*std::sin(0.511919856071472*x_115 + 5.26783990859985) + 8.22416536238513*std::sin(0.466559857130051*x_117 - 7.35599946975708) - 39.4134196695418*std::sin(0.433039873838425*x_120 - 1.17831993103027) - 24.6289940718863*std::sin(0.340079843997955*x_14 - 1.2299998998642) - 8.07850614511887*std::sin(0.479199856519699*x_14 - 4.32376003265381) + 1.30136213915392*std::sin(0.410479873418808*x_15 + 5.20991992950439) - 4.38464152686918*std::sin(0.549839854240417*x_15 + 2.14871978759766) - 5.26357601230526*std::sin(0.475679844617844*x_17 - 4.10208034515381) - 8.69175141396486*std::sin(0.441199839115143*x_19 - 1.15015983581543) + 15.4334671771492*std::sin(0.315679848194122*x_21 + 8.31968021392822) - 2.24307386901088*std::sin(0.457839846611023*x_21 - 1.17007982730865) + 17.468753544988*std::sin(0.256719976663589*x_26 + 5.04903984069824) + 6.31184852775052*std::sin(0.300159931182861*x_28 + 5.10303974151611) + 4.47438799641158*std::sin(0.321759849786758*x_28 + 8.30416011810303) - 8.79294615294657*std::sin(0.32551982998848*x_28 - 4.27016019821167) - 496665.13165598*std::sin(0.338879853487015*x_28 - 4.24847984313965) - 1348.93444052956*std::sin(0.342879861593246*x_28 - 4.26847982406616) - 6.03838506195192*std::sin(0.344799846410751*x_28 + 5.13168001174927) - 8.66404215365859*std::sin(0.369919836521149*x_28 - 4.22656011581421) - 43.0427894975201*std::sin(0.36303985118866*x_3 + 5.17160034179688) + 4.97677684374451*std::sin(0.380399852991104*x_34 + 1.99079978466034) - 1833.72564622034*std::sin(0.329919844865799*x_36 - 1.23263990879059) - 3.7027546672549*std::sin(0.330239832401276*x_36 - 7.44320011138916) + 8.80134630223057*std::sin(0.3503198325634*x_36 + 5.15304040908813) + 0.0288944730665642*std::sin(0.364159852266312*x_36 - 7.42759990692139) + 40.476089864177*std::sin(0.365519851446152*x_36 + 1.96367979049683) - 7.71107614180751*std::sin(0.3781598508358*x_36 + 8.38055992126465) + 204917.245116989*std::sin(0.42663985490799*x_36 - 4.18807983398438) + 0.00175549265961431*std::sin(0.362399846315384*x_43 - 7.43351984024048) - 6.5722559334046*std::sin(0.452079862356186*x_45 - 7.34592008590698) - 1796.69089813189*std::sin(0.34215983748436*x_46 + 8.32800006866455) - 9.27974347159374*std::sin(0.370959848165512*x_46 - 4.22959995269775) - 5.43023360814614*std::sin(0.40287983417511*x_46 - 4.18824005126953) + 62.4688106610291*std::sin(0.407039850950241*x_46 - 7.38815975189209) - 0.470508369007111*std::sin(0.306159913539886*x_47 - 7.47959995269775) - 0.406393358540223*std::sin(0.690959870815277*x_47 + 5.23975992202759) + 10.2018963936245*std::sin(0.403599858283997*x_49 + 5.19695997238159) + 0.111615703399361*std::sin(0.157360032200813*x_53 - 4.46767997741699) - 3344.44313131002*std::sin(0.233919993042946*x_53 - 4.36143970489502) - 90.0765630451686*std::sin(0.290159940719604*x_53 + 5.1017599105835) - 5.8940268924361*std::sin(0.44191986322403*x_53 - 7.35687971115112) + 0.0553980103090978*std::sin(0.174800008535385*x_55 - 7.63616037368774) + 4.97347669424371*std::sin(0.417919874191284*x_55 + 5.20223999023438) - 8.38038826754929*std::sin(0.473199844360352*x_55 + 2.05047988891602) - 88.3149488148973*std::sin(0.130960047245026*x_67 - 7.68008041381836) - 3.79210446864364*std::sin(0.179680004715919*x_67 + 1.78391993045807) + 0.0463897650532304*std::sin(0.655519843101501*x_67 + 5.42639970779419) + 0.0641618335730568*std::sin(0.304239928722382*x_68 + 5.14751958847046) + 0.00104299214330661*std::sin(0.352319836616516*x_69 - 4.24432039260864) + 0.000761756390365743*std::sin(0.40735986828804*x_72 + 5.19271993637085) + 15.2206715464074*std::sin(0.241279974579811*x_73 + 1.85223984718323) + 0.94727150918503*std::sin(0.483999848365784*x_73 + 8.48151969909668) - 699.287900940017*std::sin(0.5933598279953*x_73 - 3.99767971038818) - 4.24654781539096*std::sin(0.821039855480194*x_73 - 0.78743988275528) + 52.4189927650294*std::sin(0.147360026836395*x_75 + 1.74791991710663) - 2275.65272886649*std::sin(0.311999946832657*x_75 - 7.47160005569458) + 0.167484297655246*std::sin(0.400079846382141*x_75 - 4.18535995483398) - 0.119531034999908*std::sin(0.495359867811203*x_78 - 7.31343984603882) - 28.6843690187111*std::sin(0.183360010385513*x_80 - 4.43607997894287) - 21.9767745067663*std::sin(0.212880000472069*x_80 + 1.8199999332428) - 19.8438987554783*std::sin(0.231199979782104*x_80 + 5.04256010055542) - 0.603253230685636*std::sin(0.251519978046417*x_80 + 1.83783984184265) - 360221.43381707*std::sin(0.323599845170975*x_80 - 1.26775979995728) - 8855.7696502646*std::sin(0.173440024256706*x_85 + 1.78063988685608) - 1.17887146172923*std::sin(0.35999983549118*x_85 - 4.4215202331543) + 13.2873483701745*std::sin(0.33231982588768*x_86 - 4.28263998031616) - 12.3285065329454*std::sin(0.348239839076996*x_92 + 1.99207985401154) + 0.055016143513101*std::sin(0.352559864521027*x_92 + 2.00831985473633) + 1836.10804992194*std::sin(0.364959836006165*x_92 + 1.97991979122162) + 38.5379764369743*std::sin(0.369199842214584*x_92 + 1.98607981204987) + 12.0105765752917*std::sin(0.376879841089249*x_95 + 1.99391984939575) + 7.65055557276124*std::sin(0.135200038552284*x_96 - 7.67199993133545) + 10.158638261904*std::sin(0.470319867134094*x_96 + 5.2292799949646) + 1.31371647244236*std::sin(0.399999856948853*x_97 + 5.1846399307251) + 0.000819896212914971*std::sin(0.513519823551178*x_98 + 5.15759992599487) - 1.50765418933599*std::sin(0.598479866981506*x_99 + 1.99935972690582) - 6600180.02912093 - 5.06730683216737*std::exp(-2.46007990837097*x_86) - 0.0216315161122538*std::exp(-2.28759980201721*x_86) + 8.32543994994181*std::exp(-2.11679983139038*x_23) + 0.0168916104816272*std::exp(-2.11087989807129*x_23) + 0.0617730966975953*std::exp(-2.10407996177673*x_23) - 0.0390727750460478*std::exp(-1.98967981338501*x_23));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.260726202764616*x_1 - 39215.0309510504*x_10 - 14727.2065415567*x_100 - 998229.536303192*x_101 + 15013.8779575117*x_102 - 8595.63933925664*x_103 - 29090.0760368743*x_104 - 16852.171092098*x_105 - 7280.46286807897*x_106 - 133476.785190075*x_107 + 6810.06444996709*x_108 - 26607.7886317132*x_109 + 39895.3105641187*x_11 - 21530.2322083756*x_110 + 37573.295541247*x_111 - 17814.2030057718*x_112 + 88274.1905134648*x_113 + 2646.63823450406*x_114 + 56.0148038125663*x_115 - 15933.1608460795*x_116 - 19128.2746551939*x_117 - 12482.1325190144*x_118 + 14469.4672586105*x_119 + 54375.9946624279*x_12 - 40838.332972929*x_120 + 6798.33726656492*x_13 - 39483.5290170423*x_14 - 13198.1740486027*x_15 + 26392.0788280917*x_16 + 73.1756544885994*x_17 - 34124.3756050154*x_18 - 3349.38963028506*x_19 + 36511.7586780043*x_2 + 9214.17699435062*x_20 + 15824.2536792919*x_21 - 7300.56634577682*x_22 + 17918.4672003226*x_23 - 7390.42612957074*x_24 + 19311.0596860733*x_25 + 10932.841488809*x_26 - 15766.7689180526*x_27 - 2.60459519225241*x_28 + 22987.8663898259*x_29 - 25433.329256327*x_3 + 41180.2591355682*x_30 - 100681.419562455*x_31 + 19313.3576690304*x_32 - 27352.0680219338*x_33 + 34774.136863418*x_34 + 157.268994020929*x_35 + 0.870455719084876*x_36 - 44236.9889392846*x_37 - 19253.4129136414*x_38 + 27302.0331799604*x_39 - 69961.6709383901*x_4 + 31441.5995597995*x_40 - 6241.28146463367*x_41 + 18955.0805220657*x_42 - 27586.5876215949*x_43 - 15401.9735680805*x_44 - 34126.8137601788*x_45 + 19753.4181826959*x_46 - 34072.3652391591*x_47 + 29208.2179175725*x_48 + 8887.81381070448*x_49 + 4286.21075549506*x_5 - 19.3448744664262*x_50 + 34464.1670091299*x_51 + 22528.4671158551*x_52 + 27212.6403138309*x_53 - 73084.0158070016*x_54 + 24099.3371915991*x_55 - 29899.4306828664*x_56 + 23700.019611063*x_57 - 16167.1505826799*x_58 + 22571.7059372728*x_59 - 15561.5893513801*x_6 - 34844.9286035787*x_60 + 40116.3270740828*x_61 - 8512.59441703619*x_62 - 22115.1117039179*x_63 - 49345.1741198268*x_64 - 31518.3871586091*x_65 - 40528.5864978899*x_66 - 26052.7689099366*x_67 - 9117.22297978912*x_68 - 28376.9005738628*x_69 - 18335.6650351273*x_7 + 48664.1794875738*x_70 + 11243.1437913757*x_71 - 61392.6343926061*x_72 - 4.96317517108033*x_73 + 7147.81592919549*x_74 + 4111.68204467701*x_75 + 27263.0426585451*x_76 + 47477.0875605923*x_77 + 50167.0567586259*x_78 + 27446.3173459142*x_79 - 337924.598798387*x_8 + 60.8950661507831*x_80 + 22736.7757996472*x_81 + 51873.2511453708*x_82 + 7332.74009422694*x_83 - 46969.9708387591*x_84 - 30602.5676260236*x_85 - 51892.1181940527*x_86 - 8870.67185139535*x_87 - 29703.24822896*x_88 - 62080.8800882003*x_89 + 196874.89443807*x_9 - 113251.225904525*x_90 + 89472.3130712165*x_91 + 32306.2548298826*x_92 - 1015469.62299301*x_93 - 22926.1304803574*x_94 - 48483.8263847448*x_95 + 40630.1931219801*x_96 + 48839.0121574242*x_97 - 13049.6803066948*x_98 - 38185.200280459*x_99 - 0.0405740887100909*std::pow(-7.1832799911499*x_110 - 7.79856014251709, 2) - 5.5574067005211e-6*std::pow(-7.43791961669922*x_117 - 7.84168004989624, 2) - 0.0234802886425138*std::pow(-6.70688009262085*x_13 - 9.36343955993652, 2) - 2.34680350167201e-5*std::pow(-4.98303985595703*x_13 - 7.76800012588501, 2) + 0.00305348693696775*std::pow(-3.44167971611023*x_14 - 5.26336002349854, 2) - 0.0175832570604989*std::pow(-6.84879970550537*x_15 - 9.66967964172363, 2) - 3.8518651404017e-6*std::pow(-8.80000019073486*x_18 - 9.99954032897949, 2) + 0.000219554198587551*std::pow(-6.13807964324951*x_22 - 8.17304039001465, 2) - 1.19018697925995e-5*std::pow(-5.08871984481812*x_23 - 5.90208005905151, 2) + 0.00217444389521772*std::pow(-8.35967922210693*x_52 - 7.54143953323364, 2) + 0.00793585785137335*std::pow(-5.13479995727539*x_6 - 7.90055990219116, 2) + 0.00528201125918452*std::pow(-6.11504030227661*x_67 - 7.49976015090942, 2) + 0.000952499593658125*std::pow(-7.30751991271973*x_69 - 7.71600008010864, 2) - 0.000837260506227548*std::pow(-8.79600048065186*x_75 - 9.9973201751709, 2) + 0.0532024282387756*std::pow(-2.12663984298706*x_75 - 2.76263999938965, 2) + 0.0123874938248665*std::pow(-7.26159954071045*x_76 - 9.62055969238281, 2) + 0.0157436214990683*std::pow(-7.6144003868103*x_83 - 8.61336040496826, 2) - 0.00638023343000124*std::pow(-5.26496028900146*x_87 - 5.67144012451172, 2) - 1.74471452995029*std::exp(0.754719853401184*x_1) + 13.8425611124086*std::exp(0.757199883460999*x_1) + 3385.32828324077*std::exp(0.825519859790802*x_1) - 0.470248559978294*std::exp(0.861039876937866*x_1) - 0.000597504633017648*std::exp(0.9440798163414*x_1) + 1.13436903741958e-5*std::exp(1.0079197883606*x_1) - 0.0211848223447418*std::exp(1.04303979873657*x_1) - 0.00422085369573089*std::exp(1.06415987014771*x_1) + 0.343553337119668*std::exp(1.10735988616943*x_1) + 0.0045099986716868*std::exp(1.13199985027313*x_1) + 1.14439629036273e-5*std::exp(1.1593599319458*x_1) - 0.00046291217175957*std::exp(1.20591986179352*x_1) + 0.024613932534175*std::exp(1.00127983093262*x_108) + 3.4871090804438*std::exp(1.28079986572266*x_108) - 0.0116800236512549*std::exp(1.56919980049133*x_108) + 0.00219046609271237*std::exp(2.03247976303101*x_108) + 403.769812086453*std::exp(2.7753598690033*x_17) - 0.00209475389760529*std::exp(2.80999994277954*x_17) + 0.00377006001010286*std::exp(2.84888005256653*x_17) - 0.00077094955156823*std::exp(3.49399995803833*x_17) - 0.016531619682687*std::exp(3.63927984237671*x_17) + 0.000332273857013183*std::exp(3.64759993553162*x_17) - 2.59816192941222e-6*std::exp(3.85743999481201*x_17) - 0.000825356399849069*std::exp(4.2695198059082*x_17) + 7.51859645816676*std::exp(0.929519832134247*x_29) - 0.335724312331235*std::exp(1.05495977401733*x_29) + 2.48516985685618*std::exp(1.27431988716125*x_29) - 0.00023014114877779*std::exp(1.46327984333038*x_29) - 0.00767113852327205*std::exp(1.66111981868744*x_29) + 0.236940729039325*std::exp(1.70815992355347*x_29) - 0.0028569557409219*std::exp(2.27495980262756*x_29) + 1.69694036245702*std::exp(1.40247988700867*x_38) - 8.62685666220062e-5*std::exp(1.75471985340118*x_38) - 0.00816361488181475*std::exp(2.47439980506897*x_38) + 0.0109476168613671*std::exp(1.59183979034424*x_50) + 0.000139281751552078*std::exp(1.66439986228943*x_50) - 0.168940128223481*std::exp(1.66527986526489*x_50) + 4.62263808792634*std::exp(1.71759986877441*x_50) - 27410.4334084198*std::exp(1.88511991500854*x_50) - 0.0633684744920584*std::exp(1.92927980422974*x_50) + 0.0496477447919979*std::exp(1.93591976165771*x_50) - 0.242889779796116*std::exp(1.9366397857666*x_50) - 40.8028210740367*std::exp(1.95703983306885*x_50) - 0.253317436748954*std::exp(2.02871990203857*x_50) + 0.570539810841071*std::exp(0.751999855041504*x_66) - 2.68108321110087*std::exp(0.740719854831696*x_71) - 0.432713137518439*std::exp(0.757279872894287*x_71) - 8.71791730677028*std::exp(1.08503985404968*x_71) - 0.0332789156043051*std::exp(1.08831977844238*x_71) + 0.000165224568594*std::exp(1.28671991825104*x_71) - 0.0303094624725353*std::exp(1.29703986644745*x_71) + 13.0901226432379*std::exp(1.67023992538452*x_71) - 0.0047899391623394*std::exp(1.67927992343903*x_71) + 0.000429756233198377*std::exp(1.84575986862183*x_71) + 1.04354615426422*std::exp(1.87239992618561*x_71) + 0.0258640720035716*std::exp(1.95615983009338*x_71) - 0.238340259267779*std::exp(0.985039830207825*x_72) + 56275.0504818919*std::exp(0.735359847545624*x_73) - 0.103017821511096*std::exp(0.856079876422882*x_73) - 0.00204556873561513*std::exp(0.937839806079865*x_76) - 1.00857094862369*std::exp(1.32255983352661*x_76) - 7.7047350082181e-5*std::exp(1.70791983604431*x_76) + 0.0561398631694327*std::exp(2.26183986663818*x_76) - 0.0434481663986788*std::exp(1.01895976066589*x_77) - 1.47982110360383*std::exp(1.48071980476379*x_77) - 0.165744896160251*std::exp(1.26399981975555*x_78) + 0.0238354019920128*std::exp(1.60799980163574*x_78) + 0.640546998195943*std::exp(1.75887989997864*x_78) + 0.229707962950609*std::exp(1.92959976196289*x_78) - 0.55029419306313*std::exp(1.39375984668732*x_81) + 0.0496909666391118*std::exp(1.04471981525421*x_87) - 1.17712974790378*std::exp(0.913439810276031*x_88) - 94.6347348656791*std::sin(0.371119856834412*x_102 + 8.18839931488037) + 0.821474456349197*std::sin(0.247919961810112*x_104 - 1.35807979106903) - 0.646545798727306*std::sin(0.286159932613373*x_104 - 7.49079990386963) + 0.00798247527238987*std::sin(0.361919850111008*x_105 + 5.16847991943359) - 11.005882218079*std::sin(0.433759868144989*x_105 + 2.01007986068726) - 482.174068418084*std::sin(0.437199860811234*x_105 + 2.02327990531921) - 2.5716415893018*std::sin(0.437999874353409*x_105 + 2.02783989906311) + 47.6581928512252*std::sin(0.467039853334427*x_105 - 7.36383962631226) + 4.92487393988909*std::sin(0.49127984046936*x_105 - 7.34815979003906) - 0.00213590140916396*std::sin(0.5065598487854*x_105 + 2.05463981628418) - 0.428542325450337*std::sin(0.517359852790833*x_109 + 2.1580798625946) + 31.2476421859123*std::sin(0.396799832582474*x_111 - 7.40463972091675) + 47.2036113595901*std::sin(0.186080008745193*x_112 - 7.60784006118774) - 1.15760480537584*std::sin(0.258879989385605*x_112 + 5.0434398651123) - 150672.328630712*std::sin(0.511919856071472*x_115 + 5.26783990859985) - 7.99731377379241*std::sin(0.466559857130051*x_117 - 7.35599946975708) + 11.638088945681*std::sin(0.433039873838425*x_120 - 1.17831993103027) + 7.27250835006254*std::sin(0.340079843997955*x_14 - 1.2299998998642) + 38.9768541019209*std::sin(0.479199856519699*x_14 - 4.32376003265381) + 0.427264203599979*std::sin(0.410479873418808*x_15 + 5.20991992950439) + 0.417058871267578*std::sin(0.549839854240417*x_15 + 2.14871978759766) + 1.70510844164776*std::sin(0.475679844617844*x_17 - 4.10208034515381) + 2.81564827296273*std::sin(0.441199839115143*x_19 - 1.15015983581543) - 15.0077575285273*std::sin(0.315679848194122*x_21 + 8.31968021392822) + 0.726632270598651*std::sin(0.457839846611023*x_21 - 1.17007982730865) - 84.2825450689055*std::sin(0.256719976663589*x_26 + 5.04903984069824) - 3.39847567265863*std::sin(0.300159931182861*x_28 + 5.10303974151611) + 111.608582628413*std::sin(0.321759849786758*x_28 + 8.30416011810303) + 8.55040557705673*std::sin(0.32551982998848*x_28 - 4.27016019821167) - 319745.598876762*std::sin(0.338879853487015*x_28 - 4.24847984313965) - 362.498284058511*std::sin(0.342879861593246*x_28 - 4.26847982406616) + 0.574359851947781*std::sin(0.344799846410751*x_28 + 5.13168001174927) + 41.8019248719746*std::sin(0.369919836521149*x_28 - 4.22656011581421) - 28.6387250463553*std::sin(0.36303985118866*x_3 + 5.17160034179688) - 2.67963576080054*std::sin(0.380399852991104*x_34 + 1.99079978466034) - 492.775912762671*std::sin(0.329919844865799*x_36 - 1.23263990879059) - 92.3610559845258*std::sin(0.330239832401276*x_36 - 7.44320011138916) - 4.73889085951095*std::sin(0.3503198325634*x_36 + 5.15304040908813) - 0.0120078260224011*std::sin(0.364159852266312*x_36 - 7.42759990692139) + 26.930959217653*std::sin(0.365519851446152*x_36 + 1.96367979049683) + 0.733463087518796*std::sin(0.3781598508358*x_36 + 8.38055992126465) + 131922.66395196*std::sin(0.42663985490799*x_36 - 4.18807983398438) - 0.00579340612723601*std::sin(0.362399846315384*x_43 - 7.43351984024048) + 2.1290485872189*std::sin(0.452079862356186*x_45 - 7.34592008590698) - 482.823588743625*std::sin(0.34215983748436*x_46 + 8.32800006866455) + 3.00612528302984*std::sin(0.370959848165512*x_46 - 4.22959995269775) + 26.1995744364128*std::sin(0.40287983417511*x_46 - 4.18824005126953) + 41.5639207723077*std::sin(0.407039850950241*x_46 - 7.38815975189209) - 0.154477664227767*std::sin(0.306159913539886*x_47 - 7.47959995269775) - 10.1370258396569*std::sin(0.690959870815277*x_47 + 5.23975992202759) - 9.92049198338044*std::sin(0.403599858283997*x_49 + 5.19695997238159) - 0.046384716713812*std::sin(0.157360032200813*x_53 - 4.46767997741699) - 898.750050265759*std::sin(0.233919993042946*x_53 - 4.36143970489502) + 26.5980232476767*std::sin(0.290159940719604*x_53 + 5.1017599105835) + 1.90933976940711*std::sin(0.44191986322403*x_53 - 7.35687971115112) - 0.023022038444736*std::sin(0.174800008535385*x_55 - 7.63616037368774) - 0.473067767037727*std::sin(0.417919874191284*x_55 + 5.20223999023438) + 40.433362920579*std::sin(0.473199844360352*x_55 + 2.05047988891602) + 85.8789099523064*std::sin(0.130960047245026*x_67 - 7.68008041381836) - 1.24502661251259*std::sin(0.179680004715919*x_67 + 1.78391993045807) - 0.0835772620550736*std::sin(0.655519843101501*x_67 + 5.42639970779419) - 0.0266640659287556*std::sin(0.304239928722382*x_68 + 5.14751958847046) - 0.00344204063776552*std::sin(0.352319836616516*x_69 - 4.24432039260864) - 0.00251391773997829*std::sin(0.40735986828804*x_72 + 5.19271993637085) - 14.8008315544317*std::sin(0.241279974579811*x_73 + 1.85223984718323) + 0.311008899665723*std::sin(0.483999848365784*x_73 + 8.48151969909668) - 187.919187573059*std::sin(0.5933598279953*x_73 - 3.99767971038818) - 2.82546081935952*std::sin(0.821039855480194*x_73 - 0.78743988275528) - 252.909064679821*std::sin(0.147360026836395*x_75 + 1.74791991710663) - 611.534693267469*std::sin(0.311999946832657*x_75 - 7.47160005569458) - 0.301744986618934*std::sin(0.400079846382141*x_75 - 4.18535995483398) + 0.215350878031787*std::sin(0.495359867811203*x_78 - 7.31343984603882) + 2.72840333529124*std::sin(0.183360010385513*x_80 - 4.43607997894287) + 7.11926333809415*std::sin(0.212880000472069*x_80 + 1.8199999332428) + 95.7420509078769*std::sin(0.231199979782104*x_80 + 5.04256010055542) + 1.08684002362871*std::sin(0.251519978046417*x_80 + 1.83783984184265) - 231905.182673192*std::sin(0.323599845170975*x_80 - 1.26775979995728) - 2379.80527873401*std::sin(0.173440024256706*x_85 + 1.78063988685608) - 0.387047971573811*std::sin(0.35999983549118*x_85 - 4.4215202331543) - 4.30436832680535*std::sin(0.33231982588768*x_86 - 4.28263998031616) + 3.99375643347615*std::sin(0.348239839076996*x_92 + 1.99207985401154) - 0.0228633440799175*std::sin(0.352559864521027*x_92 + 2.00831985473633) + 493.41613457614*std::sin(0.364959836006165*x_92 + 1.97991979122162) + 25.6414262157664*std::sin(0.369199842214584*x_92 + 1.98607981204987) - 11.6792823641513*std::sin(0.376879841089249*x_95 + 1.99391984939575) - 3.05993701395696*std::sin(0.135200038552284*x_96 - 7.67199993133545) - 9.87842706403684*std::sin(0.470319867134094*x_96 + 5.2292799949646) + 0.43132038766641*std::sin(0.399999856948853*x_97 + 5.1846399307251) - 0.00270578843926513*std::sin(0.513519823551178*x_98 + 5.15759992599487) + 7.27406977457145*std::sin(0.598479866981506*x_99 + 1.99935972690582) - 4270691.10451398 - 1.36173410379938*std::exp(-2.46007990837097*x_86) + 0.00205754920631444*std::exp(-2.28759980201721*x_86) + 2.23729011967498*std::exp(-2.11679983139038*x_23) - 0.00675601446803416*std::exp(-2.11087989807129*x_23) - 0.298040372087951*std::exp(-2.10407996177673*x_23) - 0.974626484280216*std::exp(-1.98967981338501*x_23));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.953817944164941*x_1 + 20906.7212664246*x_10 + 8094.3139008128*x_100 + 523407.388411261*x_101 - 8411.4113978302*x_102 + 4914.20459998993*x_103 + 16146.1643115697*x_104 + 8959.3839665338*x_105 + 3567.31818458312*x_106 + 72121.2571644745*x_107 - 3466.03823170614*x_108 + 13882.2662983153*x_109 - 21557.5000882721*x_11 + 11256.217377734*x_110 - 19562.223350717*x_111 + 9139.60978305744*x_112 - 47069.857256214*x_113 - 1257.24231844599*x_114 - 204.813865553061*x_115 + 7922.97445952193*x_116 + 9858.38102064623*x_117 + 5853.91434518078*x_118 - 7386.5624286647*x_119 - 28477.5135638371*x_12 + 21488.8315022046*x_120 - 3627.41281084553*x_13 + 20693.4914887379*x_14 + 6744.59812584676*x_15 - 13488.7052408796*x_16 - 407.758765539349*x_17 + 18341.9772600781*x_18 + 1509.16657308547*x_19 - 19339.2270129061*x_2 - 4348.34996875425*x_20 - 8053.3996325778*x_21 + 3950.08368535287*x_22 - 9529.76561145522*x_23 + 4023.79414760324*x_24 - 10112.0916043249*x_25 - 5948.0003169151*x_26 + 8465.92305824683*x_27 + 2.39571246771599*x_28 - 12234.4503947931*x_29 + 13322.5815814592*x_3 - 22870.1285358329*x_30 + 57366.4157250525*x_31 - 10457.7045403568*x_32 + 14217.91617176*x_33 - 18029.764961945*x_34 + 80.6817164102341*x_35 - 5.87115042258602*x_36 + 23351.9084674339*x_37 + 10429.6376025035*x_38 - 14305.1806946512*x_39 + 37470.7797797661*x_4 - 17537.1285998831*x_40 + 2998.51912840154*x_41 - 10378.678923383*x_42 + 15055.0907828358*x_43 + 8104.32215039485*x_44 + 18401.0620623568*x_45 - 10500.8306823338*x_46 + 17935.0708126081*x_47 - 13913.3858057402*x_48 - 5369.89294167599*x_49 - 2265.55125324636*x_5 + 0.316558888980125*x_50 - 18328.0723985362*x_51 - 11984.1747401828*x_52 - 14465.3242554543*x_53 + 38531.3328029656*x_54 - 12960.2813338604*x_55 + 16177.9233914883*x_56 - 12924.7750707886*x_57 + 8461.85176628468*x_58 - 11536.6045681663*x_59 + 8061.84107553118*x_6 + 18939.8292516037*x_60 - 21300.8128081486*x_61 + 5598.03062331988*x_62 + 11303.0221987139*x_63 + 26796.9040638415*x_64 + 17059.5719878475*x_65 + 22019.7303102162*x_66 + 14261.0905097507*x_67 + 4725.66557586965*x_68 + 15161.4968838201*x_69 + 9285.40510800616*x_7 - 25360.8147777041*x_70 - 5979.46131801089*x_71 + 32434.8221972151*x_72 - 0.942770093241045*x_73 - 3504.05910226372*x_74 - 2188.2774443345*x_75 - 14587.8671390601*x_76 - 25200.9630698722*x_77 - 26524.9682467705*x_78 - 14575.4416253445*x_79 + 182994.800859975*x_8 - 333.227757287574*x_80 - 12014.3367200406*x_81 - 27330.6062880115*x_82 - 4550.83542186211*x_83 + 25835.1609210702*x_84 + 16266.7000944872*x_85 + 27590.8665761969*x_86 + 5100.253684979*x_87 + 15603.6463739269*x_88 + 32708.1756304919*x_89 - 105185.819249976*x_9 + 60623.6022090064*x_90 - 47961.1386888704*x_91 - 17180.1163812979*x_92 + 548290.633032394*x_93 + 12422.1809925836*x_94 + 25367.6484524438*x_95 - 21557.4758325173*x_96 - 26178.0019387913*x_97 + 6625.88340612934*x_98 + 20492.7444784695*x_99 + 0.00910221425544964*std::pow(-7.1832799911499*x_110 - 7.79856014251709, 2) - 3.78290465503659e-6*std::pow(-7.43791961669922*x_117 - 7.84168004989624, 2) - 0.0330007405053988*std::pow(-6.70688009262085*x_13 - 9.36343955993652, 2) + 5.68023588561979e-5*std::pow(-4.98303985595703*x_13 - 7.76800012588501, 2) + 0.0524037481719205*std::pow(-3.44167971611023*x_14 - 5.26336002349854, 2) + 0.000953829514363177*std::pow(-6.84879970550537*x_15 - 9.66967964172363, 2) - 2.62194929315367e-6*std::pow(-8.80000019073486*x_18 - 9.99954032897949, 2) - 3.98556751445909e-5*std::pow(-6.13807964324951*x_22 - 8.17304039001465, 2) - 8.10155546792039e-6*std::pow(-5.08871984481812*x_23 - 5.90208005905151, 2) - 0.00219648536237138*std::pow(-8.35967922210693*x_52 - 7.54143953323364, 2) - 0.00801630046502362*std::pow(-5.13479995727539*x_6 - 7.90055990219116, 2) + 0.0243592505000221*std::pow(-6.11504030227661*x_67 - 7.49976015090942, 2) - 0.000172907257635772*std::pow(-7.30751991271973*x_69 - 7.71600008010864, 2) - 0.0143690114378592*std::pow(-8.79600048065186*x_75 - 9.9973201751709, 2) + 0.24535564448567*std::pow(-2.12663984298706*x_75 - 2.76263999938965, 2) - 0.000671977733049988*std::pow(-7.26159954071045*x_76 - 9.62055969238281, 2) + 0.0221271201396248*std::pow(-7.6144003868103*x_83 - 8.61336040496826, 2) + 0.00644490730173892*std::pow(-5.26496028900146*x_87 - 5.67144012451172, 2) + 0.66821483963096*std::exp(0.754719853401184*x_1) - 90.6508890878871*std::exp(0.757199883460999*x_1) - 1799.69745407987*std::exp(0.825519859790802*x_1) + 0.105493512788978*std::exp(0.861039876937866*x_1) + 0.00150563253028529*std::exp(0.9440798163414*x_1) + 7.72160495610577e-6*std::exp(1.0079197883606*x_1) + 0.00114920169451142*std::exp(1.04303979873657*x_1) + 0.000766211599742255*std::exp(1.06415987014771*x_1) + 0.482852434255091*std::exp(1.10735988616943*x_1) + 0.077400309719834*std::exp(1.13199985027313*x_1) - 2.7699127222442e-5*std::exp(1.1593599319458*x_1) - 0.0013768134308351*std::exp(1.20591986179352*x_1) - 0.0620238496470484*std::exp(1.00127983093262*x_108) - 1.33554114152463*std::exp(1.28079986572266*x_108) - 0.0347392322271268*std::exp(1.56919980049133*x_108) + 0.01010185507867*std::exp(2.03247976303101*x_108) - 214.650823213713*std::exp(2.7753598690033*x_17) + 0.00527850235277303*std::exp(2.80999994277954*x_17) + 0.0112130757703642*std::exp(2.84888005256653*x_17) - 0.0132309870608964*std::exp(3.49399995803833*x_17) + 0.00370863152137787*std::exp(3.63927984237671*x_17) - 6.03176754958608e-5*std::exp(3.64759993553162*x_17) + 6.28862732545942e-6*std::exp(3.85743999481201*x_17) - 0.001160010117021*std::exp(4.2695198059082*x_17) - 2.80821864650282*std::exp(0.929519832134247*x_29) + 0.339127415266753*std::exp(1.05495977401733*x_29) - 0.557512176303402*std::exp(1.27431988716125*x_29) - 0.000156656165355927*std::exp(1.46327984333038*x_29) + 0.0193302529666275*std::exp(1.66111981868744*x_29) + 0.33301206953773*std::exp(1.70815992355347*x_29) + 0.000518623194842942*std::exp(2.27495980262756*x_29) - 0.633812386975344*std::exp(1.40247988700867*x_38) - 5.87226704547503e-5*std::exp(1.75471985340118*x_38) + 0.00183138978879332*std::exp(2.47439980506897*x_38) + 0.187882302734021*std::exp(1.59183979034424*x_50) - 0.000337119491603972*std::exp(1.66439986228943*x_50) + 0.170652606662388*std::exp(1.66527986526489*x_50) - 1.77044170583234*std::exp(1.71759986877441*x_50) + 14571.8474230614*std::exp(1.88511991500854*x_50) + 0.0115032796002608*std::exp(1.92927980422974*x_50) - 0.125105740580804*std::exp(1.93591976165771*x_50) + 0.0131759116021326*std::exp(1.9366397857666*x_50) + 267.205756046094*std::exp(1.95703983306885*x_50) + 0.0568281299034289*std::exp(2.02871990203857*x_50) - 0.576323144468657*std::exp(0.751999855041504*x_66) + 0.145439282859409*std::exp(0.740719854831696*x_71) + 0.437099377342124*std::exp(0.757279872894287*x_71) + 3.33890823688243*std::exp(1.08503985404968*x_71) + 0.0838584592280153*std::exp(1.08831977844238*x_71) + 0.000112467707213519*std::exp(1.28671991825104*x_71) - 0.520169062918703*std::exp(1.29703986644745*x_71) - 85.7233893528047*std::exp(1.67023992538452*x_71) - 0.0142464445178105*std::exp(1.67927992343903*x_71) - 0.00104018797319119*std::exp(1.84575986862183*x_71) - 0.389767662780725*std::exp(1.87239992618561*x_71) + 0.119278316150897*std::exp(1.95615983009338*x_71) - 1.09916276108817*std::exp(0.985039830207825*x_72) - 29916.7633407546*std::exp(0.735359847545624*x_73) - 1.76798528604425*std::exp(0.856079876422882*x_73) + 0.0049511230617581*std::exp(0.937839806079865*x_76) + 0.376704317089612*std::exp(1.32255983352661*x_76) - 5.24458250026558e-5*std::exp(1.70791983604431*x_76) - 0.0125941722681923*std::exp(2.26183986663818*x_76) - 0.129225418323908*std::exp(1.01895976066589*x_77) + 0.55271768338022*std::exp(1.48071980476379*x_77) + 0.167424985811052*std::exp(1.26399981975555*x_78) - 0.0600620558042459*std::exp(1.60799980163574*x_78) - 0.143697522325734*std::exp(1.75887989997864*x_78) + 0.322846664824697*std::exp(1.92959976196289*x_78) + 0.0298515139214707*std::exp(1.39375984668732*x_81) - 0.125214653910405*std::exp(1.04471981525421*x_87) + 0.0638551260396381*std::exp(0.913439810276031*x_88) + 36.2445162783105*std::sin(0.371119856834412*x_102 + 8.18839931488037) + 14.0980922561069*std::sin(0.247919961810112*x_104 - 1.35807979106903) + 0.117367463186544*std::sin(0.286159932613373*x_104 - 7.49079990386963) - 0.0193208943424521*std::sin(0.361919850111008*x_105 + 5.16847991943359) - 15.4683900458611*std::sin(0.433759868144989*x_105 + 2.01007986068726) + 3157.61712318115*std::sin(0.437199860811234*x_105 + 2.02327990531921) - 11.8597364897986*std::sin(0.437999874353409*x_105 + 2.02783989906311) - 17.8004799922552*std::sin(0.467039853334427*x_105 - 7.36383962631226) - 0.267156994987991*std::sin(0.49127984046936*x_105 - 7.34815979003906) - 0.00145389960080984*std::sin(0.5065598487854*x_105 + 2.05463981628418) - 7.35461607253827*std::sin(0.517359852790833*x_109 + 2.1580798625946) - 7.00995988316708*std::sin(0.396799832582474*x_111 - 7.40463972091675) - 2.56062898610824*std::sin(0.186080008745193*x_112 - 7.60784006118774) + 0.210140008096812*std::sin(0.258879989385605*x_112 + 5.0434398651123) + 80099.9440968225*std::sin(0.511919856071472*x_115 + 5.26783990859985) + 0.43382599064669*std::sin(0.466559857130051*x_117 - 7.35599946975708) + 16.3569349219912*std::sin(0.433039873838425*x_120 - 1.17831993103027) + 10.2212610985205*std::sin(0.340079843997955*x_14 - 1.2299998998642) - 14.5579735632896*std::sin(0.479199856519699*x_14 - 4.32376003265381) - 1.07664919804491*std::sin(0.410479873418808*x_15 + 5.20991992950439) + 7.15753776385074*std::sin(0.549839854240417*x_15 + 2.14871978759766) + 7.86351289720891*std::sin(0.475679844617844*x_17 - 4.10208034515381) + 12.9850313139323*std::sin(0.441199839115143*x_19 - 1.15015983581543) + 0.814117772711972*std::sin(0.315679848194122*x_21 + 8.31968021392822) + 3.35103744243913*std::sin(0.457839846611023*x_21 - 1.17007982730865) + 31.4797869461563*std::sin(0.256719976663589*x_26 + 5.04903984069824) + 3.43292465985769*std::sin(0.300159931182861*x_28 + 5.10303974151611) - 42.7453946546823*std::sin(0.321759849786758*x_28 + 8.30416011810303) - 0.463829265028148*std::sin(0.32551982998848*x_28 - 4.27016019821167) + 169982.13824654*std::sin(0.338879853487015*x_28 - 4.24847984313965) + 2373.89537065368*std::sin(0.342879861593246*x_28 - 4.26847982406616) + 9.85712716734998*std::sin(0.344799846410751*x_28 + 5.13168001174927) - 15.6131460889459*std::sin(0.369919836521149*x_28 - 4.22656011581421) + 6.42468678070413*std::sin(0.36303985118866*x_3 + 5.17160034179688) + 2.70679815562496*std::sin(0.380399852991104*x_34 + 1.99079978466034) + 3227.04550482266*std::sin(0.329919844865799*x_36 - 1.23263990879059) + 35.3737113742066*std::sin(0.330239832401276*x_36 - 7.44320011138916) + 4.78692709877858*std::sin(0.3503198325634*x_36 + 5.15304040908813) + 0.0290639093695432*std::sin(0.364159852266312*x_36 - 7.42759990692139) - 6.04157403645861*std::sin(0.365519851446152*x_36 + 1.96367979049683) + 12.5876467544031*std::sin(0.3781598508358*x_36 + 8.38055992126465) - 70132.3069981547*std::sin(0.42663985490799*x_36 - 4.18807983398438) - 0.0039435485269026*std::sin(0.362399846315384*x_43 - 7.43351984024048) + 9.81861365263166*std::sin(0.452079862356186*x_45 - 7.34592008590698) + 3161.87064205767*std::sin(0.34215983748436*x_46 + 8.32800006866455) + 13.8634613238365*std::sin(0.370959848165512*x_46 - 4.22959995269775) - 9.78562074346417*std::sin(0.40287983417511*x_46 - 4.18824005126953) - 9.32426886699215*std::sin(0.407039850950241*x_46 - 7.38815975189209) + 0.389263251883346*std::sin(0.306159913539886*x_47 - 7.47959995269775) + 3.88241799990867*std::sin(0.690959870815277*x_47 + 5.23975992202759) + 0.538151607418008*std::sin(0.403599858283997*x_49 + 5.19695997238159) + 0.112270214457404*std::sin(0.157360032200813*x_53 - 4.46767997741699) + 5885.65153968087*std::sin(0.233919993042946*x_53 - 4.36143970489502) + 37.3826095801849*std::sin(0.290159940719604*x_53 + 5.1017599105835) + 8.8053742126674*std::sin(0.44191986322403*x_53 - 7.35687971115112) + 0.0557228625407873*std::sin(0.174800008535385*x_55 - 7.63616037368774) - 8.11875886284809*std::sin(0.417919874191284*x_55 + 5.20223999023438) - 15.1019840373334*std::sin(0.473199844360352*x_55 + 2.05047988891602) - 4.65862716401207*std::sin(0.130960047245026*x_67 - 7.68008041381836) + 3.13730214844124*std::sin(0.179680004715919*x_67 + 1.78391993045807) + 0.0151717809423401*std::sin(0.655519843101501*x_67 + 5.42639970779419) + 0.0645380765953098*std::sin(0.304239928722382*x_68 + 5.14751958847046) - 0.00234298338291624*std::sin(0.352319836616516*x_69 - 4.24432039260864) - 0.00171121381489881*std::sin(0.40735986828804*x_72 + 5.19271993637085) + 0.802892770387229*std::sin(0.241279974579811*x_73 + 1.85223984718323) - 0.783701231202196*std::sin(0.483999848365784*x_73 + 8.48151969909668) + 1230.62786516441*std::sin(0.5933598279953*x_73 - 3.99767971038818) + 0.63385156797847*std::sin(0.821039855480194*x_73 - 0.78743988275528) + 94.4623049335238*std::sin(0.147360026836395*x_75 + 1.74791991710663) + 4004.76206697695*std::sin(0.311999946832657*x_75 - 7.47160005569458) + 0.054775769448096*std::sin(0.400079846382141*x_75 - 4.18535995483398) - 0.0390926463358646*std::sin(0.495359867811203*x_78 - 7.31343984603882) + 46.8246841219548*std::sin(0.183360010385513*x_80 - 4.43607997894287) + 32.8321751921129*std::sin(0.212880000472069*x_80 + 1.8199999332428) - 35.7599472334865*std::sin(0.231199979782104*x_80 + 5.04256010055542) - 0.197294076790848*std::sin(0.251519978046417*x_80 + 1.83783984184265) + 123284.695582118*std::sin(0.323599845170975*x_80 - 1.26775979995728) + 15584.649590595*std::sin(0.173440024256706*x_85 + 1.78063988685608) + 0.975309620344409*std::sin(0.35999983549118*x_85 - 4.4215202331543) - 19.8506177234466*std::sin(0.33231982588768*x_86 - 4.28263998031616) + 18.4181571423117*std::sin(0.348239839076996*x_92 + 1.99207985401154) + 0.0553387564896223*std::sin(0.352559864521027*x_92 + 2.00831985473633) - 3231.23813045986*std::sin(0.364959836006165*x_92 + 1.97991979122162) - 5.7522858220883*std::sin(0.369199842214584*x_92 + 1.98607981204987) + 0.63355976581467*std::sin(0.376879841089249*x_95 + 1.99391984939575) - 9.10099719847837*std::sin(0.135200038552284*x_96 - 7.67199993133545) + 0.535869734301374*std::sin(0.470319867134094*x_96 + 5.2292799949646) - 1.08687024461387*std::sin(0.399999856948853*x_97 + 5.1846399307251) - 0.00184181943737904*std::sin(0.513519823551178*x_98 + 5.15759992599487) - 2.71688718640112*std::sin(0.598479866981506*x_99 + 1.99935972690582) + 2187430.59489728 + 8.91759886109919*std::exp(-2.46007990837097*x_86) + 0.0353115283231276*std::exp(-2.28759980201721*x_86) - 14.6513594449136*std::exp(-2.11679983139038*x_23) - 0.0200940308463889*std::exp(-2.11087989807129*x_23) + 0.111318985526734*std::exp(-2.10407996177673*x_23) + 0.373275896264787*std::exp(-1.98967981338501*x_23));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.377039956170833*x_1 + 35913.5527377026*x_10 + 13690.856206954*x_100 + 907612.948815117*x_101 - 14098.1382893595*x_102 + 8143.77776088608*x_103 + 27180.6375681545*x_104 + 15425.3916920292*x_105 + 6426.73751059431*x_106 + 123155.235337693*x_107 - 6105.39349497929*x_108 + 24136.1951440042*x_109 - 36787.8251595897*x_11 + 19548.2668008643*x_110 - 34024.5916509835*x_111 + 16025.2831203548*x_112 - 80890.4842267979*x_113 - 2299.86842595074*x_114 - 188.134125296357*x_115 + 14110.2883009729*x_116 + 17237.1889643555*x_117 + 10770.8735942859*x_118 - 12991.0364588469*x_119 - 49388.9984785682*x_12 + 37172.8621619263*x_120 - 6232.26719395468*x_13 + 35894.4617547593*x_14 + 11852.1463936371*x_15 - 23702.9545629779*x_16 - 366.572519780513*x_17 + 31401.0304236925*x_18 + 2838.77597649068*x_19 - 33344.4825241856*x_2 - 8000.06903700867*x_20 - 14177.9697531562*x_21 + 6745.56262090128*x_22 - 16396.9268416639*x_23 + 6844.10542896652*x_24 - 17566.4240684329*x_25 - 10117.5853122907*x_26 + 14473.1073476668*x_27 + 0.532068173900829*x_28 - 21043.7919079849*x_29 + 23106.2916732453*x_3 - 38525.2304979642*x_30 + 95036.7268122675*x_31 - 17837.5610206882*x_32 + 24774.5254332125*x_33 - 31423.1132476552*x_34 - 18.3138580570575*x_35 - 20.2766321048361*x_36 + 40345.7138837855*x_37 + 17770.7458942145*x_38 - 24828.7874048717*x_39 + 64201.1073693086*x_4 - 29455.4901185791*x_40 + 5428.99862498538*x_41 - 17599.7780960396*x_42 + 25556.0117728746*x_43 + 14024.1113844988*x_44 + 31439.6609977823*x_45 - 18078.0487843075*x_46 + 31024.4018660174*x_47 - 25389.473323594*x_48 - 8696.83940498621*x_49 - 3911.08184522599*x_5 + 20.7837814349674*x_50 - 31543.6581763883*x_51 - 20616.0516965807*x_52 - 24887.983340221*x_53 + 66588.30027415*x_54 - 22177.3982694596*x_55 + 27578.9660121225*x_56 - 21946.1411144042*x_57 + 14696.652715817*x_58 - 20273.7238303761*x_59 + 14059.6252528278*x_6 + 32224.6146436817*x_60 - 36708.327498081*x_61 + 8633.58871035577*x_62 + 19866.5598580344*x_63 + 45617.4144130901*x_64 + 29091.3237286659*x_65 + 37474.4051840906*x_66 + 24179.4888768188*x_67 + 8244.53425391129*x_68 + 26023.9506370602*x_69 + 16410.4473687407*x_7 - 44096.1627574252*x_70 - 10292.3157374201*x_71 + 55978.8357536802*x_72 + 0.184419036054688*x_73 - 6305.85652909757*x_74 - 3767.56907163987*x_75 - 25026.3081112086*x_76 - 43412.8564082878*x_77 - 45778.2598584259*x_78 - 25085.7306787643*x_79 + 312056.081678546*x_8 - 294.265170278024*x_80 - 20739.1661607108*x_81 - 47263.4166802356*x_82 - 7240.1044719117*x_83 + 43677.9497173335*x_84 + 27996.0208397668*x_85 + 47486.0124048413*x_86 + 8433.78068694145*x_87 + 27024.3808118927*x_88 + 56551.9972885807*x_89 - 180510.773883928*x_9 + 103921.075629239*x_90 - 82205.195738669*x_91 - 29576.8355034709*x_92 + 935840.516189806*x_93 + 21170.7784108208*x_94 + 44030.39726947*x_95 - 37140.8596533687*x_96 - 44871.0025890585*x_97 + 11689.6572105952*x_98 + 35086.5789398757*x_99 - 0.0431434173373862*std::pow(-7.1832799911499*x_110 - 7.79856014251709, 2) + 2.47232549528701e-6*std::pow(-7.43791961669922*x_117 - 7.84168004989624, 2) - 0.0792283223834535*std::pow(-6.70688009262085*x_13 - 9.36343955993652, 2) + 3.4016515514083e-5*std::pow(-4.98303985595703*x_13 - 7.76800012588501, 2) + 0.0182854796345614*std::pow(-3.44167971611023*x_14 - 5.26336002349854, 2) - 0.0508983018803771*std::pow(-6.84879970550537*x_15 - 9.66967964172363, 2) + 1.71358061488094e-6*std::pow(-8.80000019073486*x_18 - 9.99954032897949, 2) - 0.000197222444723543*std::pow(-6.13807964324951*x_22 - 8.17304039001465, 2) + 5.29478904739344e-6*std::pow(-5.08871984481812*x_23 - 5.90208005905151, 2) - 0.000380531424765644*std::pow(-8.35967922210693*x_52 - 7.54143953323364, 2) - 0.00138878878483014*std::pow(-5.13479995727539*x_6 - 7.90055990219116, 2) - 0.0197087977229725*std::pow(-6.11504030227661*x_67 - 7.49976015090942, 2) - 0.000855616971426426*std::pow(-7.30751991271973*x_69 - 7.71600008010864, 2) - 0.0050138449096002*std::pow(-8.79600048065186*x_75 - 9.9973201751709, 2) - 0.198514513710233*std::pow(-2.12663984298706*x_75 - 2.76263999938965, 2) + 0.0358581119567317*std::pow(-7.26159954071045*x_76 - 9.62055969238281, 2) + 0.0531228869713636*std::pow(-7.6144003868103*x_83 - 8.61336040496826, 2) + 0.00111655183322753*std::pow(-5.26496028900146*x_87 - 5.67144012451172, 2) + 1.1535629078041*std::exp(0.754719853401184*x_1) - 81.5135611011392*std::exp(0.757199883460999*x_1) - 3097.36767919694*std::exp(0.825519859790802*x_1) - 0.500026754030404*std::exp(0.861039876937866*x_1) + 0.000872756567789856*std::exp(0.9440798163414*x_1) - 5.04647157101826e-6*std::exp(1.0079197883606*x_1) - 0.0613237626723425*std::exp(1.04303979873657*x_1) + 0.00379153343478646*std::exp(1.06415987014771*x_1) + 1.15923423956318*std::exp(1.10735988616943*x_1) + 0.0270076442327676*std::exp(1.13199985027313*x_1) - 1.65878285666643e-5*std::exp(1.1593599319458*x_1) + 0.000128438954970394*std::exp(1.20591986179352*x_1) - 0.0359528112273284*std::exp(1.00127983093262*x_108) - 2.30559190149087*std::exp(1.28079986572266*x_108) + 0.00324072280513684*std::exp(1.56919980049133*x_108) - 0.0081732982043971*std::exp(2.03247976303101*x_108) - 369.424605579102*std::exp(2.7753598690033*x_17) + 0.00305974233673334*std::exp(2.80999994277954*x_17) - 0.00104603550611493*std::exp(2.84888005256653*x_17) - 0.00461674885646451*std::exp(3.49399995803833*x_17) - 0.0175784740928939*std::exp(3.63927984237671*x_17) - 0.00029847692651493*std::exp(3.64759993553162*x_17) + 3.76599129483926e-6*std::exp(3.85743999481201*x_17) - 0.00278495737101329*std::exp(4.2695198059082*x_17) - 5.95496006533261*std::exp(0.929519832134247*x_29) + 0.0587523325760857*std::exp(1.05495977401733*x_29) + 2.64254167369563*std::exp(1.27431988716125*x_29) + 0.000102382974703762*std::exp(1.46327984333038*x_29) + 0.0112049951726713*std::exp(1.66111981868744*x_29) + 0.799496835490705*std::exp(1.70815992355347*x_29) + 0.00256636310904749*std::exp(2.27495980262756*x_29) - 1.34402905487848*std::exp(1.40247988700867*x_38) + 3.83783279135307e-5*std::exp(1.75471985340118*x_38) - 0.00868057065543497*std::exp(2.47439980506897*x_38) + 0.0655586315899883*std::exp(1.59183979034424*x_50) - 0.00020188651751731*std::exp(1.66439986228943*x_50) + 0.0295648132537974*std::exp(1.66527986526489*x_50) - 3.05637612508805*std::exp(1.71759986877441*x_50) + 25078.8648570131*std::exp(1.88511991500854*x_50) + 0.0569230082509287*std::exp(1.92927980422974*x_50) - 0.0725189278020058*std::exp(1.93591976165771*x_50) - 0.703093704038144*std::exp(1.9366397857666*x_50) + 240.272245988922*std::exp(1.95703983306885*x_50) - 0.269358603974733*std::exp(2.02871990203857*x_50) - 0.0998454490283069*std::exp(0.751999855041504*x_66) - 7.76093883945928*std::exp(0.740719854831696*x_71) + 0.0757255439410714*std::exp(0.757279872894287*x_71) + 5.7640753634809*std::exp(1.08503985404968*x_71) + 0.0486094844418114*std::exp(1.08831977844238*x_71) - 7.3503512590583e-5*std::exp(1.28671991825104*x_71) - 0.18150497127275*std::exp(1.29703986644745*x_71) - 77.0827380306442*std::exp(1.67023992538452*x_71) + 0.00132900972995406*std::exp(1.67927992343903*x_71) - 0.000622924312301865*std::exp(1.84575986862183*x_71) - 0.826520708958236*std::exp(1.87239992618561*x_71) - 0.0965067544156444*std::exp(1.95615983009338*x_71) + 0.889320323007926*std::exp(0.985039830207825*x_72) - 51488.2185490521*std::exp(0.735359847545624*x_73) - 0.616911195666898*std::exp(0.856079876422882*x_73) + 0.00296501690834362*std::exp(0.937839806079865*x_76) + 0.798819268400147*std::exp(1.32255983352661*x_76) + 3.42760820320417e-5*std::exp(1.70791983604431*x_76) + 0.0596948846661396*std::exp(2.26183986663818*x_76) + 0.0120550666585723*std::exp(1.01895976066589*x_77) + 1.17206391177243*std::exp(1.48071980476379*x_77) + 0.0290056421424379*std::exp(1.26399981975555*x_78) - 0.0348156357037422*std::exp(1.60799980163574*x_78) + 0.68110923365001*std::exp(1.75887989997864*x_78) + 0.775091687320448*std::exp(1.92959976196289*x_78) - 1.59293809248051*std::exp(1.39375984668732*x_81) - 0.0725820606194873*std::exp(1.04471981525421*x_87) - 3.40744067239832*std::exp(0.913439810276031*x_88) + 62.5701901697542*std::sin(0.371119856834412*x_102 + 8.18839931488037) + 4.91931183986078*std::sin(0.247919961810112*x_104 - 1.35807979106903) + 0.58078298602833*std::sin(0.286159932613373*x_104 - 7.49079990386963) - 0.0115704614276643*std::sin(0.361919850111008*x_105 + 5.16847991943359) - 37.1365785899864*std::sin(0.433759868144989*x_105 + 2.01007986068726) + 2839.33912721903*std::sin(0.437199860811234*x_105 + 2.02327990531921) + 9.59558043565357*std::sin(0.437999874353409*x_105 + 2.02783989906311) - 37.7467572297616*std::sin(0.467039853334427*x_105 - 7.36383962631226) + 14.2560459448896*std::sin(0.49127984046936*x_105 - 7.34815979003906) + 0.00095019921950293*std::sin(0.5065598487854*x_105 + 2.05463981628418) - 2.5662798388623*std::sin(0.517359852790833*x_109 + 2.1580798625946) + 33.2263794578051*std::sin(0.396799832582474*x_111 - 7.40463972091675) + 136.64042176929*std::sin(0.186080008745193*x_112 - 7.60784006118774) + 1.03986009472237*std::sin(0.258879989385605*x_112 + 5.0434398651123) + 137855.936501185*std::sin(0.511919856071472*x_115 + 5.26783990859985) - 23.1498458613238*std::sin(0.466559857130051*x_117 - 7.35599946975708) + 39.2698010213643*std::sin(0.433039873838425*x_120 - 1.17831993103027) + 24.5392484252453*std::sin(0.340079843997955*x_14 - 1.2299998998642) - 30.8708694422773*std::sin(0.479199856519699*x_14 - 4.32376003265381) - 0.624091629198078*std::sin(0.410479873418808*x_15 + 5.20991992950439) + 2.4975124028366*std::sin(0.549839854240417*x_15 + 2.14871978759766) - 6.36228052595196*std::sin(0.475679844617844*x_17 - 4.10208034515381) - 10.5060439192299*std::sin(0.441199839115143*x_19 - 1.15015983581543) - 43.4429964031253*std::sin(0.315679848194122*x_21 + 8.31968021392822) - 2.71128699608718*std::sin(0.457839846611023*x_21 - 1.17007982730865) + 66.7543726920949*std::sin(0.256719976663589*x_26 + 5.04903984069824) + 0.594739092874449*std::sin(0.300159931182861*x_28 + 5.10303974151611) - 73.7928864021064*std::sin(0.321759849786758*x_28 + 8.30416011810303) + 24.7508822036379*std::sin(0.32551982998848*x_28 - 4.27016019821167) + 292547.605627857*std::sin(0.338879853487015*x_28 - 4.24847984313965) + 2134.61409248711*std::sin(0.342879861593246*x_28 - 4.26847982406616) + 3.43949248596763*std::sin(0.344799846410751*x_28 + 5.13168001174927) - 33.1084125410474*std::sin(0.369919836521149*x_28 - 4.22656011581421) - 30.4522542826272*std::sin(0.36303985118866*x_3 + 5.17160034179688) + 0.468940870883358*std::sin(0.380399852991104*x_34 + 1.99079978466034) + 2901.7693436905*std::sin(0.329919844865799*x_36 - 1.23263990879059) + 61.0668888694373*std::sin(0.330239832401276*x_36 - 7.44320011138916) + 0.829314057973444*std::sin(0.3503198325634*x_36 + 5.15304040908813) + 0.0174051385167272*std::sin(0.364159852266312*x_36 - 7.42759990692139) + 28.6363452578138*std::sin(0.365519851446152*x_36 + 1.96367979049683) + 4.392265179574*std::sin(0.3781598508358*x_36 + 8.38055992126465) - 120701.143667874*std::sin(0.42663985490799*x_36 - 4.18807983398438) + 0.00257731464418008*std::sin(0.362399846315384*x_43 - 7.43351984024048) - 7.94413072764937*std::sin(0.452079862356186*x_45 - 7.34592008590698) + 2843.16390460758*std::sin(0.34215983748436*x_46 + 8.32800006866455) - 11.2167718366991*std::sin(0.370959848165512*x_46 - 4.22959995269775) - 20.7508702409583*std::sin(0.40287983417511*x_46 - 4.18824005126953) + 44.1959298918709*std::sin(0.407039850950241*x_46 - 7.38815975189209) + 0.225640754199202*std::sin(0.306159913539886*x_47 - 7.47959995269775) + 6.702355487584*std::sin(0.690959870815277*x_47 + 5.23975992202759) - 28.7168750382604*std::sin(0.403599858283997*x_49 + 5.19695997238159) + 0.0672338538180796*std::sin(0.157360032200813*x_53 - 4.46767997741699) + 5292.39614996668*std::sin(0.233919993042946*x_53 - 4.36143970489502) + 89.7483328554138*std::sin(0.290159940719604*x_53 + 5.1017599105835) - 7.12433000483257*std::sin(0.44191986322403*x_53 - 7.35687971115112) + 0.033370051108379*std::sin(0.174800008535385*x_55 - 7.63616037368774) - 2.83291567918935*std::sin(0.417919874191284*x_55 + 5.20223999023438) - 32.0244693060514*std::sin(0.473199844360352*x_55 + 2.05047988891602) + 248.59391345247*std::sin(0.130960047245026*x_67 - 7.68008041381836) + 1.81857192915092*std::sin(0.179680004715919*x_67 + 1.78391993045807) + 0.0750762775289346*std::sin(0.655519843101501*x_67 + 5.42639970779419) + 0.0386491076772226*std::sin(0.304239928722382*x_68 + 5.14751958847046) + 0.00153126184264393*std::sin(0.352319836616516*x_69 - 4.24432039260864) + 0.00111836747902935*std::sin(0.40735986828804*x_72 + 5.19271993637085) - 42.8440072249447*std::sin(0.241279974579811*x_73 + 1.85223984718323) - 0.454281096455261*std::sin(0.483999848365784*x_73 + 8.48151969909668) + 1106.58439965866*std::sin(0.5933598279953*x_73 - 3.99767971038818) - 3.00438134719571*std::sin(0.821039855480194*x_73 - 0.78743988275528) + 200.311772111809*std::sin(0.147360026836395*x_75 + 1.74791991710663) + 3601.09449258198*std::sin(0.311999946832657*x_75 - 7.47160005569458) + 0.271053272161989*std::sin(0.400079846382141*x_75 - 4.18535995483398) - 0.193446661061478*std::sin(0.495359867811203*x_78 - 7.31343984603882) + 16.3387512873662*std::sin(0.183360010385513*x_80 - 4.43607997894287) - 26.5641465309437*std::sin(0.212880000472069*x_80 + 1.8199999332428) - 75.8306544182402*std::sin(0.231199979782104*x_80 + 5.04256010055542) - 0.976293087822557*std::sin(0.251519978046417*x_80 + 1.83783984184265) + 212179.014072627*std::sin(0.323599845170975*x_80 - 1.26775979995728) + 14013.7653301026*std::sin(0.173440024256706*x_85 + 1.78063988685608) + 0.565349020868274*std::sin(0.35999983549118*x_85 - 4.4215202331543) + 16.0609132611493*std::sin(0.33231982588768*x_86 - 4.28263998031616) - 14.901925391646*std::sin(0.348239839076996*x_92 + 1.99207985401154) + 0.0331400263398375*std::sin(0.352559864521027*x_92 + 2.00831985473633) - 2905.53936568908*std::sin(0.364959836006165*x_92 + 1.97991979122162) + 27.2651533903083*std::sin(0.369199842214584*x_92 + 1.98607981204987) - 33.8080503214726*std::sin(0.376879841089249*x_95 + 1.99391984939575) + 0.849005786246609*std::sin(0.135200038552284*x_96 - 7.67199993133545) - 28.5951096022006*std::sin(0.470319867134094*x_96 + 5.2292799949646) - 0.630016372017667*std::sin(0.399999856948853*x_97 + 5.1846399307251) + 0.00120372506525764*std::sin(0.513519823551178*x_98 + 5.15759992599487) - 5.76128739732599*std::sin(0.598479866981506*x_99 + 1.99935972690582) + 3842220.4188849 + 8.01873260101083*std::exp(-2.46007990837097*x_86) + 0.0123214131534921*std::exp(-2.28759980201721*x_86) - 13.1745479315691*std::exp(-2.11679983139038*x_23) + 0.00187451419724141*std::exp(-2.11087989807129*x_23) + 0.236057158209735*std::exp(-2.10407996177673*x_23) + 0.644399379915296*std::exp(-1.98967981338501*x_23));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.586254534897311*x_1 + 52111.0713502579*x_10 + 19684.4733013411*x_100 + 1321111.06784498*x_101 - 20146.9254638374*x_102 + 11578.7184169152*x_103 + 38944.6144467785*x_104 + 22380.5792129796*x_105 + 9529.03462549286*x_106 + 177824.697586373*x_107 - 8971.32545476898*x_108 + 35227.2294185613*x_109 - 53126.4561285076*x_11 + 28468.3877951181*x_110 - 49703.0730836219*x_111 + 23489.7515006822*x_112 - 117253.643978713*x_113 - 3435.50627790984*x_114 - 146.693191251679*x_115 + 20912.5653670917*x_116 + 25230.1268651425*x_117 + 16223.7897995918*x_118 - 19061.5570879748*x_119 - 71978.8609609619*x_12 + 54112.898936113*x_120 - 9040.10441785416*x_13 + 52270.6035478376*x_14 + 17393.5227539443*x_15 - 34773.8659878687*x_16 - 262.302516110801*x_17 + 45404.5062205322*x_18 + 4311.8988926525*x_19 - 48407.9663553094*x_2 - 11969.7617403729*x_20 - 20827.7872651524*x_21 + 9715.39684855066*x_22 - 23787.9064102862*x_23 + 9863.41692912864*x_24 - 25583.0976427708*x_25 - 14575.8274777751*x_26 + 20975.6624423622*x_27 - 4.26898008353564*x_28 - 30514.531148005*x_29 + 33647.9177803281*x_3 - 55153.9474314406*x_30 + 135584.397659607*x_31 - 25687.7149981734*x_32 + 36094.8087792379*x_33 - 45932.3773249438*x_34 - 131.852696200948*x_35 + 12.022721876342*x_36 + 58644.4567375658*x_37 + 25646.1595555606*x_38 - 36093.5176160603*x_39 + 92973.5205485856*x_4 - 42191.4748159526*x_40 + 8092.56748724166*x_41 - 25335.4164339604*x_42 + 36821.6011230456*x_43 + 20406.1139747814*x_44 + 45450.3658884152*x_45 - 26209.3227559934*x_46 + 45175.8306098608*x_47 - 38004.9894204843*x_48 - 12061.8319431677*x_49 - 5688.34471350815*x_5 - 1.77374056366967*x_50 - 45750.0107176506*x_51 - 29908.8577308406*x_52 - 36118.8657405332*x_53 + 96846.567726452*x_54 - 32067.5952556332*x_55 + 39819.6583131996*x_56 - 31629.3920780787*x_57 + 21409.2205045993*x_58 - 29749.5460904764*x_59 + 20550.9411389517*x_6 + 46436.5546555518*x_60 - 53258.2716430716*x_61 + 11817.4420665156*x_62 + 29166.6988695202*x_63 + 65755.4907766363*x_64 + 42007.1464402054*x_65 + 54033.3208573275*x_66 + 34784.9846181563*x_67 + 12013.9230815577*x_68 + 37723.208527538*x_69 + 24135.4349382827*x_7 - 64376.8240194206*x_70 - 14924.2862880066*x_71 + 81441.9533278546*x_72 + 3.32868035014409*x_73 - 9342.08136566646*x_74 - 5454.29121336607*x_75 - 36240.0894100769*x_76 - 63013.2072096083*x_77 - 66547.3860559258*x_78 - 36431.0412408871*x_79 + 450109.224850011*x_8 - 216.674429054709*x_80 - 30185.3128077892*x_81 - 68760.7949584535*x_82 - 10016.4850820986*x_83 + 62770.3748748651*x_84 + 40624.0347978796*x_85 + 68902.6764673683*x_86 + 11963.3095510958*x_87 + 39350.488485801*x_88 + 82259.0270414939*x_89 - 261601.532400935*x_9 + 150545.196677174*x_90 - 118931.906208963*x_91 - 42876.1000430532*x_92 + 1352194.61428297*x_93 + 30530.6060249845*x_94 + 64194.2923129388*x_95 - 53927.2370089596*x_96 - 64932.1819597452*x_97 + 17185.8754458076*x_98 + 50791.9223193104*x_99 + 0.00045465375278556*std::pow(-7.1832799911499*x_110 - 7.79856014251709, 2) + 1.82095515275074e-6*std::pow(-7.43791961669922*x_117 - 7.84168004989624, 2) + 0.0740124057792174*std::pow(-6.70688009262085*x_13 - 9.36343955993652, 2) + 5.05647458404139e-5*std::pow(-4.98303985595703*x_13 - 7.76800012588501, 2) + 0.0347554579541997*std::pow(-3.44167971611023*x_14 - 5.26336002349854, 2) + 0.0182627455894514*std::pow(-6.84879970550537*x_15 - 9.66967964172363, 2) + 1.26211271787212e-6*std::pow(-8.80000019073486*x_18 - 9.99954032897949, 2) - 2.57441249372903e-5*std::pow(-6.13807964324951*x_22 - 8.17304039001465, 2) + 3.89979936580317e-6*std::pow(-5.08871984481812*x_23 - 5.90208005905151, 2) - 0.00113648172805455*std::pow(-8.35967922210693*x_52 - 7.54143953323364, 2) - 0.00414770758829859*std::pow(-5.13479995727539*x_6 - 7.90055990219116, 2) + 0.0163100561580854*std::pow(-6.11504030227661*x_67 - 7.49976015090942, 2) - 0.000111686629996624*std::pow(-7.30751991271973*x_69 - 7.71600008010864, 2) - 0.00952988269529016*std::pow(-8.79600048065186*x_75 - 9.9973201751709, 2) + 0.164281094784131*std::pow(-2.12663984298706*x_75 - 2.76263999938965, 2) - 0.012866196941559*std::pow(-7.26159954071045*x_76 - 9.62055969238281, 2) - 0.0496255953478222*std::pow(-7.6144003868103*x_83 - 8.61336040496826, 2) + 0.00333465431316324*std::pow(-5.26496028900146*x_87 - 5.67144012451172, 2) + 0.487260067355915*std::exp(0.754719853401184*x_1) - 58.0038273244909*std::exp(0.757199883460999*x_1) - 4494.36888199012*std::exp(0.825519859790802*x_1) + 0.00526937953095578*std::exp(0.861039876937866*x_1) - 0.000647523353602998*std::exp(0.9440798163414*x_1) - 3.71690476354088e-6*std::exp(1.0079197883606*x_1) + 0.0220034899966802*std::exp(1.04303979873657*x_1) + 0.000494921917157456*std::exp(1.06415987014771*x_1) - 1.08291722392485*std::exp(1.10735988616943*x_1) + 0.0513337939355863*std::exp(1.13199985027313*x_1) - 2.46574148716228e-5*std::exp(1.1593599319458*x_1) + 0.000698826544750145*std::exp(1.20591986179352*x_1) + 0.0266744310573675*std::exp(1.00127983093262*x_108) - 0.973872215910805*std::exp(1.28079986572266*x_108) + 0.0176325252796459*std::exp(1.56919980049133*x_108) + 0.00676382976700363*std::exp(2.03247976303101*x_108) - 536.045643759886*std::exp(2.7753598690033*x_17) - 0.00227011138290248*std::exp(2.80999994277954*x_17) - 0.00569139930010149*std::exp(2.84888005256653*x_17) - 0.00877511686719285*std::exp(3.49399995803833*x_17) + 0.000185245391019416*std::exp(3.63927984237671*x_17) - 3.89612211625806e-5*std::exp(3.64759993553162*x_17) + 5.59805699622352e-6*std::exp(3.85743999481201*x_17) + 0.002601612514571*std::exp(4.2695198059082*x_17) - 1.60548913878147*std::exp(0.929519832134247*x_29) + 0.175467643689158*std::exp(1.05495977401733*x_29) - 0.0278476199379977*std::exp(1.27431988716125*x_29) + 7.54086812987066e-5*std::exp(1.46327984333038*x_29) - 0.008313310170426*std::exp(1.66111981868744*x_29) - 0.746862768608821*std::exp(1.70815992355347*x_29) + 0.000334996215092981*std::exp(2.27495980262756*x_29) - 0.362357434162508*std::exp(1.40247988700867*x_38) + 2.82669956287405e-5*std::exp(1.75471985340118*x_38) + 9.14775478713347e-5*std::exp(2.47439980506897*x_38) + 0.124608175956953*std::exp(1.59183979034424*x_50) - 0.000300099533788013*std::exp(1.66439986228943*x_50) + 0.0882972282170357*std::exp(1.66527986526489*x_50) - 1.29100027965559*std::exp(1.71759986877441*x_50) + 36390.148501265*std::exp(1.88511991500854*x_50) + 0.00743035630793692*std::exp(1.92927980422974*x_50) + 0.0538038910998549*std::exp(1.93591976165771*x_50) + 0.252276028237084*std::exp(1.9366397857666*x_50) + 170.974126009743*std::exp(1.95703983306885*x_50) + 0.00283855354304698*std::exp(2.02871990203857*x_50) - 0.298194895520013*std::exp(0.751999855041504*x_66) + 2.78469116501077*std::exp(0.740719854831696*x_71) + 0.226159237936845*std::exp(0.757279872894287*x_71) + 2.43472092493046*std::exp(1.08503985404968*x_71) - 0.0360647831758893*std::exp(1.08831977844238*x_71) - 5.41379362273507e-5*std::exp(1.28671991825104*x_71) - 0.344988948806406*std::exp(1.29703986644745*x_71) - 54.850920092681*std::exp(1.67023992538452*x_71) + 0.00723104044047389*std::exp(1.67927992343903*x_71) - 0.000925962258430559*std::exp(1.84575986862183*x_71) - 0.222834411423763*std::exp(1.87239992618561*x_71) + 0.0798643634319219*std::exp(1.95615983009338*x_71) - 0.735958865409586*std::exp(0.985039830207825*x_72) - 74710.8742659714*std::exp(0.735359847545624*x_73) - 1.17257143651568*std::exp(0.856079876422882*x_73) + 0.00440742751328704*std::exp(0.937839806079865*x_76) + 0.215365954632*std::exp(1.32255983352661*x_76) + 2.52455464749021e-5*std::exp(1.70791983604431*x_76) - 0.000629076346069664*std::exp(2.26183986663818*x_76) + 0.0655906970099892*std::exp(1.01895976066589*x_77) + 0.315994710235433*std::exp(1.48071980476379*x_77) + 0.0866272275034091*std::exp(1.26399981975555*x_78) + 0.025830727628664*std::exp(1.60799980163574*x_78) - 0.00717766204550348*std::exp(1.75887989997864*x_78) - 0.724064308725538*std::exp(1.92959976196289*x_78) + 0.571559797635082*std::exp(1.39375984668732*x_81) + 0.0538507311640913*std::exp(1.04471981525421*x_87) + 1.22261882640826*std::exp(0.913439810276031*x_88) + 26.4293822819104*std::sin(0.371119856834412*x_102 + 8.18839931488037) + 9.35020241365294*std::sin(0.247919961810112*x_104 - 1.35807979106903) + 0.0758116033635246*std::sin(0.286159932613373*x_104 - 7.49079990386963) - 0.0171992172773822*std::sin(0.361919850111008*x_105 + 5.16847991943359) + 34.6917294367436*std::sin(0.433759868144989*x_105 + 2.01007986068726) + 2020.43113104258*std::sin(0.437199860811234*x_105 + 2.02327990531921) - 7.94084235754846*std::sin(0.437999874353409*x_105 + 2.02783989906311) - 10.1767279867087*std::sin(0.467039853334427*x_105 - 7.36383962631226) - 5.11519108859354*std::sin(0.49127984046936*x_105 - 7.34815979003906) + 0.000699855325761923*std::sin(0.5065598487854*x_105 + 2.05463981628418) - 4.8777627287231*std::sin(0.517359852790833*x_109 + 2.1580798625946) - 0.350146071968145*std::sin(0.396799832582474*x_111 - 7.40463972091675) - 49.0277507857279*std::sin(0.186080008745193*x_112 - 7.60784006118774) + 0.135736519407619*std::sin(0.258879989385605*x_112 + 5.0434398651123) + 200032.897408283*std::sin(0.511919856071472*x_115 + 5.26783990859985) + 8.30636248718085*std::sin(0.466559857130051*x_117 - 7.35599946975708) - 36.6845133233484*std::sin(0.433039873838425*x_120 - 1.17831993103027) - 22.9237317833904*std::sin(0.340079843997955*x_14 - 1.2299998998642) - 8.32295179993766*std::sin(0.479199856519699*x_14 - 4.32376003265381) + 0.463031639758685*std::sin(0.410479873418808*x_15 + 5.20991992950439) + 4.74705553486355*std::sin(0.549839854240417*x_15 + 2.14871978759766) + 5.26511835629711*std::sin(0.475679844617844*x_17 - 4.10208034515381) + 8.69429828904383*std::sin(0.441199839115143*x_19 - 1.15015983581543) + 15.5877182861302*std::sin(0.315679848194122*x_21 + 8.31968021392822) + 2.24373113918178*std::sin(0.457839846611023*x_21 - 1.17007982730865) + 17.9973365308105*std::sin(0.256719976663589*x_26 + 5.04903984069824) + 1.77622679238074*std::sin(0.300159931182861*x_28 + 5.10303974151611) - 31.1698014520279*std::sin(0.321759849786758*x_28 + 8.30416011810303) - 8.88082800604761*std::sin(0.32551982998848*x_28 - 4.27016019821167) + 424494.923242517*std::sin(0.338879853487015*x_28 - 4.24847984313965) + 1518.95936764953*std::sin(0.342879861593246*x_28 - 4.26847982406616) + 6.5374897934801*std::sin(0.344799846410751*x_28 + 5.13168001174927) - 8.92620540755528*std::sin(0.369919836521149*x_28 - 4.22656011581421) + 0.320911799408596*std::sin(0.36303985118866*x_3 + 5.17160034179688) + 1.40052226074403*std::sin(0.380399852991104*x_34 + 1.99079978466034) + 2064.85553659087*std::sin(0.329919844865799*x_36 - 1.23263990879059) + 25.79439420463*std::sin(0.330239832401276*x_36 - 7.44320011138916) + 2.47680010733948*std::sin(0.3503198325634*x_36 + 5.15304040908813) + 0.0258723267834751*std::sin(0.364159852266312*x_36 - 7.42759990692139) - 0.301775395669591*std::sin(0.365519851446152*x_36 + 1.96367979049683) + 8.34843771250305*std::sin(0.3781598508358*x_36 + 8.38055992126465) - 175140.803516798*std::sin(0.42663985490799*x_36 - 4.18807983398438) + 0.00189828337349846*std::sin(0.362399846315384*x_43 - 7.43351984024048) + 6.57418174950911*std::sin(0.452079862356186*x_45 - 7.34592008590698) + 2023.15278525819*std::sin(0.34215983748436*x_46 + 8.32800006866455) + 9.28246264132851*std::sin(0.370959848165512*x_46 - 4.22959995269775) - 5.59454579486946*std::sin(0.40287983417511*x_46 - 4.18824005126953) - 0.465745335517828*std::sin(0.407039850950241*x_46 - 7.38815975189209) - 0.167409405166181*std::sin(0.306159913539886*x_47 - 7.47959995269775) + 2.83104645982433*std::sin(0.690959870815277*x_47 + 5.23975992202759) + 10.3038601205281*std::sin(0.403599858283997*x_49 + 5.19695997238159) + 0.0999415336581214*std::sin(0.157360032200813*x_53 - 4.46767997741699) + 3765.98971101972*std::sin(0.233919993042946*x_53 - 4.36143970489502) - 83.8398419842146*std::sin(0.290159940719604*x_53 + 5.1017599105835) + 5.89575397245624*std::sin(0.44191986322403*x_53 - 7.35687971115112) + 0.0496037917898509*std::sin(0.174800008535385*x_55 - 7.63616037368774) - 5.384561069416*std::sin(0.417919874191284*x_55 + 5.20223999023438) - 8.63396850390705*std::sin(0.473199844360352*x_55 + 2.05047988891602) - 89.1976201315841*std::sin(0.130960047245026*x_67 - 7.68008041381836) - 1.34925114034274*std::sin(0.179680004715919*x_67 + 1.78391993045807) + 0.00979996506604939*std::sin(0.655519843101501*x_67 + 5.42639970779419) + 0.0574509845327476*std::sin(0.304239928722382*x_68 + 5.14751958847046) + 0.00112782849502968*std::sin(0.352319836616516*x_69 - 4.24432039260864) + 0.000823717195607752*std::sin(0.40735986828804*x_72 + 5.19271993637085) + 15.3727958512392*std::sin(0.241279974579811*x_73 + 1.85223984718323) + 0.33704429151427*std::sin(0.483999848365784*x_73 + 8.48151969909668) + 787.428859329755*std::sin(0.5933598279953*x_73 - 3.99767971038818) + 0.0316607570424837*std::sin(0.821039855480194*x_73 - 0.78743988275528) + 54.0051269810851*std::sin(0.147360026836395*x_75 + 1.74791991710663) + 2562.48482222158*std::sin(0.311999946832657*x_75 - 7.47160005569458) + 0.0353815171137396*std::sin(0.400079846382141*x_75 - 4.18535995483398) - 0.025251258892208*std::sin(0.495359867811203*x_78 - 7.31343984603882) + 31.0552851082377*std::sin(0.183360010385513*x_80 - 4.43607997894287) + 21.9832141869461*std::sin(0.212880000472069*x_80 + 1.8199999332428) - 20.444350712598*std::sin(0.231199979782104*x_80 + 5.04256010055542) - 0.127438899074333*std::sin(0.251519978046417*x_80 + 1.83783984184265) + 307877.803679608*std::sin(0.323599845170975*x_80 - 1.26775979995728) + 9971.98519353914*std::sin(0.173440024256706*x_85 + 1.78063988685608) - 0.419448798736443*std::sin(0.35999983549118*x_85 - 4.4215202331543) - 13.2912418566328*std::sin(0.33231982588768*x_86 - 4.28263998031616) + 12.3321190575742*std::sin(0.348239839076996*x_92 + 1.99207985401154) + 0.0492618654113691*std::sin(0.352559864521027*x_92 + 2.00831985473633) - 2067.53822769234*std::sin(0.364959836006165*x_92 + 1.97991979122162) - 0.287325508135759*std::sin(0.369199842214584*x_92 + 1.98607981204987) + 12.1306173111143*std::sin(0.376879841089249*x_95 + 1.99391984939575) + 4.6193756420111*std::sin(0.135200038552284*x_96 - 7.67199993133545) + 10.2601696417067*std::sin(0.470319867134094*x_96 + 5.2292799949646) + 0.467427377907629*std::sin(0.399999856948853*x_97 + 5.1846399307251) + 0.000886586076248699*std::sin(0.513519823551178*x_98 + 5.15759992599487) - 1.55327394983778*std::sin(0.598479866981506*x_99 + 1.99935972690582) + 5627643.3345631 + 5.70600983280803*std::exp(-2.46007990837097*x_86) + 0.0234194762921672*std::exp(-2.28759980201721*x_86) - 9.37481068153556*std::exp(-2.11679983139038*x_23) + 0.0101990885852759*std::exp(-2.11087989807129*x_23) + 0.0636422745878111*std::exp(-2.10407996177673*x_23) + 0.2721915581174*std::exp(-1.98967981338501*x_23));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.247237555764935*x_1 + 62801.8290192031*x_10 + 23471.0049642986*x_100 + 1601536.18427116*x_101 - 23847.569475089*x_102 + 13568.540821073*x_103 + 46262.0495178262*x_104 + 27009.7993512898*x_105 + 11863.3533631002*x_106 + 213381.101685623*x_107 - 11007.8834343423*x_108 + 42775.0442923286*x_109 - 63728.4468279101*x_11 + 34552.4919379765*x_110 - 60416.0481441125*x_111 + 28680.3347963733*x_112 - 141334.787110418*x_113 - 4279.14778896059*x_114 + 63.3464568364177*x_115 + 25778.2243706508*x_116 + 30751.6127482179*x_117 + 20450.4650452044*x_118 - 23355.6863866618*x_119 - 87276.1146021956*x_12 + 65526.0781577493*x_120 - 10903.0896429866*x_13 + 63368.2789360741*x_14 + 21269.026040695*x_15 - 42522.7157743129*x_16 + 103.055259849312*x_17 + 54602.7972621971*x_18 + 5477.73271054875*x_19 - 58455.0663137693*x_2 - 15068.395238475*x_20 - 25498.6551874578*x_21 + 11641.2590119815*x_22 - 28703.9686642684*x_23 + 11813.9178923894*x_24 - 31044.0103205912*x_25 - 17428.1491598829*x_26 + 25212.9305969055*x_27 - 0.320944609056717*x_28 - 36783.7062296161*x_29 + 40790.9970170858*x_3 - 65590.8611437971*x_30 + 158909.647903609*x_31 - 30777.252102002*x_32 + 43853.8422626601*x_33 - 55892.4166946877*x_34 - 383.062533928539*x_35 - 5.49063528994323*x_36 + 70942.4723025045*x_37 + 30725.7572403014*x_38 - 43763.2347835351*x_39 + 111826.936585099*x_4 - 50068.4877852618*x_40 + 10054.6750251192*x_41 - 30315.3828599011*x_42 + 43999.9283845321*x_43 + 24695.6513331501*x_44 + 54580.4562443672*x_45 - 31617.1337876082*x_46 + 54679.1316330241*x_47 - 47716.3624970148*x_48 - 13874.9726772716*x_49 - 6885.80705202024*x_5 - 5.2858896630051*x_50 - 55188.183424244*x_51 - 36067.2598723479*x_52 - 43570.2741100266*x_53 + 117112.212001338*x_54 - 38520.7249209619*x_55 + 47754.5353142522*x_56 - 37815.6117586231*x_57 + 26009.2544073064*x_58 - 36391.7692497342*x_59 + 25012.3592572199*x_6 + 55562.3963990353*x_60 - 64323.6532614608*x_61 + 13006.6884394658*x_62 + 35685.8095057496*x_63 + 78732.8895320843*x_64 + 50339.0978603656*x_65 + 64621.1634916871*x_66 + 41546.7248229515*x_67 + 14589.5339469061*x_68 + 45423.9554268173*x_69 + 29643.0791678002*x_7 - 78199.0056387723*x_70 - 18011.8845970935*x_71 + 98420.820789053*x_72 - 4.0805171267212*x_73 - 11571.7101544418*x_74 - 6594.45099737292*x_75 - 43630.2597007414*x_76 - 76058.6652718278*x_77 - 80468.3848953664*x_78 - 43953.6384180752*x_79 + 540045.042934011*x_8 + 75.7482254534342*x_80 - 36501.1059849937*x_81 - 83236.4958155451*x_82 - 11371.4321371547*x_83 + 74770.2848503657*x_84 + 49001.4703593367*x_85 + 83160.7365097411*x_86 + 14035.5504813527*x_87 + 47685.2058576935*x_88 + 99536.7738526545*x_89 - 314634.324548124*x_9 + 181190.891743356*x_90 - 143122.417454171*x_91 - 51744.4809808879*x_92 + 1622428.2759233*x_93 + 36546.1409600134*x_94 + 77922.029332424*x_95 - 65086.0038927113*x_96 - 78136.688504466*x_97 + 21091.1675640814*x_98 + 61049.5208406969*x_99 - 0.00880730833621158*std::pow(-7.1832799911499*x_110 - 7.79856014251709, 2) - 2.13696480926202e-5*std::pow(-7.43791961669922*x_117 - 7.84168004989624, 2) - 0.0139845076598375*std::pow(-6.70688009262085*x_13 - 9.36343955993652, 2) + 3.55311601114097e-5*std::pow(-4.98303985595703*x_13 - 7.76800012588501, 2) + 0.018224734625449*std::pow(-3.44167971611023*x_14 - 5.26336002349854, 2) - 0.0621325259634702*std::pow(-6.84879970550537*x_15 - 9.66967964172363, 2) - 1.48114052086375e-5*std::pow(-8.80000019073486*x_18 - 9.99954032897949, 2) - 0.0002491670553205*std::pow(-6.13807964324951*x_22 - 8.17304039001465, 2) - 4.57657290203702e-5*std::pow(-5.08871984481812*x_23 - 5.90208005905151, 2) + 0.00218109067842819*std::pow(-8.35967922210693*x_52 - 7.54143953323364, 2) + 0.00796011597403323*std::pow(-5.13479995727539*x_6 - 7.90055990219116, 2) + 0.0229694302060936*std::pow(-6.11504030227661*x_67 - 7.49976015090942, 2) - 0.00108097007696771*std::pow(-7.30751991271973*x_69 - 7.71600008010864, 2) - 0.00499718873974253*std::pow(-8.79600048065186*x_75 - 9.9973201751709, 2) + 0.231356845387324*std::pow(-2.12663984298706*x_75 - 2.76263999938965, 2) + 0.0437726798310259*std::pow(-7.26159954071045*x_76 - 9.62055969238281, 2) + 0.00937666477611633*std::pow(-7.6144003868103*x_83 - 8.61336040496826, 2) - 0.00639973636062857*std::pow(-5.26496028900146*x_87 - 5.67144012451172, 2) - 1.92847664217125*std::exp(0.754719853401184*x_1) + 18.6190629388041*std::exp(0.757199883460999*x_1) - 5422.52956479739*std::exp(0.825519859790802*x_1) - 0.102075590458259*std::exp(0.861039876937866*x_1) - 0.000238965097799*std::exp(0.9440798163414*x_1) + 4.36193866008543e-5*std::exp(1.0079197883606*x_1) - 0.0748590844026951*std::exp(1.04303979873657*x_1) + 0.00479015064649075*std::exp(1.06415987014771*x_1) + 0.204615213537613*std::exp(1.10735988616943*x_1) + 0.0269179238848296*std::exp(1.13199985027313*x_1) - 1.73264305233955e-5*std::exp(1.1593599319458*x_1) + 0.00167924266551961*std::exp(1.20591986179352*x_1) + 0.00984405889129463*std::exp(1.00127983093262*x_108) + 3.85438895297715*std::exp(1.28079986572266*x_108) + 0.0423700115184103*std::exp(1.56919980049133*x_108) + 0.00952549238661395*std::exp(2.03247976303101*x_108) - 646.747836613209*std::exp(2.7753598690033*x_17) - 0.000837772700569671*std::exp(2.80999994277954*x_17) - 0.0136761269345542*std::exp(2.84888005256653*x_17) - 0.00460141185371912*std::exp(3.49399995803833*x_17) - 0.00358847423247727*std::exp(3.63927984237671*x_17) - 0.000377090026264951*std::exp(3.64759993553162*x_17) + 3.93367861619191e-6*std::exp(3.85743999481201*x_17) - 0.000491569889600365*std::exp(4.2695198059082*x_17) - 0.795671917875192*std::exp(0.929519832134247*x_29) - 0.336750545625853*std::exp(1.05495977401733*x_29) + 0.539449138428774*std::exp(1.27431988716125*x_29) - 0.000884951493751857*std::exp(1.46327984333038*x_29) - 0.00306798352037086*std::exp(1.66111981868744*x_29) + 0.141118343587074*std::exp(1.70815992355347*x_29) + 0.00324229394712597*std::exp(2.27495980262756*x_29) - 0.179582426085575*std::exp(1.40247988700867*x_38) - 0.000331724671148176*std::exp(1.75471985340118*x_38) - 0.00177205393116682*std::exp(2.47439980506897*x_38) + 0.0653408435005904*std::exp(1.59183979034424*x_50) - 0.000210875866320661*std::exp(1.66439986228943*x_50) - 0.169456539987574*std::exp(1.66527986526489*x_50) + 5.10951758854847*std::exp(1.71759986877441*x_50) + 43905.3093541579*std::exp(1.88511991500854*x_50) + 0.0719154372401681*std::exp(1.92927980422974*x_50) + 0.0198560438432101*std::exp(1.93591976165771*x_50) - 0.858279868031204*std::exp(1.9366397857666*x_50) - 54.8822062253521*std::exp(1.95703983306885*x_50) - 0.0549869348472131*std::exp(2.02871990203857*x_50) + 0.572283822008223*std::exp(0.751999855041504*x_66) - 9.47392577215851*std::exp(0.740719854831696*x_71) - 0.43403584371644*std::exp(0.757279872894287*x_71) - 9.63613221869938*std::exp(1.08503985404968*x_71) - 0.0133095190942102*std::exp(1.08831977844238*x_71) + 0.00063533066363088*std::exp(1.28671991825104*x_71) - 0.180902005348188*std::exp(1.29703986644745*x_71) + 17.6069887206517*std::exp(1.67023992538452*x_71) + 0.0173758019281922*std::exp(1.67927992343903*x_71) - 0.000650661102208547*std::exp(1.84575986862183*x_71) - 0.1104355546377*std::exp(1.87239992618561*x_71) + 0.112472875876288*std::exp(1.95615983009338*x_71) - 1.03644988280443*std::exp(0.985039830207825*x_72) - 90139.8917526551*std::exp(0.735359847545624*x_73) - 0.614861794888177*std::exp(0.856079876422882*x_73) + 0.0030970394501394*std::exp(0.937839806079865*x_76) + 0.106734226988994*std::exp(1.32255983352661*x_76) - 0.000296266738507861*std::exp(1.70791983604431*x_76) + 0.0121861291431285*std::exp(2.26183986663818*x_76) + 0.157610923208023*std::exp(1.01895976066589*x_77) + 0.156605305547112*std::exp(1.48071980476379*x_77) - 0.166251540822568*std::exp(1.26399981975555*x_78) + 0.00953269456561954*std::exp(1.60799980163574*x_78) + 0.139041814524928*std::exp(1.75887989997864*x_78) + 0.136810616611932*std::exp(1.92959976196289*x_78) - 1.94452985134665*std::exp(1.39375984668732*x_81) + 0.0198733299232702*std::exp(1.04471981525421*x_87) - 4.15952769002683*std::exp(0.913439810276031*x_88) - 104.602141263609*std::sin(0.371119856834412*x_102 + 8.18839931488037) + 4.9029697121993*std::sin(0.247919961810112*x_104 - 1.35807979106903) + 0.733750089203979*std::sin(0.286159932613373*x_104 - 7.49079990386963) - 0.0120856563741523*std::sin(0.361919850111008*x_105 + 5.16847991943359) - 6.55493833680219*std::sin(0.433759868144989*x_105 + 2.01007986068726) - 648.552623638979*std::sin(0.437199860811234*x_105 + 2.02327990531921) - 11.183077638815*std::sin(0.437999874353409*x_105 + 2.02783989906311) - 5.04353251559482*std::sin(0.467039853334427*x_105 - 7.36383962631226) + 17.402626651259*std::sin(0.49127984046936*x_105 - 7.34815979003906) - 0.00821308641494343*std::sin(0.5065598487854*x_105 + 2.05463981628418) - 2.55775456660736*std::sin(0.517359852790833*x_109 + 2.1580798625946) + 6.78284166718688*std::sin(0.396799832582474*x_111 - 7.40463972091675) + 166.79956382814*std::sin(0.186080008745193*x_112 - 7.60784006118774) + 1.31373930644893*std::sin(0.258879989385605*x_112 + 5.0434398651123) + 241342.962406814*std::sin(0.511919856071472*x_115 + 5.26783990859985) - 28.2594575042899*std::sin(0.466559857130051*x_117 - 7.35599946975708) + 6.93147117927939*std::sin(0.433039873838425*x_120 - 1.17831993103027) + 4.33139686977858*std::sin(0.340079843997955*x_14 - 1.2299998998642) - 4.12481085114372*std::sin(0.479199856519699*x_14 - 4.32376003265381) + 0.170879398346465*std::sin(0.410479873418808*x_15 + 5.20991992950439) + 2.48921557843271*std::sin(0.549839854240417*x_15 + 2.14871978759766) + 7.41485911756575*std::sin(0.475679844617844*x_17 - 4.10208034515381) + 12.2441686163142*std::sin(0.441199839115143*x_19 - 1.15015983581543) - 53.0316926543429*std::sin(0.315679848194122*x_21 + 8.31968021392822) + 3.1598435531521*std::sin(0.457839846611023*x_21 - 1.17007982730865) + 8.91938470850313*std::sin(0.256719976663589*x_26 + 5.04903984069824) - 3.40886404418292*std::sin(0.300159931182861*x_28 + 5.10303974151611) + 123.363760070747*std::sin(0.321759849786758*x_28 + 8.30416011810303) + 30.21387304336*std::sin(0.32551982998848*x_28 - 4.27016019821167) + 512160.067815726*std::sin(0.338879853487015*x_28 - 4.24847984313965) - 487.581619563425*std::sin(0.342879861593246*x_28 - 4.26847982406616) + 3.4280663704608*std::sin(0.344799846410751*x_28 + 5.13168001174927) - 4.4237801455125*std::sin(0.369919836521149*x_28 - 4.22656011581421) - 6.21653103884761*std::sin(0.36303985118866*x_3 + 5.17160034179688) - 2.68782680128875*std::sin(0.380399852991104*x_34 + 1.99079978466034) - 662.812730964229*std::sin(0.329919844865799*x_36 - 1.23263990879059) - 102.088987083465*std::sin(0.330239832401276*x_36 - 7.44320011138916) - 4.75337657711008*std::sin(0.3503198325634*x_36 + 5.15304040908813) + 0.0181801326224335*std::sin(0.364159852266312*x_36 - 7.42759990692139) + 5.84583090244043*std::sin(0.365519851446152*x_36 + 1.96367979049683) + 4.37767391953107*std::sin(0.3781598508358*x_36 + 8.38055992126465) - 211310.243998413*std::sin(0.42663985490799*x_36 - 4.18807983398438) - 0.0222771261612101*std::sin(0.362399846315384*x_43 - 7.43351984024048) + 9.25841133800549*std::sin(0.452079862356186*x_45 - 7.34592008590698) - 649.426266870393*std::sin(0.34215983748436*x_46 + 8.32800006866455) + 13.0724796845638*std::sin(0.370959848165512*x_46 - 4.22959995269775) - 2.77262727895058*std::sin(0.40287983417511*x_46 - 4.18824005126953) + 9.02216852038728*std::sin(0.407039850950241*x_46 - 7.38815975189209) - 0.0617815630207157*std::sin(0.306159913539886*x_47 - 7.47959995269775) - 11.2047084020224*std::sin(0.690959870815277*x_47 + 5.23975992202759) - 35.0552359899522*std::sin(0.403599858283997*x_49 + 5.19695997238159) + 0.0702275582555858*std::sin(0.157360032200813*x_53 - 4.46767997741699) - 1208.87194329603*std::sin(0.233919993042946*x_53 - 4.36143970489502) + 15.8413836178399*std::sin(0.290159940719604*x_53 + 5.1017599105835) + 8.30298240975093*std::sin(0.44191986322403*x_53 - 7.35687971115112) + 0.0348559107521422*std::sin(0.174800008535385*x_55 - 7.63616037368774) - 2.82350463325639*std::sin(0.417919874191284*x_55 + 5.20223999023438) - 4.27894908313846*std::sin(0.473199844360352*x_55 + 2.05047988891602) + 303.463322180128*std::sin(0.130960047245026*x_67 - 7.68008041381836) - 0.497934057379337*std::sin(0.179680004715919*x_67 + 1.78391993045807) + 0.0948499295936182*std::sin(0.655519843101501*x_67 + 5.42639970779419) + 0.0403700265088581*std::sin(0.304239928722382*x_68 + 5.14751958847046) - 0.0132355253292242*std::sin(0.352319836616516*x_69 - 4.24432039260864) - 0.00966665575008103*std::sin(0.40735986828804*x_72 + 5.19271993637085) - 52.300495162674*std::sin(0.241279974579811*x_73 + 1.85223984718323) + 0.124384428200381*std::sin(0.483999848365784*x_73 + 8.48151969909668) - 252.762415308774*std::sin(0.5933598279953*x_73 - 3.99767971038818) - 0.613315182647476*std::sin(0.821039855480194*x_73 - 0.78743988275528) + 26.7646550338838*std::sin(0.147360026836395*x_75 + 1.74791991710663) - 822.550310650427*std::sin(0.311999946832657*x_75 - 7.47160005569458) + 0.342443507148793*std::sin(0.400079846382141*x_75 - 4.18535995483398) - 0.244396802634896*std::sin(0.495359867811203*x_78 - 7.31343984603882) + 16.2844733785733*std::sin(0.183360010385513*x_80 - 4.43607997894287) + 30.9589310471104*std::sin(0.212880000472069*x_80 + 1.8199999332428) - 10.1321119827396*std::sin(0.231199979782104*x_80 + 5.04256010055542) - 1.23342996870106*std::sin(0.251519978046417*x_80 + 1.83783984184265) + 371459.605705154*std::sin(0.323599845170975*x_80 - 1.26775979995728) - 3200.97877170482*std::sin(0.173440024256706*x_85 + 1.78063988685608) - 0.154795379431491*std::sin(0.35999983549118*x_85 - 4.4215202331543) - 18.7180380753561*std::sin(0.33231982588768*x_86 - 4.28263998031616) + 17.3673067241872*std::sin(0.348239839076996*x_92 + 1.99207985401154) + 0.0346156437301642*std::sin(0.352559864521027*x_92 + 2.00831985473633) + 663.673867147263*std::sin(0.364959836006165*x_92 + 1.97991979122162) + 5.56591544115958*std::sin(0.369199842214584*x_92 + 1.98607981204987) - 41.2701305695829*std::sin(0.376879841089249*x_95 + 1.99391984939575) + 11.1001116434415*std::sin(0.135200038552284*x_96 - 7.67199993133545) - 34.9065946043275*std::sin(0.470319867134094*x_96 + 5.2292799949646) + 0.172501622457482*std::sin(0.399999856948853*x_97 + 5.1846399307251) - 0.0104044475914916*std::sin(0.513519823551178*x_98 + 5.15759992599487) - 0.769794346656883*std::sin(0.598479866981506*x_99 + 1.99935972690582) + 6883429.46079103 - 1.83161286258139*std::exp(-2.46007990837097*x_86) + 0.0122804809838556*std::exp(-2.28759980201721*x_86) + 3.00928745860849*std::exp(-2.11679983139038*x_23) + 0.0245078622592001*std::exp(-2.11087989807129*x_23) + 0.0315407743696458*std::exp(-2.10407996177673*x_23) - 1.07727904910004*std::exp(-1.98967981338501*x_23));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.218287125343664*x_1 + 41462.4635735516*x_10 + 15733.8775727391*x_100 + 1049130.22885342*x_101 - 16163.4309309145*x_102 + 9320.22482450574*x_103 + 31201.8321375448*x_104 + 17808.1851921135*x_105 + 7503.62709459182*x_106 + 141847.1279618*x_107 - 7077.79909429608*x_108 + 27944.3602094458*x_109 - 42372.1946352522*x_11 + 22596.4243292548*x_110 - 39402.3682033103*x_111 + 18585.8090731225*x_112 - 93346.4786060485*x_113 - 2681.54776336926*x_114 - 177.088963489876*x_115 + 16446.8334096864*x_116 + 19966.9976909311*x_117 + 12656.0660457057*x_118 - 15070.86446502*x_119 - 57129.9957683027*x_12 + 42973.8044140328*x_120 - 7193.34814471969*x_13 + 41496.5333183201*x_14 + 13746.907770295*x_15 - 27493.6339505693*x_16 - 320.644437385653*x_17 + 36188.448299719*x_18 + 3345.89210767959*x_19 - 38500.1702617628*x_2 - 9363.35124022405*x_20 - 16450.1035054042*x_21 + 7757.64909096566*x_22 - 18925.6714503393*x_23 + 7874.65013307593*x_24 - 20316.5134735362*x_25 - 11637.3808833718*x_26 + 16702.449036725*x_27 - 2.65995597405197*x_28 - 24280.4746573933*x_29 + 26712.5896537942*x_3 - 44201.2046752485*x_30 + 108882.528058862*x_31 - 20484.4385880186*x_32 + 28626.700210266*x_33 - 36397.4426504018*x_34 - 54.6268440464716*x_35 - 7.25100642039792*x_36 + 46601.8762455204*x_37 + 20466.7999203533*x_38 - 28663.8680844084*x_39 + 74036.7251887331*x_4 - 33806.4148211306*x_40 + 6340.17681609433*x_41 - 20261.4398215097*x_42 + 29415.8007349284*x_43 + 16210.1630782526*x_44 + 36224.7483696418*x_45 - 20855.5665834809*x_46 + 35871.1322174884*x_47 - 29739.6414722989*x_48 - 9832.7625453369*x_49 - 4527.76605800718*x_5 + 22.45026773677*x_50 - 36386.8258118773*x_51 - 23788.8705030937*x_52 - 28734.6408255292*x_53 + 76942.8158521087*x_54 - 25557.4081563901*x_55 + 31760.489777152*x_56 - 25259.4301406733*x_57 + 16998.3914998602*x_58 - 23517.2344965664*x_59 + 16281.1129195985*x_6 + 37079.6103756184*x_60 - 42372.2254020404*x_61 + 9707.32295929066*x_62 + 23054.9691426878*x_63 + 52504.1274783*x_64 + 33511.6405170995*x_65 + 43127.2562810602*x_66 + 27799.5031027913*x_67 + 9532.11146083408*x_68 + 30021.1946612084*x_69 + 19056.4394724983*x_7 - 51048.7339548027*x_70 - 11876.6519575692*x_71 + 64705.9056371739*x_72 + 1.68020772331678*x_73 - 7340.87693017556*x_74 - 4341.21810437229*x_75 - 28864.2682532616*x_76 - 50120.7000720271*x_77 - 52890.7262419826*x_78 - 28974.9648045323*x_79 + 359237.915870448*x_8 - 261.672895938717*x_80 - 23979.5286468232*x_81 - 54629.7986719126*x_82 - 8183.58592878977*x_83 + 50196.9570119638*x_84 + 32323.4195540914*x_85 + 54811.7176451386*x_86 + 9635.66305852141*x_87 + 31248.3313050014*x_88 + 65360.9105064946*x_89 - 208236.046017447*x_9 + 119886.173167184*x_90 - 94772.5167815713*x_91 - 34120.3485079559*x_92 + 1078135.60710704*x_93 + 24364.7688193353*x_94 + 50936.8142851126*x_95 - 42884.3016504537*x_96 - 51729.5234462328*x_97 + 13579.5345800184*x_98 + 40465.2496640552*x_99 - 0.0366466418681341*std::pow(-7.1832799911499*x_110 - 7.79856014251709, 2) - 2.92119705874049e-6*std::pow(-7.43791961669922*x_117 - 7.84168004989624, 2) - 0.0119625472108355*std::pow(-6.70688009262085*x_13 - 9.36343955993652, 2) + 6.85456698183985e-5*std::pow(-4.98303985595703*x_13 - 7.76800012588501, 2) + 0.0297437326106575*std::pow(-3.44167971611023*x_14 - 5.26336002349854, 2) + 0.00901409524195783*std::pow(-6.84879970550537*x_15 - 9.66967964172363, 2) - 2.02469564045968e-6*std::pow(-8.80000019073486*x_18 - 9.99954032897949, 2) - 0.00049149098297449*std::pow(-6.13807964324951*x_22 - 8.17304039001465, 2) - 6.25610269415659e-6*std::pow(-5.08871984481812*x_23 - 5.90208005905151, 2) - 0.0011399889114276*std::pow(-8.35967922210693*x_52 - 7.54143953323364, 2) - 0.00416050741669076*std::pow(-5.13479995727539*x_6 - 7.90055990219116, 2) - 0.0183315592764273*std::pow(-6.11504030227661*x_67 - 7.49976015090942, 2) - 0.00213225237586679*std::pow(-7.30751991271973*x_69 - 7.71600008010864, 2) - 0.00815567681695275*std::pow(-8.79600048065186*x_75 - 9.9973201751709, 2) - 0.18464244376858*std::pow(-2.12663984298706*x_75 - 2.76263999938965, 2) - 0.00635047583973289*std::pow(-7.26159954071045*x_76 - 9.62055969238281, 2) + 0.00802093272018508*std::pow(-7.6144003868103*x_83 - 8.61336040496826, 2) + 0.00334494505860444*std::pow(-5.26496028900146*x_87 - 5.67144012451172, 2) + 0.224548238607919*std::exp(0.754719853401184*x_1) - 72.4765475917275*std::exp(0.757199883460999*x_1) - 3575.41567672799*std::exp(0.825519859790802*x_1) - 0.424729947471239*std::exp(0.861039876937866*x_1) + 0.00153576881236299*std::exp(0.9440798163414*x_1) + 5.96270108380883e-6*std::exp(1.0079197883606*x_1) + 0.0108604455728773*std::exp(1.04303979873657*x_1) + 0.00944874452527965*std::exp(1.06415987014771*x_1) + 0.175030770588266*std::exp(1.10735988616943*x_1) + 0.0439314781212996*std::exp(1.13199985027313*x_1) - 3.34256405381685e-5*std::exp(1.1593599319458*x_1) + 0.00153084042261268*std::exp(1.20591986179352*x_1) - 0.0632653001277668*std::exp(1.00127983093262*x_108) - 0.448797891234187*std::exp(1.28079986572266*x_108) + 0.0386255826336315*std::exp(1.56919980049133*x_108) - 0.00760215324261922*std::exp(2.03247976303101*x_108) - 426.441631398128*std::exp(2.7753598690033*x_17) + 0.00538415524791923*std::exp(2.80999994277954*x_17) - 0.0124675059573473*std::exp(2.84888005256653*x_17) - 0.00750974796732655*std::exp(3.49399995803833*x_17) - 0.0149314098054149*std::exp(3.63927984237671*x_17) - 0.000743823646510736*std::exp(3.64759993553162*x_17) + 7.58873717468629e-6*std::exp(3.85743999481201*x_17) - 0.000420495891225238*std::exp(4.2695198059082*x_17) - 7.23558494686571*std::exp(0.929519832134247*x_29) + 0.176009136954965*std::exp(1.05495977401733*x_29) + 2.2446130676261*std::exp(1.27431988716125*x_29) - 0.000120971468012553*std::exp(1.46327984333038*x_29) + 0.0197171614215911*std::exp(1.66111981868744*x_29) + 0.120714642841769*std::exp(1.70815992355347*x_29) + 0.00639554148567277*std::exp(2.27495980262756*x_29) - 1.63306492250771*std::exp(1.40247988700867*x_38) - 4.53462373114302e-5*std::exp(1.75471985340118*x_38) - 0.00737340210055859*std::exp(2.47439980506897*x_38) + 0.106639718908308*std::exp(1.59183979034424*x_50) - 0.000406815523618186*std::exp(1.66439986228943*x_50) + 0.0885697135223815*std::exp(1.66527986526489*x_50) - 0.594942738509384*std::exp(1.71759986877441*x_50) + 28949.539044572*std::exp(1.88511991500854*x_50) + 0.141855787855845*std::exp(1.92927980422974*x_50) - 0.127609818974333*std::exp(1.93591976165771*x_50) + 0.124517977576461*std::exp(1.9366397857666*x_50) + 213.634426421152*std::exp(1.95703983306885*x_50) - 0.228797088945682*std::exp(2.02871990203857*x_50) - 0.299115125167071*std::exp(0.751999855041504*x_66) + 1.37446318013345*std::exp(0.740719854831696*x_71) + 0.226857165496411*std::exp(0.757279872894287*x_71) + 1.12201333912232*std::exp(1.08503985404968*x_71) + 0.0855369446028083*std::exp(1.08831977844238*x_71) + 8.68486957708533e-5*std::exp(1.28671991825104*x_71) - 0.295241658459851*std::exp(1.29703986644745*x_71) - 68.5369484035531*std::exp(1.67023992538452*x_71) + 0.0158402239969035*std::exp(1.67927992343903*x_71) - 0.00125523627530924*std::exp(1.84575986862183*x_71) - 1.00426547523404*std::exp(1.87239992618561*x_71) - 0.0897629228333858*std::exp(1.95615983009338*x_71) + 0.827175175579022*std::exp(0.985039830207825*x_72) - 59434.914686915*std::exp(0.735359847545624*x_73) - 1.00348702988109*std::exp(0.856079876422882*x_73) + 0.00597471748454507*std::exp(0.937839806079865*x_76) + 0.970606790018759*std::exp(1.32255983352661*x_76) - 4.04991940616316e-5*std::exp(1.70791983604431*x_76) + 0.0507056972935682*std::exp(2.26183986663818*x_76) + 0.143682135552151*std::exp(1.01895976066589*x_77) + 1.4241183658234*std::exp(1.48071980476379*x_77) + 0.0868945591854354*std::exp(1.26399981975555*x_78) - 0.061264239617012*std::exp(1.60799980163574*x_78) + 0.578544021292018*std::exp(1.75887989997864*x_78) + 0.117029751777673*std::exp(1.92959976196289*x_78) + 0.282109523298218*std::exp(1.39375984668732*x_81) - 0.127720912279962*std::exp(1.04471981525421*x_87) + 0.60345814334841*std::exp(0.913439810276031*x_88) + 12.1796790594855*std::sin(0.371119856834412*x_102 + 8.18839931488037) + 8.00190637147429*std::sin(0.247919961810112*x_104 - 1.35807979106903) + 1.44734845518244*std::sin(0.286159932613373*x_104 - 7.49079990386963) - 0.023315293076942*std::sin(0.361919850111008*x_105 + 5.16847991943359) - 5.60718769837783*std::sin(0.433759868144989*x_105 + 2.01007986068726) + 2524.55535745289*std::sin(0.437199860811234*x_105 + 2.02327990531921) + 8.92504728194953*std::sin(0.437999874353409*x_105 + 2.02783989906311) - 45.8642653197041*std::sin(0.467039853334427*x_105 - 7.36383962631226) - 2.52474741147512*std::sin(0.49127984046936*x_105 - 7.34815979003906) - 0.00112271590877529*std::sin(0.5065598487854*x_105 + 2.05463981628418) - 4.17439098436163*std::sin(0.517359852790833*x_109 + 2.1580798625946) + 28.2229666473305*std::sin(0.396799832582474*x_111 - 7.40463972091675) - 24.1990347462755*std::sin(0.186080008745193*x_112 - 7.60784006118774) + 2.59139805729238*std::sin(0.258879989385605*x_112 + 5.0434398651123) + 159132.633754398*std::sin(0.511919856071472*x_115 + 5.26783990859985) + 4.09984042141623*std::sin(0.466559857130051*x_117 - 7.35599946975708) + 5.92927925956305*std::sin(0.433039873838425*x_120 - 1.17831993103027) + 3.70513862939907*std::sin(0.340079843997955*x_14 - 1.2299998998642) - 37.5097054862823*std::sin(0.479199856519699*x_14 - 4.32376003265381) - 1.09819908042216*std::sin(0.410479873418808*x_15 + 5.20991992950439) + 4.06253172388027*std::sin(0.549839854240417*x_15 + 2.14871978759766) - 5.91768834578899*std::sin(0.475679844617844*x_17 - 4.10208034515381) - 9.77188814727273*std::sin(0.441199839115143*x_19 - 1.15015983581543) + 7.69375976617358*std::sin(0.315679848194122*x_21 + 8.31968021392822) - 2.52182395815275*std::sin(0.457839846611023*x_21 - 1.17007982730865) + 81.1100207036245*std::sin(0.256719976663589*x_26 + 5.04903984069824) + 1.78170822945026*std::sin(0.300159931182861*x_28 + 5.10303974151611) - 14.3642471089242*std::sin(0.321759849786758*x_28 + 8.30416011810303) - 4.38338414571126*std::sin(0.32551982998848*x_28 - 4.27016019821167) + 337699.42857487*std::sin(0.338879853487015*x_28 - 4.24847984313965) + 1897.95977226607*std::sin(0.342879861593246*x_28 - 4.26847982406616) + 5.59478596479487*std::sin(0.344799846410751*x_28 + 5.13168001174927) - 40.228436256229*std::sin(0.369919836521149*x_28 - 4.22656011581421) - 25.8665846528977*std::sin(0.36303985118866*x_3 + 5.17160034179688) + 1.40484427337759*std::sin(0.380399852991104*x_34 + 1.99079978466034) + 2580.06423835728*std::sin(0.329919844865799*x_36 - 1.23263990879059) + 11.8870520542312*std::sin(0.330239832401276*x_36 - 7.44320011138916) + 2.48444351412763*std::sin(0.3503198325634*x_36 + 5.15304040908813) + 0.035072577537142*std::sin(0.364159852266312*x_36 - 7.42759990692139) + 24.3241252974636*std::sin(0.365519851446152*x_36 + 1.96367979049683) + 7.14459580318707*std::sin(0.3781598508358*x_36 + 8.38055992126465) - 139330.168700218*std::sin(0.42663985490799*x_36 - 4.18807983398438) - 0.00304524787386607*std::sin(0.362399846315384*x_43 - 7.43351984024048) - 7.38899984568047*std::sin(0.452079862356186*x_45 - 7.34592008590698) + 2527.95610030701*std::sin(0.34215983748436*x_46 + 8.32800006866455) - 10.4329508428075*std::sin(0.370959848165512*x_46 - 4.22959995269775) - 25.2133822397775*std::sin(0.40287983417511*x_46 - 4.18824005126953) + 37.5406612348497*std::sin(0.407039850950241*x_46 - 7.38815975189209) + 0.39705462655497*std::sin(0.306159913539886*x_47 - 7.47959995269775) + 1.3046554367165*std::sin(0.690959870815277*x_47 + 5.23975992202759) + 5.08576194260182*std::sin(0.403599858283997*x_49 + 5.19695997238159) + 0.135480941383446*std::sin(0.157360032200813*x_53 - 4.46767997741699) + 4705.65383545702*std::sin(0.233919993042946*x_53 - 4.36143970489502) + 13.5509453763328*std::sin(0.290159940719604*x_53 + 5.1017599105835) - 6.62648628415271*std::sin(0.44191986322403*x_53 - 7.35687971115112) + 0.0672429986002254*std::sin(0.174800008535385*x_55 - 7.63616037368774) - 4.60810917483862*std::sin(0.417919874191284*x_55 + 5.20223999023438) - 38.9113890773483*std::sin(0.473199844360352*x_55 + 2.05047988891602) - 44.0260112743664*std::sin(0.130960047245026*x_67 - 7.68008041381836) + 3.2000974325538*std::sin(0.179680004715919*x_67 + 1.78391993045807) + 0.187094899327941*std::sin(0.655519843101501*x_67 + 5.42639970779419) + 0.0778806686570187*std::sin(0.304239928722382*x_68 + 5.14751958847046) - 0.00180927535610504*std::sin(0.352319836616516*x_69 - 4.24432039260864) - 0.00132141653538718*std::sin(0.40735986828804*x_72 + 5.19271993637085) + 7.58767871235549*std::sin(0.241279974579811*x_73 + 1.85223984718323) - 0.799387556313458*std::sin(0.483999848365784*x_73 + 8.48151969909668) + 983.902749710726*std::sin(0.5933598279953*x_73 - 3.99767971038818) - 2.55196491286227*std::sin(0.821039855480194*x_73 - 0.78743988275528) + 243.38917928432*std::sin(0.147360026836395*x_75 + 1.74791991710663) + 3201.85859687927*std::sin(0.311999946832657*x_75 - 7.47160005569458) + 0.675482140788235*std::sin(0.400079846382141*x_75 - 4.18535995483398) - 0.482081487893094*std::sin(0.495359867811203*x_78 - 7.31343984603882) + 26.5771234441623*std::sin(0.183360010385513*x_80 - 4.43607997894287) - 24.7078606013644*std::sin(0.212880000472069*x_80 + 1.8199999332428) - 92.1381731531307*std::sin(0.231199979782104*x_80 + 5.04256010055542) - 2.43298499862795*std::sin(0.251519978046417*x_80 + 1.83783984184265) + 244926.741595189*std::sin(0.323599845170975*x_80 - 1.26775979995728) + 12460.1270778279*std::sin(0.173440024256706*x_85 + 1.78063988685608) + 0.994831120604648*std::sin(0.35999983549118*x_85 - 4.4215202331543) + 14.9385866971042*std::sin(0.33231982588768*x_86 - 4.28263998031616) - 13.8605881743584*std::sin(0.348239839076996*x_92 + 1.99207985401154) + 0.0667794825229255*std::sin(0.352559864521027*x_92 + 2.00831985473633) - 2583.41629628618*std::sin(0.364959836006165*x_92 + 1.97991979122162) + 23.1594151191294*std::sin(0.369199842214584*x_92 + 1.98607981204987) + 5.98740968331102*std::sin(0.376879841089249*x_95 + 1.99391984939575) + 10.1191447479307*std::sin(0.135200038552284*x_96 - 7.67199993133545) + 5.06419726957203*std::sin(0.470319867134094*x_96 + 5.2292799949646) - 1.10862470834569*std::sin(0.399999856948853*x_97 + 5.1846399307251) - 0.00142227151192915*std::sin(0.513519823551178*x_98 + 5.15759992599487) - 7.00026262297541*std::sin(0.598479866981506*x_99 + 1.99935972690582) + 4451962.78570876 + 7.12973457583829*std::exp(-2.46007990837097*x_86) + 0.0200423956903057*std::exp(-2.28759980201721*x_86) - 11.7139496454721*std::exp(-2.11679983139038*x_23) + 0.0223419920113798*std::exp(-2.11087989807129*x_23) + 0.286821675007631*std::exp(-2.10407996177673*x_23) + 0.125436371732393*std::exp(-1.98967981338501*x_23));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.440431374187309*x_1 + 30977.9406909892*x_10 + 11500.3005139941*x_100 + 793842.280191453*x_101 - 11615.3401044479*x_102 + 6583.61698553739*x_103 + 22622.7591331734*x_104 + 13332.9161836265*x_105 + 5941.3953856235*x_106 + 104974.853293116*x_107 - 5478.34633210735*x_108 + 21190.4264410281*x_109 - 31348.1566185176*x_11 + 17153.0015661453*x_110 - 29951.5364034374*x_111 + 14276.6190719097*x_112 - 69762.8172866398*x_113 - 2177.04701754653*x_114 + 71.8814649898437*x_115 + 12922.549873492*x_116 + 15322.7590755045*x_117 + 10293.1318932883*x_118 - 11609.7177989304*x_119 - 43237.5568392157*x_12 + 32430.2978187821*x_120 - 5369.47488397368*x_13 + 31410.8650522252*x_14 + 10610.620505489*x_15 - 21195.9707832737*x_16 + 144.826888278928*x_17 + 26880.6729047557*x_18 + 2824.87957565918*x_19 - 28920.4403718562*x_2 - 7629.7772603646*x_20 - 12736.2696892674*x_21 + 5740.65879178727*x_22 - 14175.8312294865*x_23 + 5783.51377390614*x_24 - 15379.9294363704*x_25 - 8560.25599484117*x_26 + 12414.623285431*x_27 + 2.06767357884265*x_28 - 18181.4565900156*x_29 + 20244.3766270377*x_3 - 32028.15473495*x_30 + 77406.2180581029*x_31 - 15245.1011427456*x_32 + 21882.0088055626*x_33 - 27765.3966114836*x_34 - 226.228500238164*x_35 - 4.53025798411247*x_36 + 35103.0459790815*x_37 + 15128.7881260883*x_38 - 21787.8515837139*x_39 + 55168.2580564565*x_4 - 24400.2217631341*x_40 + 5122.60381549628*x_41 - 14797.247612652*x_42 + 21585.8134048293*x_43 + 12210.878133235*x_44 + 26845.9323257112*x_45 - 15640.0035519336*x_46 + 27065.036759084*x_47 - 24044.9688844624*x_48 - 6689.60605112181*x_49 - 3393.92817096782*x_5 + 0.152703450415891*x_50 - 27281.0148814056*x_51 - 17828.4467162148*x_52 - 21522.8037252818*x_53 + 57986.3615582588*x_54 - 18964.3572098639*x_55 + 23485.5693279162*x_56 - 18546.4159716156*x_57 + 12857.1665342962*x_58 - 18133.5806853899*x_59 + 12447.2590167686*x_6 + 27315.1317560212*x_60 - 31758.9429798691*x_61 + 6098.22991099841*x_62 + 17744.3885254803*x_63 + 38699.6339431644*x_64 + 24753.9655233872*x_65 + 31775.1647593838*x_66 + 20382.3458746575*x_67 + 7265.10453029049*x_68 + 22391.3938070439*x_69 + 14792.7115841555*x_7 - 38783.9796405524*x_70 - 8897.53714135272*x_71 + 48650.020687224*x_72 + 0.881434053825597*x_73 - 5837.16956583861*x_74 - 3250.0744792839*x_75 - 21510.1167860816*x_76 - 37581.7127532287*x_77 - 39765.0179539556*x_78 - 21692.2284579467*x_79 + 265570.805799063*x_8 + 132.508534329874*x_80 - 18017.1252724423*x_81 - 41191.1132084761*x_82 - 5414.72018175793*x_83 + 36670.9745165717*x_84 + 24204.0809364209*x_85 + 41044.8128177664*x_86 + 6784.07777391393*x_87 + 23602.8074667403*x_88 + 49268.2292296447*x_89 - 155440.27125086*x_9 + 89291.1956159643*x_90 - 70564.5577733405*x_91 - 25568.6167971557*x_92 + 798007.116101722*x_93 + 18012.1909371344*x_94 + 38600.6671354363*x_95 - 32164.6427154814*x_96 - 38515.9075642165*x_97 + 10485.8426479838*x_98 + 30085.3238387849*x_99 - 0.00565906156146003*std::pow(-7.1832799911499*x_110 - 7.79856014251709, 2) - 1.88605120042303e-5*std::pow(-7.43791961669922*x_117 - 7.84168004989624, 2) - 0.0488694784829651*std::pow(-6.70688009262085*x_13 - 9.36343955993652, 2) + 5.2342493662101e-5*std::pow(-4.98303985595703*x_13 - 7.76800012588501, 2) - 0.0747097959160459*std::pow(-3.44167971611023*x_14 - 5.26336002349854, 2) + 0.0451782263722267*std::pow(-6.84879970550537*x_15 - 9.66967964172363, 2) - 1.30723109957763e-5*std::pow(-8.80000019073486*x_18 - 9.99954032897949, 2) + 0.000348281481606983*std::pow(-6.13807964324951*x_22 - 8.17304039001465, 2) - 4.03921055615853e-5*std::pow(-5.08871984481812*x_23 - 5.90208005905151, 2) - 0.00214668325151369*std::pow(-8.35967922210693*x_52 - 7.54143953323364, 2) - 0.00783454251149161*std::pow(-5.13479995727539*x_6 - 7.90055990219116, 2) + 0.00471644596677395*std::pow(-6.11504030227661*x_67 - 7.49976015090942, 2) + 0.00151096162971812*std::pow(-7.30751991271973*x_69 - 7.71600008010864, 2) + 0.0204852887338506*std::pow(-8.79600048065186*x_75 - 9.9973201751709, 2) + 0.0475058393056311*std::pow(-2.12663984298706*x_75 - 2.76263999938965, 2) - 0.0318282897348769*std::pow(-7.26159954071045*x_76 - 9.62055969238281, 2) + 0.032767168402675*std::pow(-7.6144003868103*x_83 - 8.61336040496826, 2) + 0.00629877840263158*std::pow(-5.26496028900146*x_87 - 5.67144012451172, 2) + 2.32914443434188*std::exp(0.754719853401184*x_1) + 37.5340956499008*std::exp(0.757199883460999*x_1) - 2677.98389465255*std::exp(0.825519859790802*x_1) - 0.0655878082467753*std::exp(0.861039876937866*x_1) + 0.000576370551869461*std::exp(0.9440798163414*x_1) + 3.84977778312916e-5*std::exp(1.0079197883606*x_1) + 0.0544320484113421*std::exp(1.04303979873657*x_1) - 0.00669559128567182*std::exp(1.06415987014771*x_1) + 0.715036883563755*std::exp(1.10735988616943*x_1) - 0.110346331030306*std::exp(1.13199985027313*x_1) - 2.55243166002463e-5*std::exp(1.1593599319458*x_1) - 0.000918843797211223*std::exp(1.20591986179352*x_1) - 0.0237433236404396*std::exp(1.00127983093262*x_108) - 4.65519176188102*std::exp(1.28079986572266*x_108) - 0.023183916816104*std::exp(1.56919980049133*x_108) + 0.00195592445024878*std::exp(2.03247976303101*x_108) - 319.404490036426*std::exp(2.7753598690033*x_17) + 0.00202066125227485*std::exp(2.80999994277954*x_17) + 0.00748326889359975*std::exp(2.84888005256653*x_17) + 0.0188628557607083*std::exp(3.49399995803833*x_17) - 0.00230574380027179*std::exp(3.63927984237671*x_17) + 0.00052709003956338*std::exp(3.64759993553162*x_17) + 5.79487265237505e-6*std::exp(3.85743999481201*x_17) - 0.00171781264861331*std::exp(4.2695198059082*x_17) - 0.350197279889097*std::exp(0.929519832134247*x_29) + 0.331438194378087*std::exp(1.05495977401733*x_29) + 0.346618486273883*std::exp(1.27431988716125*x_29) - 0.000781044133189653*std::exp(1.46327984333038*x_29) + 0.00739980595932015*std::exp(1.66111981868744*x_29) + 0.493144272449868*std::exp(1.70815992355347*x_29) - 0.00453202345814888*std::exp(2.27495980262756*x_29) - 0.0790392066355643*std::exp(1.40247988700867*x_38) - 0.00029277492615567*std::exp(1.75471985340118*x_38) - 0.00113861828198624*std::exp(2.47439980506897*x_38) - 0.267855811524122*std::exp(1.59183979034424*x_50) - 0.00031065038861016*std::exp(1.66439986228943*x_50) + 0.166783307016349*std::exp(1.66527986526489*x_50) - 6.17109079430729*std::exp(1.71759986877441*x_50) + 21683.1849296826*std::exp(1.88511991500854*x_50) - 0.100522177782301*std::exp(1.92927980422974*x_50) - 0.0478916756181752*std::exp(1.93591976165771*x_50) + 0.624078315944148*std::exp(1.9366397857666*x_50) - 110.63682338421*std::exp(1.95703983306885*x_50) - 0.0353313904200408*std::exp(2.02871990203857*x_50) - 0.563255855415708*std::exp(0.751999855041504*x_66) + 6.8887455729692*std::exp(0.740719854831696*x_71) + 0.427188784711214*std::exp(0.757279872894287*x_71) + 11.6381724491601*std::exp(1.08503985404968*x_71) + 0.0321018212956752*std::exp(1.08831977844238*x_71) + 0.000560732753114635*std::exp(1.28671991825104*x_71) + 0.741582918935568*std::exp(1.29703986644745*x_71) + 35.4938592194326*std::exp(1.67023992538452*x_71) - 0.00950764779332828*std::exp(1.67927992343903*x_71) - 0.00095851710193921*std::exp(1.84575986862183*x_71) - 0.0486057506471314*std::exp(1.87239992618561*x_71) + 0.0230947061828924*std::exp(1.95615983009338*x_71) - 0.212820249595023*std::exp(0.985039830207825*x_72) - 44516.7104198821*std::exp(0.735359847545624*x_73) + 2.52054145954609*std::exp(0.856079876422882*x_73) + 0.00456238319497322*std::exp(0.937839806079865*x_76) + 0.0469766936885587*std::exp(1.32255983352661*x_76) - 0.000261480317966086*std::exp(1.70791983604431*x_76) + 0.00783009432442901*std::exp(2.26183986663818*x_76) - 0.0862411503328585*std::exp(1.01895976066589*x_77) + 0.0689263385909797*std::exp(1.48071980476379*x_77) + 0.163628867773322*std::exp(1.26399981975555*x_78) - 0.0229923301695321*std::exp(1.60799980163574*x_78) + 0.0893401432056746*std::exp(1.75887989997864*x_78) + 0.478090730641831*std::exp(1.92959976196289*x_78) + 1.41391981815356*std::exp(1.39375984668732*x_81) - 0.0479333686837972*std::exp(1.04471981525421*x_87) + 3.02450416537164*std::exp(0.913439810276031*x_88) + 126.33468812465*std::sin(0.371119856834412*x_102 + 8.18839931488037) - 20.0990507740763*std::sin(0.247919961810112*x_104 - 1.35807979106903) - 1.02562342308258*std::sin(0.286159932613373*x_104 - 7.49079990386963) - 0.0178039048030763*std::sin(0.361919850111008*x_105 + 5.16847991943359) - 22.9065209730265*std::sin(0.433759868144989*x_105 + 2.01007986068726) - 1307.41467976493*std::sin(0.437199860811234*x_105 + 2.02327990531921) - 2.29628601808835*std::sin(0.437999874353409*x_105 + 2.02783989906311) - 2.21979854801231*std::sin(0.467039853334427*x_105 - 7.36383962631226) - 12.6539166745638*std::sin(0.49127984046936*x_105 - 7.34815979003906) - 0.00724873962591438*std::sin(0.5065598487854*x_105 + 2.05463981628418) + 10.4851634661244*std::sin(0.517359852790833*x_109 + 2.1580798625946) + 4.35825760731316*std::sin(0.396799832582474*x_111 - 7.40463972091675) - 121.284437362918*std::sin(0.186080008745193*x_112 - 7.60784006118774) - 1.83632250863511*std::sin(0.258879989385605*x_112 + 5.0434398651123) + 119190.233762669*std::sin(0.511919856071472*x_115 + 5.26783990859985) + 20.5482096291361*std::sin(0.466559857130051*x_117 - 7.35599946975708) + 24.2223315893999*std::sin(0.433039873838425*x_120 - 1.17831993103027) + 15.1362572982627*std::sin(0.340079843997955*x_14 - 1.2299998998642) - 1.81544366173564*std::sin(0.479199856519699*x_14 - 4.32376003265381) - 0.412151623961905*std::sin(0.410479873418808*x_15 + 5.20991992950439) - 10.2041972998643*std::sin(0.549839854240417*x_15 + 2.14871978759766) + 1.52253591253484*std::sin(0.475679844617844*x_17 - 4.10208034515381) + 2.51416596618905*std::sin(0.441199839115143*x_19 - 1.15015983581543) + 38.560766337568*std::sin(0.315679848194122*x_21 + 8.31968021392822) + 0.648828954318039*std::sin(0.457839846611023*x_21 - 1.17007982730865) + 3.92566859911745*std::sin(0.256719976663589*x_26 + 5.04903984069824) + 3.35508808630013*std::sin(0.300159931182861*x_28 + 5.10303974151611) - 148.994293674599*std::sin(0.321759849786758*x_28 + 8.30416011810303) - 21.9693175960232*std::sin(0.32551982998848*x_28 - 4.27016019821167) + 252936.640861989*std::sin(0.338879853487015*x_28 - 4.24847984313965) - 982.913866609587*std::sin(0.342879861593246*x_28 - 4.26847982406616) - 14.0528871441648*std::sin(0.344799846410751*x_28 + 5.13168001174927) - 1.94702834042821*std::sin(0.369919836521149*x_28 - 4.22656011581421) - 3.99437949764094*std::sin(0.36303985118866*x_3 + 5.17160034179688) + 2.64542544441769*std::sin(0.380399852991104*x_34 + 1.99079978466034) - 1336.16157396057*std::sin(0.329919844865799*x_36 - 1.23263990879059) + 123.299391277739*std::sin(0.330239832401276*x_36 - 7.44320011138916) + 4.67839048928182*std::sin(0.3503198325634*x_36 + 5.15304040908813) + 0.0267819422045921*std::sin(0.364159852266312*x_36 - 7.42759990692139) + 3.75618925691273*std::sin(0.365519851446152*x_36 + 1.96367979049683) - 17.9456728362159*std::sin(0.3781598508358*x_36 + 8.38055992126465) - 104358.200991016*std::sin(0.42663985490799*x_36 - 4.18807983398438) - 0.0196614377345949*std::sin(0.362399846315384*x_43 - 7.43351984024048) + 1.9010831536555*std::sin(0.452079862356186*x_45 - 7.34592008590698) - 1309.17585371442*std::sin(0.34215983748436*x_46 + 8.32800006866455) + 2.68424786904983*std::sin(0.370959848165512*x_46 - 4.22959995269775) - 1.22031016732088*std::sin(0.40287983417511*x_46 - 4.18824005126953) + 5.79711815752102*std::sin(0.407039850950241*x_46 - 7.38815975189209) + 0.149013700752064*std::sin(0.306159913539886*x_47 - 7.47959995269775) + 13.5326421084424*std::sin(0.690959870815277*x_47 + 5.23975992202759) + 25.4896024671042*std::sin(0.403599858283997*x_49 + 5.19695997238159) + 0.103455263249832*std::sin(0.157360032200813*x_53 - 4.46767997741699) - 2436.96018952655*std::sin(0.233919993042946*x_53 - 4.36143970489502) + 55.3584133730898*std::sin(0.290159940719604*x_53 + 5.1017599105835) + 1.70489940530941*std::sin(0.44191986322403*x_53 - 7.35687971115112) + 0.0513477545318004*std::sin(0.174800008535385*x_55 - 7.63616037368774) + 11.57456935609*std::sin(0.417919874191284*x_55 + 5.20223999023438) - 1.88328417282924*std::sin(0.473199844360352*x_55 + 2.05047988891602) - 220.656322152141*std::sin(0.130960047245026*x_67 - 7.68008041381836) + 1.20098930801906*std::sin(0.179680004715919*x_67 + 1.78391993045807) - 0.132579621999753*std::sin(0.655519843101501*x_67 + 5.42639970779419) + 0.0594708377112688*std::sin(0.304239928722382*x_68 + 5.14751958847046) - 0.0116814644430356*std::sin(0.352319836616516*x_69 - 4.24432039260864) - 0.00853163683486802*std::sin(0.40735986828804*x_72 + 5.19271993637085) + 38.0290930265418*std::sin(0.241279974579811*x_73 + 1.85223984718323) - 0.30000833672423*std::sin(0.483999848365784*x_73 + 8.48151969909668) - 509.542757553451*std::sin(0.5933598279953*x_73 - 3.99767971038818) - 0.394080488917357*std::sin(0.821039855480194*x_73 - 0.78743988275528) + 11.7798670274378*std::sin(0.147360026836395*x_75 + 1.74791991710663) - 1658.17593174707*std::sin(0.311999946832657*x_75 - 7.47160005569458) - 0.478661723087999*std::sin(0.400079846382141*x_75 - 4.18535995483398) + 0.341613703353375*std::sin(0.495359867811203*x_78 - 7.31343984603882) - 66.7559614840497*std::sin(0.183360010385513*x_80 - 4.43607997894287) + 6.35697638829717*std::sin(0.212880000472069*x_80 + 1.8199999332428) - 4.45942350882828*std::sin(0.231199979782104*x_80 + 5.04256010055542) + 1.72406747916612*std::sin(0.251519978046417*x_80 + 1.83783984184265) + 183449.961813082*std::sin(0.323599845170975*x_80 - 1.26775979995728) - 6452.84049929679*std::sin(0.173440024256706*x_85 + 1.78063988685608) + 0.373357863100224*std::sin(0.35999983549118*x_85 - 4.4215202331543) - 3.84348302915298*std::sin(0.33231982588768*x_86 - 4.28263998031616) + 3.56612954775379*std::sin(0.348239839076996*x_92 + 1.99207985401154) + 0.0509938067565051*std::sin(0.352559864521027*x_92 + 2.00831985473633) + 1337.89753500049*std::sin(0.364959836006165*x_92 + 1.97991979122162) + 3.57633194217789*std::sin(0.369199842214584*x_92 + 1.98607981204987) + 30.0086190344196*std::sin(0.376879841089249*x_95 + 1.99391984939575) - 6.07373129646652*std::sin(0.135200038552284*x_96 - 7.67199993133545) + 25.3815213282176*std::sin(0.470319867134094*x_96 + 5.2292799949646) - 0.416064338474336*std::sin(0.399999856948853*x_97 + 5.1846399307251) - 0.00918280019615669*std::sin(0.513519823551178*x_98 + 5.15759992599487) - 0.338807843053135*std::sin(0.598479866981506*x_99 + 1.99935972690582) + 3426880.40642223 - 3.69234115614061*std::exp(-2.46007990837097*x_86) - 0.0503421447231158*std::exp(-2.28759980201721*x_86) + 6.06641073617388*std::exp(-2.11679983139038*x_23) - 0.0134101507079115*std::exp(-2.11087989807129*x_23) + 0.0138819696180082*std::exp(-2.10407996177673*x_23) + 1.30109872558242*std::exp(-1.98967981338501*x_23));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.43649425716728*x_1 - 61528.6576881982*x_10 - 23110.4452647668*x_100 - 1563576.03114049*x_101 + 23595.3380584332*x_102 - 13507.0131297841*x_103 - 45654.344932393*x_104 - 26441.8347367767*x_105 - 11432.1999572459*x_106 - 209456.506553282*x_107 + 10669.8617492566*x_108 - 41763.393524096*x_109 + 62565.5136998186*x_11 - 33696.6849108971*x_110 + 58933.6736885213*x_111 - 27909.9987021913*x_112 + 138407.531653006*x_113 + 4117.81989297409*x_114 + 74.6008981906906*x_115 - 24981.7640145735*x_116 - 29921.4529968764*x_117 - 19606.8058064145*x_118 + 22681.8020144374*x_119 + 85234.011726602*x_12 - 64022.7523947194*x_120 + 10677.0909219072*x_13 - 61869.7463210236*x_14 - 20666.6678881456*x_15 + 41333.0295957921*x_16 + 97.6189610990141*x_17 - 53535.1852344895*x_18 - 5210.28107150836*x_19 + 57182.3340359464*x_2 + 14416.2486529068*x_20 + 24752.9483461025*x_21 - 11428.2162991101*x_22 + 28089.126530267*x_23 - 11615.6496581544*x_24 + 30305.1371586527*x_25 + 17145.762197118*x_26 - 24736.4464511746*x_27 + 10.9009276147926*x_28 + 36015.3183144943*x_29 - 39813.130944657*x_3 + 64674.20641953*x_30 - 158017.882925569*x_31 + 30145.7983604563*x_32 - 42703.9942396239*x_33 + 54471.9416337212*x_34 + 248.731444226667*x_35 - 18.8174361752032*x_36 - 69330.1937167432*x_37 - 30178.9704686032*x_38 + 42648.8114342036*x_39 - 109645.351559547*x_4 + 49448.4498195983*x_40 - 9675.10682211523*x_41 + 29834.8694854236*x_42 - 43306.7447243029*x_43 - 24147.4311335257*x_44 - 53557.614309617*x_45 + 30932.2125707015*x_46 - 53448.5546383452*x_47 + 45750.6579568933*x_48 + 13879.3785922624*x_49 + 6741.29280535566*x_5 - 11.7707982883243*x_50 + 53996.5267700151*x_51 + 35301.7270902299*x_52 + 42655.6771699447*x_53 - 114505.702720735*x_54 + 37802.5663577052*x_55 - 46880.9847969696*x_56 + 37202.6084890658*x_57 - 25379.0816136765*x_58 + 35364.2374446101*x_59 - 24357.6621837254*x_6 - 54621.6339471548*x_60 + 62926.4270367808*x_61 - 13384.6564318592*x_62 - 34700.8571994699*x_63 - 77373.0753817348*x_64 - 49464.218729293*x_65 - 63558.3518167529*x_66 - 40867.3798003356*x_67 - 14230.738635726*x_68 - 44521.916330667*x_69 - 28739.1803939701*x_7 + 76291.0725295058*x_70 + 17622.6127942658*x_71 - 96310.1740556893*x_72 - 4.62320078370122*x_73 + 11164.4780203513*x_74 + 6441.53124253913*x_75 + 42757.5797804818*x_76 + 74439.1128540827*x_77 + 78685.8458965912*x_78 + 43050.8582840088*x_79 - 529963.665727722*x_8 + 94.5784331494403*x_80 + 35720.592845791*x_81 + 81338.092118872*x_82 + 11495.7176442973*x_83 - 73675.3603326321*x_84 - 47980.4818474113*x_85 - 81386.8723610867*x_86 - 13949.1962752554*x_87 - 46583.0046995764*x_88 - 97292.9261201172*x_89 + 308531.510912617*x_9 - 177633.469068542*x_90 + 140251.267986467*x_91 + 50620.3776652543*x_92 - 1592926.40384833*x_93 - 35911.4671956196*x_94 - 76037.7858167583*x_95 + 63705.5442111591*x_96 + 76579.7866433292*x_97 - 20483.7930294033*x_98 - 59890.4687646238*x_99 + 0.023657038043058*std::pow(-7.1832799911499*x_110 - 7.79856014251709, 2) + 4.47387194108452e-6*std::pow(-7.43791961669922*x_117 - 7.84168004989624, 2) - 0.153686173599501*std::pow(-6.70688009262085*x_13 - 9.36343955993652, 2) - 5.24583324067917e-5*std::pow(-4.98303985595703*x_13 - 7.76800012588501, 2) - 0.0174114922449454*std::pow(-3.44167971611023*x_14 - 5.26336002349854, 2) + 0.0110578257608632*std::pow(-6.84879970550537*x_15 - 9.66967964172363, 2) + 3.10086202092585e-6*std::pow(-8.80000019073486*x_18 - 9.99954032897949, 2) + 0.000217245772567996*std::pow(-6.13807964324951*x_22 - 8.17304039001465, 2) + 9.58134687291458e-6*std::pow(-5.08871984481812*x_23 - 5.90208005905151, 2) + 0.00268646287325964*std::pow(-8.35967922210693*x_52 - 7.54143953323364, 2) + 0.00980452405880351*std::pow(-5.13479995727539*x_6 - 7.90055990219116, 2) + 0.000506512095138422*std::pow(-6.11504030227661*x_67 - 7.49976015090942, 2) + 0.000942484869003523*std::pow(-7.30751991271973*x_69 - 7.71600008010864, 2) + 0.00477419917363608*std::pow(-8.79600048065186*x_75 - 9.9973201751709, 2) + 0.00510178264895145*std::pow(-2.12663984298706*x_75 - 2.76263999938965, 2) - 0.00779029436115497*std::pow(-7.26159954071045*x_76 - 9.62055969238281, 2) + 0.103047155153354*std::pow(-7.6144003868103*x_83 - 8.61336040496826, 2) - 0.00788259484189275*std::pow(-5.26496028900146*x_87 - 5.67144012451172, 2) + 2.1260172697646*std::exp(0.754719853401184*x_1) + 26.7344790068837*std::exp(0.757199883460999*x_1) + 5307.97566684939*std::exp(0.825519859790802*x_1) + 0.274182080898665*std::exp(0.861039876937866*x_1) - 0.00138010894147139*std::exp(0.9440798163414*x_1) - 9.13199641636926e-6*std::exp(1.0079197883606*x_1) + 0.0133227918728016*std::exp(1.04303979873657*x_1) - 0.0041764750021844*std::exp(1.06415987014771*x_1) + 2.24866902673683*std::exp(1.10735988616943*x_1) - 0.0257167652974368*std::exp(1.13199985027313*x_1) + 2.55808042565882e-5*std::exp(1.1593599319458*x_1) - 0.000347497102426871*std::exp(1.20591986179352*x_1) + 0.0568529623002692*std::exp(1.00127983093262*x_108) - 4.24920753470638*std::exp(1.28079986572266*x_108) - 0.00876791456932454*std::exp(1.56919980049133*x_108) + 0.000210052102410836*std::exp(2.03247976303101*x_108) + 633.084935417713*std::exp(2.7753598690033*x_17) - 0.00483843710075756*std::exp(2.80999994277954*x_17) + 0.00283009393446367*std::exp(2.84888005256653*x_17) + 0.00439608304062515*std::exp(3.49399995803833*x_17) + 0.00963888945334284*std::exp(3.63927984237671*x_17) + 0.000328780279472504*std::exp(3.64759993553162*x_17) - 5.80769723765421e-6*std::exp(3.85743999481201*x_17) - 0.00540222775281366*std::exp(4.2695198059082*x_17) + 5.39510784137554*std::exp(0.929519832134247*x_29) - 0.414777729014793*std::exp(1.05495977401733*x_29) - 1.44899761685802*std::exp(1.27431988716125*x_29) + 0.000185270231870806*std::exp(1.46327984333038*x_29) - 0.0177187025542624*std::exp(1.66111981868744*x_29) + 1.55085461556028*std::exp(1.70815992355347*x_29) - 0.00282691727656327*std::exp(2.27495980262756*x_29) + 1.2176709186053*std::exp(1.40247988700867*x_38) + 6.94486728084133e-5*std::exp(1.75471985340118*x_38) + 0.00475985916055669*std::exp(2.47439980506897*x_38) - 0.062425138871436*std::exp(1.59183979034424*x_50) + 0.000311337886444837*std::exp(1.66439986228943*x_50) - 0.208720667971367*std::exp(1.66527986526489*x_50) - 5.63290339943635*std::exp(1.71759986877441*x_50) - 42977.7857202098*std::exp(1.88511991500854*x_50) - 0.0627022087759935*std::exp(1.92927980422974*x_50) + 0.114675757684547*std::exp(1.93591976165771*x_50) + 0.152749451073752*std::exp(1.9366397857666*x_50) - 78.8034926894867*std::exp(1.95703983306885*x_50) + 0.147698702020374*std::exp(2.02871990203857*x_50) + 0.704885521724464*std::exp(0.751999855041504*x_66) + 1.68608983516094*std::exp(0.740719854831696*x_71) - 0.5346046321414*std::exp(0.757279872894287*x_71) + 10.6231950456109*std::exp(1.08503985404968*x_71) - 0.0768672349133347*std::exp(1.08831977844238*x_71) - 0.000133010521137706*std::exp(1.28671991825104*x_71) + 0.172829614693906*std::exp(1.29703986644745*x_71) + 25.2812760703271*std::exp(1.67023992538452*x_71) - 0.00359569283604504*std::exp(1.67927992343903*x_71) + 0.000960638388299198*std::exp(1.84575986862183*x_71) + 0.748815828995956*std::exp(1.87239992618561*x_71) + 0.00248020397089472*std::exp(1.95615983009338*x_71) - 0.0228553515230854*std::exp(0.985039830207825*x_72) + 88235.6373198323*std::exp(0.735359847545624*x_73) + 0.587424815418674*std::exp(0.856079876422882*x_73) - 0.00457248016791294*std::exp(0.937839806079865*x_76) - 0.723718723804202*std::exp(1.32255983352661*x_76) + 6.20253287626518e-5*std::exp(1.70791983604431*x_76) - 0.0327327839257431*std::exp(2.26183986663818*x_76) - 0.0326154999811566*std::exp(1.01895976066589*x_77) - 1.06187298178691*std::exp(1.48071980476379*x_77) - 0.204773050684853*std::exp(1.26399981975555*x_78) + 0.0550547219133787*std::exp(1.60799980163574*x_78) - 0.373475910031204*std::exp(1.75887989997864*x_78) + 1.50351379442989*std::exp(1.92959976196289*x_78) + 0.346071110896576*std::exp(1.39375984668732*x_81) + 0.114775590981852*std::exp(1.04471981525421*x_87) + 0.740277845308346*std::exp(0.913439810276031*x_88) + 115.316905539705*std::sin(0.371119856834412*x_102 + 8.18839931488037) - 4.68418448200351*std::sin(0.247919961810112*x_104 - 1.35807979106903) - 0.639747918503572*std::sin(0.286159932613373*x_104 - 7.49079990386963) + 0.0178433064792038*std::sin(0.361919850111008*x_105 + 5.16847991943359) - 72.037101031236*std::sin(0.433759868144989*x_105 + 2.01007986068726) - 931.234646905885*std::sin(0.437199860811234*x_105 + 2.02327990531921) - 0.246604466637101*std::sin(0.437999874353409*x_105 + 2.02783989906311) + 34.1980170618342*std::sin(0.467039853334427*x_105 - 7.36383962631226) - 3.09717350625848*std::sin(0.49127984046936*x_105 - 7.34815979003906) + 0.00171946195380761*std::sin(0.5065598487854*x_105 + 2.05463981628418) + 2.4436198779416*std::sin(0.517359852790833*x_109 + 2.1580798625946) - 18.2191808479026*std::sin(0.396799832582474*x_111 - 7.40463972091675) - 29.6855871413303*std::sin(0.186080008745193*x_112 - 7.60784006118774) - 1.14543357353294*std::sin(0.258879989385605*x_112 + 5.0434398651123) - 236244.460544233*std::sin(0.511919856071472*x_115 + 5.26783990859985) + 5.02938118695961*std::sin(0.466559857130051*x_117 - 7.35599946975708) + 76.1751009667688*std::sin(0.433039873838425*x_120 - 1.17831993103027) + 47.6009472374133*std::sin(0.340079843997955*x_14 - 1.2299998998642) + 27.9685620005595*std::sin(0.479199856519699*x_14 - 4.32376003265381) + 0.986889666078236*std::sin(0.410479873418808*x_15 + 5.20991992950439) - 2.3781393052142*std::sin(0.549839854240417*x_15 + 2.14871978759766) + 0.163509316212733*std::sin(0.475679844617844*x_17 - 4.10208034515381) + 0.270003193088879*std::sin(0.441199839115143*x_19 - 1.15015983581543) + 9.43813579251788*std::sin(0.315679848194122*x_21 + 8.31968021392822) + 0.0696795246576081*std::sin(0.457839846611023*x_21 - 1.17007982730865) - 60.4784978582573*std::sin(0.256719976663589*x_26 + 5.04903984069824) - 4.19871891859475*std::sin(0.300159931182861*x_28 + 5.10303974151611) - 136.000342777403*std::sin(0.321759849786758*x_28 + 8.30416011810303) - 5.37721166962929*std::sin(0.32551982998848*x_28 - 4.27016019821167) - 501340.406725727*std::sin(0.338879853487015*x_28 - 4.24847984313965) - 700.101858788712*std::sin(0.342879861593246*x_28 - 4.26847982406616) - 3.27509575591232*std::sin(0.344799846410751*x_28 + 5.13168001174927) + 29.9957437423594*std::sin(0.369919836521149*x_28 - 4.22656011581421) + 16.6980314152516*std::sin(0.36303985118866*x_3 + 5.17160034179688) - 3.31061288869388*std::sin(0.380399852991104*x_34 + 1.99079978466034) - 951.710249849803*std::sin(0.329919844865799*x_36 - 1.23263990879059) + 112.546320160692*std::sin(0.330239832401276*x_36 - 7.44320011138916) - 5.85476331787855*std::sin(0.3503198325634*x_36 + 5.15304040908813) - 0.0268412131018747*std::sin(0.364159852266312*x_36 - 7.42759990692139) - 15.7023052643351*std::sin(0.365519851446152*x_36 + 1.96367979049683) - 4.1823289648552*std::sin(0.3781598508358*x_36 + 8.38055992126465) + 206846.199711129*std::sin(0.42663985490799*x_36 - 4.18807983398438) + 0.00466385825487955*std::sin(0.362399846315384*x_43 - 7.43351984024048) + 0.204162544842858*std::sin(0.452079862356186*x_45 - 7.34592008590698) - 932.48908149835*std::sin(0.34215983748436*x_46 + 8.32800006866455) + 0.288268756093318*std::sin(0.370959848165512*x_46 - 4.22959995269775) + 18.7999888368869*std::sin(0.40287983417511*x_46 - 4.18824005126953) - 24.2341673267103*std::sin(0.407039850950241*x_46 - 7.38815975189209) - 0.356810631880172*std::sin(0.306159913539886*x_47 - 7.47959995269775) + 12.3524459899893*std::sin(0.690959870815277*x_47 + 5.23975992202759) + 6.23883683420076*std::sin(0.403599858283997*x_49 + 5.19695997238159) - 0.103684219246921*std::sin(0.157360032200813*x_53 - 4.46767997741699) - 1735.77809454112*std::sin(0.233919993042946*x_53 - 4.36143970489502) + 174.092766936633*std::sin(0.290159940719604*x_53 + 5.1017599105835) + 0.183093832912961*std::sin(0.44191986322403*x_53 - 7.35687971115112) - 0.0514613918274563*std::sin(0.174800008535385*x_55 - 7.63616037368774) + 2.69751137867665*std::sin(0.417919874191284*x_55 + 5.20223999023438) + 29.0137068214441*std::sin(0.473199844360352*x_55 + 2.05047988891602) - 54.0078564237587*std::sin(0.130960047245026*x_67 - 7.68008041381836) - 2.87574734210926*std::sin(0.179680004715919*x_67 + 1.78391993045807) - 0.0826985180929345*std::sin(0.655519843101501*x_67 + 5.42639970779419) - 0.0596024521358823*std::sin(0.304239928722382*x_68 + 5.14751958847046) + 0.00277094153068334*std::sin(0.352319836616516*x_69 - 4.24432039260864) + 0.00202377595255515*std::sin(0.40735986828804*x_72 + 5.19271993637085) + 9.30800339673522*std::sin(0.241279974579811*x_73 + 1.85223984718323) + 0.718364577590088*std::sin(0.483999848365784*x_73 + 8.48151969909668) - 362.932952534275*std::sin(0.5933598279953*x_73 - 3.99767971038818) + 1.64740690962541*std::sin(0.821039855480194*x_73 - 0.78743988275528) - 181.47957342849*std::sin(0.147360026836395*x_75 + 1.74791991710663) - 1181.07200585047*std::sin(0.311999946832657*x_75 - 7.47160005569458) - 0.298572394234627*std::sin(0.400079846382141*x_75 - 4.18535995483398) + 0.213086646359695*std::sin(0.495359867811203*x_78 - 7.31343984603882) - 15.5578112807261*std::sin(0.183360010385513*x_80 - 4.43607997894287) + 0.682693165969689*std::sin(0.212880000472069*x_80 + 1.8199999332428) + 68.7014780586334*std::sin(0.231199979782104*x_80 + 5.04256010055542) + 1.07541282339397*std::sin(0.251519978046417*x_80 + 1.83783984184265) - 363612.318704637*std::sin(0.323599845170975*x_80 - 1.26775979995728) - 4596.17651301197*std::sin(0.173440024256706*x_85 + 1.78063988685608) - 0.893998701984299*std::sin(0.35999983549118*x_85 - 4.4215202331543) - 0.412762205999963*std::sin(0.33231982588768*x_86 - 4.28263998031616) + 0.382976453349111*std::sin(0.348239839076996*x_92 + 1.99207985401154) - 0.0511066607332339*std::sin(0.352559864521027*x_92 + 2.00831985473633) + 952.946725997023*std::sin(0.364959836006165*x_92 + 1.97991979122162) - 14.9504330164731*std::sin(0.369199842214584*x_92 + 1.98607981204987) + 7.34491163669783*std::sin(0.376879841089249*x_95 + 1.99391984939575) - 2.29702157520941*std::sin(0.135200038552284*x_96 - 7.67199993133545) + 6.21238288729287*std::sin(0.470319867134094*x_96 + 5.2292799949646) + 0.996258590750943*std::sin(0.399999856948853*x_97 + 5.1846399307251) + 0.00217823737388233*std::sin(0.513519823551178*x_98 + 5.15759992599487) + 5.21964320041085*std::sin(0.598479866981506*x_99 + 1.99935972690582) - 6686412.77941088 - 2.62995059334418*std::exp(-2.46007990837097*x_86) - 0.0117324890490323*std::exp(-2.28759980201721*x_86) + 4.32093347835338*std::exp(-2.11679983139038*x_23) - 0.00507157857325741*std::exp(-2.11087989807129*x_23) - 0.213864377140711*std::exp(-2.10407996177673*x_23) + 1.18762852121644*std::exp(-1.98967981338501*x_23));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
