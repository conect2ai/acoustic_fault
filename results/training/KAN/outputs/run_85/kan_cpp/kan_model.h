
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (9.00204132184262e-5*x_1 - 8.94696037402962e-5*x_10 + 0.000864122488242634*x_100 + 0.000973757106122714*x_101 + 0.00137955078763067*x_102 + 2.09215098229049e-5*x_103 - 0.000361201169094633*x_104 - 3.95216349726609e-6*x_105 + 0.000211772793532766*x_106 + 6.29532754357069e-5*x_107 - 0.000867649521987038*x_108 - 0.000629212020504165*x_109 + 0.000417328690466291*x_11 - 0.00136536580648214*x_110 - 3.96696407613578e-5*x_111 - 0.000351008062227911*x_112 - 0.00219624575225451*x_113 + 0.000296951686773543*x_114 + 1.51267581148477e-5*x_115 - 0.000310765313168542*x_116 + 0.00012788928286608*x_117 - 6.01079678833191e-5*x_118 - 0.00172006691688794*x_119 - 6.11871497302041e-5*x_12 + 5.910520453455e-5*x_120 + 0.00173244004402852*x_13 - 3.73107785011911e-5*x_14 + 0.000271403986881074*x_15 + 2.30672917529642e-5*x_16 + 0.00352324463972614*x_17 + 0.000282129656358037*x_18 + 0.000658997607948786*x_19 + 0.00144923158389387*x_2 + 0.000640610092048578*x_20 - 0.00052976732465194*x_21 - 0.00225007475040904*x_22 - 0.000276699533299388*x_23 - 0.000452186426513082*x_24 - 0.000786900065461388*x_25 + 0.000293213837678809*x_26 - 9.99906172680048e-6*x_27 + 9.51401547895138e-5*x_28 - 0.00314851994564726*x_29 + 3.2132213933718e-5*x_3 - 0.00109971367635333*x_30 - 0.0064099925365866*x_31 + 0.000719544279781939*x_32 - 0.00223019366373358*x_33 + 0.000926438528936558*x_34 + 3.41806331934092e-5*x_35 + 0.000445005570530495*x_36 - 0.000824197265290741*x_37 - 0.000338071323197202*x_38 - 0.0011416325518132*x_39 - 0.00290257180168311*x_4 - 0.000873492765458897*x_40 - 3.54311231180532e-5*x_41 - 0.00109700118228354*x_42 - 0.000267321279097111*x_43 + 0.000729182014564106*x_44 + 1.89351546669445e-5*x_45 + 7.28134164783899e-6*x_46 - 0.000338869468917027*x_47 + 0.000108330553660259*x_48 - 0.000487997015170447*x_49 - 0.000120653289359862*x_5 - 5.73367995123085e-5*x_50 - 0.00106298086194795*x_51 - 0.00175381758131944*x_52 - 0.00015748215573425*x_53 - 0.000320542967601218*x_54 - 0.000114685585985729*x_55 + 0.000367390133522678*x_56 - 4.27867018202194e-5*x_57 + 0.00078247325741853*x_58 - 0.000214759899532934*x_59 + 0.000352223859093406*x_6 - 0.000770366388935519*x_60 + 0.00039199295042491*x_61 - 0.00101105876227559*x_62 - 2.15389613647266e-5*x_63 - 0.000182962189340971*x_64 + 8.05331761280759e-5*x_65 - 0.000576183796170541*x_66 - 0.000534560585824536*x_67 - 0.000508204829554936*x_68 - 0.000211491002755276*x_69 - 0.00114516300688489*x_7 - 0.000547541116152808*x_70 - 0.000423487664581359*x_71 + 0.00124743926635418*x_72 - 0.00182131452952786*x_73 + 0.000693680451508147*x_74 + 0.00108483997831081*x_75 + 0.00170525235951311*x_76 + 0.0008226132084496*x_77 - 0.00124656638532652*x_78 - 0.000202184347017346*x_79 - 0.000615012141183695*x_8 - 1.55578553067625e-5*x_80 + 0.00070937634675471*x_81 - 0.000195539588561998*x_82 - 0.00158277422475368*x_83 - 9.49272367388498e-5*x_84 - 8.86188179005199e-5*x_85 + 0.000210478851946067*x_86 + 0.000207096053256191*x_87 + 0.000269671007425028*x_88 + 0.000358536583859948*x_89 + 0.000289881625441491*x_9 + 0.000224210925280176*x_90 - 0.0237899320003395*x_91 + 0.000128361902183378*x_92 - 0.0021761473844427*x_93 + 1.59169425146709e-5*x_94 + 0.000281950665419443*x_95 - 0.000555217785108649*x_96 + 0.000722154770376785*x_97 + 0.000246638937290442*x_98 - 8.73531267358983e-5*x_99 + 9.65833402052338e-5*std::pow(-5.50903987884521*x_13 - 8.56120014190674, 2) - 2.40973143156702e-6*std::pow(-5.40360021591187*x_14 - 8.1974401473999, 2) + 1.88849599938952e-5*std::pow(-5.1081600189209*x_14 - 7.96799993515015, 2) + 0.000118004320346241*std::pow(-4.90744018554688*x_14 - 7.37560033798218, 2) - 2.24575529610498e-5*std::pow(-5.78351974487305*x_15 - 7.58104038238525, 2) + 7.91612688687367e-5*std::pow(-5.33127975463867*x_15 - 7.50687980651855, 2) + 3.677641110367e-7*std::pow(-5.31104040145874*x_15 - 7.75784015655518, 2) + 6.72284503820643e-6*std::pow(-3.07200002670288*x_15 - 4.79999971389771, 2) + 4.53401100680241e-5*std::pow(-5.25880002975464*x_17 - 7.69080018997192, 2) + 6.79869629186162e-5*std::pow(-4.46319961547852*x_17 - 6.49072027206421, 2) - 7.06150609154399e-5*std::pow(-2.07751989364624*x_17 - 2.91079998016357, 2) + 7.4222608427694e-7*std::pow(-6.5796799659729*x_18 - 9.78975963592529, 2) - 9.52459343111756e-7*std::pow(-6.57512044906616*x_18 - 9.37152004241943, 2) + 6.00839198020374e-5*std::pow(-5.29320001602173*x_18 - 8.33983993530273, 2) + 5.38872966171075e-6*std::pow(-4.91903972625732*x_18 - 9.68000030517578, 2) + 9.80143748202216e-6*std::pow(-3.24055981636047*x_2 - 5.87591981887817, 2) - 3.25767068256302e-6*std::pow(-3.23535990715027*x_2 - 5.85767984390259, 2) + 2.00569351980519e-5*std::pow(-5.72215986251831*x_22 - 9.58920001983643, 2) - 2.06949826317009e-5*std::pow(-4.69063997268677*x_22 - 7.54383945465088, 2) + 0.000114510259175738*std::pow(-3.50623989105225*x_22 - 5.77040004730225, 2) + 2.43514835275889e-5*std::pow(-1.23087990283966*x_23 - 1.85415983200073, 2) + 7.32007620310636e-7*std::pow(-6.60400009155273*x_27 - 9.9750394821167, 2) + 6.42699642191592e-5*std::pow(-5.82399988174438*x_4 - 9.65783977508545, 2) + 4.44010798211139e-7*std::pow(-3.396399974823*x_4 - 5.59624004364014, 2) - 6.15634835693481e-6*std::pow(-6.40000009536743*x_5 - 9.99995994567871, 2) - 1.01269076490861e-6*std::pow(-6.19999980926514*x_5 - 9.99948024749756, 2) + 1.08175918493565e-6*std::pow(-5.87680006027222*x_5 - 9.11728000640869, 2) - 2.27606664097844e-6*std::pow(-4.81839990615845*x_5 - 7.81911993026733, 2) - 5.01940003668875e-8*std::pow(-3.91319990158081*x_5 - 6.38520002365112, 2) - 0.00135549825831217*std::pow(-1.71423983573914*x_5 - 2.66727995872498, 2) + 7.15811167955504e-5*std::pow(-3.50671982765198*x_6 - 5.57079982757568, 2) + 2.83253038883279e-6*std::pow(-5.26424026489258*x_67 - 8.09687995910645, 2) - 7.96798005389334e-6*std::pow(-4.71519947052002*x_67 - 8.39935970306396, 2) - 9.58075514875701e-7*std::pow(-6.60000038146973*x_68 - 9.96571922302246, 2) + 0.000106024327240149*std::pow(-5.98231983184814*x_7 - 9.59111976623535, 2) - 3.66345487591032e-7*std::pow(-5.28568029403687*x_7 - 8.53200054168701, 2) + 3.73587073707752e-5*std::pow(-5.20592021942139*x_7 - 8.61111927032471, 2) + 7.27921252951943e-7*std::pow(-4.92143964767456*x_7 - 8.06775951385498, 2) - 2.7749925226907e-8*std::pow(-4.3101601600647*x_71 - 6.57128000259399, 2) - 7.75993996045678e-7*std::pow(-4.37599992752075*x_72 - 6.1669602394104, 2) + 2.49428700910524e-6*std::pow(-3.8711199760437*x_72 - 5.22455978393555, 2) - 1.33313845279056e-8*std::pow(-6.0*x_77 - 9.99911975860596, 2) - 7.60482571035198e-6*std::pow(-7.76000022888184*x_80 - 9.79903984069824, 2) - 3.10750554831361e-6*std::pow(-4.18959999084473*x_80 - 6.58544015884399, 2) - 1.40609319487067e-8*std::pow(-9.97459983825684*x_81 - 6.60400009155273, 2) - 5.20888907406134e-7*std::pow(-7.59576034545898*x_81 - 8.78192043304443, 2) - 5.12458363121061e-9*std::pow(-5.0*x_81 - 9.99964046478271, 2) + 1.99896522065173e-5*std::pow(-7.46039962768555*x_82 - 9.46856021881104, 2) - 7.78546587676368e-7*std::pow(-5.52776002883911*x_85 - 7.56920003890991, 2) + 4.45039689042361e-7*std::pow(-5.29983949661255*x_85 - 7.26336002349854, 2) - 3.28722048691129e-6*std::pow(-4.47440004348755*x_85 - 8.12800025939941, 2) - 9.34955320985348e-7*std::pow(-6.60000038146973*x_88 - 9.99792003631592, 2) - 1.47610708265868e-5*std::pow(-6.29087972640991*x_88 - 8.66224002838135, 2) + 2.8377027669341e-5*std::pow(-5.65199995040894*x_88 - 7.40236043930054, 2) - 1.62577742384089e-5*std::pow(-6.20728015899658*x_90 - 8.81319999694824, 2) + 8.57710906650747e-5*std::exp(0.868719875812531*x_27) + 0.000115084942370104*std::exp(0.473039865493774*x_71) - 0.00119079470708863*std::exp(0.530879855155945*x_71) + 0.00704398597786682*std::sin(0.228959992527962*x_1 + 5.01823997497559) - 9.36457450310253e-5*std::sin(0.236639991402626*x_1 + 1.97687971591949) - 0.0114128372846713*std::sin(0.276399940252304*x_1 - 1.18871986865997) + 0.0078731562784006*std::sin(0.285039931535721*x_1 + 1.9968798160553) + 0.0463057605892423*std::sin(0.297599911689758*x_1 + 1.98135983943939) - 0.127959340789067*std::sin(0.302639931440353*x_1 - 7.43455982208252) + 0.00754232823206011*std::sin(0.311999946832657*x_1 - 7.43711996078491) - 0.001458125929403*std::sin(0.269119948148727*x_10 - 4.30751943588257) + 0.18044795172737*std::sin(0.285759955644608*x_10 + 5.09208011627197) - 7.35165270272282e-5*std::sin(0.294239938259125*x_10 + 5.10759973526001) - 0.00800896197076965*std::sin(0.323919832706451*x_10 - 4.27239990234375) + 3.35349094426724e-5*std::sin(0.368399828672409*x_101 + 8.18271923065186) + 2.09254184340939e-5*std::sin(0.282879948616028*x_102 - 4.32231998443604) - 0.00143385224465243*std::sin(0.383199840784073*x_102 + 5.18440008163452) - 0.00560803643688787*std::sin(0.385439842939377*x_102 + 1.96247982978821) + 0.00498267969998147*std::sin(0.306239932775497*x_103 - 4.27127981185913) - 0.00361740722363609*std::sin(0.361359834671021*x_103 + 1.97855985164642) - 0.000798841980617774*std::sin(0.365279853343964*x_103 - 7.4171199798584) + 0.0258628154357232*std::sin(0.321119844913483*x_105 - 4.27928018569946) + 0.00018483890731398*std::sin(0.393999844789505*x_105 - 4.1908802986145) - 0.00303158177472366*std::sin(0.241679981350899*x_106 + 5.03127956390381) - 0.0177120712069284*std::sin(0.263999968767166*x_106 + 5.06047964096069) - 0.000104496453997972*std::sin(0.353919863700867*x_106 - 7.43991994857788) + 0.00271660090525771*std::sin(0.373599827289581*x_106 - 7.40431976318359) - 0.000353275594799376*std::sin(0.374559849500656*x_106 - 7.4235200881958) - 6.93752604440818e-6*std::sin(0.485679864883423*x_106 + 5.2596001625061) + 0.000756612998228648*std::sin(0.539679825305939*x_106 - 7.21880006790161) - 1.32944329075437e-5*std::sin(0.337519854307175*x_107 - 7.45607995986938) + 0.000574917185599363*std::sin(0.345039844512939*x_107 - 4.25472021102905) - 1.77679303510454e-5*std::sin(0.499759823083878*x_108 + 5.28000020980835) + 0.00708233556448252*std::sin(0.333519846200943*x_109 - 7.4410400390625) + 8.69048897060851e-6*std::sin(0.40311986207962*x_109 + 1.98511981964111) + 0.00038677144300198*std::sin(0.471919864416122*x_109 + 2.02095985412598) - 0.0189366508810156*std::sin(0.269839972257614*x_11 + 8.28728008270264) + 0.00864548911034366*std::sin(0.289919942617416*x_11 + 8.31727981567383) - 0.0127106858308036*std::sin(0.294399946928024*x_11 + 8.31807994842529) + 0.00683748588378747*std::sin(0.41567987203598*x_110 + 5.20975971221924) + 0.00848708278274416*std::sin(0.308079928159714*x_111 + 5.13520002365112) - 6.18038937813271e-5*std::sin(0.55351984500885*x_111 - 7.41264009475708) - 0.000602308464442201*std::sin(0.241919979453087*x_112 - 1.15607988834381) - 2.14525591253089e-5*std::sin(0.357759833335876*x_112 + 5.15887975692749) - 0.000176903053353073*std::sin(0.437519878149033*x_112 + 8.21895980834961) - 0.000546240735405346*std::sin(0.437919855117798*x_113 - 1.18151986598969) - 0.00992836095173748*std::sin(0.347919851541519*x_114 + 8.33896064758301) - 0.020883965903325*std::sin(0.362399846315384*x_114 - 7.42384004592896) - 0.000264351170965722*std::sin(0.386159837245941*x_114 - 7.42127990722656) - 6.41027963253871e-6*std::sin(0.481919854879379*x_114 - 1.14231991767883) - 0.000688222295867898*std::sin(0.294959932565689*x_115 + 8.33543968200684) - 0.0022850401828439*std::sin(0.396719843149185*x_115 - 7.40727996826172) - 1.21373748878208e-5*std::sin(0.404239863157272*x_115 + 5.19208002090454) + 0.000603936110532565*std::sin(0.521999835968018*x_115 + 8.35608005523682) - 0.000215926506040222*std::sin(0.53415983915329*x_115 - 4.23967981338501) - 0.00126176230485978*std::sin(0.638719856739044*x_115 - 4.17447996139526) - 0.00147687484493257*std::sin(0.257519960403442*x_117 - 4.34143972396851) - 0.00465508327128854*std::sin(0.393999844789505*x_117 + 5.18584012985229) + 5.3862440322181e-5*std::sin(0.438319861888885*x_117 - 4.16440010070801) - 0.000420690844620232*std::sin(0.370799839496613*x_118 - 7.40967988967896) + 0.00809722591360712*std::sin(0.390239834785461*x_118 + 5.17920017242432) - 9.072014138159e-5*std::sin(0.392959833145142*x_118 - 7.40463972091675) + 1.78303486335181e-5*std::sin(0.393359839916229*x_118 + 5.19456005096436) + 0.00730549251191138*std::sin(0.328399837017059*x_119 - 4.2469596862793) - 1.85174440016112e-5*std::sin(0.343999862670898*x_119 - 7.43631982803345) - 0.00173240143551376*std::sin(0.415999859571457*x_119 - 1.17535984516144) - 0.000191438998570233*std::sin(0.421519845724106*x_119 + 1.98623979091644) - 0.000644622034637517*std::sin(0.433919847011566*x_119 - 1.15335988998413) + 0.0413723412308197*std::sin(0.341599822044373*x_12 - 4.25816011428833) + 0.00435232205405671*std::sin(0.392639845609665*x_12 + 5.19840002059937) + 0.0130819363264071*std::sin(0.300879925489426*x_120 + 1.90599989891052) + 0.000975722857084021*std::sin(0.331999838352203*x_120 - 1.06463980674744) - 0.00790144929349974*std::sin(0.460639864206314*x_120 + 2.05159974098206) - 0.000705813047014401*std::sin(0.117440059781075*x_14 - 4.53320026397705) - 0.152705990372335*std::sin(0.12216005474329*x_14 - 4.52631998062134) - 0.000814532403690993*std::sin(0.250799983739853*x_14 - 4.31239986419678) + 0.00841984075682612*std::sin(0.142320036888123*x_15 - 4.48423957824707) - 0.0142178670192589*std::sin(0.333919852972031*x_16 - 4.24720001220703) + 0.0868932919367132*std::sin(0.359999865293503*x_16 + 5.17304039001465) - 4.8122926811076e-5*std::sin(0.363919854164124*x_16 - 4.24200010299683) + 0.0018307342991976*std::sin(0.388799846172333*x_16 - 1.18391978740692) + 0.00334083911811419*std::sin(0.401599854230881*x_16 + 5.20815992355347) + 4.96142661710177e-5*std::sin(1.23015987873077*x_17 + 5.81080007553101) + 0.00568532656089828*std::sin(0.222159996628761*x_18 - 4.37863969802856) - 0.000172678659988698*std::sin(0.159040033817291*x_19 - 4.45383977890015) - 0.0150583862828459*std::sin(0.326479852199554*x_21 - 4.25343990325928) + 0.00043060305927107*std::sin(0.335279852151871*x_21 + 5.160560131073) + 0.0026428965521497*std::sin(0.153520032763481*x_23 - 7.64976024627686) + 0.0591189687517718*std::sin(0.191040009260178*x_23 + 4.99199962615967) + 0.0889436442562286*std::sin(0.205360010266304*x_23 + 5.00831985473633) + 8.46771157925073e-5*std::sin(0.245599970221519*x_23 + 5.0688796043396) - 0.0222607228474879*std::sin(0.326639831066132*x_24 - 4.2720799446106) + 0.000947419185588062*std::sin(0.358239859342575*x_24 + 8.34879970550537) + 0.102244907268588*std::sin(0.311839938163757*x_26 - 4.27183961868286) + 1.66202403933952e-5*std::sin(0.312079936265945*x_26 - 4.2720799446106) + 0.013395905915931*std::sin(0.346559852361679*x_26 - 4.25408029556274) + 0.0556300743820895*std::sin(0.181520000100136*x_27 - 7.61520004272461) + 0.0329139229074603*std::sin(0.222159996628761*x_27 + 5.0272798538208) - 0.105613475341654*std::sin(0.22919999063015*x_27 - 7.55919981002808) + 0.00232766379313399*std::sin(0.250079959630966*x_27 - 7.52135992050171) + 0.000453498247530311*std::sin(0.293599933385849*x_27 + 8.32111930847168) - 8.90790868161303e-5*std::sin(0.301199913024902*x_27 + 5.11639976501465) + 0.0130692150247146*std::sin(0.225199982523918*x_28 - 4.36520004272461) + 0.00091270273558826*std::sin(0.279359966516495*x_28 + 5.0991997718811) + 0.00215258073829805*std::sin(0.327599853277206*x_28 - 4.27360010147095) + 0.00117837674302653*std::sin(0.475359857082367*x_28 + 5.25095987319946) - 0.0136943103634842*std::sin(0.285999953746796*x_3 + 8.2903995513916) + 0.0243422592896*std::sin(0.300399929285049*x_3 - 4.27288007736206) - 0.027771414962835*std::sin(0.316799849271774*x_3 + 8.31775951385498) + 0.0449218509158959*std::sin(0.321359843015671*x_3 + 8.31960010528564) - 0.000197451770195852*std::sin(0.321439832448959*x_3 + 8.32264041900635) + 0.000587771967002994*std::sin(0.368239849805832*x_3 - 1.03407979011536) - 0.00776922734352272*std::sin(0.274559944868088*x_30 + 8.28799915313721) + 0.00317034651139942*std::sin(0.275599956512451*x_30 + 8.26799964904785) - 0.000644251408773105*std::sin(0.170720010995865*x_31 + 8.43936061859131) - 0.0842297727336703*std::sin(0.270079970359802*x_32 - 7.44039964675903) + 0.00432739667995816*std::sin(0.273199945688248*x_32 + 1.97919988632202) - 0.000271599035675374*std::sin(0.337679862976074*x_34 + 5.20703983306885) - 0.000404184963540242*std::sin(0.379599839448929*x_34 + 1.97711980342865) + 0.00677823605289328*std::sin(0.303839921951294*x_35 - 1.11191987991333) + 1.73309054070221e-5*std::sin(0.340079843997955*x_35 - 1.19399988651276) + 0.000198656809478285*std::sin(0.322799831628799*x_36 - 4.26735973358154) + 7.37560379736666e-5*std::sin(0.338079839944839*x_36 - 7.43224000930786) + 1.86739630939082e-5*std::sin(0.350559860467911*x_36 + 8.34632015228271) + 0.00103815618633477*std::sin(0.357679843902588*x_36 - 4.24528026580811) + 0.0181510566317394*std::sin(0.364799857139587*x_36 - 4.22959995269775) + 0.00837150710321592*std::sin(0.2360799908638*x_37 - 4.35727977752686) + 0.00693586963527212*std::sin(0.362399846315384*x_37 + 5.16695976257324) + 8.44969713192853e-5*std::sin(0.388159841299057*x_37 - 4.19992017745972) - 0.000254884891371311*std::sin(0.433199852705002*x_38 + 5.23192024230957) + 0.00274842414951384*std::sin(0.451359868049622*x_38 + 8.44312000274658) - 0.00126881434330408*std::sin(0.345439851284027*x_39 + 1.95567977428436) + 0.000793045553001364*std::sin(0.308479934930801*x_41 - 4.28967952728271) - 0.000741357947520179*std::sin(0.319679856300354*x_42 - 4.26688003540039) - 0.000938384882964324*std::sin(0.369279831647873*x_43 + 5.17000007629395) + 0.000597373389969263*std::sin(0.404799848794937*x_43 + 5.19200038909912) + 0.000126556056393655*std::sin(0.420399844646454*x_43 + 5.20608043670654) + 0.000391370983454847*std::sin(0.331839829683304*x_45 - 4.27144002914429) + 0.00908048904682529*std::sin(0.352159857749939*x_45 + 5.16239976882935) - 0.0139521892020772*std::sin(0.355999857187271*x_45 - 7.44447994232178) + 0.00053926246252359*std::sin(0.363999843597412*x_45 - 4.23320007324219) - 0.000154049245711098*std::sin(0.365999847650528*x_45 - 4.23720026016235) - 0.00155099166805448*std::sin(0.288639932870865*x_46 + 5.12536001205444) + 0.00186716522885299*std::sin(0.30927985906601*x_46 - 7.48751974105835) - 0.00781904539433225*std::sin(0.32847985625267*x_46 - 7.45831966400146) + 0.0166402091064018*std::sin(0.334399849176407*x_46 - 4.27008008956909) + 0.00197616096536833*std::sin(0.337759852409363*x_46 + 5.14007997512817) + 4.66688018577202e-5*std::sin(0.416399866342545*x_46 - 7.3724799156189) - 0.000239711418928268*std::sin(0.454959839582443*x_46 + 5.23360013961792) + 0.0208895484305679*std::sin(0.211119994521141*x_47 + 8.22288036346436) + 0.000121250518076951*std::sin(0.451359868049622*x_47 + 2.03895974159241) + 0.00087596948127459*std::sin(0.536159813404083*x_47 - 4.23135995864868) - 0.00197560355302284*std::sin(0.416239857673645*x_48 + 5.21384000778198) + 0.00279003417642521*std::sin(0.500239849090576*x_48 + 2.05039978027344) - 3.48969066144531e-6*std::sin(0.591679811477661*x_48 + 5.18351984024048) + 0.00718035532226612*std::sin(0.348399847745895*x_49 + 5.13439989089966) + 0.000730637789515822*std::sin(0.411999881267548*x_49 + 2.01895976066589) + 0.0289847766682213*std::sin(0.180480018258095*x_50 - 4.43503999710083) + 0.000435945304451786*std::sin(0.459599852561951*x_50 - 7.339439868927) + 0.00800831040082662*std::sin(0.282959938049316*x_51 + 5.10951995849609) + 0.00112320609278562*std::sin(0.322239845991135*x_51 + 5.13632011413574) - 0.000435056213285304*std::sin(0.339839845895767*x_53 + 5.13575983047485) - 0.000745228589553873*std::sin(0.435999870300293*x_53 + 8.42735958099365) - 0.029924150307184*std::sin(0.193519994616508*x_54 - 4.41111993789673) + 7.6812489810437e-5*std::sin(0.465039849281311*x_54 + 8.46759986877441) - 0.00294142343309298*std::sin(0.210319995880127*x_55 - 4.39687967300415) + 0.00584358533546586*std::sin(0.265359967947006*x_55 - 4.29959964752197) + 5.83161898752116e-5*std::sin(0.346879839897156*x_55 - 4.23952007293701) + 1.06584627930027e-5*std::sin(0.349599838256836*x_55 + 1.96415984630585) - 0.00368223001521675*std::sin(0.289999932050705*x_56 - 4.28191947937012) + 0.000157494218605455*std::sin(0.282079964876175*x_57 - 4.2885594367981) - 0.00255141695635466*std::sin(0.197759985923767*x_58 + 4.99087953567505) - 0.000320587411115697*std::sin(0.366159826517105*x_58 + 5.17632007598877) + 8.66671663770529e-6*std::sin(0.38239985704422*x_58 + 5.19072008132935) + 0.00626217023188282*std::sin(0.435119867324829*x_58 + 5.24216032028198) + 4.53743578778116e-5*std::sin(0.467359870672226*x_58 + 2.0590398311615) + 0.00764521437254966*std::sin(0.329519838094711*x_59 - 4.26416015625) + 0.000180355752564501*std::sin(0.331599831581116*x_59 - 7.44951963424683) + 0.000137653668543828*std::sin(0.350239843130112*x_59 + 5.14416027069092) - 0.0180855522608295*std::sin(0.384639829397202*x_59 + 5.174880027771) + 0.000541269774360846*std::sin(0.41007986664772*x_59 - 4.20344018936157) - 9.11679808925721e-5*std::sin(0.562719821929932*x_59 - 4.22799968719482) + 0.00121115696628093*std::sin(0.319439828395844*x_60 - 4.28592014312744) + 0.00873056022683361*std::sin(0.355039834976196*x_60 + 5.15856027603149) + 3.41614625648753e-5*std::sin(0.236559987068176*x_64 + 5.06039953231812) + 0.00101539714882453*std::sin(0.264559954404831*x_64 + 5.08464002609253) - 0.000262827563437754*std::sin(0.280799955129623*x_65 + 8.31047916412354) - 0.000903693143950775*std::sin(0.343039840459824*x_65 + 5.14752006530762) + 5.83227682858147e-5*std::sin(0.302559942007065*x_66 - 7.21759986877441) - 0.000245609722041828*std::sin(0.358399838209152*x_66 + 8.3439998626709) - 0.00942998224436942*std::sin(0.378879845142365*x_66 + 5.16160011291504) - 0.0081079233334574*std::sin(0.237599983811378*x_67 + 5.032639503479) + 3.54224635159905e-5*std::sin(0.274799972772598*x_67 + 5.09183979034424) - 0.000313092598937759*std::sin(0.333919852972031*x_67 - 4.28336000442505) - 8.2870951245598e-5*std::sin(0.367839843034744*x_67 - 7.41863965988159) + 0.0213930260329837*std::sin(0.325999826192856*x_68 - 4.26984024047852) + 2.76301078678757e-5*std::sin(0.193519994616508*x_69 + 4.98655986785889) + 0.0228591725714811*std::sin(0.258639961481094*x_69 + 5.07599973678589) + 0.000100221984167439*std::sin(0.356879830360413*x_69 + 8.36288070678711) + 0.00568194635778315*std::sin(0.20728000998497*x_70 + 5.01175975799561) - 1.39059656162481e-5*std::sin(0.313279926776886*x_70 + 1.92271995544434) - 0.000536040751692085*std::sin(0.537359833717346*x_71 + 5.15304040908813) + 0.00189942543908354*std::sin(0.239039987325668*x_73 + 5.04247999191284) - 0.00166410665115371*std::sin(0.165840014815331*x_74 - 1.26447987556458) - 0.00252140694411899*std::sin(0.365199834108353*x_74 - 4.24535989761353) + 0.00601662204068856*std::sin(0.321599841117859*x_75 + 5.1287202835083) + 0.000543954251360719*std::sin(0.352319836616516*x_75 - 4.25432014465332) - 0.000401837263555783*std::sin(0.178240016102791*x_76 + 4.96903991699219) - 0.000162298203248457*std::sin(0.264239966869354*x_77 - 7.53952026367188) - 6.28715964780015e-5*std::sin(0.234319984912872*x_78 + 5.03319978713989) + 0.0191220480461081*std::sin(0.194319993257523*x_79 + 8.17903900146484) - 0.000115272068877128*std::sin(0.211119994521141*x_79 - 7.58400011062622) + 1.09246721146929e-5*std::sin(0.289679944515228*x_79 - 4.26887989044189) + 0.000296600532614878*std::sin(0.316639840602875*x_79 - 4.29895973205566) - 0.000370957107629405*std::sin(0.317599833011627*x_79 - 7.47359991073608) - 0.00249377915434357*std::sin(0.32711985707283*x_79 + 8.31087970733643) - 0.00480657722276896*std::sin(0.376959830522537*x_79 - 4.22320032119751) + 0.00294004536452664*std::sin(0.204960003495216*x_8 + 8.20911979675293) - 0.0348642699718633*std::sin(0.2291199862957*x_8 + 8.25759983062744) + 0.00190487417229308*std::sin(0.305919945240021*x_8 + 5.13575983047485) - 4.01005836516554e-5*std::sin(0.467999875545502*x_80 - 4.13312005996704) + 3.5995994026372e-6*std::sin(0.496479868888855*x_80 - 4.09999990463257) - 3.82602156034864e-5*std::sin(1.71655988693237*x_80 - 1.58871984481812) + 0.00213497565618646*std::sin(0.180960014462471*x_84 - 4.41928005218506) + 0.000265785288339752*std::sin(0.225439995527267*x_84 + 8.22103977203369) - 0.00142963895138261*std::sin(0.464079856872559*x_84 - 1.13943982124329) - 4.43144158196226e-7*std::sin(1.40207982063293*x_84 - 4.79184007644653) + 0.000384777596866224*std::sin(1.99599981307983*x_84 - 4.20552015304565) - 0.0637058177261832*std::sin(0.148400038480759*x_85 - 7.67167997360229) - 0.0105802668328634*std::sin(0.292079925537109*x_85 + 5.12319993972778) + 0.00275710494374112*std::sin(0.257279992103577*x_86 + 1.86807990074158) - 0.00111055111735837*std::sin(0.549119889736176*x_86 + 8.37264060974121) - 0.00360909311574329*std::sin(0.162640020251274*x_87 + 4.94559955596924) + 0.00128117709728517*std::sin(0.174160018563271*x_87 - 7.61856031417847) - 0.0106691808241767*std::sin(0.217519983649254*x_87 + 5.00527954101563) - 0.000993128187367413*std::sin(0.306719928979874*x_89 + 5.14775991439819) - 0.00075888675210434*std::sin(0.214959993958473*x_9 + 5.03159952163696) + 0.0107191415430772*std::sin(0.215039998292923*x_9 - 4.37368011474609) - 0.00361323366841296*std::sin(0.22511999309063*x_9 - 4.36303997039795) - 0.00013222000926288*std::sin(0.240799978375435*x_9 - 4.34663963317871) - 0.000169282361047298*std::sin(0.273439943790436*x_9 - 4.31191968917847) + 0.00169380917577443*std::sin(0.186160013079643*x_91 - 7.37151956558228) + 0.00659697863429627*std::sin(0.189440011978149*x_91 + 2.01639986038208) - 0.00110194515236764*std::sin(0.20040000975132*x_91 + 2.00647974014282) + 0.000561725789270608*std::sin(0.34759983420372*x_92 + 5.18064022064209) + 0.00153345300470295*std::sin(0.351359844207764*x_92 - 7.38607978820801) + 0.00244688365018708*std::sin(0.361999839544296*x_92 + 2.00455975532532) - 0.0427250134181034*std::sin(0.365679860115051*x_92 + 1.99591982364655) + 0.143936913330756*std::sin(0.366239845752716*x_92 + 1.99783980846405) - 0.00112869853792486*std::sin(0.399119853973389*x_92 - 4.40703964233398) - 0.00284061025418593*std::sin(0.404639840126038*x_92 + 2.00263977050781) + 0.00290308897369843*std::sin(0.296879917383194*x_94 - 1.11263990402222) - 7.36223284873238e-6*std::sin(0.375759840011597*x_94 + 5.18688011169434) - 0.00302897526083459*std::sin(0.386319845914841*x_94 + 1.98831987380981) - 0.00745525355638525*std::sin(0.412479877471924*x_94 + 5.20128011703491) + 0.00602102554969009*std::sin(0.358399868011475*x_95 - 4.21600008010864) + 5.76974308147739e-5*std::sin(0.374239832162857*x_95 + 1.98471975326538) - 0.000638216250324052*std::sin(0.386959850788116*x_95 - 7.40423965454102) - 8.14823291931993e-6*std::sin(0.369519859552383*x_96 - 7.43304014205933) - 0.00576098384392494*std::sin(0.374959826469421*x_96 - 7.40423965454102) + 0.00294030909158884*std::sin(0.391199827194214*x_96 + 5.18480014801025) + 0.00739661874462227*std::sin(0.33927983045578*x_97 - 4.25487995147705) - 9.20679497818717e-6*std::sin(0.408799856901169*x_97 - 4.18495988845825) - 0.00410490821834398*std::sin(0.529279828071594*x_97 - 4.23943996429443) - 8.22781492051201e-5*std::sin(0.283199936151505*x_98 + 5.1069598197937) + 0.00271478313877136*std::sin(0.345519840717316*x_98 - 4.25439977645874) + 0.000938939935393026*std::sin(0.360719859600067*x_98 - 4.22751998901367) + 0.000321400858224343*std::sin(0.361119836568832*x_98 + 5.15664005279541) - 0.00169687541055412*std::sin(0.382719844579697*x_98 + 5.17623996734619) + 7.60615060006231e-6*std::sin(0.386799842119217*x_98 - 7.39551973342896) + 0.00183042872172599*std::sin(0.391679853200912*x_99 - 7.39479970932007) + 9.25376040298671e-5*std::sin(0.398319840431213*x_99 - 4.20351982116699) + 0.00161858171508464*std::sin(0.476239860057831*x_99 - 1.14175987243652) - 0.0146249290555716*std::sin(0.123374175949329*x_1 - 0.00405954511978*x_100 - 0.0146670659278114*x_101 - 0.00965382474999966*x_102 + 0.0596133886165013*x_103 - 0.0133964169900939*x_104 + 0.0194061669612204*x_105 - 0.0453330259260933*x_107 + 0.0449038950263289*x_108 - 0.0216957947991418*x_109 + 0.00938149274470547*x_11 + 0.00157341277014531*x_110 + 0.00973239116551281*x_112 + 0.00361151245118585*x_113 - 0.0163014082961958*x_114 - 0.0198228949261435*x_116 + 0.0343709275120299*x_12 + 0.0366628917941598*x_120 + 0.0161246361737888*x_14 + 0.0284857557464947*x_15 + 0.0235378876870967*x_16 + 0.00776899263327535*x_19 - 0.457051656471762*x_2 - 0.00823051357870079*x_20 - 0.00303798972318253*x_25 - 0.0908755371592691*x_26 - 0.00125997224862891*x_29 - 0.00137232211137161*x_30 + 0.0698770068157206*x_31 + 0.0249546000496885*x_32 - 0.00902684185416176*x_33 + 0.0637950712030696*x_34 - 0.0183470589750851*x_35 + 0.027989842002574*x_37 - 0.0258739619683495*x_38 + 0.00663156127802828*x_39 - 0.00327617455206049*x_4 - 0.0358497406045805*x_40 - 0.0211941108299521*x_41 - 0.0142028589031818*x_42 + 0.00569547635788165*x_43 - 0.0306378557214006*x_44 + 0.00351441814489652*x_45 - 0.00923660219861717*x_46 + 0.00157361031708036*x_48 - 0.00958358514240453*x_49 - 0.00137149654141647*x_5 + 0.00406557858970604*x_50 + 0.00496854062155271*x_51 + 0.0010862517039722*x_52 - 0.00267841447041519*x_53 + 0.0367523397667068*x_54 + 0.0157573245851812*x_56 + 0.0189794052183432*x_57 + 0.0216648035839286*x_58 - 0.0130574508154652*x_60 + 0.0016091035794583*x_61 + 0.0235639369590616*x_62 + 0.0271542557556309*x_63 - 0.0258101626065085*x_64 + 0.0174401811607713*x_65 - 0.00712713615028551*x_68 + 0.00396750815971777*x_69 + 0.0108417591065764*x_70 + 0.0243131382932737*x_71 - 0.0528690583721135*x_72 - 0.0241236617221621*x_73 - 0.022835855712659*x_74 - 0.0324505144232634*x_75 + 0.00966934594222485*x_76 - 0.00496056908625695*x_77 - 0.0131709083598453*x_78 + 0.0150544255140561*x_8 - 0.00177489392848148*x_80 - 0.0692148549213733*x_81 + 0.0192106658030633*x_82 - 0.00184106632401984*x_83 + 0.0078830339828902*x_84 + 0.0126594461551413*x_85 - 0.017779248870581*x_86 - 0.00286688720024562*x_87 + 0.00166937292146218*x_88 + 0.160008791190645*x_9 + 0.0159496196877851*x_90 + 0.108787265906499*x_91 + 0.0459276198809402*x_92 + 0.0304995510457773*x_93 - 0.00385772751760009*x_94 + 0.0335514710961801*x_96 + 0.0420996277953335*x_97 + 0.000996900480659747*x_98 + 0.017054860370857*x_99 - 0.000954910198046943*std::pow(-5.64527988433838*x_22 - 9.06455993652344, 2) - 0.000366727779793088*std::pow(-6.78079986572266*x_27 - 9.1778392791748, 2) + 0.0103229002119347*std::pow(-5.514479637146*x_6 - 8.792799949646, 2) + 0.000441216887828486*std::pow(-5.12335968017578*x_66 - 7.99567985534668, 2) + 0.00959886376978258*std::pow(-4.83440017700195*x_7 - 7.85383987426758, 2) + 0.833544414492451*std::sin(0.218239992856979*x_10 - 4.37031984329224) + 0.180624191710947*std::sin(0.388399839401245*x_106 - 7.39368009567261) + 0.0846743015311606*std::sin(0.447919845581055*x_111 + 5.0274395942688) + 0.500748671061885*std::sin(0.337519854307175*x_115 + 5.14039993286133) + 0.210491892930527*std::sin(0.476639837026596*x_117 + 5.24015998840332) + 0.0684186420626425*std::sin(0.42647984623909*x_118 - 1.16159987449646) + 0.387944314417453*std::sin(0.335759848356247*x_119 - 7.44079971313477) + 0.860939231237552*std::sin(0.203759998083115*x_13 + 8.19944000244141) - 2.49923302467715*std::sin(0.331119894981384*x_17 - 4.21216011047363) - 0.911068931484806*std::sin(0.269999951124191*x_18 + 8.30519962310791) + 0.38611146716481*std::sin(0.33679986000061*x_21 + 8.35943984985352) - 0.170609846883533*std::sin(0.414879858493805*x_23 + 5.20208024978638) - 3.41367288684421*std::sin(0.276959955692291*x_24 + 5.09240007400513) + 1.32568035312914*std::sin(0.29911994934082*x_28 - 4.28567981719971) - 0.759787472244341*std::sin(0.293039947748184*x_3 + 8.30327987670898) + 0.289161678863536*std::sin(0.411119878292084*x_36 + 5.20232009887695) + 0.22043251281189*std::sin(0.502319812774658*x_47 - 4.3219199180603) + 0.283197832651254*std::sin(0.421679854393005*x_55 + 5.23280000686646) + 0.352607121810571*std::sin(0.366159826517105*x_59 + 5.15992021560669) + 0.146855186603393*std::sin(0.341039836406708*x_67 + 5.12520027160645) - 0.193593505341958*std::sin(0.266399949789047*x_79 + 1.87991988658905) + 1.11595770585518*std::sin(0.190400004386902*x_89 + 4.97095966339111) + 0.108128878507372*std::sin(0.472799867391586*x_95 + 2.02503991127014) - 9.28644359097686) - 0.0799795353964677);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000436061573820331*x_1 - 0.000647848065483579*x_10 - 0.00398256331589917*x_100 + 0.00434987102746831*x_101 - 0.0031823651044644*x_102 - 0.000767012782175212*x_103 + 0.00333018131364574*x_104 - 0.00112370614217128*x_105 + 2.68476591619157e-5*x_106 - 0.00159060271602582*x_107 - 0.00144071664133858*x_108 + 0.000832570927863658*x_109 + 7.55407048803104e-6*x_11 - 9.77055062133481e-5*x_110 + 0.000356267444765701*x_111 - 0.000416629614994524*x_112 - 0.00065269960675668*x_113 - 0.00198242570680283*x_114 + 4.56033873183753e-5*x_115 - 0.00102170847632337*x_116 + 1.86702483525603e-5*x_117 - 0.000724471623178378*x_118 - 0.000245143602934114*x_119 + 0.000482248628493071*x_12 - 0.00190607336551688*x_120 - 0.00224232828749484*x_13 + 4.60648871740523e-5*x_14 + 0.000982564139450551*x_15 + 0.000190410426574065*x_16 + 0.000433791346146509*x_17 + 0.000367937961171188*x_18 - 0.000418581406709113*x_19 + 0.000885041519116093*x_2 + 0.00293765415451867*x_20 - 0.00172040005580051*x_21 + 2.93636748431655e-5*x_22 + 0.000445465546143534*x_23 - 0.00304206802310895*x_24 + 0.0027513490490851*x_25 + 0.00155291850864911*x_26 + 6.50645726709383e-5*x_27 + 0.00126774710887887*x_28 + 0.00526784278387329*x_29 + 8.27699951276231e-5*x_3 + 0.00480320486437511*x_30 + 0.0153679195508361*x_31 + 3.42276726205709e-5*x_32 - 0.000742157679594234*x_33 + 0.00539868048596276*x_34 - 0.00119008498308097*x_35 - 0.00123118608132661*x_36 + 0.00219826761700633*x_37 + 0.00429503429709864*x_38 - 0.000174458867883587*x_39 - 0.00461881539607762*x_4 - 0.00169188918025158*x_40 + 0.00274772920362363*x_41 - 0.000843033089506065*x_42 - 0.000337242931315401*x_43 - 0.00296302251934334*x_44 + 0.00286374268086857*x_45 - 4.86466085163999e-5*x_46 - 0.00390574852141947*x_47 + 0.00224657996896079*x_48 - 0.00139780654645418*x_49 - 0.000768181382476556*x_5 - 0.000323524245188965*x_50 + 0.000754203846736495*x_51 + 0.00200797828549225*x_52 + 4.39698681389504e-5*x_53 - 0.00365370245547876*x_54 - 8.16282866713615e-5*x_55 + 0.0024156264736097*x_56 + 0.00157829272653843*x_57 + 0.0012952974269846*x_58 - 0.00018998509083825*x_59 + 0.00275021933797999*x_6 - 0.00147091377770173*x_60 - 0.000336874370564862*x_61 - 0.000996344760716788*x_62 + 0.00220196492269814*x_63 - 0.00100466213080248*x_64 + 0.000105438254776173*x_65 + 0.00292082990210542*x_66 + 5.52274127385068e-5*x_67 - 0.0015330126109031*x_68 - 4.03823429311998e-5*x_69 + 0.00184006348647661*x_7 + 0.000289043123300437*x_70 + 0.00213254568384956*x_71 - 0.000929773576184741*x_72 + 0.00214323642255208*x_73 - 0.000278563489034325*x_74 + 0.00100815247392991*x_75 + 0.0022725750920362*x_76 + 0.000404201542805263*x_77 + 0.00250199549734311*x_78 - 0.000245632111357678*x_79 - 0.00363983861615376*x_8 + 0.00201278158601322*x_80 - 0.00103629090208176*x_81 + 0.00111262487613199*x_82 + 0.00157140143084972*x_83 - 0.00288759373777959*x_84 - 0.000109987854835781*x_85 + 0.0026210000757694*x_86 - 0.00150501465451192*x_87 - 9.7164084648147e-5*x_88 - 0.00208282251506197*x_89 + 0.0024222762843775*x_9 - 0.000467560964983263*x_90 + 0.00332069377764301*x_91 + 0.000306783278968526*x_92 - 0.00141383649597593*x_93 - 0.000461773433109454*x_94 - 0.000489452054273101*x_95 + 0.0022925214453938*x_96 + 0.00384264128663237*x_97 + 7.7384834805818e-5*x_98 - 0.000262182044262794*x_99 + 4.27007318228965e-6*std::pow(-5.50903987884521*x_13 - 8.56120014190674, 2) + 4.5757033695558e-5*std::pow(-5.40360021591187*x_14 - 8.1974401473999, 2) + 2.3155253876961e-5*std::pow(-5.1081600189209*x_14 - 7.96799993515015, 2) + 5.21712215206133e-6*std::pow(-4.90744018554688*x_14 - 7.37560033798218, 2) - 9.92877181872736e-7*std::pow(-5.78351974487305*x_15 - 7.58104038238525, 2) + 9.70613270279896e-5*std::pow(-5.33127975463867*x_15 - 7.50687980651855, 2) + 2.88611318301701e-5*std::pow(-5.31104040145874*x_15 - 7.75784015655518, 2) + 1.03594699157888e-5*std::pow(-3.07200002670288*x_15 - 4.79999971389771, 2) + 3.51124899645725e-6*std::pow(-5.25880002975464*x_17 - 7.69080018997192, 2) + 8.33602712006266e-5*std::pow(-4.46319961547852*x_17 - 6.49072027206421, 2) + 0.0013408696419005*std::pow(-2.07751989364624*x_17 - 2.91079998016357, 2) + 1.14372244891607e-6*std::pow(-6.5796799659729*x_18 - 9.78975963592529, 2) + 6.68239294593712e-7*std::pow(-6.57512044906616*x_18 - 9.37152004241943, 2) + 2.65638705483101e-6*std::pow(-5.29320001602173*x_18 - 8.33983993530273, 2) + 4.17316402374713e-7*std::pow(-4.91903972625732*x_18 - 9.68000030517578, 2) - 6.87662493560353e-6*std::pow(-3.24055981636047*x_2 - 5.87591981887817, 2) + 2.11978840270076e-5*std::pow(-3.23535990715027*x_2 - 5.85767984390259, 2) + 1.55325810811904e-6*std::pow(-5.72215986251831*x_22 - 9.58920001983643, 2) - 1.76967281343909e-6*std::pow(-5.64527988433838*x_22 - 9.06455993652344, 2) + 0.00039296537581034*std::pow(-4.69063997268677*x_22 - 7.54383945465088, 2) + 0.000140403481055186*std::pow(-3.50623989105225*x_22 - 5.77040004730225, 2) + 9.34593203523408e-5*std::pow(-1.23087990283966*x_23 - 1.85415983200073, 2) - 6.7963268500019e-7*std::pow(-6.78079986572266*x_27 - 9.1778392791748, 2) + 2.80939494341108e-6*std::pow(-6.60400009155273*x_27 - 9.9750394821167, 2) + 4.97722319218668e-6*std::pow(-5.82399988174438*x_4 - 9.65783977508545, 2) + 3.48447654260422e-5*std::pow(-3.396399974823*x_4 - 5.59624004364014, 2) + 0.0001168994334886*std::pow(-6.40000009536743*x_5 - 9.99995994567871, 2) + 7.10497269283116e-7*std::pow(-6.19999980926514*x_5 - 9.99948024749756, 2) - 7.03908036811592e-6*std::pow(-5.87680006027222*x_5 - 9.11728000640869, 2) - 3.50727166245039e-6*std::pow(-4.81839990615845*x_5 - 7.81911993026733, 2) - 3.93908926455248e-6*std::pow(-3.91319990158081*x_5 - 6.38520002365112, 2) - 5.99283142326597e-5*std::pow(-1.71423983573914*x_5 - 2.66727995872498, 2) + 1.91307579479924e-5*std::pow(-5.514479637146*x_6 - 8.792799949646, 2) + 8.77671402392783e-5*std::pow(-3.50671982765198*x_6 - 5.57079982757568, 2) + 8.17678492508771e-7*std::pow(-5.12335968017578*x_66 - 7.99567985534668, 2) - 5.37853250979222e-5*std::pow(-5.26424026489258*x_67 - 8.09687995910645, 2) - 6.17059859935264e-7*std::pow(-4.71519947052002*x_67 - 8.39935970306396, 2) + 6.72179564259811e-7*std::pow(-6.60000038146973*x_68 - 9.96571922302246, 2) + 4.68747131188914e-6*std::pow(-5.98231983184814*x_7 - 9.59111976623535, 2) - 1.40600880622384e-6*std::pow(-5.28568029403687*x_7 - 8.53200054168701, 2) + 4.58063111579282e-5*std::pow(-5.20592021942139*x_7 - 8.61111927032471, 2) - 4.73663295171667e-6*std::pow(-4.92143964767456*x_7 - 8.06775951385498, 2) + 1.7788948414241e-5*std::pow(-4.83440017700195*x_7 - 7.85383987426758, 2) - 2.17773900773914e-6*std::pow(-4.3101601600647*x_71 - 6.57128000259399, 2) - 2.9782116307518e-6*std::pow(-4.37599992752075*x_72 - 6.1669602394104, 2) - 1.74997558009484e-6*std::pow(-3.8711199760437*x_72 - 5.22455978393555, 2) - 1.04621096728e-6*std::pow(-6.0*x_77 - 9.99911975860596, 2) - 3.36219085535428e-7*std::pow(-7.76000022888184*x_80 - 9.79903984069824, 2) + 2.18020572801235e-6*std::pow(-4.18959999084473*x_80 - 6.58544015884399, 2) + 9.14954376314755e-8*std::pow(-9.97459983825684*x_81 - 6.60400009155273, 2) + 3.6545227737445e-7*std::pow(-7.59576034545898*x_81 - 8.78192043304443, 2) - 4.02163450202302e-7*std::pow(-5.0*x_81 - 9.99964046478271, 2) + 8.83768128426367e-7*std::pow(-7.46039962768555*x_82 - 9.46856021881104, 2) - 2.98800830201707e-6*std::pow(-5.52776002883911*x_85 - 7.56920003890991, 2) + 6.85777411760236e-7*std::pow(-5.29983949661255*x_85 - 7.26336002349854, 2) + 6.24191794213832e-5*std::pow(-4.47440004348755*x_85 - 8.12800025939941, 2) + 6.5595858625388e-7*std::pow(-6.60000038146973*x_88 - 9.99792003631592, 2) - 1.1431334209098e-6*std::pow(-6.29087972640991*x_88 - 8.66224002838135, 2) + 1.2545847408721e-6*std::pow(-5.65199995040894*x_88 - 7.40236043930054, 2) - 7.18777023362745e-7*std::pow(-6.20728015899658*x_90 - 8.81319999694824, 2) - 0.00162865895935732*std::exp(0.868719875812531*x_27) - 8.07428487776752e-5*std::exp(0.473039865493774*x_71) - 5.26465592673309e-5*std::exp(0.530879855155945*x_71) + 0.00863678205704354*std::sin(0.228959992527962*x_1 + 5.01823997497559) - 0.00734906455405925*std::sin(0.236639991402626*x_1 + 1.97687971591949) + 0.216711942814736*std::sin(0.276399940252304*x_1 - 1.18871986865997) - 0.00552375535580962*std::sin(0.285039931535721*x_1 + 1.9968798160553) + 0.00358603133418138*std::sin(0.297599911689758*x_1 + 1.98135983943939) - 0.00565724635704044*std::sin(0.302639931440353*x_1 - 7.43455982208252) + 0.0116222405798419*std::sin(0.311999946832657*x_1 - 7.43711996078491) + 0.00154475351937626*std::sin(0.218239992856979*x_10 - 4.37031984329224) - 0.00559618711507812*std::sin(0.269119948148727*x_10 - 4.30751943588257) + 0.00797783507831494*std::sin(0.285759955644608*x_10 + 5.09208011627197) - 0.00576937801855648*std::sin(0.294239938259125*x_10 + 5.10759973526001) - 0.000620233599793614*std::sin(0.323919832706451*x_10 - 4.27239990234375) + 0.00263172890799342*std::sin(0.368399828672409*x_101 + 8.18271923065186) + 0.00164217018981384*std::sin(0.282879948616028*x_102 - 4.32231998443604) + 0.00100598143054357*std::sin(0.383199840784073*x_102 + 5.18440008163452) - 0.000434300055327951*std::sin(0.385439842939377*x_102 + 1.96247982978821) + 0.000220290651758562*std::sin(0.306239932775497*x_103 - 4.27127981185913) - 0.000280140861253162*std::sin(0.361359834671021*x_103 + 1.97855985164642) + 0.000560462349895002*std::sin(0.365279853343964*x_103 - 7.4171199798584) + 0.00114342819761585*std::sin(0.321119844913483*x_105 - 4.27928018569946) + 0.000709399024197533*std::sin(0.393999844789505*x_105 - 4.1908802986145) + 0.0575649998168735*std::sin(0.241679981350899*x_106 + 5.03127956390381) - 0.000783073355123115*std::sin(0.263999968767166*x_106 + 5.06047964096069) + 0.000679965511842273*std::sin(0.353919863700867*x_106 - 7.43991994857788) - 0.00190594956703474*std::sin(0.373599827289581*x_106 - 7.40431976318359) - 0.00135584745584853*std::sin(0.374559849500656*x_106 - 7.4235200881958) + 0.000334739038470883*std::sin(0.388399839401245*x_106 - 7.39368009567261) - 0.000544438262826909*std::sin(0.485679864883423*x_106 + 5.2596001625061) + 0.000927699400277065*std::sin(0.539679825305939*x_106 - 7.21880006790161) - 0.00104331110414872*std::sin(0.337519854307175*x_107 - 7.45607995986938) - 0.000403358166763915*std::sin(0.345039844512939*x_107 - 4.25472021102905) - 0.00139437907294774*std::sin(0.499759823083878*x_108 + 5.28000020980835) + 0.000548473384957676*std::sin(0.333519846200943*x_109 - 7.4410400390625) + 0.000682006047687297*std::sin(0.40311986207962*x_109 + 1.98511981964111) - 0.000271356334640217*std::sin(0.471919864416122*x_109 + 2.02095985412598) - 0.0232186331806389*std::sin(0.269839972257614*x_11 + 8.28728008270264) - 0.164164326096425*std::sin(0.289919942617416*x_11 + 8.31727981567383) - 0.000984346592911518*std::sin(0.294399946928024*x_11 + 8.31807994842529) + 0.000529511626939587*std::sin(0.41567987203598*x_110 + 5.20975971221924) + 0.000657260444649352*std::sin(0.308079928159714*x_111 + 5.13520002365112) + 0.000156921362577461*std::sin(0.447919845581055*x_111 + 5.0274395942688) + 0.000402162127622831*std::sin(0.55351984500885*x_111 - 7.41264009475708) + 0.000422575710257328*std::sin(0.241919979453087*x_112 - 1.15607988834381) - 0.00168353876419517*std::sin(0.357759833335876*x_112 + 5.15887975692749) - 0.000678941762045046*std::sin(0.437519878149033*x_112 + 8.21895980834961) + 0.000383238955390025*std::sin(0.437919855117798*x_113 - 1.18151986598969) - 0.000768876550496932*std::sin(0.347919851541519*x_114 + 8.33896064758301) - 0.000923306882472132*std::sin(0.362399846315384*x_114 - 7.42384004592896) - 0.000407348077675393*std::sin(0.386159837245941*x_114 - 7.42127990722656) - 0.000503061391774827*std::sin(0.481919854879379*x_114 - 1.14231991767883) + 0.0130682657700088*std::sin(0.294959932565689*x_115 + 8.33543968200684) + 0.000928004865123882*std::sin(0.337519854307175*x_115 + 5.14039993286133) - 0.000176959099500148*std::sin(0.396719843149185*x_115 - 7.40727996826172) - 0.000952508323126275*std::sin(0.404239863157272*x_115 + 5.19208002090454) + 0.000740498998640531*std::sin(0.521999835968018*x_115 + 8.35608005523682) + 0.000151492635485096*std::sin(0.53415983915329*x_115 - 4.23967981338501) - 5.57841276658786e-5*std::sin(0.638719856739044*x_115 - 4.17447996139526) + 0.0280435450849212*std::sin(0.257519960403442*x_117 - 4.34143972396851) - 0.000360501031872531*std::sin(0.393999844789505*x_117 + 5.18584012985229) - 0.000350486551471466*std::sin(0.438319861888885*x_117 - 4.16440010070801) + 0.000390090901877848*std::sin(0.476639837026596*x_117 + 5.24015998840332) - 0.00064825741541319*std::sin(0.370799839496613*x_118 - 7.40967988967896) + 0.000357988729227662*std::sin(0.390239834785461*x_118 + 5.17920017242432) + 0.000590322111505656*std::sin(0.392959833145142*x_118 - 7.40463972091675) + 0.00139927749077861*std::sin(0.393359839916229*x_118 + 5.19456005096436) + 0.00012679580869313*std::sin(0.42647984623909*x_118 - 1.16159987449646) + 0.000565755204665137*std::sin(0.328399837017059*x_119 - 4.2469596862793) + 0.0007189519053802*std::sin(0.335759848356247*x_119 - 7.44079971313477) - 0.00145319887517508*std::sin(0.343999862670898*x_119 - 7.43631982803345) + 0.0328955956753603*std::sin(0.415999859571457*x_119 - 1.17535984516144) - 0.000294995130056747*std::sin(0.421519845724106*x_119 + 1.98623979091644) - 0.000790384881489818*std::sin(0.433919847011566*x_119 - 1.15335988998413) + 0.0507275135871916*std::sin(0.341599822044373*x_12 - 4.25816011428833) + 0.00033705446285061*std::sin(0.392639845609665*x_12 + 5.19840002059937) + 0.000578369161401034*std::sin(0.300879925489426*x_120 + 1.90599989891052) - 0.000684560825039105*std::sin(0.331999838352203*x_120 - 1.06463980674744) - 0.000611907555158874*std::sin(0.460639864206314*x_120 + 2.05159974098206) + 0.00159552254720956*std::sin(0.203759998083115*x_13 + 8.19944000244141) - 0.0553902971660655*std::sin(0.117440059781075*x_14 - 4.53320026397705) - 0.0118259253152104*std::sin(0.12216005474329*x_14 - 4.52631998062134) - 0.00312611939094686*std::sin(0.250799983739853*x_14 - 4.31239986419678) - 0.00590730563842314*std::sin(0.142320036888123*x_15 - 4.48423957824707) - 0.0174328312332265*std::sin(0.333919852972031*x_16 - 4.24720001220703) + 0.00384166373653454*std::sin(0.359999865293503*x_16 + 5.17304039001465) - 0.00377655701866324*std::sin(0.363919854164124*x_16 - 4.24200010299683) - 0.0347627830714414*std::sin(0.388799846172333*x_16 - 1.18391978740692) + 0.000258722750853586*std::sin(0.401599854230881*x_16 + 5.20815992355347) - 0.00463166562391544*std::sin(0.331119894981384*x_17 - 4.21216011047363) - 3.48090471973201e-5*std::sin(1.23015987873077*x_17 + 5.81080007553101) - 0.107955465745867*std::sin(0.222159996628761*x_18 - 4.37863969802856) - 0.00168842465240737*std::sin(0.269999951124191*x_18 + 8.30519962310791) - 0.0135513537635368*std::sin(0.159040033817291*x_19 - 4.45383977890015) - 0.00116615825688516*std::sin(0.326479852199554*x_21 - 4.25343990325928) + 0.00066353149787242*std::sin(0.335279852151871*x_21 + 5.160560131073) + 0.000715555209061716*std::sin(0.33679986000061*x_21 + 8.35943984985352) + 0.00407253285877331*std::sin(0.153520032763481*x_23 - 7.64976024627686) - 1.12257681905338*std::sin(0.191040009260178*x_23 + 4.99199962615967) + 0.006888013310232*std::sin(0.205360010266304*x_23 + 5.00831985473633) + 0.00664523081112245*std::sin(0.245599970221519*x_23 + 5.0688796043396) - 0.000316180106100356*std::sin(0.414879858493805*x_23 + 5.20208024978638) - 0.00632633740238406*std::sin(0.276959955692291*x_24 + 5.09240007400513) - 0.00172392481274056*std::sin(0.326639831066132*x_24 - 4.2720799446106) + 0.00145991176279725*std::sin(0.358239859342575*x_24 + 8.34879970550537) + 0.00452037831395719*std::sin(0.311839938163757*x_26 - 4.27183961868286) + 0.00130431147207572*std::sin(0.312079936265945*x_26 - 4.2720799446106) + 0.0164250071218333*std::sin(0.346559852361679*x_26 - 4.25408029556274) + 0.00430812899558245*std::sin(0.181520000100136*x_27 - 7.61520004272461) + 0.0403564657407446*std::sin(0.222159996628761*x_27 + 5.0272798538208) - 0.00466930702320407*std::sin(0.22919999063015*x_27 - 7.55919981002808) + 0.00358677954080518*std::sin(0.250079959630966*x_27 - 7.52135992050171) - 0.000318171427705321*std::sin(0.293599933385849*x_27 + 8.32111930847168) - 0.00699068558012435*std::sin(0.301199913024902*x_27 + 5.11639976501465) + 0.000577806736358727*std::sin(0.225199982523918*x_28 - 4.36520004272461) + 0.00350289037853321*std::sin(0.279359966516495*x_28 + 5.0991997718811) + 0.00245679696901473*std::sin(0.29911994934082*x_28 - 4.28567981719971) + 0.00331698786346775*std::sin(0.327599853277206*x_28 - 4.27360010147095) + 9.12563765326736e-5*std::sin(0.475359857082367*x_28 + 5.25095987319946) - 0.00106052088203617*std::sin(0.285999953746796*x_3 + 8.2903995513916) - 0.00140806458698677*std::sin(0.293039947748184*x_3 + 8.30327987670898) + 0.00107620246274346*std::sin(0.300399929285049*x_3 - 4.27288007736206) + 0.527335765961859*std::sin(0.316799849271774*x_3 + 8.31775951385498) + 0.0550796434261343*std::sin(0.321359843015671*x_3 + 8.31960010528564) - 0.0154954803873025*std::sin(0.321439832448959*x_3 + 8.32264041900635) - 0.000412376997981691*std::sin(0.368239849805832*x_3 - 1.03407979011536) - 0.00952601602678797*std::sin(0.274559944868088*x_30 + 8.28799915313721) - 0.00222429453993671*std::sin(0.275599956512451*x_30 + 8.26799964904785) - 0.00247259263411021*std::sin(0.170720010995865*x_31 + 8.43936061859131) - 0.00372390614091547*std::sin(0.270079970359802*x_32 - 7.44039964675903) - 0.0821704996270594*std::sin(0.273199945688248*x_32 + 1.97919988632202) - 0.000418516568989211*std::sin(0.337679862976074*x_34 + 5.20703983306885) - 0.00155123411459962*std::sin(0.379599839448929*x_34 + 1.97711980342865) + 0.000524923175148108*std::sin(0.303839921951294*x_35 - 1.11191987991333) + 0.00136008253844639*std::sin(0.340079843997955*x_35 - 1.19399988651276) + 0.000762431183142099*std::sin(0.322799831628799*x_36 - 4.26735973358154) - 0.00047993554033131*std::sin(0.338079839944839*x_36 - 7.43224000930786) + 0.00146548206981304*std::sin(0.350559860467911*x_36 + 8.34632015228271) - 0.000728363643709933*std::sin(0.357679843902588*x_36 - 4.24528026580811) + 0.000802481463042333*std::sin(0.364799857139587*x_36 - 4.22959995269775) + 0.000535884487169389*std::sin(0.411119878292084*x_36 + 5.20232009887695) + 0.000370115051941976*std::sin(0.2360799908638*x_37 - 4.35727977752686) + 0.00850421829403647*std::sin(0.362399846315384*x_37 + 5.16695976257324) - 0.000549827521930601*std::sin(0.388159841299057*x_37 - 4.19992017745972) - 0.000392761152331222*std::sin(0.433199852705002*x_38 + 5.23192024230957) + 0.000212844687018642*std::sin(0.451359868049622*x_38 + 8.44312000274658) + 0.0240928013385368*std::sin(0.345439851284027*x_39 + 1.95567977428436) - 0.000556395613892499*std::sin(0.308479934930801*x_41 - 4.28967952728271) + 0.000520131925289119*std::sin(0.319679856300354*x_42 - 4.26688003540039) + 0.000658364744683812*std::sin(0.369279831647873*x_43 + 5.17000007629395) - 0.0113431870355271*std::sin(0.404799848794937*x_43 + 5.19200038909912) + 0.000485713447545126*std::sin(0.420399844646454*x_43 + 5.20608043670654) + 0.0015020549396047*std::sin(0.331839829683304*x_45 - 4.27144002914429) + 0.0007032152768304*std::sin(0.352159857749939*x_45 + 5.16239976882935) - 0.00061684415572524*std::sin(0.355999857187271*x_45 - 7.44447994232178) + 0.000830968619011592*std::sin(0.363999843597412*x_45 - 4.23320007324219) + 0.00100240888758672*std::sin(0.365999847650528*x_45 - 4.23720026016235) + 0.0294509077181884*std::sin(0.288639932870865*x_46 + 5.12536001205444) + 0.00228937127313486*std::sin(0.30927985906601*x_46 - 7.48751974105835) - 0.000605525995700329*std::sin(0.32847985625267*x_46 - 7.45831966400146) + 0.00073568495873047*std::sin(0.334399849176407*x_46 - 4.27008008956909) - 0.00138646170994242*std::sin(0.337759852409363*x_46 + 5.14007997512817) - 0.000303677058198227*std::sin(0.416399866342545*x_46 - 7.3724799156189) - 0.000919995952950853*std::sin(0.454959839582443*x_46 + 5.23360013961792) + 0.000923553693152097*std::sin(0.211119994521141*x_47 + 8.22288036346436) + 0.000186839215712027*std::sin(0.451359868049622*x_47 + 2.03895974159241) + 0.000408513204612449*std::sin(0.502319812774658*x_47 - 4.3219199180603) + 0.0010740449402032*std::sin(0.536159813404083*x_47 - 4.23135995864868) + 0.00138607063305789*std::sin(0.416239857673645*x_48 + 5.21384000778198) + 0.00342092065333511*std::sin(0.500239849090576*x_48 + 2.05039978027344) - 0.0002738614758862*std::sin(0.591679811477661*x_48 + 5.18351984024048) + 0.000556064274693812*std::sin(0.348399847745895*x_49 + 5.13439989089966) - 0.000512610731996646*std::sin(0.411999881267548*x_49 + 2.01895976066589) + 0.00128145410256706*std::sin(0.180480018258095*x_50 - 4.43503999710083) - 0.000305856396742933*std::sin(0.459599852561951*x_50 - 7.339439868927) + 0.000620183140623904*std::sin(0.282959938049316*x_51 + 5.10951995849609) - 0.00078803410618479*std::sin(0.322239845991135*x_51 + 5.13632011413574) - 0.000670393520539706*std::sin(0.339839845895767*x_53 + 5.13575983047485) + 0.0141507261914807*std::sin(0.435999870300293*x_53 + 8.42735958099365) - 0.00231739937504114*std::sin(0.193519994616508*x_54 - 4.41111993789673) - 0.000499824079684532*std::sin(0.465039849281311*x_54 + 8.46759986877441) + 0.0558530338185515*std::sin(0.210319995880127*x_55 - 4.39687967300415) + 0.000452541538035154*std::sin(0.265359967947006*x_55 - 4.29959964752197) - 0.000379467401812115*std::sin(0.346879839897156*x_55 - 4.23952007293701) + 0.000836447305607579*std::sin(0.349599838256836*x_55 + 1.96415984630585) + 0.000524832079804808*std::sin(0.421679854393005*x_55 + 5.23280000686646) - 0.00451486107798332*std::sin(0.289999932050705*x_56 - 4.28191947937012) - 0.00102482555980642*std::sin(0.282079964876175*x_57 - 4.2885594367981) + 0.00179005758036732*std::sin(0.197759985923767*x_58 + 4.99087953567505) - 0.00049400449094982*std::sin(0.366159826517105*x_58 + 5.17632007598877) + 0.000680140459357059*std::sin(0.38239985704422*x_58 + 5.19072008132935) + 0.000484957776003504*std::sin(0.435119867324829*x_58 + 5.24216032028198) - 0.000295254023447528*std::sin(0.467359870672226*x_58 + 2.0590398311615) + 0.00937396106729398*std::sin(0.329519838094711*x_59 - 4.26416015625) + 0.000277916563926909*std::sin(0.331599831581116*x_59 - 7.44951963424683) - 0.000895721755210829*std::sin(0.350239843130112*x_59 + 5.14416027069092) + 0.00065346379017569*std::sin(0.366159826517105*x_59 + 5.15992021560669) - 0.000799585430901067*std::sin(0.384639829397202*x_59 + 5.174880027771) - 0.0102778670599448*std::sin(0.41007986664772*x_59 - 4.20344018936157) + 6.3962863802825e-5*std::sin(0.562719821929932*x_59 - 4.22799968719482) - 0.000849739868313587*std::sin(0.319439828395844*x_60 - 4.28592014312744) + 0.000676115933309093*std::sin(0.355039834976196*x_60 + 5.15856027603149) + 0.00268089910083124*std::sin(0.236559987068176*x_64 + 5.06039953231812) - 0.000712396050676736*std::sin(0.264559954404831*x_64 + 5.08464002609253) - 0.00100871412704384*std::sin(0.280799955129623*x_65 + 8.31047916412354) + 0.0171597204138682*std::sin(0.343039840459824*x_65 + 5.14752006530762) - 0.000379510207975977*std::sin(0.302559942007065*x_66 - 7.21759986877441) - 0.000378468715559801*std::sin(0.358399838209152*x_66 + 8.3439998626709) - 0.000416911593713627*std::sin(0.378879845142365*x_66 + 5.16160011291504) - 0.00994129843334755*std::sin(0.237599983811378*x_67 + 5.032639503479) + 0.00277985904171702*std::sin(0.274799972772598*x_67 + 5.09183979034424) + 0.000219663735748699*std::sin(0.333919852972031*x_67 - 4.28336000442505) + 0.000272157142918871*std::sin(0.341039836406708*x_67 + 5.12520027160645) + 0.00053924689905423*std::sin(0.367839843034744*x_67 - 7.41863965988159) + 0.000945813082850058*std::sin(0.325999826192856*x_68 - 4.26984024047852) + 0.00216833606576962*std::sin(0.193519994616508*x_69 + 4.98655986785889) + 0.00101063329927704*std::sin(0.258639961481094*x_69 + 5.07599973678589) + 0.000154435603376667*std::sin(0.356879830360413*x_69 + 8.36288070678711) + 0.00696675611027362*std::sin(0.20728000998497*x_70 + 5.01175975799561) - 0.00109130253559815*std::sin(0.313279926776886*x_70 + 1.92271995544434) - 0.000657251045161843*std::sin(0.537359833717346*x_71 + 5.15304040908813) - 0.00133262456263985*std::sin(0.239039987325668*x_73 + 5.04247999191284) + 0.00116752642801802*std::sin(0.165840014815331*x_74 - 1.26447987556458) - 0.0030915510510523*std::sin(0.365199834108353*x_74 - 4.24535989761353) + 0.00737710913228824*std::sin(0.321599841117859*x_75 + 5.1287202835083) - 0.000381634773021369*std::sin(0.352319836616516*x_75 - 4.25432014465332) + 0.00261478232166912*std::sin(0.178240016102791*x_76 + 4.96903991699219) + 0.00105608541362619*std::sin(0.264239966869354*x_77 - 7.53952026367188) - 0.00493399268680621*std::sin(0.234319984912872*x_78 + 5.03319978713989) + 0.000845410237196537*std::sin(0.194319993257523*x_79 + 8.17903900146484) + 0.000750083168531974*std::sin(0.211119994521141*x_79 - 7.58400011062622) - 0.000358774221872115*std::sin(0.266399949789047*x_79 + 1.87991988658905) + 0.000857338692497024*std::sin(0.289679944515228*x_79 - 4.26887989044189) + 0.000457042260704927*std::sin(0.316639840602875*x_79 - 4.29895973205566) - 0.00142370788702199*std::sin(0.317599833011627*x_79 - 7.47359991073608) + 0.0473529685921786*std::sin(0.32711985707283*x_79 + 8.31087970733643) - 0.000372233093932083*std::sin(0.376959830522537*x_79 - 4.22320032119751) + 0.0112836920700295*std::sin(0.204960003495216*x_8 + 8.20911979675293) - 0.00269997432223381*std::sin(0.2291199862957*x_8 + 8.25759983062744) - 0.00133644735850269*std::sin(0.305919945240021*x_8 + 5.13575983047485) + 0.000260937216954759*std::sin(0.467999875545502*x_80 - 4.13312005996704) + 0.00028248681635209*std::sin(0.496479868888855*x_80 - 4.09999990463257) - 4.69116697081898e-5*std::sin(1.71655988693237*x_80 - 1.58871984481812) - 0.00149788506646775*std::sin(0.180960014462471*x_84 - 4.41928005218506) - 0.00172948289354961*std::sin(0.225439995527267*x_84 + 8.22103977203369) - 0.00175291093454038*std::sin(0.464079856872559*x_84 - 1.13943982124329) - 3.47767538638232e-5*std::sin(1.40207982063293*x_84 - 4.79184007644653) + 1.70115104119715e-5*std::sin(1.99599981307983*x_84 - 4.20552015304565) - 0.00493353430823062*std::sin(0.148400038480759*x_85 - 7.67167997360229) - 0.000467767148749224*std::sin(0.292079925537109*x_85 + 5.12319993972778) - 0.00193436693760295*std::sin(0.257279992103577*x_86 + 1.86807990074158) - 0.00136167050785855*std::sin(0.549119889736176*x_86 + 8.37264060974121) + 0.00253211631050622*std::sin(0.162640020251274*x_87 + 4.94559955596924) + 0.00197421114434378*std::sin(0.174160018563271*x_87 - 7.61856031417847) - 0.000826247452988241*std::sin(0.217519983649254*x_87 + 5.00527954101563) + 0.00206813165996023*std::sin(0.190400004386902*x_89 + 4.97095966339111) + 0.000696772291822291*std::sin(0.306719928979874*x_89 + 5.14775991439819) - 0.00116939546177804*std::sin(0.214959993958473*x_9 + 5.03159952163696) + 0.0411393286261818*std::sin(0.215039998292923*x_9 - 4.37368011474609) + 0.00253502129539111*std::sin(0.22511999309063*x_9 - 4.36303997039795) - 0.0103762683834625*std::sin(0.240799978375435*x_9 - 4.34663963317871) + 0.00110153180200382*std::sin(0.273439943790436*x_9 - 4.31191968917847) + 0.00650072321857059*std::sin(0.186160013079643*x_91 - 7.37151956558228) - 0.125266313790859*std::sin(0.189440011978149*x_91 + 2.01639986038208) - 0.00169802629540415*std::sin(0.20040000975132*x_91 + 2.00647974014282) + 0.000865583154423574*std::sin(0.34759983420372*x_92 + 5.18064022064209) - 0.00107586067748308*std::sin(0.351359844207764*x_92 - 7.38607978820801) - 0.0159220378296305*std::sin(0.361999839544296*x_92 + 2.00455975532532) - 0.00330872951704054*std::sin(0.365679860115051*x_92 + 1.99591982364655) + 0.00636363530448606*std::sin(0.366239845752716*x_92 + 1.99783980846405) + 0.0214322211825781*std::sin(0.399119853973389*x_92 - 4.40703964233398) - 0.00348293306538305*std::sin(0.404639840126038*x_92 + 2.00263977050781) + 0.000224822309214323*std::sin(0.296879917383194*x_94 - 1.11263990402222) - 0.000577768103072109*std::sin(0.375759840011597*x_94 + 5.18688011169434) - 0.00371389143394168*std::sin(0.386319845914841*x_94 + 1.98831987380981) - 0.00032960630902435*std::sin(0.412479877471924*x_94 + 5.20128011703491) + 0.000266197251772198*std::sin(0.358399868011475*x_95 - 4.21600008010864) - 0.00037544109464914*std::sin(0.374239832162857*x_95 + 1.98471975326538) + 0.000447768379825476*std::sin(0.386959850788116*x_95 - 7.40423965454102) + 0.000200388200936093*std::sin(0.472799867391586*x_95 + 2.02503991127014) - 0.000639451260767413*std::sin(0.369519859552383*x_96 - 7.43304014205933) - 0.000446144676540028*std::sin(0.374959826469421*x_96 - 7.40423965454102) + 0.00360517594501046*std::sin(0.391199827194214*x_96 + 5.18480014801025) + 0.000327013988892062*std::sin(0.33927983045578*x_97 - 4.25487995147705) - 0.00072252434542829*std::sin(0.408799856901169*x_97 - 4.18495988845825) - 0.000317894130397676*std::sin(0.529279828071594*x_97 - 4.23943996429443) + 0.000535389495980222*std::sin(0.283199936151505*x_98 + 5.1069598197937) + 0.000210239444882438*std::sin(0.345519840717316*x_98 - 4.25439977645874) - 0.000658754165866041*std::sin(0.360719859600067*x_98 - 4.22751998901367) + 0.000495257960396491*std::sin(0.361119836568832*x_98 + 5.15664005279541) + 0.0322210119853056*std::sin(0.382719844579697*x_98 + 5.17623996734619) + 0.000596910107866996*std::sin(0.386799842119217*x_98 - 7.39551973342896) - 0.0347569806328452*std::sin(0.391679853200912*x_99 - 7.39479970932007) - 0.000602148464196188*std::sin(0.398319840431213*x_99 - 4.20351982116699) + 0.000125346926027493*std::sin(0.476239860057831*x_99 - 1.14175987243652) - 0.8698311682742);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000493273262462617*x_1 + 0.00147071269813135*x_10 - 0.00191852343301402*x_100 + 0.00100989194375383*x_101 - 0.000554535381957367*x_102 + 0.000112814723434384*x_103 - 0.000844248144149537*x_104 + 0.00190021152423662*x_105 + 0.00020027558806894*x_106 + 6.37881203890963e-5*x_107 + 0.00156609275656354*x_108 + 0.000137194764942543*x_109 - 0.00109582376988947*x_11 - 0.002796992932809*x_110 + 0.000704110684993896*x_111 - 0.000367163081383505*x_112 + 0.000669837214046062*x_113 - 0.000245565098567676*x_114 - 5.27997786137559e-5*x_115 - 0.000913995225570367*x_116 - 0.000991607828283638*x_117 + 0.000500525726683146*x_118 + 0.00023260968489824*x_119 - 0.00487722132358905*x_12 - 0.000436312824692524*x_120 - 0.00233094753743038*x_13 + 0.00156921272372334*x_14 + 0.000830114537534798*x_15 - 0.0019588121594057*x_16 - 0.000687493679518556*x_17 + 9.1063635031995e-5*x_18 - 0.00197938636344838*x_19 + 0.00828324179038278*x_2 + 0.00293475987149851*x_20 + 0.00168212244432815*x_21 + 0.00132127942764113*x_22 - 0.00319166442200601*x_23 - 0.00117721159083642*x_24 + 0.0143432772577319*x_25 + 0.0017704608261944*x_26 - 0.000382105766054507*x_27 + 0.000149698540470662*x_28 + 0.0164660950852378*x_29 + 0.00062463203772179*x_3 + 2.08195989859905e-5*x_30 + 0.00902275903865149*x_31 - 0.00374536721276467*x_32 - 0.00181212472531241*x_33 + 6.8383688361462e-5*x_34 + 0.000707307652487193*x_35 + 0.000168177970652852*x_36 + 0.000866009112333951*x_37 + 0.00232231974589862*x_38 - 0.000502666916717537*x_39 - 0.000736664812238859*x_4 - 0.000860457157439389*x_40 - 0.000229175076479718*x_41 + 2.05405256701501e-5*x_42 + 0.000390150292102309*x_43 + 0.000426187867451307*x_44 + 0.00157576584376332*x_45 + 0.000113360920773394*x_46 - 0.00125224395709984*x_47 - 0.000283194147883052*x_48 + 0.000472530145755741*x_49 - 0.000807334081375481*x_5 - 0.00050941350657303*x_50 + 0.000495278506747912*x_51 - 0.00384063455655806*x_52 - 0.000770601714133836*x_53 + 0.000274618095408426*x_54 + 0.000561913444397673*x_55 - 0.00144470668014886*x_56 + 0.00256450135016079*x_57 - 0.000224070476547988*x_58 - 0.000193375315429624*x_59 + 0.00102727723487884*x_6 + 0.000607563466995361*x_60 + 0.000422476897467407*x_61 - 0.00131128115381595*x_62 - 0.00103709367980528*x_63 + 0.000142059672724845*x_64 + 0.000720922471031162*x_65 - 0.000386085514561704*x_66 + 0.000276803906897032*x_67 - 0.000224887859546746*x_68 - 6.53486396257199e-5*x_69 - 0.000140111345095005*x_7 + 0.00125357415920656*x_70 - 0.00034510845157734*x_71 + 0.000270238307628736*x_72 + 0.000842935215604459*x_73 - 0.000150525333384767*x_74 - 3.53905799974095e-5*x_75 + 0.000438216190761736*x_76 + 0.000407875017846132*x_77 - 0.000473785101064927*x_78 + 1.87901761484838e-5*x_79 - 0.000554125029694184*x_8 + 5.66306444355356e-5*x_80 + 0.000971983070931027*x_81 + 0.00228810344605626*x_82 + 0.003158781740634*x_83 - 0.000392794542694156*x_84 - 0.000413443942066178*x_85 + 0.000865332740690364*x_86 - 0.00024681090027797*x_87 - 0.000730683947516079*x_88 - 0.000269218839930955*x_89 - 0.00054976964463283*x_9 + 0.000980494270941748*x_90 - 0.00781828058792951*x_91 + 0.000946830551316776*x_92 + 0.00116991139253985*x_93 + 0.000163736674792028*x_94 - 1.55428746644159e-5*x_95 + 0.000469787127664726*x_96 - 0.00050710553847423*x_97 - 9.70100041242295e-5*x_98 + 9.04023512541353e-5*x_99 - 2.88274970113792e-5*std::pow(-5.50903987884521*x_13 - 8.56120014190674, 2) + 2.38473717242856e-6*std::pow(-5.40360021591187*x_14 - 8.1974401473999, 2) + 1.2588354420609e-6*std::pow(-5.1081600189209*x_14 - 7.96799993515015, 2) - 3.52210762734292e-5*std::pow(-4.90744018554688*x_14 - 7.37560033798218, 2) + 6.70296802214417e-6*std::pow(-5.78351974487305*x_15 - 7.58104038238525, 2) + 5.27673931650856e-6*std::pow(-5.33127975463867*x_15 - 7.50687980651855, 2) - 4.11387410504243e-5*std::pow(-5.31104040145874*x_15 - 7.75784015655518, 2) + 1.68142818400459e-5*std::pow(-3.07200002670288*x_15 - 4.79999971389771, 2) + 4.04184725320923e-5*std::pow(-5.25880002975464*x_17 - 7.69080018997192, 2) + 4.53188137796959e-6*std::pow(-4.46319961547852*x_17 - 6.49072027206421, 2) + 6.98826261268663e-5*std::pow(-2.07751989364624*x_17 - 2.91079998016357, 2) + 1.85635672087358e-6*std::pow(-6.5796799659729*x_18 - 9.78975963592529, 2) + 2.60305898583522e-5*std::pow(-6.57512044906616*x_18 - 9.37152004241943, 2) - 1.79334139287857e-5*std::pow(-5.29320001602173*x_18 - 8.33983993530273, 2) + 4.80378679028246e-6*std::pow(-4.91903972625732*x_18 - 9.68000030517578, 2) - 0.000267872010455845*std::pow(-3.24055981636047*x_2 - 5.87591981887817, 2) - 0.000124489155655243*std::pow(-3.23535990715027*x_2 - 5.85767984390259, 2) + 1.78797687778914e-5*std::pow(-5.72215986251831*x_22 - 9.58920001983643, 2) + 3.26742636761788e-6*std::pow(-5.64527988433838*x_22 - 9.06455993652344, 2) + 2.04803297654159e-5*std::pow(-4.69063997268677*x_22 - 7.54383945465088, 2) + 7.63303564193922e-6*std::pow(-3.50623989105225*x_22 - 5.77040004730225, 2) + 0.000128751421246982*std::pow(-1.23087990283966*x_23 - 1.85415983200073, 2) + 1.25483633946382e-6*std::pow(-6.78079986572266*x_27 - 9.1778392791748, 2) + 3.87027843177765e-6*std::pow(-6.60400009155273*x_27 - 9.9750394821167, 2) + 5.72935041298599e-5*std::pow(-5.82399988174438*x_4 - 9.65783977508545, 2) - 4.9667829739312e-5*std::pow(-3.396399974823*x_4 - 5.59624004364014, 2) + 6.09249337120313e-6*std::pow(-6.40000009536743*x_5 - 9.99995994567871, 2) + 2.76767067752769e-5*std::pow(-6.19999980926514*x_5 - 9.99948024749756, 2) + 4.13385208872592e-5*std::pow(-5.87680006027222*x_5 - 9.11728000640869, 2) - 5.69259380078585e-6*std::pow(-4.81839990615845*x_5 - 7.81911993026733, 2) + 5.61478926684128e-6*std::pow(-3.91319990158081*x_5 - 6.38520002365112, 2) + 0.000404579318828594*std::pow(-1.71423983573914*x_5 - 2.66727995872498, 2) - 3.5321977303991e-5*std::pow(-5.514479637146*x_6 - 8.792799949646, 2) + 4.77146082563418e-6*std::pow(-3.50671982765198*x_6 - 5.57079982757568, 2) - 1.5097165116444e-6*std::pow(-5.12335968017578*x_66 - 7.99567985534668, 2) - 2.80315076684312e-6*std::pow(-5.26424026489258*x_67 - 8.09687995910645, 2) - 7.10306133931673e-6*std::pow(-4.71519947052002*x_67 - 8.39935970306396, 2) + 2.6184079101561e-5*std::pow(-6.60000038146973*x_68 - 9.96571922302246, 2) - 3.16453745558415e-5*std::pow(-5.98231983184814*x_7 - 9.59111976623535, 2) - 1.93694573644049e-6*std::pow(-5.28568029403687*x_7 - 8.53200054168701, 2) + 2.49026023476439e-6*std::pow(-5.20592021942139*x_7 - 8.61111927032471, 2) + 2.78169007839058e-5*std::pow(-4.92143964767456*x_7 - 8.06775951385498, 2) - 3.28445341192364e-5*std::pow(-4.83440017700195*x_7 - 7.85383987426758, 2) + 3.10415550027513e-6*std::pow(-4.3101601600647*x_71 - 6.57128000259399, 2) - 4.10284366276138e-6*std::pow(-4.37599992752075*x_72 - 6.1669602394104, 2) - 6.81685392584954e-5*std::pow(-3.8711199760437*x_72 - 5.22455978393555, 2) + 1.49127214831034e-6*std::pow(-6.0*x_77 - 9.99911975860596, 2) + 2.26983338918892e-6*std::pow(-7.76000022888184*x_80 - 9.79903984069824, 2) + 8.49277221077293e-5*std::pow(-4.18959999084473*x_80 - 6.58544015884399, 2) - 5.37326733297411e-7*std::pow(-9.97459983825684*x_81 - 6.60400009155273, 2) + 1.42358260313305e-5*std::pow(-7.59576034545898*x_81 - 8.78192043304443, 2) + 5.73244948783429e-7*std::pow(-5.0*x_81 - 9.99964046478271, 2) - 5.96636684978369e-6*std::pow(-7.46039962768555*x_82 - 9.46856021881104, 2) - 4.11633975222723e-6*std::pow(-5.52776002883911*x_85 - 7.56920003890991, 2) + 1.11307381310116e-6*std::pow(-5.29983949661255*x_85 - 7.26336002349854, 2) + 3.25312472021346e-6*std::pow(-4.47440004348755*x_85 - 8.12800025939941, 2) + 2.55522072122695e-5*std::pow(-6.60000038146973*x_88 - 9.99792003631592, 2) - 1.31587668149361e-5*std::pow(-6.29087972640991*x_88 - 8.66224002838135, 2) - 8.46977003064371e-6*std::pow(-5.65199995040894*x_88 - 7.40236043930054, 2) + 4.85250289825877e-6*std::pow(-6.20728015899658*x_90 - 8.81319999694824, 2) - 8.48814542356418e-5*std::exp(0.868719875812531*x_27) - 0.00314525649349085*std::exp(0.473039865493774*x_71) + 0.000355419793794867*std::exp(0.530879855155945*x_71) + 0.000469538680790704*std::sin(0.228959992527962*x_1 + 5.01823997497559) + 0.0104753779384442*std::sin(0.236639991402626*x_1 + 1.97687971591949) + 0.0112944608511561*std::sin(0.276399940252304*x_1 - 1.18871986865997) - 0.215172336179929*std::sin(0.285039931535721*x_1 + 1.9968798160553) + 0.0412793023582419*std::sin(0.297599911689758*x_1 + 1.98135983943939) + 0.0381923787926211*std::sin(0.302639931440353*x_1 - 7.43455982208252) + 0.0188638637218726*std::sin(0.311999946832657*x_1 - 7.43711996078491) - 0.00285214777689426*std::sin(0.218239992856979*x_10 - 4.37031984329224) - 0.00770941883499704*std::sin(0.269119948148727*x_10 - 4.30751943588257) - 0.0538587998517821*std::sin(0.285759955644608*x_10 + 5.09208011627197) + 0.00822368816732597*std::sin(0.294239938259125*x_10 + 5.10759973526001) - 0.00713959469750868*std::sin(0.323919832706451*x_10 - 4.27239990234375) - 0.00375127402133553*std::sin(0.368399828672409*x_101 + 8.18271923065186) - 0.00234075415326772*std::sin(0.282879948616028*x_102 - 4.32231998443604) + 0.0391869951908758*std::sin(0.383199840784073*x_102 + 5.18440008163452) - 0.0049992879669514*std::sin(0.385439842939377*x_102 + 1.96247982978821) - 0.00148719420817973*std::sin(0.306239932775497*x_103 - 4.27127981185913) - 0.00322474017567596*std::sin(0.361359834671021*x_103 + 1.97855985164642) + 0.0218322473389346*std::sin(0.365279853343964*x_103 - 7.4171199798584) - 0.00771934614287405*std::sin(0.321119844913483*x_105 - 4.27928018569946) + 0.000977282225596318*std::sin(0.393999844789505*x_105 - 4.1908802986145) + 0.00300013754841517*std::sin(0.241679981350899*x_106 + 5.03127956390381) + 0.00528657094171812*std::sin(0.263999968767166*x_106 + 5.06047964096069) - 0.00399324443591078*std::sin(0.353919863700867*x_106 - 7.43991994857788) - 0.0742443491000481*std::sin(0.373599827289581*x_106 - 7.40431976318359) - 0.001867842461046*std::sin(0.374559849500656*x_106 - 7.4235200881958) - 0.000618043715349455*std::sin(0.388399839401245*x_106 - 7.39368009567261) + 0.000776043879504604*std::sin(0.485679864883423*x_106 + 5.2596001625061) + 5.04343805018425e-5*std::sin(0.539679825305939*x_106 - 7.21880006790161) + 0.00148713867498914*std::sin(0.337519854307175*x_107 - 7.45607995986938) - 0.0157124118410787*std::sin(0.345039844512939*x_107 - 4.25472021102905) + 0.00198755197632835*std::sin(0.499759823083878*x_108 + 5.28000020980835) + 0.00631355294565063*std::sin(0.333519846200943*x_109 - 7.4410400390625) - 0.000972133399193361*std::sin(0.40311986207962*x_109 + 1.98511981964111) - 0.0105704131882575*std::sin(0.471919864416122*x_109 + 2.02095985412598) - 0.00126228105808338*std::sin(0.269839972257614*x_11 + 8.28728008270264) - 0.00855581621469562*std::sin(0.289919942617416*x_11 + 8.31727981567383) - 0.0113309496899239*std::sin(0.294399946928024*x_11 + 8.31807994842529) + 0.00609528152816141*std::sin(0.41567987203598*x_110 + 5.20975971221924) + 0.00756581582658888*std::sin(0.308079928159714*x_111 + 5.13520002365112) - 0.000289730956951138*std::sin(0.447919845581055*x_111 + 5.0274395942688) - 0.00236178401771122*std::sin(0.55351984500885*x_111 - 7.41264009475708) + 0.0164610119261219*std::sin(0.241919979453087*x_112 - 1.15607988834381) + 0.00239972103922052*std::sin(0.357759833335876*x_112 + 5.15887975692749) - 0.00093532369460507*std::sin(0.437519878149033*x_112 + 8.21895980834961) + 0.0149286881903083*std::sin(0.437919855117798*x_113 - 1.18151986598969) - 0.00885064424886578*std::sin(0.347919851541519*x_114 + 8.33896064758301) + 0.00623329513541948*std::sin(0.362399846315384*x_114 - 7.42384004592896) - 0.000661159831604512*std::sin(0.386159837245941*x_114 - 7.42127990722656) + 0.000717065167453229*std::sin(0.481919854879379*x_114 - 1.14231991767883) + 0.000681083904351543*std::sin(0.294959932565689*x_115 + 8.33543968200684) - 0.00171341704667477*std::sin(0.337519854307175*x_115 + 5.14039993286133) - 0.00203700065408836*std::sin(0.396719843149185*x_115 - 7.40727996826172) + 0.00135770812745824*std::sin(0.404239863157272*x_115 + 5.19208002090454) + 4.02572301410522e-5*std::sin(0.521999835968018*x_115 + 8.35608005523682) + 0.00590124330128026*std::sin(0.53415983915329*x_115 - 4.23967981338501) + 0.000376601689226372*std::sin(0.638719856739044*x_115 - 4.17447996139526) + 0.00146155637744455*std::sin(0.257519960403442*x_117 - 4.34143972396851) - 0.00414977720726512*std::sin(0.393999844789505*x_117 + 5.18584012985229) + 0.00205830802761308*std::sin(0.438319861888885*x_117 - 4.16440010070801) - 0.000720242345864227*std::sin(0.476639837026596*x_117 + 5.24015998840332) - 0.00105217573642879*std::sin(0.370799839496613*x_118 - 7.40967988967896) - 0.00241680144141798*std::sin(0.390239834785461*x_118 + 5.17920017242432) - 0.00346679419192641*std::sin(0.392959833145142*x_118 - 7.40463972091675) - 0.00199453419531708*std::sin(0.393359839916229*x_118 + 5.19456005096436) - 0.00023410879428172*std::sin(0.42647984623909*x_118 - 1.16159987449646) + 0.00651248636104081*std::sin(0.328399837017059*x_119 - 4.2469596862793) - 0.00132743318134792*std::sin(0.335759848356247*x_119 - 7.44079971313477) + 0.00207139389308707*std::sin(0.343999862670898*x_119 - 7.43631982803345) + 0.00171443259058612*std::sin(0.415999859571457*x_119 - 1.17535984516144) - 0.000478801647047154*std::sin(0.421519845724106*x_119 + 1.98623979091644) - 4.29692763022763e-5*std::sin(0.433919847011566*x_119 - 1.15335988998413) + 0.00275780141865427*std::sin(0.341599822044373*x_12 - 4.25816011428833) + 0.00387988051040867*std::sin(0.392639845609665*x_12 + 5.19840002059937) - 0.00390460176207614*std::sin(0.300879925489426*x_120 + 1.90599989891052) - 0.0266663786668253*std::sin(0.331999838352203*x_120 - 1.06463980674744) - 0.00704375244687088*std::sin(0.460639864206314*x_120 + 2.05159974098206) - 0.00294588491233597*std::sin(0.203759998083115*x_13 + 8.19944000244141) + 0.0789534902937792*std::sin(0.117440059781075*x_14 - 4.53320026397705) - 0.136129860913219*std::sin(0.12216005474329*x_14 - 4.52631998062134) - 0.00430660433924372*std::sin(0.250799983739853*x_14 - 4.31239986419678) - 0.230113151809213*std::sin(0.142320036888123*x_15 - 4.48423957824707) - 0.00094773591896078*std::sin(0.333919852972031*x_16 - 4.24720001220703) - 0.0259352814708179*std::sin(0.359999865293503*x_16 + 5.17304039001465) + 0.00538311533196837*std::sin(0.363919854164124*x_16 - 4.24200010299683) - 0.0018117455243954*std::sin(0.388799846172333*x_16 - 1.18391978740692) + 0.00297819334640011*std::sin(0.401599854230881*x_16 + 5.20815992355347) + 0.00855165218714114*std::sin(0.331119894981384*x_17 - 4.21216011047363) - 0.00135595143578674*std::sin(1.23015987873077*x_17 + 5.81080007553101) - 0.00562635711580229*std::sin(0.222159996628761*x_18 - 4.37863969802856) + 0.00311741424014467*std::sin(0.269999951124191*x_18 + 8.30519962310791) + 0.0193161389733878*std::sin(0.159040033817291*x_19 - 4.45383977890015) - 0.0134238088844006*std::sin(0.326479852199554*x_21 - 4.25343990325928) + 0.0010769668434454*std::sin(0.335279852151871*x_21 + 5.160560131073) - 0.00132116170843523*std::sin(0.33679986000061*x_21 + 8.35943984985352) + 0.00661005976627211*std::sin(0.153520032763481*x_23 - 7.64976024627686) - 0.0585057739344474*std::sin(0.191040009260178*x_23 + 4.99199962615967) + 0.0792888732930073*std::sin(0.205360010266304*x_23 + 5.00831985473633) - 0.00947213127910984*std::sin(0.245599970221519*x_23 + 5.0688796043396) + 0.000583777525282121*std::sin(0.414879858493805*x_23 + 5.20208024978638) + 0.011680600776607*std::sin(0.276959955692291*x_24 + 5.09240007400513) - 0.0198443368047809*std::sin(0.326639831066132*x_24 - 4.2720799446106) + 0.0023695582921534*std::sin(0.358239859342575*x_24 + 8.34879970550537) - 0.0305173206108918*std::sin(0.311839938163757*x_26 - 4.27183961868286) - 0.00185916935671696*std::sin(0.312079936265945*x_26 - 4.2720799446106) + 0.000892945558314052*std::sin(0.346559852361679*x_26 - 4.25408029556274) + 0.0495914683488267*std::sin(0.181520000100136*x_27 - 7.61520004272461) + 0.00219397937335133*std::sin(0.222159996628761*x_27 + 5.0272798538208) + 0.0315227464519593*std::sin(0.22919999063015*x_27 - 7.55919981002808) + 0.00582164170439761*std::sin(0.250079959630966*x_27 - 7.52135992050171) - 0.0123940480696801*std::sin(0.293599933385849*x_27 + 8.32111930847168) + 0.0099645435091717*std::sin(0.301199913024902*x_27 + 5.11639976501465) - 0.00390080479993191*std::sin(0.225199982523918*x_28 - 4.36520004272461) + 0.00482565155629484*std::sin(0.279359966516495*x_28 + 5.0991997718811) - 0.00453609454554617*std::sin(0.29911994934082*x_28 - 4.28567981719971) + 0.00538374735867086*std::sin(0.327599853277206*x_28 - 4.27360010147095) + 0.00105046476395883*std::sin(0.475359857082367*x_28 + 5.25095987319946) - 0.012207802461044*std::sin(0.285999953746796*x_3 + 8.2903995513916) + 0.00259977286416503*std::sin(0.293039947748184*x_3 + 8.30327987670898) - 0.00726550153918922*std::sin(0.300399929285049*x_3 - 4.27288007736206) + 0.0274833637994854*std::sin(0.316799849271774*x_3 + 8.31775951385498) + 0.00299440496957292*std::sin(0.321359843015671*x_3 + 8.31960010528564) + 0.022087302703728*std::sin(0.321439832448959*x_3 + 8.32264041900635) - 0.0160637313434351*std::sin(0.368239849805832*x_3 - 1.03407979011536) - 0.000517881888053596*std::sin(0.274559944868088*x_30 + 8.28799915313721) - 0.0866451574483773*std::sin(0.275599956512451*x_30 + 8.26799964904785) - 0.00340629286203167*std::sin(0.170720010995865*x_31 + 8.43936061859131) + 0.0251402935184204*std::sin(0.270079970359802*x_32 - 7.44039964675903) - 0.00428251197928284*std::sin(0.273199945688248*x_32 + 1.97919988632202) - 0.000679287222504352*std::sin(0.337679862976074*x_34 + 5.20703983306885) - 0.00213701101386731*std::sin(0.379599839448929*x_34 + 1.97711980342865) + 0.00604246322536208*std::sin(0.303839921951294*x_35 - 1.11191987991333) - 0.00193866559653977*std::sin(0.340079843997955*x_35 - 1.19399988651276) + 0.00105034038405678*std::sin(0.322799831628799*x_36 - 4.26735973358154) + 0.00281852519377247*std::sin(0.338079839944839*x_36 - 7.43224000930786) - 0.00208890239436334*std::sin(0.350559860467911*x_36 + 8.34632015228271) - 0.0283726734278261*std::sin(0.357679843902588*x_36 - 4.24528026580811) - 0.00541759613710781*std::sin(0.364799857139587*x_36 - 4.22959995269775) - 0.000989427588013805*std::sin(0.411119878292084*x_36 + 5.20232009887695) - 0.00249866690762492*std::sin(0.2360799908638*x_37 - 4.35727977752686) + 0.000462331851442471*std::sin(0.362399846315384*x_37 + 5.16695976257324) + 0.00322898096215397*std::sin(0.388159841299057*x_37 - 4.19992017745972) - 0.00063748403777429*std::sin(0.433199852705002*x_38 + 5.23192024230957) + 0.002450084612212*std::sin(0.451359868049622*x_38 + 8.44312000274658) + 0.00125565392464509*std::sin(0.345439851284027*x_39 + 1.95567977428436) - 0.0216738317267433*std::sin(0.308479934930801*x_41 - 4.28967952728271) + 0.0202612161975121*std::sin(0.319679856300354*x_42 - 4.26688003540039) + 0.0256459366947027*std::sin(0.369279831647873*x_43 + 5.17000007629395) - 0.000591177303087661*std::sin(0.404799848794937*x_43 + 5.19200038909912) + 0.00066912851981424*std::sin(0.420399844646454*x_43 + 5.20608043670654) + 0.00206926080283989*std::sin(0.331839829683304*x_45 - 4.27144002914429) + 0.00809480825182009*std::sin(0.352159857749939*x_45 + 5.16239976882935) + 0.0041643485477973*std::sin(0.355999857187271*x_45 - 7.44447994232178) + 0.00134873122600604*std::sin(0.363999843597412*x_45 - 4.23320007324219) - 0.00588686285282022*std::sin(0.365999847650528*x_45 - 4.23720026016235) + 0.00153490444473775*std::sin(0.288639932870865*x_46 + 5.12536001205444) + 0.000124461675694505*std::sin(0.30927985906601*x_46 - 7.48751974105835) - 0.006970293433868*std::sin(0.32847985625267*x_46 - 7.45831966400146) - 0.00496664929235414*std::sin(0.334399849176407*x_46 - 4.27008008956909) - 0.0540082219315819*std::sin(0.337759852409363*x_46 + 5.14007997512817) + 0.00178340916097097*std::sin(0.416399866342545*x_46 - 7.3724799156189) - 0.00126740474933197*std::sin(0.454959839582443*x_46 + 5.23360013961792) - 0.0062349613677849*std::sin(0.211119994521141*x_47 + 8.22288036346436) + 0.000303255596791405*std::sin(0.451359868049622*x_47 + 2.03895974159241) - 0.000754256270500556*std::sin(0.502319812774658*x_47 - 4.3219199180603) + 5.83904561909911e-5*std::sin(0.536159813404083*x_47 - 4.23135995864868) + 0.0539929879247422*std::sin(0.416239857673645*x_48 + 5.21384000778198) + 0.000185978360927458*std::sin(0.500239849090576*x_48 + 2.05039978027344) + 0.000390362942328965*std::sin(0.591679811477661*x_48 + 5.18351984024048) + 0.0064009327266356*std::sin(0.348399847745895*x_49 + 5.13439989089966) - 0.0199682356747777*std::sin(0.411999881267548*x_49 + 2.01895976066589) - 0.00865116655732898*std::sin(0.180480018258095*x_50 - 4.43503999710083) - 0.0119143284203444*std::sin(0.459599852561951*x_50 - 7.339439868927) + 0.00713901385503155*std::sin(0.282959938049316*x_51 + 5.10951995849609) - 0.0306970762995332*std::sin(0.322239845991135*x_51 + 5.13632011413574) - 0.00108810447732613*std::sin(0.339839845895767*x_53 + 5.13575983047485) + 0.000737498916346021*std::sin(0.435999870300293*x_53 + 8.42735958099365) - 0.0266759045230043*std::sin(0.193519994616508*x_54 - 4.41111993789673) + 0.00293532493982939*std::sin(0.465039849281311*x_54 + 8.46759986877441) + 0.00291091434873628*std::sin(0.210319995880127*x_55 - 4.39687967300415) + 0.00520926819577871*std::sin(0.265359967947006*x_55 - 4.29959964752197) + 0.00222850433515405*std::sin(0.346879839897156*x_55 - 4.23952007293701) - 0.00119227441633956*std::sin(0.349599838256836*x_55 + 1.96415984630585) - 0.000969021032081862*std::sin(0.421679854393005*x_55 + 5.23280000686646) - 0.000245450435186187*std::sin(0.289999932050705*x_56 - 4.28191947937012) + 0.00601850960556572*std::sin(0.282079964876175*x_57 - 4.2885594367981) + 0.0697298932797815*std::sin(0.197759985923767*x_58 + 4.99087953567505) - 0.000801810402327537*std::sin(0.366159826517105*x_58 + 5.17632007598877) - 0.000969474184174492*std::sin(0.38239985704422*x_58 + 5.19072008132935) + 0.00558241599168822*std::sin(0.435119867324829*x_58 + 5.24216032028198) + 0.00173394306884435*std::sin(0.467359870672226*x_58 + 2.0590398311615) + 0.000509615419753603*std::sin(0.329519838094711*x_59 - 4.26416015625) + 0.000451081712855029*std::sin(0.331599831581116*x_59 - 7.44951963424683) + 0.00526031960860622*std::sin(0.350239843130112*x_59 + 5.14416027069092) - 0.00120651953405683*std::sin(0.366159826517105*x_59 + 5.15992021560669) + 0.00539804486612645*std::sin(0.384639829397202*x_59 + 5.174880027771) - 0.000535655606397159*std::sin(0.41007986664772*x_59 - 4.20344018936157) + 0.00249160904976307*std::sin(0.562719821929932*x_59 - 4.22799968719482) - 0.0331007622229244*std::sin(0.319439828395844*x_60 - 4.28592014312744) + 0.00778286396280533*std::sin(0.355039834976196*x_60 + 5.15856027603149) - 0.00382136135687238*std::sin(0.236559987068176*x_64 + 5.06039953231812) - 0.0277506718953886*std::sin(0.264559954404831*x_64 + 5.08464002609253) - 0.00138962467305756*std::sin(0.280799955129623*x_65 + 8.31047916412354) + 0.000894319841878324*std::sin(0.343039840459824*x_65 + 5.14752006530762) + 0.00222875572360345*std::sin(0.302559942007065*x_66 - 7.21759986877441) - 0.000614286223406449*std::sin(0.358399838209152*x_66 + 8.3439998626709) + 0.00281459291415341*std::sin(0.378879845142365*x_66 + 5.16160011291504) - 0.000540458717252678*std::sin(0.237599983811378*x_67 + 5.032639503479) - 0.00396241914374025*std::sin(0.274799972772598*x_67 + 5.09183979034424) + 0.00855677997131904*std::sin(0.333919852972031*x_67 - 4.28336000442505) - 0.000502495951881939*std::sin(0.341039836406708*x_67 + 5.12520027160645) - 0.00316684396741866*std::sin(0.367839843034744*x_67 - 7.41863965988159) - 0.00638523572201717*std::sin(0.325999826192856*x_68 - 4.26984024047852) - 0.00309075251950943*std::sin(0.193519994616508*x_69 + 4.98655986785889) - 0.00682284053944185*std::sin(0.258639961481094*x_69 + 5.07599973678589) + 0.000250661837180989*std::sin(0.356879830360413*x_69 + 8.36288070678711) + 0.000378747715503684*std::sin(0.20728000998497*x_70 + 5.01175975799561) + 0.00155554580062285*std::sin(0.313279926776886*x_70 + 1.92271995544434) - 3.57314549163513e-5*std::sin(0.537359833717346*x_71 + 5.15304040908813) - 0.051911049987467*std::sin(0.239039987325668*x_73 + 5.04247999191284) + 0.0454798181465847*std::sin(0.165840014815331*x_74 - 1.26447987556458) - 0.0001680721815742*std::sin(0.365199834108353*x_74 - 4.24535989761353) + 0.000401056558698134*std::sin(0.321599841117859*x_75 + 5.1287202835083) - 0.0148661988790177*std::sin(0.352319836616516*x_75 - 4.25432014465332) - 0.015355874342558*std::sin(0.178240016102791*x_76 + 4.96903991699219) - 0.00620208985362123*std::sin(0.264239966869354*x_77 - 7.53952026367188) + 0.00703292749160389*std::sin(0.234319984912872*x_78 + 5.03319978713989) - 0.00570741063344133*std::sin(0.194319993257523*x_79 + 8.17903900146484) - 0.00440502553003809*std::sin(0.211119994521141*x_79 - 7.58400011062622) + 0.000662420953559438*std::sin(0.266399949789047*x_79 + 1.87991988658905) - 0.0012220530598275*std::sin(0.289679944515228*x_79 - 4.26887989044189) + 0.000741817626459046*std::sin(0.316639840602875*x_79 - 4.29895973205566) - 0.00196132834267961*std::sin(0.317599833011627*x_79 - 7.47359991073608) + 0.00246791313392268*std::sin(0.32711985707283*x_79 + 8.31087970733643) - 0.00428482659526844*std::sin(0.376959830522537*x_79 - 4.22320032119751) + 0.015544638945079*std::sin(0.204960003495216*x_8 + 8.20911979675293) - 0.0310797776206329*std::sin(0.2291199862957*x_8 + 8.25759983062744) - 0.0520599631567806*std::sin(0.305919945240021*x_8 + 5.13575983047485) - 0.00153241020548751*std::sin(0.467999875545502*x_80 - 4.13312005996704) - 0.00040265752765521*std::sin(0.496479868888855*x_80 - 4.09999990463257) - 2.55035305545416e-6*std::sin(1.71655988693237*x_80 - 1.58871984481812) - 0.0583486067575225*std::sin(0.180960014462471*x_84 - 4.41928005218506) + 0.0101567621024754*std::sin(0.225439995527267*x_84 + 8.22103977203369) - 9.52970078799731e-5*std::sin(0.464079856872559*x_84 - 1.13943982124329) + 4.95708858611915e-5*std::sin(1.40207982063293*x_84 - 4.79184007644653) - 0.000114845634869705*std::sin(1.99599981307983*x_84 - 4.20552015304565) - 0.0567905953478517*std::sin(0.148400038480759*x_85 - 7.67167997360229) + 0.00315792154066997*std::sin(0.292079925537109*x_85 + 5.12319993972778) - 0.0753513191990806*std::sin(0.257279992103577*x_86 + 1.86807990074158) - 7.4027220984475e-5*std::sin(0.549119889736176*x_86 + 8.37264060974121) + 0.0986360450301057*std::sin(0.162640020251274*x_87 + 4.94559955596924) + 0.00320430899096134*std::sin(0.174160018563271*x_87 - 7.61856031417847) - 0.00951104863739703*std::sin(0.217519983649254*x_87 + 5.00527954101563) - 0.00381848433571585*std::sin(0.190400004386902*x_89 + 4.97095966339111) + 0.0271420640776859*std::sin(0.306719928979874*x_89 + 5.14775991439819) - 0.00189802615738464*std::sin(0.214959993958473*x_9 + 5.03159952163696) + 0.0566743585315931*std::sin(0.215039998292923*x_9 - 4.37368011474609) + 0.0987492057955605*std::sin(0.22511999309063*x_9 - 4.36303997039795) + 0.0147903630602159*std::sin(0.240799978375435*x_9 - 4.34663963317871) - 0.00646898359214262*std::sin(0.273439943790436*x_9 - 4.31191968917847) + 0.00895552578778473*std::sin(0.186160013079643*x_91 - 7.37151956558228) - 0.0065285533353785*std::sin(0.189440011978149*x_91 + 2.01639986038208) - 0.00275603799565263*std::sin(0.20040000975132*x_91 + 2.00647974014282) + 0.00140491349777385*std::sin(0.34759983420372*x_92 + 5.18064022064209) - 0.0419090709972664*std::sin(0.351359844207764*x_92 - 7.38607978820801) + 0.0935056085407481*std::sin(0.361999839544296*x_92 + 2.00455975532532) - 0.0380872428117628*std::sin(0.365679860115051*x_92 + 1.99591982364655) - 0.0429612491145205*std::sin(0.366239845752716*x_92 + 1.99783980846405) + 0.00111699143091014*std::sin(0.399119853973389*x_92 - 4.40703964233398) - 0.000189349665882629*std::sin(0.404639840126038*x_92 + 2.00263977050781) + 0.00258796067688425*std::sin(0.296879917383194*x_94 - 1.11263990402222) + 0.000823552330495633*std::sin(0.375759840011597*x_94 + 5.18688011169434) - 0.000201905718238049*std::sin(0.386319845914841*x_94 + 1.98831987380981) + 0.00222519017419657*std::sin(0.412479877471924*x_94 + 5.20128011703491) - 0.00179711216934827*std::sin(0.358399868011475*x_95 - 4.21600008010864) + 0.00220485897609421*std::sin(0.374239832162857*x_95 + 1.98471975326538) + 0.0174423670398827*std::sin(0.386959850788116*x_95 - 7.40423965454102) - 0.000369985732122814*std::sin(0.472799867391586*x_95 + 2.02503991127014) + 0.000911475682446334*std::sin(0.369519859552383*x_96 - 7.43304014205933) - 0.00513563303891765*std::sin(0.374959826469421*x_96 - 7.40423965454102) + 0.000195995400376937*std::sin(0.391199827194214*x_96 + 5.18480014801025) - 0.00220768927955709*std::sin(0.33927983045578*x_97 - 4.25487995147705) + 0.00102988829835599*std::sin(0.408799856901169*x_97 - 4.18495988845825) - 0.00365932327515248*std::sin(0.529279828071594*x_97 - 4.23943996429443) - 0.00314419053412818*std::sin(0.283199936151505*x_98 + 5.1069598197937) + 0.00242009530987889*std::sin(0.345519840717316*x_98 - 4.25439977645874) - 0.0256611062053237*std::sin(0.360719859600067*x_98 - 4.22751998901367) + 0.000803844887559459*std::sin(0.361119836568832*x_98 + 5.15664005279541) + 0.00167927504929332*std::sin(0.382719844579697*x_98 + 5.17623996734619) - 0.000850837399670212*std::sin(0.386799842119217*x_98 - 7.39551973342896) - 0.00181144311643987*std::sin(0.391679853200912*x_99 - 7.39479970932007) + 0.00353624700424719*std::sin(0.398319840431213*x_99 - 4.20351982116699) + 0.00144288579127718*std::sin(0.476239860057831*x_99 - 1.14175987243652) + 0.966460156474255);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00448216384183116*x_1 + 0.000789160897801531*x_10 - 0.00106031708773381*x_100 + 0.00237378528080132*x_101 - 0.000684495926831106*x_102 - 0.00196722280673066*x_103 + 0.00200773575888417*x_104 - 0.00294306245307307*x_105 - 0.0002430249227899*x_106 + 0.00128774212906081*x_107 - 0.00194197386994994*x_108 + 0.000990690165747042*x_109 + 0.000202512531827656*x_11 + 0.000546600687273381*x_110 + 0.000413302104009556*x_111 - 0.00101766161433017*x_112 + 0.00120279907088529*x_113 - 0.00032452938030276*x_114 - 0.000466174492976966*x_115 - 4.61028172868031e-5*x_116 + 0.000385228789627431*x_117 - 0.000196881967793199*x_118 - 6.08371525043859e-5*x_119 - 0.000416803794095554*x_12 - 0.00143926135949282*x_120 - 0.00223240422104495*x_13 - 0.0010732393146993*x_14 - 0.000833861754314235*x_15 - 0.000964504912680138*x_16 - 0.00285838251601526*x_17 - 0.000232159397536693*x_18 - 0.000136026244115109*x_19 + 0.0267922896784836*x_2 - 0.00103184673298332*x_20 - 0.00156983904256675*x_21 - 0.000207112559295044*x_22 + 0.000106340700438058*x_23 - 0.000727001901702468*x_24 - 0.00209092251450652*x_25 + 0.00277025773516385*x_26 - 5.25778533173336e-5*x_27 + 0.000197610057505273*x_28 - 0.00361597215847543*x_29 + 0.000900257130637616*x_3 + 0.00213884347177993*x_30 - 0.00910959040130962*x_31 + 0.000926804397732966*x_32 + 0.00242391596606397*x_33 - 0.00138054013263324*x_34 - 1.58185777159224e-5*x_35 - 0.000985513686272147*x_36 - 0.000292218445896988*x_37 + 0.00206236567902075*x_38 + 0.000122966438249732*x_39 - 0.00065343401887251*x_4 + 0.00159308760005421*x_40 + 0.00184957510250663*x_41 + 0.00255961464153073*x_42 - 0.000267142991955753*x_43 + 0.000755526590817276*x_44 + 0.000231428728950158*x_45 + 0.000190686568731848*x_46 - 0.000998287485825139*x_47 + 0.00182519879109047*x_48 + 0.000907504870841733*x_49 + 0.000122809728198237*x_5 + 0.000257547808601365*x_50 + 0.00051536626896185*x_51 + 0.00457445330824354*x_52 + 0.000324780761843529*x_53 - 0.00118844317628591*x_54 - 0.000218584905930536*x_55 + 0.00133159310351649*x_56 - 0.000273836294502283*x_57 - 0.000499948944769943*x_58 + 0.00015963296704698*x_59 + 0.000601879376156342*x_6 + 8.31026811035115e-6*x_60 - 0.000728014505602283*x_61 - 0.00170253115333411*x_62 + 0.00211566971656319*x_63 + 0.000682994413642074*x_64 - 0.000961719576711815*x_65 + 0.000918474199723761*x_66 - 0.000123241603559548*x_67 - 0.000594242792937027*x_68 - 0.000144070314851086*x_69 + 0.000711403336145468*x_7 - 0.000929188129521224*x_70 + 0.0004902052960466*x_71 + 0.00139960866257577*x_72 + 0.00215933328424535*x_73 + 0.000722142988742655*x_74 + 0.00156134546698934*x_75 - 0.000555159702821459*x_76 + 0.000463935902821714*x_77 + 0.00134856857078387*x_78 + 0.000156830530221392*x_79 - 0.00312952020447991*x_8 + 0.0013969181674025*x_80 + 0.00227662097800881*x_81 - 0.000962136333667968*x_82 - 0.000601216939984441*x_83 - 0.00101308903861954*x_84 - 0.000317381713000029*x_85 + 0.00116138043822421*x_86 - 0.000580360139497962*x_87 - 0.000953830647073411*x_88 - 0.00140742152562272*x_89 - 0.00505685060895484*x_9 - 0.00112052265094544*x_90 - 0.0101613608229667*x_91 - 0.00133446292446428*x_92 - 0.00237406717349056*x_93 - 4.86195034248395e-5*x_94 - 0.000168209551360783*x_95 - 0.00031248249678033*x_96 - 0.000117745481816528*x_97 - 8.14886154243559e-5*x_98 + 7.90961914368319e-5*x_99 + 1.17610744163577e-5*std::pow(-5.50903987884521*x_13 - 8.56120014190674, 2) + 1.44211404554327e-5*std::pow(-5.40360021591187*x_14 - 8.1974401473999, 2) - 1.53190704656381e-5*std::pow(-5.1081600189209*x_14 - 7.96799993515015, 2) + 1.43695340220657e-5*std::pow(-4.90744018554688*x_14 - 7.37560033798218, 2) - 2.73468437748115e-6*std::pow(-5.78351974487305*x_15 - 7.58104038238525, 2) - 6.42139065341686e-5*std::pow(-5.33127975463867*x_15 - 7.50687980651855, 2) - 3.89643041017464e-5*std::pow(-5.31104040145874*x_15 - 7.75784015655518, 2) - 0.000178125859850452*std::pow(-3.07200002670288*x_15 - 4.79999971389771, 2) - 1.19381032258922e-5*std::pow(-5.25880002975464*x_17 - 7.69080018997192, 2) - 5.51495516025282e-5*std::pow(-4.46319961547852*x_17 - 6.49072027206421, 2) + 0.000422598841676008*std::pow(-2.07751989364624*x_17 - 2.91079998016357, 2) - 1.96657306116542e-5*std::pow(-6.5796799659729*x_18 - 9.78975963592529, 2) - 5.03132562968819e-6*std::pow(-6.57512044906616*x_18 - 9.37152004241943, 2) + 7.31649423717006e-6*std::pow(-5.29320001602173*x_18 - 8.33983993530273, 2) - 1.41885872931084e-6*std::pow(-4.91903972625732*x_18 - 9.68000030517578, 2) + 5.17756731221423e-5*std::pow(-3.24055981636047*x_2 - 5.87591981887817, 2) - 1.71297403680279e-5*std::pow(-3.23535990715027*x_2 - 5.85767984390259, 2) - 5.28101414906447e-6*std::pow(-5.72215986251831*x_22 - 9.58920001983643, 2) + 3.50947324082255e-5*std::pow(-5.64527988433838*x_22 - 9.06455993652344, 2) + 0.000123850005583577*std::pow(-4.69063997268677*x_22 - 7.54383945465088, 2) - 9.28882417499783e-5*std::pow(-3.50623989105225*x_22 - 5.77040004730225, 2) - 5.75279185533719e-6*std::pow(-1.23087990283966*x_23 - 1.85415983200073, 2) + 1.34779305162143e-5*std::pow(-6.78079986572266*x_27 - 9.1778392791748, 2) - 1.72929401668562e-7*std::pow(-6.60400009155273*x_27 - 9.9750394821167, 2) - 1.69223556365786e-5*std::pow(-5.82399988174438*x_4 - 9.65783977508545, 2) - 4.70425776925022e-5*std::pow(-3.396399974823*x_4 - 5.59624004364014, 2) + 3.68429291268344e-5*std::pow(-6.40000009536743*x_5 - 9.99995994567871, 2) - 5.34949553204747e-6*std::pow(-6.19999980926514*x_5 - 9.99948024749756, 2) + 5.68819128276593e-6*std::pow(-5.87680006027222*x_5 - 9.11728000640869, 2) + 6.03057671561883e-5*std::pow(-4.81839990615845*x_5 - 7.81911993026733, 2) + 5.31801292101448e-6*std::pow(-3.91319990158081*x_5 - 6.38520002365112, 2) - 0.000165060722205057*std::pow(-1.71423983573914*x_5 - 2.66727995872498, 2) - 0.000379385853618095*std::pow(-5.514479637146*x_6 - 8.792799949646, 2) - 5.80650513718102e-5*std::pow(-3.50671982765198*x_6 - 5.57079982757568, 2) - 1.62155442930661e-5*std::pow(-5.12335968017578*x_66 - 7.99567985534668, 2) - 1.6951398834963e-5*std::pow(-5.26424026489258*x_67 - 8.09687995910645, 2) + 2.09797832961843e-6*std::pow(-4.71519947052002*x_67 - 8.39935970306396, 2) - 5.06099281615765e-6*std::pow(-6.60000038146973*x_68 - 9.96571922302246, 2) + 1.29107152430837e-5*std::pow(-5.98231983184814*x_7 - 9.59111976623535, 2) + 8.65454186750279e-8*std::pow(-5.28568029403687*x_7 - 8.53200054168701, 2) - 3.03045741639411e-5*std::pow(-5.20592021942139*x_7 - 8.61111927032471, 2) + 3.82761282108051e-6*std::pow(-4.92143964767456*x_7 - 8.06775951385498, 2) - 0.000352776162735012*std::pow(-4.83440017700195*x_7 - 7.85383987426758, 2) + 2.94008167978639e-6*std::pow(-4.3101601600647*x_71 - 6.57128000259399, 2) + 1.83320738351917e-7*std::pow(-4.37599992752075*x_72 - 6.1669602394104, 2) + 1.31759641474135e-5*std::pow(-3.8711199760437*x_72 - 5.22455978393555, 2) + 1.41244919026586e-6*std::pow(-6.0*x_77 - 9.99911975860596, 2) - 9.26049160370963e-7*std::pow(-7.76000022888184*x_80 - 9.79903984069824, 2) - 1.64152647802774e-5*std::pow(-4.18959999084473*x_80 - 6.58544015884399, 2) - 7.39362989951931e-8*std::pow(-9.97459983825684*x_81 - 6.60400009155273, 2) - 2.7515733128204e-6*std::pow(-7.59576034545898*x_81 - 8.78192043304443, 2) + 5.42945407148214e-7*std::pow(-5.0*x_81 - 9.99964046478271, 2) + 2.43416500877258e-6*std::pow(-7.46039962768555*x_82 - 9.46856021881104, 2) + 1.83923762324826e-7*std::pow(-5.52776002883911*x_85 - 7.56920003890991, 2) - 1.17915966867797e-5*std::pow(-5.29983949661255*x_85 - 7.26336002349854, 2) + 1.96725111058937e-5*std::pow(-4.47440004348755*x_85 - 8.12800025939941, 2) - 4.93886138354043e-6*std::pow(-6.60000038146973*x_88 - 9.99792003631592, 2) + 3.88660695768309e-6*std::pow(-6.29087972640991*x_88 - 8.66224002838135, 2) + 3.45550623352821e-6*std::pow(-5.65199995040894*x_88 - 7.40236043930054, 2) - 1.97972955020982e-6*std::pow(-6.20728015899658*x_90 - 8.81319999694824, 2) - 0.000513300747665617*std::exp(0.868719875812531*x_27) + 0.00060793127215925*std::exp(0.473039865493774*x_71) - 0.000145004564295606*std::exp(0.530879855155945*x_71) - 0.00571392884013473*std::sin(0.228959992527962*x_1 + 5.01823997497559) + 0.00992168941373224*std::sin(0.236639991402626*x_1 + 1.97687971591949) + 0.0683006111474482*std::sin(0.276399940252304*x_1 - 1.18871986865997) + 0.0415896103666124*std::sin(0.285039931535721*x_1 + 1.9968798160553) - 0.012192360120839*std::sin(0.297599911689758*x_1 + 1.98135983943939) - 0.0155817693412796*std::sin(0.302639931440353*x_1 - 7.43455982208252) - 0.199838564473065*std::sin(0.311999946832657*x_1 - 7.43711996078491) - 0.0306343132964902*std::sin(0.218239992856979*x_10 - 4.37031984329224) + 0.000344467513086917*std::sin(0.269119948148727*x_10 - 4.30751943588257) + 0.0219733732964219*std::sin(0.285759955644608*x_10 + 5.09208011627197) + 0.0077890153759656*std::sin(0.294239938259125*x_10 + 5.10759973526001) + 0.00210876891555504*std::sin(0.323919832706451*x_10 - 4.27239990234375) - 0.00355299598393498*std::sin(0.368399828672409*x_101 + 8.18271923065186) - 0.0022170308163674*std::sin(0.282879948616028*x_102 - 4.32231998443604) - 0.00757426298547973*std::sin(0.383199840784073*x_102 + 5.18440008163452) + 0.00147660245592011*std::sin(0.385439842939377*x_102 + 1.96247982978821) + 0.000606747153492846*std::sin(0.306239932775497*x_103 - 4.27127981185913) + 0.000952467490287633*std::sin(0.361359834671021*x_103 + 1.97855985164642) - 0.00421984850085249*std::sin(0.365279853343964*x_103 - 7.4171199798584) + 0.00314934745795405*std::sin(0.321119844913483*x_105 - 4.27928018569946) - 4.36663236283154e-5*std::sin(0.393999844789505*x_105 - 4.1908802986145) + 0.0181426303374355*std::sin(0.241679981350899*x_106 + 5.03127956390381) - 0.00215682111521364*std::sin(0.263999968767166*x_106 + 5.06047964096069) - 0.0005494714784849*std::sin(0.353919863700867*x_106 - 7.43991994857788) + 0.014350327768955*std::sin(0.373599827289581*x_106 - 7.40431976318359) + 8.34577886044909e-5*std::sin(0.374559849500656*x_106 - 7.4235200881958) - 0.00663827623530742*std::sin(0.388399839401245*x_106 - 7.39368009567261) + 0.000735025159867029*std::sin(0.485679864883423*x_106 + 5.2596001625061) - 0.000613748074596354*std::sin(0.539679825305939*x_106 - 7.21880006790161) + 0.00140853419657935*std::sin(0.337519854307175*x_107 - 7.45607995986938) + 0.00303697537514195*std::sin(0.345039844512939*x_107 - 4.25472021102905) + 0.00188249755938718*std::sin(0.499759823083878*x_108 + 5.28000020980835) - 0.00186478711503677*std::sin(0.333519846200943*x_109 - 7.4410400390625) - 0.000920750135430891*std::sin(0.40311986207962*x_109 + 1.98511981964111) + 0.00204310355930754*std::sin(0.471919864416122*x_109 + 2.02095985412598) + 0.0153610009935547*std::sin(0.269839972257614*x_11 + 8.28728008270264) - 0.0517392980532701*std::sin(0.289919942617416*x_11 + 8.31727981567383) + 0.00334673822565409*std::sin(0.294399946928024*x_11 + 8.31807994842529) - 0.00180031791197178*std::sin(0.41567987203598*x_110 + 5.20975971221924) - 0.00223465867628204*std::sin(0.308079928159714*x_111 + 5.13520002365112) - 0.00311193865157925*std::sin(0.447919845581055*x_111 + 5.0274395942688) - 0.00032498209836679*std::sin(0.55351984500885*x_111 - 7.41264009475708) - 0.00318166863083689*std::sin(0.241919979453087*x_112 - 1.15607988834381) + 0.00227288093762856*std::sin(0.357759833335876*x_112 + 5.15887975692749) + 4.17915583402078e-5*std::sin(0.437519878149033*x_112 + 8.21895980834961) - 0.00288549325690448*std::sin(0.437919855117798*x_113 - 1.18151986598969) + 0.00261414887894923*std::sin(0.347919851541519*x_114 + 8.33896064758301) - 0.00254306670876943*std::sin(0.362399846315384*x_114 - 7.42384004592896) + 0.00700414472788522*std::sin(0.386159837245941*x_114 - 7.42127990722656) + 0.000679163837589754*std::sin(0.481919854879379*x_114 - 1.14231991767883) + 0.00411869566178883*std::sin(0.294959932565689*x_115 + 8.33543968200684) - 0.0184034484610536*std::sin(0.337519854307175*x_115 + 5.14039993286133) + 0.000601653713173066*std::sin(0.396719843149185*x_115 - 7.40727996826172) + 0.00128594485414254*std::sin(0.404239863157272*x_115 + 5.19208002090454) - 0.000489899890546895*std::sin(0.521999835968018*x_115 + 8.35608005523682) - 0.00114062250722415*std::sin(0.53415983915329*x_115 - 4.23967981338501) - 0.000153646377643158*std::sin(0.638719856739044*x_115 - 4.17447996139526) + 0.00883842045419056*std::sin(0.257519960403442*x_117 - 4.34143972396851) + 0.00122568878933885*std::sin(0.393999844789505*x_117 + 5.18584012985229) + 0.000283223722780182*std::sin(0.438319861888885*x_117 - 4.16440010070801) - 0.00773597001226554*std::sin(0.476639837026596*x_117 + 5.24015998840332) + 0.0111464592748048*std::sin(0.370799839496613*x_118 - 7.40967988967896) + 0.000986009350407956*std::sin(0.390239834785461*x_118 + 5.17920017242432) - 0.000477031787263031*std::sin(0.392959833145142*x_118 - 7.40463972091675) - 0.00188911072491036*std::sin(0.393359839916229*x_118 + 5.19456005096436) - 0.00251451281998411*std::sin(0.42647984623909*x_118 - 1.16159987449646) - 0.00192354459643644*std::sin(0.328399837017059*x_119 - 4.2469596862793) - 0.0142576777707674*std::sin(0.335759848356247*x_119 - 7.44079971313477) + 0.00196190791219929*std::sin(0.343999862670898*x_119 - 7.43631982803345) + 0.0103676302261164*std::sin(0.415999859571457*x_119 - 1.17535984516144) + 0.00507229246478803*std::sin(0.421519845724106*x_119 + 1.98623979091644) + 0.000522903430852241*std::sin(0.433919847011566*x_119 - 1.15335988998413) - 0.0335603470088488*std::sin(0.341599822044373*x_12 - 4.25816011428833) - 0.00114597141197281*std::sin(0.392639845609665*x_12 + 5.19840002059937) + 0.00159300378634647*std::sin(0.300879925489426*x_120 + 1.90599989891052) + 0.00515421414449122*std::sin(0.331999838352203*x_120 - 1.06463980674744) + 0.00208046070374403*std::sin(0.460639864206314*x_120 + 2.05159974098206) - 0.0316411239526211*std::sin(0.203759998083115*x_13 + 8.19944000244141) + 0.0747803099256331*std::sin(0.117440059781075*x_14 - 4.53320026397705) + 0.0402076632267092*std::sin(0.12216005474329*x_14 - 4.52631998062134) + 0.00019242504763839*std::sin(0.250799983739853*x_14 - 4.31239986419678) + 0.0444774476769891*std::sin(0.142320036888123*x_15 - 4.48423957824707) + 0.0115332257420458*std::sin(0.333919852972031*x_16 - 4.24720001220703) + 0.0105811050909854*std::sin(0.359999865293503*x_16 + 5.17304039001465) + 0.00509858438673406*std::sin(0.363919854164124*x_16 - 4.24200010299683) - 0.0109561074397981*std::sin(0.388799846172333*x_16 - 1.18391978740692) - 0.000879646789416895*std::sin(0.401599854230881*x_16 + 5.20815992355347) + 0.0918514792346295*std::sin(0.331119894981384*x_17 - 4.21216011047363) + 0.000262085233128029*std::sin(1.23015987873077*x_17 + 5.81080007553101) - 0.0340240791134137*std::sin(0.222159996628761*x_18 - 4.37863969802856) + 0.0334834840190233*std::sin(0.269999951124191*x_18 + 8.30519962310791) + 0.0182951615390504*std::sin(0.159040033817291*x_19 - 4.45383977890015) + 0.00396489045990991*std::sin(0.326479852199554*x_21 - 4.25343990325928) - 0.0114090894183926*std::sin(0.335279852151871*x_21 + 5.160560131073) - 0.0141903172126665*std::sin(0.33679986000061*x_21 + 8.35943984985352) - 0.0700251483073085*std::sin(0.153520032763481*x_23 - 7.64976024627686) - 0.353799988156864*std::sin(0.191040009260178*x_23 + 4.99199962615967) - 0.023418964021588*std::sin(0.205360010266304*x_23 + 5.00831985473633) - 0.00897147054642532*std::sin(0.245599970221519*x_23 + 5.0688796043396) + 0.00627023036808281*std::sin(0.414879858493805*x_23 + 5.20208024978638) + 0.125458851249092*std::sin(0.276959955692291*x_24 + 5.09240007400513) + 0.00586127397656468*std::sin(0.326639831066132*x_24 - 4.2720799446106) - 0.0251024463768855*std::sin(0.358239859342575*x_24 + 8.34879970550537) + 0.0124504905351605*std::sin(0.311839938163757*x_26 - 4.27183961868286) - 0.00176090075539686*std::sin(0.312079936265945*x_26 - 4.2720799446106) - 0.0108664687001478*std::sin(0.346559852361679*x_26 - 4.25408029556274) - 0.0146474626868146*std::sin(0.181520000100136*x_27 - 7.61520004272461) - 0.0266990612891399*std::sin(0.222159996628761*x_27 + 5.0272798538208) - 0.0128606852923486*std::sin(0.22919999063015*x_27 - 7.55919981002808) - 0.0616728650204572*std::sin(0.250079959630966*x_27 - 7.52135992050171) + 0.00239558504236355*std::sin(0.293599933385849*x_27 + 8.32111930847168) + 0.00943785574406742*std::sin(0.301199913024902*x_27 + 5.11639976501465) + 0.00159145469749159*std::sin(0.225199982523918*x_28 - 4.36520004272461) - 0.00021561679631089*std::sin(0.279359966516495*x_28 + 5.0991997718811) - 0.0487212277626363*std::sin(0.29911994934082*x_28 - 4.28567981719971) - 0.0570339332124713*std::sin(0.327599853277206*x_28 - 4.27360010147095) - 0.0003102679542713*std::sin(0.475359857082367*x_28 + 5.25095987319946) + 0.00360572769853014*std::sin(0.285999953746796*x_3 + 8.2903995513916) + 0.027923607979131*std::sin(0.293039947748184*x_3 + 8.30327987670898) + 0.00296418742982908*std::sin(0.300399929285049*x_3 - 4.27288007736206) + 0.166199216468164*std::sin(0.316799849271774*x_3 + 8.31775951385498) - 0.0364396323767672*std::sin(0.321359843015671*x_3 + 8.31960010528564) + 0.0209198521238293*std::sin(0.321439832448959*x_3 + 8.32264041900635) + 0.00310488020657426*std::sin(0.368239849805832*x_3 - 1.03407979011536) + 0.00630222892595274*std::sin(0.274559944868088*x_30 + 8.28799915313721) + 0.0167472194725742*std::sin(0.275599956512451*x_30 + 8.26799964904785) + 0.000152197883672281*std::sin(0.170720010995865*x_31 + 8.43936061859131) - 0.010256765018569*std::sin(0.270079970359802*x_32 - 7.44039964675903) - 0.0258974898656933*std::sin(0.273199945688248*x_32 + 1.97919988632202) + 0.00719618130260167*std::sin(0.337679862976074*x_34 + 5.20703983306885) + 9.54846124126175e-5*std::sin(0.379599839448929*x_34 + 1.97711980342865) - 0.00178471736322432*std::sin(0.303839921951294*x_35 - 1.11191987991333) - 0.00183619512718146*std::sin(0.340079843997955*x_35 - 1.19399988651276) - 4.69306633527762e-5*std::sin(0.322799831628799*x_36 - 4.26735973358154) + 0.000387829803615784*std::sin(0.338079839944839*x_36 - 7.43224000930786) - 0.00197849098087555*std::sin(0.350559860467911*x_36 + 8.34632015228271) + 0.00548401552853751*std::sin(0.357679843902588*x_36 - 4.24528026580811) + 0.00221027692071724*std::sin(0.364799857139587*x_36 - 4.22959995269775) - 0.0106272315063601*std::sin(0.411119878292084*x_36 + 5.20232009887695) + 0.00101940891471316*std::sin(0.2360799908638*x_37 - 4.35727977752686) - 0.00562622720501182*std::sin(0.362399846315384*x_37 + 5.16695976257324) + 0.000444308624665916*std::sin(0.388159841299057*x_37 - 4.19992017745972) + 0.00675332990428651*std::sin(0.433199852705002*x_38 + 5.23192024230957) - 0.000723663245550238*std::sin(0.451359868049622*x_38 + 8.44312000274658) + 0.00759327351461605*std::sin(0.345439851284027*x_39 + 1.95567977428436) + 0.00418922912057343*std::sin(0.308479934930801*x_41 - 4.28967952728271) - 0.00391619156146349*std::sin(0.319679856300354*x_42 - 4.26688003540039) - 0.00495697789760291*std::sin(0.369279831647873*x_43 + 5.17000007629395) - 0.0035750065124405*std::sin(0.404799848794937*x_43 + 5.19200038909912) - 2.98975891813809e-5*std::sin(0.420399844646454*x_43 + 5.20608043670654) - 9.24574391323451e-5*std::sin(0.331839829683304*x_45 - 4.27144002914429) - 0.00239090322939104*std::sin(0.352159857749939*x_45 + 5.16239976882935) - 0.00169897556999007*std::sin(0.355999857187271*x_45 - 7.44447994232178) - 0.0142880862605325*std::sin(0.363999843597412*x_45 - 4.23320007324219) - 0.000810033867771284*std::sin(0.365999847650528*x_45 - 4.23720026016235) + 0.00928197574103696*std::sin(0.288639932870865*x_46 + 5.12536001205444) - 0.00151460398756653*std::sin(0.30927985906601*x_46 - 7.48751974105835) + 0.00205876366214*std::sin(0.32847985625267*x_46 - 7.45831966400146) + 0.00202629912351632*std::sin(0.334399849176407*x_46 - 4.27008008956909) + 0.0104389855434285*std::sin(0.337759852409363*x_46 + 5.14007997512817) + 0.000245397566853112*std::sin(0.416399866342545*x_46 - 7.3724799156189) + 5.66293998835643e-5*std::sin(0.454959839582443*x_46 + 5.23360013961792) + 0.00254374650011021*std::sin(0.211119994521141*x_47 + 8.22288036346436) - 0.00321260607183825*std::sin(0.451359868049622*x_47 + 2.03895974159241) - 0.00810130635009273*std::sin(0.502319812774658*x_47 - 4.3219199180603) - 0.000710567468172119*std::sin(0.536159813404083*x_47 - 4.23135995864868) - 0.0104360410366205*std::sin(0.416239857673645*x_48 + 5.21384000778198) - 0.00226321528687446*std::sin(0.500239849090576*x_48 + 2.05039978027344) + 0.000369729846042564*std::sin(0.591679811477661*x_48 + 5.18351984024048) - 0.00189059583020843*std::sin(0.348399847745895*x_49 + 5.13439989089966) + 0.00385956278658538*std::sin(0.411999881267548*x_49 + 2.01895976066589) + 0.00352951259101294*std::sin(0.180480018258095*x_50 - 4.43503999710083) + 0.00230286237338441*std::sin(0.459599852561951*x_50 - 7.339439868927) - 0.00210859735643825*std::sin(0.282959938049316*x_51 + 5.10951995849609) + 0.00593328801163449*std::sin(0.322239845991135*x_51 + 5.13632011413574) + 0.0115270784369292*std::sin(0.339839845895767*x_53 + 5.13575983047485) + 0.00445985225597181*std::sin(0.435999870300293*x_53 + 8.42735958099365) + 0.0078790632571979*std::sin(0.193519994616508*x_54 - 4.41111993789673) + 0.000403901479212553*std::sin(0.465039849281311*x_54 + 8.46759986877441) + 0.0176030738993807*std::sin(0.210319995880127*x_55 - 4.39687967300415) - 0.00153862275233647*std::sin(0.265359967947006*x_55 - 4.29959964752197) + 0.00030664277919862*std::sin(0.346879839897156*x_55 - 4.23952007293701) - 0.00112925533802906*std::sin(0.349599838256836*x_55 + 1.96415984630585) - 0.0104080490247279*std::sin(0.421679854393005*x_55 + 5.23280000686646) + 0.00298694522477292*std::sin(0.289999932050705*x_56 - 4.28191947937012) + 0.00082814849537041*std::sin(0.282079964876175*x_57 - 4.2885594367981) - 0.013477750643496*std::sin(0.197759985923767*x_58 + 4.99087953567505) + 0.00849415804435211*std::sin(0.366159826517105*x_58 + 5.17632007598877) - 0.000918231476375667*std::sin(0.38239985704422*x_58 + 5.19072008132935) - 0.00164883663789448*std::sin(0.435119867324829*x_58 + 5.24216032028198) + 0.000238591019642715*std::sin(0.467359870672226*x_58 + 2.0590398311615) - 0.00620163229023821*std::sin(0.329519838094711*x_59 - 4.26416015625) - 0.00477863513467177*std::sin(0.331599831581116*x_59 - 7.44951963424683) + 0.000723821353546752*std::sin(0.350239843130112*x_59 + 5.14416027069092) - 0.0129589699748586*std::sin(0.366159826517105*x_59 + 5.15992021560669) - 0.00220230037135344*std::sin(0.384639829397202*x_59 + 5.174880027771) - 0.00323925203368498*std::sin(0.41007986664772*x_59 - 4.20344018936157) - 0.000481590948935551*std::sin(0.562719821929932*x_59 - 4.22799968719482) + 0.00639788472872342*std::sin(0.319439828395844*x_60 - 4.28592014312744) - 0.00229876656786755*std::sin(0.355039834976196*x_60 + 5.15856027603149) - 0.0036193787702286*std::sin(0.236559987068176*x_64 + 5.06039953231812) + 0.00536379188900849*std::sin(0.264559954404831*x_64 + 5.08464002609253) + 6.20903553818325e-5*std::sin(0.280799955129623*x_65 + 8.31047916412354) + 0.00540819013555004*std::sin(0.343039840459824*x_65 + 5.14752006530762) + 0.000306677370314987*std::sin(0.302559942007065*x_66 - 7.21759986877441) + 0.0065075786631552*std::sin(0.358399838209152*x_66 + 8.3439998626709) - 0.00114830075958535*std::sin(0.378879845142365*x_66 + 5.16160011291504) + 0.00657697177623761*std::sin(0.237599983811378*x_67 + 5.032639503479) - 0.00375298078047734*std::sin(0.274799972772598*x_67 + 5.09183979034424) - 0.00165389822557119*std::sin(0.333919852972031*x_67 - 4.28336000442505) - 0.00539720225749723*std::sin(0.341039836406708*x_67 + 5.12520027160645) - 0.000435758557943534*std::sin(0.367839843034744*x_67 - 7.41863965988159) + 0.00260505559892993*std::sin(0.325999826192856*x_68 - 4.26984024047852) - 0.00292738712946497*std::sin(0.193519994616508*x_69 + 4.98655986785889) + 0.00278359010092491*std::sin(0.258639961481094*x_69 + 5.07599973678589) - 0.00265544230222299*std::sin(0.356879830360413*x_69 + 8.36288070678711) - 0.00460907180449379*std::sin(0.20728000998497*x_70 + 5.01175975799561) + 0.00147332558245698*std::sin(0.313279926776886*x_70 + 1.92271995544434) + 0.000434824646188246*std::sin(0.537359833717346*x_71 + 5.15304040908813) + 0.0100336334169609*std::sin(0.239039987325668*x_73 + 5.04247999191284) - 0.00879057201237602*std::sin(0.165840014815331*x_74 - 1.26447987556458) + 0.00204531069496542*std::sin(0.365199834108353*x_74 - 4.24535989761353) - 0.00488055346880342*std::sin(0.321599841117859*x_75 + 5.1287202835083) + 0.0028734150030044*std::sin(0.352319836616516*x_75 - 4.25432014465332) - 0.00211297232459782*std::sin(0.178240016102791*x_76 + 4.96903991699219) - 0.000853409185503114*std::sin(0.264239966869354*x_77 - 7.53952026367188) + 0.0066611937679984*std::sin(0.234319984912872*x_78 + 5.03319978713989) + 0.00232851576250681*std::sin(0.194319993257523*x_79 + 8.17903900146484) - 0.000606132664704186*std::sin(0.211119994521141*x_79 - 7.58400011062622) + 0.00711492272241123*std::sin(0.266399949789047*x_79 + 1.87991988658905) - 0.00115745999599804*std::sin(0.289679944515228*x_79 - 4.26887989044189) - 0.00785861113916467*std::sin(0.316639840602875*x_79 - 4.29895973205566) + 8.76348672980083e-5*std::sin(0.317599833011627*x_79 - 7.47359991073608) + 0.0149241276345191*std::sin(0.32711985707283*x_79 + 8.31087970733643) + 0.0012655773213287*std::sin(0.376959830522537*x_79 - 4.22320032119751) - 0.000694556001411935*std::sin(0.204960003495216*x_8 + 8.20911979675293) + 0.00917980245736131*std::sin(0.2291199862957*x_8 + 8.25759983062744) + 0.0100624161164481*std::sin(0.305919945240021*x_8 + 5.13575983047485) - 0.000210860044950523*std::sin(0.467999875545502*x_80 - 4.13312005996704) - 0.000381374586480038*std::sin(0.496479868888855*x_80 - 4.09999990463257) + 3.10358581140644e-5*std::sin(1.71655988693237*x_80 - 1.58871984481812) + 0.0112779173362268*std::sin(0.180960014462471*x_84 - 4.41928005218506) + 0.00139757312096365*std::sin(0.225439995527267*x_84 + 8.22103977203369) + 0.00115969214887036*std::sin(0.464079856872559*x_84 - 1.13943982124329) + 4.6950757898035e-5*std::sin(1.40207982063293*x_84 - 4.79184007644653) + 4.68548503383165e-5*std::sin(1.99599981307983*x_84 - 4.20552015304565) + 0.0167738152149174*std::sin(0.148400038480759*x_85 - 7.67167997360229) - 0.00128837235595507*std::sin(0.292079925537109*x_85 + 5.12319993972778) + 0.0145642886150544*std::sin(0.257279992103577*x_86 + 1.86807990074158) + 0.00090085500991294*std::sin(0.549119889736176*x_86 + 8.37264060974121) - 0.0190648795924928*std::sin(0.162640020251274*x_87 + 4.94559955596924) - 0.0339455648282369*std::sin(0.174160018563271*x_87 - 7.61856031417847) + 0.00280920760500223*std::sin(0.217519983649254*x_87 + 5.00527954101563) - 0.0410135289642801*std::sin(0.190400004386902*x_89 + 4.97095966339111) - 0.00524615705521107*std::sin(0.306719928979874*x_89 + 5.14775991439819) + 0.0201071651182615*std::sin(0.214959993958473*x_9 + 5.03159952163696) - 0.00253228884783787*std::sin(0.215039998292923*x_9 - 4.37368011474609) - 0.019086751884385*std::sin(0.22511999309063*x_9 - 4.36303997039795) + 0.0140086008793296*std::sin(0.240799978375435*x_9 - 4.34663963317871) - 0.000890133833707691*std::sin(0.273439943790436*x_9 - 4.31191968917847) - 0.000400145297917926*std::sin(0.186160013079643*x_91 - 7.37151956558228) - 0.0394798998014517*std::sin(0.189440011978149*x_91 + 2.01639986038208) + 0.0291967056592886*std::sin(0.20040000975132*x_91 + 2.00647974014282) - 0.0148832657372532*std::sin(0.34759983420372*x_92 + 5.18064022064209) + 0.00810039972864127*std::sin(0.351359844207764*x_92 - 7.38607978820801) + 0.0128663961838832*std::sin(0.361999839544296*x_92 + 2.00455975532532) + 0.0112495452646169*std::sin(0.365679860115051*x_92 + 1.99591982364655) + 0.0175273783796112*std::sin(0.366239845752716*x_92 + 1.99783980846405) + 0.00675474450556138*std::sin(0.399119853973389*x_92 - 4.40703964233398) + 0.00230424150558726*std::sin(0.404639840126038*x_92 + 2.00263977050781) - 0.00076438667197686*std::sin(0.296879917383194*x_94 - 1.11263990402222) + 0.000780022495336007*std::sin(0.375759840011597*x_94 + 5.18688011169434) + 0.0024570391186637*std::sin(0.386319845914841*x_94 + 1.98831987380981) - 0.000907835571674615*std::sin(0.412479877471924*x_94 + 5.20128011703491) + 0.000733187829311154*std::sin(0.358399868011475*x_95 - 4.21600008010864) + 0.000303389171609493*std::sin(0.374239832162857*x_95 + 1.98471975326538) - 0.00337134996969853*std::sin(0.386959850788116*x_95 - 7.40423965454102) - 0.00397393814054881*std::sin(0.472799867391586*x_95 + 2.02503991127014) + 0.000863298554242449*std::sin(0.369519859552383*x_96 - 7.43304014205933) + 0.00151687368443282*std::sin(0.374959826469421*x_96 - 7.40423965454102) - 0.00238511504283654*std::sin(0.391199827194214*x_96 + 5.18480014801025) + 0.000900695537140003*std::sin(0.33927983045578*x_97 - 4.25487995147705) + 0.00097545233090109*std::sin(0.408799856901169*x_97 - 4.18495988845825) + 0.00108082706393702*std::sin(0.529279828071594*x_97 - 4.23943996429443) - 0.000432641439599627*std::sin(0.283199936151505*x_98 + 5.1069598197937) - 0.000714805528657524*std::sin(0.345519840717316*x_98 - 4.25439977645874) + 0.00495990993825173*std::sin(0.360719859600067*x_98 - 4.22751998901367) - 0.00851571081923341*std::sin(0.361119836568832*x_98 + 5.15664005279541) + 0.0101550232156194*std::sin(0.382719844579697*x_98 + 5.17623996734619) - 0.000805865379819331*std::sin(0.386799842119217*x_98 - 7.39551973342896) - 0.0109542786983954*std::sin(0.391679853200912*x_99 - 7.39479970932007) + 0.000486588512398023*std::sin(0.398319840431213*x_99 - 4.20351982116699) - 0.000426174430658241*std::sin(0.476239860057831*x_99 - 1.14175987243652) - 0.818819797164566);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000599773170931431*x_1 + 0.000537237183266053*x_10 + 0.000230390169340992*x_100 - 0.000112879045780629*x_101 + 0.000799377926422807*x_102 + 0.00089756122433771*x_103 + 0.000297579690973614*x_104 - 0.00140313732918687*x_105 - 0.000165086732436146*x_106 + 0.000739526233154213*x_107 - 0.00138966967287609*x_108 + 0.000633520435870885*x_109 + 0.000522442861343738*x_11 + 0.00131401699313824*x_110 - 0.000280443078448994*x_111 - 5.34626416047814e-5*x_112 + 0.000228160591627209*x_113 + 0.000799186463983036*x_114 - 0.000334939317295458*x_115 + 0.000575440131947401*x_116 + 0.000371915160775783*x_117 - 0.000274488864375973*x_118 - 7.34076160806265e-5*x_119 + 0.00164018468039339*x_12 + 0.00025593959064917*x_120 + 0.00140740341615123*x_13 - 0.000622932496849881*x_14 + 0.00055072749143502*x_15 - 5.10016658368213e-5*x_16 - 0.00222075277931128*x_17 + 0.000189187313804119*x_18 - 0.000240762147212943*x_19 + 0.0168686342899165*x_2 - 0.00099389006312599*x_20 - 0.000140375771596478*x_21 + 0.000481963844994862*x_22 + 0.000908698893327395*x_23 + 0.00208483401522553*x_24 - 0.00360358482741059*x_25 - 0.000753865590291689*x_26 - 6.53612342662687e-5*x_27 - 0.000203360392291014*x_28 - 0.00222301080614915*x_29 + 0.0014477954170196*x_3 - 8.07046632027883e-5*x_30 - 0.00923868317712624*x_31 + 0.00321654421072955*x_32 + 0.00310437937302919*x_33 - 0.0008528556848788*x_34 + 0.000981103795534771*x_35 - 9.67433903998135e-6*x_36 - 0.000824529873252748*x_37 - 0.00103872262647316*x_38 - 0.000305132465252316*x_39 - 0.00489920234719379*x_4 + 0.000803745253549973*x_40 - 0.000262018100906189*x_41 + 0.00254768677769068*x_42 - 0.000158761413384793*x_43 + 0.00170568613401267*x_44 - 0.000867436501156719*x_45 - 0.000177688285591577*x_46 + 0.00123136843251574*x_47 + 8.74464650584757e-5*x_48 + 0.000529383990669964*x_49 - 0.00252656979514775*x_5 + 0.000547838052311545*x_50 + 2.0938218117534e-5*x_51 + 0.0044163916137033*x_52 + 0.000694368864965729*x_53 + 0.00144892542297691*x_54 - 0.000327549505459987*x_55 + 0.000353173253414702*x_56 - 0.000567993170015924*x_57 - 0.000321256343019213*x_58 - 0.000463155439348134*x_59 + 0.00051646438805267*x_6 + 4.28684546321907e-5*x_60 - 8.78305739406605e-5*x_61 + 0.000844911965244987*x_62 + 0.00124845463599982*x_63 + 0.000287162949843913*x_64 - 0.000272464377286358*x_65 - 0.000504784071695905*x_66 + 0.000275265532418028*x_67 - 0.000444100470976855*x_68 - 2.33473367837046e-5*x_69 + 0.000348200924472368*x_7 - 0.000357548589246414*x_70 + 1.91301523980783e-5*x_71 - 9.38628511382645e-7*x_72 - 6.62320436319371e-5*x_73 - 0.000376104436420299*x_74 + 3.15074729971e-6*x_75 - 0.000864088832607713*x_76 + 0.000132290885630829*x_77 + 0.000955001467586896*x_78 - 4.72141364058592e-5*x_79 - 0.000655062994106033*x_8 - 0.000244298642532128*x_80 + 0.000295714700026496*x_81 - 0.00181404459335097*x_82 - 0.00167550444571182*x_83 + 0.000654506479698052*x_84 + 0.000108254906091835*x_85 - 5.4292755003777e-5*x_86 + 0.000472106873344765*x_87 - 0.00042993412925314*x_88 + 9.49374288697125e-5*x_89 - 0.0012000408796106*x_9 - 0.000157597997993566*x_90 - 0.00295241474108082*x_91 + 0.00119854843704496*x_92 - 0.000193165742467982*x_93 + 4.78008234814348e-5*x_94 + 0.000515198462033142*x_95 - 0.000609231248379368*x_96 - 0.000192056733866893*x_97 - 0.000125973255470764*x_98 - 0.000165257276530189*x_99 - 4.73730110423949e-6*std::pow(-5.50903987884521*x_13 - 8.56120014190674, 2) - 8.38993218299083e-6*std::pow(-5.40360021591187*x_14 - 8.1974401473999, 2) + 3.55218320973165e-6*std::pow(-5.1081600189209*x_14 - 7.96799993515015, 2) - 5.7879753992085e-6*std::pow(-4.90744018554688*x_14 - 7.37560033798218, 2) + 1.10151699262864e-6*std::pow(-5.78351974487305*x_15 - 7.58104038238525, 2) + 1.48899087012882e-5*std::pow(-5.33127975463867*x_15 - 7.50687980651855, 2) + 4.68312514228523e-5*std::pow(-5.31104040145874*x_15 - 7.75784015655518, 2) - 0.000128789470109795*std::pow(-3.07200002670288*x_15 - 4.79999971389771, 2) - 6.27709363877904e-6*std::pow(-5.25880002975464*x_17 - 7.69080018997192, 2) + 1.27880677660014e-5*std::pow(-4.46319961547852*x_17 - 6.49072027206421, 2) - 0.000245859586017451*std::pow(-2.07751989364624*x_17 - 2.91079998016357, 2) - 1.42188171157367e-5*std::pow(-6.5796799659729*x_18 - 9.78975963592529, 2) - 7.60616857065947e-6*std::pow(-6.57512044906616*x_18 - 9.37152004241943, 2) - 2.94704675796462e-6*std::pow(-5.29320001602173*x_18 - 8.33983993530273, 2) - 7.46040550626715e-7*std::pow(-4.91903972625732*x_18 - 9.68000030517578, 2) + 7.82725123777733e-5*std::pow(-3.24055981636047*x_2 - 5.87591981887817, 2) - 2.12945356737476e-5*std::pow(-3.23535990715027*x_2 - 5.85767984390259, 2) - 2.77677447532015e-6*std::pow(-5.72215986251831*x_22 - 9.58920001983643, 2) + 4.46620666283073e-6*std::pow(-5.64527988433838*x_22 - 9.06455993652344, 2) - 7.20534655993734e-5*std::pow(-4.69063997268677*x_22 - 7.54383945465088, 2) + 2.15389082167802e-5*std::pow(-3.50623989105225*x_22 - 5.77040004730225, 2) + 0.000346043769359276*std::pow(-1.23087990283966*x_23 - 1.85415983200073, 2) + 1.71522103011041e-6*std::pow(-6.78079986572266*x_27 - 9.1778392791748, 2) + 1.04021044896515e-5*std::pow(-6.60400009155273*x_27 - 9.9750394821167, 2) - 8.89782982351331e-6*std::pow(-5.82399988174438*x_4 - 9.65783977508545, 2) + 5.6540539714089e-5*std::pow(-3.396399974823*x_4 - 5.59624004364014, 2) - 2.14344820891354e-5*std::pow(-6.40000009536743*x_5 - 9.99995994567871, 2) - 8.08716584445447e-6*std::pow(-6.19999980926514*x_5 - 9.99948024749756, 2) + 7.07117502002774e-6*std::pow(-5.87680006027222*x_5 - 9.11728000640869, 2) + 4.36025841679072e-5*std::pow(-4.81839990615845*x_5 - 7.81911993026733, 2) - 6.39172714399496e-6*std::pow(-3.91319990158081*x_5 - 6.38520002365112, 2) + 6.64856214565767e-5*std::pow(-1.71423983573914*x_5 - 2.66727995872498, 2) - 4.82811952375998e-5*std::pow(-5.514479637146*x_6 - 8.792799949646, 2) + 1.34641133101256e-5*std::pow(-3.50671982765198*x_6 - 5.57079982757568, 2) - 2.06361373897082e-6*std::pow(-5.12335968017578*x_66 - 7.99567985534668, 2) + 9.8619860940743e-6*std::pow(-5.26424026489258*x_67 - 8.09687995910645, 2) + 1.10312385292345e-6*std::pow(-4.71519947052002*x_67 - 8.39935970306396, 2) - 7.65101830568206e-6*std::pow(-6.60000038146973*x_68 - 9.96571922302246, 2) - 5.20037059645809e-6*std::pow(-5.98231983184814*x_7 - 9.59111976623535, 2) - 5.2059076101108e-6*std::pow(-5.28568029403687*x_7 - 8.53200054168701, 2) + 7.0270190195078e-6*std::pow(-5.20592021942139*x_7 - 8.61111927032471, 2) + 4.75822960609043e-6*std::pow(-4.92143964767456*x_7 - 8.06775951385498, 2) - 4.48948072938058e-5*std::pow(-4.83440017700195*x_7 - 7.85383987426758, 2) - 3.53368826991644e-6*std::pow(-4.3101601600647*x_71 - 6.57128000259399, 2) - 1.10271674860214e-5*std::pow(-4.37599992752075*x_72 - 6.1669602394104, 2) + 1.99189262954549e-5*std::pow(-3.8711199760437*x_72 - 5.22455978393555, 2) - 1.69762465097843e-6*std::pow(-6.0*x_77 - 9.99911975860596, 2) + 3.73007903419425e-7*std::pow(-7.76000022888184*x_80 - 9.79903984069824, 2) - 2.48159789766056e-5*std::pow(-4.18959999084473*x_80 - 6.58544015884399, 2) - 9.19126106240729e-8*std::pow(-9.97459983825684*x_81 - 6.60400009155273, 2) - 4.15972489006579e-6*std::pow(-7.59576034545898*x_81 - 8.78192043304443, 2) - 6.52566841811023e-7*std::pow(-5.0*x_81 - 9.99964046478271, 2) - 9.80469315619776e-7*std::pow(-7.46039962768555*x_82 - 9.46856021881104, 2) - 1.1063440776251e-5*std::pow(-5.52776002883911*x_85 - 7.56920003890991, 2) - 8.52562053771282e-6*std::pow(-5.29983949661255*x_85 - 7.26336002349854, 2) - 1.14450749965066e-5*std::pow(-4.47440004348755*x_85 - 8.12800025939941, 2) - 7.46638460620905e-6*std::pow(-6.60000038146973*x_88 - 9.99792003631592, 2) + 2.04359062313967e-6*std::pow(-6.29087972640991*x_88 - 8.66224002838135, 2) - 1.3918603791021e-6*std::pow(-5.65199995040894*x_88 - 7.40236043930054, 2) + 7.9742501852216e-7*std::pow(-6.20728015899658*x_90 - 8.81319999694824, 2) + 0.000298628147732288*std::exp(0.868719875812531*x_27) + 0.000919047598138721*std::exp(0.473039865493774*x_71) + 5.84071028070306e-5*std::exp(0.530879855155945*x_71) + 0.00132494475647564*std::sin(0.228959992527962*x_1 + 5.01823997497559) - 0.0119248923389118*std::sin(0.236639991402626*x_1 + 1.97687971591949) - 0.0397359347102154*std::sin(0.276399940252304*x_1 - 1.18871986865997) + 0.0628736063851436*std::sin(0.285039931535721*x_1 + 1.9968798160553) - 0.00641078274396491*std::sin(0.297599911689758*x_1 + 1.98135983943939) + 0.00627625763542349*std::sin(0.302639931440353*x_1 - 7.43455982208252) - 0.144488300842989*std::sin(0.311999946832657*x_1 - 7.43711996078491) - 0.00389856724264297*std::sin(0.218239992856979*x_10 - 4.37031984329224) - 0.0207205196447049*std::sin(0.269119948148727*x_10 - 4.30751943588257) - 0.00885076328028568*std::sin(0.285759955644608*x_10 + 5.09208011627197) - 0.00936162843960451*std::sin(0.294239938259125*x_10 + 5.10759973526001) + 0.00110879757822635*std::sin(0.323919832706451*x_10 - 4.27239990234375) + 0.00427035082658093*std::sin(0.368399828672409*x_101 + 8.18271923065186) + 0.00266465242911549*std::sin(0.282879948616028*x_102 - 4.32231998443604) - 0.011450485479636*std::sin(0.383199840784073*x_102 + 5.18440008163452) + 0.000776402390537118*std::sin(0.385439842939377*x_102 + 1.96247982978821) - 0.000244394675050954*std::sin(0.306239932775497*x_103 - 4.27127981185913) + 0.000500810514978731*std::sin(0.361359834671021*x_103 + 1.97855985164642) - 0.00637940801341411*std::sin(0.365279853343964*x_103 - 7.4171199798584) - 0.00126854117761972*std::sin(0.321119844913483*x_105 - 4.27928018569946) + 0.00262663061733851*std::sin(0.393999844789505*x_105 - 4.1908802986145) - 0.0105550208475235*std::sin(0.241679981350899*x_106 + 5.03127956390381) + 0.00086875660241872*std::sin(0.263999968767166*x_106 + 5.06047964096069) - 0.000683065811209995*std::sin(0.353919863700867*x_106 - 7.43991994857788) + 0.0216942849834292*std::sin(0.373599827289581*x_106 - 7.40431976318359) - 0.00502017950193939*std::sin(0.374559849500656*x_106 - 7.4235200881958) - 0.000844796683643953*std::sin(0.388399839401245*x_106 - 7.39368009567261) - 0.000883427764396085*std::sin(0.485679864883423*x_106 + 5.2596001625061) + 0.000142315789360493*std::sin(0.539679825305939*x_106 - 7.21880006790161) - 0.00169291921460843*std::sin(0.337519854307175*x_107 - 7.45607995986938) + 0.00459118497756685*std::sin(0.345039844512939*x_107 - 4.25472021102905) - 0.00226257644115388*std::sin(0.499759823083878*x_108 + 5.28000020980835) - 0.000980511151226*std::sin(0.333519846200943*x_109 - 7.4410400390625) + 0.00110665087145896*std::sin(0.40311986207962*x_109 + 1.98511981964111) + 0.00308868700282684*std::sin(0.471919864416122*x_109 + 2.02095985412598) - 0.00356190605274453*std::sin(0.269839972257614*x_11 + 8.28728008270264) + 0.0301008927278673*std::sin(0.289919942617416*x_11 + 8.31727981567383) + 0.00175972588185941*std::sin(0.294399946928024*x_11 + 8.31807994842529) - 0.000946613033845118*std::sin(0.41567987203598*x_110 + 5.20975971221924) - 0.00117499082528531*std::sin(0.308079928159714*x_111 + 5.13520002365112) - 0.00039602983656733*std::sin(0.447919845581055*x_111 + 5.0274395942688) - 0.00040399578384256*std::sin(0.55351984500885*x_111 - 7.41264009475708) - 0.00480992679132646*std::sin(0.241919979453087*x_112 - 1.15607988834381) - 0.00273177876772399*std::sin(0.357759833335876*x_112 + 5.15887975692749) - 0.00251385913815509*std::sin(0.437519878149033*x_112 + 8.21895980834961) - 0.00436218001713335*std::sin(0.437919855117798*x_113 - 1.18151986598969) + 0.00137452801239681*std::sin(0.347919851541519*x_114 + 8.33896064758301) + 0.00102433436785778*std::sin(0.362399846315384*x_114 - 7.42384004592896) + 0.00506417253976481*std::sin(0.386159837245941*x_114 - 7.42127990722656) - 0.000816287963270706*std::sin(0.481919854879379*x_114 - 1.14231991767883) - 0.00239617507308648*std::sin(0.294959932565689*x_115 + 8.33543968200684) - 0.00234204960390451*std::sin(0.337519854307175*x_115 + 5.14039993286133) + 0.000316351486014579*std::sin(0.396719843149185*x_115 - 7.40727996826172) - 0.00154557891302294*std::sin(0.404239863157272*x_115 + 5.19208002090454) + 0.000113597895482856*std::sin(0.521999835968018*x_115 + 8.35608005523682) - 0.00172435014228502*std::sin(0.53415983915329*x_115 - 4.23967981338501) + 6.18879813785536e-5*std::sin(0.638719856739044*x_115 - 4.17447996139526) - 0.00514201691916003*std::sin(0.257519960403442*x_117 - 4.34143972396851) + 0.000644471165737191*std::sin(0.393999844789505*x_117 + 5.18584012985229) + 0.000352084593158871*std::sin(0.438319861888885*x_117 - 4.16440010070801) - 0.000984490789396677*std::sin(0.476639837026596*x_117 + 5.24015998840332) + 0.0080591699869281*std::sin(0.370799839496613*x_118 - 7.40967988967896) - 0.000397159563753925*std::sin(0.390239834785461*x_118 + 5.17920017242432) - 0.000593013682235611*std::sin(0.392959833145142*x_118 - 7.40463972091675) + 0.00227052481401609*std::sin(0.393359839916229*x_118 + 5.19456005096436) - 0.000320000556771709*std::sin(0.42647984623909*x_118 - 1.16159987449646) - 0.00101140602671381*std::sin(0.328399837017059*x_119 - 4.2469596862793) - 0.00181445279922893*std::sin(0.335759848356247*x_119 - 7.44079971313477) - 0.00235801985491049*std::sin(0.343999862670898*x_119 - 7.43631982803345) - 0.00603168069572989*std::sin(0.415999859571457*x_119 - 1.17535984516144) + 0.00366739483716968*std::sin(0.421519845724106*x_119 + 1.98623979091644) - 0.000121250750269138*std::sin(0.433919847011566*x_119 - 1.15335988998413) + 0.00778196702110639*std::sin(0.341599822044373*x_12 - 4.25816011428833) - 0.000602555508543072*std::sin(0.392639845609665*x_12 + 5.19840002059937) - 0.00064165384291939*std::sin(0.300879925489426*x_120 + 1.90599989891052) + 0.00779194679846377*std::sin(0.331999838352203*x_120 - 1.06463980674744) + 0.0010939130280661*std::sin(0.460639864206314*x_120 + 2.05159974098206) - 0.00402669543032411*std::sin(0.203759998083115*x_13 + 8.19944000244141) - 0.089878558756274*std::sin(0.117440059781075*x_14 - 4.53320026397705) + 0.0211413205510864*std::sin(0.12216005474329*x_14 - 4.52631998062134) - 0.0115748128001798*std::sin(0.250799983739853*x_14 - 4.31239986419678) + 0.0672393300540222*std::sin(0.142320036888123*x_15 - 4.48423957824707) - 0.00267432223951413*std::sin(0.333919852972031*x_16 - 4.24720001220703) - 0.00426201544664003*std::sin(0.359999865293503*x_16 + 5.17304039001465) - 0.00612799568272208*std::sin(0.363919854164124*x_16 - 4.24200010299683) + 0.00637404501353698*std::sin(0.388799846172333*x_16 - 1.18391978740692) - 0.000462521152794649*std::sin(0.401599854230881*x_16 + 5.20815992355347) + 0.0116891527701864*std::sin(0.331119894981384*x_17 - 4.21216011047363) + 0.000396210583407601*std::sin(1.23015987873077*x_17 + 5.81080007553101) + 0.0197945313154979*std::sin(0.222159996628761*x_18 - 4.37863969802856) + 0.00426115685057903*std::sin(0.269999951124191*x_18 + 8.30519962310791) - 0.0219889801603967*std::sin(0.159040033817291*x_19 - 4.45383977890015) + 0.00208475234410583*std::sin(0.326479852199554*x_21 - 4.25343990325928) - 0.0082490581764135*std::sin(0.335279852151871*x_21 + 5.160560131073) - 0.00180588039668422*std::sin(0.33679986000061*x_21 + 8.35943984985352) - 0.0506299408318909*std::sin(0.153520032763481*x_23 - 7.64976024627686) + 0.205833783822612*std::sin(0.191040009260178*x_23 + 4.99199962615967) - 0.0123137677154503*std::sin(0.205360010266304*x_23 + 5.00831985473633) + 0.0107828229575266*std::sin(0.245599970221519*x_23 + 5.0688796043396) + 0.000797958631559515*std::sin(0.414879858493805*x_23 + 5.20208024978638) + 0.0159660757871587*std::sin(0.276959955692291*x_24 + 5.09240007400513) + 0.00308187698642433*std::sin(0.326639831066132*x_24 - 4.2720799446106) - 0.0181496991512231*std::sin(0.358239859342575*x_24 + 8.34879970550537) - 0.00501499441909027*std::sin(0.311839938163757*x_26 - 4.27183961868286) + 0.00211642907291098*std::sin(0.312079936265945*x_26 - 4.2720799446106) + 0.0025197147406771*std::sin(0.346559852361679*x_26 - 4.25408029556274) - 0.00770168368591781*std::sin(0.181520000100136*x_27 - 7.61520004272461) + 0.00619097336484043*std::sin(0.222159996628761*x_27 + 5.0272798538208) + 0.00518021878613259*std::sin(0.22919999063015*x_27 - 7.55919981002808) - 0.0445910302569548*std::sin(0.250079959630966*x_27 - 7.52135992050171) + 0.00362155523189558*std::sin(0.293599933385849*x_27 + 8.32111930847168) - 0.0113433719767941*std::sin(0.301199913024902*x_27 + 5.11639976501465) - 0.000641029877788061*std::sin(0.225199982523918*x_28 - 4.36520004272461) + 0.0129698502585956*std::sin(0.279359966516495*x_28 + 5.0991997718811) - 0.00620033427021596*std::sin(0.29911994934082*x_28 - 4.28567981719971) - 0.0412369660580363*std::sin(0.327599853277206*x_28 - 4.27360010147095) - 0.000163139902983022*std::sin(0.475359857082367*x_28 + 5.25095987319946) + 0.0018959033919663*std::sin(0.285999953746796*x_3 + 8.2903995513916) + 0.00355359894345392*std::sin(0.293039947748184*x_3 + 8.30327987670898) - 0.0011939596577139*std::sin(0.300399929285049*x_3 - 4.27288007736206) - 0.0966913927052711*std::sin(0.316799849271774*x_3 + 8.31775951385498) + 0.00844961517657949*std::sin(0.321359843015671*x_3 + 8.31960010528564) - 0.0251435994335141*std::sin(0.321439832448959*x_3 + 8.32264041900635) + 0.00469384094393655*std::sin(0.368239849805832*x_3 - 1.03407979011536) - 0.00146135967093236*std::sin(0.274559944868088*x_30 + 8.28799915313721) + 0.0253178155765928*std::sin(0.275599956512451*x_30 + 8.26799964904785) - 0.00915505561105922*std::sin(0.170720010995865*x_31 + 8.43936061859131) + 0.00413137291103372*std::sin(0.270079970359802*x_32 - 7.44039964675903) + 0.015066643609383*std::sin(0.273199945688248*x_32 + 1.97919988632202) + 0.00520301980607524*std::sin(0.337679862976074*x_34 + 5.20703983306885) - 0.00574362084114287*std::sin(0.379599839448929*x_34 + 1.97711980342865) - 0.000938410214397907*std::sin(0.303839921951294*x_35 - 1.11191987991333) + 0.00220692548333224*std::sin(0.340079843997955*x_35 - 1.19399988651276) + 0.00282298822093816*std::sin(0.322799831628799*x_36 - 4.26735973358154) + 0.000482123804039281*std::sin(0.338079839944839*x_36 - 7.43224000930786) + 0.00237795106827215*std::sin(0.350559860467911*x_36 + 8.34632015228271) + 0.00829052810814702*std::sin(0.357679843902588*x_36 - 4.24528026580811) - 0.000890288329663641*std::sin(0.364799857139587*x_36 - 4.22959995269775) - 0.00135243693010822*std::sin(0.411119878292084*x_36 + 5.20232009887695) - 0.000410612738800935*std::sin(0.2360799908638*x_37 - 4.35727977752686) + 0.00130460851763867*std::sin(0.362399846315384*x_37 + 5.16695976257324) + 0.00055233445778089*std::sin(0.388159841299057*x_37 - 4.19992017745972) + 0.00488282712336047*std::sin(0.433199852705002*x_38 + 5.23192024230957) - 0.000380504496343228*std::sin(0.451359868049622*x_38 + 8.44312000274658) - 0.00441761523864291*std::sin(0.345439851284027*x_39 + 1.95567977428436) + 0.00633311878765672*std::sin(0.308479934930801*x_41 - 4.28967952728271) - 0.00592035089037388*std::sin(0.319679856300354*x_42 - 4.26688003540039) - 0.00749377246976907*std::sin(0.369279831647873*x_43 + 5.17000007629395) + 0.00207986755872884*std::sin(0.404799848794937*x_43 + 5.19200038909912) + 0.00179840931416312*std::sin(0.420399844646454*x_43 + 5.20608043670654) + 0.00556152934908979*std::sin(0.331839829683304*x_45 - 4.27144002914429) - 0.00125714472124822*std::sin(0.352159857749939*x_45 + 5.16239976882935) + 0.000684338739715452*std::sin(0.355999857187271*x_45 - 7.44447994232178) - 0.0103306451961661*std::sin(0.363999843597412*x_45 - 4.23320007324219) - 0.00100697936592166*std::sin(0.365999847650528*x_45 - 4.23720026016235) - 0.00540006854743097*std::sin(0.288639932870865*x_46 + 5.12536001205444) + 0.000351206090871803*std::sin(0.30927985906601*x_46 - 7.48751974105835) + 0.00108250465277767*std::sin(0.32847985625267*x_46 - 7.45831966400146) - 0.000816183006375891*std::sin(0.334399849176407*x_46 - 4.27008008956909) + 0.0157812651364637*std::sin(0.337759852409363*x_46 + 5.14007997512817) + 0.000305061672233979*std::sin(0.416399866342545*x_46 - 7.3724799156189) - 0.00340638971216763*std::sin(0.454959839582443*x_46 + 5.23360013961792) - 0.00102460818436088*std::sin(0.211119994521141*x_47 + 8.22288036346436) - 0.00232279487105874*std::sin(0.451359868049622*x_47 + 2.03895974159241) - 0.00103098402283121*std::sin(0.502319812774658*x_47 - 4.3219199180603) + 0.000164766252331316*std::sin(0.536159813404083*x_47 - 4.23135995864868) - 0.0157768137419829*std::sin(0.416239857673645*x_48 + 5.21384000778198) + 0.000524793939689513*std::sin(0.500239849090576*x_48 + 2.05039978027344) - 0.000444378817425761*std::sin(0.591679811477661*x_48 + 5.18351984024048) - 0.000994081457895634*std::sin(0.348399847745895*x_49 + 5.13439989089966) + 0.00583474164156453*std::sin(0.411999881267548*x_49 + 2.01895976066589) - 0.00142166976442029*std::sin(0.180480018258095*x_50 - 4.43503999710083) + 0.00348138059354276*std::sin(0.459599852561951*x_50 - 7.339439868927) - 0.00110870737188282*std::sin(0.282959938049316*x_51 + 5.10951995849609) + 0.00896972132522492*std::sin(0.322239845991135*x_51 + 5.13632011413574) + 0.00833436719998181*std::sin(0.339839845895767*x_53 + 5.13575983047485) - 0.00259465318220837*std::sin(0.435999870300293*x_53 + 8.42735958099365) + 0.00414283717567689*std::sin(0.193519994616508*x_54 - 4.41111993789673) + 0.000502103025088719*std::sin(0.465039849281311*x_54 + 8.46759986877441) - 0.0102411176622542*std::sin(0.210319995880127*x_55 - 4.39687967300415) - 0.000809012864809611*std::sin(0.265359967947006*x_55 - 4.29959964752197) + 0.000381197581542439*std::sin(0.346879839897156*x_55 - 4.23952007293701) + 0.00135725356515393*std::sin(0.349599838256836*x_55 + 1.96415984630585) - 0.00132454344887421*std::sin(0.421679854393005*x_55 + 5.23280000686646) - 0.000692612303052329*std::sin(0.289999932050705*x_56 - 4.28191947937012) + 0.0010294982468468*std::sin(0.282079964876175*x_57 - 4.2885594367981) - 0.0203751557527589*std::sin(0.197759985923767*x_58 + 4.99087953567505) + 0.00614148958763994*std::sin(0.366159826517105*x_58 + 5.17632007598877) + 0.00110362369162904*std::sin(0.38239985704422*x_58 + 5.19072008132935) - 0.000866963685543082*std::sin(0.435119867324829*x_58 + 5.24216032028198) + 0.000296600232698247*std::sin(0.467359870672226*x_58 + 2.0590398311615) + 0.00143803334175708*std::sin(0.329519838094711*x_59 - 4.26416015625) - 0.00345507321261004*std::sin(0.331599831581116*x_59 - 7.44951963424683) + 0.000899805794096582*std::sin(0.350239843130112*x_59 + 5.14416027069092) - 0.00164917735721419*std::sin(0.366159826517105*x_59 + 5.15992021560669) + 0.000887075416049505*std::sin(0.384639829397202*x_59 + 5.174880027771) + 0.00188453229272821*std::sin(0.41007986664772*x_59 - 4.20344018936157) - 0.000728051056384253*std::sin(0.562719821929932*x_59 - 4.22799968719482) + 0.00967208114202979*std::sin(0.319439828395844*x_60 - 4.28592014312744) - 0.00120869896391107*std::sin(0.355039834976196*x_60 + 5.15856027603149) + 0.0043501363899763*std::sin(0.236559987068176*x_64 + 5.06039953231812) + 0.0081087785384034*std::sin(0.264559954404831*x_64 + 5.08464002609253) - 0.00373487884795493*std::sin(0.280799955129623*x_65 + 8.31047916412354) - 0.00314637726539108*std::sin(0.343039840459824*x_65 + 5.14752006530762) + 0.000381240582880793*std::sin(0.302559942007065*x_66 - 7.21759986877441) + 0.00470514280424646*std::sin(0.358399838209152*x_66 + 8.3439998626709) + 0.000462529719973271*std::sin(0.378879845142365*x_66 + 5.16160011291504) - 0.00152506699194539*std::sin(0.237599983811378*x_67 + 5.032639503479) + 0.00451071283235851*std::sin(0.274799972772598*x_67 + 5.09183979034424) - 0.00250030103958679*std::sin(0.333919852972031*x_67 - 4.28336000442505) - 0.000686855805101664*std::sin(0.341039836406708*x_67 + 5.12520027160645) - 0.000541705592607164*std::sin(0.367839843034744*x_67 - 7.41863965988159) - 0.00104930317830928*std::sin(0.325999826192856*x_68 - 4.26984024047852) + 0.00351843067218674*std::sin(0.193519994616508*x_69 + 4.98655986785889) - 0.00112121596990503*std::sin(0.258639961481094*x_69 + 5.07599973678589) - 0.00191995147306269*std::sin(0.356879830360413*x_69 + 8.36288070678711) + 0.00106875071259021*std::sin(0.20728000998497*x_70 + 5.01175975799561) - 0.00177079207162513*std::sin(0.313279926776886*x_70 + 1.92271995544434) - 0.000100827058066741*std::sin(0.537359833717346*x_71 + 5.15304040908813) + 0.0151684690601782*std::sin(0.239039987325668*x_73 + 5.04247999191284) - 0.0132892556514568*std::sin(0.165840014815331*x_74 - 1.26447987556458) - 0.000474266263454916*std::sin(0.365199834108353*x_74 - 4.24535989761353) + 0.001131701830406*std::sin(0.321599841117859*x_75 + 5.1287202835083) + 0.00434392056784207*std::sin(0.352319836616516*x_75 - 4.25432014465332) - 0.00262670440865356*std::sin(0.178240016102791*x_76 + 4.96903991699219) - 0.00106090062981452*std::sin(0.264239966869354*x_77 - 7.53952026367188) - 0.0080060980766108*std::sin(0.234319984912872*x_78 + 5.03319978713989) - 0.000937914335243085*std::sin(0.194319993257523*x_79 + 8.17903900146484) - 0.000753503169006466*std::sin(0.211119994521141*x_79 - 7.58400011062622) + 0.00090545540848492*std::sin(0.266399949789047*x_79 + 1.87991988658905) + 0.001391152782889*std::sin(0.289679944515228*x_79 - 4.26887989044189) - 0.0056819732141177*std::sin(0.316639840602875*x_79 - 4.29895973205566) - 0.00527144047093726*std::sin(0.317599833011627*x_79 - 7.47359991073608) - 0.00868256010201643*std::sin(0.32711985707283*x_79 + 8.31087970733643) + 0.000665444686042382*std::sin(0.376959830522537*x_79 - 4.22320032119751) + 0.041779153983593*std::sin(0.204960003495216*x_8 + 8.20911979675293) + 0.00482677009236903*std::sin(0.2291199862957*x_8 + 8.25759983062744) + 0.0152119816610971*std::sin(0.305919945240021*x_8 + 5.13575983047485) - 0.000262126958897036*std::sin(0.467999875545502*x_80 - 4.13312005996704) + 0.000458374647192339*std::sin(0.496479868888855*x_80 - 4.09999990463257) - 7.19658900582003e-6*std::sin(1.71655988693237*x_80 - 1.58871984481812) + 0.0170495306205455*std::sin(0.180960014462471*x_84 - 4.41928005218506) + 0.00173736846219681*std::sin(0.225439995527267*x_84 + 8.22103977203369) - 0.000268909199739967*std::sin(0.464079856872559*x_84 - 1.13943982124329) - 5.64301813751063e-5*std::sin(1.40207982063293*x_84 - 4.79184007644653) - 1.88728959947712e-5*std::sin(1.99599981307983*x_84 - 4.20552015304565) + 0.00881972678500975*std::sin(0.148400038480759*x_85 - 7.67167997360229) + 0.000518949848327527*std::sin(0.292079925537109*x_85 + 5.12319993972778) + 0.0220177429312413*std::sin(0.257279992103577*x_86 + 1.86807990074158) - 0.000208890092110566*std::sin(0.549119889736176*x_86 + 8.37264060974121) - 0.0288215668459552*std::sin(0.162640020251274*x_87 + 4.94559955596924) - 0.0245434958768859*std::sin(0.174160018563271*x_87 - 7.61856031417847) + 0.00147709052717219*std::sin(0.217519983649254*x_87 + 5.00527954101563) - 0.00521944131659874*std::sin(0.190400004386902*x_89 + 4.97095966339111) - 0.00793094262765156*std::sin(0.306719928979874*x_89 + 5.14775991439819) + 0.014537985350163*std::sin(0.214959993958473*x_9 + 5.03159952163696) + 0.152323045931046*std::sin(0.215039998292923*x_9 - 4.37368011474609) - 0.0288546325529683*std::sin(0.22511999309063*x_9 - 4.36303997039795) - 0.0168369569272731*std::sin(0.240799978375435*x_9 - 4.34663963317871) - 0.00110655423077381*std::sin(0.273439943790436*x_9 - 4.31191968917847) + 0.0240696675049081*std::sin(0.186160013079643*x_91 - 7.37151956558228) + 0.0229686190873117*std::sin(0.189440011978149*x_91 + 2.01639986038208) + 0.0211099514352851*std::sin(0.20040000975132*x_91 + 2.00647974014282) - 0.0107609749051227*std::sin(0.34759983420372*x_92 + 5.18064022064209) + 0.0122458791898127*std::sin(0.351359844207764*x_92 - 7.38607978820801) + 0.0159946342818863*std::sin(0.361999839544296*x_92 + 2.00455975532532) + 0.00591504761548131*std::sin(0.365679860115051*x_92 + 1.99591982364655) - 0.00705993908487404*std::sin(0.366239845752716*x_92 + 1.99783980846405) - 0.00392977576844422*std::sin(0.399119853973389*x_92 - 4.40703964233398) - 0.000534307091652439*std::sin(0.404639840126038*x_92 + 2.00263977050781) - 0.000401917006868134*std::sin(0.296879917383194*x_94 - 1.11263990402222) - 0.000937510124630301*std::sin(0.375759840011597*x_94 + 5.18688011169434) - 0.000569737773747325*std::sin(0.386319845914841*x_94 + 1.98831987380981) + 0.000365671562300507*std::sin(0.412479877471924*x_94 + 5.20128011703491) - 0.000295324337764572*std::sin(0.358399868011475*x_95 - 4.21600008010864) + 0.00037715291645199*std::sin(0.374239832162857*x_95 + 1.98471975326538) - 0.0050966798946392*std::sin(0.386959850788116*x_95 - 7.40423965454102) - 0.000505729144606224*std::sin(0.472799867391586*x_95 + 2.02503991127014) - 0.00103759973593115*std::sin(0.369519859552383*x_96 - 7.43304014205933) + 0.000797577133923045*std::sin(0.374959826469421*x_96 - 7.40423965454102) + 0.000553060032424718*std::sin(0.391199827194214*x_96 + 5.18480014801025) - 0.000362795592615452*std::sin(0.33927983045578*x_97 - 4.25487995147705) - 0.00117239751645889*std::sin(0.408799856901169*x_97 - 4.18495988845825) + 0.000568302397733057*std::sin(0.529279828071594*x_97 - 4.23943996429443) - 0.000537830601723034*std::sin(0.283199936151505*x_98 + 5.1069598197937) - 0.000375847079891947*std::sin(0.345519840717316*x_98 - 4.25439977645874) + 0.00749820501837999*std::sin(0.360719859600067*x_98 - 4.22751998901367) - 0.0061570727851537*std::sin(0.361119836568832*x_98 + 5.15664005279541) - 0.00590799017311064*std::sin(0.382719844579697*x_98 + 5.17623996734619) + 0.000968570723520247*std::sin(0.386799842119217*x_98 - 7.39551973342896) + 0.0063729810882257*std::sin(0.391679853200912*x_99 - 7.39479970932007) + 0.000604893957122387*std::sin(0.398319840431213*x_99 - 4.20351982116699) - 0.000224083906553353*std::sin(0.476239860057831*x_99 - 1.14175987243652) - 0.143132513615745);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0036060537087016*x_1 + 0.000504249758996073*x_10 + 0.00158669177066284*x_100 - 0.0010216451789158*x_101 - 0.000587216341399157*x_102 + 0.00178040598881679*x_103 - 0.0011873773518973*x_104 - 0.000337249472097184*x_105 - 7.26824627812869e-5*x_106 - 0.00243360579459355*x_107 + 0.0029052459023481*x_108 - 0.00102063303520066*x_109 + 0.000763363515854101*x_11 + 0.000843934420570991*x_110 - 0.00029261282903319*x_111 + 0.000836814047857196*x_112 - 8.05695170468539e-5*x_113 - 0.000611229654977563*x_114 + 7.54876978264949e-5*x_115 - 0.00203078030712358*x_116 + 0.00048521454878447*x_117 + 0.000164066729615472*x_118 - 2.55115030955967e-5*x_119 + 0.00447592671528899*x_12 + 0.00289403015864431*x_120 + 0.00109611110860096*x_13 - 1.88088987841212e-5*x_14 - 0.000687588465854801*x_15 + 0.00334196999903279*x_16 - 0.00105925857172932*x_17 - 0.000245834568147717*x_18 + 0.00144493512742013*x_19 - 0.0402219054564123*x_2 - 0.000974849776865773*x_20 + 0.000508300610059459*x_21 - 0.000619033080716284*x_22 + 0.00180175114581279*x_23 - 0.00141848099900089*x_24 - 0.00475976940827384*x_25 - 0.00538508931367558*x_26 + 0.000822883403021816*x_27 - 2.6701604521884e-5*x_28 - 0.0107118719618313*x_29 - 0.00197143492646373*x_3 - 0.000795275963721437*x_30 + 8.19168527558735e-5*x_31 - 0.000158724503317236*x_32 - 0.00205324196205613*x_33 + 0.00286731009205499*x_34 - 0.00274939355043991*x_35 - 7.87712427169515e-5*x_36 + 0.00160426188847096*x_37 - 0.00233298428035962*x_38 + 0.00180083010523427*x_39 + 0.00675744921365084*x_4 - 0.00156296654621946*x_40 - 0.000897948533550758*x_41 + 0.000178342002978497*x_42 - 0.000650740447912503*x_43 - 0.00236241651412683*x_44 - 0.000266924037010942*x_45 - 0.00067786881471045*x_46 - 1.94952129965923e-5*x_47 + 0.000673531465944564*x_48 - 0.00117720531469435*x_49 + 0.00416320739961456*x_5 + 0.00135107414623054*x_50 - 0.000170979151963591*x_51 + 0.000561407065415224*x_52 - 0.000878646959638906*x_53 + 0.00190414904941581*x_54 - 0.000161045889996426*x_55 + 0.000947868958465488*x_56 - 8.29827555065117e-5*x_57 + 0.00117884946582292*x_58 + 0.000408978584582633*x_59 - 0.0022168471173171*x_6 - 0.00101947723134342*x_60 + 0.000158949444901933*x_61 + 0.00185035667343948*x_62 + 0.00118443722526975*x_63 - 0.00220717679319975*x_64 + 0.000895503802652966*x_65 + 0.00018363033093412*x_66 - 0.000508594109517195*x_67 - 0.000371605871848746*x_68 + 0.00019132472152442*x_69 + 0.000738524018599798*x_7 - 1.27525604688299e-5*x_70 + 0.00153633670978925*x_71 - 0.00317490782903651*x_72 - 0.00179366961142413*x_73 - 0.00124672359655958*x_74 - 0.00248831242528214*x_75 + 0.000159989737302579*x_76 - 0.00010675787001076*x_77 - 0.000539454705093528*x_78 - 1.76964020946467e-5*x_79 + 0.0019612735774166*x_8 + 0.000598660709119322*x_80 - 0.00272231436442122*x_81 + 0.00144115911300948*x_82 - 0.00226225359074027*x_83 + 0.000488224878446886*x_84 + 0.000641713993809202*x_85 - 0.00279983760694631*x_86 + 0.000180534263662744*x_87 + 0.00186521146943998*x_88 + 6.14412416802415e-5*x_89 + 0.00844940417466726*x_9 + 0.000720830051505013*x_90 + 0.0400200218421678*x_91 - 0.00160646412274291*x_92 + 0.000492004413729872*x_93 - 0.000164181030053739*x_94 + 0.000152229944387915*x_95 + 0.00115385557806032*x_96 + 0.00374575460361773*x_97 + 0.000278863402333428*x_98 + 0.00124256535662632*x_99 + 1.76368812975435e-6*std::pow(-5.50903987884521*x_13 - 8.56120014190674, 2) - 1.2261123709346e-6*std::pow(-5.40360021591187*x_14 - 8.1974401473999, 2) + 8.28856982685353e-7*std::pow(-5.1081600189209*x_14 - 7.96799993515015, 2) + 2.15485215785815e-6*std::pow(-4.90744018554688*x_14 - 7.37560033798218, 2) - 4.10092667084907e-7*std::pow(-5.78351974487305*x_15 - 7.58104038238525, 2) + 3.47437169479286e-6*std::pow(-5.33127975463867*x_15 - 7.50687980651855, 2) + 8.65466074368098e-5*std::pow(-5.31104040145874*x_15 - 7.75784015655518, 2) - 4.80331413260925e-5*std::pow(-3.07200002670288*x_15 - 4.79999971389771, 2) - 4.80313375654126e-6*std::pow(-5.25880002975464*x_17 - 7.69080018997192, 2) + 2.98393372106065e-6*std::pow(-4.46319961547852*x_17 - 6.49072027206421, 2) - 3.59301450064158e-5*std::pow(-2.07751989364624*x_17 - 2.91079998016357, 2) - 5.30303022000011e-6*std::pow(-6.5796799659729*x_18 - 9.78975963592529, 2) - 7.17646300807832e-6*std::pow(-6.57512044906616*x_18 - 9.37152004241943, 2) + 1.09717986475501e-6*std::pow(-5.29320001602173*x_18 - 8.33983993530273, 2) - 5.70858546752664e-7*std::pow(-4.91903972625732*x_18 - 9.68000030517578, 2) + 7.38505575323767e-5*std::pow(-3.24055981636047*x_2 - 5.87591981887817, 2) + 0.000268093468210805*std::pow(-3.23535990715027*x_2 - 5.85767984390259, 2) - 2.12474434574574e-6*std::pow(-5.72215986251831*x_22 - 9.58920001983643, 2) - 5.07730871206638e-5*std::pow(-5.64527988433838*x_22 - 9.06455993652344, 2) - 1.05299594339044e-5*std::pow(-4.69063997268677*x_22 - 7.54383945465088, 2) + 5.02583155789588e-6*std::pow(-3.50623989105225*x_22 - 5.77040004730225, 2) - 0.000589283971008725*std::pow(-1.23087990283966*x_23 - 1.85415983200073, 2) - 1.94991126402095e-5*std::pow(-6.78079986572266*x_27 - 9.1778392791748, 2) - 1.7713925183104e-5*std::pow(-6.60400009155273*x_27 - 9.9750394821167, 2) - 6.80848004580495e-6*std::pow(-5.82399988174438*x_4 - 9.65783977508545, 2) + 0.000104489881141907*std::pow(-3.396399974823*x_4 - 5.59624004364014, 2) - 3.13245483763808e-6*std::pow(-6.40000009536743*x_5 - 9.99995994567871, 2) - 7.63028665270431e-6*std::pow(-6.19999980926514*x_5 - 9.99948024749756, 2) - 8.90245208671984e-5*std::pow(-5.87680006027222*x_5 - 9.11728000640869, 2) + 1.62619590385336e-5*std::pow(-4.81839990615845*x_5 - 7.81911993026733, 2) - 1.18122468045899e-5*std::pow(-3.91319990158081*x_5 - 6.38520002365112, 2) - 2.47524695564248e-5*std::pow(-1.71423983573914*x_5 - 2.66727995872498, 2) + 0.000548874137977019*std::pow(-5.514479637146*x_6 - 8.792799949646, 2) + 3.14168039029932e-6*std::pow(-3.50671982765198*x_6 - 5.57079982757568, 2) + 2.34597384451879e-5*std::pow(-5.12335968017578*x_66 - 7.99567985534668, 2) + 1.44123967729367e-6*std::pow(-5.26424026489258*x_67 - 8.09687995910645, 2) + 8.44093097940959e-7*std::pow(-4.71519947052002*x_67 - 8.39935970306396, 2) - 7.21877898639536e-6*std::pow(-6.60000038146973*x_68 - 9.96571922302246, 2) + 1.93608801498572e-6*std::pow(-5.98231983184814*x_7 - 9.59111976623535, 2) + 8.86523087778981e-6*std::pow(-5.28568029403687*x_7 - 8.53200054168701, 2) + 1.63966592878013e-6*std::pow(-5.20592021942139*x_7 - 8.61111927032471, 2) - 5.99050525066282e-5*std::pow(-4.92143964767456*x_7 - 8.06775951385498, 2) + 0.000510376732219793*std::pow(-4.83440017700195*x_7 - 7.85383987426758, 2) - 6.53044115219357e-6*std::pow(-4.3101601600647*x_71 - 6.57128000259399, 2) + 1.87783558628225e-5*std::pow(-4.37599992752075*x_72 - 6.1669602394104, 2) + 1.87936194671501e-5*std::pow(-3.8711199760437*x_72 - 5.22455978393555, 2) - 3.1372993413451e-6*std::pow(-6.0*x_77 - 9.99911975860596, 2) - 1.38870128178397e-7*std::pow(-7.76000022888184*x_80 - 9.79903984069824, 2) - 2.34140163316705e-5*std::pow(-4.18959999084473*x_80 - 6.58544015884399, 2) + 1.15715932631934e-6*std::pow(-9.97459983825684*x_81 - 6.60400009155273, 2) - 3.92472392900853e-6*std::pow(-7.59576034545898*x_81 - 8.78192043304443, 2) - 1.20597773001082e-6*std::pow(-5.0*x_81 - 9.99964046478271, 2) + 3.65026848726049e-7*std::pow(-7.46039962768555*x_82 - 9.46856021881104, 2) + 1.88401262814828e-5*std::pow(-5.52776002883911*x_85 - 7.56920003890991, 2) - 3.17970355675415e-6*std::pow(-5.29983949661255*x_85 - 7.26336002349854, 2) - 1.67259373895065e-6*std::pow(-4.47440004348755*x_85 - 8.12800025939941, 2) - 7.04457604808237e-6*std::pow(-6.60000038146973*x_88 - 9.99792003631592, 2) + 1.56372354331528e-6*std::pow(-6.29087972640991*x_88 - 8.66224002838135, 2) + 5.18186953896792e-7*std::pow(-5.65199995040894*x_88 - 7.40236043930054, 2) - 2.96879807424118e-7*std::pow(-6.20728015899658*x_90 - 8.81319999694824, 2) + 4.36417909296279e-5*std::exp(0.868719875812531*x_27) + 0.000867126599868916*std::exp(0.473039865493774*x_71) - 2.17448525325771e-5*std::exp(0.530879855155945*x_71) + 0.000309159085620514*std::sin(0.228959992527962*x_1 + 5.01823997497559) - 0.0220378261230578*std::sin(0.236639991402626*x_1 + 1.97687971591949) - 0.00580704588025367*std::sin(0.276399940252304*x_1 - 1.18871986865997) + 0.0593216027512179*std::sin(0.285039931535721*x_1 + 1.9968798160553) - 0.00490543056633123*std::sin(0.297599911689758*x_1 + 1.98135983943939) - 0.00233663869940004*std::sin(0.302639931440353*x_1 - 7.43455982208252) - 0.0538881553627142*std::sin(0.311999946832657*x_1 - 7.43711996078491) + 0.0443200033495583*std::sin(0.218239992856979*x_10 - 4.37031984329224) + 0.0352853343384975*std::sin(0.269119948148727*x_10 - 4.30751943588257) + 0.00329512222111783*std::sin(0.285759955644608*x_10 + 5.09208011627197) - 0.0173007800755963*std::sin(0.294239938259125*x_10 + 5.10759973526001) + 0.000848434543695305*std::sin(0.323919832706451*x_10 - 4.27239990234375) + 0.00789183217139506*std::sin(0.368399828672409*x_101 + 8.18271923065186) + 0.00492441736514574*std::sin(0.282879948616028*x_102 - 4.32231998443604) - 0.0108035977254211*std::sin(0.383199840784073*x_102 + 5.18440008163452) + 0.000594090951202301*std::sin(0.385439842939377*x_102 + 1.96247982978821) + 9.0987669535466e-5*std::sin(0.306239932775497*x_103 - 4.27127981185913) + 0.000383212363643031*std::sin(0.361359834671021*x_103 + 1.97855985164642) - 0.00601900749324774*std::sin(0.365279853343964*x_103 - 7.4171199798584) + 0.000472275451326137*std::sin(0.321119844913483*x_105 - 4.27928018569946) - 0.00447293509553503*std::sin(0.393999844789505*x_105 - 4.1908802986145) - 0.0015425204106963*std::sin(0.241679981350899*x_106 + 5.03127956390381) - 0.000323436419517521*std::sin(0.263999968767166*x_106 + 5.06047964096069) + 0.00859964664875393*std::sin(0.353919863700867*x_106 - 7.43991994857788) + 0.0204686804169514*std::sin(0.373599827289581*x_106 - 7.40431976318359) + 0.00854895124266206*std::sin(0.374559849500656*x_106 - 7.4235200881958) + 0.00960388509893009*std::sin(0.388399839401245*x_106 - 7.39368009567261) - 0.00163262081624958*std::sin(0.485679864883423*x_106 + 5.2596001625061) + 3.32075877828198e-5*std::sin(0.539679825305939*x_106 - 7.21880006790161) - 0.0031286034482831*std::sin(0.337519854307175*x_107 - 7.45607995986938) + 0.00433180895856699*std::sin(0.345039844512939*x_107 - 4.25472021102905) - 0.00418135986331481*std::sin(0.499759823083878*x_108 + 5.28000020980835) - 0.0007502717786499*std::sin(0.333519846200943*x_109 - 7.4410400390625) + 0.0020451488190432*std::sin(0.40311986207962*x_109 + 1.98511981964111) + 0.00291419363289201*std::sin(0.471919864416122*x_109 + 2.02095985412598) - 0.000831125685014868*std::sin(0.269839972257614*x_11 + 8.28728008270264) + 0.00439897202323473*std::sin(0.289919942617416*x_11 + 8.31727981567383) + 0.00134651468845418*std::sin(0.294399946928024*x_11 + 8.31807994842529) - 0.000724333470056023*std::sin(0.41567987203598*x_110 + 5.20975971221924) - 0.000899084579794782*std::sin(0.308079928159714*x_111 + 5.13520002365112) + 0.00450217800303734*std::sin(0.447919845581055*x_111 + 5.0274395942688) + 0.00508621706959406*std::sin(0.55351984500885*x_111 - 7.41264009475708) - 0.00453819309536107*std::sin(0.241919979453087*x_112 - 1.15607988834381) - 0.00504847035753247*std::sin(0.357759833335876*x_112 + 5.15887975692749) + 0.00428089457651983*std::sin(0.437519878149033*x_112 + 8.21895980834961) - 0.00411574148491712*std::sin(0.437919855117798*x_113 - 1.18151986598969) + 0.0010517673107293*std::sin(0.347919851541519*x_114 + 8.33896064758301) - 0.000381357723678033*std::sin(0.362399846315384*x_114 - 7.42384004592896) + 0.00188872673437407*std::sin(0.386159837245941*x_114 - 7.42127990722656) - 0.00150854294442598*std::sin(0.481919854879379*x_114 - 1.14231991767883) - 0.000350179219087457*std::sin(0.294959932565689*x_115 + 8.33543968200684) + 0.0266250752723994*std::sin(0.337519854307175*x_115 + 5.14039993286133) + 0.000242067203207146*std::sin(0.396719843149185*x_115 - 7.40727996826172) - 0.00285631084764764*std::sin(0.404239863157272*x_115 + 5.19208002090454) + 2.65066308042256e-5*std::sin(0.521999835968018*x_115 + 8.35608005523682) - 0.0016269340988337*std::sin(0.53415983915329*x_115 - 4.23967981338501) - 2.3040776959297e-5*std::sin(0.638719856739044*x_115 - 4.17447996139526) - 0.000751459060529572*std::sin(0.257519960403442*x_117 - 4.34143972396851) + 0.000493139243956204*std::sin(0.393999844789505*x_117 + 5.18584012985229) - 0.00443266672397653*std::sin(0.438319861888885*x_117 - 4.16440010070801) + 0.0111919667836972*std::sin(0.476639837026596*x_117 + 5.24015998840332) + 0.00300573680925239*std::sin(0.370799839496613*x_118 - 7.40967988967896) + 0.000147861745073447*std::sin(0.390239834785461*x_118 + 5.17920017242432) + 0.00746591037263157*std::sin(0.392959833145142*x_118 - 7.40463972091675) + 0.00419604887300314*std::sin(0.393359839916229*x_118 + 5.19456005096436) + 0.00363785587506448*std::sin(0.42647984623909*x_118 - 1.16159987449646) - 0.000773912053576321*std::sin(0.328399837017059*x_119 - 4.2469596862793) + 0.0206272071595524*std::sin(0.335759848356247*x_119 - 7.44079971313477) - 0.00435774429490382*std::sin(0.343999862670898*x_119 - 7.43631982803345) - 0.000881475339402025*std::sin(0.415999859571457*x_119 - 1.17535984516144) + 0.00136778646858456*std::sin(0.421519845724106*x_119 + 1.98623979091644) - 2.82923275863367e-5*std::sin(0.433919847011566*x_119 - 1.15335988998413) + 0.00181582348759496*std::sin(0.341599822044373*x_12 - 4.25816011428833) - 0.000461066039447526*std::sin(0.392639845609665*x_12 + 5.19840002059937) + 0.000238886497030015*std::sin(0.300879925489426*x_120 + 1.90599989891052) + 0.00735174581533647*std::sin(0.331999838352203*x_120 - 1.06463980674744) + 0.00083704511899659*std::sin(0.460639864206314*x_120 + 2.05159974098206) + 0.0457766004411995*std::sin(0.203759998083115*x_13 + 8.19944000244141) - 0.166100287849018*std::sin(0.117440059781075*x_14 - 4.53320026397705) + 0.0161770074241769*std::sin(0.12216005474329*x_14 - 4.52631998062134) + 0.0197109506210785*std::sin(0.250799983739853*x_14 - 4.31239986419678) + 0.0634406876915722*std::sin(0.142320036888123*x_15 - 4.48423957824707) - 0.000624019238675326*std::sin(0.333919852972031*x_16 - 4.24720001220703) + 0.00158674018954416*std::sin(0.359999865293503*x_16 + 5.17304039001465) - 0.0113248572398433*std::sin(0.363919854164124*x_16 - 4.24200010299683) + 0.000931508774270651*std::sin(0.388799846172333*x_16 - 1.18391978740692) - 0.000353913943290237*std::sin(0.401599854230881*x_16 + 5.20815992355347) - 0.132885559664465*std::sin(0.331119894981384*x_17 - 4.21216011047363) + 0.000373826923347723*std::sin(1.23015987873077*x_17 + 5.81080007553101) + 0.00289279093006118*std::sin(0.222159996628761*x_18 - 4.37863969802856) - 0.0484420234759438*std::sin(0.269999951124191*x_18 + 8.30519962310791) - 0.0406367879579876*std::sin(0.159040033817291*x_19 - 4.45383977890015) + 0.00159521984762855*std::sin(0.326479852199554*x_21 - 4.25343990325928) - 0.00307655724382621*std::sin(0.335279852151871*x_21 + 5.160560131073) + 0.0205297536886107*std::sin(0.33679986000061*x_21 + 8.35943984985352) - 0.0188828721885157*std::sin(0.153520032763481*x_23 - 7.64976024627686) + 0.0300807376265603*std::sin(0.191040009260178*x_23 + 4.99199962615967) - 0.00942230222899647*std::sin(0.205360010266304*x_23 + 5.00831985473633) + 0.0199272220410982*std::sin(0.245599970221519*x_23 + 5.0688796043396) - 0.00907141701615264*std::sin(0.414879858493805*x_23 + 5.20208024978638) - 0.18150681733181*std::sin(0.276959955692291*x_24 + 5.09240007400513) + 0.00235820400950424*std::sin(0.326639831066132*x_24 - 4.2720799446106) - 0.00676908650694463*std::sin(0.358239859342575*x_24 + 8.34879970550537) + 0.00186707281912446*std::sin(0.311839938163757*x_26 - 4.27183961868286) + 0.00391127186602783*std::sin(0.312079936265945*x_26 - 4.2720799446106) + 0.000587943536094582*std::sin(0.346559852361679*x_26 - 4.25408029556274) - 0.00589320775231103*std::sin(0.181520000100136*x_27 - 7.61520004272461) + 0.00144458525928754*std::sin(0.222159996628761*x_27 + 5.0272798538208) - 0.0019285855345898*std::sin(0.22919999063015*x_27 - 7.55919981002808) - 0.0166306085146746*std::sin(0.250079959630966*x_27 - 7.52135992050171) + 0.00341695781679971*std::sin(0.293599933385849*x_27 + 8.32111930847168) - 0.0209631460116449*std::sin(0.301199913024902*x_27 + 5.11639976501465) + 0.000238654196006438*std::sin(0.225199982523918*x_28 - 4.36520004272461) - 0.0220865842431584*std::sin(0.279359966516495*x_28 + 5.0991997718811) + 0.0704871350219568*std::sin(0.29911994934082*x_28 - 4.28567981719971) - 0.0153796814043596*std::sin(0.327599853277206*x_28 - 4.27360010147095) - 0.000124832099080974*std::sin(0.475359857082367*x_28 + 5.25095987319946) + 0.00145071558672266*std::sin(0.285999953746796*x_3 + 8.2903995513916) - 0.0403983071919758*std::sin(0.293039947748184*x_3 + 8.30327987670898) + 0.000444508894279716*std::sin(0.300399929285049*x_3 - 4.27288007736206) - 0.0141305686593245*std::sin(0.316799849271774*x_3 + 8.31775951385498) + 0.00197161073249967*std::sin(0.321359843015671*x_3 + 8.31960010528564) - 0.0464666897340024*std::sin(0.321439832448959*x_3 + 8.32264041900635) + 0.00442866544266498*std::sin(0.368239849805832*x_3 - 1.03407979011536) - 0.000340989778947398*std::sin(0.274559944868088*x_30 + 8.28799915313721) + 0.0238875019982649*std::sin(0.275599956512451*x_30 + 8.26799964904785) + 0.0155903038950239*std::sin(0.170720010995865*x_31 + 8.43936061859131) - 0.00153810222370246*std::sin(0.270079970359802*x_32 - 7.44039964675903) + 0.00220185309189732*std::sin(0.273199945688248*x_32 + 1.97919988632202) + 0.00194051101735734*std::sin(0.337679862976074*x_34 + 5.20703983306885) + 0.00978091211844099*std::sin(0.379599839448929*x_34 + 1.97711980342865) - 0.000718056801066683*std::sin(0.303839921951294*x_35 - 1.11191987991333) + 0.00407851397614039*std::sin(0.340079843997955*x_35 - 1.19399988651276) - 0.00480731588384169*std::sin(0.322799831628799*x_36 - 4.26735973358154) - 0.00606983146813692*std::sin(0.338079839944839*x_36 - 7.43224000930786) + 0.00439457822195343*std::sin(0.350559860467911*x_36 + 8.34632015228271) + 0.00782216009714234*std::sin(0.357679843902588*x_36 - 4.24528026580811) + 0.000331452640340173*std::sin(0.364799857139587*x_36 - 4.22959995269775) + 0.0153748814735917*std::sin(0.411119878292084*x_36 + 5.20232009887695) + 0.000152870336382258*std::sin(0.2360799908638*x_37 - 4.35727977752686) + 0.000304413881737054*std::sin(0.362399846315384*x_37 + 5.16695976257324) - 0.00695376798383852*std::sin(0.388159841299057*x_37 - 4.19992017745972) + 0.00182109240054567*std::sin(0.433199852705002*x_38 + 5.23192024230957) - 0.000291156082109582*std::sin(0.451359868049622*x_38 + 8.44312000274658) - 0.000645594335686085*std::sin(0.345439851284027*x_39 + 1.95567977428436) + 0.00597533334729179*std::sin(0.308479934930801*x_41 - 4.28967952728271) - 0.00558588450478267*std::sin(0.319679856300354*x_42 - 4.26688003540039) - 0.00707041665204519*std::sin(0.369279831647873*x_43 + 5.17000007629395) + 0.000303953749332201*std::sin(0.404799848794937*x_43 + 5.19200038909912) - 0.00306254259139347*std::sin(0.420399844646454*x_43 + 5.20608043670654) - 0.00947082534033595*std::sin(0.331839829683304*x_45 - 4.27144002914429) - 0.000961947454500531*std::sin(0.352159857749939*x_45 + 5.16239976882935) - 0.000254778002370816*std::sin(0.355999857187271*x_45 - 7.44447994232178) - 0.00385290303837833*std::sin(0.363999843597412*x_45 - 4.23320007324219) + 0.0126776462639415*std::sin(0.365999847650528*x_45 - 4.23720026016235) - 0.000789170961753787*std::sin(0.288639932870865*x_46 + 5.12536001205444) + 8.19494951677089e-5*std::sin(0.30927985906601*x_46 - 7.48751974105835) + 0.000828315608874797*std::sin(0.32847985625267*x_46 - 7.45831966400146) + 0.000303863370382802*std::sin(0.334399849176407*x_46 - 4.27008008956909) + 0.0148897127930322*std::sin(0.337759852409363*x_46 + 5.14007997512817) - 0.00384065860746715*std::sin(0.416399866342545*x_46 - 7.3724799156189) + 0.00580080045973987*std::sin(0.454959839582443*x_46 + 5.23360013961792) + 0.00038145966503781*std::sin(0.211119994521141*x_47 + 8.22288036346436) - 0.000866306338693462*std::sin(0.451359868049622*x_47 + 2.03895974159241) + 0.0117205148715719*std::sin(0.502319812774658*x_47 - 4.3219199180603) + 3.84461191026307e-5*std::sin(0.536159813404083*x_47 - 4.23135995864868) - 0.0148855128771969*std::sin(0.416239857673645*x_48 + 5.21384000778198) + 0.000122454022132341*std::sin(0.500239849090576*x_48 + 2.05039978027344) - 0.000821235348116579*std::sin(0.591679811477661*x_48 + 5.18351984024048) - 0.000760655564809926*std::sin(0.348399847745895*x_49 + 5.13439989089966) + 0.00550511169498727*std::sin(0.411999881267548*x_49 + 2.01895976066589) + 0.000529284930969418*std::sin(0.180480018258095*x_50 - 4.43503999710083) + 0.00328470225377022*std::sin(0.459599852561951*x_50 - 7.339439868927) - 0.000848365519213815*std::sin(0.282959938049316*x_51 + 5.10951995849609) + 0.00846298273371909*std::sin(0.322239845991135*x_51 + 5.13632011413574) + 0.00310837397839274*std::sin(0.339839845895767*x_53 + 5.13575983047485) - 0.000379184991678493*std::sin(0.435999870300293*x_53 + 8.42735958099365) + 0.00317003413226415*std::sin(0.193519994616508*x_54 - 4.41111993789673) - 0.00632136541775468*std::sin(0.465039849281311*x_54 + 8.46759986877441) - 0.00149664631179539*std::sin(0.210319995880127*x_55 - 4.39687967300415) - 0.000619043975453426*std::sin(0.265359967947006*x_55 - 4.29959964752197) - 0.00479919277297387*std::sin(0.346879839897156*x_55 - 4.23952007293701) + 0.00250827573312012*std::sin(0.349599838256836*x_55 + 1.96415984630585) + 0.0150577805734969*std::sin(0.421679854393005*x_55 + 5.23280000686646) - 0.000161612312705593*std::sin(0.289999932050705*x_56 - 4.28191947937012) - 0.012961153966572*std::sin(0.282079964876175*x_57 - 4.2885594367981) - 0.0192240745370216*std::sin(0.197759985923767*x_58 + 4.99087953567505) + 0.00229052139949289*std::sin(0.366159826517105*x_58 + 5.17632007598877) + 0.00203955443203836*std::sin(0.38239985704422*x_58 + 5.19072008132935) - 0.000663387036000527*std::sin(0.435119867324829*x_58 + 5.24216032028198) - 0.00373413096554318*std::sin(0.467359870672226*x_58 + 2.0590398311615) + 0.000335546875336916*std::sin(0.329519838094711*x_59 - 4.26416015625) - 0.0012885992913226*std::sin(0.331599831581116*x_59 - 7.44951963424683) - 0.0113283548301514*std::sin(0.350239843130112*x_59 + 5.14416027069092) + 0.0187483096857392*std::sin(0.366159826517105*x_59 + 5.15992021560669) - 0.000330256478753968*std::sin(0.384639829397202*x_59 + 5.174880027771) + 0.000275407274712453*std::sin(0.41007986664772*x_59 - 4.20344018936157) - 0.000686920283924359*std::sin(0.562719821929932*x_59 - 4.22799968719482) + 0.00912566318798935*std::sin(0.319439828395844*x_60 - 4.28592014312744) - 0.000924877519620201*std::sin(0.355039834976196*x_60 + 5.15856027603149) + 0.00803928007476101*std::sin(0.236559987068176*x_64 + 5.06039953231812) + 0.00765067835151937*std::sin(0.264559954404831*x_64 + 5.08464002609253) + 0.00636019033902706*std::sin(0.280799955129623*x_65 + 8.31047916412354) - 0.000459814454346178*std::sin(0.343039840459824*x_65 + 5.14752006530762) - 0.00479973415026021*std::sin(0.302559942007065*x_66 - 7.21759986877441) + 0.00175482350446156*std::sin(0.358399838209152*x_66 + 8.3439998626709) - 0.00017219892905803*std::sin(0.378879845142365*x_66 + 5.16160011291504) - 0.000355855075795029*std::sin(0.237599983811378*x_67 + 5.032639503479) + 0.00833603375740275*std::sin(0.274799972772598*x_67 + 5.09183979034424) - 0.00235904815321476*std::sin(0.333919852972031*x_67 - 4.28336000442505) + 0.00780836899510089*std::sin(0.341039836406708*x_67 + 5.12520027160645) + 0.00681995293516938*std::sin(0.367839843034744*x_67 - 7.41863965988159) + 0.000390653563996896*std::sin(0.325999826192856*x_68 - 4.26984024047852) + 0.00650224431181408*std::sin(0.193519994616508*x_69 + 4.98655986785889) + 0.000417426558603766*std::sin(0.258639961481094*x_69 + 5.07599973678589) - 0.000716062426270097*std::sin(0.356879830360413*x_69 + 8.36288070678711) + 0.00024937944880024*std::sin(0.20728000998497*x_70 + 5.01175975799561) - 0.00327251657000075*std::sin(0.313279926776886*x_70 + 1.92271995544434) - 2.35267175671813e-5*std::sin(0.537359833717346*x_71 + 5.15304040908813) + 0.0143115362338218*std::sin(0.239039987325668*x_73 + 5.04247999191284) - 0.0125384877683965*std::sin(0.165840014815331*x_74 - 1.26447987556458) - 0.000110664028544405*std::sin(0.365199834108353*x_74 - 4.24535989761353) + 0.000264068295205041*std::sin(0.321599841117859*x_75 + 5.1287202835083) + 0.00409851359137658*std::sin(0.352319836616516*x_75 - 4.25432014465332) + 0.0330696243237978*std::sin(0.178240016102791*x_76 + 4.96903991699219) + 0.0133565029842206*std::sin(0.264239966869354*x_77 - 7.53952026367188) - 0.0147956889103954*std::sin(0.234319984912872*x_78 + 5.03319978713989) + 0.000349183711019406*std::sin(0.194319993257523*x_79 + 8.17903900146484) + 0.00948643731808708*std::sin(0.211119994521141*x_79 - 7.58400011062622) - 0.0102934704570395*std::sin(0.266399949789047*x_79 + 1.87991988658905) + 0.00257092326442869*std::sin(0.289679944515228*x_79 - 4.26887989044189) - 0.00211914081308136*std::sin(0.316639840602875*x_79 - 4.29895973205566) + 0.00897682792960462*std::sin(0.317599833011627*x_79 - 7.47359991073608) - 0.0012688772829473*std::sin(0.32711985707283*x_79 + 8.31087970733643) + 0.000509187853259882*std::sin(0.376959830522537*x_79 - 4.22320032119751) - 0.0711464500875768*std::sin(0.204960003495216*x_8 + 8.20911979675293) + 0.00369336889010164*std::sin(0.2291199862957*x_8 + 8.25759983062744) + 0.0143525906185595*std::sin(0.305919945240021*x_8 + 5.13575983047485) + 0.00330012011526945*std::sin(0.467999875545502*x_80 - 4.13312005996704) + 0.000847100375160664*std::sin(0.496479868888855*x_80 - 4.09999990463257) - 1.67923293839374e-6*std::sin(1.71655988693237*x_80 - 1.58871984481812) + 0.0160863284407638*std::sin(0.180960014462471*x_84 - 4.41928005218506) - 0.0218730825469295*std::sin(0.225439995527267*x_84 + 8.22103977203369) - 6.27465574698328e-5*std::sin(0.464079856872559*x_84 - 1.13943982124329) - 0.000104285933146688*std::sin(1.40207982063293*x_84 - 4.79184007644653) + 7.0263430395586e-6*std::sin(1.99599981307983*x_84 - 4.20552015304565) + 0.00674871682379288*std::sin(0.148400038480759*x_85 - 7.67167997360229) - 0.000193204034806653*std::sin(0.292079925537109*x_85 + 5.12319993972778) + 0.0207738648176886*std::sin(0.257279992103577*x_86 + 1.86807990074158) - 4.87418585238763e-5*std::sin(0.549119889736176*x_86 + 8.37264060974121) - 0.0271933111110264*std::sin(0.162640020251274*x_87 + 4.94559955596924) - 0.00915370802508776*std::sin(0.174160018563271*x_87 - 7.61856031417847) + 0.00113024654096256*std::sin(0.217519983649254*x_87 + 5.00527954101563) + 0.059336069442182*std::sin(0.190400004386902*x_89 + 4.97095966339111) - 0.00748288916526053*std::sin(0.306719928979874*x_89 + 5.14775991439819) + 0.00542206676000551*std::sin(0.214959993958473*x_9 + 5.03159952163696) - 0.259393571942043*std::sin(0.215039998292923*x_9 - 4.37368011474609) - 0.0272245087923572*std::sin(0.22511999309063*x_9 - 4.36303997039795) - 0.0311155789636687*std::sin(0.240799978375435*x_9 - 4.34663963317871) + 0.0139312716669009*std::sin(0.273439943790436*x_9 - 4.31191968917847) - 0.0409886566500368*std::sin(0.186160013079643*x_91 - 7.37151956558228) + 0.00335665502318734*std::sin(0.189440011978149*x_91 + 2.01639986038208) + 0.0078731380742041*std::sin(0.20040000975132*x_91 + 2.00647974014282) - 0.00401339820704008*std::sin(0.34759983420372*x_92 + 5.18064022064209) + 0.0115540561835678*std::sin(0.351359844207764*x_92 - 7.38607978820801) - 0.201368888389558*std::sin(0.361999839544296*x_92 + 2.00455975532532) + 0.0045261018089565*std::sin(0.365679860115051*x_92 + 1.99591982364655) + 0.00262840180237606*std::sin(0.366239845752716*x_92 + 1.99783980846405) - 0.000574301028851801*std::sin(0.399119853973389*x_92 - 4.40703964233398) - 0.000124673795709958*std::sin(0.404639840126038*x_92 + 2.00263977050781) - 0.000307540599855039*std::sin(0.296879917383194*x_94 - 1.11263990402222) - 0.00173256785285947*std::sin(0.375759840011597*x_94 + 5.18688011169434) - 0.000132941096837669*std::sin(0.386319845914841*x_94 + 1.98831987380981) - 0.000136138822428022*std::sin(0.412479877471924*x_94 + 5.20128011703491) + 0.000109948685439652*std::sin(0.358399868011475*x_95 - 4.21600008010864) - 0.00474827133902184*std::sin(0.374239832162857*x_95 + 1.98471975326538) - 0.00480874626799436*std::sin(0.386959850788116*x_95 - 7.40423965454102) + 0.00574927043395614*std::sin(0.472799867391586*x_95 + 2.02503991127014) - 0.00191753870105531*std::sin(0.369519859552383*x_96 - 7.43304014205933) + 0.000610293533256316*std::sin(0.374959826469421*x_96 - 7.40423965454102) + 0.000129049557033981*std::sin(0.391199827194214*x_96 + 5.18480014801025) + 0.000135068104421408*std::sin(0.33927983045578*x_97 - 4.25487995147705) - 0.00216665206532032*std::sin(0.408799856901169*x_97 - 4.18495988845825) + 0.00043485609544068*std::sin(0.529279828071594*x_97 - 4.23943996429443) + 0.00677116766173924*std::sin(0.283199936151505*x_98 + 5.1069598197937) - 0.000287592299973656*std::sin(0.345519840717316*x_98 - 4.25439977645874) + 0.0070745987866958*std::sin(0.360719859600067*x_98 - 4.22751998901367) - 0.00229633328712511*std::sin(0.361119836568832*x_98 + 5.15664005279541) - 0.000863399093177021*std::sin(0.382719844579697*x_98 + 5.17623996734619) + 0.0017899694677471*std::sin(0.386799842119217*x_98 - 7.39551973342896) + 0.000931353291251544*std::sin(0.391679853200912*x_99 - 7.39479970932007) - 0.0076154803912735*std::sin(0.398319840431213*x_99 - 4.20351982116699) - 0.000171465496263236*std::sin(0.476239860057831*x_99 - 1.14175987243652) + 0.493969611307492);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00466108205129963*x_1 - 0.00037533489767389*x_10 + 0.00266059084046122*x_100 - 0.00233445464108275*x_101 - 0.00197512938789592*x_102 - 0.00332947315842325*x_103 - 0.0010865626219653*x_104 + 0.000163498750684517*x_105 + 8.01406357710984e-5*x_106 - 0.00148534296549889*x_107 + 0.00151790094987354*x_108 - 0.00201189681560078*x_109 - 3.34264869712262e-5*x_11 - 0.00137380787300169*x_110 + 0.000361830429442793*x_111 - 0.0002648980528366*x_112 + 0.00331320387547876*x_113 - 0.00207816235258657*x_114 - 0.000172925361173282*x_115 - 0.00210919494076542*x_116 + 0.000479192514886527*x_117 + 0.000869365907795818*x_118 + 0.00237914680603741*x_119 - 0.000814859873220581*x_12 + 0.00225809652741742*x_120 + 0.000462508361512298*x_13 + 0.000176865118938948*x_14 - 0.00326153087213053*x_15 - 0.00122686665402914*x_16 - 0.00165846550566101*x_17 - 0.00043460493120763*x_18 + 0.00380813669969488*x_19 - 0.0490065280805731*x_2 + 0.00033390772260762*x_20 + 0.000587558214184916*x_21 - 0.00152884939961569*x_22 - 0.000290848302346067*x_23 - 0.0048165504451167*x_24 - 0.00157866561308023*x_25 + 1.00296885718993e-6*x_26 - 0.000451635196099693*x_27 + 5.90900885748467e-6*x_28 - 0.0186784292777017*x_29 - 0.00310547354908106*x_3 - 0.00114226046386842*x_30 + 0.00024268514559367*x_31 - 0.006805738347157*x_32 - 0.00439198158562925*x_33 + 0.000557857731985538*x_34 - 0.00313396327702912*x_35 + 8.77735374253413e-5*x_36 + 0.000637267008409342*x_37 - 0.000373218729970708*x_38 + 0.00294764349692789*x_39 + 0.0289048125062326*x_4 + 0.000409335416983444*x_40 - 0.000514303883450163*x_41 - 0.00145623459721921*x_42 + 0.000496109996285439*x_43 - 0.00102316418001483*x_44 + 6.48240847640987e-7*x_45 - 2.72430977695526e-5*x_46 - 0.00120313758616268*x_47 + 0.00107031155056787*x_48 + 0.00108360818033791*x_49 + 0.0120189647604383*x_5 + 0.000429681494410749*x_50 + 0.000838659615148225*x_51 - 0.00546889008137792*x_52 - 0.00130508957517548*x_53 - 0.000498794885987946*x_54 + 9.05175301677871e-5*x_55 - 0.00125082060296107*x_56 - 0.00124581115956345*x_57 + 3.00186359744476e-5*x_58 + 0.00162278597361081*x_59 - 0.00546145314227403*x_6 + 0.00172328777099286*x_60 - 0.000388373862162869*x_61 - 0.00240403756704274*x_62 - 0.00263762610784949*x_63 + 0.000350147464881209*x_64 + 7.07060964096784e-5*x_65 + 0.000298386405379981*x_66 - 0.00129264552664722*x_67 - 0.000649781290223948*x_68 - 4.91778230575419e-5*x_69 - 0.000265934311747132*x_7 - 0.000846220841042958*x_70 - 0.000300638786674057*x_71 - 5.22139429076427e-6*x_72 + 0.00165509920094893*x_73 + 0.00127044779169523*x_74 - 0.0007552549447922*x_75 - 4.97057309278686e-5*x_76 + 0.000448894240549985*x_77 - 0.000356805184747925*x_78 - 2.60203945209083e-5*x_79 - 0.000982979988117116*x_8 + 0.00172907670207237*x_80 + 0.00303851277709523*x_81 + 0.00316853751165659*x_82 - 0.000813252249651288*x_83 - 0.000314617463994528*x_84 + 0.000135650854784994*x_85 - 0.00139387350305766*x_86 - 0.000513981238244809*x_87 + 0.00061671714032972*x_88 + 0.000765268618006332*x_89 - 9.73183418375881e-5*x_9 - 0.000190940651316804*x_90 - 0.0168803867860528*x_91 - 0.00916523002825165*x_92 - 0.00105256458199593*x_93 - 0.000118502428517728*x_94 - 0.000231588345907048*x_95 + 0.00168363083327905*x_96 + 0.00311076567127497*x_97 + 0.000603937770809901*x_98 + 0.00127947325015528*x_99 - 1.26292952255713e-5*std::pow(-5.50903987884521*x_13 - 8.56120014190674, 2) + 3.74964330582293e-7*std::pow(-5.40360021591187*x_14 - 8.1974401473999, 2) + 2.34919828795498e-6*std::pow(-5.1081600189209*x_14 - 7.96799993515015, 2) - 1.54303153771525e-5*std::pow(-4.90744018554688*x_14 - 7.37560033798218, 2) + 2.93656303236478e-6*std::pow(-5.78351974487305*x_15 - 7.58104038238525, 2) + 9.8472815064949e-6*std::pow(-5.33127975463867*x_15 - 7.50687980651855, 2) + 1.63604096142197e-5*std::pow(-5.31104040145874*x_15 - 7.75784015655518, 2) - 4.92782193163079e-6*std::pow(-3.07200002670288*x_15 - 4.79999971389771, 2) + 1.89158826323208e-5*std::pow(-5.25880002975464*x_17 - 7.69080018997192, 2) + 8.45725153472932e-6*std::pow(-4.46319961547852*x_17 - 6.49072027206421, 2) + 1.09880000311766e-5*std::pow(-2.07751989364624*x_17 - 2.91079998016357, 2) - 5.44049127347451e-7*std::pow(-6.5796799659729*x_18 - 9.78975963592529, 2) - 8.21738434709631e-7*std::pow(-6.57512044906616*x_18 - 9.37152004241943, 2) - 7.85660922346481e-6*std::pow(-5.29320001602173*x_18 - 8.33983993530273, 2) + 2.2481766732656e-6*std::pow(-4.91903972625732*x_18 - 9.68000030517578, 2) + 8.45623275432153e-6*std::pow(-3.24055981636047*x_2 - 5.87591981887817, 2) - 0.000147141679664213*std::pow(-3.23535990715027*x_2 - 5.85767984390259, 2) + 8.36774837117082e-6*std::pow(-5.72215986251831*x_22 - 9.58920001983643, 2) + 3.3287038767994e-7*std::pow(-5.64527988433838*x_22 - 9.06455993652344, 2) + 3.2202262074748e-6*std::pow(-4.69063997268677*x_22 - 7.54383945465088, 2) + 1.42445260617912e-5*std::pow(-3.50623989105225*x_22 - 5.77040004730225, 2) - 0.00165815793010374*std::pow(-1.23087990283966*x_23 - 1.85415983200073, 2) + 1.27836961509472e-7*std::pow(-6.78079986572266*x_27 - 9.1778392791748, 2) - 4.98443652987015e-5*std::pow(-6.60400009155273*x_27 - 9.9750394821167, 2) + 2.68134130713206e-5*std::pow(-5.82399988174438*x_4 - 9.65783977508545, 2) + 1.97523312195789e-5*std::pow(-3.396399974823*x_4 - 5.59624004364014, 2) + 9.57953658341222e-7*std::pow(-6.40000009536743*x_5 - 9.99995994567871, 2) - 8.73703355444176e-7*std::pow(-6.19999980926514*x_5 - 9.99948024749756, 2) + 4.88606366246913e-5*std::pow(-5.87680006027222*x_5 - 9.11728000640869, 2) + 1.6683488980521e-6*std::pow(-4.81839990615845*x_5 - 7.81911993026733, 2) - 2.2329378575405e-6*std::pow(-3.91319990158081*x_5 - 6.38520002365112, 2) + 0.000177245761490494*std::pow(-1.71423983573914*x_5 - 2.66727995872498, 2) - 3.59844077752652e-6*std::pow(-5.514479637146*x_6 - 8.792799949646, 2) + 8.90434700843273e-6*std::pow(-3.50671982765198*x_6 - 5.57079982757568, 2) - 1.53802982524211e-7*std::pow(-5.12335968017578*x_66 - 7.99567985534668, 2) - 4.40753623905722e-7*std::pow(-5.26424026489258*x_67 - 8.09687995910645, 2) - 3.32423929474346e-6*std::pow(-4.71519947052002*x_67 - 8.39935970306396, 2) - 8.26583811289473e-7*std::pow(-6.60000038146973*x_68 - 9.96571922302246, 2) - 1.3863804326534e-5*std::pow(-5.98231983184814*x_7 - 9.59111976623535, 2) + 2.49454483838151e-5*std::pow(-5.28568029403687*x_7 - 8.53200054168701, 2) + 4.64724370207862e-6*std::pow(-5.20592021942139*x_7 - 8.61111927032471, 2) + 3.28785706903802e-5*std::pow(-4.92143964767456*x_7 - 8.06775951385498, 2) - 3.34605024731068e-6*std::pow(-4.83440017700195*x_7 - 7.85383987426758, 2) - 1.2344873516787e-6*std::pow(-4.3101601600647*x_71 - 6.57128000259399, 2) + 5.2839515785486e-5*std::pow(-4.37599992752075*x_72 - 6.1669602394104, 2) + 2.15195694955581e-6*std::pow(-3.8711199760437*x_72 - 5.22455978393555, 2) - 5.93061979284436e-7*std::pow(-6.0*x_77 - 9.99911975860596, 2) + 9.94411549972939e-7*std::pow(-7.76000022888184*x_80 - 9.79903984069824, 2) - 2.68101390740739e-6*std::pow(-4.18959999084473*x_80 - 6.58544015884399, 2) - 6.35100765602596e-7*std::pow(-9.97459983825684*x_81 - 6.60400009155273, 2) - 4.4939916703542e-7*std::pow(-7.59576034545898*x_81 - 8.78192043304443, 2) - 2.27972998976413e-7*std::pow(-5.0*x_81 - 9.99964046478271, 2) - 2.6138588563633e-6*std::pow(-7.46039962768555*x_82 - 9.46856021881104, 2) + 5.30133286067849e-5*std::pow(-5.52776002883911*x_85 - 7.56920003890991, 2) - 3.26212537645249e-7*std::pow(-5.29983949661255*x_85 - 7.26336002349854, 2) + 5.1150531266862e-7*std::pow(-4.47440004348755*x_85 - 8.12800025939941, 2) - 8.06636763601776e-7*std::pow(-6.60000038146973*x_88 - 9.99792003631592, 2) - 6.15831507387556e-6*std::pow(-6.29087972640991*x_88 - 8.66224002838135, 2) - 3.7105970791523e-6*std::pow(-5.65199995040894*x_88 - 7.40236043930054, 2) + 2.12587626531917e-6*std::pow(-6.20728015899658*x_90 - 8.81319999694824, 2) - 1.33463419089939e-5*std::exp(0.868719875812531*x_27) + 9.9290033832721e-5*std::exp(0.473039865493774*x_71) + 0.000155709026804346*std::exp(0.530879855155945*x_71) + 0.000876238011885273*std::sin(0.228959992527962*x_1 + 5.01823997497559) - 0.00416593871277305*std::sin(0.236639991402626*x_1 + 1.97687971591949) + 0.00177588541047852*std::sin(0.276399940252304*x_1 - 1.18871986865997) + 0.00679259977155592*std::sin(0.285039931535721*x_1 + 1.9968798160553) + 0.0193187517893608*std::sin(0.297599911689758*x_1 + 1.98135983943939) + 0.0167320397934119*std::sin(0.302639931440353*x_1 - 7.43455982208252) - 0.00552850025045641*std::sin(0.311999946832657*x_1 - 7.43711996078491) - 0.000290563712659094*std::sin(0.218239992856979*x_10 - 4.37031984329224) + 0.0992877115757751*std::sin(0.269119948148727*x_10 - 4.30751943588257) - 0.0235954818954491*std::sin(0.285759955644608*x_10 + 5.09208011627197) - 0.00327046728999688*std::sin(0.294239938259125*x_10 + 5.10759973526001) - 0.00334133694026124*std::sin(0.323919832706451*x_10 - 4.27239990234375) + 0.00149183903048967*std::sin(0.368399828672409*x_101 + 8.18271923065186) + 0.000930891314994455*std::sin(0.282879948616028*x_102 - 4.32231998443604) - 0.00123706225115724*std::sin(0.383199840784073*x_102 + 5.18440008163452) - 0.00233967140526998*std::sin(0.385439842939377*x_102 + 1.96247982978821) - 0.000651538172233527*std::sin(0.306239932775497*x_103 - 4.27127981185913) - 0.00150918139309651*std::sin(0.361359834671021*x_103 + 1.97855985164642) - 0.000689204388072414*std::sin(0.365279853343964*x_103 - 7.4171199798584) - 0.00338183718649762*std::sin(0.321119844913483*x_105 - 4.27928018569946) - 0.0125861777417851*std::sin(0.393999844789505*x_105 - 4.1908802986145) + 0.000471726855480127*std::sin(0.241679981350899*x_106 + 5.03127956390381) + 0.00231604100513929*std::sin(0.263999968767166*x_106 + 5.06047964096069) - 0.00471987050210938*std::sin(0.353919863700867*x_106 - 7.43991994857788) + 0.00234375922894937*std::sin(0.373599827289581*x_106 - 7.40431976318359) + 0.0240554842732698*std::sin(0.374559849500656*x_106 - 7.4235200881958) - 6.29634544087707e-5*std::sin(0.388399839401245*x_106 - 7.39368009567261) - 0.000308623828126907*std::sin(0.485679864883423*x_106 + 5.2596001625061) + 9.41190217325217e-5*std::sin(0.539679825305939*x_106 - 7.21880006790161) - 0.000591418143937572*std::sin(0.337519854307175*x_107 - 7.45607995986938) + 0.000496012298686281*std::sin(0.345039844512939*x_107 - 4.25472021102905) - 0.000790426824739897*std::sin(0.499759823083878*x_108 + 5.28000020980835) + 0.00295474863425494*std::sin(0.333519846200943*x_109 - 7.4410400390625) + 0.000386606400788318*std::sin(0.40311986207962*x_109 + 1.98511981964111) + 0.000333688742161397*std::sin(0.471919864416122*x_109 + 2.02095985412598) - 0.00235562838595706*std::sin(0.269839972257614*x_11 + 8.28728008270264) - 0.00134527441288693*std::sin(0.289919942617416*x_11 + 8.31727981567383) - 0.00530289496410706*std::sin(0.294399946928024*x_11 + 8.31807994842529) + 0.00285259740842774*std::sin(0.41567987203598*x_110 + 5.20975971221924) + 0.0035408088239821*std::sin(0.308079928159714*x_111 + 5.13520002365112) - 2.95164588616321e-5*std::sin(0.447919845581055*x_111 + 5.0274395942688) - 0.00279154329179102*std::sin(0.55351984500885*x_111 - 7.41264009475708) - 0.000519644243465647*std::sin(0.241919979453087*x_112 - 1.15607988834381) - 0.000954341775150256*std::sin(0.357759833335876*x_112 + 5.15887975692749) + 0.0120458041270723*std::sin(0.437519878149033*x_112 + 8.21895980834961) - 0.000471271566742308*std::sin(0.437919855117798*x_113 - 1.18151986598969) - 0.00414210971725961*std::sin(0.347919851541519*x_114 + 8.33896064758301) + 0.0027307998492639*std::sin(0.362399846315384*x_114 - 7.42384004592896) + 0.000193768484999128*std::sin(0.386159837245941*x_114 - 7.42127990722656) - 0.000285168664866152*std::sin(0.481919854879379*x_114 - 1.14231991767883) + 0.00010709027947322*std::sin(0.294959932565689*x_115 + 8.33543968200684) - 0.000174555057226848*std::sin(0.337519854307175*x_115 + 5.14039993286133) - 0.000953318195389547*std::sin(0.396719843149185*x_115 - 7.40727996826172) - 0.000539945086665283*std::sin(0.404239863157272*x_115 + 5.19208002090454) + 7.51267504594093e-5*std::sin(0.521999835968018*x_115 + 8.35608005523682) - 0.000186291530834396*std::sin(0.53415983915329*x_115 - 4.23967981338501) + 0.000164988792256617*std::sin(0.638719856739044*x_115 - 4.17447996139526) + 0.000229807928107513*std::sin(0.257519960403442*x_117 - 4.34143972396851) - 0.00194209958183305*std::sin(0.393999844789505*x_117 + 5.18584012985229) + 0.00243284564711855*std::sin(0.438319861888885*x_117 - 4.16440010070801) - 7.3374981382097e-5*std::sin(0.476639837026596*x_117 + 5.24015998840332) + 0.000308364919728826*std::sin(0.370799839496613*x_118 - 7.40967988967896) - 0.00105879809451391*std::sin(0.390239834785461*x_118 + 5.17920017242432) - 0.00409762535351172*std::sin(0.392959833145142*x_118 - 7.40463972091675) + 0.000793203573851684*std::sin(0.393359839916229*x_118 + 5.19456005096436) - 2.38499284587254e-5*std::sin(0.42647984623909*x_118 - 1.16159987449646) + 0.0030478496571642*std::sin(0.328399837017059*x_119 - 4.2469596862793) - 0.000135232794248594*std::sin(0.335759848356247*x_119 - 7.44079971313477) - 0.000823769801845898*std::sin(0.343999862670898*x_119 - 7.43631982803345) + 0.000269568938703181*std::sin(0.415999859571457*x_119 - 1.17535984516144) + 0.000140324117298933*std::sin(0.421519845724106*x_119 + 1.98623979091644) - 8.01878839371671e-5*std::sin(0.433919847011566*x_119 - 1.15335988998413) + 0.00514652047023395*std::sin(0.341599822044373*x_12 - 4.25816011428833) + 0.0018157876773806*std::sin(0.392639845609665*x_12 + 5.19840002059937) - 0.00171060180396793*std::sin(0.300879925489426*x_120 + 1.90599989891052) + 0.000841809132420423*std::sin(0.331999838352203*x_120 - 1.06463980674744) - 0.00329648267807103*std::sin(0.460639864206314*x_120 + 2.05159974098206) - 0.000300113221386735*std::sin(0.203759998083115*x_13 + 8.19944000244141) - 0.0313989054768419*std::sin(0.117440059781075*x_14 - 4.53320026397705) - 0.0637089011650314*std::sin(0.12216005474329*x_14 - 4.52631998062134) + 0.055463699489869*std::sin(0.250799983739853*x_14 - 4.31239986419678) + 0.00726425417951602*std::sin(0.142320036888123*x_15 - 4.48423957824707) - 0.00176863434557508*std::sin(0.333919852972031*x_16 - 4.24720001220703) - 0.0113622187290126*std::sin(0.359999865293503*x_16 + 5.17304039001465) - 0.0021408037675154*std::sin(0.363919854164124*x_16 - 4.24200010299683) - 0.000284869945247913*std::sin(0.388799846172333*x_16 - 1.18391978740692) + 0.0013937972483283*std::sin(0.401599854230881*x_16 + 5.20815992355347) + 0.000871203038283917*std::sin(0.331119894981384*x_17 - 4.21216011047363) + 4.28049236090652e-5*std::sin(1.23015987873077*x_17 + 5.81080007553101) - 0.000884660688789983*std::sin(0.222159996628761*x_18 - 4.37863969802856) + 0.000317587841293101*std::sin(0.269999951124191*x_18 + 8.30519962310791) - 0.00768180886679219*std::sin(0.159040033817291*x_19 - 4.45383977890015) - 0.006282355008206*std::sin(0.326479852199554*x_21 - 4.25343990325928) - 0.00031563053844677*std::sin(0.335279852151871*x_21 + 5.160560131073) - 0.00013459388539958*std::sin(0.33679986000061*x_21 + 8.35943984985352) - 0.00193723394168687*std::sin(0.153520032763481*x_23 - 7.64976024627686) - 0.0091991598118917*std::sin(0.191040009260178*x_23 + 4.99199962615967) + 0.0371072662399259*std::sin(0.205360010266304*x_23 + 5.00831985473633) + 0.00376695892214965*std::sin(0.245599970221519*x_23 + 5.0688796043396) + 5.94725723845972e-5*std::sin(0.414879858493805*x_23 + 5.20208024978638) + 0.00118996594609672*std::sin(0.276959955692291*x_24 + 5.09240007400513) - 0.00928716802985152*std::sin(0.326639831066132*x_24 - 4.2720799446106) - 0.000694454953915491*std::sin(0.358239859342575*x_24 + 8.34879970550537) - 0.0133696051147357*std::sin(0.311839938163757*x_26 - 4.27183961868286) + 0.000739370516487429*std::sin(0.312079936265945*x_26 - 4.2720799446106) + 0.00166638633354183*std::sin(0.346559852361679*x_26 - 4.25408029556274) + 0.0232088531823174*std::sin(0.181520000100136*x_27 - 7.61520004272461) + 0.0040943338703965*std::sin(0.222159996628761*x_27 + 5.0272798538208) + 0.0138100810870078*std::sin(0.22919999063015*x_27 - 7.55919981002808) - 0.00170616943036496*std::sin(0.250079959630966*x_27 - 7.52135992050171) + 0.000391257582556354*std::sin(0.293599933385849*x_27 + 8.32111930847168) - 0.00396278566786822*std::sin(0.301199913024902*x_27 + 5.11639976501465) - 0.00170893835896399*std::sin(0.225199982523918*x_28 - 4.36520004272461) - 0.062148381109038*std::sin(0.279359966516495*x_28 + 5.0991997718811) - 0.000462116473348298*std::sin(0.29911994934082*x_28 - 4.28567981719971) - 0.00157783416269566*std::sin(0.327599853277206*x_28 - 4.27360010147095) + 0.000491618483817185*std::sin(0.475359857082367*x_28 + 5.25095987319946) - 0.00571326287425419*std::sin(0.285999953746796*x_3 + 8.2903995513916) + 0.000264852915968023*std::sin(0.293039947748184*x_3 + 8.30327987670898) - 0.00318300835705726*std::sin(0.300399929285049*x_3 - 4.27288007736206) + 0.00432134879615644*std::sin(0.316799849271774*x_3 + 8.31775951385498) + 0.00558806242096914*std::sin(0.321359843015671*x_3 + 8.31960010528564) - 0.00878386917731226*std::sin(0.321439832448959*x_3 + 8.32264041900635) + 0.000507102817169352*std::sin(0.368239849805832*x_3 - 1.03407979011536) - 0.000966454553254898*std::sin(0.274559944868088*x_30 + 8.28799915313721) + 0.00273523022122197*std::sin(0.275599956512451*x_30 + 8.26799964904785) + 0.0438688091108429*std::sin(0.170720010995865*x_31 + 8.43936061859131) + 0.0110139353678995*std::sin(0.270079970359802*x_32 - 7.44039964675903) - 0.000673361096597133*std::sin(0.273199945688248*x_32 + 1.97919988632202) + 0.000199081144516154*std::sin(0.337679862976074*x_34 + 5.20703983306885) + 0.0275220399514322*std::sin(0.379599839448929*x_34 + 1.97711980342865) + 0.00282787839372976*std::sin(0.303839921951294*x_35 - 1.11191987991333) + 0.000770985267281509*std::sin(0.340079843997955*x_35 - 1.19399988651276) - 0.0135270758199323*std::sin(0.322799831628799*x_36 - 4.26735973358154) + 0.00333139484322717*std::sin(0.338079839944839*x_36 - 7.43224000930786) + 0.000830732733751367*std::sin(0.350559860467911*x_36 + 8.34632015228271) + 0.000895673758373496*std::sin(0.357679843902588*x_36 - 4.24528026580811) - 0.00237344300136225*std::sin(0.364799857139587*x_36 - 4.22959995269775) - 0.000100798337207365*std::sin(0.411119878292084*x_36 + 5.20232009887695) - 0.00109466326661326*std::sin(0.2360799908638*x_37 - 4.35727977752686) + 0.000862788858325745*std::sin(0.362399846315384*x_37 + 5.16695976257324) + 0.00381653871676084*std::sin(0.388159841299057*x_37 - 4.19992017745972) + 0.000186829735119994*std::sin(0.433199852705002*x_38 + 5.23192024230957) + 0.00114664187091828*std::sin(0.451359868049622*x_38 + 8.44312000274658) + 0.000197432840289943*std::sin(0.345439851284027*x_39 + 1.95567977428436) + 0.000684203494973025*std::sin(0.308479934930801*x_41 - 4.28967952728271) - 0.000639609788869799*std::sin(0.319679856300354*x_42 - 4.26688003540039) - 0.000809595633093398*std::sin(0.369279831647873*x_43 + 5.17000007629395) - 9.29538081892549e-5*std::sin(0.404799848794937*x_43 + 5.19200038909912) - 0.0086175418542385*std::sin(0.420399844646454*x_43 + 5.20608043670654) - 0.0266495016245284*std::sin(0.331839829683304*x_45 - 4.27144002914429) + 0.00378837776961989*std::sin(0.352159857749939*x_45 + 5.16239976882935) + 0.00182439658953224*std::sin(0.355999857187271*x_45 - 7.44447994232178) - 0.000395277501508191*std::sin(0.363999843597412*x_45 - 4.23320007324219) - 0.00695805898560086*std::sin(0.365999847650528*x_45 - 4.23720026016235) + 0.000241340817043904*std::sin(0.288639932870865*x_46 + 5.12536001205444) + 0.000232266383427259*std::sin(0.30927985906601*x_46 - 7.48751974105835) - 0.00326210379185396*std::sin(0.32847985625267*x_46 - 7.45831966400146) - 0.00217588367697186*std::sin(0.334399849176407*x_46 - 4.27008008956909) + 0.00170494145514987*std::sin(0.337759852409363*x_46 + 5.14007997512817) + 0.00210792512884042*std::sin(0.416399866342545*x_46 - 7.3724799156189) + 0.0163225944646044*std::sin(0.454959839582443*x_46 + 5.23360013961792) - 0.00273152982385896*std::sin(0.211119994521141*x_47 + 8.22288036346436) - 8.88762062498171e-5*std::sin(0.451359868049622*x_47 + 2.03895974159241) - 7.68401637630746e-5*std::sin(0.502319812774658*x_47 - 4.3219199180603) + 0.000108966394759443*std::sin(0.536159813404083*x_47 - 4.23135995864868) - 0.00170446054522801*std::sin(0.416239857673645*x_48 + 5.21384000778198) + 0.000347066846459445*std::sin(0.500239849090576*x_48 + 2.05039978027344) - 0.000155242904173608*std::sin(0.591679811477661*x_48 + 5.18351984024048) + 0.00299564245279886*std::sin(0.348399847745895*x_49 + 5.13439989089966) + 0.000630360925994917*std::sin(0.411999881267548*x_49 + 2.01895976066589) - 0.00379006670107255*std::sin(0.180480018258095*x_50 - 4.43503999710083) + 0.000376113704684602*std::sin(0.459599852561951*x_50 - 7.339439868927) + 0.00334106510544322*std::sin(0.282959938049316*x_51 + 5.10951995849609) + 0.000969050934527587*std::sin(0.322239845991135*x_51 + 5.13632011413574) + 0.000318894684785345*std::sin(0.339839845895767*x_53 + 5.13575983047485) + 0.000115960698172552*std::sin(0.435999870300293*x_53 + 8.42735958099365) - 0.0124843480581186*std::sin(0.193519994616508*x_54 - 4.41111993789673) + 0.00346944791884418*std::sin(0.465039849281311*x_54 + 8.46759986877441) + 0.000457697838896328*std::sin(0.210319995880127*x_55 - 4.39687967300415) + 0.0024379423471135*std::sin(0.265359967947006*x_55 - 4.29959964752197) + 0.00263401152725014*std::sin(0.346879839897156*x_55 - 4.23952007293701) + 0.000474153980549893*std::sin(0.349599838256836*x_55 + 1.96415984630585) - 9.87194110373378e-5*std::sin(0.421679854393005*x_55 + 5.23280000686646) - 0.000458051722132319*std::sin(0.289999932050705*x_56 - 4.28191947937012) + 0.00711366068616148*std::sin(0.282079964876175*x_57 - 4.2885594367981) - 0.00220124605965515*std::sin(0.197759985923767*x_58 + 4.99087953567505) + 0.000234989452608615*std::sin(0.366159826517105*x_58 + 5.17632007598877) + 0.000385548861207618*std::sin(0.38239985704422*x_58 + 5.19072008132935) + 0.00261257586168605*std::sin(0.435119867324829*x_58 + 5.24216032028198) + 0.00204945799695552*std::sin(0.467359870672226*x_58 + 2.0590398311615) + 0.000951027935502554*std::sin(0.329519838094711*x_59 - 4.26416015625) - 0.000132200136687999*std::sin(0.331599831581116*x_59 - 7.44951963424683) + 0.00621750753073178*std::sin(0.350239843130112*x_59 + 5.14416027069092) - 0.000122914667343434*std::sin(0.366159826517105*x_59 + 5.15992021560669) + 0.0023648776107159*std::sin(0.384639829397202*x_59 + 5.174880027771) - 8.42238499896491e-5*std::sin(0.41007986664772*x_59 - 4.20344018936157) - 7.86555714489008e-5*std::sin(0.562719821929932*x_59 - 4.22799968719482) + 0.00104493093259791*std::sin(0.319439828395844*x_60 - 4.28592014312744) + 0.00364238755303907*std::sin(0.355039834976196*x_60 + 5.15856027603149) + 0.00151971196701795*std::sin(0.236559987068176*x_64 + 5.06039953231812) + 0.000876038299921209*std::sin(0.264559954404831*x_64 + 5.08464002609253) + 0.0178966348424074*std::sin(0.280799955129623*x_65 + 8.31047916412354) + 0.000140618448319346*std::sin(0.343039840459824*x_65 + 5.14752006530762) + 0.00263430865930552*std::sin(0.302559942007065*x_66 - 7.21759986877441) + 0.000180031068397548*std::sin(0.358399838209152*x_66 + 8.3439998626709) + 0.00123307010798104*std::sin(0.378879845142365*x_66 + 5.16160011291504) - 0.00100858670709314*std::sin(0.237599983811378*x_67 + 5.032639503479) + 0.00157580904518583*std::sin(0.274799972772598*x_67 + 5.09183979034424) - 0.000270121999464807*std::sin(0.333919852972031*x_67 - 4.28336000442505) - 5.11919790965288e-5*std::sin(0.341039836406708*x_67 + 5.12520027160645) - 0.00374309503625295*std::sin(0.367839843034744*x_67 - 7.41863965988159) - 0.00279736485572739*std::sin(0.325999826192856*x_68 - 4.26984024047852) + 0.00122915713860511*std::sin(0.193519994616508*x_69 + 4.98655986785889) - 0.00298907905239202*std::sin(0.258639961481094*x_69 + 5.07599973678589) - 7.3462364342049e-5*std::sin(0.356879830360413*x_69 + 8.36288070678711) + 0.000706806827246185*std::sin(0.20728000998497*x_70 + 5.01175975799561) - 0.000618622880089487*std::sin(0.313279926776886*x_70 + 1.92271995544434) - 6.66808940318762e-5*std::sin(0.537359833717346*x_71 + 5.15304040908813) + 0.00163873754659261*std::sin(0.239039987325668*x_73 + 5.04247999191284) - 0.00143571524033912*std::sin(0.165840014815331*x_74 - 1.26447987556458) - 0.000313650909415583*std::sin(0.365199834108353*x_74 - 4.24535989761353) + 0.000748438874206079*std::sin(0.321599841117859*x_75 + 5.1287202835083) + 0.000469298892702824*std::sin(0.352319836616516*x_75 - 4.25432014465332) - 0.0181500881067419*std::sin(0.178240016102791*x_76 + 4.96903991699219) - 0.00733064589993277*std::sin(0.264239966869354*x_77 - 7.53952026367188) - 0.00279691530688102*std::sin(0.234319984912872*x_78 + 5.03319978713989) - 0.00250041041838779*std::sin(0.194319993257523*x_79 + 8.17903900146484) - 0.00520658086274237*std::sin(0.211119994521141*x_79 - 7.58400011062622) + 6.74844035672644e-5*std::sin(0.266399949789047*x_79 + 1.87991988658905) + 0.000485996608515133*std::sin(0.289679944515228*x_79 - 4.26887989044189) - 0.000217407154448246*std::sin(0.316639840602875*x_79 - 4.29895973205566) + 0.0252594659806729*std::sin(0.317599833011627*x_79 - 7.47359991073608) + 0.000388042509210432*std::sin(0.32711985707283*x_79 + 8.31087970733643) - 0.00200530282067413*std::sin(0.376959830522537*x_79 - 4.22320032119751) - 0.200195586873852*std::sin(0.204960003495216*x_8 + 8.20911979675293) - 0.0145453647523104*std::sin(0.2291199862957*x_8 + 8.25759983062744) + 0.00164343846483247*std::sin(0.305919945240021*x_8 + 5.13575983047485) - 0.00181125344117889*std::sin(0.467999875545502*x_80 - 4.13312005996704) + 0.000160132320982153*std::sin(0.496479868888855*x_80 - 4.09999990463257) - 4.75938699481248e-6*std::sin(1.71655988693237*x_80 - 1.58871984481812) + 0.00184195951937024*std::sin(0.180960014462471*x_84 - 4.41928005218506) + 0.012004925471957*std::sin(0.225439995527267*x_84 + 8.22103977203369) - 0.000177840216662755*std::sin(0.464079856872559*x_84 - 1.13943982124329) - 1.9713777741394e-5*std::sin(1.40207982063293*x_84 - 4.79184007644653) - 5.03137482787748e-5*std::sin(1.99599981307983*x_84 - 4.20552015304565) - 0.0265780512949032*std::sin(0.148400038480759*x_85 - 7.67167997360229) + 0.00138348200749337*std::sin(0.292079925537109*x_85 + 5.12319993972778) + 0.00237870426405611*std::sin(0.257279992103577*x_86 + 1.86807990074158) - 0.000138147223209799*std::sin(0.549119889736176*x_86 + 8.37264060974121) - 0.00311376075955424*std::sin(0.162640020251274*x_87 + 4.94559955596924) - 0.000939098337448706*std::sin(0.174160018563271*x_87 - 7.61856031417847) - 0.00445117958360372*std::sin(0.217519983649254*x_87 + 5.00527954101563) - 0.000389009641893226*std::sin(0.190400004386902*x_89 + 4.97095966339111) - 0.000856825656712106*std::sin(0.306719928979874*x_89 + 5.14775991439819) + 0.000556261338672997*std::sin(0.214959993958473*x_9 + 5.03159952163696) - 0.729895143079102*std::sin(0.215039998292923*x_9 - 4.37368011474609) - 0.00311733303935203*std::sin(0.22511999309063*x_9 - 4.36303997039795) - 0.00588195923914059*std::sin(0.240799978375435*x_9 - 4.34663963317871) - 0.0076461046462886*std::sin(0.273439943790436*x_9 - 4.31191968917847) - 0.115336016949886*std::sin(0.186160013079643*x_91 - 7.37151956558228) - 0.00102651757995538*std::sin(0.189440011978149*x_91 + 2.01639986038208) + 0.000807721947840727*std::sin(0.20040000975132*x_91 + 2.00647974014282) - 0.000411743041554444*std::sin(0.34759983420372*x_92 + 5.18064022064209) + 0.00132299323944742*std::sin(0.351359844207764*x_92 - 7.38607978820801) + 0.110520247537164*std::sin(0.361999839544296*x_92 + 2.00455975532532) - 0.017824864961039*std::sin(0.365679860115051*x_92 + 1.99591982364655) - 0.0188212767175874*std::sin(0.366239845752716*x_92 + 1.99783980846405) + 0.000175630232547115*std::sin(0.399119853973389*x_92 - 4.40703964233398) - 0.00035335826753343*std::sin(0.404639840126038*x_92 + 2.00263977050781) + 0.00121116799706211*std::sin(0.296879917383194*x_94 - 1.11263990402222) - 0.000327517398968018*std::sin(0.375759840011597*x_94 + 5.18688011169434) - 0.00037678996933596*std::sin(0.386319845914841*x_94 + 1.98831987380981) + 0.000974853405825548*std::sin(0.412479877471924*x_94 + 5.20128011703491) - 0.000787312895434769*std::sin(0.358399868011475*x_95 - 4.21600008010864) + 0.0026060635680081*std::sin(0.374239832162857*x_95 + 1.98471975326538) - 0.000550623841679299*std::sin(0.386959850788116*x_95 - 7.40423965454102) - 3.76924466633215e-5*std::sin(0.472799867391586*x_95 + 2.02503991127014) - 0.00036248351644851*std::sin(0.369519859552383*x_96 - 7.43304014205933) - 0.00240348102540743*std::sin(0.374959826469421*x_96 - 7.40423965454102) + 0.000365760323890115*std::sin(0.391199827194214*x_96 + 5.18480014801025) - 0.000967186282834389*std::sin(0.33927983045578*x_97 - 4.25487995147705) - 0.000409574867576602*std::sin(0.408799856901169*x_97 - 4.18495988845825) - 0.0017125666867184*std::sin(0.529279828071594*x_97 - 4.23943996429443) - 0.00371631949739595*std::sin(0.283199936151505*x_98 + 5.1069598197937) + 0.00113260684961192*std::sin(0.345519840717316*x_98 - 4.25439977645874) + 0.000810074506986801*std::sin(0.360719859600067*x_98 - 4.22751998901367) - 0.000235585706498065*std::sin(0.361119836568832*x_98 + 5.15664005279541) + 0.000264040940025512*std::sin(0.382719844579697*x_98 + 5.17623996734619) + 0.000338368360777989*std::sin(0.386799842119217*x_98 - 7.39551973342896) - 0.000284822396110037*std::sin(0.391679853200912*x_99 - 7.39479970932007) + 0.00417971606581909*std::sin(0.398319840431213*x_99 - 4.20351982116699) + 0.000675271888564602*std::sin(0.476239860057831*x_99 - 1.14175987243652) + 0.740158392063424);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00324164109973402*x_1 - 0.00120156339647663*x_10 + 0.00057791231085228*x_100 - 0.00123412982192501*x_101 + 0.000170003561880174*x_102 - 0.00210385958599549*x_103 + 0.00165356832292912*x_104 + 0.00141302216175989*x_105 - 0.000416754892857074*x_106 + 0.000174144046037181*x_107 + 0.00102004516078304*x_108 - 0.000625184412398199*x_109 - 0.000448269756659319*x_11 - 0.000716944179287035*x_110 - 0.000219690011395372*x_111 + 0.000912857611551188*x_112 + 0.000289247032322615*x_113 - 0.000102637756106949*x_114 + 0.000391411048466118*x_115 + 0.00217807527367111*x_116 - 0.000143518763853696*x_117 + 0.000151399427098786*x_118 + 0.000320191172785107*x_119 - 0.00107079867278006*x_12 - 0.000364769554653217*x_120 - 0.00108538401845739*x_13 - 1.26715694848242e-5*x_14 - 0.00219483420901296*x_15 - 0.000268817307749362*x_16 + 0.00284651175337968*x_17 - 0.000255283474988662*x_18 + 0.00192009415730244*x_19 - 0.0252501832241489*x_2 - 0.00815229141457756*x_20 + 0.00016047661224145*x_21 - 0.000836987869950492*x_22 - 0.000264242295755882*x_23 - 0.00118173257891272*x_24 - 0.00404589599820922*x_25 + 0.000836385817943868*x_26 - 2.21278680902001e-6*x_27 - 0.000139208285795551*x_28 - 0.00507981187328079*x_29 - 0.00172625294493296*x_3 + 0.000576952254283474*x_30 + 0.00676084672301973*x_31 - 0.00487301840183542*x_32 + 0.000155938976781993*x_33 - 0.00253747000784914*x_34 - 0.000455193653078559*x_35 - 0.000266049479103618*x_36 + 0.00126220097986633*x_37 + 5.68288357252625e-5*x_38 + 0.000207532175918656*x_39 + 0.00755690102467821*x_4 + 0.00137428993187515*x_40 + 0.000630493603336447*x_41 - 0.00305496560347736*x_42 + 0.000305808356489388*x_43 - 0.00089826070672611*x_44 - 0.000300568328608392*x_45 + 0.00032407062029859*x_46 + 0.0016696304258181*x_47 - 0.000435599215738096*x_48 - 0.000174259042370961*x_49 + 0.00284767761894904*x_5 - 0.000396329655699307*x_50 - 0.000324082776287783*x_51 - 0.00134762524114052*x_52 + 9.78092266381465e-5*x_53 - 0.00178931173194925*x_54 + 0.000226842468037867*x_55 - 0.000174431725868474*x_56 - 0.00111299293184575*x_57 - 0.000378916920025194*x_58 + 0.00100291580457171*x_59 - 0.0023383946998868*x_6 + 0.000361010404358195*x_60 - 0.000316953353669031*x_61 + 0.00162735273856695*x_62 - 0.00123610019016442*x_63 + 0.00151793026523836*x_64 - 0.000784458124574163*x_65 + 0.00146052817309664*x_66 - 0.000361898606056235*x_67 + 0.00145737425226396*x_68 + 0.000597137572102617*x_69 + 0.00229566134741478*x_7 - 0.000635648128731991*x_70 - 0.000304818598227744*x_71 + 0.000486467459939161*x_72 + 0.000249000894521781*x_73 + 0.00135367519522586*x_74 + 0.000810826744743597*x_75 + 0.000399862355292082*x_76 - 0.000677357599962076*x_77 - 0.00237726062437664*x_78 + 8.43508335549377e-5*x_79 + 0.00122030126886015*x_8 - 0.000726084260751818*x_80 - 0.00163301445622091*x_81 + 0.000696722482281047*x_82 + 0.000712405923338059*x_83 + 0.000625169628275862*x_84 - 0.000150253606399407*x_85 - 0.000458997852052677*x_86 + 2.49181426496178e-5*x_87 + 0.000574858566236544*x_88 + 0.00120245991150485*x_89 - 0.00257513685552521*x_9 - 0.00114103665032899*x_90 - 0.00329708745615577*x_91 - 0.00308333919498005*x_92 + 0.000332867272746643*x_93 + 7.2976064755139e-5*x_94 - 0.000667677744967119*x_95 - 0.000545974629883495*x_96 - 0.00157398004278704*x_97 + 0.000127741279651589*x_98 - 0.000348170052628338*x_99 + 7.63584224188763e-6*std::pow(-5.50903987884521*x_13 - 8.56120014190674, 2) - 3.20379008200346e-6*std::pow(-5.40360021591187*x_14 - 8.1974401473999, 2) - 7.8866494554997e-6*std::pow(-5.1081600189209*x_14 - 7.96799993515015, 2) + 9.32937680670771e-6*std::pow(-4.90744018554688*x_14 - 7.37560033798218, 2) - 1.77548561879329e-6*std::pow(-5.78351974487305*x_15 - 7.58104038238525, 2) - 3.30589621700075e-5*std::pow(-5.33127975463867*x_15 - 7.50687980651855, 2) + 0.00015889523775645*std::pow(-3.07200002670288*x_15 - 4.79999971389771, 2) - 0.000129722733142345*std::pow(-5.25880002975464*x_17 - 7.69080018997192, 2) - 2.83924003151986e-5*std::pow(-4.46319961547852*x_17 - 6.49072027206421, 2) - 9.38842515133885e-5*std::pow(-2.07751989364624*x_17 - 2.91079998016357, 2) + 1.75426013034635e-5*std::pow(-6.5796799659729*x_18 - 9.78975963592529, 2) + 3.29463358587864e-7*std::pow(-6.57512044906616*x_18 - 9.37152004241943, 2) + 4.75021190929701e-6*std::pow(-5.29320001602173*x_18 - 8.33983993530273, 2) - 1.54177115766496e-5*std::pow(-4.91903972625732*x_18 - 9.68000030517578, 2) - 3.3903961729914e-6*std::pow(-3.24055981636047*x_2 - 5.87591981887817, 2) - 7.20920713509113e-7*std::pow(-3.23535990715027*x_2 - 5.85767984390259, 2) - 5.73849610961826e-5*std::pow(-5.72215986251831*x_22 - 9.58920001983643, 2) + 1.43540006285463e-5*std::pow(-5.64527988433838*x_22 - 9.06455993652344, 2) - 2.75144272237679e-5*std::pow(-4.69063997268677*x_22 - 7.54383945465088, 2) - 4.7821243649412e-5*std::pow(-3.50623989105225*x_22 - 5.77040004730225, 2) - 0.000441482006081234*std::pow(-1.23087990283966*x_23 - 1.85415983200073, 2) + 5.51257154067655e-6*std::pow(-6.78079986572266*x_27 - 9.1778392791748, 2) - 1.32709858237326e-5*std::pow(-6.60400009155273*x_27 - 9.9750394821167, 2) - 0.000183882999069953*std::pow(-5.82399988174438*x_4 - 9.65783977508545, 2) - 8.18499835663426e-6*std::pow(-6.40000009536743*x_5 - 9.99995994567871, 2) + 3.50297892535403e-7*std::pow(-6.19999980926514*x_5 - 9.99948024749756, 2) + 2.39392707072305e-7*std::pow(-5.87680006027222*x_5 - 9.11728000640869, 2) - 5.37951043066551e-5*std::pow(-4.81839990615845*x_5 - 7.81911993026733, 2) - 0.000107165178152166*std::pow(-1.71423983573914*x_5 - 2.66727995872498, 2) - 0.00015517157156096*std::pow(-5.514479637146*x_6 - 8.792799949646, 2) - 2.98933741973602e-5*std::pow(-3.50671982765198*x_6 - 5.57079982757568, 2) - 6.63227547278115e-6*std::pow(-5.12335968017578*x_66 - 7.99567985534668, 2) + 3.76591044455714e-6*std::pow(-5.26424026489258*x_67 - 8.09687995910645, 2) + 2.27972130783091e-5*std::pow(-4.71519947052002*x_67 - 8.39935970306396, 2) + 3.31406037637776e-7*std::pow(-6.60000038146973*x_68 - 9.96571922302246, 2) + 8.38224309583545e-6*std::pow(-5.98231983184814*x_7 - 9.59111976623535, 2) + 6.64168737798911e-6*std::pow(-5.28568029403687*x_7 - 8.53200054168701, 2) - 1.56015702039687e-5*std::pow(-5.20592021942139*x_7 - 8.61111927032471, 2) + 1.61088569162457e-7*std::pow(-4.92143964767456*x_7 - 8.06775951385498, 2) - 0.000144288014586704*std::pow(-4.83440017700195*x_7 - 7.85383987426758, 2) + 1.40684400477329e-5*std::pow(-4.37599992752075*x_72 - 6.1669602394104, 2) - 8.62793967264877e-7*std::pow(-3.8711199760437*x_72 - 5.22455978393555, 2) - 6.01234636096714e-7*std::pow(-7.76000022888184*x_80 - 9.79903984069824, 2) + 1.07491119928853e-6*std::pow(-4.18959999084473*x_80 - 6.58544015884399, 2) - 3.111676434123e-9*std::pow(-9.97459983825684*x_81 - 6.60400009155273, 2) + 1.80179668692747e-7*std::pow(-7.59576034545898*x_81 - 8.78192043304443, 2) + 1.58037432123201e-6*std::pow(-7.46039962768555*x_82 - 9.46856021881104, 2) + 1.41147174448593e-5*std::pow(-5.52776002883911*x_85 - 7.56920003890991, 2) + 1.05185656964523e-5*std::pow(-5.29983949661255*x_85 - 7.26336002349854, 2) - 4.37043076890789e-6*std::pow(-4.47440004348755*x_85 - 8.12800025939941, 2) + 3.23408576344119e-7*std::pow(-6.60000038146973*x_88 - 9.99792003631592, 2) + 4.22329466968588e-5*std::pow(-6.29087972640991*x_88 - 8.66224002838135, 2) + 2.24347704393254e-6*std::pow(-5.65199995040894*x_88 - 7.40236043930054, 2) - 1.28533346460084e-6*std::pow(-6.20728015899658*x_90 - 8.81319999694824, 2) + 0.000114034521024067*std::exp(0.868719875812531*x_27) - 3.98088085442787e-5*std::exp(0.473039865493774*x_71) - 9.41437778656453e-5*std::exp(0.530879855155945*x_71) - 0.00294167677320202*std::sin(0.228959992527962*x_1 + 5.01823997497559) - 0.0151736141302567*std::sin(0.276399940252304*x_1 - 1.18871986865997) - 0.00272338817286885*std::sin(0.285039931535721*x_1 + 1.9968798160553) - 0.132485558920333*std::sin(0.297599911689758*x_1 + 1.98135983943939) - 0.0101164169469084*std::sin(0.302639931440353*x_1 - 7.43455982208252) + 0.178263819983884*std::sin(0.311999946832657*x_1 - 7.43711996078491) - 0.0125296567928765*std::sin(0.218239992856979*x_10 - 4.37031984329224) + 0.0264352009479252*std::sin(0.269119948148727*x_10 - 4.30751943588257) + 0.0142661466183925*std::sin(0.285759955644608*x_10 + 5.09208011627197) + 0.0229144665710473*std::sin(0.323919832706451*x_10 - 4.27239990234375) + 0.000495981040721975*std::sin(0.383199840784073*x_102 + 5.18440008163452) + 0.0160451708887229*std::sin(0.385439842939377*x_102 + 1.96247982978821) + 0.000393928767115188*std::sin(0.306239932775497*x_103 - 4.27127981185913) + 0.0103497753145041*std::sin(0.361359834671021*x_103 + 1.97855985164642) + 0.000276325875554388*std::sin(0.365279853343964*x_103 - 7.4171199798584) + 0.00204470437840104*std::sin(0.321119844913483*x_105 - 4.27928018569946) - 0.00335105052266681*std::sin(0.393999844789505*x_105 - 4.1908802986145) - 0.00403055356933537*std::sin(0.241679981350899*x_106 + 5.03127956390381) - 0.00140030963130696*std::sin(0.263999968767166*x_106 + 5.06047964096069) - 2.31250072570625e-5*std::sin(0.353919863700867*x_106 - 7.43991994857788) - 0.000939694134623046*std::sin(0.373599827289581*x_106 - 7.40431976318359) + 0.00640473579832909*std::sin(0.374559849500656*x_106 - 7.4235200881958) - 0.00271510322819084*std::sin(0.388399839401245*x_106 - 7.39368009567261) - 0.000315973213204206*std::sin(0.539679825305939*x_106 - 7.21880006790161) - 0.00019886848530313*std::sin(0.345039844512939*x_107 - 4.25472021102905) - 0.020263292812424*std::sin(0.333519846200943*x_109 - 7.4410400390625) - 0.000133787357475012*std::sin(0.471919864416122*x_109 + 2.02095985412598) + 0.00790823636417698*std::sin(0.269839972257614*x_11 + 8.28728008270264) + 0.0114943648503501*std::sin(0.289919942617416*x_11 + 8.31727981567383) + 0.0363665836631566*std::sin(0.294399946928024*x_11 + 8.31807994842529) - 0.0195627526121215*std::sin(0.41567987203598*x_110 + 5.20975971221924) - 0.0242824195470881*std::sin(0.308079928159714*x_111 + 5.13520002365112) - 0.00127280552651533*std::sin(0.447919845581055*x_111 + 5.0274395942688) - 1.36771673824995e-5*std::sin(0.55351984500885*x_111 - 7.41264009475708) + 0.000208343349284299*std::sin(0.241919979453087*x_112 - 1.15607988834381) + 0.00320717687642019*std::sin(0.437519878149033*x_112 + 8.21895980834961) + 0.000188949070199875*std::sin(0.437919855117798*x_113 - 1.18151986598969) + 0.0284060651010953*std::sin(0.347919851541519*x_114 + 8.33896064758301) - 0.00165107842288218*std::sin(0.362399846315384*x_114 - 7.42384004592896) - 0.00624797119717645*std::sin(0.386159837245941*x_114 - 7.42127990722656) - 0.000915006434672009*std::sin(0.294959932565689*x_115 + 8.33543968200684) - 0.0075271441794914*std::sin(0.337519854307175*x_115 + 5.14039993286133) + 0.00653773573583901*std::sin(0.396719843149185*x_115 - 7.40727996826172) - 0.000252212999065286*std::sin(0.521999835968018*x_115 + 8.35608005523682) + 7.46907176696227e-5*std::sin(0.53415983915329*x_115 - 4.23967981338501) - 9.97544492269253e-5*std::sin(0.638719856739044*x_115 - 4.17447996139526) - 0.0019635370641609*std::sin(0.257519960403442*x_117 - 4.34143972396851) + 0.0133186735552862*std::sin(0.393999844789505*x_117 + 5.18584012985229) + 1.1919728140801e-5*std::sin(0.438319861888885*x_117 - 4.16440010070801) - 0.00316406796116356*std::sin(0.476639837026596*x_117 + 5.24015998840332) - 0.00994307787819059*std::sin(0.370799839496613*x_118 - 7.40967988967896) + 0.000640163609395215*std::sin(0.390239834785461*x_118 + 5.17920017242432) - 2.00763169231727e-5*std::sin(0.392959833145142*x_118 - 7.40463972091675) - 0.00102845401921572*std::sin(0.42647984623909*x_118 - 1.16159987449646) - 0.0209017678645742*std::sin(0.328399837017059*x_119 - 4.2469596862793) - 0.00583149383510442*std::sin(0.335759848356247*x_119 - 7.44079971313477) - 0.00230326519563147*std::sin(0.415999859571457*x_119 - 1.17535984516144) - 0.00452468337746919*std::sin(0.421519845724106*x_119 + 1.98623979091644) + 0.000269204066099188*std::sin(0.433919847011566*x_119 - 1.15335988998413) - 0.0172777253722681*std::sin(0.341599822044373*x_12 - 4.25816011428833) - 0.0124524424735819*std::sin(0.392639845609665*x_12 + 5.19840002059937) + 0.00103425292389557*std::sin(0.300879925489426*x_120 + 1.90599989891052) - 0.00033751039545226*std::sin(0.331999838352203*x_120 - 1.06463980674744) + 0.0226068617081129*std::sin(0.460639864206314*x_120 + 2.05159974098206) - 0.0129414496688792*std::sin(0.203759998083115*x_13 + 8.19944000244141) + 0.436907594811474*std::sin(0.12216005474329*x_14 - 4.52631998062134) + 0.0147671249348016*std::sin(0.250799983739853*x_14 - 4.31239986419678) - 0.00291249073735364*std::sin(0.142320036888123*x_15 - 4.48423957824707) + 0.00593759972073294*std::sin(0.333919852972031*x_16 - 4.24720001220703) + 0.00686975070128166*std::sin(0.359999865293503*x_16 + 5.17304039001465) + 0.00243400086570589*std::sin(0.388799846172333*x_16 - 1.18391978740692) - 0.00955848542803331*std::sin(0.401599854230881*x_16 + 5.20815992355347) + 0.0375679225967759*std::sin(0.331119894981384*x_17 - 4.21216011047363) - 1.71619742982119e-5*std::sin(1.23015987873077*x_17 + 5.81080007553101) + 0.00755876468644971*std::sin(0.222159996628761*x_18 - 4.37863969802856) + 0.0136949883265767*std::sin(0.269999951124191*x_18 + 8.30519962310791) + 0.0430835968945211*std::sin(0.326479852199554*x_21 - 4.25343990325928) + 0.0101773542440278*std::sin(0.335279852151871*x_21 + 5.160560131073) - 0.00580394287725489*std::sin(0.33679986000061*x_21 + 8.35943984985352) + 0.0624651726513042*std::sin(0.153520032763481*x_23 - 7.64976024627686) + 0.0785999482199685*std::sin(0.191040009260178*x_23 + 4.99199962615967) - 0.254476943510897*std::sin(0.205360010266304*x_23 + 5.00831985473633) + 0.00256456979348547*std::sin(0.414879858493805*x_23 + 5.20208024978638) + 0.051313582013923*std::sin(0.276959955692291*x_24 + 5.09240007400513) + 0.063690224950224*std::sin(0.326639831066132*x_24 - 4.2720799446106) + 0.0223923645262542*std::sin(0.358239859342575*x_24 + 8.34879970550537) + 0.00808344358644431*std::sin(0.311839938163757*x_26 - 4.27183961868286) - 0.00559433613478423*std::sin(0.346559852361679*x_26 - 4.25408029556274) - 0.159163382773656*std::sin(0.181520000100136*x_27 - 7.61520004272461) - 0.013745359919237*std::sin(0.222159996628761*x_27 + 5.0272798538208) - 0.00834976130057944*std::sin(0.22919999063015*x_27 - 7.55919981002808) + 0.0550146091015328*std::sin(0.250079959630966*x_27 - 7.52135992050171) - 0.000156868696627942*std::sin(0.293599933385849*x_27 + 8.32111930847168) + 0.00103324718260904*std::sin(0.225199982523918*x_28 - 4.36520004272461) - 0.0165469111648506*std::sin(0.279359966516495*x_28 + 5.0991997718811) - 0.0199273362678359*std::sin(0.29911994934082*x_28 - 4.28567981719971) + 0.0508765003890487*std::sin(0.327599853277206*x_28 - 4.27360010147095) - 0.00337145744788524*std::sin(0.475359857082367*x_28 + 5.25095987319946) + 0.0391808349425148*std::sin(0.285999953746796*x_3 + 8.2903995513916) + 0.011420958616279*std::sin(0.293039947748184*x_3 + 8.30327987670898) + 0.00192448978624615*std::sin(0.300399929285049*x_3 - 4.27288007736206) - 0.036922697133628*std::sin(0.316799849271774*x_3 + 8.31775951385498) - 0.0187600551539646*std::sin(0.321359843015671*x_3 + 8.31960010528564) - 0.000203315057732475*std::sin(0.368239849805832*x_3 - 1.03407979011536) + 0.00324454871062762*std::sin(0.274559944868088*x_30 + 8.28799915313721) - 0.00109664839458708*std::sin(0.275599956512451*x_30 + 8.26799964904785) + 0.0116800031523161*std::sin(0.170720010995865*x_31 + 8.43936061859131) - 0.00665917388338059*std::sin(0.270079970359802*x_32 - 7.44039964675903) + 0.00575336752574497*std::sin(0.273199945688248*x_32 + 1.97919988632202) - 0.00641927533697469*std::sin(0.337679862976074*x_34 + 5.20703983306885) + 0.00732770093162715*std::sin(0.379599839448929*x_34 + 1.97711980342865) - 0.0193932327324766*std::sin(0.303839921951294*x_35 - 1.11191987991333) - 0.00360156319309283*std::sin(0.322799831628799*x_36 - 4.26735973358154) + 1.63221702568618e-5*std::sin(0.338079839944839*x_36 - 7.43224000930786) - 0.00035910658692388*std::sin(0.357679843902588*x_36 - 4.24528026580811) + 0.00143501565248227*std::sin(0.364799857139587*x_36 - 4.22959995269775) - 0.00434661492635421*std::sin(0.411119878292084*x_36 + 5.20232009887695) + 0.000661848176208909*std::sin(0.2360799908638*x_37 - 4.35727977752686) - 0.00289652572735756*std::sin(0.362399846315384*x_37 + 5.16695976257324) + 1.86991328432657e-5*std::sin(0.388159841299057*x_37 - 4.19992017745972) - 0.00602423455914972*std::sin(0.433199852705002*x_38 + 5.23192024230957) - 0.00786352507690104*std::sin(0.451359868049622*x_38 + 8.44312000274658) - 0.00168691612506291*std::sin(0.345439851284027*x_39 + 1.95567977428436) - 0.000274320844553197*std::sin(0.308479934930801*x_41 - 4.28967952728271) + 0.000256441685487404*std::sin(0.319679856300354*x_42 - 4.26688003540039) + 0.000324594889456852*std::sin(0.369279831647873*x_43 + 5.17000007629395) + 0.000794220848417014*std::sin(0.404799848794937*x_43 + 5.19200038909912) - 0.00229440730356738*std::sin(0.420399844646454*x_43 + 5.20608043670654) - 0.00709538894013901*std::sin(0.331839829683304*x_45 - 4.27144002914429) - 0.0259802160968737*std::sin(0.352159857749939*x_45 + 5.16239976882935) - 0.00110305478615303*std::sin(0.355999857187271*x_45 - 7.44447994232178) + 0.0127455320937569*std::sin(0.363999843597412*x_45 - 4.23320007324219) - 3.40910125532424e-5*std::sin(0.365999847650528*x_45 - 4.23720026016235) - 0.00206207698430177*std::sin(0.288639932870865*x_46 + 5.12536001205444) - 0.000779756888032678*std::sin(0.30927985906601*x_46 - 7.48751974105835) + 0.0223710956500783*std::sin(0.32847985625267*x_46 - 7.45831966400146) + 0.00131556862020414*std::sin(0.334399849176407*x_46 - 4.27008008956909) - 0.000683569995369444*std::sin(0.337759852409363*x_46 + 5.14007997512817) + 1.03277799422662e-5*std::sin(0.416399866342545*x_46 - 7.3724799156189) + 0.00434586574526899*std::sin(0.454959839582443*x_46 + 5.23360013961792) + 0.00165151977536851*std::sin(0.211119994521141*x_47 + 8.22288036346436) + 0.00286577033806953*std::sin(0.451359868049622*x_47 + 2.03895974159241) - 0.00331349317865213*std::sin(0.502319812774658*x_47 - 4.3219199180603) - 0.000365818314402669*std::sin(0.536159813404083*x_47 - 4.23135995864868) + 0.000683377181949331*std::sin(0.416239857673645*x_48 + 5.21384000778198) - 0.00116516114015823*std::sin(0.500239849090576*x_48 + 2.05039978027344) - 0.0205437374532191*std::sin(0.348399847745895*x_49 + 5.13439989089966) - 0.000252733496485688*std::sin(0.411999881267548*x_49 + 2.01895976066589) + 0.00229152544926056*std::sin(0.180480018258095*x_50 - 4.43503999710083) - 0.000150796992232814*std::sin(0.459599852561951*x_50 - 7.339439868927) - 0.0229126023622106*std::sin(0.282959938049316*x_51 + 5.10951995849609) - 0.0003885260346195*std::sin(0.322239845991135*x_51 + 5.13632011413574) - 0.0102826050659397*std::sin(0.339839845895767*x_53 + 5.13575983047485) - 0.000990797535676214*std::sin(0.435999870300293*x_53 + 8.42735958099365) + 0.0856160816324948*std::sin(0.193519994616508*x_54 - 4.41111993789673) + 1.69985613515065e-5*std::sin(0.465039849281311*x_54 + 8.46759986877441) - 0.00391068610321762*std::sin(0.210319995880127*x_55 - 4.39687967300415) - 0.0167191005917246*std::sin(0.265359967947006*x_55 - 4.29959964752197) + 1.29053404443244e-5*std::sin(0.346879839897156*x_55 - 4.23952007293701) - 0.00425696769831671*std::sin(0.421679854393005*x_55 + 5.23280000686646) + 0.00153775583077335*std::sin(0.289999932050705*x_56 - 4.28191947937012) + 3.48533831422379e-5*std::sin(0.282079964876175*x_57 - 4.2885594367981) + 0.000882555676184912*std::sin(0.197759985923767*x_58 + 4.99087953567505) - 0.00757712138558287*std::sin(0.366159826517105*x_58 + 5.17632007598877) - 0.0179167151703801*std::sin(0.435119867324829*x_58 + 5.24216032028198) + 1.00413202081414e-5*std::sin(0.467359870672226*x_58 + 2.0590398311615) - 0.00319275898852517*std::sin(0.329519838094711*x_59 - 4.26416015625) + 0.00426272954703198*std::sin(0.331599831581116*x_59 - 7.44951963424683) + 3.04626804283626e-5*std::sin(0.350239843130112*x_59 + 5.14416027069092) - 0.00530031290738193*std::sin(0.366159826517105*x_59 + 5.15992021560669) - 0.0014298369017644*std::sin(0.384639829397202*x_59 + 5.174880027771) + 0.000719629877449807*std::sin(0.41007986664772*x_59 - 4.20344018936157) + 3.15357389244664e-5*std::sin(0.562719821929932*x_59 - 4.22799968719482) - 0.000418948950182312*std::sin(0.319439828395844*x_60 - 4.28592014312744) - 0.0249790336368732*std::sin(0.355039834976196*x_60 + 5.15856027603149) - 0.000351234052531122*std::sin(0.264559954404831*x_64 + 5.08464002609253) + 0.00476495158204562*std::sin(0.280799955129623*x_65 + 8.31047916412354) - 0.00120147958973223*std::sin(0.343039840459824*x_65 + 5.14752006530762) + 1.29067962429388e-5*std::sin(0.302559942007065*x_66 - 7.21759986877441) - 0.00580501483484194*std::sin(0.358399838209152*x_66 + 8.3439998626709) - 0.000745530819381461*std::sin(0.378879845142365*x_66 + 5.16160011291504) + 0.00338599335999207*std::sin(0.237599983811378*x_67 + 5.032639503479) + 0.000108301251849796*std::sin(0.333919852972031*x_67 - 4.28336000442505) - 0.00220749495096162*std::sin(0.341039836406708*x_67 + 5.12520027160645) - 1.83392955036669e-5*std::sin(0.367839843034744*x_67 - 7.41863965988159) + 0.00169132452364292*std::sin(0.325999826192856*x_68 - 4.26984024047852) + 0.00180723751285686*std::sin(0.258639961481094*x_69 + 5.07599973678589) + 0.00236875845154939*std::sin(0.356879830360413*x_69 + 8.36288070678711) - 0.00237286810050298*std::sin(0.20728000998497*x_70 + 5.01175975799561) + 0.000223858854020588*std::sin(0.537359833717346*x_71 + 5.15304040908813) - 0.000657026558743376*std::sin(0.239039987325668*x_73 + 5.04247999191284) + 0.000575627894568487*std::sin(0.165840014815331*x_74 - 1.26447987556458) + 0.00105297828056598*std::sin(0.365199834108353*x_74 - 4.24535989761353) - 0.00251263380788114*std::sin(0.321599841117859*x_75 + 5.1287202835083) - 0.000188158156951821*std::sin(0.352319836616516*x_75 - 4.25432014465332) - 8.89263633392384e-5*std::sin(0.178240016102791*x_76 + 4.96903991699219) - 3.5916502276734e-5*std::sin(0.264239966869354*x_77 - 7.53952026367188) + 0.00151178186539841*std::sin(0.194319993257523*x_79 + 8.17903900146484) - 2.55096448475845e-5*std::sin(0.211119994521141*x_79 - 7.58400011062622) + 0.00291005510575178*std::sin(0.266399949789047*x_79 + 1.87991988658905) + 0.00701018867469004*std::sin(0.316639840602875*x_79 - 4.29895973205566) + 0.006725294081602*std::sin(0.317599833011627*x_79 - 7.47359991073608) - 0.00331553334812808*std::sin(0.32711985707283*x_79 + 8.31087970733643) + 0.0137521133817685*std::sin(0.376959830522537*x_79 - 4.22320032119751) - 0.053301768002369*std::sin(0.204960003495216*x_8 + 8.20911979675293) + 0.0997502737196112*std::sin(0.2291199862957*x_8 + 8.25759983062744) - 0.000658911319448646*std::sin(0.305919945240021*x_8 + 5.13575983047485) - 8.87423689970355e-6*std::sin(0.467999875545502*x_80 - 4.13312005996704) + 1.5978053893367e-5*std::sin(1.71655988693237*x_80 - 1.58871984481812) - 0.000738505276133333*std::sin(0.180960014462471*x_84 - 4.41928005218506) + 5.88181367551146e-5*std::sin(0.225439995527267*x_84 + 8.22103977203369) + 0.000597039192094004*std::sin(0.464079856872559*x_84 - 1.13943982124329) + 3.04203708594032e-5*std::sin(1.99599981307983*x_84 - 4.20552015304565) + 0.182268917744352*std::sin(0.148400038480759*x_85 - 7.67167997360229) - 0.000836471882636782*std::sin(0.292079925537109*x_85 + 5.12319993972778) - 0.000953704807783668*std::sin(0.257279992103577*x_86 + 1.86807990074158) + 0.000463783209911499*std::sin(0.549119889736176*x_86 + 8.37264060974121) + 0.00124841437901629*std::sin(0.162640020251274*x_87 + 4.94559955596924) + 0.0302807722510821*std::sin(0.174160018563271*x_87 - 7.61856031417847) + 0.0305256271946765*std::sin(0.217519983649254*x_87 + 5.00527954101563) - 0.0167748314386406*std::sin(0.190400004386902*x_89 + 4.97095966339111) + 0.00034353103939257*std::sin(0.306719928979874*x_89 + 5.14775991439819) - 0.0179363781584366*std::sin(0.214959993958473*x_9 + 5.03159952163696) - 0.194333462540175*std::sin(0.215039998292923*x_9 - 4.37368011474609) + 0.00124984662953577*std::sin(0.22511999309063*x_9 - 4.36303997039795) - 3.74620925202634e-5*std::sin(0.273439943790436*x_9 - 4.31191968917847) - 0.0307080376434764*std::sin(0.186160013079643*x_91 - 7.37151956558228) + 0.00877082584510383*std::sin(0.189440011978149*x_91 + 2.01639986038208) - 0.0260446040307269*std::sin(0.20040000975132*x_91 + 2.00647974014282) + 0.0132764554787202*std::sin(0.34759983420372*x_92 + 5.18064022064209) - 0.000530433745880958*std::sin(0.351359844207764*x_92 - 7.38607978820801) + 0.000541493993364238*std::sin(0.361999839544296*x_92 + 2.00455975532532) + 0.122240671798644*std::sin(0.365679860115051*x_92 + 1.99591982364655) + 0.0113795977716491*std::sin(0.366239845752716*x_92 + 1.99783980846405) - 0.0015006291298711*std::sin(0.399119853973389*x_92 - 4.40703964233398) + 0.00118628248731818*std::sin(0.404639840126038*x_92 + 2.00263977050781) - 0.0083060370973638*std::sin(0.296879917383194*x_94 - 1.11263990402222) + 0.00126494660826951*std::sin(0.386319845914841*x_94 + 1.98831987380981) - 0.000589409518337871*std::sin(0.412479877471924*x_94 + 5.20128011703491) + 0.000476019996141291*std::sin(0.358399868011475*x_95 - 4.21600008010864) + 1.27684094077624e-5*std::sin(0.374239832162857*x_95 + 1.98471975326538) + 0.000220764141648452*std::sin(0.386959850788116*x_95 - 7.40423965454102) - 0.00162536958264062*std::sin(0.472799867391586*x_95 + 2.02503991127014) + 0.0164827692015218*std::sin(0.374959826469421*x_96 - 7.40423965454102) - 0.00122791825366197*std::sin(0.391199827194214*x_96 + 5.18480014801025) + 0.000584773872360485*std::sin(0.33927983045578*x_97 - 4.25487995147705) + 0.0117445659612017*std::sin(0.529279828071594*x_97 - 4.23943996429443) - 1.82081087412116e-5*std::sin(0.283199936151505*x_98 + 5.1069598197937) - 0.00776727467405381*std::sin(0.345519840717316*x_98 - 4.25439977645874) - 0.000324786886562739*std::sin(0.360719859600067*x_98 - 4.22751998901367) + 0.00759634730422237*std::sin(0.361119836568832*x_98 + 5.15664005279541) - 0.00225603257670652*std::sin(0.382719844579697*x_98 + 5.17623996734619) + 0.00243359459384505*std::sin(0.391679853200912*x_99 - 7.39479970932007) + 2.04785203982462e-5*std::sin(0.398319840431213*x_99 - 4.20351982116699) - 0.00463092929373108*std::sin(0.476239860057831*x_99 - 1.14175987243652) + 0.0169829279184341*std::sin(-0.00528998419956832*x_100 - 0.00593702492679531*x_103 + 0.0357048130724707*x_104 + 0.00302065982887096*x_105 + 0.00653700748341841*x_11 - 0.0129233033277287*x_110 - 0.0376056832833286*x_111 - 0.0453937809451239*x_113 + 0.00128007684661622*x_116 + 0.000230340712147581*x_117 + 0.0663618871091688*x_12 + 0.0187216918347878*x_120 + 0.0473114200483551*x_13 + 0.0091721611009836*x_17 + 0.00357041266312629*x_18 + 0.0868676580505094*x_2 + 0.0146320401054976*x_20 + 0.01797508234659*x_21 + 0.00570002854045982*x_22 - 0.0160467580473755*x_24 + 0.00524976517611575*x_25 - 0.0011034260688951*x_28 - 0.0299269577007259*x_29 + 0.0117148817127546*x_30 + 0.0630530245123135*x_31 - 0.0225252435217468*x_32 - 0.00332930098644892*x_33 + 0.00416470172501859*x_34 + 0.0156257903477627*x_37 + 0.026838598681395*x_38 - 0.0246534251783298*x_39 - 0.00517233441267259*x_40 - 0.00527074588570773*x_41 + 0.0306860134951575*x_42 + 0.00900104407406468*x_43 + 0.0187089037633871*x_44 + 0.000352975966312674*x_45 - 0.0135334454380939*x_46 + 0.00779945783750497*x_47 - 0.0194085670788325*x_49 + 0.0321764218451531*x_50 + 0.00534397256361482*x_51 + 0.0194608821150324*x_52 - 0.000587910378506488*x_53 - 0.0240439358340445*x_54 - 0.01819809685004*x_56 - 0.00712302602313607*x_57 - 0.0239171528329127*x_59 - 0.0067127593887132*x_6 - 0.0434761989325766*x_60 + 0.000311435087188776*x_61 + 0.0108455574220642*x_62 - 0.0550353691041194*x_63 + 0.0150205866672324*x_65 + 0.00228912680096767*x_66 + 0.00323364812762482*x_68 + 0.0871922220063955*x_7 - 0.0235327630840231*x_72 + 0.00382279279509436*x_73 - 0.0102315705416448*x_74 - 0.00083311579778465*x_75 - 0.0123467883167016*x_76 - 0.0292189849107447*x_8 - 8.4106214085894e-5*x_82 - 0.0111362755411761*x_83 + 0.00845084581778094*x_85 + 0.0116436736506142*x_86 + 0.0142527915092689*x_87 + 0.014090515158498*x_88 + 0.032343648962478*x_89 + 0.028671104020316*x_90 - 0.105920684549274*x_91 - 0.0884250418220366*x_92 - 0.0218239057765815*x_93 + 0.0186064498277275*x_95 - 0.0233905470631312*x_99 + 0.00895740968550829*std::pow(-5.31104040145874*x_15 - 7.75784015655518, 2) + 0.0108145044744995*std::pow(-3.396399974823*x_4 - 5.59624004364014, 2) - 0.00122254513572125*std::pow(-3.91319990158081*x_5 - 6.38520002365112, 2) - 0.000675888270606217*std::pow(-4.3101601600647*x_71 - 6.57128000259399, 2) - 0.000324704530180707*std::pow(-6.0*x_77 - 9.99911975860596, 2) - 0.000124816407242692*std::pow(-5.0*x_81 - 9.99964046478271, 2) - 2.28087319663402*std::sin(0.236639991402626*x_1 + 1.97687971591949) - 1.7905979171875*std::sin(0.294239938259125*x_10 + 5.10759973526001) + 0.81678965845164*std::sin(0.368399828672409*x_101 + 8.18271923065186) + 0.509667855372005*std::sin(0.282879948616028*x_102 - 4.32231998443604) - 0.168973157300405*std::sin(0.485679864883423*x_106 + 5.2596001625061) - 0.32380452174543*std::sin(0.337519854307175*x_107 - 7.45607995986938) - 0.432762813557979*std::sin(0.499759823083878*x_108 + 5.28000020980835) + 0.211669022998722*std::sin(0.40311986207962*x_109 + 1.98511981964111) - 0.522507104747927*std::sin(0.357759833335876*x_112 + 5.15887975692749) - 0.156131332949965*std::sin(0.481919854879379*x_114 - 1.14231991767883) - 0.295622754135358*std::sin(0.404239863157272*x_115 + 5.19208002090454) + 0.434283098194772*std::sin(0.393359839916229*x_118 + 5.19456005096436) - 0.4510182676154*std::sin(0.343999862670898*x_119 - 7.43631982803345) - 17.1910646899801*std::sin(0.117440059781075*x_14 - 4.53320026397705) - 1.17210124037776*std::sin(0.363919854164124*x_16 - 4.24200010299683) - 4.20583046318242*std::sin(0.159040033817291*x_19 - 4.45383977890015) + 2.06242967809608*std::sin(0.245599970221519*x_23 + 5.0688796043396) + 0.404809218212208*std::sin(0.312079936265945*x_26 - 4.2720799446106) - 2.16964584383661*std::sin(0.301199913024902*x_27 + 5.11639976501465) - 4.80921423732013*std::sin(0.321439832448959*x_3 + 8.32264041900635) + 0.422118459340357*std::sin(0.340079843997955*x_35 - 1.19399988651276) + 0.454830509188824*std::sin(0.350559860467911*x_36 + 8.34632015228271) - 0.0849963005964405*std::sin(0.591679811477661*x_48 + 5.18351984024048) + 0.259601780025633*std::sin(0.349599838256836*x_55 + 1.96415984630585) + 0.211090014556614*std::sin(0.38239985704422*x_58 + 5.19072008132935) + 0.832050236732336*std::sin(0.236559987068176*x_64 + 5.06039953231812) + 0.862763679925891*std::sin(0.274799972772598*x_67 + 5.09183979034424) + 0.67296995111807*std::sin(0.193519994616508*x_69 + 4.98655986785889) - 0.338699256831223*std::sin(0.313279926776886*x_70 + 1.92271995544434) - 1.53132573390018*std::sin(0.234319984912872*x_78 + 5.03319978713989) + 0.266085680669876*std::sin(0.289679944515228*x_79 - 4.26887989044189) + 0.0876732818279669*std::sin(0.496479868888855*x_80 - 4.09999990463257) - 0.0107933962438961*std::sin(1.40207982063293*x_84 - 4.79184007644653) - 3.22040339458553*std::sin(0.240799978375435*x_9 - 4.34663963317871) - 0.179317485983894*std::sin(0.375759840011597*x_94 + 5.18688011169434) - 0.198461617871164*std::sin(0.369519859552383*x_96 - 7.43304014205933) - 0.224244378489322*std::sin(0.408799856901169*x_97 - 4.18495988845825) + 0.185258444230394*std::sin(0.386799842119217*x_98 - 7.39551973342896) + 27.8144707907268) - 0.60559984261943);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00304223895791571*x_1 - 3.96180343821952e-5*x_10 + 0.00231666915622275*x_100 - 0.000563399714040656*x_101 + 0.000619072062291046*x_102 - 0.00140834467513153*x_103 - 0.00459779667157617*x_104 - 0.000428688344260379*x_105 + 0.00115517807312737*x_106 + 0.00169848728217102*x_107 - 0.00231612814300225*x_108 + 0.00070939046054062*x_109 - 0.000372502219288043*x_11 + 0.000283636564626581*x_110 - 0.000142958828589813*x_111 - 0.00142203896611199*x_112 - 0.00188982562733372*x_113 + 0.000983033539288057*x_114 + 0.00016602544572198*x_115 - 0.00270202288238611*x_116 - 2.6932801129248e-5*x_117 + 0.000377553855958939*x_118 + 0.000112884888162022*x_119 - 0.000426064033729461*x_12 - 0.000605173066389911*x_120 + 0.00372793025008544*x_13 - 0.000409730182146947*x_14 + 0.000311221009792759*x_15 + 8.5767831294525e-5*x_16 + 0.000182311650178736*x_17 + 0.000106801252926041*x_18 - 0.00218976302181805*x_19 + 0.0295219545237395*x_2 + 0.0166597438054949*x_20 + 0.000879537917709339*x_21 + 0.000345233758964866*x_22 + 0.000607165084474289*x_23 + 0.000499470871150531*x_24 + 0.00628227430870213*x_25 + 0.00396981548021064*x_26 + 0.000236387083761622*x_27 - 7.92926135720763e-5*x_28 + 0.00298820878027053*x_29 - 0.000525304112562351*x_3 - 0.00407735476861045*x_30 - 0.0056113968537648*x_31 + 0.00240470587971948*x_32 - 0.0055561804313527*x_33 - 1.28774920845217e-5*x_34 + 0.000510981862074753*x_35 + 0.00158729563100887*x_36 - 0.00436407998038163*x_37 - 0.000323308590737025*x_38 + 0.000125921894400924*x_39 + 0.000497863281101843*x_4 - 0.000887277028149201*x_40 - 0.00127281610491286*x_41 + 0.00117030335497541*x_42 - 0.000486557957832052*x_43 + 0.00160951681556783*x_44 - 0.000362435466032168*x_45 + 0.000219954088638262*x_46 - 0.00258756729359199*x_47 - 0.00139225005834868*x_48 - 8.50377985801937e-5*x_49 + 0.000946892062470747*x_5 - 0.000142799594996166*x_50 - 0.000452913025224046*x_51 - 0.00742575028985589*x_52 - 0.00102602080316593*x_53 - 0.000469545858748109*x_54 + 5.91302561836945e-6*x_55 - 0.00300506289772764*x_56 - 0.000634735290062035*x_57 - 0.000667072529957747*x_58 - 0.00103641968753942*x_59 + 0.000966977659883141*x_6 + 0.00061295997776773*x_60 + 0.000921333390475534*x_61 - 0.00447335402353763*x_62 - 0.004665021975138*x_63 - 0.00131017512841636*x_64 + 0.000812538867099998*x_65 - 0.00336007439126172*x_66 + 8.38404293660189e-5*x_67 - 0.000305182503533744*x_68 - 0.00130265385050825*x_69 - 0.00564626597359093*x_7 + 0.000752122657520631*x_70 - 0.00251857591943112*x_71 + 0.00251273648919561*x_72 - 0.000583008060674089*x_73 - 0.000335522812584975*x_74 - 0.000465490662328671*x_75 - 0.0011185442002626*x_76 + 0.000689781613979496*x_77 + 0.00274576252575663*x_78 - 0.000102360330391929*x_79 + 0.00111732739946661*x_8 + 0.000374316503262151*x_80 + 0.00709688515202392*x_81 - 0.000609862975755681*x_82 - 0.000142600683995547*x_83 - 0.00108654849733137*x_84 - 0.000374621437506827*x_85 + 0.00025420211659658*x_86 + 0.000464758883521407*x_87 + 0.000678770053719071*x_88 - 0.000286498522542507*x_89 - 0.00371495449555838*x_9 + 0.00164321275744126*x_90 + 0.0110199748294585*x_91 - 0.00130740831031635*x_92 - 0.0012888783398821*x_93 + 0.000182766149808051*x_94 + 0.000752959538594353*x_95 - 0.00131128822126237*x_96 - 0.00106782045026244*x_97 + 2.550370329789e-6*x_98 - 0.00057454867040804*x_99 - 1.66577516654851e-5*std::pow(-5.50903987884521*x_13 - 8.56120014190674, 2) - 7.04605084535689e-6*std::pow(-5.40360021591187*x_14 - 8.1974401473999, 2) + 9.62044905978485e-6*std::pow(-5.1081600189209*x_14 - 7.96799993515015, 2) - 2.0352233207146e-5*std::pow(-4.90744018554688*x_14 - 7.37560033798218, 2) + 3.87325950256766e-6*std::pow(-5.78351974487305*x_15 - 7.58104038238525, 2) + 4.03266384946433e-5*std::pow(-5.33127975463867*x_15 - 7.50687980651855, 2) + 1.70672346292504e-5*std::pow(-5.31104040145874*x_15 - 7.75784015655518, 2) + 4.15831595213449e-5*std::pow(-3.07200002670288*x_15 - 4.79999971389771, 2) + 0.000246165682342286*std::pow(-5.25880002975464*x_17 - 7.69080018997192, 2) + 3.46341805171662e-5*std::pow(-4.46319961547852*x_17 - 6.49072027206421, 2) - 0.000206478324986867*std::pow(-2.07751989364624*x_17 - 2.91079998016357, 2) + 4.59092921047387e-6*std::pow(-6.5796799659729*x_18 - 9.78975963592529, 2) + 3.00856636338689e-8*std::pow(-6.57512044906616*x_18 - 9.37152004241943, 2) - 1.03626879441577e-5*std::pow(-5.29320001602173*x_18 - 8.33983993530273, 2) + 2.92571039669501e-5*std::pow(-4.91903972625732*x_18 - 9.68000030517578, 2) - 3.09601405398691e-7*std::pow(-3.24055981636047*x_2 - 5.87591981887817, 2) + 7.70143533010485e-5*std::pow(-3.23535990715027*x_2 - 5.85767984390259, 2) + 0.000108895393754359*std::pow(-5.72215986251831*x_22 - 9.58920001983643, 2) + 2.03939942800996e-5*std::pow(-5.64527988433838*x_22 - 9.06455993652344, 2) - 6.05120960603972e-5*std::pow(-4.69063997268677*x_22 - 7.54383945465088, 2) + 5.83342572914671e-5*std::pow(-3.50623989105225*x_22 - 5.77040004730225, 2) - 2.9158947172707e-5*std::pow(-1.23087990283966*x_23 - 1.85415983200073, 2) + 7.83219642930885e-6*std::pow(-6.78079986572266*x_27 - 9.1778392791748, 2) - 8.76520377350913e-7*std::pow(-6.60400009155273*x_27 - 9.9750394821167, 2) + 0.000348941799488072*std::pow(-5.82399988174438*x_4 - 9.65783977508545, 2) + 2.06056987171161e-5*std::pow(-3.396399974823*x_4 - 5.59624004364014, 2) - 1.80011527328105e-5*std::pow(-6.40000009536743*x_5 - 9.99995994567871, 2) + 3.19882144455911e-8*std::pow(-6.19999980926514*x_5 - 9.99948024749756, 2) - 2.55737894260516e-5*std::pow(-5.87680006027222*x_5 - 9.11728000640869, 2) - 1.40782721712515e-5*std::pow(-4.81839990615845*x_5 - 7.81911993026733, 2) - 2.32940832325224e-6*std::pow(-3.91319990158081*x_5 - 6.38520002365112, 2) + 0.000233783107127808*std::pow(-1.71423983573914*x_5 - 2.66727995872498, 2) - 0.000220465933138863*std::pow(-5.514479637146*x_6 - 8.792799949646, 2) + 3.64651282288506e-5*std::pow(-3.50671982765198*x_6 - 5.57079982757568, 2) - 9.42305852954682e-6*std::pow(-5.12335968017578*x_66 - 7.99567985534668, 2) + 8.28231431905081e-6*std::pow(-5.26424026489258*x_67 - 8.09687995910645, 2) - 4.32606635474331e-5*std::pow(-4.71519947052002*x_67 - 8.39935970306396, 2) + 3.02630635993604e-8*std::pow(-6.60000038146973*x_68 - 9.96571922302246, 2) - 1.82860409457119e-5*std::pow(-5.98231983184814*x_7 - 9.59111976623535, 2) + 4.38669319983076e-7*std::pow(-5.28568029403687*x_7 - 8.53200054168701, 2) + 1.90314166043314e-5*std::pow(-5.20592021942139*x_7 - 8.61111927032471, 2) - 1.72087328686264e-5*std::pow(-4.92143964767456*x_7 - 8.06775951385498, 2) - 0.000205002704146194*std::pow(-4.83440017700195*x_7 - 7.85383987426758, 2) - 1.28782137946167e-6*std::pow(-4.3101601600647*x_71 - 6.57128000259399, 2) + 9.29190532125008e-7*std::pow(-4.37599992752075*x_72 - 6.1669602394104, 2) - 7.8787908906537e-8*std::pow(-3.8711199760437*x_72 - 5.22455978393555, 2) - 6.18684262118817e-7*std::pow(-6.0*x_77 - 9.99911975860596, 2) + 1.31160609969746e-6*std::pow(-7.76000022888184*x_80 - 9.79903984069824, 2) + 9.81578556009556e-8*std::pow(-4.18959999084473*x_80 - 6.58544015884399, 2) + 3.32413459296542e-7*std::pow(-9.97459983825684*x_81 - 6.60400009155273, 2) + 1.64534985899085e-8*std::pow(-7.59576034545898*x_81 - 8.78192043304443, 2) - 2.37822203380687e-7*std::pow(-5.0*x_81 - 9.99964046478271, 2) - 3.44762007224034e-6*std::pow(-7.46039962768555*x_82 - 9.46856021881104, 2) + 9.32247055742079e-7*std::pow(-5.52776002883911*x_85 - 7.56920003890991, 2) + 2.7527269002344e-6*std::pow(-5.29983949661255*x_85 - 7.26336002349854, 2) - 9.61182743738951e-6*std::pow(-4.47440004348755*x_85 - 8.12800025939941, 2) + 2.95327580156465e-8*std::pow(-6.60000038146973*x_88 - 9.99792003631592, 2) - 8.01424845832513e-5*std::pow(-6.29087972640991*x_88 - 8.66224002838135, 2) - 4.8941927139404e-6*std::pow(-5.65199995040894*x_88 - 7.40236043930054, 2) + 2.80398219114667e-6*std::pow(-6.20728015899658*x_90 - 8.81319999694824, 2) + 0.000250794531693862*std::exp(0.868719875812531*x_27) - 3.63522799215576e-6*std::exp(0.473039865493774*x_71) + 0.000205376646460003*std::exp(0.530879855155945*x_71) + 0.00358837446835009*std::sin(0.228959992527962*x_1 + 5.01823997497559) - 0.00434592135151538*std::sin(0.236639991402626*x_1 + 1.97687971591949) - 0.0333711179362778*std::sin(0.276399940252304*x_1 - 1.18871986865997) - 0.000248692118190552*std::sin(0.285039931535721*x_1 + 1.9968798160553) + 0.251408501980421*std::sin(0.297599911689758*x_1 + 1.98135983943939) + 0.0220691779515402*std::sin(0.302639931440353*x_1 - 7.43455982208252) + 0.046651951109046*std::sin(0.311999946832657*x_1 - 7.43711996078491) - 0.0178019881410172*std::sin(0.218239992856979*x_10 - 4.37031984329224) + 0.00174598877717025*std::sin(0.269119948148727*x_10 - 4.30751943588257) - 0.031121901168801*std::sin(0.285759955644608*x_10 + 5.09208011627197) - 0.00341176253540444*std::sin(0.294239938259125*x_10 + 5.10759973526001) - 0.0434831672316195*std::sin(0.323919832706451*x_10 - 4.27239990234375) + 0.00155629152098433*std::sin(0.368399828672409*x_101 + 8.18271923065186) + 0.000971108967438866*std::sin(0.282879948616028*x_102 - 4.32231998443604) + 4.52915881872128e-5*std::sin(0.383199840784073*x_102 + 5.18440008163452) - 0.0304477892536149*std::sin(0.385439842939377*x_102 + 1.96247982978821) - 0.00085936395339584*std::sin(0.306239932775497*x_103 - 4.27127981185913) - 0.0196400387246589*std::sin(0.361359834671021*x_103 + 1.97855985164642) + 2.52332987221902e-5*std::sin(0.365279853343964*x_103 - 7.4171199798584) - 0.00446056593179624*std::sin(0.321119844913483*x_105 - 4.27928018569946) - 0.000221329757085353*std::sin(0.393999844789505*x_105 - 4.1908802986145) - 0.00886434025250257*std::sin(0.241679981350899*x_106 + 5.03127956390381) + 0.00305480513533134*std::sin(0.263999968767166*x_106 + 5.06047964096069) + 0.00247039299275483*std::sin(0.353919863700867*x_106 - 7.43991994857788) - 8.58102150544576e-5*std::sin(0.373599827289581*x_106 - 7.40431976318359) + 0.000423019172301803*std::sin(0.374559849500656*x_106 - 7.4235200881958) - 0.00385758654597549*std::sin(0.388399839401245*x_106 - 7.39368009567261) - 0.00032195742105633*std::sin(0.485679864883423*x_106 + 5.2596001625061) + 0.000385436707823728*std::sin(0.539679825305939*x_106 - 7.21880006790161) - 0.000616969407526643*std::sin(0.337519854307175*x_107 - 7.45607995986938) - 1.81601085530467e-5*std::sin(0.345039844512939*x_107 - 4.25472021102905) - 0.000824575936250642*std::sin(0.499759823083878*x_108 + 5.28000020980835) + 0.0384522217566786*std::sin(0.333519846200943*x_109 - 7.4410400390625) + 0.000403309104540347*std::sin(0.40311986207962*x_109 + 1.98511981964111) - 1.22170837227835e-5*std::sin(0.471919864416122*x_109 + 2.02095985412598) - 0.00964678163060087*std::sin(0.269839972257614*x_11 + 8.28728008270264) + 0.025279396308014*std::sin(0.289919942617416*x_11 + 8.31727981567383) - 0.0690103011634475*std::sin(0.294399946928024*x_11 + 8.31807994842529) + 0.0371228560222514*std::sin(0.41567987203598*x_110 + 5.20975971221924) + 0.0460790351230995*std::sin(0.308079928159714*x_111 + 5.13520002365112) - 0.00180838703433035*std::sin(0.447919845581055*x_111 + 5.0274395942688) + 0.00146110131282845*std::sin(0.55351984500885*x_111 - 7.41264009475708) + 1.90253263785916e-5*std::sin(0.241919979453087*x_112 - 1.15607988834381) - 0.000995572566766788*std::sin(0.357759833335876*x_112 + 5.15887975692749) + 0.00021182720886671*std::sin(0.437519878149033*x_112 + 8.21895980834961) + 1.7254295574267e-5*std::sin(0.437919855117798*x_113 - 1.18151986598969) - 0.0539041864820835*std::sin(0.347919851541519*x_114 + 8.33896064758301) + 0.00360186256831481*std::sin(0.362399846315384*x_114 - 7.42384004592896) - 0.00163510490714131*std::sin(0.386159837245941*x_114 - 7.42127990722656) - 0.000297488915433419*std::sin(0.481919854879379*x_114 - 1.14231991767883) - 0.00201236089054125*std::sin(0.294959932565689*x_115 + 8.33543968200684) - 0.0106944774014253*std::sin(0.337519854307175*x_115 + 5.14039993286133) - 0.0124062000499203*std::sin(0.396719843149185*x_115 - 7.40727996826172) - 0.000563272540133577*std::sin(0.404239863157272*x_115 + 5.19208002090454) + 0.000307659459624025*std::sin(0.521999835968018*x_115 + 8.35608005523682) + 6.82054544096216e-6*std::sin(0.53415983915329*x_115 - 4.23967981338501) + 0.000217616444933072*std::sin(0.638719856739044*x_115 - 4.17447996139526) - 0.00431837968053413*std::sin(0.257519960403442*x_117 - 4.34143972396851) - 0.0252739075427401*std::sin(0.393999844789505*x_117 + 5.18584012985229) - 0.00127335799497248*std::sin(0.438319861888885*x_117 - 4.16440010070801) - 0.00449547032717047*std::sin(0.476639837026596*x_117 + 5.24015998840332) - 0.00260212073929932*std::sin(0.370799839496613*x_118 - 7.40967988967896) - 0.00139653047991075*std::sin(0.390239834785461*x_118 + 5.17920017242432) + 0.00214470819818592*std::sin(0.392959833145142*x_118 - 7.40463972091675) + 0.000827472650313121*std::sin(0.393359839916229*x_118 + 5.19456005096436) - 0.0014612153035244*std::sin(0.42647984623909*x_118 - 1.16159987449646) + 0.0396638108364322*std::sin(0.328399837017059*x_119 - 4.2469596862793) - 0.00828531745226766*std::sin(0.335759848356247*x_119 - 7.44079971313477) - 0.000859359442710726*std::sin(0.343999862670898*x_119 - 7.43631982803345) - 0.00506553902202345*std::sin(0.415999859571457*x_119 - 1.17535984516144) - 0.00118411749354799*std::sin(0.421519845724106*x_119 + 1.98623979091644) - 0.000328385839792609*std::sin(0.433919847011566*x_119 - 1.15335988998413) + 0.0210760574247339*std::sin(0.341599822044373*x_12 - 4.25816011428833) + 0.0236301219075743*std::sin(0.392639845609665*x_12 + 5.19840002059937) - 0.00225624467082957*std::sin(0.300879925489426*x_120 + 1.90599989891052) - 3.08204963187211e-5*std::sin(0.331999838352203*x_120 - 1.06463980674744) - 0.042899447176223*std::sin(0.460639864206314*x_120 + 2.05159974098206) - 0.0183870585875855*std::sin(0.203759998083115*x_13 + 8.19944000244141) - 0.0327554443630276*std::sin(0.117440059781075*x_14 - 4.53320026397705) - 0.829088730957253*std::sin(0.12216005474329*x_14 - 4.52631998062134) + 0.00097533718234354*std::sin(0.250799983739853*x_14 - 4.31239986419678) - 0.00026596043042951*std::sin(0.142320036888123*x_15 - 4.48423957824707) - 0.00724292058028141*std::sin(0.333919852972031*x_16 - 4.24720001220703) - 0.0149865067350387*std::sin(0.359999865293503*x_16 + 5.17304039001465) - 0.00223329372900369*std::sin(0.363919854164124*x_16 - 4.24200010299683) + 0.00535306415789943*std::sin(0.388799846172333*x_16 - 1.18391978740692) + 0.0181384637106643*std::sin(0.401599854230881*x_16 + 5.20815992355347) + 0.0533760599835968*std::sin(0.331119894981384*x_17 - 4.21216011047363) - 1.56718303438107e-6*std::sin(1.23015987873077*x_17 + 5.81080007553101) + 0.016623885755807*std::sin(0.222159996628761*x_18 - 4.37863969802856) + 0.0194576773978114*std::sin(0.269999951124191*x_18 + 8.30519962310791) - 0.0080136889844522*std::sin(0.159040033817291*x_19 - 4.45383977890015) - 0.08175670347357*std::sin(0.326479852199554*x_21 - 4.25343990325928) + 0.00266343127088128*std::sin(0.335279852151871*x_21 + 5.160560131073) - 0.00824617337729269*std::sin(0.33679986000061*x_21 + 8.35943984985352) + 0.0163472441060122*std::sin(0.153520032763481*x_23 - 7.64976024627686) + 0.172863769917782*std::sin(0.191040009260178*x_23 + 4.99199962615967) + 0.482902949408261*std::sin(0.205360010266304*x_23 + 5.00831985473633) + 0.00392970428486076*std::sin(0.245599970221519*x_23 + 5.0688796043396) + 0.00364371042281024*std::sin(0.414879858493805*x_23 + 5.20208024978638) + 0.0729057302674335*std::sin(0.276959955692291*x_24 + 5.09240007400513) - 0.120860448308637*std::sin(0.326639831066132*x_24 - 4.2720799446106) + 0.00586012066379587*std::sin(0.358239859342575*x_24 + 8.34879970550537) - 0.017634203483971*std::sin(0.311839938163757*x_26 - 4.27183961868286) + 0.000771313822844212*std::sin(0.312079936265945*x_26 - 4.2720799446106) + 0.00682419398905506*std::sin(0.346559852361679*x_26 - 4.25408029556274) + 0.302033126926107*std::sin(0.181520000100136*x_27 - 7.61520004272461) + 0.0167671373829369*std::sin(0.222159996628761*x_27 + 5.0272798538208) + 0.0182151812210236*std::sin(0.22919999063015*x_27 - 7.55919981002808) + 0.0143974186928117*std::sin(0.250079959630966*x_27 - 7.52135992050171) - 1.43248064417854e-5*std::sin(0.293599933385849*x_27 + 8.32111930847168) - 0.00413399140814625*std::sin(0.301199913024902*x_27 + 5.11639976501465) - 0.00225405062489985*std::sin(0.225199982523918*x_28 - 4.36520004272461) - 0.00109288827603672*std::sin(0.279359966516495*x_28 + 5.0991997718811) - 0.028312523621857*std::sin(0.29911994934082*x_28 - 4.28567981719971) + 0.0133144684600826*std::sin(0.327599853277206*x_28 - 4.27360010147095) + 0.00639777703601079*std::sin(0.475359857082367*x_28 + 5.25095987319946) - 0.0743507073488898*std::sin(0.285999953746796*x_3 + 8.2903995513916) + 0.0162267628880016*std::sin(0.293039947748184*x_3 + 8.30327987670898) - 0.00419831525148507*std::sin(0.300399929285049*x_3 - 4.27288007736206) - 0.0812035728597326*std::sin(0.316799849271774*x_3 + 8.31775951385498) + 0.0228842623202447*std::sin(0.321359843015671*x_3 + 8.31960010528564) - 0.00916336202679967*std::sin(0.321439832448959*x_3 + 8.32264041900635) - 1.85661569919575e-5*std::sin(0.368239849805832*x_3 - 1.03407979011536) - 0.00395782971827367*std::sin(0.274559944868088*x_30 + 8.28799915313721) - 0.000100142834898498*std::sin(0.275599956512451*x_30 + 8.26799964904785) + 0.000771439356993337*std::sin(0.170720010995865*x_31 + 8.43936061859131) + 0.0145271289443528*std::sin(0.270079970359802*x_32 - 7.44039964675903) + 0.0126533009594292*std::sin(0.273199945688248*x_32 + 1.97919988632202) - 0.00167993549786559*std::sin(0.337679862976074*x_34 + 5.20703983306885) + 0.000483979055588952*std::sin(0.379599839448929*x_34 + 1.97711980342865) + 0.0368011701015765*std::sin(0.303839921951294*x_35 - 1.11191987991333) + 0.000804294437772023*std::sin(0.340079843997955*x_35 - 1.19399988651276) - 0.000237875585958165*std::sin(0.322799831628799*x_36 - 4.26735973358154) - 0.00174366107568628*std::sin(0.338079839944839*x_36 - 7.43224000930786) + 0.000866623196818376*std::sin(0.350559860467911*x_36 + 8.34632015228271) - 3.27925995449271e-5*std::sin(0.357679843902588*x_36 - 4.24528026580811) - 0.00313051705599728*std::sin(0.364799857139587*x_36 - 4.22959995269775) - 0.00617561906536163*std::sin(0.411119878292084*x_36 + 5.20232009887695) - 0.00144383582194291*std::sin(0.2360799908638*x_37 - 4.35727977752686) + 0.00353329742467096*std::sin(0.362399846315384*x_37 + 5.16695976257324) - 0.00199758669189119*std::sin(0.388159841299057*x_37 - 4.19992017745972) - 0.00157655264062156*std::sin(0.433199852705002*x_38 + 5.23192024230957) + 0.0149220569847764*std::sin(0.451359868049622*x_38 + 8.44312000274658) - 0.00371001110709877*std::sin(0.345439851284027*x_39 + 1.95567977428436) - 2.50502049525647e-5*std::sin(0.308479934930801*x_41 - 4.28967952728271) + 2.34175306302502e-5*std::sin(0.319679856300354*x_42 - 4.26688003540039) + 2.96410887794289e-5*std::sin(0.369279831647873*x_43 + 5.17000007629395) + 0.00174671883523945*std::sin(0.404799848794937*x_43 + 5.19200038909912) - 0.00015154072065416*std::sin(0.420399844646454*x_43 + 5.20608043670654) - 0.000468635342834909*std::sin(0.331839829683304*x_45 - 4.27144002914429) + 0.0493008239031567*std::sin(0.352159857749939*x_45 + 5.16239976882935) + 0.00240633739135758*std::sin(0.355999857187271*x_45 - 7.44447994232178) + 0.00333552787183895*std::sin(0.363999843597412*x_45 - 4.23320007324219) + 0.0036418669015434*std::sin(0.365999847650528*x_45 - 4.23720026016235) - 0.00453509715260266*std::sin(0.288639932870865*x_46 + 5.12536001205444) + 0.000951178502691475*std::sin(0.30927985906601*x_46 - 7.48751974105835) - 0.0424520505546489*std::sin(0.32847985625267*x_46 - 7.45831966400146) - 0.00286994082382299*std::sin(0.334399849176407*x_46 - 4.27008008956909) - 6.24216818496549e-5*std::sin(0.337759852409363*x_46 + 5.14007997512817) - 0.00110329371647208*std::sin(0.416399866342545*x_46 - 7.3724799156189) + 0.000287035185897607*std::sin(0.454959839582443*x_46 + 5.23360013961792) - 0.00360282538811666*std::sin(0.211119994521141*x_47 + 8.22288036346436) + 0.000749977071698905*std::sin(0.451359868049622*x_47 + 2.03895974159241) - 0.00470777190842469*std::sin(0.502319812774658*x_47 - 4.3219199180603) + 0.000446239747145482*std::sin(0.536159813404083*x_47 - 4.23135995864868) + 6.24040746725579e-5*std::sin(0.416239857673645*x_48 + 5.21384000778198) + 0.0014213099566022*std::sin(0.500239849090576*x_48 + 2.05039978027344) - 0.000161949922559049*std::sin(0.591679811477661*x_48 + 5.18351984024048) + 0.0389844017739221*std::sin(0.348399847745895*x_49 + 5.13439989089966) - 2.3078909281052e-5*std::sin(0.411999881267548*x_49 + 2.01895976066589) - 0.00499901132838036*std::sin(0.180480018258095*x_50 - 4.43503999710083) - 1.37703555404801e-5*std::sin(0.459599852561951*x_50 - 7.339439868927) + 0.0434796296539785*std::sin(0.282959938049316*x_51 + 5.10951995849609) - 3.54791004397711e-5*std::sin(0.322239845991135*x_51 + 5.13632011413574) - 0.00269097559366347*std::sin(0.339839845895767*x_53 + 5.13575983047485) - 0.00217904720195129*std::sin(0.435999870300293*x_53 + 8.42735958099365) - 0.162467600273342*std::sin(0.193519994616508*x_54 - 4.41111993789673) - 0.00181591842903529*std::sin(0.465039849281311*x_54 + 8.46759986877441) - 0.00860071740601394*std::sin(0.210319995880127*x_55 - 4.39687967300415) + 0.031726658123947*std::sin(0.265359967947006*x_55 - 4.29959964752197) - 0.00137864876098742*std::sin(0.346879839897156*x_55 - 4.23952007293701) + 0.000494639035773556*std::sin(0.349599838256836*x_55 + 1.96415984630585) - 0.00604824934432458*std::sin(0.421679854393005*x_55 + 5.23280000686646) - 0.00187581579729345*std::sin(0.289999932050705*x_56 - 4.28191947937012) - 0.00372330925267441*std::sin(0.282079964876175*x_57 - 4.2885594367981) + 8.05924923659752e-5*std::sin(0.197759985923767*x_58 + 4.99087953567505) - 0.00198294581850359*std::sin(0.366159826517105*x_58 + 5.17632007598877) + 0.000402205875673886*std::sin(0.38239985704422*x_58 + 5.19072008132935) + 0.0339992868513599*std::sin(0.435119867324829*x_58 + 5.24216032028198) - 0.0010726918614317*std::sin(0.467359870672226*x_58 + 2.0590398311615) + 0.00389465455293657*std::sin(0.329519838094711*x_59 - 4.26416015625) + 0.00111556372143938*std::sin(0.331599831581116*x_59 - 7.44951963424683) - 0.00325426026613563*std::sin(0.350239843130112*x_59 + 5.14416027069092) - 0.00753062187421907*std::sin(0.366159826517105*x_59 + 5.15992021560669) + 0.00311921950156085*std::sin(0.384639829397202*x_59 + 5.174880027771) + 0.00158267195308205*std::sin(0.41007986664772*x_59 - 4.20344018936157) + 2.87975463430473e-6*std::sin(0.562719821929932*x_59 - 4.22799968719482) - 3.82572351868564e-5*std::sin(0.319439828395844*x_60 - 4.28592014312744) + 0.0474009505544761*std::sin(0.355039834976196*x_60 + 5.15856027603149) + 0.00158536866261781*std::sin(0.236559987068176*x_64 + 5.06039953231812) - 3.20737019330599e-5*std::sin(0.264559954404831*x_64 + 5.08464002609253) + 0.00031471491373945*std::sin(0.280799955129623*x_65 + 8.31047916412354) - 0.0026423973051374*std::sin(0.343039840459824*x_65 + 5.14752006530762) - 0.00137880428070925*std::sin(0.302559942007065*x_66 - 7.21759986877441) - 0.00151918245826223*std::sin(0.358399838209152*x_66 + 8.3439998626709) + 0.00162639128138299*std::sin(0.378879845142365*x_66 + 5.16160011291504) - 0.00413036953403041*std::sin(0.237599983811378*x_67 + 5.032639503479) + 0.00164388932424442*std::sin(0.274799972772598*x_67 + 5.09183979034424) + 9.88976451962842e-6*std::sin(0.333919852972031*x_67 - 4.28336000442505) - 0.00313638271087489*std::sin(0.341039836406708*x_67 + 5.12520027160645) + 0.00195914607077506*std::sin(0.367839843034744*x_67 - 7.41863965988159) - 0.00368966028999885*std::sin(0.325999826192856*x_68 - 4.26984024047852) + 0.00128226088316016*std::sin(0.193519994616508*x_69 + 4.98655986785889) - 0.00394252693233699*std::sin(0.258639961481094*x_69 + 5.07599973678589) + 0.000619908198314229*std::sin(0.356879830360413*x_69 + 8.36288070678711) + 0.00289451899888341*std::sin(0.20728000998497*x_70 + 5.01175975799561) - 0.0006453494802681*std::sin(0.313279926776886*x_70 + 1.92271995544434) - 0.000273071944409177*std::sin(0.537359833717346*x_71 + 5.15304040908813) - 5.99978101649806e-5*std::sin(0.239039987325668*x_73 + 5.04247999191284) + 5.25647139897079e-5*std::sin(0.165840014815331*x_74 - 1.26447987556458) - 0.00128446483724222*std::sin(0.365199834108353*x_74 - 4.24535989761353) + 0.00306501077434817*std::sin(0.321599841117859*x_75 + 5.1287202835083) - 1.71820716096764e-5*std::sin(0.352319836616516*x_75 - 4.25432014465332) + 0.00949980522913487*std::sin(0.178240016102791*x_76 + 4.96903991699219) + 0.00383687990072343*std::sin(0.264239966869354*x_77 - 7.53952026367188) - 0.00291775150538962*std::sin(0.234319984912872*x_78 + 5.03319978713989) - 0.00329798417626359*std::sin(0.194319993257523*x_79 + 8.17903900146484) + 0.00272513851254644*std::sin(0.211119994521141*x_79 - 7.58400011062622) + 0.00413457186726394*std::sin(0.266399949789047*x_79 + 1.87991988658905) + 0.000506993305310549*std::sin(0.289679944515228*x_79 - 4.26887989044189) + 0.00183457854401636*std::sin(0.316639840602875*x_79 - 4.29895973205566) + 0.000444191364869054*std::sin(0.317599833011627*x_79 - 7.47359991073608) - 0.00729180625210565*std::sin(0.32711985707283*x_79 + 8.31087970733643) - 0.0260964157342941*std::sin(0.376959830522537*x_79 - 4.22320032119751) - 0.00352046836787042*std::sin(0.204960003495216*x_8 + 8.20911979675293) - 0.189289059821716*std::sin(0.2291199862957*x_8 + 8.25759983062744) - 6.01699211907777e-5*std::sin(0.305919945240021*x_8 + 5.13575983047485) + 0.000948014952357631*std::sin(0.467999875545502*x_80 - 4.13312005996704) + 0.000167050578706381*std::sin(0.496479868888855*x_80 - 4.09999990463257) - 1.9490666400602e-5*std::sin(1.71655988693237*x_80 - 1.58871984481812) - 6.74382165738152e-5*std::sin(0.180960014462471*x_84 - 4.41928005218506) - 0.00628341047730282*std::sin(0.225439995527267*x_84 + 8.22103977203369) - 0.000728292181191099*std::sin(0.464079856872559*x_84 - 1.13943982124329) - 2.05654795983121e-5*std::sin(1.40207982063293*x_84 - 4.79184007644653) - 6.6362683682505e-5*std::sin(1.99599981307983*x_84 - 4.20552015304565) - 0.345878871185162*std::sin(0.148400038480759*x_85 - 7.67167997360229) + 0.00182478113805031*std::sin(0.292079925537109*x_85 + 5.12319993972778) - 8.70896301669643e-5*std::sin(0.257279992103577*x_86 + 1.86807990074158) - 0.000565741227743509*std::sin(0.549119889736176*x_86 + 8.37264060974121) + 0.000114001676070308*std::sin(0.162640020251274*x_87 + 4.94559955596924) + 0.00792453065759138*std::sin(0.174160018563271*x_87 - 7.61856031417847) - 0.0579263299907367*std::sin(0.217519983649254*x_87 + 5.00527954101563) - 0.023833482055791*std::sin(0.190400004386902*x_89 + 4.97095966339111) + 3.13702845234667e-5*std::sin(0.306719928979874*x_89 + 5.14775991439819) - 0.00469398129691371*std::sin(0.214959993958473*x_9 + 5.03159952163696) - 0.0128353117228872*std::sin(0.215039998292923*x_9 - 4.37368011474609) + 0.000114132465143646*std::sin(0.22511999309063*x_9 - 4.36303997039795) - 0.00613607976702774*std::sin(0.240799978375435*x_9 - 4.34663963317871) + 0.00400199186219618*std::sin(0.273439943790436*x_9 - 4.31191968917847) - 0.00202820054971587*std::sin(0.186160013079643*x_91 - 7.37151956558228) + 0.0192895549578973*std::sin(0.189440011978149*x_91 + 2.01639986038208) - 0.0068159180814468*std::sin(0.20040000975132*x_91 + 2.00647974014282) + 0.00347447144322767*std::sin(0.34759983420372*x_92 + 5.18064022064209) - 4.8437711941711e-5*std::sin(0.351359844207764*x_92 - 7.38607978820801) - 0.0578465966283016*std::sin(0.361999839544296*x_92 + 2.00455975532532) - 0.231967502182314*std::sin(0.365679860115051*x_92 + 1.99591982364655) - 0.0248248336893847*std::sin(0.366239845752716*x_92 + 1.99783980846405) - 0.00330031271664448*std::sin(0.399119853973389*x_92 - 4.40703964233398) - 0.00144707461694027*std::sin(0.404639840126038*x_92 + 2.00263977050781) + 0.0157617808390553*std::sin(0.296879917383194*x_94 - 1.11263990402222) - 0.00034166725804289*std::sin(0.375759840011597*x_94 + 5.18688011169434) - 0.00154303224415765*std::sin(0.386319845914841*x_94 + 1.98831987380981) + 0.00128580935471478*std::sin(0.412479877471924*x_94 + 5.20128011703491) - 0.00103844770915102*std::sin(0.358399868011475*x_95 - 4.21600008010864) - 0.00136402072349308*std::sin(0.374239832162857*x_95 + 1.98471975326538) + 2.01595580659505e-5*std::sin(0.386959850788116*x_95 - 7.40423965454102) - 0.00230930587431482*std::sin(0.472799867391586*x_95 + 2.02503991127014) - 0.000378144030029992*std::sin(0.369519859552383*x_96 - 7.43304014205933) - 0.0312781887113859*std::sin(0.374959826469421*x_96 - 7.40423965454102) + 0.00149786358270268*std::sin(0.391199827194214*x_96 + 5.18480014801025) - 0.00127569659477891*std::sin(0.33927983045578*x_97 - 4.25487995147705) - 0.000427269886757503*std::sin(0.408799856901169*x_97 - 4.18495988845825) - 0.0222868345710908*std::sin(0.529279828071594*x_97 - 4.23943996429443) + 0.0019451316812828*std::sin(0.283199936151505*x_98 + 5.1069598197937) + 0.0147394093830904*std::sin(0.345519840717316*x_98 - 4.25439977645874) - 2.96586214130157e-5*std::sin(0.360719859600067*x_98 - 4.22751998901367) + 0.0019879772747827*std::sin(0.361119836568832*x_98 + 5.15664005279541) - 0.00496166098195647*std::sin(0.382719844579697*x_98 + 5.17623996734619) + 0.00035298701809357*std::sin(0.386799842119217*x_98 - 7.39551973342896) + 0.00535217064986201*std::sin(0.391679853200912*x_99 - 7.39479970932007) - 0.00218767469914474*std::sin(0.398319840431213*x_99 - 4.20351982116699) + 0.00878778793705565*std::sin(0.476239860057831*x_99 - 1.14175987243652) + 2.63304905849342);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00577071220141576*x_1 + 0.000410852820151825*x_10 - 0.00155278351791626*x_100 - 0.000610982541677641*x_101 + 0.00138949585375432*x_102 + 0.00311849606965258*x_103 + 0.00235062153014396*x_104 + 0.00184401208806561*x_105 - 0.000546997518531094*x_106 - 0.000525893764324032*x_107 + 0.000670357643589694*x_108 + 6.96243968324555e-6*x_109 + 0.000304117276587498*x_11 - 0.000704808557681025*x_110 - 0.00122855280877009*x_111 + 0.00136724993503496*x_112 - 0.00130132233512599*x_113 + 0.000971117996195268*x_114 - 9.43145688834044e-5*x_115 + 0.00259470937801283*x_116 - 0.000325315013545028*x_117 - 0.00038897855584672*x_118 - 0.000530273696341152*x_119 + 0.00152914220864234*x_12 + 0.00123508018682122*x_120 + 0.00208169548126758*x_13 + 0.000920503347003886*x_14 + 0.00185732327611822*x_15 - 0.000567471835503595*x_16 + 0.00070906598909796*x_17 + 0.000742220529464265*x_18 - 7.91234474445851e-5*x_19 - 0.00292197049046272*x_2 - 0.00818392512126732*x_20 + 0.00159331651077384*x_21 + 0.00105283132788018*x_22 - 0.000711312258851461*x_23 + 0.00245139729088366*x_24 + 0.000310864921373941*x_25 - 0.00344485371322326*x_26 - 0.00040919464531641*x_27 - 0.000198105702042794*x_28 + 0.00743879510236864*x_29 + 0.00209481000731038*x_3 + 0.00102321018627369*x_30 + 0.0050759281935059*x_31 + 0.000189814824648236*x_32 + 0.00442034696241101*x_33 + 8.84250370321176e-5*x_34 + 0.00198538470735779*x_35 + 5.50035067236104e-5*x_36 + 0.00203872897181203*x_37 - 0.000673692728864495*x_38 - 0.00212618115550562*x_39 - 0.0104079395674516*x_4 - 0.000231588999367238*x_40 - 0.000930906925141334*x_41 + 0.000775179880407847*x_42 + 0.000573761839741212*x_43 + 0.00173584002219246*x_44 - 0.000177087672677106*x_45 - 0.000631635560625131*x_46 + 0.00346548886038971*x_47 - 0.00088734051792795*x_48 - 0.000482448455219231*x_49 - 0.00586714995402619*x_5 + 0.00079220819734743*x_50 - 0.000130198067616422*x_51 + 0.00490990410880819*x_52 + 0.00111843719345412*x_53 + 0.00185005727269971*x_54 - 2.5500374631727e-5*x_55 + 6.92777669395409e-5*x_56 + 0.000807292935795114*x_57 + 0.000291274878742654*x_58 - 0.00101009186037357*x_59 + 0.000801531335033399*x_6 - 0.00118067109837591*x_60 + 0.000286693085244073*x_61 + 0.0046571986117101*x_62 + 0.000642447481380839*x_63 + 0.000981708452539714*x_64 + 0.000439929356960679*x_65 + 0.000528454861771801*x_66 + 0.000607838780714615*x_67 - 9.95942025773806e-7*x_68 + 0.00076264550485354*x_69 + 0.00503311055199476*x_7 + 0.00035626462842886*x_70 + 0.000603828648865781*x_71 - 0.00215557087019085*x_72 - 0.00118825152510981*x_73 - 0.000862452070751003*x_74 - 0.000215706118354793*x_75 + 0.000512371475505354*x_76 - 0.000252691333589013*x_77 - 0.00156581119053679*x_78 - 0.000245559508326777*x_79 - 0.000239186565410525*x_8 - 0.00187985409048832*x_80 - 0.00475394448274158*x_81 - 0.000715157504456479*x_82 - 0.00036048000232859*x_83 + 0.00190781129323185*x_84 + 0.000427932881378748*x_85 + 0.000246791858381841*x_86 + 0.00108991126216823*x_87 - 0.000230892362254802*x_88 + 0.00214119532753568*x_89 + 0.0027843954531389*x_9 + 0.000673495527242711*x_90 - 0.0157719446417162*x_91 + 0.00240929621565898*x_92 + 0.00192467581726898*x_93 + 9.41509375733132e-5*x_94 + 0.000843091045867079*x_95 - 3.0008536367241e-5*x_96 - 0.000178141054377926*x_97 - 0.000146592683064897*x_98 - 0.000972486536648955*x_99 + 4.25698209564049e-7*std::pow(-5.50903987884521*x_13 - 8.56120014190674, 2) - 1.56168779580822e-5*std::pow(-5.40360021591187*x_14 - 8.1974401473999, 2) + 2.37944777443075e-5*std::pow(-5.1081600189209*x_14 - 7.96799993515015, 2) + 5.20112762568292e-7*std::pow(-4.90744018554688*x_14 - 7.37560033798218, 2) - 9.89833243123916e-8*std::pow(-5.78351974487305*x_15 - 7.58104038238525, 2) + 9.97408017235509e-5*std::pow(-5.33127975463867*x_15 - 7.50687980651855, 2) + 0.000272689698358492*std::pow(-5.31104040145874*x_15 - 7.75784015655518, 2) - 3.11944268446253e-6*std::pow(-3.07200002670288*x_15 - 4.79999971389771, 2) - 0.000120462548007594*std::pow(-5.25880002975464*x_17 - 7.69080018997192, 2) + 8.56615145911357e-5*std::pow(-4.46319961547852*x_17 - 6.49072027206421, 2) - 0.000457638877873555*std::pow(-2.07751989364624*x_17 - 2.91079998016357, 2) - 3.44397604831997e-7*std::pow(-6.5796799659729*x_18 - 9.78975963592529, 2) + 6.22900981437009e-6*std::pow(-6.57512044906616*x_18 - 9.37152004241943, 2) + 2.64824316791761e-7*std::pow(-5.29320001602173*x_18 - 8.33983993530273, 2) - 1.43171268133197e-5*std::pow(-4.91903972625732*x_18 - 9.68000030517578, 2) - 6.41006366434344e-5*std::pow(-3.24055981636047*x_2 - 5.87591981887817, 2) - 0.000133314648507084*std::pow(-3.23535990715027*x_2 - 5.85767984390259, 2) - 5.32885675741771e-5*std::pow(-5.72215986251831*x_22 - 9.58920001983643, 2) - 2.23309495878243e-5*std::pow(-5.64527988433838*x_22 - 9.06455993652344, 2) - 0.000134119103012959*std::pow(-4.69063997268677*x_22 - 7.54383945465088, 2) + 0.000144279459121585*std::pow(-3.50623989105225*x_22 - 5.77040004730225, 2) + 0.000742980384670251*std::pow(-1.23087990283966*x_23 - 1.85415983200073, 2) - 8.57607299593588e-6*std::pow(-6.78079986572266*x_27 - 9.1778392791748, 2) + 2.23340521617001e-5*std::pow(-6.60400009155273*x_27 - 9.9750394821167, 2) - 0.000170756613483762*std::pow(-5.82399988174438*x_4 - 9.65783977508545, 2) + 0.00032922508477187*std::pow(-3.396399974823*x_4 - 5.59624004364014, 2) - 3.98977826733041e-5*std::pow(-6.40000009536743*x_5 - 9.99995994567871, 2) + 6.62291861501274e-6*std::pow(-6.19999980926514*x_5 - 9.99948024749756, 2) + 4.42691602564146e-5*std::pow(-5.87680006027222*x_5 - 9.11728000640869, 2) + 1.05610933945364e-6*std::pow(-4.81839990615845*x_5 - 7.81911993026733, 2) - 3.72178426569925e-5*std::pow(-3.91319990158081*x_5 - 6.38520002365112, 2) - 5.97445874624461e-6*std::pow(-1.71423983573914*x_5 - 2.66727995872498, 2) + 0.000241405071078236*std::pow(-5.514479637146*x_6 - 8.792799949646, 2) + 9.01900396429215e-5*std::pow(-3.50671982765198*x_6 - 5.57079982757568, 2) + 1.03180300090483e-5*std::pow(-5.12335968017578*x_66 - 7.99567985534668, 2) + 1.83569342273944e-5*std::pow(-5.26424026489258*x_67 - 8.09687995910645, 2) + 2.11698467058332e-5*std::pow(-4.71519947052002*x_67 - 8.39935970306396, 2) + 6.26573913965815e-6*std::pow(-6.60000038146973*x_68 - 9.96571922302246, 2) + 4.67310057619218e-7*std::pow(-5.98231983184814*x_7 - 9.59111976623535, 2) - 1.11774508926416e-5*std::pow(-5.28568029403687*x_7 - 8.53200054168701, 2) + 4.70708400429422e-5*std::pow(-5.20592021942139*x_7 - 8.61111927032471, 2) + 2.9788942908672e-5*std::pow(-4.92143964767456*x_7 - 8.06775951385498, 2) + 0.000224473194842632*std::pow(-4.83440017700195*x_7 - 7.85383987426758, 2) - 2.05760119394599e-5*std::pow(-4.3101601600647*x_71 - 6.57128000259399, 2) - 2.36761065103334e-5*std::pow(-4.37599992752075*x_72 - 6.1669602394104, 2) - 1.63124424910485e-5*std::pow(-3.8711199760437*x_72 - 5.22455978393555, 2) - 9.88495374213629e-6*std::pow(-6.0*x_77 - 9.99911975860596, 2) - 3.35188313229206e-8*std::pow(-7.76000022888184*x_80 - 9.79903984069824, 2) + 2.03228439078725e-5*std::pow(-4.18959999084473*x_80 - 6.58544015884399, 2) - 5.75419796254252e-7*std::pow(-9.97459983825684*x_81 - 6.60400009155273, 2) + 3.40657282633072e-6*std::pow(-7.59576034545898*x_81 - 8.78192043304443, 2) - 3.79977578744283e-6*std::pow(-5.0*x_81 - 9.99964046478271, 2) + 8.81058693563523e-8*std::pow(-7.46039962768555*x_82 - 9.46856021881104, 2) - 2.37539878233764e-5*std::pow(-5.52776002883911*x_85 - 7.56920003890991, 2) - 2.06501234877347e-7*std::pow(-5.29983949661255*x_85 - 7.26336002349854, 2) - 2.13036691528806e-5*std::pow(-4.47440004348755*x_85 - 8.12800025939941, 2) + 6.11453487493579e-6*std::pow(-6.60000038146973*x_88 - 9.99792003631592, 2) + 3.92181712929991e-5*std::pow(-6.29087972640991*x_88 - 8.66224002838135, 2) + 1.25073846544534e-7*std::pow(-5.65199995040894*x_88 - 7.40236043930054, 2) - 7.1657341422244e-8*std::pow(-6.20728015899658*x_90 - 8.81319999694824, 2) + 0.0005558613867509*std::exp(0.868719875812531*x_27) - 0.000752646546746597*std::exp(0.473039865493774*x_71) - 5.24851567246281e-6*std::exp(0.530879855155945*x_71) + 0.00887520903596021*std::sin(0.228959992527962*x_1 + 5.01823997497559) - 0.0694364381915403*std::sin(0.236639991402626*x_1 + 1.97687971591949) - 0.0739637972494963*std::sin(0.276399940252304*x_1 - 1.18871986865997) - 0.0514898279731323*std::sin(0.285039931535721*x_1 + 1.9968798160553) - 0.123028151004505*std::sin(0.297599911689758*x_1 + 1.98135983943939) - 0.00056399025085643*std::sin(0.302639931440353*x_1 - 7.43455982208252) - 0.00349968807753332*std::sin(0.311999946832657*x_1 - 7.43711996078491) + 0.0194927631282124*std::sin(0.218239992856979*x_10 - 4.37031984329224) - 0.0444884174181061*std::sin(0.269119948148727*x_10 - 4.30751943588257) + 0.000795337682530043*std::sin(0.285759955644608*x_10 + 5.09208011627197) - 0.0545110275249732*std::sin(0.294239938259125*x_10 + 5.10759973526001) + 0.0212787301232257*std::sin(0.323919832706451*x_10 - 4.27239990234375) + 0.0248654614900396*std::sin(0.368399828672409*x_101 + 8.18271923065186) + 0.0155157772865142*std::sin(0.282879948616028*x_102 - 4.32231998443604) + 0.00937728184293593*std::sin(0.383199840784073*x_102 + 5.18440008163452) + 0.0148997952914846*std::sin(0.385439842939377*x_102 + 1.96247982978821) + 2.19615290028901e-5*std::sin(0.306239932775497*x_103 - 4.27127981185913) + 0.00961096236172568*std::sin(0.361359834671021*x_103 + 1.97855985164642) + 0.00522436424545116*std::sin(0.365279853343964*x_103 - 7.4171199798584) + 0.00011399227032196*std::sin(0.321119844913483*x_105 - 4.27928018569946) + 0.00563956123258693*std::sin(0.393999844789505*x_105 - 4.1908802986145) - 0.0196469374037332*std::sin(0.241679981350899*x_106 + 5.03127956390381) - 7.80672627850551e-5*std::sin(0.263999968767166*x_106 + 5.06047964096069) - 0.0042763401805906*std::sin(0.353919863700867*x_106 - 7.43991994857788) - 0.0177663580319264*std::sin(0.373599827289581*x_106 - 7.40431976318359) - 0.0107786795421018*std::sin(0.374559849500656*x_106 - 7.4235200881958) + 0.00422396758112786*std::sin(0.388399839401245*x_106 - 7.39368009567261) - 0.00514403615695678*std::sin(0.485679864883423*x_106 + 5.2596001625061) + 0.0009533094670693*std::sin(0.539679825305939*x_106 - 7.21880006790161) - 0.00985755485815615*std::sin(0.337519854307175*x_107 - 7.45607995986938) - 0.00375991355163626*std::sin(0.345039844512939*x_107 - 4.25472021102905) - 0.0131745633205568*std::sin(0.499759823083878*x_108 + 5.28000020980835) - 0.018816808928394*std::sin(0.333519846200943*x_109 - 7.4410400390625) + 0.00644382294211018*std::sin(0.40311986207962*x_109 + 1.98511981964111) - 0.00252945506997324*std::sin(0.471919864416122*x_109 + 2.02095985412598) - 0.0238596066968479*std::sin(0.269839972257614*x_11 + 8.28728008270264) + 0.0560292929558405*std::sin(0.289919942617416*x_11 + 8.31727981567383) + 0.0337705753207351*std::sin(0.294399946928024*x_11 + 8.31807994842529) - 0.018166276400548*std::sin(0.41567987203598*x_110 + 5.20975971221924) - 0.0225490325371258*std::sin(0.308079928159714*x_111 + 5.13520002365112) + 0.00198014175861134*std::sin(0.447919845581055*x_111 + 5.0274395942688) - 0.00252921954939421*std::sin(0.55351984500885*x_111 - 7.41264009475708) + 0.00393905037881332*std::sin(0.241919979453087*x_112 - 1.15607988834381) - 0.0159066415165085*std::sin(0.357759833335876*x_112 + 5.15887975692749) - 0.00539743291125155*std::sin(0.437519878149033*x_112 + 8.21895980834961) + 0.00357237180406282*std::sin(0.437919855117798*x_113 - 1.18151986598969) + 0.0263783139474305*std::sin(0.347919851541519*x_114 + 8.33896064758301) - 9.20476230657465e-5*std::sin(0.362399846315384*x_114 - 7.42384004592896) + 0.000122660617894909*std::sin(0.386159837245941*x_114 - 7.42127990722656) - 0.00475309353722156*std::sin(0.481919854879379*x_114 - 1.14231991767883) - 0.00446019978069128*std::sin(0.294959932565689*x_115 + 8.33543968200684) + 0.0117102041139823*std::sin(0.337519854307175*x_115 + 5.14039993286133) + 0.00607104310757379*std::sin(0.396719843149185*x_115 - 7.40727996826172) - 0.00899961958684301*std::sin(0.404239863157272*x_115 + 5.19208002090454) + 0.000760941211720656*std::sin(0.521999835968018*x_115 + 8.35608005523682) + 0.00141214250774521*std::sin(0.53415983915329*x_115 - 4.23967981338501) - 5.56131060421859e-6*std::sin(0.638719856739044*x_115 - 4.17447996139526) - 0.00957126338252356*std::sin(0.257519960403442*x_117 - 4.34143972396851) + 0.0123679274533217*std::sin(0.393999844789505*x_117 + 5.18584012985229) + 0.00220422903325386*std::sin(0.438319861888885*x_117 - 4.16440010070801) + 0.00492243549109759*std::sin(0.476639837026596*x_117 + 5.24015998840332) + 0.000195203216824563*std::sin(0.370799839496613*x_118 - 7.40967988967896) + 3.56891216076558e-5*std::sin(0.390239834785461*x_118 + 5.17920017242432) - 0.00371256794787012*std::sin(0.392959833145142*x_118 - 7.40463972091675) + 0.0132208452227564*std::sin(0.393359839916229*x_118 + 5.19456005096436) + 0.00159999678492611*std::sin(0.42647984623909*x_118 - 1.16159987449646) - 0.019409706794159*std::sin(0.328399837017059*x_119 - 4.2469596862793) + 0.00907222998126711*std::sin(0.335759848356247*x_119 - 7.44079971313477) - 0.013730312631473*std::sin(0.343999862670898*x_119 - 7.43631982803345) - 0.011227268499059*std::sin(0.415999859571457*x_119 - 1.17535984516144) + 8.88289080317796e-5*std::sin(0.421519845724106*x_119 + 1.98623979091644) - 0.000812204244098527*std::sin(0.433919847011566*x_119 - 1.15335988998413) + 0.0521278971713396*std::sin(0.341599822044373*x_12 - 4.25816011428833) - 0.0115635317954614*std::sin(0.392639845609665*x_12 + 5.19840002059937) + 5.76596011273653e-5*std::sin(0.300879925489426*x_120 + 1.90599989891052) - 0.00638115138124952*std::sin(0.331999838352203*x_120 - 1.06463980674744) + 0.0209930834622974*std::sin(0.460639864206314*x_120 + 2.05159974098206) + 0.0201334016646462*std::sin(0.203759998083115*x_13 + 8.19944000244141) - 0.523346191517418*std::sin(0.117440059781075*x_14 - 4.53320026397705) + 0.405719189227283*std::sin(0.12216005474329*x_14 - 4.52631998062134) - 0.0248519396337837*std::sin(0.250799983739853*x_14 - 4.31239986419678) - 0.0550651018219361*std::sin(0.142320036888123*x_15 - 4.48423957824707) - 0.0179140819186612*std::sin(0.333919852972031*x_16 - 4.24720001220703) + 0.000382988605715881*std::sin(0.359999865293503*x_16 + 5.17304039001465) - 0.035682183232204*std::sin(0.363919854164124*x_16 - 4.24200010299683) + 0.0118645396535547*std::sin(0.388799846172333*x_16 - 1.18391978740692) - 0.00887615826357027*std::sin(0.401599854230881*x_16 + 5.20815992355347) - 0.0584455447186956*std::sin(0.331119894981384*x_17 - 4.21216011047363) - 0.000324473430962793*std::sin(1.23015987873077*x_17 + 5.81080007553101) + 0.0368452060218406*std::sin(0.222159996628761*x_18 - 4.37863969802856) - 0.021305704370559*std::sin(0.269999951124191*x_18 + 8.30519962310791) - 0.128037756518791*std::sin(0.159040033817291*x_19 - 4.45383977890015) + 0.0400080982995564*std::sin(0.326479852199554*x_21 - 4.25343990325928) - 0.000199802547212762*std::sin(0.335279852151871*x_21 + 5.160560131073) + 0.00902936812924723*std::sin(0.33679986000061*x_21 + 8.35943984985352) - 0.00122632074196881*std::sin(0.153520032763481*x_23 - 7.64976024627686) + 0.383135526187545*std::sin(0.191040009260178*x_23 + 4.99199962615967) - 0.236311248475388*std::sin(0.205360010266304*x_23 + 5.00831985473633) + 0.062786379829819*std::sin(0.245599970221519*x_23 + 5.0688796043396) - 0.00398977819876136*std::sin(0.414879858493805*x_23 + 5.20208024978638) - 0.0798300796256583*std::sin(0.276959955692291*x_24 + 5.09240007400513) + 0.0591437336759008*std::sin(0.326639831066132*x_24 - 4.2720799446106) - 0.000439608503662698*std::sin(0.358239859342575*x_24 + 8.34879970550537) + 0.000450651984791487*std::sin(0.311839938163757*x_26 - 4.27183961868286) + 0.0123235742790255*std::sin(0.312079936265945*x_26 - 4.2720799446106) + 0.016878435817947*std::sin(0.346559852361679*x_26 - 4.25408029556274) - 0.147801593244136*std::sin(0.181520000100136*x_27 - 7.61520004272461) + 0.0414705462099249*std::sin(0.222159996628761*x_27 + 5.0272798538208) - 0.000465499197514217*std::sin(0.22919999063015*x_27 - 7.55919981002808) - 0.00108005074490268*std::sin(0.250079959630966*x_27 - 7.52135992050171) - 0.00296584316705526*std::sin(0.293599933385849*x_27 + 8.32111930847168) - 0.0660503528891554*std::sin(0.301199913024902*x_27 + 5.11639976501465) + 5.7603531050038e-5*std::sin(0.225199982523918*x_28 - 4.36520004272461) + 0.0278471834707189*std::sin(0.279359966516495*x_28 + 5.0991997718811) + 0.0310015551156996*std::sin(0.29911994934082*x_28 - 4.28567981719971) - 0.000998811098372458*std::sin(0.327599853277206*x_28 - 4.27360010147095) - 0.00313078783366199*std::sin(0.475359857082367*x_28 + 5.25095987319946) + 0.0363839328382114*std::sin(0.285999953746796*x_3 + 8.2903995513916) - 0.0177679280992606*std::sin(0.293039947748184*x_3 + 8.30327987670898) + 0.000107290306737238*std::sin(0.300399929285049*x_3 - 4.27288007736206) - 0.179979724095569*std::sin(0.316799849271774*x_3 + 8.31775951385498) + 0.0566001718932374*std::sin(0.321359843015671*x_3 + 8.31960010528564) - 0.146406519938222*std::sin(0.321439832448959*x_3 + 8.32264041900635) - 0.0038439828193734*std::sin(0.368239849805832*x_3 - 1.03407979011536) - 0.00978899119593984*std::sin(0.274559944868088*x_30 + 8.28799915313721) - 0.0207338189050069*std::sin(0.275599956512451*x_30 + 8.26799964904785) - 0.0196565502455852*std::sin(0.170720010995865*x_31 + 8.43936061859131) - 0.000371248947991625*std::sin(0.270079970359802*x_32 - 7.44039964675903) + 0.0280447957568325*std::sin(0.273199945688248*x_32 + 1.97919988632202) + 0.000126023673032728*std::sin(0.337679862976074*x_34 + 5.20703983306885) - 0.0123319591329553*std::sin(0.379599839448929*x_34 + 1.97711980342865) - 0.0180088576032*std::sin(0.303839921951294*x_35 - 1.11191987991333) + 0.0128505181062891*std::sin(0.340079843997955*x_35 - 1.19399988651276) + 0.00606115485967498*std::sin(0.322799831628799*x_36 - 4.26735973358154) + 0.00301834078268416*std::sin(0.338079839944839*x_36 - 7.43224000930786) + 0.0138463683932641*std::sin(0.350559860467911*x_36 + 8.34632015228271) - 0.00678946048489712*std::sin(0.357679843902588*x_36 - 4.24528026580811) + 8.00021234863902e-5*std::sin(0.364799857139587*x_36 - 4.22959995269775) + 0.00676215929690471*std::sin(0.411119878292084*x_36 + 5.20232009887695) + 3.68980362205223e-5*std::sin(0.2360799908638*x_37 - 4.35727977752686) + 0.00873898571811908*std::sin(0.362399846315384*x_37 + 5.16695976257324) + 0.00345789526597606*std::sin(0.388159841299057*x_37 - 4.19992017745972) + 0.000118268204197725*std::sin(0.433199852705002*x_38 + 5.23192024230957) - 0.00730219171412059*std::sin(0.451359868049622*x_38 + 8.44312000274658) - 0.00822287433830692*std::sin(0.345439851284027*x_39 + 1.95567977428436) - 0.00518645606094751*std::sin(0.308479934930801*x_41 - 4.28967952728271) + 0.0048484231526118*std::sin(0.319679856300354*x_42 - 4.26688003540039) + 0.00613696394278056*std::sin(0.369279831647873*x_43 + 5.17000007629395) + 0.00387143031972207*std::sin(0.404799848794937*x_43 + 5.19200038909912) + 0.00386131166732322*std::sin(0.420399844646454*x_43 + 5.20608043670654) + 0.0119409958537688*std::sin(0.331839829683304*x_45 - 4.27144002914429) - 0.0241256328247659*std::sin(0.352159857749939*x_45 + 5.16239976882935) - 6.14953049894754e-5*std::sin(0.355999857187271*x_45 - 7.44447994232178) - 0.000250221198639029*std::sin(0.363999843597412*x_45 - 4.23320007324219) - 0.0063042041525814*std::sin(0.365999847650528*x_45 - 4.23720026016235) - 0.0100515963217768*std::sin(0.288639932870865*x_46 + 5.12536001205444) + 0.00235257164946333*std::sin(0.30927985906601*x_46 - 7.48751974105835) + 0.0207741474331483*std::sin(0.32847985625267*x_46 - 7.45831966400146) + 7.33429513652581e-5*std::sin(0.334399849176407*x_46 - 4.27008008956909) - 0.0129239385776177*std::sin(0.337759852409363*x_46 + 5.14007997512817) + 0.00190984157766793*std::sin(0.416399866342545*x_46 - 7.3724799156189) - 0.00731375901773695*std::sin(0.454959839582443*x_46 + 5.23360013961792) + 9.20722284671242e-5*std::sin(0.211119994521141*x_47 + 8.22288036346436) - 5.62610084648544e-5*std::sin(0.451359868049622*x_47 + 2.03895974159241) + 0.00515490078667873*std::sin(0.502319812774658*x_47 - 4.3219199180603) + 0.00110369502152075*std::sin(0.536159813404083*x_47 - 4.23135995864868) + 0.012920293144355*std::sin(0.416239857673645*x_48 + 5.21384000778198) + 0.00351535857837493*std::sin(0.500239849090576*x_48 + 2.05039978027344) - 0.00258753550244876*std::sin(0.591679811477661*x_48 + 5.18351984024048) - 0.01907723418453*std::sin(0.348399847745895*x_49 + 5.13439989089966) - 0.00477831415541033*std::sin(0.411999881267548*x_49 + 2.01895976066589) + 0.000127752545170384*std::sin(0.180480018258095*x_50 - 4.43503999710083) - 0.00285104828840984*std::sin(0.459599852561951*x_50 - 7.339439868927) - 0.0212769989898997*std::sin(0.282959938049316*x_51 + 5.10951995849609) - 0.0073456802393937*std::sin(0.322239845991135*x_51 + 5.13632011413574) + 0.000201868838884449*std::sin(0.339839845895767*x_53 + 5.13575983047485) - 0.00482964357831712*std::sin(0.435999870300293*x_53 + 8.42735958099365) + 0.0795044252772519*std::sin(0.193519994616508*x_54 - 4.41111993789673) + 0.00314342089114291*std::sin(0.465039849281311*x_54 + 8.46759986877441) - 0.019062643320291*std::sin(0.210319995880127*x_55 - 4.39687967300415) - 0.015525616897575*std::sin(0.265359967947006*x_55 - 4.29959964752197) + 0.00238649118129079*std::sin(0.346879839897156*x_55 - 4.23952007293701) + 0.00790303598629034*std::sin(0.349599838256836*x_55 + 1.96415984630585) + 0.00662269241364344*std::sin(0.421679854393005*x_55 + 5.23280000686646) - 0.00463949831902313*std::sin(0.289999932050705*x_56 - 4.28191947937012) + 0.00644518382648946*std::sin(0.282079964876175*x_57 - 4.2885594367981) + 0.0166860678900587*std::sin(0.197759985923767*x_58 + 4.99087953567505) + 0.000148754589560262*std::sin(0.366159826517105*x_58 + 5.17632007598877) + 0.00642619623495166*std::sin(0.38239985704422*x_58 + 5.19072008132935) - 0.0166377404258204*std::sin(0.435119867324829*x_58 + 5.24216032028198) + 0.00185686865283629*std::sin(0.467359870672226*x_58 + 2.0590398311615) + 0.00963273860770148*std::sin(0.329519838094711*x_59 - 4.26416015625) - 8.36862116768593e-5*std::sin(0.331599831581116*x_59 - 7.44951963424683) + 0.00563324295971898*std::sin(0.350239843130112*x_59 + 5.14416027069092) + 0.00824585586955119*std::sin(0.366159826517105*x_59 + 5.15992021560669) - 7.97134081307635e-5*std::sin(0.384639829397202*x_59 + 5.174880027771) + 0.00350783655716155*std::sin(0.41007986664772*x_59 - 4.20344018936157) + 0.000596231484150084*std::sin(0.562719821929932*x_59 - 4.22799968719482) - 0.00792087209209246*std::sin(0.319439828395844*x_60 - 4.28592014312744) - 0.0231959192176695*std::sin(0.355039834976196*x_60 + 5.15856027603149) + 0.0253300380399848*std::sin(0.236559987068176*x_64 + 5.06039953231812) - 0.00664061815473135*std::sin(0.264559954404831*x_64 + 5.08464002609253) - 0.0080190483657265*std::sin(0.280799955129623*x_65 + 8.31047916412354) - 0.00585661346146672*std::sin(0.343039840459824*x_65 + 5.14752006530762) + 0.00238676039158942*std::sin(0.302559942007065*x_66 - 7.21759986877441) + 0.000113964466874081*std::sin(0.358399838209152*x_66 + 8.3439998626709) - 4.15633436275722e-5*std::sin(0.378879845142365*x_66 + 5.16160011291504) - 0.0102157378873383*std::sin(0.237599983811378*x_67 + 5.032639503479) + 0.0262650449062612*std::sin(0.274799972772598*x_67 + 5.09183979034424) + 0.00204760117656918*std::sin(0.333919852972031*x_67 - 4.28336000442505) + 0.00343426614927582*std::sin(0.341039836406708*x_67 + 5.12520027160645) - 0.00339135315177484*std::sin(0.367839843034744*x_67 - 7.41863965988159) + 9.42913432072912e-5*std::sin(0.325999826192856*x_68 - 4.26984024047852) + 0.0204871697753883*std::sin(0.193519994616508*x_69 + 4.98655986785889) + 0.000100753492425475*std::sin(0.258639961481094*x_69 + 5.07599973678589) - 4.65036355228623e-5*std::sin(0.356879830360413*x_69 + 8.36288070678711) + 0.00715908035803753*std::sin(0.20728000998497*x_70 + 5.01175975799561) - 0.0103109940733174*std::sin(0.313279926776886*x_70 + 1.92271995544434) - 0.000675395115494144*std::sin(0.537359833717346*x_71 + 5.15304040908813) - 0.0124220942209051*std::sin(0.239039987325668*x_73 + 5.04247999191284) + 0.010883127702154*std::sin(0.165840014815331*x_74 - 1.26447987556458) - 0.00317689639986401*std::sin(0.365199834108353*x_74 - 4.24535989761353) + 0.00758076158431643*std::sin(0.321599841117859*x_75 + 5.1287202835083) - 0.00355741837675132*std::sin(0.352319836616516*x_75 - 4.25432014465332) - 0.0164445085977322*std::sin(0.178240016102791*x_76 + 4.96903991699219) - 0.00664177875167427*std::sin(0.264239966869354*x_77 - 7.53952026367188) - 0.0466180254255213*std::sin(0.234319984912872*x_78 + 5.03319978713989) + 8.42818399024974e-5*std::sin(0.194319993257523*x_79 + 8.17903900146484) - 0.00471731394683152*std::sin(0.211119994521141*x_79 - 7.58400011062622) - 0.00452726006818595*std::sin(0.266399949789047*x_79 + 1.87991988658905) + 0.00810042484902435*std::sin(0.289679944515228*x_79 - 4.26887989044189) - 0.000137624525987886*std::sin(0.316639840602875*x_79 - 4.29895973205566) - 0.0113181545678892*std::sin(0.317599833011627*x_79 - 7.47359991073608) - 0.0161615706205349*std::sin(0.32711985707283*x_79 + 8.31087970733643) + 0.0127704264189327*std::sin(0.376959830522537*x_79 - 4.22320032119751) + 0.0897027909371185*std::sin(0.204960003495216*x_8 + 8.20911979675293) + 0.0926296559257189*std::sin(0.2291199862957*x_8 + 8.25759983062744) - 0.0124577285111072*std::sin(0.305919945240021*x_8 + 5.13575983047485) - 0.00164104838560395*std::sin(0.467999875545502*x_80 - 4.13312005996704) + 0.00266903062549949*std::sin(0.496479868888855*x_80 - 4.09999990463257) - 4.82067131179444e-5*std::sin(1.71655988693237*x_80 - 1.58871984481812) - 0.0139625742683972*std::sin(0.180960014462471*x_84 - 4.41928005218506) + 0.0108768122213908*std::sin(0.225439995527267*x_84 + 8.22103977203369) - 0.00180130178841073*std::sin(0.464079856872559*x_84 - 1.13943982124329) - 0.000328582488615367*std::sin(1.40207982063293*x_84 - 4.79184007644653) + 1.69593569365323e-6*std::sin(1.99599981307983*x_84 - 4.20552015304565) + 0.169257752455602*std::sin(0.148400038480759*x_85 - 7.67167997360229) - 4.66333079585889e-5*std::sin(0.292079925537109*x_85 + 5.12319993972778) - 0.0180312512843886*std::sin(0.257279992103577*x_86 + 1.86807990074158) - 0.00139926077971262*std::sin(0.549119889736176*x_86 + 8.37264060974121) + 0.0236031874762162*std::sin(0.162640020251274*x_87 + 4.94559955596924) - 0.000594474288922982*std::sin(0.174160018563271*x_87 - 7.61856031417847) + 0.0283465722801695*std::sin(0.217519983649254*x_87 + 5.00527954101563) + 0.026097108736052*std::sin(0.190400004386902*x_89 + 4.97095966339111) + 0.00649498088372822*std::sin(0.306719928979874*x_89 + 5.14775991439819) + 0.000352128260243074*std::sin(0.214959993958473*x_9 + 5.03159952163696) + 0.327048325330464*std::sin(0.215039998292923*x_9 - 4.37368011474609) + 0.0236302663677225*std::sin(0.22511999309063*x_9 - 4.36303997039795) - 0.0980384799952757*std::sin(0.240799978375435*x_9 - 4.34663963317871) - 0.0069275935662454*std::sin(0.273439943790436*x_9 - 4.31191968917847) + 0.0516792741415162*std::sin(0.186160013079643*x_91 - 7.37151956558228) + 0.0427533993515971*std::sin(0.189440011978149*x_91 + 2.01639986038208) + 0.00051130953111322*std::sin(0.20040000975132*x_91 + 2.00647974014282) - 0.000260644324546505*std::sin(0.34759983420372*x_92 + 5.18064022064209) - 0.0100286630450421*std::sin(0.351359844207764*x_92 - 7.38607978820801) + 0.100134564094666*std::sin(0.361999839544296*x_92 + 2.00455975532532) + 0.113514589450304*std::sin(0.365679860115051*x_92 + 1.99591982364655) + 0.000634412582593187*std::sin(0.366239845752716*x_92 + 1.99783980846405) - 0.00731481819398269*std::sin(0.399119853973389*x_92 - 4.40703964233398) - 0.00357908290487924*std::sin(0.404639840126038*x_92 + 2.00263977050781) - 0.00771311526019204*std::sin(0.296879917383194*x_94 - 1.11263990402222) - 0.0054589477181624*std::sin(0.375759840011597*x_94 + 5.18688011169434) - 0.00381641710945031*std::sin(0.386319845914841*x_94 + 1.98831987380981) - 3.28595810007742e-5*std::sin(0.412479877471924*x_94 + 5.20128011703491) + 2.65381150703211e-5*std::sin(0.358399868011475*x_95 - 4.21600008010864) + 0.00236116951599959*std::sin(0.374239832162857*x_95 + 1.98471975326538) + 0.00417388449775807*std::sin(0.386959850788116*x_95 - 7.40423965454102) + 0.00252863624231334*std::sin(0.472799867391586*x_95 + 2.02503991127014) - 0.0060417509763544*std::sin(0.369519859552383*x_96 - 7.43304014205933) + 0.0153061558921801*std::sin(0.374959826469421*x_96 - 7.40423965454102) + 0.00370470042106586*std::sin(0.391199827194214*x_96 + 5.18480014801025) + 3.26011437347552e-5*std::sin(0.33927983045578*x_97 - 4.25487995147705) - 0.00682665347190391*std::sin(0.408799856901169*x_97 - 4.18495988845825) + 0.0109061866540938*std::sin(0.529279828071594*x_97 - 4.23943996429443) - 0.00336709373350902*std::sin(0.283199936151505*x_98 + 5.1069598197937) - 0.00721281209273216*std::sin(0.345519840717316*x_98 - 4.25439977645874) - 0.00614059394237149*std::sin(0.360719859600067*x_98 - 4.22751998901367) - 0.00014913203417156*std::sin(0.361119836568832*x_98 + 5.15664005279541) - 0.0109970330508831*std::sin(0.382719844579697*x_98 + 5.17623996734619) + 0.00563980782940856*std::sin(0.386799842119217*x_98 - 7.39551973342896) + 0.0118625592809629*std::sin(0.391679853200912*x_99 - 7.39479970932007) + 0.00378694452479875*std::sin(0.398319840431213*x_99 - 4.20351982116699) - 0.00430035298249319*std::sin(0.476239860057831*x_99 - 1.14175987243652) - 0.102500346419977);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-8.93004110264015e-5*x_1 + 7.84428649523501e-5*x_10 + 0.000422880239816034*x_100 - 0.000118097278469159*x_101 - 0.000196762020641861*x_102 + 0.000470952806789292*x_103 - 0.00315730449931031*x_104 - 0.00033351057939511*x_105 - 3.86017161745782e-6*x_106 - 5.5166639361887e-6*x_107 - 4.9641714023533e-5*x_108 + 0.000188979784217861*x_109 - 0.000612658594833275*x_11 + 0.00136644576989732*x_110 + 0.00321756874904306*x_111 + 8.8279576532351e-5*x_112 + 0.00412218300991818*x_113 + 4.90304475597321e-5*x_114 - 2.71874430520901e-6*x_115 - 0.000183041495843605*x_116 - 5.25932858200743e-6*x_117 - 8.99646804843718e-6*x_118 + 0.000257263426549938*x_119 - 0.00551663354875873*x_12 - 0.0015530179433026*x_120 - 0.00387488913143951*x_13 - 2.99285590253286e-5*x_14 - 7.11264464403084e-5*x_15 + 0.000103395452009272*x_16 - 0.00143942499639185*x_17 - 0.000274008615836827*x_18 - 0.000107991586050356*x_19 - 0.00814701460563939*x_2 - 0.000838379158593691*x_20 - 0.00128822033308263*x_21 - 0.000117295359620938*x_22 + 0.000237388142371661*x_23 + 0.00144163508284467*x_24 - 0.000226541288879158*x_25 - 3.17441823168473e-5*x_26 + 4.54236022567967e-5*x_27 + 0.000117262757206127*x_28 + 0.00287403289332921*x_29 - 5.54672036188989e-5*x_3 - 0.000973092012607718*x_30 - 0.00439572030211733*x_31 + 0.00184915468775754*x_32 + 0.000423084775636153*x_33 - 0.000309173772261784*x_34 - 2.41733175783323e-5*x_35 + 9.07638047913677e-6*x_36 - 0.00130994824741765*x_37 - 0.00235612658775085*x_38 + 0.00235771461583366*x_39 + 0.000449571684693249*x_4 + 0.000490961941497252*x_40 + 0.000422140623187482*x_41 - 0.00231657473986151*x_42 - 0.000855310074299881*x_43 - 0.00163688433848133*x_44 - 9.48345336636818e-7*x_45 + 0.00113765908949575*x_46 - 0.000679003245862522*x_47 - 2.8593382623579e-5*x_48 + 0.00165826297384998*x_49 + 9.41941843556244e-5*x_5 - 0.00267563403983091*x_50 - 0.00036096329047937*x_51 - 0.00144091776636582*x_52 + 2.76698535188589e-5*x_53 + 0.0021801065707626*x_54 - 1.31199373332439e-5*x_55 + 0.00142522130943202*x_56 + 0.000593696083947167*x_57 - 8.88127913882467e-5*x_58 + 0.00203761717272893*x_59 + 0.000497825987267096*x_6 + 0.00388603544748365*x_60 + 5.70981258941852e-6*x_61 - 0.000712268853750541*x_62 + 0.00463867837405756*x_63 - 7.14460071954973e-5*x_64 - 0.00125286265292208*x_65 - 0.000175534362640764*x_66 + 7.78885787846953e-5*x_67 - 0.000356491986825924*x_68 - 3.89483255019521e-8*x_69 - 0.00737370186171833*x_7 + 0.00010173894308109*x_70 + 2.78451782444883e-5*x_71 + 0.00184316140014699*x_72 - 0.000136873829560869*x_73 + 0.000711487721735879*x_74 - 0.000174981308510029*x_75 + 0.000882454829978198*x_76 - 2.97504230729258e-5*x_77 + 0.000419199826947299*x_78 - 2.84058867669766e-5*x_79 + 0.0026474939705766*x_8 + 3.75128786203361e-5*x_80 + 0.000144174376384127*x_81 + 3.75324219985366e-5*x_82 + 0.000970025983031398*x_83 + 1.36157228490769e-7*x_84 - 0.000740769806671711*x_85 - 0.00110424237656065*x_86 - 0.00118664395986918*x_87 - 0.00108633409995288*x_88 - 0.00280494335846408*x_89 - 6.73554793097223e-5*x_9 - 0.00244585385082931*x_90 + 0.0151531132041226*x_91 + 0.00741154671422296*x_92 + 0.0021489303948035*x_93 + 4.75625239809554e-6*x_94 - 0.00154856693670318*x_95 + 3.37619456875883e-5*x_96 + 0.000212334841271605*x_97 - 1.08912118939989e-5*x_98 + 0.00198741163745963*x_99 - 1.58627003738926e-5*std::pow(-5.50903987884521*x_13 - 8.56120014190674, 2) + 1.07446682325424e-8*std::pow(-5.40360021591187*x_14 - 8.1974401473999, 2) + 2.66595084434722e-6*std::pow(-5.1081600189209*x_14 - 7.96799993515015, 2) - 1.93808494560206e-5*std::pow(-4.90744018554688*x_14 - 7.37560033798218, 2) + 3.68839421990349e-6*std::pow(-5.78351974487305*x_15 - 7.58104038238525, 2) + 1.11750330235503e-5*std::pow(-5.33127975463867*x_15 - 7.50687980651855, 2) - 0.00075810826427992*std::pow(-5.31104040145874*x_15 - 7.75784015655518, 2) - 5.54880818323453e-6*std::pow(-3.07200002670288*x_15 - 4.79999971389771, 2) + 4.50197035936708e-7*std::pow(-5.25880002975464*x_17 - 7.69080018997192, 2) + 9.59757930417004e-6*std::pow(-4.46319961547852*x_17 - 6.49072027206421, 2) + 3.14863055616026e-7*std::pow(-2.07751989364624*x_17 - 2.91079998016357, 2) - 6.12608225660481e-7*std::pow(-6.5796799659729*x_18 - 9.78975963592529, 2) - 2.44270549646943e-8*std::pow(-6.57512044906616*x_18 - 9.37152004241943, 2) - 9.86809127830375e-6*std::pow(-5.29320001602173*x_18 - 8.33983993530273, 2) + 5.35064894533047e-8*std::pow(-4.91903972625732*x_18 - 9.68000030517578, 2) + 2.51370574332513e-7*std::pow(-3.24055981636047*x_2 - 5.87591981887817, 2) + 1.4798902278176e-5*std::pow(-3.23535990715027*x_2 - 5.85767984390259, 2) + 1.9915198182339e-7*std::pow(-5.72215986251831*x_22 - 9.58920001983643, 2) - 1.31555735359091e-7*std::pow(-5.64527988433838*x_22 - 9.06455993652344, 2) + 9.2276143118262e-8*std::pow(-4.69063997268677*x_22 - 7.54383945465088, 2) + 1.61651770633701e-5*std::pow(-3.50623989105225*x_22 - 5.77040004730225, 2) - 1.45034876273367e-5*std::pow(-1.23087990283966*x_23 - 1.85415983200073, 2) - 5.05232249545152e-8*std::pow(-6.78079986572266*x_27 - 9.1778392791748, 2) - 4.35976044427165e-7*std::pow(-6.60400009155273*x_27 - 9.9750394821167, 2) + 6.38157855104755e-7*std::pow(-5.82399988174438*x_4 - 9.65783977508545, 2) - 0.000915283045440499*std::pow(-3.396399974823*x_4 - 5.59624004364014, 2) + 2.74503290087422e-8*std::pow(-6.40000009536743*x_5 - 9.99995994567871, 2) - 2.59717678823361e-8*std::pow(-6.19999980926514*x_5 - 9.99948024749756, 2) - 4.91420098172318e-6*std::pow(-5.87680006027222*x_5 - 9.11728000640869, 2) + 1.8785881767725e-6*std::pow(-4.81839990615845*x_5 - 7.81911993026733, 2) + 0.000103469820337117*std::pow(-3.91319990158081*x_5 - 6.38520002365112, 2) + 0.000222624964960303*std::pow(-1.71423983573914*x_5 - 2.66727995872498, 2) + 1.42216171865914e-6*std::pow(-5.514479637146*x_6 - 8.792799949646, 2) + 1.01049585925574e-5*std::pow(-3.50671982765198*x_6 - 5.57079982757568, 2) + 6.07854144293811e-8*std::pow(-5.12335968017578*x_66 - 7.99567985534668, 2) - 1.26298718968907e-8*std::pow(-5.26424026489258*x_67 - 8.09687995910645, 2) - 7.9116724623821e-8*std::pow(-4.71519947052002*x_67 - 8.39935970306396, 2) - 2.45710889724041e-8*std::pow(-6.60000038146973*x_68 - 9.96571922302246, 2) - 1.74132736741164e-5*std::pow(-5.98231983184814*x_7 - 9.59111976623535, 2) + 2.18191521702877e-7*std::pow(-5.28568029403687*x_7 - 8.53200054168701, 2) + 5.2738516518454e-6*std::pow(-5.20592021942139*x_7 - 8.61111927032471, 2) - 3.30679081415555e-6*std::pow(-4.92143964767456*x_7 - 8.06775951385498, 2) + 1.32241291843801e-6*std::pow(-4.83440017700195*x_7 - 7.85383987426758, 2) + 5.72036449896241e-5*std::pow(-4.3101601600647*x_71 - 6.57128000259399, 2) + 4.62173867468286e-7*std::pow(-4.37599992752075*x_72 - 6.1669602394104, 2) + 6.39692248385952e-8*std::pow(-3.8711199760437*x_72 - 5.22455978393555, 2) + 2.74812916257893e-5*std::pow(-6.0*x_77 - 9.99911975860596, 2) + 1.2490049669296e-6*std::pow(-7.76000022888184*x_80 - 9.79903984069824, 2) - 7.96960094734906e-8*std::pow(-4.18959999084473*x_80 - 6.58544015884399, 2) + 6.38758113159795e-8*std::pow(-9.97459983825684*x_81 - 6.60400009155273, 2) - 1.33588714980102e-8*std::pow(-7.59576034545898*x_81 - 8.78192043304443, 2) + 1.05638073026291e-5*std::pow(-5.0*x_81 - 9.99964046478271, 2) - 3.28306996689602e-6*std::pow(-7.46039962768555*x_82 - 9.46856021881104, 2) + 4.63694164212894e-7*std::pow(-5.52776002883911*x_85 - 7.56920003890991, 2) - 3.67320658796743e-7*std::pow(-5.29983949661255*x_85 - 7.26336002349854, 2) + 1.46572738672832e-8*std::pow(-4.47440004348755*x_85 - 8.12800025939941, 2) - 2.39781416187576e-8*std::pow(-6.60000038146973*x_88 - 9.99792003631592, 2) - 1.46567582729973e-7*std::pow(-6.29087972640991*x_88 - 8.66224002838135, 2) - 4.66059971071516e-6*std::pow(-5.65199995040894*x_88 - 7.40236043930054, 2) + 2.67015202562123e-6*std::pow(-6.20728015899658*x_90 - 8.81319999694824, 2) - 3.82441753079615e-7*std::exp(0.868719875812531*x_27) + 2.95150258456057e-6*std::exp(0.473039865493774*x_71) + 0.000195574305105059*std::exp(0.530879855155945*x_71) + 0.000994384969379577*std::sin(0.228959992527962*x_1 + 5.01823997497559) + 0.193041167128964*std::sin(0.236639991402626*x_1 + 1.97687971591949) + 5.08883058955826e-5*std::sin(0.276399940252304*x_1 - 1.18871986865997) + 0.000201917302348888*std::sin(0.285039931535721*x_1 + 1.9968798160553) + 0.000459785301200091*std::sin(0.297599911689758*x_1 + 1.98135983943939) + 0.0210158468185571*std::sin(0.302639931440353*x_1 - 7.43455982208252) - 0.00622518180574652*std::sin(0.311999946832657*x_1 - 7.43711996078491) + 0.000114835456388776*std::sin(0.218239992856979*x_10 - 4.37031984329224) + 0.000868444476996066*std::sin(0.269119948148727*x_10 - 4.30751943588257) - 0.0296364961622935*std::sin(0.285759955644608*x_10 + 5.09208011627197) + 0.151546834038241*std::sin(0.294239938259125*x_10 + 5.10759973526001) - 7.95236477097385e-5*std::sin(0.323919832706451*x_10 - 4.27239990234375) - 0.0691288008465613*std::sin(0.368399828672409*x_101 + 8.18271923065186) - 0.0431356191980868*std::sin(0.282879948616028*x_102 - 4.32231998443604) - 3.67730001754685e-5*std::sin(0.383199840784073*x_102 + 5.18440008163452) - 5.56840593797439e-5*std::sin(0.385439842939377*x_102 + 1.96247982978821) - 0.000818347708537833*std::sin(0.306239932775497*x_103 - 4.27127981185913) - 3.59184397085425e-5*std::sin(0.361359834671021*x_103 + 1.97855985164642) - 2.04873384987794e-5*std::sin(0.365279853343964*x_103 - 7.4171199798584) - 0.00424766933107093*std::sin(0.321119844913483*x_105 - 4.27928018569946) - 0.000110088110329768*std::sin(0.393999844789505*x_105 - 4.1908802986145) + 1.35174152449204e-5*std::sin(0.241679981350899*x_106 + 5.03127956390381) + 0.00290900353994311*std::sin(0.263999968767166*x_106 + 5.06047964096069) + 0.000474705076670063*std::sin(0.353919863700867*x_106 - 7.43991994857788) + 6.96707529930568e-5*std::sin(0.373599827289581*x_106 - 7.40431976318359) + 0.000210407230935555*std::sin(0.374559849500656*x_106 - 7.4235200881958) + 2.48841706924643e-5*std::sin(0.388399839401245*x_106 - 7.39368009567261) + 0.0143010034695805*std::sin(0.485679864883423*x_106 + 5.2596001625061) + 0.000106809496134691*std::sin(0.539679825305939*x_106 - 7.21880006790161) + 0.0274051196233175*std::sin(0.337519854307175*x_107 - 7.45607995986938) + 1.47444967539525e-5*std::sin(0.345039844512939*x_107 - 4.25472021102905) + 0.0366267790522207*std::sin(0.499759823083878*x_108 + 5.28000020980835) + 7.0322865865467e-5*std::sin(0.333519846200943*x_109 - 7.4410400390625) - 0.0179145580319945*std::sin(0.40311986207962*x_109 + 1.98511981964111) + 9.91925520528488e-6*std::sin(0.471919864416122*x_109 + 2.02095985412598) - 0.00267324794024831*std::sin(0.269839972257614*x_11 + 8.28728008270264) - 3.85490727231347e-5*std::sin(0.289919942617416*x_11 + 8.31727981567383) - 0.000126208628015355*std::sin(0.294399946928024*x_11 + 8.31807994842529) + 6.78916719329074e-5*std::sin(0.41567987203598*x_110 + 5.20975971221924) + 8.42710683059311e-5*std::sin(0.308079928159714*x_111 + 5.13520002365112) + 1.16653796626451e-5*std::sin(0.447919845581055*x_111 + 5.0274395942688) + 0.000280761892040306*std::sin(0.55351984500885*x_111 - 7.41264009475708) - 1.5446981619775e-5*std::sin(0.241919979453087*x_112 - 1.15607988834381) + 0.0442222660525658*std::sin(0.357759833335876*x_112 + 5.15887975692749) + 0.000105361599125473*std::sin(0.437519878149033*x_112 + 8.21895980834961) - 1.4009052002271e-5*std::sin(0.437919855117798*x_113 - 1.18151986598969) - 9.85819987087817e-5*std::sin(0.347919851541519*x_114 + 8.33896064758301) + 0.00342995068341074*std::sin(0.362399846315384*x_114 - 7.42384004592896) + 0.000218186486876628*std::sin(0.386159837245941*x_114 - 7.42127990722656) + 0.0132141386827381*std::sin(0.481919854879379*x_114 - 1.14231991767883) + 3.0686906194067e-6*std::sin(0.294959932565689*x_115 + 8.33543968200684) + 6.89869683938543e-5*std::sin(0.337519854307175*x_115 + 5.14039993286133) - 2.268892412853e-5*std::sin(0.396719843149185*x_115 - 7.40727996826172) + 0.0250199623426612*std::sin(0.404239863157272*x_115 + 5.19208002090454) + 8.52564148574601e-5*std::sin(0.521999835968018*x_115 + 8.35608005523682) - 5.53771525212498e-6*std::sin(0.53415983915329*x_115 - 4.23967981338501) + 0.000207229915040547*std::sin(0.638719856739044*x_115 - 4.17447996139526) + 6.58518622528354e-6*std::sin(0.257519960403442*x_117 - 4.34143972396851) - 4.62218703842681e-5*std::sin(0.393999844789505*x_117 + 5.18584012985229) - 0.000244685564768293*std::sin(0.438319861888885*x_117 - 4.16440010070801) + 2.89989737445878e-5*std::sin(0.476639837026596*x_117 + 5.24015998840332) + 0.000347223948785731*std::sin(0.370799839496613*x_118 - 7.40967988967896) - 0.00132987602472987*std::sin(0.390239834785461*x_118 + 5.17920017242432) + 0.000412122230204123*std::sin(0.392959833145142*x_118 - 7.40463972091675) - 0.0367554479852802*std::sin(0.393359839916229*x_118 + 5.19456005096436) + 9.42587563441108e-6*std::sin(0.42647984623909*x_118 - 1.16159987449646) + 7.25386654330117e-5*std::sin(0.328399837017059*x_119 - 4.2469596862793) + 5.3446177102255e-5*std::sin(0.335759848356247*x_119 - 7.44079971313477) + 0.0381718251174357*std::sin(0.343999862670898*x_119 - 7.43631982803345) + 7.72454491248884e-6*std::sin(0.415999859571457*x_119 - 1.17535984516144) + 0.000158007253747459*std::sin(0.421519845724106*x_119 + 1.98623979091644) - 9.09999628319173e-5*std::sin(0.433919847011566*x_119 - 1.15335988998413) + 0.00584044806409861*std::sin(0.341599822044373*x_12 - 4.25816011428833) + 4.3215653540289e-5*std::sin(0.392639845609665*x_12 + 5.19840002059937) - 0.0021485572544414*std::sin(0.300879925489426*x_120 + 1.90599989891052) + 2.50236779476932e-5*std::sin(0.331999838352203*x_120 - 1.06463980674744) - 7.84561185714123e-5*std::sin(0.460639864206314*x_120 + 2.05159974098206) + 0.000118609575954469*std::sin(0.203759998083115*x_13 + 8.19944000244141) + 1.45496172116918*std::sin(0.117440059781075*x_14 - 4.53320026397705) - 0.00151626857835726*std::sin(0.12216005474329*x_14 - 4.52631998062134) + 0.000485126937979487*std::sin(0.250799983739853*x_14 - 4.31239986419678) + 0.000215937734716339*std::sin(0.142320036888123*x_15 - 4.48423957824707) - 0.00200710695691506*std::sin(0.333919852972031*x_16 - 4.24720001220703) - 0.0142712216368198*std::sin(0.359999865293503*x_16 + 5.17304039001465) + 0.0992005131060052*std::sin(0.363919854164124*x_16 - 4.24200010299683) - 8.16299792131716e-6*std::sin(0.388799846172333*x_16 - 1.18391978740692) + 3.31723029842649e-5*std::sin(0.401599854230881*x_16 + 5.20815992355347) - 0.000344313464310666*std::sin(0.331119894981384*x_17 - 4.21216011047363) + 1.27242219372111e-6*std::sin(1.23015987873077*x_17 + 5.81080007553101) - 2.53501061945269e-5*std::sin(0.222159996628761*x_18 - 4.37863969802856) - 0.000125515827026923*std::sin(0.269999951124191*x_18 + 8.30519962310791) + 0.355959473133991*std::sin(0.159040033817291*x_19 - 4.45383977890015) - 0.000149519726801639*std::sin(0.326479852199554*x_21 - 4.25343990325928) - 0.000355405154429468*std::sin(0.335279852151871*x_21 + 5.160560131073) + 5.3193670040737e-5*std::sin(0.33679986000061*x_21 + 8.35943984985352) - 0.00218135713863233*std::sin(0.153520032763481*x_23 - 7.64976024627686) - 0.000263603527416645*std::sin(0.191040009260178*x_23 + 4.99199962615967) + 0.000883151032264536*std::sin(0.205360010266304*x_23 + 5.00831985473633) - 0.174553251258608*std::sin(0.245599970221519*x_23 + 5.0688796043396) - 2.3504517924482e-5*std::sin(0.414879858493805*x_23 + 5.20208024978638) - 0.000470293696540984*std::sin(0.276959955692291*x_24 + 5.09240007400513) - 0.000221034122517831*std::sin(0.326639831066132*x_24 - 4.2720799446106) - 0.000781967649122989*std::sin(0.358239859342575*x_24 + 8.34879970550537) - 0.0167925475067609*std::sin(0.311839938163757*x_26 - 4.27183961868286) - 0.0342609330775467*std::sin(0.312079936265945*x_26 - 4.2720799446106) + 0.00189107240359084*std::sin(0.346559852361679*x_26 - 4.25408029556274) + 0.000552369514722855*std::sin(0.181520000100136*x_27 - 7.61520004272461) + 0.00464639059835383*std::sin(0.222159996628761*x_27 + 5.0272798538208) + 0.0173457959854174*std::sin(0.22919999063015*x_27 - 7.55919981002808) - 0.00192117471543065*std::sin(0.250079959630966*x_27 - 7.52135992050171) + 1.1630550636024e-5*std::sin(0.293599933385849*x_27 + 8.32111930847168) + 0.1836274662567*std::sin(0.301199913024902*x_27 + 5.11639976501465) - 0.00214646792726877*std::sin(0.225199982523918*x_28 - 4.36520004272461) - 0.000543596155776031*std::sin(0.279359966516495*x_28 + 5.0991997718811) + 0.000182635868863587*std::sin(0.29911994934082*x_28 - 4.28567981719971) - 0.00177666710267173*std::sin(0.327599853277206*x_28 - 4.27360010147095) + 1.17004946863027e-5*std::sin(0.475359857082367*x_28 + 5.25095987319946) - 0.000135975363217873*std::sin(0.285999953746796*x_3 + 8.2903995513916) - 0.000104674135674918*std::sin(0.293039947748184*x_3 + 8.30327987670898) - 0.00399793551055509*std::sin(0.300399929285049*x_3 - 4.27288007736206) + 0.000123829002773924*std::sin(0.316799849271774*x_3 + 8.31775951385498) + 0.00634152502401837*std::sin(0.321359843015671*x_3 + 8.31960010528564) + 0.407026717099204*std::sin(0.321439832448959*x_3 + 8.32264041900635) + 1.50741742926071e-5*std::sin(0.368239849805832*x_3 - 1.03407979011536) - 0.00109676579686086*std::sin(0.274559944868088*x_30 + 8.28799915313721) + 8.13076474614349e-5*std::sin(0.275599956512451*x_30 + 8.26799964904785) + 0.00038370936725267*std::sin(0.170720010995865*x_31 + 8.43936061859131) + 0.0138337693084141*std::sin(0.270079970359802*x_32 - 7.44039964675903) - 1.92952795600627e-5*std::sin(0.273199945688248*x_32 + 1.97919988632202) + 0.000224168628482353*std::sin(0.337679862976074*x_34 + 5.20703983306885) + 0.000240728315842441*std::sin(0.379599839448929*x_34 + 1.97711980342865) + 6.73033606516093e-5*std::sin(0.303839921951294*x_35 - 1.11191987991333) - 0.035725896633796*std::sin(0.340079843997955*x_35 - 1.19399988651276) - 0.000118317907617013*std::sin(0.322799831628799*x_36 - 4.26735973358154) - 0.000335057930882986*std::sin(0.338079839944839*x_36 - 7.43224000930786) - 0.0384944732873548*std::sin(0.350559860467911*x_36 + 8.34632015228271) + 2.66248616373345e-5*std::sin(0.357679843902588*x_36 - 4.24528026580811) - 0.00298110183606216*std::sin(0.364799857139587*x_36 - 4.22959995269775) + 3.98371253950014e-5*std::sin(0.411119878292084*x_36 + 5.20232009887695) - 0.00137492354865805*std::sin(0.2360799908638*x_37 - 4.35727977752686) + 0.000979122408329871*std::sin(0.362399846315384*x_37 + 5.16695976257324) - 0.000383851697487151*std::sin(0.388159841299057*x_37 - 4.19992017745972) + 0.000210373340897546*std::sin(0.433199852705002*x_38 + 5.23192024230957) + 2.72900176852597e-5*std::sin(0.451359868049622*x_38 + 8.44312000274658) + 5.65747244232446e-6*std::sin(0.345439851284027*x_39 + 1.95567977428436) + 2.03386815959847e-5*std::sin(0.308479934930801*x_41 - 4.28967952728271) - 1.90130859270321e-5*std::sin(0.319679856300354*x_42 - 4.26688003540039) - 2.40660971830251e-5*std::sin(0.369279831647873*x_43 + 5.17000007629395) - 2.66360757140266e-6*std::sin(0.404799848794937*x_43 + 5.19200038909912) - 7.5375456940452e-5*std::sin(0.420399844646454*x_43 + 5.20608043670654) - 0.000233096443993036*std::sin(0.331839829683304*x_45 - 4.27144002914429) + 9.01631965075343e-5*std::sin(0.352159857749939*x_45 + 5.16239976882935) + 0.00229148625841806*std::sin(0.355999857187271*x_45 - 7.44447994232178) - 0.000445088938977002*std::sin(0.363999843597412*x_45 - 4.23320007324219) + 0.000699812828076174*std::sin(0.365999847650528*x_45 - 4.23720026016235) + 6.91566316742853e-6*std::sin(0.288639932870865*x_46 + 5.12536001205444) + 0.000263583863561559*std::sin(0.30927985906601*x_46 - 7.48751974105835) - 7.76379028436786e-5*std::sin(0.32847985625267*x_46 - 7.45831966400146) - 0.00273296254460525*std::sin(0.334399849176407*x_46 - 4.27008008956909) + 5.06812105621517e-5*std::sin(0.337759852409363*x_46 + 5.14007997512817) - 0.000212006401331083*std::sin(0.416399866342545*x_46 - 7.3724799156189) + 0.000142769601474941*std::sin(0.454959839582443*x_46 + 5.23360013961792) - 0.00343086754916414*std::sin(0.211119994521141*x_47 + 8.22288036346436) - 0.000100076063497413*std::sin(0.451359868049622*x_47 + 2.03895974159241) + 3.03684695998971e-5*std::sin(0.502319812774658*x_47 - 4.3219199180603) + 0.000123658804624489*std::sin(0.536159813404083*x_47 - 4.23135995864868) - 5.06669149997219e-5*std::sin(0.416239857673645*x_48 + 5.21384000778198) + 0.000393863369093863*std::sin(0.500239849090576*x_48 + 2.05039978027344) + 0.00719364193195607*std::sin(0.591679811477661*x_48 + 5.18351984024048) + 7.12961366482507e-5*std::sin(0.348399847745895*x_49 + 5.13439989089966) + 1.87381535735449e-5*std::sin(0.411999881267548*x_49 + 2.01895976066589) - 0.00476041547864456*std::sin(0.180480018258095*x_50 - 4.43503999710083) + 1.11803826488316e-5*std::sin(0.459599852561951*x_50 - 7.339439868927) + 7.95171780550196e-5*std::sin(0.282959938049316*x_51 + 5.10951995849609) + 2.8806076777531e-5*std::sin(0.322239845991135*x_51 + 5.13632011413574) + 0.000359080636653876*std::sin(0.339839845895767*x_53 + 5.13575983047485) + 3.32287401295789e-6*std::sin(0.435999870300293*x_53 + 8.42735958099365) - 0.000297126843119855*std::sin(0.193519994616508*x_54 - 4.41111993789673) - 0.000348942738912363*std::sin(0.465039849281311*x_54 + 8.46759986877441) + 1.31154113300742e-5*std::sin(0.210319995880127*x_55 - 4.39687967300415) + 5.80229027526177e-5*std::sin(0.265359967947006*x_55 - 4.29959964752197) - 0.000264917997948099*std::sin(0.346879839897156*x_55 - 4.23952007293701) - 0.0219713356616492*std::sin(0.349599838256836*x_55 + 1.96415984630585) + 3.90155003085483e-5*std::sin(0.421679854393005*x_55 + 5.23280000686646) - 0.00051981281513549*std::sin(0.289999932050705*x_56 - 4.28191947937012) - 0.000715462604306605*std::sin(0.282079964876175*x_57 - 4.2885594367981) - 6.5434396419602e-5*std::sin(0.197759985923767*x_58 + 4.99087953567505) + 0.000264601971357551*std::sin(0.366159826517105*x_58 + 5.17632007598877) - 0.0178655537885289*std::sin(0.38239985704422*x_58 + 5.19072008132935) + 6.21791714377194e-5*std::sin(0.435119867324829*x_58 + 5.24216032028198) - 0.000206126018741837*std::sin(0.467359870672226*x_58 + 2.0590398311615) + 0.00107925914157631*std::sin(0.329519838094711*x_59 - 4.26416015625) - 0.000148859518557387*std::sin(0.331599831581116*x_59 - 7.44951963424683) - 0.000625331222065026*std::sin(0.350239843130112*x_59 + 5.14416027069092) + 4.85778550669136e-5*std::sin(0.366159826517105*x_59 + 5.15992021560669) + 0.00297034349816749*std::sin(0.384639829397202*x_59 + 5.174880027771) - 2.41344909794717e-6*std::sin(0.41007986664772*x_59 - 4.20344018936157) - 2.33812109292497e-6*std::sin(0.562719821929932*x_59 - 4.22799968719482) + 3.10616909794389e-5*std::sin(0.319439828395844*x_60 - 4.28592014312744) + 8.66886368447384e-5*std::sin(0.355039834976196*x_60 + 5.15856027603149) - 0.070420376304029*std::sin(0.236559987068176*x_64 + 5.06039953231812) + 2.60411766073888e-5*std::sin(0.264559954404831*x_64 + 5.08464002609253) + 0.000156537334167909*std::sin(0.280799955129623*x_65 + 8.31047916412354) + 4.02944614017008e-6*std::sin(0.343039840459824*x_65 + 5.14752006530762) - 0.000264947882262736*std::sin(0.302559942007065*x_66 - 7.21759986877441) + 0.000202717930846617*std::sin(0.358399838209152*x_66 + 8.3439998626709) + 0.00154876589022186*std::sin(0.378879845142365*x_66 + 5.16160011291504) - 0.00114457881106027*std::sin(0.237599983811378*x_67 + 5.032639503479) - 0.0730198013529018*std::sin(0.274799972772598*x_67 + 5.09183979034424) - 8.0296657055253e-6*std::sin(0.333919852972031*x_67 - 4.28336000442505) + 2.02318941659853e-5*std::sin(0.341039836406708*x_67 + 5.12520027160645) + 0.000376465035507581*std::sin(0.367839843034744*x_67 - 7.41863965988159) - 0.0035135579420944*std::sin(0.325999826192856*x_68 - 4.26984024047852) - 0.0569566537053745*std::sin(0.193519994616508*x_69 + 4.98655986785889) - 0.00375435561170268*std::sin(0.258639961481094*x_69 + 5.07599973678589) - 8.27198251228245e-5*std::sin(0.356879830360413*x_69 + 8.36288070678711) + 0.000802108645978825*std::sin(0.20728000998497*x_70 + 5.01175975799561) + 0.0286657320279358*std::sin(0.313279926776886*x_70 + 1.92271995544434) - 7.56717671120294e-5*std::sin(0.537359833717346*x_71 + 5.15304040908813) + 4.87132284830643e-5*std::sin(0.239039987325668*x_73 + 5.04247999191284) - 4.26781730147567e-5*std::sin(0.165840014815331*x_74 - 1.26447987556458) - 0.000355941816863255*std::sin(0.365199834108353*x_74 - 4.24535989761353) + 0.000849354121728447*std::sin(0.321599841117859*x_75 + 5.1287202835083) + 1.39504121539269e-5*std::sin(0.352319836616516*x_75 - 4.25432014465332) + 0.00182546088127391*std::sin(0.178240016102791*x_76 + 4.96903991699219) + 0.000737286080712056*std::sin(0.264239966869354*x_77 - 7.53952026367188) + 0.129603393719103*std::sin(0.234319984912872*x_78 + 5.03319978713989) - 0.00314057598387092*std::sin(0.194319993257523*x_79 + 8.17903900146484) + 0.000523656394075306*std::sin(0.211119994521141*x_79 - 7.58400011062622) - 2.66709225727144e-5*std::sin(0.266399949789047*x_79 + 1.87991988658905) - 0.0225200990693477*std::sin(0.289679944515228*x_79 - 4.26887989044189) - 0.000244804015736205*std::sin(0.316639840602875*x_79 - 4.29895973205566) + 0.000220938154124378*std::sin(0.317599833011627*x_79 - 7.47359991073608) + 1.11194257200801e-5*std::sin(0.32711985707283*x_79 + 8.31087970733643) - 4.77261042252645e-5*std::sin(0.376959830522537*x_79 - 4.22320032119751) - 0.00175106011590263*std::sin(0.204960003495216*x_8 + 8.20911979675293) - 0.000346178934675755*std::sin(0.2291199862957*x_8 + 8.25759983062744) + 4.8852968311919e-5*std::sin(0.305919945240021*x_8 + 5.13575983047485) + 0.0001821683885775*std::sin(0.467999875545502*x_80 - 4.13312005996704) - 0.00742020760955656*std::sin(0.496479868888855*x_80 - 4.09999990463257) - 5.40111570932604e-6*std::sin(1.71655988693237*x_80 - 1.58871984481812) + 5.47542192526236e-5*std::sin(0.180960014462471*x_84 - 4.41928005218506) - 0.00120740580997654*std::sin(0.225439995527267*x_84 + 8.22103977203369) - 0.000201819181548819*std::sin(0.464079856872559*x_84 - 1.13943982124329) + 0.000913496555302545*std::sin(1.40207982063293*x_84 - 4.79184007644653) - 6.3195285198312e-5*std::sin(1.99599981307983*x_84 - 4.20552015304565) - 0.000632556256904159*std::sin(0.148400038480759*x_85 - 7.67167997360229) + 0.00173768687528214*std::sin(0.292079925537109*x_85 + 5.12319993972778) + 7.07095315839562e-5*std::sin(0.257279992103577*x_86 + 1.86807990074158) - 0.000156774210269408*std::sin(0.549119889736176*x_86 + 8.37264060974121) - 9.25598730786108e-5*std::sin(0.162640020251274*x_87 + 4.94559955596924) - 0.00105744010477523*std::sin(0.174160018563271*x_87 - 7.61856031417847) - 0.000105937845667132*std::sin(0.217519983649254*x_87 + 5.00527954101563) + 0.000153742872286515*std::sin(0.190400004386902*x_89 + 4.97095966339111) - 2.54700602133362e-5*std::sin(0.306719928979874*x_89 + 5.14775991439819) + 0.000626359375575947*std::sin(0.214959993958473*x_9 + 5.03159952163696) - 0.00638420803272855*std::sin(0.215039998292923*x_9 - 4.37368011474609) - 9.2666062921125e-5*std::sin(0.22511999309063*x_9 - 4.36303997039795) + 0.272558084699445*std::sin(0.240799978375435*x_9 - 4.34663963317871) + 0.000769013618217197*std::sin(0.273439943790436*x_9 - 4.31191968917847) - 0.00100881494123681*std::sin(0.186160013079643*x_91 - 7.37151956558228) - 2.94150401302564e-5*std::sin(0.189440011978149*x_91 + 2.01639986038208) + 0.000909508138917988*std::sin(0.20040000975132*x_91 + 2.00647974014282) - 0.000463629406676043*std::sin(0.34759983420372*x_92 + 5.18064022064209) + 3.93273908251845e-5*std::sin(0.351359844207764*x_92 - 7.38607978820801) - 0.011115669922994*std::sin(0.361999839544296*x_92 + 2.00455975532532) - 0.000424230871348312*std::sin(0.365679860115051*x_92 + 1.99591982364655) - 0.0236399789451992*std::sin(0.366239845752716*x_92 + 1.99783980846405) + 5.03271491822304e-6*std::sin(0.399119853973389*x_92 - 4.40703964233398) - 0.000401003089657398*std::sin(0.404639840126038*x_92 + 2.00263977050781) + 2.88257361761745e-5*std::sin(0.296879917383194*x_94 - 1.11263990402222) + 0.0151764932974119*std::sin(0.375759840011597*x_94 + 5.18688011169434) - 0.000427594189065752*std::sin(0.386319845914841*x_94 + 1.98831987380981) + 0.00122443946466378*std::sin(0.412479877471924*x_94 + 5.20128011703491) - 0.000988884045999377*std::sin(0.358399868011475*x_95 - 4.21600008010864) - 0.000262107107664386*std::sin(0.374239832162857*x_95 + 1.98471975326538) - 1.63678833524735e-5*std::sin(0.386959850788116*x_95 - 7.40423965454102) + 1.48966616491113e-5*std::sin(0.472799867391586*x_95 + 2.02503991127014) + 0.0167967524019703*std::sin(0.369519859552383*x_96 - 7.43304014205933) - 5.72027250644762e-5*std::sin(0.374959826469421*x_96 - 7.40423965454102) + 0.000415077368863743*std::sin(0.391199827194214*x_96 + 5.18480014801025) - 0.00121480937267795*std::sin(0.33927983045578*x_97 - 4.25487995147705) + 0.0189788702894885*std::sin(0.408799856901169*x_97 - 4.18495988845825) - 4.07589992595541e-5*std::sin(0.529279828071594*x_97 - 4.23943996429443) + 0.000373772062422765*std::sin(0.283199936151505*x_98 + 5.1069598197937) + 2.69559848984082e-5*std::sin(0.345519840717316*x_98 - 4.25439977645874) + 2.40803322223286e-5*std::sin(0.360719859600067*x_98 - 4.22751998901367) - 0.000265273363000142*std::sin(0.361119836568832*x_98 + 5.15664005279541) + 7.56613914709446e-6*std::sin(0.382719844579697*x_98 + 5.17623996734619) - 0.0156793049028362*std::sin(0.386799842119217*x_98 - 7.39551973342896) - 8.16163539248563e-6*std::sin(0.391679853200912*x_99 - 7.39479970932007) - 0.000420378574920013*std::sin(0.398319840431213*x_99 - 4.20351982116699) + 1.60714362946895e-5*std::sin(0.476239860057831*x_99 - 1.14175987243652) - 1.9828566942947);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-7.47655518336512e-5*x_1 - 0.000122976131731129*x_10 + 0.000107670293904939*x_100 - 0.00114326594875176*x_101 + 6.91486555925451e-5*x_102 + 0.000350753662157303*x_103 + 0.000172773721147965*x_104 + 9.79513754415966e-5*x_105 + 2.7104107257969e-5*x_106 + 0.000736937880821715*x_107 + 0.0039970756780177*x_108 - 0.00128305672065972*x_109 - 3.54396664055269e-5*x_11 - 0.000132421112331695*x_110 - 0.000767221867515123*x_111 - 0.0014549845445591*x_112 + 0.00027402636689383*x_113 - 0.00109758386282145*x_114 + 3.03508862636324e-5*x_115 - 0.000421671372779654*x_116 - 0.000476161934206347*x_117 + 0.000819434078461933*x_118 + 9.72595834790481e-5*x_119 + 0.000219594707494761*x_12 - 4.69499044670244e-5*x_120 - 0.00643676319072385*x_13 + 2.63159031014518e-5*x_14 + 8.70510893626161e-6*x_15 - 2.98709884476769e-5*x_16 + 6.35165424181309e-5*x_17 - 0.00185156132275468*x_18 - 0.00154135246994432*x_19 + 0.026026891349688*x_2 - 9.6057900767412e-5*x_20 - 0.002247349949051*x_21 + 0.000162316638709774*x_22 - 0.00268031668840643*x_23 - 0.00014217518549405*x_24 + 7.32740964361605e-6*x_25 + 0.000162690707406886*x_26 - 4.1728773291223e-6*x_27 - 0.0010717156002402*x_28 + 0.000637568729416182*x_29 - 4.48455709541603e-5*x_3 + 3.21730806561947e-6*x_30 - 0.00792665142731847*x_31 + 0.000980680564244334*x_32 + 0.000648031833407744*x_33 - 0.00429625466339874*x_34 - 0.00052767053876743*x_35 - 0.000864246885772057*x_36 + 1.20503736777661e-5*x_37 + 0.00159361403416804*x_38 - 0.000773596867161664*x_39 + 0.00163819957980501*x_4 + 0.00112170242667781*x_40 - 0.000451271454452503*x_41 + 0.000483520908382542*x_42 + 0.00183492759048501*x_43 - 0.000885765583930639*x_44 - 0.00139981337271731*x_45 - 4.42159232683546e-5*x_46 - 4.70554905407159e-6*x_47 - 0.000112260694140396*x_48 + 0.000893699507312159*x_49 + 0.00054652731992226*x_5 + 0.00019084531723752*x_50 + 0.00118785736013459*x_51 - 0.00136139994432416*x_52 - 0.000263840224397091*x_53 - 0.000804557132023239*x_54 + 0.000570967469420317*x_55 - 0.000238853826285003*x_56 - 0.000115160647756508*x_57 - 0.00106788651846819*x_58 - 0.000133550330671797*x_59 - 1.14600256143521e-6*x_6 - 0.00199024376737912*x_60 - 0.0013726052458861*x_61 - 0.00311634801802561*x_62 - 0.00133348487242141*x_63 - 9.52079217368053e-6*x_64 + 0.000156711145712385*x_65 - 0.000942900237566796*x_66 + 4.11392727660302e-5*x_67 + 0.00331750208504616*x_68 - 0.000140149593409012*x_69 + 0.000332653575728351*x_7 + 7.79399244780664e-5*x_70 - 8.5013393949689e-5*x_71 - 0.000645351118249328*x_72 + 0.000958194280901225*x_73 - 7.30559165738983e-5*x_74 - 4.89416043881387e-5*x_75 - 0.00388324543641312*x_76 - 0.00169835849908762*x_77 - 0.00297885619922909*x_78 + 0.00137833923767407*x_79 + 0.000368842915903533*x_8 - 4.24176201527998e-5*x_80 - 0.00125353214121989*x_81 - 0.000167888219632638*x_82 + 0.00311452505689025*x_83 - 2.85658037402745e-5*x_84 + 0.000762763555631928*x_85 + 9.56013387057183e-5*x_86 - 0.000538311320565665*x_87 - 0.00170903130998972*x_88 - 0.000430985761255506*x_89 + 0.000492933422171055*x_9 + 0.00106416250266744*x_90 - 0.00857624387061953*x_91 - 0.000440032831688595*x_92 - 6.97981820834021e-5*x_93 + 5.54537014865788e-6*x_94 - 0.000857660717324558*x_95 - 1.00334098638605e-5*x_96 - 0.0066975583865928*x_97 - 0.000586933205576247*x_98 + 0.000495585326446678*x_99 - 5.89887977532611e-6*std::pow(-5.50903987884521*x_13 - 8.56120014190674, 2) - 3.51726877727145e-8*std::pow(-5.40360021591187*x_14 - 8.1974401473999, 2) - 0.000129454347853354*std::pow(-5.1081600189209*x_14 - 7.96799993515015, 2) - 7.20717773078037e-6*std::pow(-4.90744018554688*x_14 - 7.37560033798218, 2) + 1.37160720144646e-6*std::pow(-5.78351974487305*x_15 - 7.58104038238525, 2) - 0.000542641892805654*std::pow(-5.33127975463867*x_15 - 7.50687980651855, 2) + 4.34488502562314e-5*std::pow(-5.31104040145874*x_15 - 7.75784015655518, 2) + 1.23292436369278e-5*std::pow(-3.07200002670288*x_15 - 4.79999971389771, 2) + 3.10463550594792e-6*std::pow(-5.25880002975464*x_17 - 7.69080018997192, 2) - 0.000466043240229513*std::pow(-4.46319961547852*x_17 - 6.49072027206421, 2) - 1.03070469061145e-6*std::pow(-2.07751989364624*x_17 - 2.91079998016357, 2) + 1.36119249733215e-6*std::pow(-6.5796799659729*x_18 - 9.78975963592529, 2) + 3.72924391624853e-7*std::pow(-6.57512044906616*x_18 - 9.37152004241943, 2) - 3.66965792019014e-6*std::pow(-5.29320001602173*x_18 - 8.33983993530273, 2) + 3.68989872644811e-7*std::pow(-4.91903972625732*x_18 - 9.68000030517578, 2) - 3.83763898844264e-6*std::pow(-3.24055981636047*x_2 - 5.87591981887817, 2) - 1.35951357321637e-6*std::pow(-3.23535990715027*x_2 - 5.85767984390259, 2) + 1.37338601655235e-6*std::pow(-5.72215986251831*x_22 - 9.58920001983643, 2) + 7.29572344701795e-7*std::pow(-5.64527988433838*x_22 - 9.06455993652344, 2) - 3.02066094599272e-7*std::pow(-4.69063997268677*x_22 - 7.54383945465088, 2) - 0.000784955378719664*std::pow(-3.50623989105225*x_22 - 5.77040004730225, 2) + 4.42259011697105e-6*std::pow(-1.23087990283966*x_23 - 1.85415983200073, 2) + 2.80188070792573e-7*std::pow(-6.78079986572266*x_27 - 9.1778392791748, 2) + 1.32943426771743e-7*std::pow(-6.60400009155273*x_27 - 9.9750394821167, 2) + 4.40084535704568e-6*std::pow(-5.82399988174438*x_4 - 9.65783977508545, 2) + 5.24568822913239e-5*std::pow(-3.396399974823*x_4 - 5.59624004364014, 2) - 8.98586936875871e-8*std::pow(-6.40000009536743*x_5 - 9.99995994567871, 2) + 3.9650730515574e-7*std::pow(-6.19999980926514*x_5 - 9.99948024749756, 2) + 4.51447195919272e-7*std::pow(-5.87680006027222*x_5 - 9.11728000640869, 2) - 4.17415245941673e-6*std::pow(-4.81839990615845*x_5 - 7.81911993026733, 2) - 5.93008273579062e-6*std::pow(-3.91319990158081*x_5 - 6.38520002365112, 2) + 8.27877897415494e-5*std::pow(-1.71423983573914*x_5 - 2.66727995872498, 2) - 7.88692227514951e-6*std::pow(-5.514479637146*x_6 - 8.792799949646, 2) - 0.000490680774350502*std::pow(-3.50671982765198*x_6 - 5.57079982757568, 2) - 3.3709938383047e-7*std::pow(-5.12335968017578*x_66 - 7.99567985534668, 2) + 4.13439048302384e-8*std::pow(-5.26424026489258*x_67 - 8.09687995910645, 2) - 5.45602420216624e-7*std::pow(-4.71519947052002*x_67 - 8.39935970306396, 2) + 3.75123338439199e-7*std::pow(-6.60000038146973*x_68 - 9.96571922302246, 2) - 6.4754931680814e-6*std::pow(-5.98231983184814*x_7 - 9.59111976623535, 2) - 6.65337670693225e-8*std::pow(-5.28568029403687*x_7 - 8.53200054168701, 2) - 0.000256089877918268*std::pow(-5.20592021942139*x_7 - 8.61111927032471, 2) + 3.0378111235057e-7*std::pow(-4.92143964767456*x_7 - 8.06775951385498, 2) - 7.33374254596569e-6*std::pow(-4.83440017700195*x_7 - 7.85383987426758, 2) - 3.27846657578064e-6*std::pow(-4.3101601600647*x_71 - 6.57128000259399, 2) - 1.4093200415705e-7*std::pow(-4.37599992752075*x_72 - 6.1669602394104, 2) - 9.76609103722343e-7*std::pow(-3.8711199760437*x_72 - 5.22455978393555, 2) - 1.57501320188203e-6*std::pow(-6.0*x_77 - 9.99911975860596, 2) + 4.64468846100691e-7*std::pow(-7.76000022888184*x_80 - 9.79903984069824, 2) + 1.21670769934348e-6*std::pow(-4.18959999084473*x_80 - 6.58544015884399, 2) - 5.86800499469109e-9*std::pow(-9.97459983825684*x_81 - 6.60400009155273, 2) + 2.03948000829023e-7*std::pow(-7.59576034545898*x_81 - 8.78192043304443, 2) - 6.0543500612485e-7*std::pow(-5.0*x_81 - 9.99964046478271, 2) - 1.22087882720004e-6*std::pow(-7.46039962768555*x_82 - 9.46856021881104, 2) - 1.41395592607658e-7*std::pow(-5.52776002883911*x_85 - 7.56920003890991, 2) + 8.16172724958375e-7*std::pow(-5.29983949661255*x_85 - 7.26336002349854, 2) - 4.79806082584957e-8*std::pow(-4.47440004348755*x_85 - 8.12800025939941, 2) + 3.66070895095382e-7*std::pow(-6.60000038146973*x_88 - 9.99792003631592, 2) - 1.01075503622019e-6*std::pow(-6.29087972640991*x_88 - 8.66224002838135, 2) - 1.73314232296011e-6*std::pow(-5.65199995040894*x_88 - 7.40236043930054, 2) + 9.92952360551837e-7*std::pow(-6.20728015899658*x_90 - 8.81319999694824, 2) + 1.25192365936235e-6*std::exp(0.868719875812531*x_27) - 4.50601723096506e-5*std::exp(0.473039865493774*x_71) + 7.27284312106433e-5*std::exp(0.530879855155945*x_71) - 0.0482857581561039*std::sin(0.228959992527962*x_1 + 5.01823997497559) - 0.0110636134165365*std::sin(0.236639991402626*x_1 + 1.97687971591949) - 0.000166582946612228*std::sin(0.276399940252304*x_1 - 1.18871986865997) - 0.00308264288289462*std::sin(0.285039931535721*x_1 + 1.9968798160553) + 0.00317075781773793*std::sin(0.297599911689758*x_1 + 1.98135983943939) + 0.00781518599212605*std::sin(0.302639931440353*x_1 - 7.43455982208252) + 0.0138321204541041*std::sin(0.311999946832657*x_1 - 7.43711996078491) - 0.000636846222962263*std::sin(0.218239992856979*x_10 - 4.37031984329224) - 0.00026481726739034*std::sin(0.269119948148727*x_10 - 4.30751943588257) - 0.0110209563127733*std::sin(0.285759955644608*x_10 + 5.09208011627197) - 0.00868548202041789*std::sin(0.294239938259125*x_10 + 5.10759973526001) - 0.00054840863118623*std::sin(0.323919832706451*x_10 - 4.27239990234375) + 0.00396192345855507*std::sin(0.368399828672409*x_101 + 8.18271923065186) + 0.00247219710898109*std::sin(0.282879948616028*x_102 - 4.32231998443604) + 0.000561408190159562*std::sin(0.383199840784073*x_102 + 5.18440008163452) - 0.00038400676607291*std::sin(0.385439842939377*x_102 + 1.96247982978821) - 0.000304319859374215*std::sin(0.306239932775497*x_103 - 4.27127981185913) - 0.000247699683329475*std::sin(0.361359834671021*x_103 + 1.97855985164642) + 0.000312777297824587*std::sin(0.365279853343964*x_103 - 7.4171199798584) - 0.00157958545006411*std::sin(0.321119844913483*x_105 - 4.27928018569946) + 3.35694835097989e-5*std::sin(0.393999844789505*x_105 - 4.1908802986145) - 4.42492793275587e-5*std::sin(0.241679981350899*x_106 + 5.03127956390381) + 0.00108177433499058*std::sin(0.263999968767166*x_106 + 5.06047964096069) - 4.36091801186765e-5*std::sin(0.353919863700867*x_106 - 7.43991994857788) - 0.0010636535272686*std::sin(0.373599827289581*x_106 - 7.40431976318359) - 6.41600809394913e-5*std::sin(0.374559849500656*x_106 - 7.4235200881958) - 0.000138000845865869*std::sin(0.388399839401245*x_106 - 7.39368009567261) - 0.0008196219294006*std::sin(0.485679864883423*x_106 + 5.2596001625061) - 0.00518649985463158*std::sin(0.539679825305939*x_106 - 7.21880006790161) - 0.0015706476170638*std::sin(0.337519854307175*x_107 - 7.45607995986938) - 0.000225102145540252*std::sin(0.345039844512939*x_107 - 4.25472021102905) - 0.00209916117972883*std::sin(0.499759823083878*x_108 + 5.28000020980835) + 0.000484958471109604*std::sin(0.333519846200943*x_109 - 7.4410400390625) + 0.00102672268066886*std::sin(0.40311986207962*x_109 + 1.98511981964111) - 0.000151435865606765*std::sin(0.471919864416122*x_109 + 2.02095985412598) + 0.129808683265465*std::sin(0.269839972257614*x_11 + 8.28728008270264) + 0.000126190448087726*std::sin(0.289919942617416*x_11 + 8.31727981567383) - 0.000870356213870168*std::sin(0.294399946928024*x_11 + 8.31807994842529) + 0.00046819254329943*std::sin(0.41567987203598*x_110 + 5.20975971221924) + 0.000581147652921327*std::sin(0.308079928159714*x_111 + 5.13520002365112) - 6.46930243602223e-5*std::sin(0.447919845581055*x_111 + 5.0274395942688) - 2.57924267554357e-5*std::sin(0.55351984500885*x_111 - 7.41264009475708) + 0.000235826882582485*std::sin(0.241919979453087*x_112 - 1.15607988834381) - 0.00253447522766973*std::sin(0.357759833335876*x_112 + 5.15887975692749) - 3.21282148800061e-5*std::sin(0.437519878149033*x_112 + 8.21895980834961) + 0.000213874214584558*std::sin(0.437919855117798*x_113 - 1.18151986598969) - 0.000679838268596739*std::sin(0.347919851541519*x_114 + 8.33896064758301) + 0.00127549952024799*std::sin(0.362399846315384*x_114 - 7.42384004592896) - 0.000484802189254841*std::sin(0.386159837245941*x_114 - 7.42127990722656) - 0.000757331320529399*std::sin(0.481919854879379*x_114 - 1.14231991767883) - 1.004536340178e-5*std::sin(0.294959932565689*x_115 + 8.33543968200684) - 0.000382582972514205*std::sin(0.337519854307175*x_115 + 5.14039993286133) - 0.000156466688623636*std::sin(0.396719843149185*x_115 - 7.40727996826172) - 0.00143394901290964*std::sin(0.404239863157272*x_115 + 5.19208002090454) - 0.00413991638633907*std::sin(0.521999835968018*x_115 + 8.35608005523682) + 8.45435151464327e-5*std::sin(0.53415983915329*x_115 - 4.23967981338501) + 7.70628156532002e-5*std::sin(0.638719856739044*x_115 - 4.17447996139526) - 2.15566171066664e-5*std::sin(0.257519960403442*x_117 - 4.34143972396851) - 0.0003187538977189*std::sin(0.393999844789505*x_117 + 5.18584012985229) + 2.24782446846192e-5*std::sin(0.438319861888885*x_117 - 4.16440010070801) - 0.000160820424978323*std::sin(0.476639837026596*x_117 + 5.24015998840332) - 0.000771518589179252*std::sin(0.370799839496613*x_118 - 7.40967988967896) - 0.000494542455008563*std::sin(0.390239834785461*x_118 + 5.17920017242432) - 3.78599544246578e-5*std::sin(0.392959833145142*x_118 - 7.40463972091675) + 0.00210653547897939*std::sin(0.393359839916229*x_118 + 5.19456005096436) - 5.22733438317527e-5*std::sin(0.42647984623909*x_118 - 1.16159987449646) + 0.000500239002659862*std::sin(0.328399837017059*x_119 - 4.2469596862793) - 0.000296397968795551*std::sin(0.335759848356247*x_119 - 7.44079971313477) - 0.00218771116432802*std::sin(0.343999862670898*x_119 - 7.43631982803345) - 2.52863094991061e-5*std::sin(0.415999859571457*x_119 - 1.17535984516144) - 0.000351086190677922*std::sin(0.421519845724106*x_119 + 1.98623979091644) + 0.00441881397328234*std::sin(0.433919847011566*x_119 - 1.15335988998413) - 0.283602901723569*std::sin(0.341599822044373*x_12 - 4.25816011428833) + 0.000298022513886092*std::sin(0.392639845609665*x_12 + 5.19840002059937) - 0.000798986341267221*std::sin(0.300879925489426*x_120 + 1.90599989891052) - 0.000382032950281876*std::sin(0.331999838352203*x_120 - 1.06463980674744) - 0.000541046768264175*std::sin(0.460639864206314*x_120 + 2.05159974098206) - 0.000657776464074231*std::sin(0.203759998083115*x_13 + 8.19944000244141) - 0.0833870529187195*std::sin(0.117440059781075*x_14 - 4.53320026397705) - 0.0104564465981578*std::sin(0.12216005474329*x_14 - 4.52631998062134) - 0.000147931149838785*std::sin(0.250799983739853*x_14 - 4.31239986419678) - 0.00329669083990401*std::sin(0.142320036888123*x_15 - 4.48423957824707) + 0.0974619328523255*std::sin(0.333919852972031*x_16 - 4.24720001220703) - 0.00530705483293287*std::sin(0.359999865293503*x_16 + 5.17304039001465) - 0.00568539935833317*std::sin(0.363919854164124*x_16 - 4.24200010299683) + 2.67215860892029e-5*std::sin(0.388799846172333*x_16 - 1.18391978740692) + 0.000228761856338587*std::sin(0.401599854230881*x_16 + 5.20815992355347) + 0.00190946887099873*std::sin(0.331119894981384*x_17 - 4.21216011047363) - 1.94258895789627e-5*std::sin(1.23015987873077*x_17 + 5.81080007553101) + 8.29836111165129e-5*std::sin(0.222159996628761*x_18 - 4.37863969802856) + 0.000696076655048617*std::sin(0.269999951124191*x_18 + 8.30519962310791) - 0.0204008194794922*std::sin(0.159040033817291*x_19 - 4.45383977890015) - 0.00103111352499722*std::sin(0.326479852199554*x_21 - 4.25343990325928) + 0.000789696921227243*std::sin(0.335279852151871*x_21 + 5.160560131073) - 0.000294997633276749*std::sin(0.33679986000061*x_21 + 8.35943984985352) + 0.00484689373523671*std::sin(0.153520032763481*x_23 - 7.64976024627686) + 0.000862906547224119*std::sin(0.191040009260178*x_23 + 4.99199962615967) + 0.00609036007129222*std::sin(0.205360010266304*x_23 + 5.00831985473633) + 0.0100040303384336*std::sin(0.245599970221519*x_23 + 5.0688796043396) + 0.000130349666675059*std::sin(0.414879858493805*x_23 + 5.20208024978638) + 0.00260812099105621*std::sin(0.276959955692291*x_24 + 5.09240007400513) - 0.00152428898908028*std::sin(0.326639831066132*x_24 - 4.2720799446106) + 0.0017375027832757*std::sin(0.358239859342575*x_24 + 8.34879970550537) - 0.00624466304784189*std::sin(0.311839938163757*x_26 - 4.27183961868286) + 0.00196356934894915*std::sin(0.312079936265945*x_26 - 4.2720799446106) - 0.0918274788409576*std::sin(0.346559852361679*x_26 - 4.25408029556274) + 0.0038092343372356*std::sin(0.181520000100136*x_27 - 7.61520004272461) - 0.225621363596122*std::sin(0.222159996628761*x_27 + 5.0272798538208) + 0.00645040016602186*std::sin(0.22919999063015*x_27 - 7.55919981002808) + 0.00426877815081407*std::sin(0.250079959630966*x_27 - 7.52135992050171) - 0.000177561970793051*std::sin(0.293599933385849*x_27 + 8.32111930847168) - 0.0105240935368205*std::sin(0.301199913024902*x_27 + 5.11639976501465) - 0.000798209380881398*std::sin(0.225199982523918*x_28 - 4.36520004272461) + 0.000165760336267478*std::sin(0.279359966516495*x_28 + 5.0991997718811) - 0.00101284887891624*std::sin(0.29911994934082*x_28 - 4.28567981719971) + 0.00394768765601578*std::sin(0.327599853277206*x_28 - 4.27360010147095) + 8.06886059670933e-5*std::sin(0.475359857082367*x_28 + 5.25095987319946) - 0.000937709284784635*std::sin(0.285999953746796*x_3 + 8.2903995513916) + 0.000580494300651613*std::sin(0.293039947748184*x_3 + 8.30327987670898) - 0.0014867166604928*std::sin(0.300399929285049*x_3 - 4.27288007736206) - 0.00040535442858837*std::sin(0.316799849271774*x_3 + 8.31775951385498) - 0.307934404762455*std::sin(0.321359843015671*x_3 + 8.31960010528564) - 0.0233275954303525*std::sin(0.321439832448959*x_3 + 8.32264041900635) - 0.000230135285872266*std::sin(0.368239849805832*x_3 - 1.03407979011536) + 0.0532572088797279*std::sin(0.274559944868088*x_30 + 8.28799915313721) - 0.00124131234845252*std::sin(0.275599956512451*x_30 + 8.26799964904785) - 0.000117005598860396*std::sin(0.170720010995865*x_31 + 8.43936061859131) + 0.00514437895607216*std::sin(0.270079970359802*x_32 - 7.44039964675903) + 6.31631269356318e-5*std::sin(0.273199945688248*x_32 + 1.97919988632202) - 0.000498094283501392*std::sin(0.337679862976074*x_34 + 5.20703983306885) - 7.34059764020615e-5*std::sin(0.379599839448929*x_34 + 1.97711980342865) + 0.000464135448412815*std::sin(0.303839921951294*x_35 - 1.11191987991333) + 0.00204752962901122*std::sin(0.340079843997955*x_35 - 1.19399988651276) + 3.60790192216537e-5*std::sin(0.322799831628799*x_36 - 4.26735973358154) + 3.07803779149865e-5*std::sin(0.338079839944839*x_36 - 7.43224000930786) + 0.0022062028398324*std::sin(0.350559860467911*x_36 + 8.34632015228271) - 0.000406477995098051*std::sin(0.357679843902588*x_36 - 4.24528026580811) - 0.00110858560739614*std::sin(0.364799857139587*x_36 - 4.22959995269775) - 0.000220925867665733*std::sin(0.411119878292084*x_36 + 5.20232009887695) - 0.000511294327108841*std::sin(0.2360799908638*x_37 - 4.35727977752686) - 0.0475446323804914*std::sin(0.362399846315384*x_37 + 5.16695976257324) + 3.52628582192548e-5*std::sin(0.388159841299057*x_37 - 4.19992017745972) - 0.000467441671975105*std::sin(0.433199852705002*x_38 + 5.23192024230957) + 0.000188196614149888*std::sin(0.451359868049622*x_38 + 8.44312000274658) - 1.85197446296143e-5*std::sin(0.345439851284027*x_39 + 1.95567977428436) - 0.000310507773925136*std::sin(0.308479934930801*x_41 - 4.28967952728271) + 0.000290270092424064*std::sin(0.319679856300354*x_42 - 4.26688003540039) + 0.000367413700249007*std::sin(0.369279831647873*x_43 + 5.17000007629395) + 8.71932342910658e-6*std::sin(0.404799848794937*x_43 + 5.19200038909912) + 2.29844544631253e-5*std::sin(0.420399844646454*x_43 + 5.20608043670654) + 7.10787678104156e-5*std::sin(0.331839829683304*x_45 - 4.27144002914429) + 0.000621780773444284*std::sin(0.352159857749939*x_45 + 5.16239976882935) + 0.00085213750664213*std::sin(0.355999857187271*x_45 - 7.44447994232178) + 0.000988970926284618*std::sin(0.363999843597412*x_45 - 4.23320007324219) - 6.42888925541143e-5*std::sin(0.365999847650528*x_45 - 4.23720026016235) - 2.26384338785367e-5*std::sin(0.288639932870865*x_46 + 5.12536001205444) - 0.0127992146720861*std::sin(0.30927985906601*x_46 - 7.48751974105835) - 0.000535404213122599*std::sin(0.32847985625267*x_46 - 7.45831966400146) - 0.00101630977709375*std::sin(0.334399849176407*x_46 - 4.27008008956909) - 0.000773742870068414*std::sin(0.337759852409363*x_46 + 5.14007997512817) + 1.94761459195128e-5*std::sin(0.416399866342545*x_46 - 7.3724799156189) - 4.35351444225638e-5*std::sin(0.454959839582443*x_46 + 5.23360013961792) - 0.0012758404761207*std::sin(0.211119994521141*x_47 + 8.22288036346436) + 0.000222365259050098*std::sin(0.451359868049622*x_47 + 2.03895974159241) - 0.000168415276692618*std::sin(0.502319812774658*x_47 - 4.3219199180603) - 0.00600467557116882*std::sin(0.536159813404083*x_47 - 4.23135995864868) + 0.000773524621739675*std::sin(0.416239857673645*x_48 + 5.21384000778198) - 0.0191253809864809*std::sin(0.500239849090576*x_48 + 2.05039978027344) - 0.00041228342418267*std::sin(0.591679811477661*x_48 + 5.18351984024048) + 0.000491670312343399*std::sin(0.348399847745895*x_49 + 5.13439989089966) - 0.000286072739087347*std::sin(0.411999881267548*x_49 + 2.01895976066589) - 0.00177026092198922*std::sin(0.180480018258095*x_50 - 4.43503999710083) - 0.000170689319833065*std::sin(0.459599852561951*x_50 - 7.339439868927) + 0.000548364015344391*std::sin(0.282959938049316*x_51 + 5.10951995849609) - 0.000439778297993197*std::sin(0.322239845991135*x_51 + 5.13632011413574) - 0.000797863704855636*std::sin(0.339839845895767*x_53 + 5.13575983047485) - 1.08774331264931e-5*std::sin(0.435999870300293*x_53 + 8.42735958099365) - 0.00204903736205364*std::sin(0.193519994616508*x_54 - 4.41111993789673) + 3.20559174531642e-5*std::sin(0.465039849281311*x_54 + 8.46759986877441) - 4.29333189019524e-5*std::sin(0.210319995880127*x_55 - 4.39687967300415) + 0.000400135828680279*std::sin(0.265359967947006*x_55 - 4.29959964752197) + 2.43369141325351e-5*std::sin(0.346879839897156*x_55 - 4.23952007293701) + 0.00125922551972064*std::sin(0.349599838256836*x_55 + 1.96415984630585) - 0.000216369358296124*std::sin(0.421679854393005*x_55 + 5.23280000686646) + 0.0252412864745292*std::sin(0.289999932050705*x_56 - 4.28191947937012) + 6.57265723767891e-5*std::sin(0.282079964876175*x_57 - 4.2885594367981) + 0.000998977670922226*std::sin(0.197759985923767*x_58 + 4.99087953567505) - 0.000587935654639432*std::sin(0.366159826517105*x_58 + 5.17632007598877) + 0.00102391413980922*std::sin(0.38239985704422*x_58 + 5.19072008132935) + 0.000428798166061461*std::sin(0.435119867324829*x_58 + 5.24216032028198) + 1.89359396396473e-5*std::sin(0.467359870672226*x_58 + 2.0590398311615) - 0.0524071134446375*std::sin(0.329519838094711*x_59 - 4.26416015625) + 0.000330760266234313*std::sin(0.331599831581116*x_59 - 7.44951963424683) + 5.7446577332097e-5*std::sin(0.350239843130112*x_59 + 5.14416027069092) - 0.000269399578247298*std::sin(0.366159826517105*x_59 + 5.15992021560669) + 0.00110458489249091*std::sin(0.384639829397202*x_59 + 5.174880027771) + 7.90042928643774e-6*std::sin(0.41007986664772*x_59 - 4.20344018936157) + 3.56957638726627e-5*std::sin(0.562719821929932*x_59 - 4.22799968719482) - 0.000474214440835741*std::sin(0.319439828395844*x_60 - 4.28592014312744) + 0.000597819617693433*std::sin(0.355039834976196*x_60 + 5.15856027603149) + 0.0040359464857271*std::sin(0.236559987068176*x_64 + 5.06039953231812) - 0.000397566958339521*std::sin(0.264559954404831*x_64 + 5.08464002609253) - 4.77333786752862e-5*std::sin(0.280799955129623*x_65 + 8.31047916412354) - 1.31903980577013e-5*std::sin(0.343039840459824*x_65 + 5.14752006530762) + 2.43396594801705e-5*std::sin(0.302559942007065*x_66 - 7.21759986877441) - 0.000450431638010755*std::sin(0.358399838209152*x_66 + 8.3439998626709) + 0.000575941269216746*std::sin(0.378879845142365*x_66 + 5.16160011291504) + 0.0555789330725096*std::sin(0.237599983811378*x_67 + 5.032639503479) + 0.00418492524644283*std::sin(0.274799972772598*x_67 + 5.09183979034424) + 0.000122587770098033*std::sin(0.333919852972031*x_67 - 4.28336000442505) - 0.00011220058497751*std::sin(0.341039836406708*x_67 + 5.12520027160645) - 3.45842763195151e-5*std::sin(0.367839843034744*x_67 - 7.41863965988159) - 0.00130659064317755*std::sin(0.325999826192856*x_68 - 4.26984024047852) + 0.00326431096261878*std::sin(0.193519994616508*x_69 + 4.98655986785889) - 0.00139613633651585*std::sin(0.258639961481094*x_69 + 5.07599973678589) + 0.000183800348446872*std::sin(0.356879830360413*x_69 + 8.36288070678711) - 0.038949124622045*std::sin(0.20728000998497*x_70 + 5.01175975799561) - 0.00164289608364849*std::sin(0.313279926776886*x_70 + 1.92271995544434) + 0.00367450108210728*std::sin(0.537359833717346*x_71 + 5.15304040908813) - 0.000743697966143933*std::sin(0.239039987325668*x_73 + 5.04247999191284) + 0.000651561628292571*std::sin(0.165840014815331*x_74 - 1.26447987556458) + 0.0172839705103615*std::sin(0.365199834108353*x_74 - 4.24535989761353) - 0.0412432900471717*std::sin(0.321599841117859*x_75 + 5.1287202835083) - 0.00021297896831765*std::sin(0.352319836616516*x_75 - 4.25432014465332) - 0.000167697495315395*std::sin(0.178240016102791*x_76 + 4.96903991699219) - 6.77314043454232e-5*std::sin(0.264239966869354*x_77 - 7.53952026367188) - 0.00742785524406511*std::sin(0.234319984912872*x_78 + 5.03319978713989) - 0.00116788943354321*std::sin(0.194319993257523*x_79 + 8.17903900146484) - 4.81061339594619e-5*std::sin(0.211119994521141*x_79 - 7.58400011062622) + 0.000147909686062886*std::sin(0.266399949789047*x_79 + 1.87991988658905) + 0.00129067635629717*std::sin(0.289679944515228*x_79 - 4.26887989044189) + 0.00054394533990731*std::sin(0.316639840602875*x_79 - 4.29895973205566) - 6.73713055782937e-5*std::sin(0.317599833011627*x_79 - 7.47359991073608) - 3.63994569771585e-5*std::sin(0.32711985707283*x_79 + 8.31087970733643) - 0.000329127350716628*std::sin(0.376959830522537*x_79 - 4.22320032119751) + 0.000533955787862815*std::sin(0.204960003495216*x_8 + 8.20911979675293) - 0.00238730894744645*std::sin(0.2291199862957*x_8 + 8.25759983062744) - 0.000745831354337339*std::sin(0.305919945240021*x_8 + 5.13575983047485) - 1.67350518455204e-5*std::sin(0.467999875545502*x_80 - 4.13312005996704) + 0.00042526840095062*std::sin(0.496479868888855*x_80 - 4.09999990463257) + 0.000262269618854325*std::sin(1.71655988693237*x_80 - 1.58871984481812) - 0.000835924917399635*std::sin(0.180960014462471*x_84 - 4.41928005218506) + 0.000110919347677842*std::sin(0.225439995527267*x_84 + 8.22103977203369) + 0.00980001960167327*std::sin(0.464079856872559*x_84 - 1.13943982124329) - 5.23544946164422e-5*std::sin(1.40207982063293*x_84 - 4.79184007644653) - 2.35004999757687e-5*std::sin(1.99599981307983*x_84 - 4.20552015304565) - 0.00436221578093699*std::sin(0.148400038480759*x_85 - 7.67167997360229) + 0.000646195523009561*std::sin(0.292079925537109*x_85 + 5.12319993972778) - 0.00107951241302474*std::sin(0.257279992103577*x_86 + 1.86807990074158) + 0.0076127071861373*std::sin(0.549119889736176*x_86 + 8.37264060974121) + 0.00141309848471725*std::sin(0.162640020251274*x_87 + 4.94559955596924) + 0.00234959224624564*std::sin(0.174160018563271*x_87 - 7.61856031417847) - 0.000730565443189741*std::sin(0.217519983649254*x_87 + 5.00527954101563) - 0.00085261617449893*std::sin(0.190400004386902*x_89 + 4.97095966339111) + 0.00038884780516666*std::sin(0.306719928979874*x_89 + 5.14775991439819) - 0.00139174703661285*std::sin(0.214959993958473*x_9 + 5.03159952163696) + 0.0019467548823922*std::sin(0.215039998292923*x_9 - 4.37368011474609) + 0.00141471967001665*std::sin(0.22511999309063*x_9 - 4.36303997039795) - 0.0156209026681429*std::sin(0.240799978375435*x_9 - 4.34663963317871) - 7.06460811959204e-5*std::sin(0.273439943790436*x_9 - 4.31191968917847) + 0.000307620836008941*std::sin(0.186160013079643*x_91 - 7.37151956558228) + 9.62901785268586e-5*std::sin(0.189440011978149*x_91 + 2.01639986038208) - 0.00202089296731681*std::sin(0.20040000975132*x_91 + 2.00647974014282) + 0.00103016715002411*std::sin(0.34759983420372*x_92 + 5.18064022064209) - 0.00060040571075279*std::sin(0.351359844207764*x_92 - 7.38607978820801) + 0.00102115034288651*std::sin(0.361999839544296*x_92 + 2.00455975532532) - 0.0029255684084343*std::sin(0.365679860115051*x_92 + 1.99591982364655) - 0.00879102488240158*std::sin(0.366239845752716*x_92 + 1.99783980846405) - 1.64745999259073e-5*std::sin(0.399119853973389*x_92 - 4.40703964233398) + 0.0194720745016173*std::sin(0.404639840126038*x_92 + 2.00263977050781) + 0.000198787190660714*std::sin(0.296879917383194*x_94 - 1.11263990402222) - 0.000869798174961557*std::sin(0.375759840011597*x_94 + 5.18688011169434) + 0.020763296145824*std::sin(0.386319845914841*x_94 + 1.98831987380981) + 0.000455333645846574*std::sin(0.412479877471924*x_94 + 5.20128011703491) - 0.000367737394112862*std::sin(0.358399868011475*x_95 - 4.21600008010864) + 2.40786893384458e-5*std::sin(0.374239832162857*x_95 + 1.98471975326538) + 0.000249886159024496*std::sin(0.386959850788116*x_95 - 7.40423965454102) - 8.26128358289049e-5*std::sin(0.472799867391586*x_95 + 2.02503991127014) - 0.00096265878409516*std::sin(0.369519859552383*x_96 - 7.43304014205933) - 0.000394479743525271*std::sin(0.374959826469421*x_96 - 7.40423965454102) - 0.0201554991941718*std::sin(0.391199827194214*x_96 + 5.18480014801025) - 0.000451752492984147*std::sin(0.33927983045578*x_97 - 4.25487995147705) - 0.00108772075453322*std::sin(0.408799856901169*x_97 - 4.18495988845825) - 0.000281081007174616*std::sin(0.529279828071594*x_97 - 4.23943996429443) - 3.43368840878282e-5*std::sin(0.283199936151505*x_98 + 5.1069598197937) + 0.000185893067108419*std::sin(0.345519840717316*x_98 - 4.25439977645874) - 0.000367631024579742*std::sin(0.360719859600067*x_98 - 4.22751998901367) + 0.000589427461684105*std::sin(0.361119836568832*x_98 + 5.15664005279541) - 2.47677679855822e-5*std::sin(0.382719844579697*x_98 + 5.17623996734619) + 0.000898615412789621*std::sin(0.386799842119217*x_98 - 7.39551973342896) + 2.67171258490042e-5*std::sin(0.391679853200912*x_99 - 7.39479970932007) + 3.86184304585835e-5*std::sin(0.398319840431213*x_99 - 4.20351982116699) + 0.000110831364423038*std::sin(0.476239860057831*x_99 - 1.14175987243652) + 0.439938535667325);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
