
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-3.66962078317333e-5*x_1 - 1.51897800271169e-5*x_10 - 6.85510697640634e-6*x_100 + 2.6497992143397e-5*x_101 + 1.70267559715097e-5*x_102 + 7.43177591817928e-6*x_103 + 1.19218976267738e-5*x_104 + 1.1897153450926e-5*x_105 - 3.83898565556909e-6*x_106 + 1.05880545464066e-5*x_107 - 2.04137623925338e-6*x_108 + 9.76821960848525e-7*x_109 - 1.18433522556694e-5*x_11 + 6.17477047863257e-6*x_110 + 6.09453494276113e-5*x_111 - 1.50798354892847e-5*x_112 - 5.79378054635908e-6*x_113 + 9.32043907197291e-6*x_114 + 9.79629060414779e-6*x_115 - 5.83058280522172e-5*x_116 - 2.73522484390401e-5*x_117 - 2.00119912189268e-6*x_118 + 1.27138097350005e-5*x_119 + 7.78094347862095e-6*x_12 - 5.95200082899453e-7*x_120 - 6.06033513119183e-6*x_13 + 1.00814746271474e-5*x_14 - 2.93134629912391e-6*x_15 - 2.68896914124274e-5*x_16 - 6.98304732118478e-7*x_17 + 2.68796861672633e-5*x_18 - 2.94703133021636e-6*x_19 + 4.32938011063552e-6*x_2 + 9.22255440372735e-6*x_20 + 2.33839346038586e-5*x_21 - 7.10008220832612e-7*x_22 + 2.06493316924842e-5*x_23 + 2.14580636529686e-5*x_24 + 1.92047566593216e-6*x_25 + 1.80268542171415e-6*x_26 + 2.14532526268387e-5*x_27 + 1.36242789043899e-5*x_28 + 3.28514273033124e-8*x_29 - 1.23992234225655e-5*x_3 - 1.59845483070777e-5*x_30 - 5.23044919162381e-6*x_31 - 1.27891446179318e-5*x_32 - 1.67407426080072e-5*x_33 - 9.65747410944057e-6*x_34 + 4.61562999860321e-6*x_35 - 7.77420631814555e-6*x_36 + 7.19186343135061e-6*x_37 - 1.7536070557904e-5*x_38 + 1.80617999362943e-5*x_39 + 1.18227121564133e-6*x_4 - 2.12809913511401e-6*x_40 + 1.71415362571591e-5*x_41 - 4.8033055689082e-5*x_42 - 3.21309609474929e-6*x_43 - 1.10773013927273e-5*x_44 + 4.57361146876031e-6*x_45 - 5.98390898056887e-6*x_46 - 3.78654228672566e-5*x_47 + 8.47491316695967e-6*x_48 - 1.15259927225476e-5*x_49 + 2.16618513762699e-6*x_5 + 2.15284701604977e-5*x_50 - 5.98975483758418e-6*x_51 - 1.6871833840076e-5*x_52 + 1.1841888260492e-6*x_53 + 3.43419198641149e-5*x_54 + 1.19610530724561e-5*x_55 + 4.92106890435357e-6*x_56 - 6.96546534812606e-6*x_57 - 7.24643885207642e-6*x_58 - 3.22597217277756e-6*x_59 + 4.55643325848985e-6*x_6 - 4.78525411413571e-6*x_60 - 3.52855833709822e-6*x_61 + 7.00194257494736e-6*x_62 - 8.24301280316726e-6*x_63 - 6.80802224839946e-6*x_64 - 1.5803701872338e-6*x_65 + 2.09224303363741e-5*x_66 + 1.83415359906497e-5*x_67 - 3.92429073720691e-5*x_68 + 5.59570621713804e-6*x_69 - 1.7687323694436e-6*x_7 - 6.29992083736324e-6*x_70 + 4.01899249977847e-6*x_71 - 8.24931474415085e-6*x_72 + 1.48509605495495e-6*x_73 + 1.98208859818556e-5*x_74 - 3.7641189043302e-6*x_75 - 3.95782697623932e-6*x_76 - 9.59677682094247e-6*x_77 - 6.59115007835439e-6*x_78 - 3.47121741286552e-6*x_79 - 6.24471568093641e-5*x_8 + 4.87107223116972e-6*x_80 + 6.11286190873196e-7*x_81 + 3.00871411172502e-6*x_82 + 9.34304155081783e-6*x_83 - 2.4613991428047e-5*x_84 - 6.18497383096513e-6*x_85 - 2.33334392859178e-5*x_86 - 1.56462484046129e-5*x_87 - 6.86240804799784e-6*x_88 - 1.17903659467971e-5*x_89 - 1.30611152120268e-5*x_9 - 1.73184548190044e-5*x_90 + 1.66330538543097e-6*x_91 + 1.09124519610086e-5*x_92 - 2.66974355434003e-5*x_93 + 2.90005469261967e-7*x_94 - 4.10462885938109e-6*x_95 + 8.31283990034346e-6*x_96 - 1.60255316549254e-5*x_97 - 9.91406878998013e-7*x_98 - 2.22244340341965e-5*x_99 + 1.51241283341661e-5*std::sin(1.69031989574432*x_106 + 7.40343999862671) + 1.10061082221452e-5*std::sin(2.32271981239319*x_111 - 3.22551989555359) - 4.11022169017399e-6*std::sin(2.11207985877991*x_120 + 6.97639989852905) - 6.66000359343666e-6*std::sin(1.80575978755951*x_14 - 1.97991979122162) - 1.0792469909215e-5*std::sin(1.22783982753754*x_19 + 1.39455986022949) - 2.51163463816311e-5*std::sin(1.55415976047516*x_19 - 3.18824005126953) - 4.0165177560503e-5*std::sin(0.562479853630066*x_30 - 4.80335998535156) - 9.49833286196642e-6*std::sin(1.89087986946106*x_42 - 2.0065598487854) + 4.20332629444499e-6*std::sin(2.43439984321594*x_59 - 6.80175971984863) - 1.17819873898765e-5*std::sin(2.14591979980469*x_67 - 7.19736003875732) - 1.37988898719448e-6*std::sin(1.48759984970093*x_88 + 4.20224046707153) + 1.45838079477725e-5*std::sin(1.69543981552124*x_89 + 0.971519827842712) + 4.2310854032651e-6*std::sin(1.58927989006042*x_98 - 5.18264007568359) + 0.0411975434259381 - 6.40983365084923e-7*std::exp(-2.37063980102539*x_111));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.86017287941019e-5*x_1 + 4.12908328026449e-6*x_10 - 1.4834552375271e-5*x_100 + 1.06558295461121e-5*x_101 + 4.30657792867559e-6*x_102 + 4.22874847259291e-6*x_103 - 8.23030388919082e-6*x_104 + 4.65024140408602e-7*x_105 + 4.23775582976263e-6*x_106 - 7.32473757456201e-6*x_107 - 5.13575143344836e-7*x_108 + 9.98622933010628e-6*x_109 + 2.96429734412663e-6*x_11 - 6.16162699270046e-6*x_110 + 1.3277063498905e-6*x_111 - 2.02330667282123e-5*x_112 + 7.33946771968045e-6*x_113 + 4.62602157547851e-6*x_114 + 6.28821119690632e-6*x_115 + 5.96973513598095e-6*x_116 + 1.48914806453878e-5*x_117 - 6.76440671567876e-6*x_118 + 5.61886215411992e-6*x_119 - 2.86738314861616e-5*x_12 + 1.28463349933825e-5*x_120 + 1.40120624433297e-5*x_13 - 6.27593565487204e-7*x_14 - 3.59211609827022e-6*x_15 + 4.57069778916245e-6*x_16 + 1.2641521970057e-5*x_17 + 1.1182964656872e-5*x_18 + 4.92881822737627e-6*x_19 + 1.12795796677931e-5*x_2 + 3.37146458605084e-6*x_20 + 9.77561638934031e-6*x_21 + 3.74823521307391e-6*x_22 + 1.1295509014465e-5*x_23 + 3.33634613237974e-6*x_24 - 2.58687416322698e-6*x_25 - 8.93541542960636e-6*x_26 - 3.37135670807841e-6*x_27 + 1.35283171225922e-5*x_28 - 6.84943303942664e-6*x_29 + 5.41621268660524e-6*x_3 + 5.08865095141653e-6*x_30 + 1.6445213928061e-5*x_31 - 1.12288204777351e-5*x_32 - 1.1270127956645e-5*x_33 + 8.3226262101091e-6*x_34 - 5.59010506496638e-6*x_35 + 2.27710826471971e-6*x_36 - 6.67158761419082e-7*x_37 + 9.67799393545543e-6*x_38 + 2.19132211725376e-5*x_39 - 2.79772070111518e-5*x_4 + 2.31241267698555e-7*x_40 - 2.5268281394567e-6*x_41 - 2.64270306917769e-5*x_42 + 6.26991485513264e-6*x_43 + 2.92409763865656e-5*x_44 + 3.94445055120238e-8*x_45 - 1.78919492133842e-6*x_46 + 1.76007517997991e-5*x_47 - 1.74388994735775e-5*x_48 - 8.61855564110798e-6*x_49 + 3.57217997318991e-6*x_5 - 1.5364769011791e-5*x_50 - 9.46477839982614e-6*x_51 + 2.68394693305657e-6*x_52 + 6.40168211970499e-6*x_53 + 3.6887349019583e-5*x_54 + 3.67367536919386e-6*x_55 + 2.52321437496982e-6*x_56 + 4.22220790025658e-6*x_57 - 3.63329698907542e-6*x_58 - 7.05584938497357e-7*x_59 + 8.45505867454995e-7*x_6 - 8.67389285927971e-6*x_60 - 1.49752894496537e-5*x_61 + 1.68705809539446e-5*x_62 - 1.54486992235118e-5*x_63 - 1.12138318196964e-5*x_64 - 4.59906680843072e-6*x_65 + 1.12786394351384e-5*x_66 + 1.08700936357396e-5*x_67 - 2.78805109181083e-5*x_68 + 8.96545913897374e-6*x_69 - 3.79206974744574e-6*x_7 - 2.26247318452273e-5*x_70 - 1.48791591832097e-5*x_71 - 1.60576640373261e-5*x_72 + 1.35717658438499e-5*x_73 + 4.98743252656889e-6*x_74 - 1.23977278291351e-7*x_75 + 7.24336908340812e-7*x_76 - 7.42553083804924e-6*x_77 + 2.37102262877194e-6*x_78 + 1.7125409831902e-5*x_79 + 5.32404995163877e-5*x_8 + 5.93460479848847e-6*x_80 - 1.84063976994284e-5*x_81 + 1.79024342051582e-5*x_82 + 3.4042324777781e-5*x_83 - 2.39381951134757e-5*x_84 + 4.3189736146089e-6*x_85 + 1.66705004657684e-5*x_86 - 2.25494327542912e-6*x_87 + 1.25415511300528e-5*x_88 + 6.04725671047028e-6*x_89 + 9.14571840809715e-6*x_9 + 3.5561292174887e-6*x_90 + 7.5580371696692e-6*x_91 - 1.38103746921012e-5*x_92 - 7.07802766093118e-6*x_93 + 1.70947342950784e-5*x_94 - 2.27243552874003e-6*x_95 + 8.55890432420217e-6*x_96 + 2.1573058723586e-5*x_97 + 8.77092174851749e-6*x_98 - 5.87869739608415e-7*x_99 - 9.23903547929485e-7*std::sin(1.69031989574432*x_106 + 7.40343999862671) + 1.99432244622072e-5*std::sin(2.32271981239319*x_111 - 3.22551989555359) + 1.82185351201252e-5*std::sin(2.11207985877991*x_120 + 6.97639989852905) - 1.4762615343177e-5*std::sin(1.80575978755951*x_14 - 1.97991979122162) - 1.95561088040201e-5*std::sin(1.22783982753754*x_19 + 1.39455986022949) + 1.53430869008123e-6*std::sin(1.55415976047516*x_19 - 3.18824005126953) - 7.27798723659463e-5*std::sin(0.562479853630066*x_30 - 4.80335998535156) - 2.10540778958216e-5*std::sin(1.89087986946106*x_42 - 2.0065598487854) - 1.86312207683985e-5*std::sin(2.43439984321594*x_59 - 6.80175971984863) - 2.13491285370447e-5*std::sin(2.14591979980469*x_67 - 7.19736003875732) + 6.20259242942587e-6*std::sin(1.48759984970093*x_88 + 4.20224046707153) - 8.90896427718801e-7*std::sin(1.69543981552124*x_89 + 0.971519827842712) + 1.15924646957101e-5*std::sin(1.58927989006042*x_98 - 5.18264007568359) + 0.0897919271780585 - 1.42080867185254e-6*std::exp(-2.37063980102539*x_111));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (6.81292164975822e-6*x_1 + 9.29411029038179e-6*x_10 + 1.97276762107611e-7*x_100 + 3.213187683103e-6*x_101 - 1.00969750381787e-5*x_102 - 2.65465210309779e-7*x_103 - 5.15812532230278e-6*x_104 + 5.72105260384715e-6*x_105 + 6.42534499172304e-7*x_106 - 1.23202849855897e-7*x_107 + 1.42520901153335e-6*x_108 - 1.52028208488067e-6*x_109 - 1.04875380803443e-5*x_11 + 1.51662446494993e-5*x_110 - 2.45209219917621e-6*x_111 - 2.10473731925351e-5*x_112 - 4.1986849515708e-6*x_113 - 4.68559486417599e-6*x_114 + 6.72135631931169e-6*x_115 + 3.04967637282083e-5*x_116 - 6.58070760778922e-7*x_117 + 5.97991111726757e-6*x_118 - 1.09976735838743e-5*x_119 - 8.4482479423456e-6*x_12 - 6.16499176694854e-6*x_120 + 8.38088864366729e-6*x_13 - 2.85313017125247e-6*x_14 + 3.45692527199133e-6*x_15 + 1.66319252376578e-6*x_16 - 1.83117414941553e-5*x_17 - 2.75722566445354e-5*x_18 + 1.43212113359036e-6*x_19 + 1.16457232747047e-6*x_2 + 4.6672057647732e-7*x_20 - 3.16493071781874e-6*x_21 + 1.97075790041253e-6*x_22 + 1.43221026954428e-5*x_23 + 8.80068362011158e-6*x_24 + 3.08488583282848e-6*x_25 - 6.83676962010677e-6*x_26 - 5.24415314797319e-6*x_27 + 7.09649283113583e-6*x_28 + 3.88165978184394e-6*x_29 + 4.5180069326687e-6*x_3 - 2.74211679802447e-6*x_30 - 2.61387679016721e-6*x_31 + 9.91133621646299e-6*x_32 + 2.96156369914172e-6*x_33 + 2.86738948678494e-6*x_34 - 6.63301761666027e-6*x_35 - 4.08796198870006e-6*x_36 + 2.47430778005106e-6*x_37 - 7.58606230274399e-7*x_38 - 1.27772747905012e-5*x_39 - 1.30355198551506e-5*x_4 - 2.19338433161936e-6*x_40 + 3.39502743861387e-6*x_41 + 1.62758832767072e-5*x_42 + 3.50852839156967e-7*x_43 + 3.63115253462232e-6*x_44 - 2.7359311714828e-6*x_45 - 5.39074188267854e-6*x_46 + 2.77594583440684e-6*x_47 + 1.55479402467041e-5*x_48 - 2.4590203344742e-6*x_49 + 1.21508553320523e-6*x_5 + 2.98920980940746e-5*x_50 - 6.45594156581026e-6*x_51 + 2.43234709698499e-5*x_52 + 2.52168322626352e-6*x_53 - 1.83887447051886e-5*x_54 + 2.3300432100395e-6*x_55 - 5.47632101543741e-6*x_56 + 3.32378549291787e-6*x_57 - 2.37830757980117e-5*x_58 - 5.27776350035826e-6*x_59 + 3.78003150621931e-6*x_6 - 8.27372131068414e-6*x_60 - 1.04802430206851e-5*x_61 - 8.86604546270289e-6*x_62 - 3.97607795788497e-6*x_63 + 5.2607203282078e-6*x_64 - 3.58651653391057e-6*x_65 - 1.24486354408735e-5*x_66 + 1.58367294995695e-6*x_67 + 1.17535829238587e-6*x_68 + 4.87620345014056e-6*x_69 - 5.32877401207931e-7*x_7 - 5.54772356541461e-6*x_70 + 7.82683736040927e-7*x_71 + 5.34546679024233e-6*x_72 + 8.76526032307203e-6*x_73 - 8.78323175456232e-6*x_74 + 3.31175503209461e-6*x_75 + 4.36535465536279e-6*x_76 + 9.76815822335024e-6*x_77 + 5.75434852930173e-6*x_78 + 7.05040055527341e-6*x_79 + 1.05315382193445e-5*x_8 + 9.7483747562908e-6*x_80 + 3.02078998274137e-6*x_81 - 1.09514329675095e-6*x_82 - 1.62541782172397e-5*x_83 - 6.00674369267206e-6*x_84 + 1.83305372228992e-5*x_85 - 4.48833680186951e-6*x_86 - 1.28329632497975e-5*x_87 + 9.95016705026439e-6*x_88 + 8.38265745924051e-6*x_89 - 2.650472669172e-5*x_9 + 1.67515409948506e-6*x_90 + 2.01942549163296e-5*x_91 + 1.21377358625283e-5*x_92 + 2.11617745258795e-6*x_93 - 4.06966080941365e-6*x_94 - 2.30137891310832e-6*x_95 - 3.63222574537717e-6*x_96 + 1.37364778409607e-5*x_97 - 9.47146955957081e-6*x_98 + 4.44321978907021e-6*x_99 + 5.43144069038624e-6*std::sin(1.69031989574432*x_106 + 7.40343999862671) + 1.27700016294753e-5*std::sin(2.32271981239319*x_111 - 3.22551989555359) - 2.59091658931387e-6*std::sin(2.11207985877991*x_120 + 6.97639989852905) - 1.74031912930171e-6*std::sin(1.80575978755951*x_14 - 1.97991979122162) - 1.25221245825508e-5*std::sin(1.22783982753754*x_19 + 1.39455986022949) - 9.01988813615472e-6*std::sin(1.55415976047516*x_19 - 3.18824005126953) - 4.66022478194221e-5*std::sin(0.562479853630066*x_30 - 4.80335998535156) - 2.48200021880551e-6*std::sin(1.89087986946106*x_42 - 2.0065598487854) + 2.64960594524907e-6*std::sin(2.43439984321594*x_59 - 6.80175971984863) - 1.36702270348797e-5*std::sin(2.14591979980469*x_67 - 7.19736003875732) + 8.64755950579859e-6*std::sin(1.48759984970093*x_88 + 4.20224046707153) + 5.23739855667374e-6*std::sin(1.69543981552124*x_89 + 0.971519827842712) + 5.71560487777086e-7*std::sin(1.58927989006042*x_98 - 5.18264007568359) + 0.0440634926929633 - 1.67494746237194e-7*std::exp(-2.37063980102539*x_111));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (6.8142232190804e-5*x_1 + 1.25900529866582e-5*x_10 - 2.70919767182084e-6*x_100 + 2.56897348989524e-5*x_101 - 7.96190113565867e-6*x_102 + 1.08394798631263e-5*x_103 + 2.09431985442922e-5*x_104 + 1.80727526727434e-5*x_105 + 6.16744991278917e-6*x_106 - 1.19581263393244e-5*x_107 - 7.80907186766163e-7*x_108 + 1.5623706363643e-5*x_109 + 6.52635578862931e-6*x_11 + 9.497434445804e-6*x_110 + 2.49890151382321e-5*x_111 - 3.19988738611863e-5*x_112 - 2.03393441643477e-5*x_113 - 7.16608388386561e-6*x_114 + 4.3907852625368e-6*x_115 + 3.15133246475426e-5*x_116 + 5.66894148444757e-6*x_117 - 3.29354687417089e-6*x_118 - 3.08767391212429e-5*x_119 - 2.87811762301583e-5*x_12 + 2.23874267110791e-5*x_120 + 1.09197489574568e-5*x_13 + 8.68326931558125e-6*x_14 + 6.94514855755282e-6*x_15 - 6.40326624573499e-6*x_16 + 3.99047384075168e-6*x_17 + 2.86282802897728e-6*x_18 + 5.96932722482074e-6*x_19 + 1.89462716974296e-5*x_2 + 1.0465358546684e-5*x_20 + 2.13157053758172e-5*x_21 + 5.31300737546584e-6*x_22 + 3.50371576841167e-5*x_23 + 1.6575969646366e-5*x_24 + 4.08373554323854e-6*x_25 - 1.02798632041686e-5*x_26 - 1.164499703242e-5*x_27 + 2.71384049406367e-5*x_28 - 6.96886578466648e-6*x_29 - 1.03009542741471e-5*x_3 - 1.06226682610471e-5*x_30 + 3.39766922196615e-5*x_31 + 6.3861697997093e-6*x_32 + 5.05583850416238e-7*x_33 + 2.1589157288061e-5*x_34 + 5.05375167374808e-6*x_35 + 9.63634641246672e-6*x_36 + 7.83833691698818e-6*x_37 - 5.29617162790291e-6*x_38 + 4.52964137339475e-6*x_39 - 2.87901435077825e-5*x_4 + 1.48382041631946e-5*x_40 + 1.51945669789931e-5*x_41 - 1.86701348098226e-5*x_42 + 1.55891987828922e-5*x_43 + 1.82184734200557e-5*x_44 - 1.35792177510241e-5*x_45 - 1.04030492951046e-5*x_46 + 6.98588603411281e-6*x_47 - 3.17554119841916e-5*x_48 - 8.36865648465897e-6*x_49 + 6.83815088154657e-6*x_5 + 6.80394837312316e-6*x_50 - 5.71731853971752e-6*x_51 + 4.62504125414088e-5*x_52 + 6.94869857489779e-6*x_53 - 6.89270797442943e-6*x_54 + 2.21552415217995e-6*x_55 - 1.39771068804039e-5*x_56 + 7.91157479166011e-6*x_57 - 4.40191654353846e-5*x_58 - 8.51997295396595e-6*x_59 + 7.89535362450765e-6*x_6 + 1.36284579994388e-5*x_60 - 7.57086626871178e-6*x_61 + 1.17281264885527e-5*x_62 + 3.64217957340671e-6*x_63 - 8.06379895366095e-6*x_64 - 9.09354516763528e-6*x_65 + 9.14549333561524e-6*x_66 + 1.70610667986556e-5*x_67 - 9.79543588012026e-6*x_68 + 1.24264383554309e-5*x_69 + 7.19204652630076e-7*x_7 + 5.32769827657778e-6*x_70 + 3.12367095029462e-6*x_71 - 3.15276152435879e-5*x_72 + 1.78195747875115e-5*x_73 + 3.34317719807712e-6*x_74 + 3.50636724278596e-6*x_75 + 6.63995445037043e-6*x_76 + 7.22918956708722e-6*x_77 + 8.87416700165976e-6*x_78 + 2.54948388033846e-5*x_79 + 5.67723796948081e-5*x_8 + 1.48702657463813e-5*x_80 + 3.1244884640901e-7*x_81 + 9.14439610123856e-6*x_82 + 2.29768268682205e-5*x_83 - 4.88913166091452e-5*x_84 + 2.33834654443914e-5*x_85 + 2.03049989636059e-5*x_86 - 1.84379001750856e-5*x_87 + 3.10442271968127e-5*x_88 + 2.20180561849402e-5*x_89 + 3.6301731237805e-5*x_9 - 1.1403659205595e-5*x_90 + 2.41580777829107e-5*x_91 - 1.18107316238673e-5*x_92 + 1.73918036628166e-5*x_93 + 2.21138037614072e-5*x_94 - 1.27868990974451e-5*x_95 + 2.94022369454865e-5*x_96 + 4.75994395278961e-5*x_97 - 7.89873587035933e-6*x_98 - 9.53647865243901e-6*x_99 + 2.60799927807559e-5*std::sin(1.69031989574432*x_106 + 7.40343999862671) + 6.79997006142912e-6*std::sin(2.32271981239319*x_111 - 3.22551989555359) + 6.00195015450783e-6*std::sin(2.11207985877991*x_120 + 6.97639989852905) - 2.18129056388203e-5*std::sin(1.80575978755951*x_14 - 1.97991979122162) - 6.66797661719089e-6*std::sin(1.22783982753754*x_19 + 1.39455986022949) - 4.33105378266429e-5*std::sin(1.55415976047516*x_19 - 3.18824005126953) - 2.48154933070585e-5*std::sin(0.562479853630066*x_30 - 4.80335998535156) - 3.1109028026405e-5*std::sin(1.89087986946106*x_42 - 2.0065598487854) - 6.13790612868937e-6*std::sin(2.43439984321594*x_59 - 6.80175971984863) - 7.27933615572609e-6*std::sin(2.14591979980469*x_67 - 7.19736003875732) + 1.19872350473658e-5*std::sin(1.48759984970093*x_88 + 4.20224046707153) + 2.51482662398877e-5*std::sin(1.69543981552124*x_89 + 0.971519827842712) + 1.25094291214627e-5*std::sin(1.58927989006042*x_98 - 5.18264007568359) + 0.0736753965049716 - 2.09935467188481e-6*std::exp(-2.37063980102539*x_111));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (6.5659064988296e-6*x_1 + 1.09067174976882e-5*x_10 - 1.62951783148826e-6*x_100 - 3.89671360533715e-5*x_101 - 2.92357730417313e-5*x_102 + 5.44267345418667e-6*x_103 + 9.85733871191937e-6*x_104 + 5.86189509898409e-6*x_105 + 5.68136323547023e-6*x_106 - 3.46638884887376e-6*x_107 + 4.96773567294592e-6*x_108 + 5.9559076854553e-6*x_109 + 1.11121509649076e-5*x_11 + 2.05141350060423e-5*x_110 - 2.40030882478779e-5*x_111 - 7.68746408816286e-6*x_112 - 1.19212307156046e-5*x_113 - 6.65363712956789e-6*x_114 - 6.52624920958649e-6*x_115 - 8.49249860074647e-6*x_116 + 1.71608789134281e-5*x_117 - 2.87381987443497e-6*x_118 - 3.82303472909512e-6*x_119 + 2.28000497889288e-5*x_12 + 2.29961381366656e-5*x_120 + 4.82607626553852e-6*x_13 - 7.18339560823753e-6*x_14 + 7.2881059477407e-6*x_15 + 1.49598961176306e-5*x_16 + 5.42622684734106e-6*x_17 - 2.06243758471395e-5*x_18 + 5.27825484944531e-6*x_19 + 1.57482587245631e-6*x_2 - 5.42369348541159e-6*x_20 - 4.23724086137759e-6*x_21 - 4.55154687888187e-6*x_22 - 2.4095097770481e-7*x_23 - 7.12031237679037e-6*x_24 - 3.18734186621873e-6*x_25 + 1.69214862014394e-6*x_26 - 8.45659067824101e-6*x_27 + 1.79251377581521e-6*x_28 + 5.06734411723233e-6*x_29 + 5.00524557334008e-6*x_3 + 7.14646833349654e-6*x_30 + 2.42260086022844e-6*x_31 - 2.56135421097258e-6*x_32 - 3.22309552278775e-6*x_33 + 1.32823180485055e-7*x_34 - 1.55214844079451e-5*x_35 - 1.11600760584775e-5*x_36 + 4.91863465693286e-6*x_37 + 1.4566166524985e-5*x_38 - 6.61844123962502e-7*x_39 - 7.0767230086511e-6*x_4 + 2.91351103096808e-6*x_40 - 2.54880333847784e-5*x_41 + 1.3609022444597e-5*x_42 + 1.16954408498651e-5*x_43 - 3.03765602766667e-5*x_44 - 3.66869621938447e-6*x_45 - 2.99033432718123e-6*x_46 + 2.87515185025934e-5*x_47 - 1.46222083495417e-5*x_48 - 2.3997197667903e-5*x_49 + 8.61789587506061e-6*x_5 + 8.12072611299555e-6*x_50 - 4.82710074994105e-6*x_51 + 2.63866805382841e-5*x_52 + 3.56247055594459e-6*x_53 - 3.31725432443344e-5*x_54 + 5.51711993781882e-6*x_55 - 9.29376230038102e-6*x_56 + 1.38743768539275e-6*x_57 - 2.28823028723222e-5*x_58 - 2.05749162910241e-6*x_59 - 8.99372810383593e-7*x_6 + 1.93408470738122e-5*x_60 + 2.33756780890508e-6*x_61 + 6.30175292736109e-6*x_62 - 5.23073932649683e-6*x_63 + 5.38442187488495e-6*x_64 + 2.57199398569683e-5*x_65 - 5.60912574958195e-6*x_66 - 1.14157267201161e-5*x_67 - 7.65876348921293e-6*x_68 + 4.01665328938171e-6*x_69 - 3.56127906098073e-6*x_7 + 2.45134480024554e-5*x_70 + 2.14035653874395e-6*x_71 - 2.28769415369063e-5*x_72 + 6.49097250076289e-6*x_73 - 7.3326211579553e-6*x_74 - 9.15413381095222e-7*x_75 - 2.90211299750721e-7*x_76 + 8.93598257816181e-6*x_77 + 8.47079442389999e-7*x_78 - 2.83746056453852e-6*x_79 + 3.23759188647521e-5*x_8 - 2.99122960366252e-6*x_80 - 1.51202844370985e-5*x_81 + 9.51889129638076e-6*x_82 - 3.59366872785325e-6*x_83 + 1.8270480979947e-5*x_84 + 8.08754653835454e-6*x_85 - 6.56753823784937e-6*x_86 + 1.8321730574496e-7*x_87 + 1.22295350649498e-6*x_88 + 8.98732316432581e-6*x_89 - 7.01495829492616e-7*x_9 - 8.10317804665348e-6*x_90 + 1.04650782288026e-6*x_91 + 2.22596794106854e-6*x_92 + 1.92889632454322e-5*x_93 - 1.20085262960492e-5*x_94 - 2.14196355116965e-6*x_95 - 5.09194244946275e-6*x_96 + 9.31591920535169e-6*x_97 + 5.53982846277962e-6*x_98 + 3.44811341194318e-6*x_99 + 1.32973549612691e-7*std::sin(1.69031989574432*x_106 + 7.40343999862671) + 1.0195223684972e-5*std::sin(2.32271981239319*x_111 - 3.22551989555359) - 1.37632072594429e-5*std::sin(2.11207985877991*x_120 + 6.97639989852905) - 6.02527304862332e-6*std::sin(1.80575978755951*x_14 - 1.97991979122162) - 9.99732535942029e-6*std::sin(1.22783982753754*x_19 + 1.39455986022949) - 2.20826592969498e-7*std::sin(1.55415976047516*x_19 - 3.18824005126953) - 3.72059733841262e-5*std::sin(0.562479853630066*x_30 - 4.80335998535156) - 8.59309581401111e-6*std::sin(1.89087986946106*x_42 - 2.0065598487854) + 1.4074970970012e-5*std::sin(2.43439984321594*x_59 - 6.80175971984863) - 1.09139392843348e-5*std::sin(2.14591979980469*x_67 - 7.19736003875732) - 8.83890520332969e-6*std::sin(1.48759984970093*x_88 + 4.20224046707153) + 1.28222973703827e-7*std::sin(1.69543981552124*x_89 + 0.971519827842712) + 2.91705648413541e-7*std::sin(1.58927989006042*x_98 - 5.18264007568359) + 0.0602147242662876 - 5.79894551118277e-7*std::exp(-2.37063980102539*x_111));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.19060265024725e-5*x_1 - 2.80653958608005e-6*x_10 - 1.68279406987192e-5*x_100 + 2.43430995149128e-5*x_101 + 1.38423936042317e-5*x_102 - 2.63538644139718e-6*x_103 - 4.61713374230032e-5*x_104 - 9.29218311845264e-7*x_105 - 2.08624358812029e-6*x_106 + 2.6845987027395e-6*x_107 - 4.01205475387829e-7*x_108 - 3.58349856092008e-6*x_109 - 1.45086915995749e-5*x_11 + 8.69151692517734e-7*x_110 + 1.3822951354705e-5*x_111 - 2.17941430173151e-5*x_112 + 2.42637271420201e-5*x_113 + 2.35695731448082e-6*x_114 + 8.60424548933504e-6*x_115 - 2.36173908377377e-5*x_116 - 6.91537657342472e-6*x_117 - 7.43864333247862e-6*x_118 - 4.30077589536789e-6*x_119 - 1.73202608726873e-5*x_12 - 1.05056740160455e-5*x_120 + 5.20118510956454e-6*x_13 - 1.24637975951571e-6*x_14 + 3.06288503990894e-7*x_15 - 1.42154900978962e-5*x_16 - 1.21643659496463e-5*x_17 - 5.19811864244752e-6*x_18 + 2.76960648846039e-6*x_19 - 9.2326533923665e-7*x_2 + 1.17539836148722e-5*x_20 - 2.06570764206394e-7*x_21 - 7.63565101359751e-7*x_22 + 1.09762256598523e-5*x_23 + 1.51268211474245e-6*x_24 - 1.54664518954856e-6*x_25 - 1.49818821667596e-5*x_26 - 6.40938739186314e-8*x_27 + 9.37561759561339e-6*x_28 - 1.48383941523029e-6*x_29 + 4.73597428073602e-6*x_3 + 1.44666131889725e-6*x_30 + 8.59376311253681e-6*x_31 + 8.88255319220368e-6*x_32 - 2.33819378625316e-6*x_33 + 2.2291292448914e-6*x_34 - 2.53244956668316e-6*x_35 + 5.36752092324604e-6*x_36 - 4.74829637275792e-6*x_37 - 4.75929483640076e-6*x_38 - 2.40160648310875e-5*x_39 - 1.62860461023407e-5*x_4 + 2.59052134849244e-7*x_40 + 6.95227586861666e-6*x_41 - 6.53859133411767e-6*x_42 + 2.76620229722113e-6*x_43 + 1.42315421630073e-5*x_44 + 5.23741506595095e-6*x_45 - 4.33965923879071e-6*x_46 - 1.16752435082301e-5*x_47 - 1.09575097482173e-5*x_48 + 1.80435134180237e-6*x_49 + 2.94954036868742e-7*x_5 + 1.83252819996242e-5*x_50 - 1.1258928078578e-5*x_51 - 1.83626541064937e-5*x_52 + 2.0054363883898e-6*x_53 + 8.25730108810623e-6*x_54 + 5.35421289994339e-6*x_55 + 7.63368364589512e-6*x_56 - 1.7561584499315e-6*x_57 + 7.62535130121301e-6*x_58 - 3.30627757960798e-6*x_59 - 2.65060719189617e-6*x_6 - 2.32351696075398e-5*x_60 - 9.85097263131365e-6*x_61 + 4.29407992308101e-6*x_62 - 2.01091237901249e-5*x_63 - 4.93500256490979e-6*x_64 - 3.38907523074147e-6*x_65 + 5.90114500406529e-6*x_66 + 1.32595454341618e-5*x_67 - 1.66115346615038e-5*x_68 + 6.35340046426096e-6*x_69 - 4.68418986707116e-6*x_7 - 2.33198594076675e-5*x_70 - 3.00909805473414e-6*x_71 + 6.14219247217076e-6*x_72 + 1.38191802770501e-5*x_73 - 1.33622799596521e-7*x_74 + 3.99819152866193e-7*x_75 - 5.66444872590114e-6*x_76 - 6.23140966720896e-6*x_77 - 1.0164263111042e-5*x_78 + 1.26617618555771e-5*x_79 + 1.41993282009226e-5*x_8 + 9.54845358780333e-6*x_80 - 4.41771803760989e-8*x_81 + 4.25794534399802e-6*x_82 + 5.17237713642952e-6*x_83 - 3.25001978524247e-5*x_84 + 8.21059383179372e-6*x_85 - 5.08136759720552e-8*x_86 - 1.59884539860264e-5*x_87 - 3.7641988586625e-7*x_88 + 1.63636079328309e-6*x_89 - 1.08715833743672e-5*x_9 + 4.34200336998203e-6*x_90 + 8.16399277588168e-6*x_91 + 4.20482081472116e-6*x_92 - 1.87446429849148e-5*x_93 + 7.71480676573293e-6*x_94 - 9.22120879874857e-7*x_95 + 3.29994051544275e-6*x_96 + 5.31970191091348e-6*x_97 - 5.4519851877625e-6*x_98 + 7.43769788089386e-6*x_99 - 1.44271650889857e-5*std::sin(1.69031989574432*x_106 + 7.40343999862671) + 1.26259503830588e-5*std::sin(2.32271981239319*x_111 - 3.22551989555359) + 2.90239741651797e-6*std::sin(2.11207985877991*x_120 + 6.97639989852905) - 3.67541277339508e-6*std::sin(1.80575978755951*x_14 - 1.97991979122162) - 1.23808694984687e-5*std::sin(1.22783982753754*x_19 + 1.39455986022949) + 2.39589130476603e-5*std::sin(1.55415976047516*x_19 - 3.18824005126953) - 4.60765539253269e-5*std::sin(0.562479853630066*x_30 - 4.80335998535156) - 5.2417830466688e-6*std::sin(1.89087986946106*x_42 - 2.0065598487854) - 2.9681424257344e-6*std::sin(2.43439984321594*x_59 - 6.80175971984863) - 1.35160208491399e-5*std::sin(2.14591979980469*x_67 - 7.19736003875732) + 1.0997039309947e-5*std::sin(1.48759984970093*x_88 + 4.20224046707153) - 1.39117442169058e-5*std::sin(1.69543981552124*x_89 + 0.971519827842712) + 8.79654958159638e-6*std::sin(1.58927989006042*x_98 - 5.18264007568359) + 0.056631987916145 - 3.53735311777995e-7*std::exp(-2.37063980102539*x_111));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-3.59688951115191e-5*x_1 + 9.43086305396648e-6*x_10 - 1.12677725448217e-6*x_100 - 2.05562698643951e-5*x_101 - 2.57023562025369e-5*x_102 + 2.75383833471243e-6*x_103 - 1.09458178817879e-5*x_104 + 1.00327314392096e-5*x_105 + 7.14622913429371e-6*x_106 - 5.06453301008454e-6*x_107 + 1.09696912992516e-5*x_108 - 5.7811225819007e-7*x_109 - 1.39343257185833e-5*x_11 + 3.65223551475791e-5*x_110 + 2.86979912627168e-5*x_111 - 2.84027089355803e-5*x_112 - 1.37716195896929e-5*x_113 - 1.11146976813427e-5*x_114 + 3.86742799389238e-6*x_115 - 4.70225560707919e-5*x_116 - 5.76299891452719e-6*x_117 - 1.51606711992669e-5*x_118 - 2.85215185854373e-5*x_119 + 1.69517616654446e-5*x_12 - 1.61411652922329e-5*x_120 - 1.6976673571902e-5*x_13 - 8.78207706314643e-6*x_14 + 1.35633622272337e-5*x_15 - 2.39912682438816e-5*x_16 - 2.37187000793394e-5*x_17 - 3.11384695930248e-5*x_18 - 1.23649871353103e-5*x_19 + 1.8628722000369e-5*x_2 + 8.51532549462136e-6*x_20 - 1.45955639616972e-5*x_21 - 6.97480318494952e-6*x_22 - 1.96691515509931e-6*x_23 - 3.98071453042506e-6*x_24 - 1.09915653978037e-5*x_25 - 9.45681274324357e-6*x_26 + 1.78333330886305e-5*x_27 - 1.01723695363513e-5*x_28 + 5.17775053645757e-6*x_29 + 1.23146687409007e-5*x_3 + 2.32110181742303e-6*x_30 - 2.04776166187813e-5*x_31 + 3.94115466212187e-6*x_32 + 1.41685509634687e-5*x_33 - 1.16222568310298e-5*x_34 - 8.26847420019865e-6*x_35 - 1.48963608221877e-5*x_36 + 2.82346686125024e-7*x_37 - 1.78388016404055e-5*x_38 + 2.96141829108204e-5*x_39 + 2.71670298406255e-6*x_4 - 5.79411154025354e-6*x_40 + 9.56884971939666e-6*x_41 + 2.94653588351014e-5*x_42 + 1.58955587647562e-6*x_43 + 2.49086349933796e-7*x_44 + 5.4258418971775e-6*x_45 + 7.14939856554376e-7*x_46 + 6.56754991357412e-6*x_47 + 2.69007300601642e-5*x_48 - 1.40967499113683e-5*x_49 - 2.07658526627876e-6*x_5 + 3.82442315811226e-5*x_50 - 1.59502512706984e-5*x_51 - 2.15586949051538e-6*x_52 - 5.74023738613188e-7*x_53 - 3.89221778198359e-5*x_54 + 9.40497254576207e-6*x_55 + 5.06805340291127e-6*x_56 - 6.96386279463035e-7*x_57 - 3.14139829587364e-5*x_58 + 6.86292746100558e-6*x_59 + 5.84610860686518e-6*x_6 - 1.53946091102003e-5*x_60 - 1.63579465278605e-5*x_61 + 1.66543508360244e-6*x_62 - 2.95787872916489e-5*x_63 + 1.68136363121715e-5*x_64 + 1.4177446120815e-5*x_65 - 2.74716032509767e-5*x_66 - 2.11035187692981e-5*x_67 - 1.9925552124938e-5*x_68 - 2.75014584169928e-6*x_69 - 7.82075262629351e-8*x_7 + 9.50368655619361e-6*x_70 + 1.62183053494625e-5*x_71 - 3.54507560966078e-6*x_72 - 9.09375071691233e-6*x_73 - 2.59579481983627e-6*x_74 + 2.35434439834536e-6*x_75 - 1.24431637229788e-5*x_76 + 2.2655953461943e-6*x_77 + 3.06804796911781e-6*x_78 - 1.61990713839633e-5*x_79 - 4.20849340528783e-6*x_8 + 1.97263582195407e-5*x_80 + 1.06470635618343e-5*x_81 - 9.96555172814938e-6*x_82 - 1.95604452517815e-5*x_83 + 3.78753540668222e-6*x_84 - 9.78315492018951e-6*x_85 - 2.91665094625309e-5*x_86 - 2.19023789061727e-5*x_87 - 2.42270874311764e-5*x_88 - 1.60215783948603e-5*x_89 - 2.08551004622081e-5*x_9 - 2.61017585237552e-5*x_90 - 7.55710852960911e-6*x_91 + 2.64413076421398e-5*x_92 - 5.28534193101162e-5*x_93 - 5.96889538847649e-6*x_94 + 6.88804245955041e-6*x_95 - 1.40735104171656e-5*x_96 + 1.62542956294111e-5*x_97 - 3.83076577788367e-6*x_98 - 1.81949221517712e-5*x_99 + 3.84379711714154e-6*std::sin(1.69031989574432*x_106 + 7.40343999862671) + 1.03574731479197e-5*std::sin(2.32271981239319*x_111 - 3.22551989555359) - 2.84027561325944e-5*std::sin(2.11207985877991*x_120 + 6.97639989852905) - 1.73051757938733e-5*std::sin(1.80575978755951*x_14 - 1.97991979122162) - 1.01564254165255e-5*std::sin(1.22783982753754*x_19 + 1.39455986022949) - 6.38331926850612e-6*std::sin(1.55415976047516*x_19 - 3.18824005126953) - 3.7798079000104e-5*std::sin(0.562479853630066*x_30 - 4.80335998535156) - 2.46802149006401e-5*std::sin(1.89087986946106*x_42 - 2.0065598487854) + 2.90461344146595e-5*std::sin(2.43439984321594*x_59 - 6.80175971984863) - 1.10876265757806e-5*std::sin(2.14591979980469*x_67 - 7.19736003875732) + 8.8862019112178e-6*std::sin(1.48759984970093*x_88 + 4.20224046707153) + 3.70647469447599e-6*std::sin(1.69543981552124*x_89 + 0.971519827842712) - 1.35563829396755e-5*std::sin(1.58927989006042*x_98 - 5.18264007568359) + 0.0388547596688257 - 1.66551408841196e-6*std::exp(-2.37063980102539*x_111));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.1214044042672e-6*x_1 + 1.35502546011033e-6*x_10 + 7.3707459312672e-6*x_100 - 9.74601612055664e-6*x_101 - 1.04121260205723e-5*x_102 + 6.54219021049709e-6*x_103 - 8.86860564200105e-6*x_104 - 1.56269133556028e-5*x_105 - 3.27410770080197e-6*x_106 - 9.39994037450393e-7*x_107 + 1.43133583577053e-6*x_108 + 3.70618235434482e-6*x_109 - 1.80681822819046e-5*x_11 - 4.1403426246073e-6*x_110 + 6.30482813118173e-6*x_111 - 1.09278605337575e-5*x_112 + 6.32984575881183e-6*x_113 + 6.34059681128723e-6*x_114 + 2.51816318702573e-5*x_115 + 2.22798231859411e-5*x_116 - 8.93191510098883e-6*x_117 - 1.31734264339778e-5*x_118 - 4.67445174578847e-7*x_119 - 3.8135126015209e-5*x_12 - 2.90527291300524e-5*x_120 + 8.82150113024311e-6*x_13 + 2.39322620045899e-6*x_14 - 9.93596258759126e-6*x_15 + 5.37480989053738e-7*x_16 - 3.25100157090097e-5*x_17 + 4.80972514023238e-6*x_18 - 9.89251238062808e-6*x_19 - 5.74417348485288e-7*x_2 + 1.62889535013747e-6*x_20 - 6.11735489164136e-6*x_21 + 5.1231157037469e-6*x_22 - 1.12631149497193e-5*x_23 + 6.41325578372244e-6*x_24 - 8.25983955705238e-6*x_25 - 1.05638236907322e-5*x_26 + 2.46521002153379e-6*x_27 - 4.99743249130232e-7*x_28 - 4.96946660758409e-6*x_29 + 2.75105394342996e-6*x_3 + 6.50284828844603e-6*x_30 - 1.5396060762273e-5*x_31 + 1.54495216049636e-5*x_32 + 8.75874537309733e-6*x_33 - 1.41899635785716e-6*x_34 + 4.24069215833091e-6*x_35 - 3.14991191672585e-6*x_36 + 1.77921850214179e-6*x_37 - 2.26790764642042e-6*x_38 + 2.67353799743236e-6*x_39 - 8.70534323891078e-6*x_4 - 1.24151953939931e-5*x_40 + 1.55834744532285e-5*x_41 - 1.85442237798987e-5*x_42 - 5.39767453913743e-6*x_43 + 2.39514103000926e-5*x_44 + 8.76187400800716e-6*x_45 + 9.4126739971339e-7*x_46 - 2.53113448282369e-5*x_47 + 4.6628097066577e-5*x_48 + 1.13770079558249e-5*x_49 - 5.66846462579866e-6*x_5 - 1.37164565583992e-5*x_50 - 3.6888072874357e-6*x_51 - 1.551255145796e-5*x_52 - 3.58041600521435e-6*x_53 - 4.07374866523129e-6*x_54 + 4.29090811273775e-6*x_55 + 6.61789681251409e-6*x_56 + 3.91189952345564e-6*x_57 + 2.44515437849044e-6*x_58 + 6.38720356813847e-6*x_59 + 1.52276870109935e-6*x_6 - 3.47425190798286e-5*x_60 - 1.45805596578097e-5*x_61 - 9.25430186998535e-6*x_62 - 9.53383637863306e-7*x_63 - 1.33030461581977e-6*x_64 - 3.6151417286249e-5*x_65 - 2.16132830120265e-5*x_66 - 1.83665717705565e-6*x_67 + 4.20239298394191e-6*x_68 + 1.97749381650857e-6*x_69 - 2.0483757289507e-6*x_7 - 4.48109036559477e-5*x_70 - 1.92514568637318e-5*x_71 + 1.11622225727176e-5*x_72 - 1.01480504373529e-5*x_73 - 6.94118127436875e-6*x_74 + 1.95148035936227e-6*x_75 - 7.62571112724261e-6*x_76 - 9.48717757000219e-6*x_77 + 4.38968722162208e-6*x_78 - 2.00934423548473e-7*x_79 - 5.9227869212599e-5*x_8 - 8.74599483005189e-9*x_80 + 1.04502284029452e-5*x_81 + 3.3039213950032e-6*x_82 - 1.65647352640834e-5*x_83 - 2.78101916904755e-5*x_84 + 2.21344503535133e-5*x_85 + 2.19784922386957e-5*x_86 - 6.17060769816709e-6*x_87 + 5.73736084475466e-6*x_88 - 8.55938470255458e-6*x_89 + 1.56601692573887e-6*x_9 + 2.4962132564053e-6*x_90 + 2.51983206492755e-6*x_91 - 1.24510498288282e-5*x_92 - 4.41481506959899e-5*x_93 + 1.1024701853671e-5*x_94 + 8.43664162852987e-6*x_95 - 1.25167111778747e-5*x_96 + 1.26053784803364e-5*x_97 + 2.85353621466683e-6*x_98 - 4.25630236134853e-6*x_99 - 4.02470396268704e-6*std::sin(1.69031989574432*x_106 + 7.40343999862671) + 1.19370690282722e-5*std::sin(2.32271981239319*x_111 - 3.22551989555359) + 2.57162238679869e-5*std::sin(2.11207985877991*x_120 + 6.97639989852905) - 1.86575793938483e-5*std::sin(1.80575978755951*x_14 - 1.97991979122162) - 1.17053599411855e-5*std::sin(1.22783982753754*x_19 + 1.39455986022949) + 6.68374775569798e-6*std::sin(1.55415976047516*x_19 - 3.18824005126953) - 4.35625824674187e-5*std::sin(0.562479853630066*x_30 - 4.80335998535156) - 2.66089795591072e-5*std::sin(1.89087986946106*x_42 - 2.0065598487854) - 2.62987469110376e-5*std::sin(2.43439984321594*x_59 - 6.80175971984863) - 1.27785765798854e-5*std::sin(2.14591979980469*x_67 - 7.19736003875732) + 8.0534801146685e-6*std::sin(1.48759984970093*x_88 + 4.20224046707153) - 3.88091851256453e-6*std::sin(1.69543981552124*x_89 + 0.971519827842712) - 3.51730365676606e-6*std::sin(1.58927989006042*x_98 - 5.18264007568359) + 0.0325946249467292 - 1.795674410145e-6*std::exp(-2.37063980102539*x_111));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (8.40710346864538e-5*x_1 + 9.58457774614709e-6*x_10 + 1.53088392325242e-5*x_100 + 1.63292677558836e-5*x_101 - 5.74409765000515e-6*x_102 + 9.00822520081193e-6*x_103 + 1.02282318130991e-5*x_104 + 5.18388943228199e-6*x_105 + 1.11235777018014e-5*x_106 - 4.24405554560808e-6*x_107 + 7.76141443059253e-6*x_108 + 1.15761039700482e-5*x_109 + 2.05356519502573e-5*x_11 + 2.12163302485665e-5*x_110 - 3.97367735680526e-5*x_111 - 4.33873651869767e-6*x_112 + 1.58731634771748e-5*x_113 - 8.76756563187417e-6*x_114 - 5.58221133761802e-6*x_115 + 2.58832555319301e-5*x_116 + 2.61937324058872e-5*x_117 - 6.64406008523696e-6*x_118 - 2.78337878301431e-5*x_119 - 1.2120171122604e-5*x_12 + 2.69296743151278e-5*x_120 + 2.18384210269643e-5*x_13 + 1.99975096685692e-8*x_14 + 1.51775907978238e-5*x_15 + 3.39248962308522e-5*x_16 + 1.85131751460235e-5*x_17 - 1.29813301107506e-5*x_18 + 2.18335804825172e-5*x_19 + 1.18149743085552e-5*x_2 + 2.95167065702717e-6*x_20 + 5.50216591560632e-6*x_21 + 7.0578552183947e-6*x_22 + 1.84563327167637e-5*x_23 - 5.78707134323278e-6*x_24 - 3.04047300595036e-6*x_25 - 6.98913747809913e-6*x_26 - 2.64161699175638e-5*x_27 + 2.33604018523911e-5*x_28 + 5.01269500568004e-6*x_29 - 5.4390979260083e-6*x_3 + 1.00160799569338e-5*x_30 + 4.42911327091537e-5*x_31 + 2.14898853415806e-5*x_32 + 1.43944150780603e-5*x_33 + 2.91748984141027e-5*x_34 - 6.71634879776165e-6*x_35 + 2.09922764783785e-5*x_36 + 2.43116314460147e-6*x_37 + 9.21652379550198e-6*x_38 - 4.35332121612399e-5*x_39 - 8.93419258462052e-6*x_4 + 3.55149350039971e-5*x_40 - 1.23027224573409e-5*x_41 + 2.52147114442033e-5*x_42 + 2.90294661356783e-5*x_43 + 5.03118756279765e-6*x_44 - 1.1170938089061e-5*x_45 - 5.1018017969866e-6*x_46 + 4.21523995089549e-5*x_47 - 7.08849086062388e-5*x_48 - 2.65367911275487e-5*x_49 + 1.13250166224938e-5*x_5 - 8.17313573902191e-7*x_50 - 5.76221757706158e-6*x_51 + 3.80070708394508e-5*x_52 + 1.04737035357581e-5*x_53 - 6.47336704804382e-5*x_54 - 1.10364203590403e-6*x_55 - 3.841175505924e-6*x_56 + 1.30148800638137e-5*x_57 - 8.48454876347379e-6*x_58 - 5.85384908558613e-6*x_59 + 3.94367869797368e-6*x_6 + 1.76849021466603e-5*x_60 + 1.04903882031874e-5*x_61 + 3.28958843061716e-5*x_62 + 1.07323260733895e-5*x_63 - 9.34314549982952e-7*x_64 + 1.90300311958125e-5*x_65 + 1.49044619440778e-5*x_66 + 1.70616866965297e-5*x_67 + 4.02488421063081e-5*x_68 + 1.48878305978164e-5*x_69 + 2.69112445468169e-7*x_7 + 3.07871710965571e-5*x_70 + 2.64831966827987e-6*x_71 - 1.57513828873712e-5*x_72 + 3.25663875898342e-5*x_73 - 1.33951245834224e-5*x_74 + 1.69993429849253e-6*x_75 + 1.16386579509227e-5*x_76 + 1.11538011312593e-5*x_77 + 1.44332521519337e-5*x_78 + 2.81175213992724e-5*x_79 + 8.94796742613405e-5*x_8 + 8.77427547689229e-6*x_80 - 1.48627815425943e-5*x_81 + 1.11938015869633e-5*x_82 + 3.5637888429595e-5*x_83 - 1.50658972405063e-5*x_84 + 3.38798856255976e-5*x_85 + 3.62760526432019e-5*x_86 + 1.99909843179561e-6*x_87 + 2.82572069645524e-5*x_88 + 1.90266282264071e-5*x_89 + 6.30299369336725e-5*x_9 + 2.84544822539422e-6*x_90 + 1.74019950613306e-5*x_91 - 6.19666779692447e-6*x_92 + 4.44774844183982e-5*x_93 + 5.47075507893494e-6*x_94 - 1.02379375097881e-5*x_95 + 2.3454505031693e-5*x_96 + 3.76228324269168e-5*x_97 + 1.35604702088629e-6*x_98 + 2.14132736769408e-5*x_99 - 7.74094214043664e-6*std::sin(1.69031989574432*x_106 + 7.40343999862671) - 3.19910352008532e-6*std::sin(2.32271981239319*x_111 - 3.22551989555359) - 3.65869251763228e-6*std::sin(2.11207985877991*x_120 + 6.97639989852905) - 1.64491378525088e-5*std::sin(1.80575978755951*x_14 - 1.97991979122162) + 3.13700608608545e-6*std::sin(1.22783982753754*x_19 + 1.39455986022949) + 1.28552323693365e-5*std::sin(1.55415976047516*x_19 - 3.18824005126953) + 1.16746590461576e-5*std::sin(0.562479853630066*x_30 - 4.80335998535156) - 2.34593547020713e-5*std::sin(1.89087986946106*x_42 - 2.0065598487854) + 3.74156909818699e-6*std::sin(2.43439984321594*x_59 - 6.80175971984863) + 3.42462536000834e-6*std::sin(2.14591979980469*x_67 - 7.19736003875732) - 1.97235113881984e-6*std::sin(1.48759984970093*x_88 + 4.20224046707153) - 7.46439140270438e-6*std::sin(1.69543981552124*x_89 + 0.971519827842712) + 2.41462431255598e-5*std::sin(1.58927989006042*x_98 - 5.18264007568359) + 0.0697024992426419 - 1.58312583252019e-6*std::exp(-2.37063980102539*x_111));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (7.66152505521164e-6*x_1 - 1.60133729247044e-6*x_10 + 5.93356926494205e-6*x_100 + 2.4991872022461e-5*x_101 + 5.55931550407863e-6*x_102 + 5.73681618642692e-6*x_103 + 2.48911740824639e-5*x_104 + 4.11396375122144e-6*x_105 - 9.23844938294265e-7*x_106 - 2.96402877864847e-6*x_107 - 3.70550338591184e-6*x_108 + 3.84998870942249e-6*x_109 - 7.85689611907355e-6*x_11 - 6.48463563261429e-6*x_110 + 3.14128788788077e-5*x_111 - 9.7472757795179e-6*x_112 - 1.4104859182649e-5*x_113 + 1.74899896887262e-6*x_114 + 1.31947263211215e-5*x_115 + 2.90291491421055e-5*x_116 - 1.41855004571929e-5*x_117 + 1.72195878687289e-6*x_118 - 3.75259447441601e-6*x_119 - 2.90699072435509e-5*x_12 - 1.03594792206311e-5*x_120 + 2.18088775866857e-6*x_13 + 9.56961557959924e-6*x_14 - 5.14514024356119e-6*x_15 - 9.43017092767347e-6*x_16 - 8.38617634710047e-6*x_17 + 1.63502216869444e-5*x_18 - 5.28515604232697e-6*x_19 + 7.6499012831984e-6*x_2 + 2.57700603380589e-6*x_20 + 1.29459437924529e-5*x_21 + 7.72442341327063e-6*x_22 + 1.28276243298585e-5*x_23 + 1.93499661299879e-5*x_24 + 2.21357762111605e-6*x_25 - 1.70352794999591e-6*x_26 + 5.95295171487391e-6*x_27 + 9.02056812837679e-6*x_28 - 6.0840836760046e-6*x_29 - 9.56483612160186e-6*x_3 - 1.19738104795141e-5*x_30 - 1.06303821026687e-6*x_31 - 1.24896209208148e-6*x_32 + 2.26319008195612e-6*x_33 + 5.2550551251955e-6*x_34 + 1.17418377810263e-5*x_35 + 3.13751602869455e-6*x_36 + 4.30214503446855e-6*x_37 - 1.41602794524883e-5*x_38 + 2.02616384091756e-5*x_39 - 5.49530399449787e-6*x_4 - 9.4686663386602e-7*x_40 + 2.56735930337363e-5*x_41 - 2.69840324665758e-5*x_42 - 5.67177754836558e-6*x_43 + 2.43970908326867e-5*x_44 - 1.42393206598819e-6*x_45 - 2.65957473605795e-6*x_46 - 1.96872030584005e-5*x_47 + 2.7412794858017e-5*x_48 + 8.267234678515e-6*x_49 - 4.17157808821171e-6*x_5 - 6.64832850156248e-6*x_50 + 5.20014378224618e-7*x_51 + 1.08339093765185e-5*x_52 - 2.15891494407742e-7*x_53 + 2.0051514227928e-5*x_54 - 1.07081126013458e-6*x_55 - 2.56189906920115e-6*x_56 + 3.10269022060712e-6*x_57 - 1.62766877190145e-5*x_58 - 5.00656827613079e-8*x_59 + 4.54531295452605e-6*x_6 - 1.02093226092347e-5*x_60 - 1.06793415372465e-5*x_61 - 4.72472652558011e-6*x_62 + 9.2159608993891e-6*x_63 - 4.95734340279606e-6*x_64 - 2.88117109123048e-5*x_65 - 5.64043276666068e-7*x_66 + 1.19707015706729e-5*x_67 - 2.95309986347132e-6*x_68 + 3.04093420948879e-6*x_69 + 4.10573714027177e-6*x_7 - 2.15769049302615e-5*x_70 - 5.07464048752398e-6*x_71 - 2.4353071250465e-6*x_72 - 4.47420648706759e-6*x_73 + 5.91210859619596e-6*x_74 + 1.75522957768385e-6*x_75 + 3.57644908754438e-6*x_76 - 3.36752811527175e-6*x_77 + 7.28513665083848e-6*x_78 + 4.29750000187184e-6*x_79 - 3.04703659998602e-5*x_8 + 7.80892888715412e-6*x_80 + 1.03500745262461e-5*x_81 - 2.7071922988599e-6*x_82 + 2.35687278651795e-6*x_83 - 2.68386961147064e-5*x_84 + 5.44981154592318e-6*x_85 + 1.02554966047519e-5*x_86 - 7.64708618642554e-6*x_87 + 1.30141313204904e-5*x_88 - 3.60306023684852e-6*x_89 + 6.64664498260655e-6*x_9 - 5.74386468184443e-6*x_90 + 1.21504471251355e-5*x_91 - 7.37058773490981e-6*x_92 - 2.02861051544056e-5*x_93 + 1.39283323523876e-5*x_94 - 1.95964856631257e-6*x_95 + 9.68954124612058e-6*x_96 + 1.13140739321851e-5*x_97 - 4.04523423280422e-6*x_98 - 1.6880504602746e-5*x_99 + 2.25758889170972e-5*std::sin(1.69031989574432*x_106 + 7.40343999862671) + 1.96516443604028e-6*std::sin(2.32271981239319*x_111 - 3.22551989555359) + 1.54258550427991e-5*std::sin(2.11207985877991*x_120 + 6.97639989852905) - 1.12773961590908e-5*std::sin(1.80575978755951*x_14 - 1.97991979122162) - 1.92701885303562e-6*std::sin(1.22783982753754*x_19 + 1.39455986022949) - 3.74913405511184e-5*std::sin(1.55415976047516*x_19 - 3.18824005126953) - 7.17157935539173e-6*std::sin(0.562479853630066*x_30 - 4.80335998535156) - 1.60835442552716e-5*std::sin(1.89087986946106*x_42 - 2.0065598487854) - 1.57752809953542e-5*std::sin(2.43439984321594*x_59 - 6.80175971984863) - 2.10369934014219e-6*std::sin(2.14591979980469*x_67 - 7.19736003875732) + 9.06265502669291e-6*std::sin(1.48759984970093*x_88 + 4.20224046707153) + 2.17693490125589e-5*std::sin(1.69543981552124*x_89 + 0.971519827842712) + 9.05114194214745e-7*std::sin(1.58927989006042*x_98 - 5.18264007568359) + 0.0544995720106025 - 1.08537829417593e-6*std::exp(-2.37063980102539*x_111));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-6.21132785056861e-6*x_1 + 1.34678240777472e-5*x_10 - 2.23218144091432e-6*x_100 - 5.06924463144647e-5*x_101 - 4.50594797343415e-5*x_102 + 1.89043675133227e-6*x_103 - 5.6051216779605e-6*x_104 + 8.04898125781153e-7*x_105 + 3.27082943095894e-6*x_106 - 3.30403525756266e-6*x_107 + 1.44979480309755e-6*x_108 - 9.55968150177854e-6*x_109 - 4.3547582800849e-6*x_11 + 2.32213285114052e-5*x_110 - 5.04613300573946e-5*x_111 - 1.00935467025125e-5*x_112 - 8.76873139484473e-6*x_113 - 1.81504864607841e-5*x_114 + 3.52080934426067e-6*x_115 + 2.346698329007e-5*x_116 + 3.81008692455034e-6*x_117 + 2.40378091458792e-6*x_118 - 3.54775586488491e-6*x_119 + 1.41030674018632e-5*x_12 - 1.87081576380878e-6*x_120 + 9.87412896624458e-6*x_13 - 1.34174826295491e-5*x_14 + 6.68543630425322e-6*x_15 + 2.32038838947687e-5*x_16 - 2.53218269579391e-5*x_17 - 5.52894733857494e-5*x_18 + 5.11326210043143e-6*x_19 - 1.73138850201823e-5*x_2 - 1.373240154447e-5*x_20 - 2.49793576806179e-5*x_21 - 1.11791471571825e-6*x_22 - 8.02922565054633e-6*x_23 - 6.22417666219078e-6*x_24 - 5.32211042664839e-6*x_25 - 2.89412222900324e-6*x_26 - 1.72533779581137e-5*x_27 - 4.16517789944404e-6*x_28 + 8.41317170382208e-6*x_29 + 7.74136806145572e-6*x_3 + 6.5911842429977e-6*x_30 - 1.66764176832841e-5*x_31 + 9.7130193616332e-6*x_32 + 1.30128483962184e-5*x_33 + 2.09127495760032e-6*x_34 - 2.09945549465263e-5*x_35 - 1.29607963743972e-5*x_36 + 9.78609347279421e-7*x_37 + 8.15488922248165e-6*x_38 - 4.19826761368629e-5*x_39 - 5.92977795523749e-6*x_4 + 1.6142872734957e-6*x_40 - 2.89640579042925e-5*x_41 + 3.71124845311947e-5*x_42 + 5.41250791036635e-6*x_43 - 4.42194443701679e-5*x_44 + 2.31994983972295e-6*x_45 - 7.30475565972549e-6*x_46 + 2.93632241432518e-5*x_47 + 3.63520083628133e-5*x_48 - 1.94014037630502e-5*x_49 + 3.14763185268887e-6*x_5 + 1.50915365109603e-5*x_50 - 9.00841138258198e-6*x_51 + 4.58790216710256e-5*x_52 + 2.79858718615255e-7*x_53 - 7.40220560094884e-5*x_54 + 7.9322021683694e-7*x_55 - 1.77988426600307e-5*x_56 + 8.66590461684191e-7*x_57 - 3.66133277079592e-5*x_58 - 3.13182778641226e-6*x_59 - 1.62701395220231e-5*x_6 - 6.82576230736762e-7*x_60 - 7.97507783294633e-6*x_61 - 1.85763596046284e-5*x_62 - 9.24445491944063e-7*x_63 + 1.36273771291519e-5*x_64 + 1.50624039439068e-5*x_65 - 2.97305481025175e-5*x_66 - 1.15226589676358e-5*x_67 + 1.2609525420077e-5*x_68 + 6.13279504156632e-6*x_69 - 1.15293961796065e-6*x_7 + 7.14660739334186e-7*x_70 - 3.99832464460992e-6*x_71 - 1.6729131708481e-5*x_72 + 4.5019153788635e-6*x_73 - 2.90358501545815e-5*x_74 + 3.84994903323382e-7*x_75 - 2.1155488090747e-7*x_76 + 1.40748331796834e-5*x_77 - 9.69767644868339e-6*x_78 - 1.23963223999964e-5*x_79 + 5.71410623462675e-6*x_8 + 1.39334512831187e-6*x_80 - 7.13581211893701e-6*x_81 - 1.50583239914525e-6*x_82 - 4.90634871726245e-5*x_83 + 2.53335224061103e-5*x_84 + 1.8621194260182e-5*x_85 - 8.69960670086261e-6*x_86 - 6.682994747152e-6*x_87 + 2.6025457852476e-6*x_88 + 3.74178091506036e-6*x_89 - 3.2507375497513e-5*x_9 - 5.03465443508266e-6*x_90 + 1.96182278830145e-5*x_91 + 3.75584167094744e-6*x_92 - 5.15469367915377e-7*x_93 - 2.49159833291137e-5*x_94 + 8.34765182923458e-7*x_95 - 1.83038797372063e-5*x_96 - 1.63796933858184e-6*x_97 - 3.45386931913814e-6*x_98 + 1.06802341141811e-5*x_99 - 1.05613882007939e-6*std::sin(1.69031989574432*x_106 + 7.40343999862671) + 1.45629842471113e-5*std::sin(2.32271981239319*x_111 - 3.22551989555359) - 1.58935793885657e-5*std::sin(2.11207985877991*x_120 + 6.97639989852905) - 2.43076829238277e-6*std::sin(1.80575978755951*x_14 - 1.97991979122162) - 1.4280303818845e-5*std::sin(1.22783982753754*x_19 + 1.39455986022949) + 1.75390923999744e-6*std::sin(1.55415976047516*x_19 - 3.18824005126953) - 5.31454748844935e-5*std::sin(0.562479853630066*x_30 - 4.80335998535156) - 3.46670178588469e-6*std::sin(1.89087986946106*x_42 - 2.0065598487854) + 1.62536002173594e-5*std::sin(2.43439984321594*x_59 - 6.80175971984863) - 1.55896065435011e-5*std::sin(2.14591979980469*x_67 - 7.19736003875732) - 3.08932046153527e-6*std::sin(1.48759984970093*x_88 + 4.20224046707153) - 1.01840749945436e-6*std::sin(1.69543981552124*x_89 + 0.971519827842712) - 2.19313249905987e-6*std::sin(1.58927989006042*x_98 - 5.18264007568359) + 0.0497521359303453 - 2.33946125994393e-7*std::exp(-2.37063980102539*x_111));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-3.54294780112287e-5*x_1 - 1.28399629979927e-5*x_10 - 2.97367823718741e-5*x_100 + 2.14049415052465e-6*x_101 + 5.19712842472027e-6*x_102 + 3.51321155327718e-6*x_103 - 1.97201262036672e-5*x_104 + 1.56026353155482e-5*x_105 + 2.63669067115485e-6*x_106 + 4.91342765214273e-6*x_107 - 4.89691457345328e-7*x_108 - 5.68877968059565e-6*x_109 - 1.80534596931089e-6*x_11 + 1.4262958264085e-5*x_110 + 3.19550804782195e-5*x_111 - 1.72722053013417e-5*x_112 + 5.02057087497046e-6*x_113 - 2.82137583012628e-6*x_114 - 4.61921068911227e-6*x_115 - 0.000110246993123648*x_116 - 1.37783793113005e-5*x_117 - 1.0044045164384e-5*x_118 + 1.42279346792203e-5*x_119 + 3.43299278430073e-5*x_12 + 1.63761043468885e-5*x_120 - 1.06384303528129e-5*x_13 - 3.42503242629111e-6*x_14 + 6.79356003255984e-6*x_15 - 2.32891363411459e-5*x_16 + 1.4481649604404e-5*x_17 + 4.95104187301453e-6*x_18 + 5.16485744284192e-6*x_19 - 3.75332093547621e-7*x_2 + 7.44572764533326e-6*x_20 + 8.11528820167697e-6*x_21 - 8.36891353414946e-6*x_22 + 1.13501737300432e-5*x_23 - 5.20821054331387e-7*x_24 - 5.75264041619621e-6*x_25 - 1.20333987812285e-6*x_26 + 1.55462508283155e-5*x_27 + 7.09818634264229e-6*x_28 + 2.54599033711298e-6*x_29 - 2.00520388028391e-6*x_3 - 5.58039801162989e-6*x_30 + 7.90732106562188e-7*x_31 - 2.43485203122232e-5*x_32 - 1.63341864128643e-5*x_33 - 9.26650844334637e-6*x_34 - 1.234771900684e-5*x_35 - 9.59785504010565e-6*x_36 - 1.18718477508494e-6*x_37 - 1.07536725042926e-5*x_38 + 3.54697889104903e-6*x_39 - 2.11098605535947e-6*x_4 + 6.86841888817976e-6*x_40 - 1.39704057263051e-5*x_41 - 2.64579027579396e-5*x_42 + 7.52006813334829e-6*x_43 - 3.8071678167096e-5*x_44 + 8.69986401480843e-6*x_45 - 6.85930476368792e-6*x_46 + 3.432138007559e-6*x_47 - 1.94851175773283e-5*x_48 - 3.30763316522333e-5*x_49 + 6.64348273301782e-6*x_5 + 1.90381362378563e-5*x_50 - 1.68791349983646e-5*x_51 - 1.48585682515622e-5*x_52 + 3.88173911020275e-6*x_53 + 1.28844128349771e-5*x_54 + 1.25483639721184e-5*x_55 + 2.27284448650542e-6*x_56 - 1.16909873933222e-5*x_57 - 8.89190883538127e-6*x_58 - 2.57449951472183e-6*x_59 - 1.26342575029582e-5*x_6 + 3.48370383618799e-6*x_60 - 4.36788331379126e-6*x_61 + 1.84931829441864e-5*x_62 - 3.11503211219536e-5*x_63 - 3.76423841890131e-6*x_64 + 3.7054585056753e-5*x_65 + 2.47075586553972e-5*x_66 + 1.18679642226681e-5*x_67 - 5.66598263811524e-5*x_68 + 7.85346299852337e-6*x_69 - 4.89012128178681e-6*x_7 + 8.47196011232407e-6*x_70 + 8.76077245701436e-6*x_71 - 3.3416515011686e-5*x_72 + 1.09798860747298e-5*x_73 + 1.25489451570735e-5*x_74 - 7.1853939857768e-6*x_75 - 1.1012146909281e-5*x_76 - 1.0349502302611e-5*x_77 - 2.66039839845752e-5*x_78 - 1.08209150383946e-5*x_79 + 5.32481522233974e-6*x_8 + 7.52852651031483e-6*x_80 - 1.90629306050833e-5*x_81 + 7.04706406416807e-6*x_82 + 1.3835888566009e-5*x_83 - 4.29863893364956e-6*x_84 - 2.61230926777672e-5*x_85 - 3.81045327883134e-5*x_86 - 1.53811365844032e-5*x_87 - 2.36676084877178e-5*x_88 - 1.4111565344861e-5*x_89 - 1.64101891513791e-5*x_9 - 2.42666565595119e-5*x_90 - 5.68164900063782e-6*x_91 + 1.15099125016326e-5*x_92 - 2.88503422598864e-5*x_93 - 1.01776057730256e-5*x_94 - 4.18609369291186e-6*x_95 + 6.03895003155936e-6*x_96 - 2.4076887964397e-5*x_97 + 5.37927044572639e-6*x_98 - 1.43589188490766e-5*x_99 - 1.47028840353151e-6*std::sin(1.69031989574432*x_106 + 7.40343999862671) + 1.59116491118263e-5*std::sin(2.32271981239319*x_111 - 3.22551989555359) - 2.73474081287614e-5*std::sin(2.11207985877991*x_120 + 6.97639989852905) - 5.23179602598036e-6*std::sin(1.80575978755951*x_14 - 1.97991979122162) - 1.56027899035053e-5*std::sin(1.22783982753754*x_19 + 1.39455986022949) + 2.44167941504239e-6*std::sin(1.55415976047516*x_19 - 3.18824005126953) - 5.80672294836258e-5*std::sin(0.562479853630066*x_30 - 4.80335998535156) - 7.46145845471415e-6*std::sin(1.89087986946106*x_42 - 2.0065598487854) + 2.79668807031368e-5*std::sin(2.43439984321594*x_59 - 6.80175971984863) - 1.70333459751442e-5*std::sin(2.14591979980469*x_67 - 7.19736003875732) - 6.60944938590717e-6*std::sin(1.48759984970093*x_88 + 4.20224046707153) - 1.4177612905136e-6*std::sin(1.69543981552124*x_89 + 0.971519827842712) + 8.78186379533113e-6*std::sin(1.58927989006042*x_98 - 5.18264007568359) + 0.0468052769852074 - 5.03527389305861e-7*std::exp(-2.37063980102539*x_111));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
