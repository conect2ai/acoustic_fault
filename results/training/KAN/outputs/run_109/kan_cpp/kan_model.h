
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000951962111599243*x_1 + 2.69747980810824e-7*x_10 - 0.000199883523364334*x_100 - 0.00145367104217427*x_101 + 0.00149112084073705*x_102 + 0.00254999926001717*x_103 + 0.000439178684610658*x_104 - 0.00252816905184457*x_105 + 0.00106479292031795*x_106 - 0.00284354696255314*x_107 - 0.000952041241310437*x_108 - 0.00277850697448274*x_109 + 0.000213396246455137*x_11 + 0.000250388983697682*x_110 - 0.00324799639474873*x_111 - 0.00109253620780299*x_112 - 0.000100385496214402*x_113 + 0.00328689759484859*x_114 + 0.000940393858704975*x_115 + 5.62003147048212e-5*x_116 - 0.00376777993340758*x_117 - 0.00140389716307538*x_118 + 0.00150590974170862*x_119 - 0.00232884043005321*x_12 + 0.0052274935878171*x_120 - 0.000324107511073233*x_13 - 0.000214781933779298*x_15 - 0.00045248919514108*x_16 + 0.000368575926480414*x_17 + 0.000165131415120649*x_18 + 0.00275760764886428*x_19 - 0.000148338508565778*x_2 - 0.00268154353934391*x_20 + 0.00142061083332191*x_21 + 0.000138173799879361*x_22 - 0.00135851276234715*x_23 + 0.00168559393560067*x_24 - 0.000283666371995656*x_25 - 0.0010571207904012*x_26 + 0.000142288220126706*x_27 - 0.00083658710576587*x_28 - 0.000411635849106684*x_29 + 0.000164272523445491*x_3 - 4.76026501824062e-5*x_30 - 3.38926212273976e-5*x_31 - 0.00103140797149489*x_32 + 0.000487935851283634*x_33 + 0.000628325287307933*x_34 - 0.00331800164734232*x_35 + 0.00520735941327813*x_36 + 0.00272568415392535*x_37 - 0.00383835006660938*x_38 + 0.000471689054421352*x_39 + 9.31559813946648e-5*x_4 - 0.00265745164819338*x_40 - 0.00211656817219519*x_41 + 0.000467595770962249*x_42 + 0.00312806681233123*x_43 - 0.00131807704971208*x_44 - 0.000611761781751407*x_45 - 0.00436910966196332*x_46 - 0.00063738177782754*x_47 + 0.00186316958725474*x_48 + 3.60202469256999e-6*x_49 - 0.000822913936716583*x_5 - 0.00217705520201584*x_50 + 6.26187562885238e-5*x_51 + 0.000810402054177768*x_52 - 0.000251881830196718*x_53 + 0.00102099015466103*x_54 - 0.00168135467179081*x_55 - 0.00281819719534013*x_56 + 0.000120011276925539*x_57 - 0.000750213479108141*x_58 - 0.00127105847008361*x_59 - 0.000130661238737142*x_6 + 3.77408335965281e-5*x_60 - 0.000127505892479519*x_61 - 9.22643220448987e-5*x_62 - 0.000885552582298124*x_63 + 0.000160662910961009*x_64 + 0.00106520334809956*x_65 - 0.0002009773948476*x_66 - 0.000312695856149595*x_67 + 4.07846458563984e-5*x_68 - 0.000129282511819942*x_69 + 5.63227480528471e-5*x_7 + 0.00108815996996209*x_70 - 0.000305358960779019*x_71 - 0.000418806169054304*x_72 - 0.00134888704195693*x_73 + 0.00131528772210184*x_74 + 0.000470648063009207*x_75 + 0.000773600188422125*x_76 + 0.000914752314871433*x_77 + 0.000217665387275428*x_78 + 0.00185160082526979*x_79 - 0.00338100400773942*x_8 - 0.00117037700614816*x_80 + 0.00110249768007542*x_81 - 0.00115672939990044*x_82 - 0.000649365367788128*x_83 + 0.00148608183579326*x_84 - 0.000838728417744396*x_85 - 0.00232329502225725*x_86 - 0.000841810958567335*x_87 + 0.00143434063108017*x_88 - 0.000400131849441936*x_89 + 0.000243162827474524*x_9 + 0.00038018304036617*x_90 + 0.000697029197298594*x_91 - 3.12274751817293e-5*x_92 + 8.87636455481097e-5*x_93 - 0.00130095469543364*x_94 - 0.000154263782534725*x_95 + 0.00127924753381244*x_96 + 1.89863756743613e-5*x_97 - 0.000324561314041594*x_98 + 0.00143850536377922*x_99 + 1.80036241570914e-6*std::pow(-9.91328048706055*x_10 - 9.80399990081787, 2) - 2.50120892854622e-7*std::pow(-8.66760063171387*x_23 - 8.67360019683838, 2) - 6.35196844203129e-5*std::pow(-2.00767993927002*x_29 - 7.99128007888794, 2) + 2.51784427192813e-5*std::pow(-5.30592012405396*x_30 - 9.79191970825195, 2) + 2.15288799641473e-6*std::pow(-2.82407999038696*x_43 - 9.27255916595459, 2) + 5.37195617458938e-6*std::pow(-1.9560798406601*x_49 - 6.25687980651855, 2) - 1.14142780998945e-5*std::pow(-2.78144001960754*x_57 - 8.74015998840332, 2) + 0.000204798260398085*std::pow(-1.45055985450745*x_58 - 3.72727990150452, 2) - 1.6130193669893e-5*std::pow(-3.40543985366821*x_61 - 6.01567983627319, 2) + 0.000615186485484632*std::exp(0.343279838562012*x_23) - 0.00450018781889967*std::exp(0.148799866437912*x_49) + 0.00191532988010016*std::exp(0.172799870371819*x_49) + 0.010223250273758*std::log(6.24751996994019 - 0.6004798412323*x_15) + 0.00169413437293573*std::sin(0.273519963026047*x_1 - 4.31824016571045) - 0.00553446065410428*std::sin(0.381679862737656*x_1 - 4.22352027893066) + 0.000915238211411916*std::sin(0.437119841575623*x_1 - 7.18616008758545) - 0.00487295303594204*std::sin(0.338639855384827*x_10 - 4.34327983856201) + 0.000933518649808561*std::sin(0.356239855289459*x_10 - 1.16279983520508) - 0.019584303457605*std::sin(0.249999970197678*x_100 - 1.20175993442535) - 0.00119791870607383*std::sin(0.253279983997345*x_100 + 8.16903972625732) + 0.00169531864831444*std::sin(0.220319986343384*x_101 + 4.9814395904541) - 0.0118728872987426*std::sin(0.241359978914261*x_102 - 1.21223986148834) - 0.00828099325656781*std::sin(0.183360010385513*x_104 - 1.39951992034912) - 0.0160632739508965*std::sin(0.250479966402054*x_106 - 7.61360025405884) - 0.0159819490726269*std::sin(0.247279971837997*x_108 + 1.95583975315094) - 0.000649951482616849*std::sin(0.257359951734543*x_108 - 7.42712020874023) - 0.000971363796825803*std::sin(0.243679970502853*x_109 - 7.43919992446899) + 0.00301894761756575*std::sin(0.287599951028824*x_109 + 4.77304029464722) - 0.00359461222187852*std::sin(0.243759974837303*x_11 - 7.41639995574951) - 0.000583406250991189*std::sin(0.37407985329628*x_11 + 5.032639503479) + 0.00696313353710086*std::sin(0.233999982476234*x_110 - 1.21967995166779) + 0.00741574618601161*std::sin(0.284559935331345*x_110 + 7.94407987594604) + 0.00210675787376101*std::sin(0.248159974813461*x_112 + 1.98031985759735) + 0.000235279943082019*std::sin(0.297039926052094*x_112 - 1.24703979492188) + 0.000352777042534024*std::sin(0.182320013642311*x_113 - 0.98695981502533) + 0.00243739083586366*std::sin(0.270559966564178*x_113 + 1.98671984672546) + 0.0208849032316584*std::sin(0.282879948616028*x_113 + 1.97383987903595) + 0.00102959624440832*std::sin(0.219999983906746*x_116 - 4.20359992980957) - 0.0169984019226799*std::sin(0.239839985966682*x_116 + 4.99567985534668) + 0.00462585656543179*std::sin(0.253439962863922*x_119 - 1.2267199754715) + 0.00509992069377454*std::sin(0.303039938211441*x_12 + 5.12728023529053) - 0.000636522157504343*std::sin(0.357359826564789*x_12 - 1.35935986042023) - 0.0138584918621888*std::sin(0.38087984919548*x_13 - 7.3758397102356) - 0.00107888106840593*std::sin(0.442479848861694*x_13 + 1.92767989635468) + 0.021284768280809*std::sin(0.111040063202381*x_14 + 8.12263965606689) + 0.0121887753613149*std::sin(0.260159969329834*x_14 + 2.13895988464355) + 0.00502506542449986*std::sin(0.313599914312363*x_14 - 7.46143960952759) - 0.00104408096263914*std::sin(0.378799855709076*x_14 + 5.03047943115234) - 0.000727289711312083*std::sin(0.405359864234924*x_14 - 7.59216022491455) + 0.00625571385533702*std::sin(0.252079963684082*x_15 - 7.4113597869873) + 0.00126794088074618*std::sin(0.282559931278229*x_15 - 7.42799949645996) - 0.00392027471828977*std::sin(0.290639936923981*x_15 + 5.16328001022339) + 0.00093064542078548*std::sin(0.194240003824234*x_16 + 8.20448017120361) + 0.000732072881184878*std::sin(0.337679862976074*x_16 - 1.15767979621887) + 0.00793437569902756*std::sin(0.447039842605591*x_16 - 1.24167990684509) - 0.0100736949991708*std::sin(0.315039932727814*x_17 + 1.82631993293762) + 0.000945580268913365*std::sin(0.345279842615128*x_17 - 1.17911994457245) + 0.0217178075510307*std::sin(0.178240016102791*x_18 + 1.95119976997375) - 0.00561254073344839*std::sin(0.443679869174957*x_18 + 1.94863975048065) + 0.000770253767232932*std::sin(0.322959929704666*x_19 + 1.99087977409363) - 0.00231323026587513*std::sin(0.390159845352173*x_19 - 1.16807985305786) - 0.00117979775455029*std::sin(0.367999851703644*x_2 - 7.41447973251343) - 0.0154386171464959*std::sin(0.404399842023849*x_2 + 1.97687971591949) - 0.0047000783414392*std::sin(0.405919849872589*x_2 + 2.01239991188049) - 0.00565583533509077*std::sin(0.269759953022003*x_21 - 1.17471981048584) - 0.000879661619941553*std::sin(0.298719942569733*x_21 - 7.41016006469727) + 0.00108006715402447*std::sin(0.315119922161102*x_22 - 4.36552000045776) + 0.00519385244073375*std::sin(0.398959845304489*x_22 - 1.17631983757019) - 0.0011802996063443*std::sin(0.400479853153229*x_22 + 2.00727987289429) + 0.0010291155812905*std::sin(0.273519963026047*x_23 - 4.36448001861572) + 0.00502372598338367*std::sin(0.422159850597382*x_23 + 5.19608020782471) - 0.0146568541861731*std::sin(0.388799846172333*x_24 + 5.20887994766235) - 0.0192045053679876*std::sin(0.24551996588707*x_25 - 7.39271974563599) - 0.00129582454917987*std::sin(0.342239856719971*x_25 - 1.15543985366821) - 0.000992281343922585*std::sin(0.349199831485748*x_25 + 2.03151988983154) + 0.00490384446985026*std::sin(0.369199842214584*x_26 - 1.15751981735229) - 0.014181331575165*std::sin(0.442559868097305*x_26 - 7.44799947738647) + 0.000981665592124884*std::sin(0.298239946365356*x_27 + 5.1923999786377) - 0.00294519507006537*std::sin(0.319439917802811*x_27 + 1.80935990810394) - 0.0125819080063255*std::sin(0.369999825954437*x_27 - 4.38503980636597) + 0.00123334660300969*std::sin(0.234079986810684*x_28 - 1.18439984321594) + 0.00393182507812333*std::sin(0.31687992811203*x_28 + 1.99743974208832) + 0.00122732123508218*std::sin(0.685199856758118*x_28 + 4.94039964675903) - 0.000449522456242277*std::sin(0.232639983296394*x_29 - 1.37055993080139) - 0.0016658830980715*std::sin(0.278799951076508*x_29 - 1.16959989070892) + 0.00750245253970284*std::sin(0.350799858570099*x_3 - 4.20911979675293) - 0.0105695381121819*std::sin(0.458639860153198*x_3 - 4.39296007156372) - 0.00230430599377201*std::sin(0.554639875888824*x_3 + 8.19847965240479) - 0.00496402844506251*std::sin(0.24679996073246*x_30 + 8.22175979614258) + 0.00109902092661958*std::sin(0.311679929494858*x_30 - 1.0311998128891) + 0.00269583265974265*std::sin(0.329039841890335*x_30 - 1.17311990261078) - 0.000518067245860064*std::sin(0.295199930667877*x_31 + 5.3310399055481) + 0.00575519489316988*std::sin(0.328239858150482*x_31 - 4.25680017471313) + 0.00393386556018384*std::sin(0.404639840126038*x_31 - 1.20063984394073) - 0.000513396612272109*std::sin(0.513359844684601*x_31 + 8.15312004089355) - 0.000267872811277804*std::sin(0.257599949836731*x_32 + 8.03176021575928) + 0.00944067080520205*std::sin(0.305119931697845*x_32 - 1.15055990219116) - 0.000865166109505867*std::sin(0.248399972915649*x_33 - 1.19327986240387) - 0.000373497311787789*std::sin(0.226879999041557*x_35 - 1.20903992652893) + 0.00337933914121713*std::sin(0.233999997377396*x_35 - 1.21071982383728) - 0.00263792932169719*std::sin(0.24975997209549*x_36 - 7.42927980422974) - 0.00256842572297011*std::sin(0.218239992856979*x_37 + 1.97247982025146) + 0.00393628035230865*std::sin(0.240559980273247*x_39 - 1.21007990837097) + 0.00144904355574656*std::sin(0.288719952106476*x_4 - 7.37999963760376) + 0.0112610610860428*std::sin(0.3713598549366*x_4 - 1.20103991031647) - 0.0013005948785282*std::sin(0.380799859762192*x_4 + 1.98911988735199) - 0.000171921597101714*std::sin(1.04431986808777*x_4 + 6.76743984222412) - 0.00863567095640877*std::sin(0.232239991426468*x_41 - 4.4125599861145) + 0.00241860369230879*std::sin(0.248079970479012*x_41 + 1.96991980075836) + 0.00532932817246577*std::sin(0.249439969658852*x_42 + 1.97775983810425) - 0.000952694378324354*std::sin(0.280639946460724*x_44 - 7.47559976577759) + 0.00316070217802905*std::sin(0.221519991755486*x_45 + 1.96543979644775) + 0.0282139090732197*std::sin(0.199280008673668*x_47 + 1.97479975223541) + 0.00585355260374864*std::sin(0.219679996371269*x_48 - 7.40263986587524) + 0.00480441449073874*std::sin(0.364319831132889*x_49 + 1.84487986564636) - 0.00127574352376868*std::sin(0.308079928159714*x_5 + 2.01263976097107) + 0.00367241742665791*std::sin(0.31399992108345*x_5 - 1.18407988548279) - 0.000664679772784716*std::sin(0.376479834318161*x_5 + 2.00879979133606) - 0.00200073943600667*std::sin(0.230079978704453*x_50 - 7.44495964050293) - 0.0304415905480806*std::sin(0.199359998106956*x_51 - 4.39431953430176) - 0.00747489741413832*std::sin(0.208000004291534*x_51 + 8.20343971252441) + 0.00638903604471293*std::sin(0.210879996418953*x_51 + 8.1988000869751) - 0.0035512477939519*std::sin(0.22639998793602*x_53 + 1.97503972053528) + 0.00039759276970267*std::sin(0.240399971604347*x_53 - 1.20711994171143) + 0.0190022644524124*std::sin(0.253679990768433*x_53 - 7.42943954467773) - 0.00259602606184782*std::sin(0.254559963941574*x_53 + 5.15840005874634) - 0.00212330536184352*std::sin(0.193759992718697*x_54 - 4.3953595161438) + 0.0207518777756485*std::sin(0.226559996604919*x_55 - 7.41791963577271) + 0.00960960901859943*std::sin(0.18792000412941*x_56 + 8.20448017120361) - 0.000999934359203433*std::sin(0.23471999168396*x_57 + 1.97623980045319) - 0.00554104200984612*std::sin(0.245999976992607*x_57 - 7.43856000900269) - 0.212052999115668*std::sin(0.0536801069974899*x_59 + 8.01991939544678) - 0.00509205536495331*std::sin(0.385519832372665*x_59 + 1.81727981567383) - 0.00504014787255921*std::sin(0.24415996670723*x_6 - 1.15775990486145) + 0.00329469541935125*std::sin(0.397839844226837*x_6 + 1.98791980743408) + 0.00136873783089099*std::sin(0.355519831180573*x_60 + 8.25080013275146) - 0.00542452331759528*std::sin(0.410879880189896*x_60 - 1.20055997371674) + 0.0119828637990347*std::sin(0.417359858751297*x_60 - 1.23583984375) - 0.000507643171121511*std::sin(0.490879863500595*x_60 - 7.56831979751587) - 6.10326799026062e-5*std::sin(1.03327977657318*x_64 - 4.59127998352051) - 0.0117857673143463*std::sin(0.312879920005798*x_7 - 7.39871978759766) + 0.00163084549382512*std::sin(0.350159853696823*x_7 + 2.01959991455078) + 0.00471231548561568*std::sin(0.366479843854904*x_7 + 2.00175976753235) - 0.000696523381155766*std::sin(0.429519861936569*x_7 + 8.19087982177734) - 0.00242713295247013*std::sin(0.355759829282761*x_8 - 1.14231991767883) - 0.00117557006582431*std::sin(0.494479864835739*x_8 - 1.44279980659485) + 0.0253927546191841*std::sin(0.312239944934845*x_9 - 7.42360019683838) + 0.00128718183257145*std::sin(0.365279853343964*x_91 + 1.97591972351074) - 0.000765399268275833*std::sin(0.373839855194092*x_91 + 5.19048023223877) - 0.00225160351948386*std::sin(0.263279944658279*x_92 - 7.39527988433838) + 0.0172517384690301*std::sin(0.292799949645996*x_92 - 1.16527986526489) - 0.00215918002098199*std::sin(0.236319988965988*x_93 + 1.98023986816406) - 0.00546853920366713*std::sin(0.236479982733727*x_93 - 1.18967986106873) + 0.000845717374491579*std::sin(0.2483199685812*x_93 - 1.21671986579895) + 0.0034512717352571*std::sin(0.291119933128357*x_94 + 1.8025598526001) + 9.36537028614391e-5*std::sin(0.337679862976074*x_94 + 1.8290399312973) + 0.00868836454306631*std::sin(0.267839968204498*x_95 + 1.96391975879669) - 0.000854814610506208*std::sin(0.285919934511185*x_95 - 1.22239983081818) - 0.0240970687293*std::sin(0.276799947023392*x_97 + 1.95687973499298) - 0.000626695725479974*std::sin(0.277999937534332*x_97 + 8.18935966491699) - 0.0026466709559902*std::sin(0.279599964618683*x_97 - 1.20447981357574) + 0.0043908135524918*std::sin(0.291679948568344*x_97 + 8.16464042663574) + 0.019501182791887*std::sin(0.230719983577728*x_98 + 5.18800020217896) + 0.006904162988125*std::sin(0.232399985194206*x_98 + 1.98495984077454) + 0.27385005513591);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000561601859907805*x_1 + 3.48457801049057e-5*x_10 - 0.000105144844072122*x_100 + 0.00135247737745669*x_101 - 0.00027444401523087*x_102 - 0.00131809386493155*x_103 - 0.000640360094847598*x_104 + 0.000527550594072453*x_105 - 0.000481417624666423*x_106 + 0.00212881212314149*x_107 + 0.000375521482442565*x_108 + 0.00245976593049337*x_109 - 0.000308820802714947*x_11 - 0.000529129840731935*x_110 + 0.000643224322364986*x_111 - 0.000730236549791228*x_112 - 0.000267186772331959*x_113 - 0.00134888165348142*x_114 - 0.00112791846341838*x_115 - 5.64766266422113e-5*x_116 + 0.000871473967934436*x_117 + 0.000189376224060498*x_118 - 0.000893534282391781*x_119 + 0.000907886171908406*x_12 - 0.00331263305363409*x_120 - 0.00022394188030073*x_13 + 0.000441533040014063*x_15 + 0.000146617316680927*x_16 + 0.000395574626084476*x_17 + 5.59651482140617e-6*x_18 - 0.00152420361477403*x_19 + 4.55600863014825e-5*x_2 + 0.00152675547162425*x_20 - 0.0010308528930487*x_21 - 5.11319578686107e-5*x_22 + 0.000821040178069627*x_23 + 0.000356307167847315*x_24 - 0.00010603245483531*x_25 - 0.000105123711026795*x_26 + 6.39147997006733e-5*x_27 + 0.000528647892430413*x_28 - 0.000129017729066294*x_29 - 0.000286581335467205*x_3 + 9.78580576025599e-5*x_30 + 1.50660112255486e-5*x_31 + 0.000726839124666724*x_32 + 9.08828835327698e-5*x_33 - 0.000546367835520272*x_34 + 0.00210529473166228*x_35 - 0.00208294485960426*x_36 - 0.00172427174750308*x_37 + 0.00243611743294549*x_38 - 0.000585186737186726*x_39 - 4.14098706618917e-5*x_4 + 0.000995371882852405*x_40 + 0.00138558088974986*x_41 - 0.000220426555987555*x_42 - 0.00295318727774115*x_43 + 0.000525104716605462*x_44 + 0.000572785511114823*x_45 + 0.00130901284717948*x_46 - 0.000193462101354282*x_47 - 0.000617637097710438*x_48 + 5.34884920817385e-6*x_49 + 0.000493648362499151*x_5 + 0.00167541094107305*x_50 - 0.000149728783711312*x_51 + 0.00151972244996777*x_52 + 0.000111966981125315*x_53 + 0.00104959321194682*x_54 + 0.00134807964786661*x_55 + 0.00239681369603374*x_56 + 0.000185948505939835*x_57 - 0.00010574507385545*x_58 - 0.000671858202362456*x_59 + 0.000140892784716803*x_6 + 1.52565003904999e-5*x_60 + 0.000202358684487692*x_61 + 0.000125060061313623*x_62 + 0.000720075115880017*x_63 - 0.000298303518724806*x_64 - 0.000853286779168203*x_65 + 0.000472070906612631*x_66 + 0.000267402288760651*x_67 - 3.87479093979577e-5*x_68 + 0.000234667389157102*x_69 + 2.27681252843694e-5*x_7 - 0.000545899299612834*x_70 - 0.000351610359585437*x_71 + 0.000242319004009659*x_72 + 0.000545553873648559*x_73 - 0.000293812993257625*x_74 - 0.00011502127602643*x_75 - 0.000521204073125078*x_76 - 0.000565802275614371*x_77 - 0.000132427272777213*x_78 - 0.000898614887101188*x_79 + 0.00204920910456394*x_8 + 0.000435640811414627*x_80 - 0.00107138196074141*x_81 + 0.00107875241204075*x_82 + 0.000626403294915652*x_83 - 0.000799177003777135*x_84 + 0.000572965752877348*x_85 + 0.00135033707951067*x_86 + 0.000665217108163811*x_87 - 0.000751607653055994*x_88 - 0.000302330592097216*x_89 - 0.000194927165667259*x_9 - 0.000184143464800044*x_90 - 0.000289970366293874*x_91 + 5.76160763457599e-5*x_92 - 3.70900273371638e-5*x_93 + 0.00128415084022911*x_94 - 0.000329324655414604*x_95 - 0.000818114213423484*x_96 + 7.67512585934821e-6*x_97 + 0.000816071966815981*x_98 - 0.00036758679818383*x_99 - 1.08807949351157e-6*std::pow(-9.91328048706055*x_10 - 9.80399990081787, 2) - 3.71418592008219e-7*std::pow(-8.66760063171387*x_23 - 8.67360019683838, 2) + 3.83891962246088e-5*std::pow(-2.00767993927002*x_29 - 7.99128007888794, 2) - 1.52170179528074e-5*std::pow(-5.30592012405396*x_30 - 9.79191970825195, 2) - 4.42575017898643e-6*std::pow(-2.82407999038696*x_43 - 9.27255916595459, 2) - 1.10432758419339e-5*std::pow(-1.9560798406601*x_49 - 6.25687980651855, 2) + 5.07389619795862e-6*std::pow(-2.78144001960754*x_57 - 8.74015998840332, 2) - 0.000123773294477616*std::pow(-1.45055985450745*x_58 - 3.72727990150452, 2) - 6.52053181056924e-6*std::pow(-3.40543985366821*x_61 - 6.01567983627319, 2) - 0.000273463844355155*std::exp(0.343279838562012*x_23) + 0.00200043188579975*std::exp(0.148799866437912*x_49) + 0.000774260350899413*std::exp(0.172799870371819*x_49) - 0.00617859431126324*std::log(6.24751996994019 - 0.6004798412323*x_15) - 0.00348267792692129*std::sin(0.273519963026047*x_1 - 4.31824016571045) - 0.00223727175804394*std::sin(0.381679862737656*x_1 - 4.22352027893066) + 0.00135908873487156*std::sin(0.437119841575623*x_1 - 7.18616008758545) - 0.00196986136264294*std::sin(0.338639855384827*x_10 - 4.34327983856201) - 0.00191905957874156*std::sin(0.356239855289459*x_10 - 1.16279983520508) + 0.0118361052202561*std::sin(0.249999970197678*x_100 - 1.20175993442535) + 0.0024625939373746*std::sin(0.253279983997345*x_100 + 8.16903972625732) + 0.000685322160515561*std::sin(0.220319986343384*x_101 + 4.9814395904541) + 0.00717558036416093*std::sin(0.241359978914261*x_102 - 1.21223986148834) + 0.00500475841406075*std::sin(0.183360010385513*x_104 - 1.39951992034912) + 0.00970811145140721*std::sin(0.250479966402054*x_106 - 7.61360025405884) + 0.0096589613849621*std::sin(0.247279971837997*x_108 + 1.95583975315094) - 0.000965149539456967*std::sin(0.257359951734543*x_108 - 7.42712020874023) - 0.00144243277571576*std::sin(0.243679970502853*x_109 - 7.43919992446899) + 0.00122039104908715*std::sin(0.287599951028824*x_109 + 4.77304029464722) + 0.00159788373177044*std::sin(0.243759974837303*x_11 - 7.41639995574951) - 0.000866332779476709*std::sin(0.37407985329628*x_11 + 5.032639503479) - 0.00309526511186904*std::sin(0.233999982476234*x_110 - 1.21967995166779) - 0.0044818317043725*std::sin(0.284559935331345*x_110 + 7.94407987594604) - 0.00433091923611743*std::sin(0.248159974813461*x_112 + 1.98031985759735) + 0.000349380430358889*std::sin(0.297039926052094*x_112 - 1.24703979492188) + 0.000523858486731727*std::sin(0.182320013642311*x_113 - 0.98695981502533) - 0.00108347352209179*std::sin(0.270559966564178*x_113 + 1.98671984672546) - 0.0126221447037874*std::sin(0.282879948616028*x_113 + 1.97383987903595) - 0.00211656889283713*std::sin(0.219999983906746*x_116 - 4.20359992980957) + 0.0102732718663484*std::sin(0.239839985966682*x_116 + 4.99567985534668) + 0.00186997413070916*std::sin(0.253439962863922*x_119 - 1.2267199754715) + 0.00206161164556915*std::sin(0.303039938211441*x_12 + 5.12728023529053) - 0.000945207578719579*std::sin(0.357359826564789*x_12 - 1.35935986042023) + 0.00837561408451482*std::sin(0.38087984919548*x_13 - 7.3758397102356) + 0.00221788504072406*std::sin(0.442479848861694*x_13 + 1.92767989635468) - 0.0094615449097412*std::sin(0.111040063202381*x_14 + 8.12263965606689) - 0.00736649266055798*std::sin(0.260159969329834*x_14 + 2.13895988464355) + 0.00203135186230285*std::sin(0.313599914312363*x_14 - 7.46143960952759) + 0.00214634552051558*std::sin(0.378799855709076*x_14 + 5.03047943115234) - 0.00107999342827632*std::sin(0.405359864234924*x_14 - 7.59216022491455) + 0.00252883393878148*std::sin(0.252079963684082*x_15 - 7.4113597869873) + 0.00188283678065282*std::sin(0.282559931278229*x_15 - 7.42799949645996) + 0.00174264783230292*std::sin(0.290639936923981*x_15 + 5.16328001022339) + 0.00138196776727463*std::sin(0.194240003824234*x_16 + 8.20448017120361) - 0.00150494205473332*std::sin(0.337679862976074*x_16 - 1.15767979621887) + 0.00320742268823979*std::sin(0.447039842605591*x_16 - 1.24167990684509) + 0.00608820805013884*std::sin(0.315039932727814*x_17 + 1.82631993293762) - 0.00194385497590149*std::sin(0.345279842615128*x_17 - 1.17911994457245) - 0.0131255245244605*std::sin(0.178240016102791*x_18 + 1.95119976997375) - 0.00226883515099224*std::sin(0.443679869174957*x_18 + 1.94863975048065) + 0.00114379317317152*std::sin(0.322959929704666*x_19 + 1.99087977409363) + 0.00102828143385915*std::sin(0.390159845352173*x_19 - 1.16807985305786) + 0.00242534220640565*std::sin(0.367999851703644*x_2 - 7.41447973251343) + 0.00933058954058516*std::sin(0.404399842023849*x_2 + 1.97687971591949) - 0.00189997782820949*std::sin(0.405919849872589*x_2 + 2.01239991188049) + 0.00251414247592779*std::sin(0.269759953022003*x_21 - 1.17471981048584) + 0.00180834422338144*std::sin(0.298719942569733*x_21 - 7.41016006469727) - 0.000480113466518343*std::sin(0.315119922161102*x_22 - 4.36552000045776) + 0.0020995829778795*std::sin(0.398959845304489*x_22 - 1.17631983757019) - 0.0017526933193504*std::sin(0.400479853153229*x_22 + 2.00727987289429) - 0.00211558078064399*std::sin(0.273519963026047*x_23 - 4.36448001861572) + 0.00203081040145091*std::sin(0.422159850597382*x_23 + 5.19608020782471) + 0.00885811786572014*std::sin(0.388799846172333*x_24 + 5.20887994766235) + 0.0116065678174633*std::sin(0.24551996588707*x_25 - 7.39271974563599) + 0.00266386163145435*std::sin(0.342239856719971*x_25 - 1.15543985366821) - 0.00147349441875678*std::sin(0.349199831485748*x_25 + 2.03151988983154) - 0.00217986609343114*std::sin(0.369199842214584*x_26 - 1.15751981735229) + 0.00857072772847644*std::sin(0.442559868097305*x_26 - 7.44799947738647) + 0.00145773049139825*std::sin(0.298239946365356*x_27 + 5.1923999786377) + 0.00130920360775065*std::sin(0.319439917802811*x_27 + 1.80935990810394) + 0.00760408902756362*std::sin(0.369999825954437*x_27 - 4.38503980636597) - 0.00253542402489708*std::sin(0.234079986810684*x_28 - 1.18439984321594) - 0.00174778221980703*std::sin(0.31687992811203*x_28 + 1.99743974208832) + 0.000496137078011508*std::sin(0.685199856758118*x_28 + 4.94039964675903) - 0.000667521196922263*std::sin(0.232639983296394*x_29 - 1.37055993080139) + 0.00342460101581621*std::sin(0.278799951076508*x_29 - 1.16959989070892) - 0.00333500420117809*std::sin(0.350799858570099*x_3 - 4.20911979675293) + 0.00638787922665242*std::sin(0.458639860153198*x_3 - 4.39296007156372) - 0.000931501557958377*std::sin(0.554639875888824*x_3 + 8.19847965240479) - 0.00200667803790946*std::sin(0.24679996073246*x_30 + 8.22175979614258) + 0.00163199803300666*std::sin(0.311679929494858*x_30 - 1.0311998128891) - 0.00119835656384852*std::sin(0.329039841890335*x_30 - 1.17311990261078) - 0.000769307213111385*std::sin(0.295199930667877*x_31 + 5.3310399055481) + 0.00232650221968405*std::sin(0.328239858150482*x_31 - 4.25680017471313) - 0.00237749822420142*std::sin(0.404639840126038*x_31 - 1.20063984394073) + 0.00105540332448238*std::sin(0.513359844684601*x_31 + 8.15312004089355) + 0.000550673395194108*std::sin(0.257599949836731*x_32 + 8.03176021575928) + 0.00381633324175955*std::sin(0.305119931697845*x_32 - 1.15055990219116) - 0.0012847338524122*std::sin(0.248399972915649*x_33 - 1.19327986240387) - 0.000554627180799748*std::sin(0.226879999041557*x_35 - 1.20903992652893) - 0.00150219014029392*std::sin(0.233999997377396*x_35 - 1.21071982383728) + 0.00542286277181969*std::sin(0.24975997209549*x_36 - 7.42927980422974) + 0.00527998234096641*std::sin(0.218239992856979*x_37 + 1.97247982025146) + 0.00159121717803389*std::sin(0.240559980273247*x_39 - 1.21007990837097) + 0.00215176633623641*std::sin(0.288719952106476*x_4 - 7.37999963760376) - 0.00680581283856565*std::sin(0.3713598549366*x_4 - 1.20103991031647) + 0.00267366812673063*std::sin(0.380799859762192*x_4 + 1.98911988735199) - 6.94982506575837e-5*std::sin(1.04431986808777*x_4 + 6.76743984222412) - 0.00349091699264424*std::sin(0.232239991426468*x_41 - 4.4125599861145) - 0.00107512222598534*std::sin(0.248079970479012*x_41 + 1.96991980075836) + 0.00215434821110591*std::sin(0.249439969658852*x_42 + 1.97775983810425) - 0.00141470950536325*std::sin(0.280639946460724*x_44 - 7.47559976577759) - 0.0064975410952313*std::sin(0.221519991755486*x_45 + 1.96543979644775) - 0.0170515534130824*std::sin(0.199280008673668*x_47 + 1.97479975223541) - 0.00260203212509651*std::sin(0.219679996371269*x_48 - 7.40263986587524) - 0.00290362920270338*std::sin(0.364319831132889*x_49 + 1.84487986564636) + 0.000567095891494013*std::sin(0.308079928159714*x_5 + 2.01263976097107) + 0.00148455220949436*std::sin(0.31399992108345*x_5 - 1.18407988548279) - 0.000987020406518111*std::sin(0.376479834318161*x_5 + 2.00879979133606) + 0.00411297426143758*std::sin(0.230079978704453*x_50 - 7.44495964050293) + 0.0183978904115233*std::sin(0.199359998106956*x_51 - 4.39431953430176) - 0.00302168141109206*std::sin(0.208000004291534*x_51 + 8.20343971252441) - 0.00284006622338991*std::sin(0.210879996418953*x_51 + 8.1988000869751) - 0.00143557012901202*std::sin(0.22639998793602*x_53 + 1.97503972053528) + 0.000590407882485234*std::sin(0.240399971604347*x_53 - 1.20711994171143) - 0.0114843400976074*std::sin(0.253679990768433*x_53 - 7.42943954467773) + 0.00533672110532921*std::sin(0.254559963941574*x_53 + 5.15840005874634) + 0.00436493635566331*std::sin(0.193759992718697*x_54 - 4.3953595161438) - 0.0125417485182548*std::sin(0.226559996604919*x_55 - 7.41791963577271) - 0.00427168133075286*std::sin(0.18792000412941*x_56 + 8.20448017120361) - 0.00148485881190199*std::sin(0.23471999168396*x_57 + 1.97623980045319) - 0.00223993223071708*std::sin(0.245999976992607*x_57 - 7.43856000900269) + 0.12815781859371*std::sin(0.0536801069974899*x_59 + 8.01991939544678) + 0.00226352995169009*std::sin(0.385519832372665*x_59 + 1.81727981567383) + 0.002240455936321*std::sin(0.24415996670723*x_6 - 1.15775990486145) + 0.00133186040587441*std::sin(0.397839844226837*x_6 + 1.98791980743408) - 0.00281375143999101*std::sin(0.355519831180573*x_60 + 8.25080013275146) + 0.002411319226324*std::sin(0.410879880189896*x_60 - 1.20055997371674) - 0.00724204652324748*std::sin(0.417359858751297*x_60 - 1.23583984375) - 0.000753827917806644*std::sin(0.490879863500595*x_60 - 7.56831979751587) + 2.71303607463289e-5*std::sin(1.03327977657318*x_64 - 4.59127998352051) + 0.00712292792725738*std::sin(0.312879920005798*x_7 - 7.39871978759766) - 0.00335257326354906*std::sin(0.350159853696823*x_7 + 2.01959991455078) - 0.00209472727200049*std::sin(0.366479843854904*x_7 + 2.00175976753235) - 0.00103430677292538*std::sin(0.429519861936569*x_7 + 8.19087982177734) + 0.00107891366862633*std::sin(0.355759829282761*x_8 - 1.14231991767883) - 0.000475216985402212*std::sin(0.494479864835739*x_8 - 1.44279980659485) - 0.0153465409763192*std::sin(0.312239944934845*x_9 - 7.42360019683838) - 0.00264609456477911*std::sin(0.365279853343964*x_91 + 1.97591972351074) - 0.00113658445443166*std::sin(0.373839855194092*x_91 + 5.19048023223877) + 0.00462868235410168*std::sin(0.263279944658279*x_92 - 7.39527988433838) - 0.0104263800953557*std::sin(0.292799949645996*x_92 - 1.16527986526489) + 0.00443868486434913*std::sin(0.236319988965988*x_93 + 1.98023986816406) + 0.0024308852501264*std::sin(0.236479982733727*x_93 - 1.18967986106873) + 0.00125585333110546*std::sin(0.2483199685812*x_93 - 1.21671986579895) - 0.00153416575120987*std::sin(0.291119933128357*x_94 + 1.8025598526001) + 0.000139071654735255*std::sin(0.337679862976074*x_94 + 1.8290399312973) - 0.00525096014501049*std::sin(0.267839968204498*x_95 + 1.96391975879669) - 0.00126936232890711*std::sin(0.285919934511185*x_95 - 1.22239983081818) + 0.0145634712818434*std::sin(0.276799947023392*x_97 + 1.95687973499298) - 0.000930615756719819*std::sin(0.277999937534332*x_97 + 8.18935966491699) + 0.00544083318625896*std::sin(0.279599964618683*x_97 - 1.20447981357574) - 0.00195181263282338*std::sin(0.291679948568344*x_97 + 8.16464042663574) - 0.0117858698392763*std::sin(0.230719983577728*x_98 + 5.18800020217896) + 0.00279096552160135*std::sin(0.232399985194206*x_98 + 1.98495984077454) + 0.0402606442629676);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-8.83869680131104e-5*x_1 - 1.06271940146686e-5*x_10 - 5.59022232754543e-5*x_100 - 0.000497983047927508*x_101 + 0.000631448848753622*x_102 - 0.000396771469029314*x_103 + 0.000478642723704917*x_104 - 0.000178770252810255*x_105 + 0.000527624543374899*x_106 - 0.000842758564253419*x_107 - 0.000542370207683524*x_108 - 0.000176947015054109*x_109 + 0.000156010725351297*x_11 + 0.000265086533189146*x_110 - 0.000327236990395118*x_111 - 0.000121936094549566*x_112 + 0.000110359243472102*x_113 - 0.000596198276758327*x_114 - 0.000778288711349479*x_115 + 5.64832701081807e-5*x_116 - 0.000620946711401549*x_117 - 0.000865036508437567*x_118 + 1.362565503297e-5*x_119 - 0.000231794284684317*x_12 + 0.000344860646315431*x_120 + 0.000103139823873795*x_13 - 0.000221814415847878*x_15 - 0.000457750787034875*x_16 - 0.000160881513995332*x_17 + 6.80100833655802e-5*x_18 + 0.000116256383315027*x_19 - 8.20170146739994e-5*x_2 - 0.000112308054708042*x_20 + 0.000109200756217394*x_21 - 1.61360605541004e-5*x_22 - 5.84228542184416e-5*x_23 + 6.18147910870057e-5*x_24 + 1.55725980685052e-5*x_25 - 6.12961023218425e-5*x_26 - 1.41445593665272e-5*x_27 - 3.64517216138893e-5*x_28 + 2.85429210768353e-6*x_29 + 0.000154741124477768*x_3 - 4.91612765432649e-5*x_30 - 2.01759836966592e-5*x_31 - 0.000110442091905666*x_32 - 6.90638387743583e-5*x_33 + 0.00040063911083918*x_34 - 0.000193859768771187*x_35 + 0.000110602029521768*x_36 - 0.000135174886925683*x_37 - 0.000528197278684496*x_38 + 0.000572660386768058*x_39 + 5.54549484164922e-5*x_4 - 3.44664932620362e-5*x_40 - 1.56683963093699e-5*x_41 - 7.82141876513445e-5*x_42 - 8.65251372339175e-5*x_43 - 0.00075829767316796*x_44 - 0.000530704513329205*x_45 - 0.000680459970892873*x_46 - 0.000116689970278758*x_47 - 1.35493608054645e-5*x_48 - 3.2870615119922e-5*x_5 - 0.000335406337196944*x_50 + 7.07948008797184e-5*x_51 - 0.000826124771511164*x_52 - 0.00014994307065945*x_53 - 0.000513493732675586*x_54 - 0.00121173189573291*x_55 - 0.000564084736807829*x_56 - 0.000171105765053826*x_57 + 0.000123420343583335*x_58 + 5.33896386666586e-5*x_59 - 4.91982230044437e-5*x_6 - 2.98501091917061e-6*x_60 - 7.69778519987018e-5*x_61 - 6.84474121126903e-5*x_62 + 0.000124438167025423*x_63 + 0.000107286505991731*x_64 + 0.000152648326343589*x_65 - 0.000181400131216182*x_66 - 6.53005934483397e-5*x_67 + 7.26997887517739e-5*x_68 - 7.36479462670449e-5*x_69 - 4.45469805285144e-6*x_7 + 0.000280658785007859*x_70 + 0.000208654033663716*x_71 - 3.93570667729333e-5*x_72 - 0.000189705042839257*x_73 + 2.20641778137987e-5*x_74 - 7.9973056378013e-5*x_75 - 0.000115397064803445*x_76 + 9.08136845744212e-5*x_77 + 3.23016945414544e-5*x_78 - 1.13779888635072e-5*x_79 - 0.000137707126481454*x_8 + 2.18629801621555e-5*x_80 + 0.000174136443546723*x_81 - 0.000100411072220556*x_82 - 0.000263859828047858*x_83 + 0.000238913106600151*x_84 - 0.000276212163368695*x_85 - 0.000296318384255839*x_86 - 0.000143740434828337*x_87 - 5.40770523553857e-5*x_88 + 0.000106326763240508*x_89 + 0.000181788930503693*x_9 + 0.0001306833950921*x_90 + 0.000134856087731916*x_91 - 5.266093279721e-5*x_92 + 1.81312143368818e-6*x_93 - 0.000321457190125709*x_94 + 7.06209816992989e-5*x_95 + 7.7654155543105e-5*x_96 - 1.50167691867457e-6*x_97 - 0.000376141984792594*x_98 - 0.000179759457451445*x_99 + 7.74246027483827e-8*std::pow(-9.91328048706055*x_10 - 9.80399990081787, 2) - 2.73166463042844e-6*std::pow(-2.00767993927002*x_29 - 7.99128007888794, 2) + 1.08279916774168e-6*std::pow(-5.30592012405396*x_30 - 9.79191970825195, 2) + 2.22337877729207e-6*std::pow(-2.82407999038696*x_43 - 9.27255916595459, 2) + 5.54784706450852e-6*std::pow(-1.9560798406601*x_49 - 6.25687980651855, 2) - 6.79482083452559e-6*std::pow(-2.78144001960754*x_57 - 8.74015998840332, 2) + 8.80735112915359e-6*std::pow(-1.45055985450745*x_58 - 3.72727990150452, 2) + 1.27577479468807e-6*std::pow(-3.40543985366821*x_61 - 6.01567983627319, 2) + 0.000366215183483937*std::exp(0.343279838562012*x_23) - 0.00267892280909297*std::exp(0.148799866437912*x_49) - 0.000151487925969889*std::exp(0.172799870371819*x_49) - 0.00773406519551041*std::exp(-0.011886504946094*x_10 + 0.0636871445881984*x_100 + 0.000456637933063231*x_101 - 0.0826967563513638*x_102 + 0.0106150868175821*x_103 - 0.0625380268496904*x_104 + 0.0518535289574122*x_105 - 0.000618043312355582*x_106 - 0.0182916323451397*x_107 + 9.77658623757714e-6*x_110 - 0.0851521490421603*x_111 + 0.00615700024226709*x_114 - 0.0761245189212714*x_115 + 0.00139611232041446*x_116 + 0.0672501204904332*x_117 + 0.0702258413784276*x_118 - 0.000344090130127828*x_119 - 0.0309126734734656*x_120 - 0.00256939358981492*x_13 - 0.0448971746899984*x_17 - 0.0811965689979465*x_18 + 0.00692800605662681*x_2 + 0.0152753569988568*x_20 - 0.0851522079288944*x_21 - 0.0563764869493173*x_24 - 0.000836295671515427*x_26 - 0.00723389961720244*x_28 - 0.00946978050654777*x_3 - 0.0382664703093935*x_32 - 0.0154849868274768*x_34 - 0.00112556678435483*x_36 - 0.0156688940711186*x_37 - 0.00471819727772073*x_38 - 0.00123603995759818*x_39 + 0.100721071291616*x_40 - 0.0702120976555099*x_41 - 0.002148319086568*x_42 - 0.000667224007987739*x_43 - 0.0973546437516174*x_45 - 0.0751048399070298*x_46 - 0.0171614807985125*x_47 + 0.0815886322782478*x_48 - 0.00236264589530642*x_49 - 0.109600150043205*x_50 + 0.00389062627278826*x_51 - 0.00508007347357674*x_52 - 0.134023764207445*x_54 + 0.109780775262186*x_55 - 0.00973069595154141*x_56 - 0.105466990719234*x_58 + 0.137035217501863*x_59 + 0.000640751109630697*x_6 + 0.00142722250767905*x_61 + 0.000181805962555342*x_62 - 0.0412354211868321*x_63 + 0.0275700610798519*x_64 + 0.0358706747585825*x_65 - 0.000680245109673204*x_66 + 0.000585162185609764*x_67 + 0.0593596091165854*x_68 - 0.0328401615080865*x_69 - 0.0759554109979122*x_70 - 0.00169066315061401*x_71 + 0.0416307876523577*x_72 + 0.0354188857400592*x_73 - 0.0621822903839562*x_74 + 0.000993058229057627*x_75 - 0.00162858065314445*x_76 - 0.0214010341127158*x_77 - 0.0517494223416697*x_78 - 0.00683339165283642*x_79 - 0.00554295152457946*x_8 + 0.0522536992816092*x_80 + 0.0408867238827574*x_81 + 2.44476865417605e-5*x_82 - 0.0485138125617927*x_83 + 0.0412481428469887*x_84 - 0.0395673958408619*x_85 + 6.66898035846906e-5*x_86 - 0.0365046916670126*x_87 + 0.0169547605669544*x_88 + 0.000862517176260456*x_89 - 0.00949648992545713*x_9 + 0.0501324532903459*x_90 - 0.000474101643280174*x_92 - 0.00438555349952656*x_96 - 0.00492911162260839*x_98 - 0.0237125276698068*x_99 + 0.000164059702881081*std::pow(-8.66760063171387*x_23 - 8.67360019683838, 2) - 0.600324536331016*std::sin(0.437119841575623*x_1 - 7.18616008758545) + 0.42631723367154*std::sin(0.257359951734543*x_108 - 7.42712020874023) + 0.637138521608051*std::sin(0.243679970502853*x_109 - 7.43919992446899) + 0.382668777102964*std::sin(0.37407985329628*x_11 + 5.032639503479) - 0.154325202966348*std::sin(0.297039926052094*x_112 - 1.24703979492188) - 0.23139409155651*std::sin(0.182320013642311*x_113 - 0.98695981502533) + 0.417508648899968*std::sin(0.357359826564789*x_12 - 1.35935986042023) + 0.477045050433588*std::sin(0.405359864234924*x_14 - 7.59216022491455) - 0.831669844897363*std::sin(0.282559931278229*x_15 - 7.42799949645996) - 0.610430458164274*std::sin(0.194240003824234*x_16 + 8.20448017120361) - 0.505226103877362*std::sin(0.322959929704666*x_19 + 1.99087977409363) + 0.774184037636758*std::sin(0.400479853153229*x_22 + 2.00727987289429) + 0.650858793123689*std::sin(0.349199831485748*x_25 + 2.03151988983154) - 0.643895691937246*std::sin(0.298239946365356*x_27 + 5.1923999786377) + 0.294851500679499*std::sin(0.232639983296394*x_29 - 1.37055993080139) - 0.720871593826018*std::sin(0.311679929494858*x_30 - 1.0311998128891) + 0.339811510578699*std::sin(0.295199930667877*x_31 + 5.3310399055481) + 0.567481161802874*std::sin(0.248399972915649*x_33 - 1.19327986240387) + 0.244984964268468*std::sin(0.226879999041557*x_35 - 1.20903992652893) - 0.950459006060328*std::sin(0.288719952106476*x_4 - 7.37999963760376) + 0.62489284625741*std::sin(0.280639946460724*x_44 - 7.47559976577759) + 0.435977837715086*std::sin(0.376479834318161*x_5 + 2.00879979133606) - 0.260789696217017*std::sin(0.240399971604347*x_53 - 1.20711994171143) + 0.65587857135489*std::sin(0.23471999168396*x_57 + 1.97623980045319) + 0.332974134520668*std::sin(0.490879863500595*x_60 - 7.56831979751587) + 0.456864749113777*std::sin(0.429519861936569*x_7 + 8.19087982177734) + 0.502041933025225*std::sin(0.373839855194092*x_91 + 5.19048023223877) - 0.554724315897516*std::sin(0.2483199685812*x_93 - 1.21671986579895) - 0.0614294891154543*std::sin(0.337679862976074*x_94 + 1.8290399312973) + 0.56069138974155*std::sin(0.285919934511185*x_95 - 1.22239983081818) + 0.411063279623136*std::sin(0.277999937534332*x_97 + 8.18935966491699)) + 0.000439650974901758*std::log(6.24751996994019 - 0.6004798412323*x_15) + 0.00174960444618536*std::sin(0.273519963026047*x_1 - 4.31824016571045) + 0.000437733454984979*std::sin(0.381679862737656*x_1 - 4.22352027893066) + 0.000385413268196352*std::sin(0.338639855384827*x_10 - 4.34327983856201) + 0.000964084317273913*std::sin(0.356239855289459*x_10 - 1.16279983520508) - 0.00084222315578144*std::sin(0.249999970197678*x_100 - 1.20175993442535) - 0.00123714147342603*std::sin(0.253279983997345*x_100 + 8.16903972625732) - 0.000134086722375886*std::sin(0.220319986343384*x_101 + 4.9814395904541) - 0.000510593630793712*std::sin(0.241359978914261*x_102 - 1.21223986148834) - 0.000356124193472045*std::sin(0.183360010385513*x_104 - 1.39951992034912) - 0.000690801248479034*std::sin(0.250479966402054*x_106 - 7.61360025405884) - 0.000687303871318394*std::sin(0.247279971837997*x_108 + 1.95583975315094) - 0.000238775637527701*std::sin(0.287599951028824*x_109 + 4.77304029464722) - 0.00213984150407955*std::sin(0.243759974837303*x_11 - 7.41639995574951) + 0.0041450930507742*std::sin(0.233999982476234*x_110 - 1.21967995166779) + 0.000318914235003417*std::sin(0.284559935331345*x_110 + 7.94407987594604) + 0.00217573824240453*std::sin(0.248159974813461*x_112 + 1.98031985759735) + 0.00145095764168925*std::sin(0.270559966564178*x_113 + 1.98671984672546) + 0.000898155461389505*std::sin(0.282879948616028*x_113 + 1.97383987903595) + 0.00106330772562684*std::sin(0.219999983906746*x_116 - 4.20359992980957) - 0.000731016435767153*std::sin(0.239839985966682*x_116 + 4.99567985534668) - 0.000365869829637288*std::sin(0.253439962863922*x_119 - 1.2267199754715) - 0.000403364671818527*std::sin(0.303039938211441*x_12 + 5.12728023529053) - 0.000595984573860938*std::sin(0.38087984919548*x_13 - 7.3758397102356) - 0.00111420625444086*std::sin(0.442479848861694*x_13 + 1.92767989635468) + 0.0126706380996471*std::sin(0.111040063202381*x_14 + 8.12263965606689) + 0.000524178399918088*std::sin(0.260159969329834*x_14 + 2.13895988464355) - 0.00039744419325859*std::sin(0.313599914312363*x_14 - 7.46143960952759) - 0.0010782667087059*std::sin(0.378799855709076*x_14 + 5.03047943115234) - 0.000494779059864372*std::sin(0.252079963684082*x_15 - 7.4113597869873) - 0.00233370556593899*std::sin(0.290639936923981*x_15 + 5.16328001022339) + 0.00075604272501316*std::sin(0.337679862976074*x_16 - 1.15767979621887) - 0.000627548356551881*std::sin(0.447039842605591*x_16 - 1.24167990684509) - 0.000433219348900901*std::sin(0.315039932727814*x_17 + 1.82631993293762) + 0.000976540863077532*std::sin(0.345279842615128*x_17 - 1.17911994457245) + 0.000933974519536981*std::sin(0.178240016102791*x_18 + 1.95119976997375) + 0.000443908991325896*std::sin(0.443679869174957*x_18 + 1.94863975048065) - 0.00137704593037459*std::sin(0.390159845352173*x_19 - 1.16807985305786) - 0.00121842719794636*std::sin(0.367999851703644*x_2 - 7.41447973251343) - 0.00066393787668634*std::sin(0.404399842023849*x_2 + 1.97687971591949) + 0.000371740203731058*std::sin(0.405919849872589*x_2 + 2.01239991188049) - 0.00336686976041665*std::sin(0.269759953022003*x_21 - 1.17471981048584) - 0.000908463877467614*std::sin(0.298719942569733*x_21 - 7.41016006469727) + 0.000642954616719919*std::sin(0.315119922161102*x_22 - 4.36552000045776) - 0.000410793953676143*std::sin(0.398959845304489*x_22 - 1.17631983757019) + 0.00106281132443134*std::sin(0.273519963026047*x_23 - 4.36448001861572) - 0.000397338253723705*std::sin(0.422159850597382*x_23 + 5.19608020782471) - 0.000630318153169422*std::sin(0.388799846172333*x_24 + 5.20887994766235) - 0.000825889935338354*std::sin(0.24551996588707*x_25 - 7.39271974563599) - 0.00133825299158088*std::sin(0.342239856719971*x_25 - 1.15543985366821) + 0.00291921611523725*std::sin(0.369199842214584*x_26 - 1.15751981735229) - 0.000609868298776812*std::sin(0.442559868097305*x_26 - 7.44799947738647) - 0.00175324910157982*std::sin(0.319439917802811*x_27 + 1.80935990810394) - 0.000541085073042219*std::sin(0.369999825954437*x_27 - 4.38503980636597) + 0.00127372936573741*std::sin(0.234079986810684*x_28 - 1.18439984321594) + 0.00234058139505025*std::sin(0.31687992811203*x_28 + 1.99743974208832) - 9.70717109011414e-5*std::sin(0.685199856758118*x_28 + 4.94039964675903) - 0.00172042815597929*std::sin(0.278799951076508*x_29 - 1.16959989070892) + 0.00446614497918037*std::sin(0.350799858570099*x_3 - 4.20911979675293) - 0.000454543086674715*std::sin(0.458639860153198*x_3 - 4.39296007156372) + 0.000182252957792445*std::sin(0.554639875888824*x_3 + 8.19847965240479) + 0.000392616635604684*std::sin(0.24679996073246*x_30 + 8.22175979614258) + 0.00160480581973758*std::sin(0.329039841890335*x_30 - 1.17311990261078) - 0.000455191842918049*std::sin(0.328239858150482*x_31 - 4.25680017471313) + 0.000169175925694277*std::sin(0.404639840126038*x_31 - 1.20063984394073) - 0.000530206464042896*std::sin(0.513359844684601*x_31 + 8.15312004089355) - 0.000276643617596677*std::sin(0.257599949836731*x_32 + 8.03176021575928) - 0.00074668476428183*std::sin(0.305119931697845*x_32 - 1.15055990219116) + 0.00201169130475997*std::sin(0.233999997377396*x_35 - 1.21071982383728) - 0.00272430153339391*std::sin(0.24975997209549*x_36 - 7.42927980422974) - 0.00265252221806838*std::sin(0.218239992856979*x_37 + 1.97247982025146) - 0.000311329631935819*std::sin(0.240559980273247*x_39 - 1.21007990837097) + 0.000484282038718695*std::sin(0.3713598549366*x_4 - 1.20103991031647) - 0.0013431795130959*std::sin(0.380799859762192*x_4 + 1.98911988735199) + 1.35976817596599e-5*std::sin(1.04431986808777*x_4 + 6.76743984222412) + 0.00068301544091003*std::sin(0.232239991426468*x_41 - 4.4125599861145) + 0.00143977381794406*std::sin(0.248079970479012*x_41 + 1.96991980075836) - 0.000421509046586542*std::sin(0.249439969658852*x_42 + 1.97775983810425) + 0.00326419124249548*std::sin(0.221519991755486*x_45 + 1.96543979644775) + 0.00121333942705786*std::sin(0.199280008673668*x_47 + 1.97479975223541) + 0.00348456913699259*std::sin(0.219679996371269*x_48 - 7.40263986587524) + 0.000206613890702391*std::sin(0.364319831132889*x_49 + 1.84487986564636) - 0.000759439063859384*std::sin(0.308079928159714*x_5 + 2.01263976097107) - 0.000290460095172216*std::sin(0.31399992108345*x_5 - 1.18407988548279) - 0.00206624850355271*std::sin(0.230079978704453*x_50 - 7.44495964050293) - 0.00130914088999447*std::sin(0.199359998106956*x_51 - 4.39431953430176) + 0.000591207142889809*std::sin(0.208000004291534*x_51 + 8.20343971252441) + 0.00380333778879557*std::sin(0.210879996418953*x_51 + 8.1988000869751) + 0.000280876505139042*std::sin(0.22639998793602*x_53 + 1.97503972053528) + 0.000817192562847543*std::sin(0.253679990768433*x_53 - 7.42943954467773) - 0.00268102625906305*std::sin(0.254559963941574*x_53 + 5.15840005874634) - 0.00219282753542925*std::sin(0.193759992718697*x_54 - 4.3953595161438) + 0.000892434700393208*std::sin(0.226559996604919*x_55 - 7.41791963577271) + 0.00572051697004193*std::sin(0.18792000412941*x_56 + 8.20448017120361) + 0.000438253989824308*std::sin(0.245999976992607*x_57 - 7.43856000900269) - 0.00911934123645147*std::sin(0.0536801069974899*x_59 + 8.01991939544678) - 0.00303125643002008*std::sin(0.385519832372665*x_59 + 1.81727981567383) - 0.00300035634963824*std::sin(0.24415996670723*x_6 - 1.15775990486145) - 0.000260585176979494*std::sin(0.397839844226837*x_6 + 1.98791980743408) + 0.00141355363119111*std::sin(0.355519831180573*x_60 + 8.25080013275146) - 0.00322917172099626*std::sin(0.410879880189896*x_60 - 1.20055997371674) + 0.000515323171230944*std::sin(0.417359858751297*x_60 - 1.23583984375) - 3.63322254250134e-5*std::sin(1.03327977657318*x_64 - 4.59127998352051) - 0.000506847035039172*std::sin(0.312879920005798*x_7 - 7.39871978759766) + 0.00168424333548779*std::sin(0.350159853696823*x_7 + 2.01959991455078) + 0.00280520057074963*std::sin(0.366479843854904*x_7 + 2.00175976753235) - 0.00144485121260188*std::sin(0.355759829282761*x_8 - 1.14231991767883) + 9.29785897219426e-5*std::sin(0.494479864835739*x_8 - 1.44279980659485) + 0.00109201565302789*std::sin(0.312239944934845*x_9 - 7.42360019683838) + 0.00132932729144353*std::sin(0.365279853343964*x_91 + 1.97591972351074) - 0.00232532648629815*std::sin(0.263279944658279*x_92 - 7.39527988433838) + 0.000741911176343641*std::sin(0.292799949645996*x_92 - 1.16527986526489) - 0.00222987681802264*std::sin(0.236319988965988*x_93 + 1.98023986816406) - 0.00325537399652466*std::sin(0.236479982733727*x_93 - 1.18967986106873) + 0.0020545121546102*std::sin(0.291119933128357*x_94 + 1.8025598526001) + 0.000373643199508294*std::sin(0.267839968204498*x_95 + 1.96391975879669) - 0.00103629466905509*std::sin(0.276799947023392*x_97 + 1.95687973499298) - 0.00273332939002105*std::sin(0.279599964618683*x_97 - 1.20447981357574) + 0.00261381325615892*std::sin(0.291679948568344*x_97 + 8.16464042663574) + 0.00083864855076456*std::sin(0.230719983577728*x_98 + 5.18800020217896) - 0.000546066420461435*std::sin(0.232399985194206*x_98 + 1.98495984077454) + 0.0551828434611067);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000453123194145174*x_1 - 1.10429059777748e-5*x_10 - 5.50225396331111e-5*x_100 + 0.000512505858707925*x_101 + 0.000432063418418037*x_102 - 0.00243367931236166*x_103 + 0.000247962717962321*x_104 + 0.000866960053486636*x_105 + 0.000281708951958153*x_106 + 0.000678967596238791*x_107 - 0.000573876849822776*x_108 + 0.00231005720902518*x_109 - 6.0360236165002e-5*x_11 - 4.75714052220118e-5*x_110 + 0.000807685149437051*x_111 - 1.91949817273651e-5*x_112 + 7.30297048723307e-5*x_113 - 0.00271342264961035*x_114 - 0.00231313732179501*x_115 + 7.13151100508431e-5*x_116 + 0.000793516107435447*x_117 - 0.000769030558851475*x_118 - 0.000960540270068854*x_119 + 0.000605087085957606*x_12 - 0.0030969534602772*x_120 + 0.000280268270233326*x_13 + 4.21892399804963e-5*x_15 - 0.000690299721591498*x_16 - 0.000364128823305492*x_17 - 5.52846468059317e-5*x_18 - 0.00158627516458918*x_19 - 8.52253360927275e-5*x_2 + 0.00151519611471242*x_20 - 0.00080345603022066*x_21 - 8.94304319074954e-5*x_22 + 0.000794144413366937*x_23 - 0.000712136186056428*x_24 + 0.000123164947356224*x_25 + 0.000464888949325707*x_26 - 6.8074256813356e-5*x_27 + 0.000495489846645311*x_28 + 0.000146759801970348*x_29 - 2.94318582067345e-5*x_3 + 9.350505402921e-6*x_30 - 2.09652228672775e-5*x_31 + 0.000498530373878745*x_32 - 0.000516140932337966*x_33 + 3.63542195781821e-5*x_34 + 0.00192432249598786*x_35 - 0.00289474602836771*x_36 - 0.0021465352898451*x_37 + 0.00160131509444214*x_38 + 0.000456884171835719*x_39 + 5.76242214568032e-5*x_4 + 0.0013055351871419*x_40 + 0.00133121112638158*x_41 - 0.000400115786429885*x_42 - 0.0026710482028938*x_43 - 0.000904364071632337*x_44 - 0.00062713118938417*x_45 + 0.00100598331876718*x_46 - 0.000214023792213363*x_47 - 0.00108121037604443*x_48 + 0.000482037745362288*x_5 + 0.000887599807443114*x_50 - 1.34652151992423e-5*x_51 - 0.00111755953931708*x_52 - 0.000155808506838744*x_53 - 0.00116724041578209*x_54 - 0.000673907477029198*x_55 + 0.00148536648539508*x_56 - 0.000139280620766533*x_57 + 0.000641376718947147*x_58 + 0.000495152836975728*x_59 + 5.87027558235259e-5*x_6 - 1.78651865025776e-5*x_60 + 7.04885665595054e-5*x_61 + 1.95410769882835e-5*x_62 + 0.000912819991386003*x_63 - 7.38585653771801e-5*x_64 - 0.000585775456027886*x_65 + 5.09324284090074e-5*x_66 + 0.000164948284017117*x_67 + 9.71903145461791e-6*x_68 + 6.4719122473975e-5*x_69 - 2.66612128671787e-5*x_7 - 0.000247783463148163*x_70 + 0.000303474946266194*x_71 + 0.000207059274035894*x_72 + 0.000536750823297157*x_73 - 0.000668520995957961*x_74 - 0.000283708113955973*x_75 - 0.000782263600349883*x_76 - 0.000490094668219722*x_77 - 0.000191163997452817*x_78 - 0.00110200931389445*x_79 + 0.00198452946663845*x_8 + 0.000663822354063319*x_80 - 0.000645412710075868*x_81 + 0.000713035909998843*x_82 + 7.22923144380068e-5*x_83 - 0.000402520383678305*x_84 + 8.41520137472902e-6*x_85 + 0.00093912333169388*x_86 + 0.000448337301292029*x_87 - 0.000892707056751986*x_88 + 0.000206812932928236*x_89 + 0.000133071210954459*x_9 + 1.6542136779738e-5*x_90 - 0.000142512105314108*x_91 - 7.42346138929515e-5*x_92 - 5.00631206462231e-5*x_93 + 0.000677190986751163*x_94 - 0.00011020601143322*x_95 - 0.000771641458227434*x_96 - 8.98748411486256e-6*x_97 + 0.000127070140790273*x_98 - 0.000923660996851473*x_99 - 1.05243601245305e-6*std::pow(-9.91328048706055*x_10 - 9.80399990081787, 2) + 3.71316368306093e-5*std::pow(-2.00767993927002*x_29 - 7.99128007888794, 2) - 1.47185364591276e-5*std::pow(-5.30592012405396*x_30 - 9.79191970825195, 2) - 4.2288802756196e-7*std::pow(-2.82407999038696*x_43 - 9.27255916595459, 2) - 1.05520396537329e-6*std::pow(-1.9560798406601*x_49 - 6.25687980651855, 2) - 7.06061896563873e-6*std::pow(-2.78144001960754*x_57 - 8.74015998840332, 2) - 0.000119718709216547*std::pow(-1.45055985450745*x_58 - 3.72727990150452, 2) + 7.63546776194804e-6*std::pow(-3.40543985366821*x_61 - 6.01567983627319, 2) + 0.00117250462062657*std::pow(0.0271233094446853*x_10 - 0.145324983092003*x_100 - 0.00104198265333878*x_101 + 0.188702206642067*x_102 - 0.024222114561109*x_103 + 0.142702860260163*x_104 - 0.118322359523605*x_105 + 0.00141028671483011*x_106 + 0.0417388968915266*x_107 - 2.23087757954952e-5*x_110 + 0.194305062659267*x_111 - 0.0140493966543874*x_114 + 0.173705297931831*x_115 - 0.00318572924992409*x_116 - 0.153455186072487*x_117 - 0.160245356844477*x_118 + 0.000785164614715949*x_119 + 0.0705383131699149*x_120 + 0.00586298981389326*x_13 + 0.102448950960062*x_17 + 0.185278993006413*x_18 - 0.0158087219885684*x_2 - 0.0348561866281963*x_20 + 0.194305197030398*x_21 + 0.128643104753267*x_24 + 0.00190830747882856*x_26 + 0.0165067274778401*x_28 + 0.0216086888633103*x_3 + 0.0873186290052914*x_32 + 0.0353345320069502*x_34 + 0.00256838291248493*x_36 + 0.0357541821144492*x_37 + 0.0107662534416178*x_38 + 0.00282046694196245*x_39 - 0.229831123331204*x_40 + 0.160213995628434*x_41 + 0.00490215783656871*x_42 + 0.00152251004981254*x_43 + 0.222149415688413*x_45 + 0.171378535812693*x_46 + 0.0391600522052563*x_47 - 0.186173625509553*x_48 + 0.00539122105423172*x_49 + 0.250091915015158*x_50 - 0.00887785440792127*x_51 + 0.0115920033222918*x_52 + 0.305823120086668*x_54 - 0.250504076010349*x_55 + 0.0222040607060474*x_56 + 0.240660634766115*x_58 - 0.312694827115197*x_59 - 0.00146210267041111*x_6 - 0.00325671826140276*x_61 - 0.000414855283671744*x_62 + 0.094093351578498*x_63 - 0.0629109482954809*x_64 - 0.0818517651638558*x_65 + 0.00155222234723952*x_66 - 0.00133525667196542*x_67 - 0.135450164189245*x_68 + 0.0749365660332288*x_69 + 0.17331941776305*x_70 + 0.0038578522457856*x_71 - 0.094995521479334*x_72 - 0.0808208470421126*x_73 + 0.141891120368191*x_74 - 0.00226601728308474*x_75 + 0.00371618883861904*x_76 + 0.0488341083697779*x_77 + 0.118084803070566*x_78 + 0.0155928254097532*x_79 + 0.0126482250350186*x_8 - 0.119235491144969*x_80 - 0.0932976740497512*x_81 - 5.57861348046414e-5*x_82 + 0.110701602903666*x_83 - 0.0941223805930523*x_84 + 0.0902871555750888*x_85 - 0.000152176622786604*x_86 + 0.0832985013473258*x_87 - 0.0386883461121319*x_88 - 0.00196814121385244*x_89 + 0.0216696359488877*x_9 - 0.114395110251657*x_90 + 0.00108183234998338*x_92 + 0.0100072077699315*x_96 + 0.0112475299033409*x_98 + 0.0541086070817798*x_99 - 0.00037436084945297*std::pow(-8.66760063171387*x_23 - 8.67360019683838, 2) + 1.36985499438117*std::sin(0.437119841575623*x_1 - 7.18616008758545) - 0.972795140616597*std::sin(0.257359951734543*x_108 - 7.42712020874023) - 1.45385925964581*std::sin(0.243679970502853*x_109 - 7.43919992446899) - 0.873195586360623*std::sin(0.37407985329628*x_11 + 5.032639503479) + 0.352148108645309*std::sin(0.297039926052094*x_112 - 1.24703979492188) + 0.528008323508203*std::sin(0.182320013642311*x_113 - 0.98695981502533) - 0.95269520614363*std::sin(0.357359826564789*x_12 - 1.35935986042023) - 1.08854878542053*std::sin(0.405359864234924*x_14 - 7.59216022491455) + 1.89775200206157*std::sin(0.282559931278229*x_15 - 7.42799949645996) + 1.39291526704756*std::sin(0.194240003824234*x_16 + 8.20448017120361) + 1.15285393117188*std::sin(0.322959929704666*x_19 + 1.99087977409363) - 1.76657758653084*std::sin(0.400479853153229*x_22 + 2.00727987289429) - 1.48516696293382*std::sin(0.349199831485748*x_25 + 2.03151988983154) + 1.46927815886306*std::sin(0.298239946365356*x_27 + 5.1923999786377) - 0.672809083025527*std::sin(0.232639983296394*x_29 - 1.37055993080139) + 1.64492619133193*std::sin(0.311679929494858*x_30 - 1.0311998128891) - 0.775401414973601*std::sin(0.295199930667877*x_31 + 5.3310399055481) - 1.29491109669431*std::sin(0.248399972915649*x_33 - 1.19327986240387) - 0.559020757176597*std::sin(0.226879999041557*x_35 - 1.20903992652893) + 2.16881193023301*std::sin(0.288719952106476*x_4 - 7.37999963760376) - 1.42591637455041*std::sin(0.280639946460724*x_44 - 7.47559976577759) - 0.994839261582683*std::sin(0.376479834318161*x_5 + 2.00879979133606) + 0.595084901958842*std::sin(0.240399971604347*x_53 - 1.20711994171143) - 1.49662138111023*std::sin(0.23471999168396*x_57 + 1.97623980045319) - 0.759799497719314*std::sin(0.490879863500595*x_60 - 7.56831979751587) - 1.04250021522546*std::sin(0.429519861936569*x_7 + 8.19087982177734) - 1.14558810730364*std::sin(0.373839855194092*x_91 + 5.19048023223877) + 1.26580179327851*std::sin(0.2483199685812*x_93 - 1.21671986579895) + 0.140173335211955*std::sin(0.337679862976074*x_94 + 1.8290399312973) - 1.27941780497287*std::sin(0.285919934511185*x_95 - 1.22239983081818) - 0.937987792469585*std::sin(0.277999937534332*x_97 + 8.18935966491699) - 6.49738562219548, 2) + 0.00038054069900904*std::exp(0.343279838562012*x_23) - 0.00278371625301061*std::exp(0.148799866437912*x_49) - 0.00090664996665831*std::exp(0.172799870371819*x_49) - 0.00597619493638755*std::log(6.24751996994019 - 0.6004798412323*x_15) - 0.000332775854846514*std::sin(0.273519963026047*x_1 - 4.31824016571045) + 0.00261981949931934*std::sin(0.381679862737656*x_1 - 4.22352027893066) + 0.00230668500161096*std::sin(0.338639855384827*x_10 - 4.34327983856201) - 0.00018336943731735*std::sin(0.356239855289459*x_10 - 1.16279983520508) + 0.0114483762034511*std::sin(0.249999970197678*x_100 - 1.20175993442535) + 0.000235305078403879*std::sin(0.253279983997345*x_100 + 8.16903972625732) - 0.000802504368536826*std::sin(0.220319986343384*x_101 + 4.9814395904541) + 0.00694052156163867*std::sin(0.241359978914261*x_102 - 1.21223986148834) + 0.00484081174215138*std::sin(0.183360010385513*x_104 - 1.39951992034912) + 0.00939009159284385*std::sin(0.250479966402054*x_106 - 7.61360025405884) + 0.00934255159209046*std::sin(0.247279971837997*x_108 + 1.95583975315094) - 0.00142906388358857*std::sin(0.287599951028824*x_109 + 4.77304029464722) - 0.00222354729802377*std::sin(0.243759974837303*x_11 - 7.41639995574951) + 0.00430723978179434*std::sin(0.233999982476234*x_110 - 1.21967995166779) - 0.00433501514876707*std::sin(0.284559935331345*x_110 + 7.94407987594604) - 0.000413826768168666*std::sin(0.248159974813461*x_112 + 1.98031985759735) + 0.0015077158460448*std::sin(0.270559966564178*x_113 + 1.98671984672546) - 0.0122086664805968*std::sin(0.282879948616028*x_113 + 1.97383987903595) - 0.00020224179135567*std::sin(0.219999983906746*x_116 - 4.20359992980957) + 0.00993673839304903*std::sin(0.239839985966682*x_116 + 4.99567985534668) - 0.00218971820175203*std::sin(0.253439962863922*x_119 - 1.2267199754715) - 0.00241412352775957*std::sin(0.303039938211441*x_12 + 5.12728023529053) + 0.00810124438656985*std::sin(0.38087984919548*x_13 - 7.3758397102356) + 0.000211922723221981*std::sin(0.442479848861694*x_13 + 1.92767989635468) + 0.0131662850061534*std::sin(0.111040063202381*x_14 + 8.12263965606689) - 0.00712517992267434*std::sin(0.260159969329834*x_14 + 2.13895988464355) - 0.00237868966955205*std::sin(0.313599914312363*x_14 - 7.46143960952759) + 0.000205086999249729*std::sin(0.378799855709076*x_14 + 5.03047943115234) - 0.00296123545990345*std::sin(0.252079963684082*x_15 - 7.4113597869873) - 0.00242499488659968*std::sin(0.290639936923981*x_15 + 5.16328001022339) - 0.000143799796957127*std::sin(0.337679862976074*x_16 - 1.15767979621887) - 0.00375585508152864*std::sin(0.447039842605591*x_16 - 1.24167990684509) + 0.00588876956277693*std::sin(0.315039932727814*x_17 + 1.82631993293762) - 0.000185738680083778*std::sin(0.345279842615128*x_17 - 1.17911994457245) - 0.0126955565050644*std::sin(0.178240016102791*x_18 + 1.95119976997375) + 0.00265677986947255*std::sin(0.443679869174957*x_18 + 1.94863975048065) - 0.00143091287457579*std::sin(0.390159845352173*x_19 - 1.16807985305786) + 0.00023174561155744*std::sin(0.367999851703644*x_2 - 7.41447973251343) + 0.00902493660480438*std::sin(0.404399842023849*x_2 + 1.97687971591949) + 0.00222485218647268*std::sin(0.405919849872589*x_2 + 2.01239991188049) - 0.00349857414406617*std::sin(0.269759953022003*x_21 - 1.17471981048584) + 0.000172790395040774*std::sin(0.298719942569733*x_21 - 7.41016006469727) + 0.000668105557366709*std::sin(0.315119922161102*x_22 - 4.36552000045776) - 0.00245858752121236*std::sin(0.398959845304489*x_22 - 1.17631983757019) - 0.000202147375539262*std::sin(0.273519963026047*x_23 - 4.36448001861572) - 0.0023780556251214*std::sin(0.422159850597382*x_23 + 5.19608020782471) + 0.00856794223218994*std::sin(0.388799846172333*x_24 + 5.20887994766235) + 0.0112263580233967*std::sin(0.24551996588707*x_25 - 7.39271974563599) + 0.000254536552101932*std::sin(0.342239856719971*x_25 - 1.15543985366821) + 0.00303340929363613*std::sin(0.369199842214584*x_26 - 1.15751981735229) + 0.00828996646675854*std::sin(0.442559868097305*x_26 - 7.44799947738647) - 0.00182183226895457*std::sin(0.319439917802811*x_27 + 1.80935990810394) + 0.00735499307011059*std::sin(0.369999825954437*x_27 - 4.38503980636597) - 0.00024226411829858*std::sin(0.234079986810684*x_28 - 1.18439984321594) + 0.00243213968270391*std::sin(0.31687992811203*x_28 + 1.99743974208832) - 0.000580970812614326*std::sin(0.685199856758118*x_28 + 4.94039964675903) + 0.000327226506286188*std::sin(0.278799951076508*x_29 - 1.16959989070892) + 0.00464085054061544*std::sin(0.350799858570099*x_3 - 4.20911979675293) + 0.00617862406324107*std::sin(0.458639860153198*x_3 - 4.39296007156372) + 0.00109077761179953*std::sin(0.554639875888824*x_3 + 8.19847965240479) + 0.00234979690494436*std::sin(0.24679996073246*x_30 + 8.22175979614258) + 0.00166758221930332*std::sin(0.329039841890335*x_30 - 1.17311990261078) - 0.00272430734372069*std::sin(0.328239858150482*x_31 - 4.25680017471313) - 0.00229961575933894*std::sin(0.404639840126038*x_31 - 1.20063984394073) + 0.000100845599530632*std::sin(0.513359844684601*x_31 + 8.15312004089355) + 5.2617788285966e-5*std::sin(0.257599949836731*x_32 + 8.03176021575928) - 0.00446888233703162*std::sin(0.305119931697845*x_32 - 1.15055990219116) + 0.00209038415070888*std::sin(0.233999997377396*x_35 - 1.21071982383728) + 0.000518163847612204*std::sin(0.24975997209549*x_36 - 7.42927980422974) + 0.000504511377152477*std::sin(0.218239992856979*x_37 + 1.97247982025146) - 0.00186329701596456*std::sin(0.240559980273247*x_39 - 1.21007990837097) - 0.00658286693944172*std::sin(0.3713598549366*x_4 - 1.20103991031647) + 0.000255473579560999*std::sin(0.380799859762192*x_4 + 1.98911988735199) + 8.13816522676299e-5*std::sin(1.04431986808777*x_4 + 6.76743984222412) + 0.00408782365170991*std::sin(0.232239991426468*x_41 - 4.4125599861145) + 0.00149609453623153*std::sin(0.248079970479012*x_41 + 1.96991980075836) - 0.00252271697950256*std::sin(0.249439969658852*x_42 + 1.97775983810425) - 0.00062085120638111*std::sin(0.221519991755486*x_45 + 1.96543979644775) - 0.0164929759150946*std::sin(0.199280008673668*x_47 + 1.97479975223541) + 0.00362087765592234*std::sin(0.219679996371269*x_48 - 7.40263986587524) - 0.00280851165558969*std::sin(0.364319831132889*x_49 + 1.84487986564636) - 0.000789146614475358*std::sin(0.308079928159714*x_5 + 2.01263976097107) - 0.00173839356448648*std::sin(0.31399992108345*x_5 - 1.18407988548279) + 0.000393001751678352*std::sin(0.230079978704453*x_50 - 7.44495964050293) + 0.0177952093920663*std::sin(0.199359998106956*x_51 - 4.39431953430176) + 0.00353835418207353*std::sin(0.208000004291534*x_51 + 8.20343971252441) + 0.00395211582148735*std::sin(0.210879996418953*x_51 + 8.1988000869751) + 0.00168103611155145*std::sin(0.22639998793602*x_53 + 1.97503972053528) - 0.0111081342586226*std::sin(0.253679990768433*x_53 - 7.42943954467773) + 0.000509932863494298*std::sin(0.254559963941574*x_53 + 5.15840005874634) + 0.000417077162340574*std::sin(0.193759992718697*x_54 - 4.3953595161438) - 0.0121309039260932*std::sin(0.226559996604919*x_55 - 7.41791963577271) + 0.00594429074666784*std::sin(0.18792000412941*x_56 + 8.20448017120361) + 0.00262293488222329*std::sin(0.245999976992607*x_57 - 7.43856000900269) + 0.123959604394485*std::sin(0.0536801069974899*x_59 + 8.01991939544678) - 0.00314983237391107*std::sin(0.385519832372665*x_59 + 1.81727981567383) - 0.00311772355178066*std::sin(0.24415996670723*x_6 - 1.15775990486145) - 0.00155959321845273*std::sin(0.397839844226837*x_6 + 1.98791980743408) - 0.000268858780632739*std::sin(0.355519831180573*x_60 + 8.25080013275146) - 0.00335548966658845*std::sin(0.410879880189896*x_60 - 1.20055997371674) - 0.00700481041171741*std::sin(0.417359858751297*x_60 - 1.23583984375) - 3.77534604880604e-5*std::sin(1.03327977657318*x_64 - 4.59127998352051) + 0.0068895939216352*std::sin(0.312879920005798*x_7 - 7.39871978759766) - 0.000320344130902552*std::sin(0.350159853696823*x_7 + 2.01959991455078) + 0.00291493371710636*std::sin(0.366479843854904*x_7 + 2.00175976753235) - 0.00150137054716546*std::sin(0.355759829282761*x_8 - 1.14231991767883) + 0.000556473624756683*std::sin(0.494479864835739*x_8 - 1.44279980659485) - 0.0148438165468404*std::sin(0.312239944934845*x_9 - 7.42360019683838) - 0.000252838878379287*std::sin(0.365279853343964*x_91 + 1.97591972351074) + 0.000442278545280472*std::sin(0.263279944658279*x_92 - 7.39527988433838) - 0.0100848310783456*std::sin(0.292799949645996*x_92 - 1.16527986526489) + 0.000424123958954142*std::sin(0.236319988965988*x_93 + 1.98023986816406) - 0.00338271691628996*std::sin(0.236479982733727*x_93 - 1.18967986106873) + 0.0021348800560374*std::sin(0.291119933128357*x_94 + 1.8025598526001) - 0.00507894835765137*std::sin(0.267839968204498*x_95 + 1.96391975879669) + 0.0140863987739282*std::sin(0.276799947023392*x_97 + 1.95687973499298) + 0.000519880951562801*std::sin(0.279599964618683*x_97 - 1.20447981357574) + 0.00271605976059001*std::sin(0.291679948568344*x_97 + 8.16464042663574) - 0.0113997864410692*std::sin(0.230719983577728*x_98 + 5.18800020217896) - 0.00326818852878739*std::sin(0.232399985194206*x_98 + 1.98495984077454) - 0.182908976736728);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000118056434294618*x_1 - 2.45316443733668e-5*x_10 - 0.00011428323216322*x_100 - 0.000404089999422615*x_101 + 0.000709163456434176*x_102 - 0.00183401209678913*x_103 + 0.0010372364246849*x_104 + 0.000715829868029706*x_105 + 0.000504362720459189*x_106 - 0.00116776486292813*x_107 - 0.00123375894401077*x_108 + 0.000757662342953934*x_109 - 1.16131790068282e-5*x_11 + 0.000139964806150331*x_110 + 0.00122151617763658*x_111 + 0.00212352816687909*x_112 + 0.000443609955037641*x_113 - 0.00113065546468893*x_114 - 0.000440932285321648*x_115 + 0.000191143507344919*x_116 + 0.000813154232474457*x_117 - 0.00034903385404496*x_118 - 9.29609692255534e-5*x_119 - 0.00084892928960088*x_12 - 0.000203253525388187*x_120 + 0.00107128441573707*x_13 - 0.000107224648094888*x_15 - 0.00109052683028665*x_16 - 0.00131942667800326*x_17 - 2.99934443520813e-5*x_18 - 0.000336905992314683*x_19 - 0.000189326762433302*x_2 - 3.17862995221907e-5*x_20 + 0.0009082867979806*x_21 - 1.11363037633822e-5*x_22 - 0.00287341339454043*x_24 + 0.000550917806078588*x_25 + 0.0018516569925436*x_26 - 0.000300569909597847*x_27 + 0.000698749552539573*x_29 + 7.4801552254903e-5*x_3 - 2.37644634461547e-5*x_30 - 4.65739174655245e-5*x_31 - 0.000158189102703201*x_32 - 0.00170727400103893*x_33 + 0.000152244345394754*x_34 - 8.612763432738e-5*x_35 - 0.00212703269101841*x_36 - 0.000534103117277121*x_37 - 0.000953849209144864*x_38 + 0.000850422239264868*x_39 + 0.000128011314314865*x_4 - 0.000174399214767465*x_40 + 4.03310045602847e-5*x_41 - 0.000149674651694512*x_42 + 0.00113912260475187*x_43 - 0.00215281613150253*x_44 - 0.00130170953624755*x_45 + 0.00104411707325566*x_46 - 1.06260737354914e-5*x_47 - 0.00155509254840586*x_48 + 1.27049131762614e-6*x_5 - 0.000716107748052965*x_50 + 3.42220661459686e-5*x_51 - 0.00413770663085878*x_52 - 0.000346126181623396*x_53 - 0.00372513340035335*x_54 - 0.00210347653433307*x_55 - 0.000257068408859555*x_56 - 8.89093710048349e-5*x_57 + 0.00240260954657401*x_58 + 0.00212325998761303*x_59 - 2.20025977026056e-5*x_6 - 7.79551453316934e-5*x_60 - 8.01441485203634e-6*x_61 + 9.06294541470073e-6*x_62 + 0.000386014648585934*x_63 - 2.55504116975851e-5*x_64 - 1.52448328863225e-5*x_65 - 0.000392941159174074*x_66 - 2.67418239628332e-5*x_67 - 0.000593102122337671*x_68 + 5.04690974870224e-5*x_69 - 0.000116336805298968*x_7 + 0.000382373016715388*x_70 + 0.000968599509928441*x_71 - 0.00025465117960105*x_72 + 0.000357118566426586*x_73 - 0.000608205870577058*x_74 + 2.52846286252472e-6*x_75 - 0.000352021309191*x_76 + 5.90314899678223e-5*x_77 - 9.19393701159505e-5*x_78 - 0.000216945863129107*x_79 + 4.06366632519799e-6*x_8 + 4.57733840479046e-5*x_80 + 0.000307200407089817*x_81 - 0.000771282847376063*x_82 - 0.000382467338650085*x_83 + 0.00039207903526446*x_84 - 0.000617987602372765*x_85 - 0.00046093770212754*x_86 + 0.000165710874958559*x_87 - 2.32902173241165e-5*x_88 + 0.00090850577315029*x_89 + 0.000379273781686274*x_9 - 0.000106214361016986*x_90 + 9.06185766336172e-5*x_91 - 0.000215492090497376*x_92 - 3.39046636483735e-5*x_93 - 0.000396146453172809*x_94 + 5.01101938111539e-5*x_95 - 6.41419765867324e-5*x_96 - 3.92170901904277e-5*x_97 - 9.93925780288229e-5*x_98 - 0.000403370246661927*x_99 - 0.000263566779906164*std::pow(6.24751996994019 - 0.6004798412323*x_15, -0.279170777701308)*std::exp(0.0236496197325703*x_1 + 0.0256296721973637*x_101 - 0.083012249382363*x_103 + 0.0405360282599425*x_105 + 0.0498958487457352*x_107 + 0.0829546930303802*x_109 - 0.000464559004734947*x_11 + 0.0404846247817715*x_111 - 0.0175931747738021*x_112 - 0.113736391718642*x_114 - 0.0851841533040777*x_115 + 0.0421511548374591*x_117 - 0.0201945389468022*x_118 - 0.04325854282232*x_119 + 0.0513418447640834*x_12 - 0.137736167757858*x_120 - 0.00931471684221014*x_16 - 0.0702283368193896*x_19 + 0.0720158873141807*x_20 - 0.0472561716884324*x_21 - 0.00438232380240888*x_22 + 0.0370975036535221*x_23 + 0.0231462138205766*x_28 + 0.0266146790867899*x_32 + 0.000831687517371915*x_33 + 0.000833354443751079*x_34 + 0.0901176765669879*x_35 - 0.112828966427065*x_36 - 0.0879362876196018*x_37 + 0.0916071122821773*x_38 + 0.00871225625931711*x_39 + 0.0681587970852425*x_40 + 0.0629272263262282*x_41 - 0.0164916280130683*x_42 - 0.128286923804048*x_43 + 0.0027326739024354*x_44 - 0.00268057367668262*x_45 + 0.0537351342176069*x_46 - 0.0339667319188478*x_48 + 0.0225411670398691*x_5 + 0.0549191944754567*x_50 - 0.00521950696095368*x_52 - 0.00475711315074216*x_54 + 0.0656813270287523*x_56 - 0.00814050682460387*x_57 + 0.00233781477475126*x_6 + 0.00175679070240623*x_61 - 5.5597847933897e-5*x_62 + 0.034357583723812*x_63 - 0.00166329358738915*x_64 - 0.0260536705012238*x_65 + 0.00479592370417313*x_66 + 0.00717165891383476*x_67 + 0.00814124602533449*x_68 + 0.00159203425203658*x_69 - 0.017316065747747*x_70 + 0.00422352619900286*x_71 + 0.0124700685915039*x_72 + 0.0215629777716423*x_73 - 0.0248289627680645*x_74 - 0.015510281329815*x_75 - 0.0288458267030775*x_76 - 0.0229261892696286*x_77 - 0.00491033447983505*x_78 - 0.0502567064937738*x_79 + 0.0927796048399911*x_8 + 0.0315159168376772*x_80 - 0.0319620653932046*x_81 + 0.0415376949850823*x_82 + 0.0098575366260761*x_83 - 0.0298684016228185*x_84 + 0.0131697349561299*x_85 + 0.0536033911836225*x_86 + 0.0177825975445145*x_87 - 0.0433882416046681*x_88 + 0.00114032562188828*x_89 - 0.00082239245364703*x_90 - 0.0106243706473981*x_91 - 0.0019756714033908*x_93 + 0.0322142379738055*x_94 - 0.0341071956340259*x_96 - 0.0414609605083014*x_99 - 4.91632858708223e-5*std::pow(-9.91328048706055*x_10 - 9.80399990081787, 2) + 0.00173455987324098*std::pow(-2.00767993927002*x_29 - 7.99128007888794, 2) - 0.000687558775049509*std::pow(-5.30592012405396*x_30 - 9.79191970825195, 2) - 0.0055925158923251*std::pow(-1.45055985450745*x_58 - 3.72727990150452, 2) + 0.534797161430369*std::sin(0.249999970197678*x_100 - 1.20175993442535) + 0.324218139240717*std::sin(0.241359978914261*x_102 - 1.21223986148834) + 0.226132713732882*std::sin(0.183360010385513*x_104 - 1.39951992034912) + 0.438646864863703*std::sin(0.250479966402054*x_106 - 7.61360025405884) + 0.436426090755175*std::sin(0.247279971837997*x_108 + 1.95583975315094) - 0.202505032601864*std::sin(0.284559935331345*x_110 + 7.94407987594604) - 0.570313209720084*std::sin(0.282879948616028*x_113 + 1.97383987903595) + 0.464182814404442*std::sin(0.239839985966682*x_116 + 4.99567985534668) + 0.378439913660875*std::sin(0.38087984919548*x_13 - 7.3758397102356) - 0.332844233069332*std::sin(0.260159969329834*x_14 + 2.13895988464355) + 0.275086806244303*std::sin(0.315039932727814*x_17 + 1.82631993293762) - 0.593057693163555*std::sin(0.178240016102791*x_18 + 1.95119976997375) + 0.421589087619557*std::sin(0.404399842023849*x_2 + 1.97687971591949) + 0.400241143691039*std::sin(0.388799846172333*x_24 + 5.20887994766235) + 0.524425848471306*std::sin(0.24551996588707*x_25 - 7.39271974563599) + 0.387255839255085*std::sin(0.442559868097305*x_26 - 7.44799947738647) + 0.343579678579172*std::sin(0.369999825954437*x_27 - 4.38503980636597) + 0.288627011538161*std::sin(0.458639860153198*x_3 - 4.39296007156372) - 0.107423791690587*std::sin(0.404639840126038*x_31 - 1.20063984394073) - 0.307510732589831*std::sin(0.3713598549366*x_4 - 1.20103991031647) - 0.770449585703961*std::sin(0.199280008673668*x_47 + 1.97479975223541) - 0.131196253037238*std::sin(0.364319831132889*x_49 + 1.84487986564636) + 0.831281860484914*std::sin(0.199359998106956*x_51 - 4.39431953430176) - 0.518903167115351*std::sin(0.253679990768433*x_53 - 7.42943954467773) - 0.566680625266617*std::sin(0.226559996604919*x_55 - 7.41791963577271) + 5.7906242233914*std::sin(0.0536801069974899*x_59 + 8.01991939544678) - 0.327221315754375*std::sin(0.417359858751297*x_60 - 1.23583984375) + 0.321839115628269*std::sin(0.312879920005798*x_7 - 7.39871978759766) - 0.693411084067129*std::sin(0.312239944934845*x_9 - 7.42360019683838) - 0.471100786553308*std::sin(0.292799949645996*x_92 - 1.16527986526489) - 0.237256980068892*std::sin(0.267839968204498*x_95 + 1.96391975879669) + 0.658029221366963*std::sin(0.276799947023392*x_97 + 1.95687973499298) - 0.532527348966607*std::sin(0.230719983577728*x_98 + 5.18800020217896)) + 1.07477688528721e-6*std::pow(-2.82407999038696*x_43 - 9.27255916595459, 2) + 2.68181825289545e-6*std::pow(-1.9560798406601*x_49 - 6.25687980651855, 2) - 1.56850555342499e-5*std::pow(-2.78144001960754*x_57 - 8.74015998840332, 2) + 3.33175362581432e-5*std::pow(-3.40543985366821*x_61 - 6.01567983627319, 2) + 0.000845365261324384*std::exp(0.343279838562012*x_23) - 0.00618398248546695*std::exp(0.148799866437912*x_49) - 0.00395618763373257*std::exp(0.172799870371819*x_49) + 0.000845755314551488*std::sin(0.273519963026047*x_1 - 4.31824016571045) + 0.0114316416334516*std::sin(0.381679862737656*x_1 - 4.22352027893066) + 0.0100652721710504*std::sin(0.338639855384827*x_10 - 4.34327983856201) + 0.000466036444287687*std::sin(0.356239855289459*x_10 - 1.16279983520508) - 0.000598031731276973*std::sin(0.253279983997345*x_100 + 8.16903972625732) - 0.00350174596103886*std::sin(0.220319986343384*x_101 + 4.9814395904541) - 0.00623575257483866*std::sin(0.287599951028824*x_109 + 4.77304029464722) - 0.00493957583920961*std::sin(0.243759974837303*x_11 - 7.41639995574951) + 0.00956846637746059*std::sin(0.233999982476234*x_110 - 1.21967995166779) + 0.00105174754533722*std::sin(0.248159974813461*x_112 + 1.98031985759735) + 0.00334936736993878*std::sin(0.270559966564178*x_113 + 1.98671984672546) + 0.000514000842826664*std::sin(0.219999983906746*x_116 - 4.20359992980957) - 0.00955488489461922*std::sin(0.253439962863922*x_119 - 1.2267199754715) - 0.0105340826096612*std::sin(0.303039938211441*x_12 + 5.12728023529053) - 0.000538605090570297*std::sin(0.442479848861694*x_13 + 1.92767989635468) + 0.0292486979549953*std::sin(0.111040063202381*x_14 + 8.12263965606689) - 0.0103794661680231*std::sin(0.313599914312363*x_14 - 7.46143960952759) - 0.000521231985538367*std::sin(0.378799855709076*x_14 + 5.03047943115234) - 0.0129214178987066*std::sin(0.252079963684082*x_15 - 7.4113597869873) - 0.00538708853312936*std::sin(0.290639936923981*x_15 + 5.16328001022339) + 0.00036546955176183*std::sin(0.337679862976074*x_16 - 1.15767979621887) - 0.0163887585882801*std::sin(0.447039842605591*x_16 - 1.24167990684509) + 0.000472057913790314*std::sin(0.345279842615128*x_17 - 1.17911994457245) + 0.0115929190444874*std::sin(0.443679869174957*x_18 + 1.94863975048065) - 0.00317875075990084*std::sin(0.390159845352173*x_19 - 1.16807985305786) - 0.000588985287676868*std::sin(0.367999851703644*x_2 - 7.41447973251343) + 0.00970819283151561*std::sin(0.405919849872589*x_2 + 2.01239991188049) - 0.00777202820424464*std::sin(0.269759953022003*x_21 - 1.17471981048584) - 0.000439149634148154*std::sin(0.298719942569733*x_21 - 7.41016006469727) + 0.00148418613453528*std::sin(0.315119922161102*x_22 - 4.36552000045776) - 0.0107281022506619*std::sin(0.398959845304489*x_22 - 1.17631983757019) + 0.000513760883474619*std::sin(0.273519963026047*x_23 - 4.36448001861572) - 0.0103766995008109*std::sin(0.422159850597382*x_23 + 5.19608020782471) - 0.000646908838344394*std::sin(0.342239856719971*x_25 - 1.15543985366821) + 0.00673867170291188*std::sin(0.369199842214584*x_26 - 1.15751981735229) - 0.0040471721320336*std::sin(0.319439917802811*x_27 + 1.80935990810394) + 0.000615718245756319*std::sin(0.234079986810684*x_28 - 1.18439984321594) + 0.00540296058687155*std::sin(0.31687992811203*x_28 + 1.99743974208832) - 0.00253507927970902*std::sin(0.685199856758118*x_28 + 4.94039964675903) - 0.000831651553810317*std::sin(0.278799951076508*x_29 - 1.16959989070892) + 0.0103095775044592*std::sin(0.350799858570099*x_3 - 4.20911979675293) + 0.00475963277742*std::sin(0.554639875888824*x_3 + 8.19847965240479) + 0.0102533919362371*std::sin(0.24679996073246*x_30 + 8.22175979614258) + 0.00370450803888326*std::sin(0.329039841890335*x_30 - 1.17311990261078) - 0.0118875767055275*std::sin(0.328239858150482*x_31 - 4.25680017471313) - 0.000256300751722211*std::sin(0.513359844684601*x_31 + 8.15312004089355) - 0.000133728975328833*std::sin(0.257599949836731*x_32 + 8.03176021575928) - 0.0195000691430383*std::sin(0.305119931697845*x_32 - 1.15055990219116) + 0.00464375597257834*std::sin(0.233999997377396*x_35 - 1.21071982383728) - 0.00131692195074849*std::sin(0.24975997209549*x_36 - 7.42927980422974) - 0.00128222397227467*std::sin(0.218239992856979*x_37 + 1.97247982025146) - 0.00813053866830167*std::sin(0.240559980273247*x_39 - 1.21007990837097) - 0.000649290309060626*std::sin(0.380799859762192*x_4 + 1.98911988735199) + 0.000355110680145493*std::sin(1.04431986808777*x_4 + 6.76743984222412) + 0.0178373109518561*std::sin(0.232239991426468*x_41 - 4.4125599861145) + 0.0033235508104149*std::sin(0.248079970479012*x_41 + 1.96991980075836) - 0.0110079325922222*std::sin(0.249439969658852*x_42 + 1.97775983810425) + 0.00157790356390103*std::sin(0.221519991755486*x_45 + 1.96543979644775) + 0.00804372355911843*std::sin(0.219679996371269*x_48 - 7.40263986587524) - 0.00175307696576593*std::sin(0.308079928159714*x_5 + 2.01263976097107) - 0.00758551963304004*std::sin(0.31399992108345*x_5 - 1.18407988548279) - 0.000998820423024128*std::sin(0.230079978704453*x_50 - 7.44495964050293) + 0.0154396884946457*std::sin(0.208000004291534*x_51 + 8.20343971252441) + 0.00877956400699342*std::sin(0.210879996418953*x_51 + 8.1988000869751) + 0.00733523908999835*std::sin(0.22639998793602*x_53 + 1.97503972053528) - 0.00129600276908215*std::sin(0.254559963941574*x_53 + 5.15840005874634) - 0.00106000847564584*std::sin(0.193759992718697*x_54 - 4.3953595161438) + 0.0132051497081147*std::sin(0.18792000412941*x_56 + 8.20448017120361) + 0.0114452356772085*std::sin(0.245999976992607*x_57 - 7.43856000900269) - 0.00699730377022322*std::sin(0.385519832372665*x_59 + 1.81727981567383) - 0.00692597451981249*std::sin(0.24415996670723*x_6 - 1.15775990486145) - 0.00680532027948686*std::sin(0.397839844226837*x_6 + 1.98791980743408) + 0.000683309017984044*std::sin(0.355519831180573*x_60 + 8.25080013275146) - 0.00745416825651919*std::sin(0.410879880189896*x_60 - 1.20055997371674) - 8.38687269837353e-5*std::sin(1.03327977657318*x_64 - 4.59127998352051) + 0.000814159883448196*std::sin(0.350159853696823*x_7 + 2.01959991455078) + 0.00647548004700107*std::sin(0.366479843854904*x_7 + 2.00175976753235) - 0.00333527138688289*std::sin(0.355759829282761*x_8 - 1.14231991767883) + 0.00242818524647938*std::sin(0.494479864835739*x_8 - 1.44279980659485) + 0.00064259417262454*std::sin(0.365279853343964*x_91 + 1.97591972351074) - 0.00112405820535143*std::sin(0.263279944658279*x_92 - 7.39527988433838) - 0.00107791802527118*std::sin(0.236319988965988*x_93 + 1.98023986816406) - 0.00751465316948383*std::sin(0.236479982733727*x_93 - 1.18967986106873) + 0.00474260293621155*std::sin(0.291119933128357*x_94 + 1.8025598526001) - 0.00132128599871263*std::sin(0.279599964618683*x_97 - 1.20447981357574) + 0.00603368463678906*std::sin(0.291679948568344*x_97 + 8.16464042663574) - 0.014260814556637*std::sin(0.232399985194206*x_98 + 1.98495984077454) - 0.0600626356899738*std::sin(0.00874435782914928*x_10 - 0.0468517183075736*x_100 - 0.000335927634168036*x_101 + 0.0608362199086894*x_102 - 0.00780903368495423*x_103 + 0.0460063649645256*x_104 - 0.0381462687277783*x_105 + 0.000454666186709982*x_106 + 0.0134563169939792*x_107 - 7.19218717332075e-6*x_110 + 0.0626425399663325*x_111 - 0.0045294233684927*x_114 + 0.0560013255400347*x_115 - 0.00102705595587201*x_116 - 0.049472836657086*x_117 - 0.0516619383621122*x_118 + 0.000253131365103668*x_119 + 0.0227410394841472*x_120 + 0.00189018530301013*x_13 + 0.0330287971769348*x_17 + 0.0597326007129261*x_18 - 0.00509661706922233*x_2 - 0.0112373812295343*x_20 + 0.0626425832866084*x_21 + 0.0414736019772735*x_24 + 0.000615224461341991*x_26 + 0.0053216489657669*x_28 + 0.00696648423470916*x_3 + 0.0281508913479072*x_32 + 0.0113915963029668*x_34 + 0.000828027983636841*x_36 + 0.0115268884475517*x_37 + 0.00347096185901691*x_38 + 0.000909298042560169*x_39 - 0.0740958837188354*x_40 + 0.0516518277339972*x_41 + 0.00158042005697519*x_42 + 0.000490846174254207*x_43 + 0.0716193570064715*x_45 + 0.0552511943440407*x_46 + 0.0126249162105115*x_47 - 0.0600210237296306*x_48 + 0.00173809048377329*x_49 + 0.0806278156996159*x_50 - 0.00286215573568827*x_51 + 0.00373717761888635*x_52 + 0.0985951511528666*x_54 - 0.0807606934088246*x_55 + 0.00715842778956595*x_56 + 0.0775872394951223*x_58 - 0.100810539554384*x_59 - 0.000471371274184045*x_6 - 0.00104994229721517*x_61 - 0.000133746328232442*x_62 + 0.0303350126659251*x_63 - 0.0202820324853311*x_64 - 0.0263884141793212*x_65 + 0.000500425202991739*x_66 - 0.000430477046218728*x_67 - 0.0436681484648205*x_68 + 0.0241590042401933*x_69 + 0.0558769205782479*x_70 + 0.00124374352465851*x_71 - 0.030625865684864*x_72 - 0.0260560536697211*x_73 + 0.0457446659231872*x_74 - 0.000730547502351792*x_75 + 0.00119807227181648*x_76 + 0.0157437616056276*x_77 + 0.0380696822539103*x_78 + 0.00502701358137735*x_79 + 0.00407769582230972*x_8 - 0.038440655725744*x_80 - 0.0300784920137472*x_81 - 1.79850443999756e-5*x_82 + 0.0356893921821819*x_83 - 0.0303443714092307*x_84 + 0.0291079227383644*x_85 - 4.90606371464851e-5*x_86 + 0.0268548314098012*x_87 - 0.0124728415945108*x_88 - 0.000634514422634155*x_89 + 0.00698613313212781*x_9 - 0.0368801521062717*x_90 + 0.000348774886733367*x_92 + 0.00322625105131007*x_96 + 0.00362612189229518*x_98 + 0.0174442216546195*x_99 - 0.000120691216959238*std::pow(-8.66760063171387*x_23 - 8.67360019683838, 2) + 0.441631293900361*std::sin(0.437119841575623*x_1 - 7.18616008758545) - 0.313622082930442*std::sin(0.257359951734543*x_108 - 7.42712020874023) - 0.468713658467518*std::sin(0.243679970502853*x_109 - 7.43919992446899) - 0.281511910541111*std::sin(0.37407985329628*x_11 + 5.032639503479) + 0.113529990768*std::sin(0.297039926052094*x_112 - 1.24703979492188) + 0.170226045864386*std::sin(0.182320013642311*x_113 - 0.98695981502533) - 0.307142010145352*std::sin(0.357359826564789*x_12 - 1.35935986042023) - 0.350940216702357*std::sin(0.405359864234924*x_14 - 7.59216022491455) + 0.61182145235092*std::sin(0.282559931278229*x_15 - 7.42799949645996) + 0.449065758202877*std::sin(0.194240003824234*x_16 + 8.20448017120361) + 0.371671728314247*std::sin(0.322959929704666*x_19 + 1.99087977409363) - 0.569531774176898*std::sin(0.400479853153229*x_22 + 2.00727987289429) - 0.478807034459024*std::sin(0.349199831485748*x_25 + 2.03151988983154) + 0.473684599508552*std::sin(0.298239946365356*x_27 + 5.1923999786377) - 0.21690875830161*std::sin(0.232639983296394*x_29 - 1.37055993080139) + 0.530312248543275*std::sin(0.311679929494858*x_30 - 1.0311998128891) - 0.249983780466968*std::sin(0.295199930667877*x_31 + 5.3310399055481) - 0.417469925988323*std::sin(0.248399972915649*x_33 - 1.19327986240387) - 0.180224229076588*std::sin(0.226879999041557*x_35 - 1.20903992652893) + 0.699209203093815*std::sin(0.288719952106476*x_4 - 7.37999963760376) - 0.459705075405363*std::sin(0.280639946460724*x_44 - 7.47559976577759) - 0.320728947310307*std::sin(0.376479834318161*x_5 + 2.00879979133606) + 0.191851047235387*std::sin(0.240399971604347*x_53 - 1.20711994171143) - 0.482499855626866*std::sin(0.23471999168396*x_57 + 1.97623980045319) - 0.244953835740993*std::sin(0.490879863500595*x_60 - 7.56831979751587) - 0.336094492358594*std::sin(0.429519861936569*x_7 + 8.19087982177734) - 0.369329279508101*std::sin(0.373839855194092*x_91 + 5.19048023223877) + 0.408085298137356*std::sin(0.2483199685812*x_93 - 1.21671986579895) + 0.0451908644739074*std::sin(0.337679862976074*x_94 + 1.8290399312973) - 0.412475001344633*std::sin(0.285919934511185*x_95 - 1.22239983081818) - 0.302400446872277*std::sin(0.277999937534332*x_97 + 8.18935966491699) + 7.45678402308836) - 0.0998858024490693);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-2.62784776123048e-5*x_1 + 0.000170282971348945*x_10 - 0.000886324523516514*x_100 - 0.000393952403385437*x_101 + 0.00111888772332096*x_102 + 6.92515628919301e-5*x_103 + 0.00112699876613965*x_104 - 0.000633224406195717*x_105 + 5.8922977063376e-5*x_106 - 6.40471760217493e-5*x_107 + 0.000145860150766395*x_108 - 0.000720941000755198*x_109 + 0.00016468609516825*x_11 + 0.000273291464145172*x_110 + 0.00146436918887647*x_111 + 8.64273943542515e-5*x_112 + 9.82988727529905e-5*x_113 - 0.000307229946807146*x_114 + 0.0012678031168527*x_115 - 3.20917138680951e-5*x_116 - 0.000918957112506602*x_117 - 0.00109458913933879*x_118 + 6.41770718813901e-5*x_119 + 0.000298430927233233*x_12 + 0.000891522970746904*x_120 + 2.06418215864593e-5*x_13 - 0.0002291942951547*x_15 + 0.000123399297551317*x_16 + 0.000661757072821215*x_17 + 0.00126031434780964*x_18 + 0.000132427878696153*x_19 - 7.9003315340603e-5*x_2 - 0.000301232975773993*x_20 + 0.00127835874514799*x_21 - 1.67595193035665e-5*x_22 - 5.96334894441778e-5*x_23 + 0.000978377405677093*x_24 + 1.39045557925054e-6*x_25 - 0.00012736408086903*x_26 - 2.77435117872963e-6*x_27 + 6.49395173628844e-5*x_28 + 6.01765877716935e-6*x_29 + 0.000293607882508073*x_3 - 5.07968974116012e-5*x_30 + 4.63063087104677e-6*x_31 + 0.000513288790331186*x_32 + 0.000212138974581527*x_33 + 0.000476058666296273*x_34 - 0.000196068831556281*x_35 + 0.000193648336964156*x_36 + 0.000426358610335154*x_37 - 7.34026408566174e-5*x_38 + 0.000217031196802101*x_39 - 1.27275774976085e-5*x_4 - 0.00131375583527019*x_40 + 0.00097648681386239*x_41 + 1.79107104496917e-5*x_42 + 0.000299270775204259*x_43 + 0.000305822467268286*x_44 + 0.00150113643976528*x_45 + 0.00117612899252718*x_46 + 0.000492266395289919*x_47 - 0.00110536543537105*x_48 + 3.33618426247979e-5*x_49 - 3.35187774459692e-5*x_5 + 0.00151509733954348*x_50 + 1.82124251586413e-5*x_51 - 0.000232579081831432*x_52 + 3.44137377554566e-5*x_53 + 0.0019953896277127*x_54 - 0.00192969305596785*x_55 - 0.000442764996096187*x_56 - 0.00017695941473907*x_57 + 0.00137112784305409*x_58 - 0.00196439720441256*x_59 - 5.98366265708766e-5*x_6 - 0.000118934250176848*x_61 - 7.12755721766822e-5*x_62 + 0.000489980618718983*x_63 - 0.000275411543572056*x_64 - 0.000361353933004072*x_65 - 0.000149650570717258*x_66 - 7.75354027416699e-5*x_67 - 0.000744191513887561*x_68 + 0.000389257582023832*x_69 + 0.00118833114791694*x_70 + 0.000135822278919293*x_71 - 0.000611484070898636*x_72 - 0.000624839027270928*x_73 + 0.000918076384386009*x_74 - 0.000122736715262457*x_75 + 0.000108932300591983*x_76 + 0.000389382694156368*x_77 + 0.000853079787413989*x_78 + 9.32245190305635e-5*x_79 - 6.21857125124404e-5*x_8 - 0.000715179695079758*x_80 - 0.000412161751285205*x_81 - 7.12437314460113e-5*x_82 + 0.00060802191534127*x_83 - 0.000651328166282577*x_84 + 0.000599175938133357*x_85 - 4.71895393497167e-5*x_86 + 0.000370026983067562*x_87 - 0.000303880666610294*x_88 + 6.81820914558621e-5*x_89 + 0.000163433163338104*x_9 - 0.000715796293905055*x_90 - 1.17876167377446e-5*x_91 + 1.78753565739167e-5*x_92 + 3.17585196242939e-6*x_93 - 0.000320821827211664*x_94 + 0.000223862985661869*x_95 + 0.000172728677167719*x_96 - 0.000376093950152595*x_98 + 0.000180961291407192*x_99 + 7.9028991179584e-8*std::pow(-9.91328048706055*x_10 - 9.80399990081787, 2) - 2.31661206593122e-6*std::pow(-8.66760063171387*x_23 - 8.67360019683838, 2) - 2.78827003717782e-6*std::pow(-2.00767993927002*x_29 - 7.99128007888794, 2) + 1.10523687354025e-6*std::pow(-5.30592012405396*x_30 - 9.79191970825195, 2) + 2.29735172881122e-6*std::pow(-2.82407999038696*x_43 - 9.27255916595459, 2) + 5.73242677990835e-6*std::pow(-1.9560798406601*x_49 - 6.25687980651855, 2) + 1.55949308805181e-6*std::pow(-2.78144001960754*x_57 - 8.74015998840332, 2) + 8.9898565829699e-6*std::pow(-1.45055985450745*x_58 - 3.72727990150452, 2) - 8.4050788282882e-5*std::exp(0.343279838562012*x_23) + 0.000614844998263522*std::exp(0.148799866437912*x_49) + 0.000448761398628323*std::log(6.24751996994019 - 0.6004798412323*x_15) + 0.00180781468287432*std::sin(0.273519963026047*x_1 - 4.31824016571045) + 0.0084769083444401*std::sin(0.437119841575623*x_1 - 7.18616008758545) + 0.000996159896653573*std::sin(0.356239855289459*x_10 - 1.16279983520508) - 0.000859675658469983*std::sin(0.249999970197678*x_100 - 1.20175993442535) - 0.00127830180434703*std::sin(0.253279983997345*x_100 + 8.16903972625732) - 0.000521174124399248*std::sin(0.241359978914261*x_102 - 1.21223986148834) - 0.000363503779750766*std::sin(0.183360010385513*x_104 - 1.39951992034912) - 0.000705115994593018*std::sin(0.250479966402054*x_106 - 7.61360025405884) - 0.000701546144971985*std::sin(0.247279971837997*x_108 + 1.95583975315094) - 0.00601983076949605*std::sin(0.257359951734543*x_108 - 7.42712020874023) - 0.00899674180134702*std::sin(0.243679970502853*x_109 - 7.43919992446899) + 0.000491119356404846*std::sin(0.243759974837303*x_11 - 7.41639995574951) - 0.00540349086779982*std::sin(0.37407985329628*x_11 + 5.032639503479) - 0.000951348699169237*std::sin(0.233999982476234*x_110 - 1.21967995166779) + 0.000325522758534984*std::sin(0.284559935331345*x_110 + 7.94407987594604) + 0.0022481261689097*std::sin(0.248159974813461*x_112 + 1.98031985759735) + 0.00217915564267643*std::sin(0.297039926052094*x_112 - 1.24703979492188) + 0.00326741018709245*std::sin(0.182320013642311*x_113 - 0.98695981502533) - 0.000333012226278711*std::sin(0.270559966564178*x_113 + 1.98671984672546) + 0.000916766990290164*std::sin(0.282879948616028*x_113 + 1.97383987903595) + 0.00109868451865962*std::sin(0.219999983906746*x_116 - 4.20359992980957) - 0.000746164518817373*std::sin(0.239839985966682*x_116 + 4.99567985534668) - 0.00589544877070386*std::sin(0.357359826564789*x_12 - 1.35935986042023) - 0.000608334533970961*std::sin(0.38087984919548*x_13 - 7.3758397102356) - 0.00115127646761546*std::sin(0.442479848861694*x_13 + 1.92767989635468) - 0.00290806380606873*std::sin(0.111040063202381*x_14 + 8.12263965606689) + 0.000535040396374786*std::sin(0.260159969329834*x_14 + 2.13895988464355) - 0.00111414119477298*std::sin(0.378799855709076*x_14 + 5.03047943115234) - 0.00673613508021696*std::sin(0.405359864234924*x_14 - 7.59216022491455) + 0.0117436296892292*std::sin(0.282559931278229*x_15 - 7.42799949645996) + 0.000535613489782912*std::sin(0.290639936923981*x_15 + 5.16328001022339) + 0.00861960944681411*std::sin(0.194240003824234*x_16 + 8.20448017120361) + 0.000781196653986038*std::sin(0.337679862976074*x_16 - 1.15767979621887) - 0.000442196496821284*std::sin(0.315039932727814*x_17 + 1.82631993293762) + 0.00100903087812071*std::sin(0.345279842615128*x_17 - 1.17911994457245) + 0.000953328289023556*std::sin(0.178240016102791*x_18 + 1.95119976997375) + 0.00713406685317537*std::sin(0.322959929704666*x_19 + 1.99087977409363) + 0.000316048599756638*std::sin(0.390159845352173*x_19 - 1.16807985305786) - 0.00125896489533011*std::sin(0.367999851703644*x_2 - 7.41447973251343) - 0.000677695961462747*std::sin(0.404399842023849*x_2 + 1.97687971591949) + 0.000772737096033675*std::sin(0.269759953022003*x_21 - 1.17471981048584) - 0.000938688936306516*std::sin(0.298719942569733*x_21 - 7.41016006469727) - 0.000147565815953663*std::sin(0.315119922161102*x_22 - 4.36552000045776) - 0.0109318988840342*std::sin(0.400479853153229*x_22 + 2.00727987289429) + 0.00109817160194192*std::sin(0.273519963026047*x_23 - 4.36448001861572) - 0.000643379571853191*std::sin(0.388799846172333*x_24 + 5.20887994766235) - 0.00084300398191614*std::sin(0.24551996588707*x_25 - 7.39271974563599) - 0.00138277735453588*std::sin(0.342239856719971*x_25 - 1.15543985366821) - 0.0091904794833177*std::sin(0.349199831485748*x_25 + 2.03151988983154) - 0.000669995201508473*std::sin(0.369199842214584*x_26 - 1.15751981735229) - 0.000622505956683741*std::sin(0.442559868097305*x_26 - 7.44799947738647) + 0.0090921567145845*std::sin(0.298239946365356*x_27 + 5.1923999786377) + 0.000402391751325356*std::sin(0.319439917802811*x_27 + 1.80935990810394) - 0.00055229740866512*std::sin(0.369999825954437*x_27 - 4.38503980636597) + 0.00131610699458883*std::sin(0.234079986810684*x_28 - 1.18439984321594) - 0.000537191575244586*std::sin(0.31687992811203*x_28 + 1.99743974208832) - 0.00416346325232084*std::sin(0.232639983296394*x_29 - 1.37055993080139) - 0.0017776676825387*std::sin(0.278799951076508*x_29 - 1.16959989070892) - 0.00102503397733156*std::sin(0.350799858570099*x_3 - 4.20911979675293) - 0.000463962103936106*std::sin(0.458639860153198*x_3 - 4.39296007156372) + 0.0101790982362983*std::sin(0.311679929494858*x_30 - 1.0311998128891) - 0.000368322233138148*std::sin(0.329039841890335*x_30 - 1.17311990261078) - 0.00479832299903372*std::sin(0.295199930667877*x_31 + 5.3310399055481) + 0.000172681580077855*std::sin(0.404639840126038*x_31 - 1.20063984394073) - 0.000547846704860324*std::sin(0.513359844684601*x_31 + 8.15312004089355) - 0.000285847692548533*std::sin(0.257599949836731*x_32 + 8.03176021575928) - 0.00801314206678847*std::sin(0.248399972915649*x_33 - 1.19327986240387) - 0.0034593206877099*std::sin(0.226879999041557*x_35 - 1.20903992652893) - 0.000461707344677344*std::sin(0.233999997377396*x_35 - 1.21071982383728) - 0.00281494044175786*std::sin(0.24975997209549*x_36 - 7.42927980422974) - 0.00274077299182076*std::sin(0.218239992856979*x_37 + 1.97247982025146) + 0.0134209971305895*std::sin(0.288719952106476*x_4 - 7.37999963760376) + 0.000494317304936125*std::sin(0.3713598549366*x_4 - 1.20103991031647) - 0.0013878677839468*std::sin(0.380799859762192*x_4 + 1.98911988735199) - 0.000330445404245672*std::sin(0.248079970479012*x_41 + 1.96991980075836) - 0.00882382621772357*std::sin(0.280639946460724*x_44 - 7.47559976577759) + 0.00337279255820313*std::sin(0.221519991755486*x_45 + 1.96543979644775) + 0.00123848218105065*std::sin(0.199280008673668*x_47 + 1.97479975223541) - 0.000799750518272203*std::sin(0.219679996371269*x_48 - 7.40263986587524) + 0.000210895332572305*std::sin(0.364319831132889*x_49 + 1.84487986564636) + 0.000174300397277206*std::sin(0.308079928159714*x_5 + 2.01263976097107) - 0.00615624374293466*std::sin(0.376479834318161*x_5 + 2.00879979133606) - 0.00213499365032702*std::sin(0.230079978704453*x_50 - 7.44495964050293) - 0.0013362688367215*std::sin(0.199359998106956*x_51 - 4.39431953430176) - 0.000872911756998087*std::sin(0.210879996418953*x_51 + 8.1988000869751) + 0.00368249208256094*std::sin(0.240399971604347*x_53 - 1.20711994171143) + 0.000834126382942909*std::sin(0.253679990768433*x_53 - 7.42943954467773) - 0.00277022537686915*std::sin(0.254559963941574*x_53 + 5.15840005874634) - 0.00226578403147251*std::sin(0.193759992718697*x_54 - 4.3953595161438) + 0.000910927683993868*std::sin(0.226559996604919*x_55 - 7.41791963577271) - 0.00131292743283736*std::sin(0.18792000412941*x_56 + 8.20448017120361) - 0.00926136147697295*std::sin(0.23471999168396*x_57 + 1.97623980045319) - 0.00930831173239947*std::sin(0.0536801069974899*x_59 + 8.01991939544678) + 0.000695709801016257*std::sin(0.385519832372665*x_59 + 1.81727981567383) + 0.000688617861000581*std::sin(0.24415996670723*x_6 - 1.15775990486145) + 0.00146058328502148*std::sin(0.355519831180573*x_60 + 8.25080013275146) + 0.000741133740191936*std::sin(0.410879880189896*x_60 - 1.20055997371674) + 0.000526001670117658*std::sin(0.417359858751297*x_60 - 1.23583984375) - 0.0047017755373647*std::sin(0.490879863500595*x_60 - 7.56831979751587) + 8.33868262367576e-6*std::sin(1.03327977657318*x_64 - 4.59127998352051) - 0.00051734989189009*std::sin(0.312879920005798*x_7 - 7.39871978759766) + 0.00174027897452282*std::sin(0.350159853696823*x_7 + 2.01959991455078) - 0.000643827263031649*std::sin(0.366479843854904*x_7 + 2.00175976753235) - 0.00645117827052744*std::sin(0.429519861936569*x_7 + 8.19087982177734) + 0.000331610727374422*std::sin(0.355759829282761*x_8 - 1.14231991767883) + 0.00111464434233615*std::sin(0.312239944934845*x_9 - 7.42360019683838) + 0.00137355469178006*std::sin(0.365279853343964*x_91 + 1.97591972351074) - 0.00708910463218809*std::sin(0.373839855194092*x_91 + 5.19048023223877) - 0.00240269129034951*std::sin(0.263279944658279*x_92 - 7.39527988433838) + 0.000757285019618924*std::sin(0.292799949645996*x_92 - 1.16527986526489) - 0.00230406596268749*std::sin(0.236319988965988*x_93 + 1.98023986816406) + 0.000747147477503467*std::sin(0.236479982733727*x_93 - 1.18967986106873) + 0.007833008477439*std::sin(0.2483199685812*x_93 - 1.21671986579895) - 0.000471535244631176*std::sin(0.291119933128357*x_94 + 1.8025598526001) + 0.00086741773384781*std::sin(0.337679862976074*x_94 + 1.8290399312973) + 0.000381385813682709*std::sin(0.267839968204498*x_95 + 1.96391975879669) - 0.00791726679939518*std::sin(0.285919934511185*x_95 - 1.22239983081818) - 0.00105776871114674*std::sin(0.276799947023392*x_97 + 1.95687973499298) - 0.00580443665758968*std::sin(0.277999937534332*x_97 + 8.18935966491699) - 0.00282426865980223*std::sin(0.279599964618683*x_97 - 1.20447981357574) - 0.000599901572934207*std::sin(0.291679948568344*x_97 + 8.16464042663574) + 0.00085602698068125*std::sin(0.230719983577728*x_98 + 5.18800020217896) + 0.403442293405533*std::sin(-9.10224873975194e-5*x_100 + 0.00370746226030781*x_102 + 0.0040593073067562*x_103 - 0.00269812596745194*x_104 - 0.00717797996785739*x_105 + 0.00283441823334189*x_106 + 4.34427812682229e-5*x_107 - 0.00029884977587028*x_108 + 0.000496433603961316*x_11 - 6.77138893068809e-5*x_110 - 0.0134712957343532*x_111 - 0.0152250924640238*x_112 - 0.00223524527628417*x_113 + 0.00109891634544745*x_114 - 0.00877943126330264*x_115 - 0.000374672911162883*x_116 - 0.0124774220448574*x_117 - 0.00746867747825384*x_118 + 0.000720997927040089*x_120 - 0.00513799893322101*x_13 + 0.00584624687767679*x_17 + 0.00194530751859355*x_19 - 5.9071516787634e-5*x_20 - 0.00510595795740794*x_21 + 0.0166164106893601*x_24 - 0.00317561538151743*x_25 - 0.0107751542040969*x_26 + 0.0016823652330574*x_27 - 0.00426827809765092*x_29 + 0.00769250970319317*x_33 + 0.00163208794778856*x_34 + 0.00034949901099246*x_35 + 0.0121615944480579*x_36 - 0.000601931263106826*x_37 + 0.00112203333259679*x_38 + 2.02348899126794e-5*x_40 - 0.011132090919174*x_43 + 0.00130198534437499*x_44 + 0.000412514178210537*x_45 - 0.0152886607888516*x_46 - 0.00353505503297885*x_47 + 0.00872124188957814*x_48 + 0.000872645254652194*x_50 + 0.0178830285243289*x_52 + 0.0155552404874266*x_54 + 0.00156155569166076*x_55 + 0.000196985537833143*x_56 - 0.0120903359076596*x_58 - 0.0120132435500877*x_59 + 0.000438226885508198*x_60 - 0.000274341972257168*x_62 + 0.000124499317445857*x_63 + 0.000436131010322747*x_64 + 0.000526806811387113*x_65 + 0.00163185858072849*x_66 + 2.09254410838943e-5*x_67 + 0.00369406318650598*x_68 - 0.000530190922402671*x_69 + 0.000653990389463276*x_7 - 5.24794644752337e-5*x_70 - 0.00434615575910775*x_71 + 0.00134324611968812*x_72 - 0.00325288755799897*x_73 + 0.00349317457738732*x_74 - 9.57664884374121e-5*x_75 - 0.000140259354868916*x_76 - 0.000143742006007555*x_77 - 0.00015149777809906*x_78 + 0.000969944725579766*x_79 - 6.34264723837722e-5*x_80 - 0.00138029447235404*x_81 + 0.00430640043654675*x_82 - 0.000121678889328832*x_83 + 0.000949598443584342*x_84 + 0.00014551589244111*x_85 - 9.49763598031867e-5*x_86 - 0.00137210439449389*x_87 - 0.000150222218845732*x_88 - 0.0049480153866207*x_89 - 0.000379095999330754*x_9 + 0.00228252936878565*x_90 + 0.00112267726868202*x_91 + 0.000579231380885818*x_92 + 0.000190595952218552*x_93 + 0.00151939487487808*x_94 - 0.00142341991338798*x_95 + 0.000185913597753377*x_96 + 0.00022045989677423*x_97 + 0.00144548855499958*x_99 - 0.000187295400259828*std::pow(-3.40543985366821*x_61 - 6.01567983627319, 2) + 0.0222398121104113*std::exp(0.172799870371819*x_49) - 0.0642632720131253*std::sin(0.381679862737656*x_1 - 4.22352027893066) - 0.0565821903935118*std::sin(0.338639855384827*x_10 - 4.34327983856201) + 0.0196851563782934*std::sin(0.220319986343384*x_101 + 4.9814395904541) + 0.0350544459643292*std::sin(0.287599951028824*x_109 + 4.77304029464722) + 0.0537130349888009*std::sin(0.253439962863922*x_119 - 1.2267199754715) + 0.0592176205185151*std::sin(0.303039938211441*x_12 + 5.12728023529053) + 0.058348440153587*std::sin(0.313599914312363*x_14 - 7.46143960952759) + 0.0726380881981106*std::sin(0.252079963684082*x_15 - 7.4113597869873) + 0.0921298344442674*std::sin(0.447039842605591*x_16 - 1.24167990684509) - 0.0651698971914931*std::sin(0.443679869174957*x_18 + 1.94863975048065) - 0.0545748595601481*std::sin(0.405919849872589*x_2 + 2.01239991188049) + 0.0603083069977894*std::sin(0.398959845304489*x_22 - 1.17631983757019) + 0.0583328872615936*std::sin(0.422159850597382*x_23 + 5.19608020782471) + 0.0142510143818767*std::sin(0.685199856758118*x_28 + 4.94039964675903) - 0.0267563999699645*std::sin(0.554639875888824*x_3 + 8.19847965240479) - 0.0576397105668054*std::sin(0.24679996073246*x_30 + 8.22175979614258) + 0.066826322928875*std::sin(0.328239858150482*x_31 - 4.25680017471313) + 0.109620147988794*std::sin(0.305119931697845*x_32 - 1.15055990219116) + 0.045706035476599*std::sin(0.240559980273247*x_39 - 1.21007990837097) - 0.00199626396318947*std::sin(1.04431986808777*x_4 + 6.76743984222412) - 0.100272909389282*std::sin(0.232239991426468*x_41 - 4.4125599861145) + 0.0618813805714566*std::sin(0.249439969658852*x_42 + 1.97775983810425) + 0.0426421967351134*std::sin(0.31399992108345*x_5 - 1.18407988548279) - 0.0867946121251668*std::sin(0.208000004291534*x_51 + 8.20343971252441) - 0.0412352381255978*std::sin(0.22639998793602*x_53 + 1.97503972053528) - 0.064339691285153*std::sin(0.245999976992607*x_57 - 7.43856000900269) + 0.0382562856919315*std::sin(0.397839844226837*x_6 + 1.98791980743408) - 0.0136501067822267*std::sin(0.494479864835739*x_8 - 1.44279980659485) + 0.0801675414929184*std::sin(0.232399985194206*x_98 + 1.98495984077454) - 1.33464121714354) + 0.430394368044059);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-2.4455334120348e-5*x_1 - 3.0744947607605e-6*x_10 - 3.26777125434576e-5*x_100 + 0.000393758072469097*x_101 + 0.000733810762417758*x_102 + 0.000651868203050322*x_103 - 0.00076639008318993*x_104 - 0.00150182441992179*x_105 + 0.000457676724541912*x_106 + 0.000262746343847937*x_107 - 0.000235964083154263*x_108 + 0.000663980497918534*x_109 - 0.00010308222326124*x_11 - 0.000332895008653997*x_110 - 0.00282740238362152*x_111 - 0.00279684595635974*x_112 - 0.000516219082836065*x_113 + 0.000710234504739856*x_114 - 0.00162235766822347*x_115 - 5.15979246012506e-5*x_116 - 0.00238264500023804*x_117 - 0.00118586748680956*x_118 + 2.89235066601587e-5*x_119 - 0.000476397231789249*x_12 - 8.99975025819569e-5*x_120 - 0.000901825597185608*x_13 + 0.00026885931224959*x_15 - 0.000132868669532629*x_16 + 0.00101354603581639*x_17 - 0.000134156371835112*x_18 + 0.000354671841589757*x_19 - 2.37278891832006e-5*x_2 - 7.59371423251189e-5*x_20 - 0.000896490998797839*x_21 + 2.97135498263753e-5*x_22 - 1.51523257600173e-5*x_23 + 0.00276639456336272*x_24 - 0.000571323591205147*x_25 - 0.00176934756547955*x_26 + 0.000304999553480133*x_27 - 9.45397769068201e-6*x_28 - 0.000773133683748241*x_29 - 0.000187560362768995*x_3 + 5.95879530652271e-5*x_30 - 5.8370023246915e-6*x_31 - 3.0696136000311e-5*x_32 + 0.00112530458091043*x_33 - 8.46184040387361e-6*x_34 + 8.59455401609851e-5*x_35 + 0.00223191696203738*x_36 - 0.000152401276845906*x_37 + 0.00014905176933259*x_38 - 0.000247868195382744*x_39 + 1.60433646105845e-5*x_4 - 0.000282256277414329*x_40 - 0.000126829923562941*x_41 + 5.13164722973021e-5*x_42 - 0.00204964531905157*x_43 - 0.000148666164093068*x_44 - 7.88611376031568e-5*x_45 - 0.00301573560848164*x_46 - 0.00093351579707489*x_47 + 0.00158735102079846*x_48 - 1.23925288191493e-5*x_5 + 6.37909024186204e-5*x_50 - 8.58097585885551e-5*x_51 + 0.00356967741900294*x_52 - 4.33792009930853e-5*x_53 + 0.00267182430273006*x_54 + 0.000711593888879946*x_55 + 0.000565223140018367*x_56 + 0.000226259821187309*x_57 - 0.00202737598996054*x_58 - 0.0021201959763727*x_59 + 5.42153103839745e-5*x_6 + 7.85993418891387e-5*x_60 + 0.000112152554295373*x_61 + 3.14586985654108e-5*x_62 + 5.5302078979893e-5*x_63 - 5.15640507127043e-5*x_64 - 1.57735618224551e-5*x_65 + 0.000468237327580809*x_66 + 6.8594789374765e-5*x_67 + 0.000533731176779482*x_68 - 1.14807554438107e-5*x_69 + 0.000117298175701895*x_7 - 0.000102769929508677*x_70 - 0.000919366372590725*x_71 + 0.000239922128257965*x_72 - 0.000488102036495357*x_73 + 0.000636641152636833*x_74 + 0.000146333562285521*x_75 - 6.30749860342838e-5*x_76 - 7.53809711057053e-5*x_77 - 0.000160864209491994*x_78 + 0.00029305175686405*x_79 - 4.808485267461e-5*x_8 - 0.000110270217102432*x_80 - 0.000367939219654394*x_81 + 0.000760234371693035*x_82 + 4.27902787719808e-5*x_83 + 0.000324758106103613*x_84 - 5.6738353659883e-5*x_85 - 8.98812350536887e-5*x_86 - 0.000116480592775024*x_87 + 0.000148328183588422*x_88 - 0.000984433524937885*x_89 - 9.99315751815224e-5*x_9 + 0.000423068624811666*x_90 + 0.000242086497710031*x_91 + 8.97959753881923e-5*x_92 + 3.49917960356618e-5*x_93 + 0.000574955896440516*x_94 - 0.000520464335114132*x_95 - 1.88627361523405e-5*x_96 + 3.95411677658873e-5*x_97 + 0.000523735707754622*x_98 + 0.000534520096197978*x_99 + 2.00805458476404e-8*std::pow(-9.91328048706055*x_10 - 9.80399990081787, 2) - 7.08473985071132e-7*std::pow(-2.00767993927002*x_29 - 7.99128007888794, 2) + 2.80830608873585e-7*std::pow(-5.30592012405396*x_30 - 9.79191970825195, 2) - 2.69493795814894e-6*std::pow(-2.82407999038696*x_43 - 9.27255916595459, 2) - 6.72449687513823e-6*std::pow(-1.9560798406601*x_49 - 6.25687980651855, 2) - 1.96577205866574e-6*std::pow(-2.78144001960754*x_57 - 8.74015998840332, 2) + 2.2842405626541e-6*std::pow(-1.45055985450745*x_58 - 3.72727990150452, 2) - 3.35928617939847e-5*std::pow(-3.40543985366821*x_61 - 6.01567983627319, 2) - 0.000695999944582582*std::pow(0.0254871344574178*x_10 - 0.136558460597942*x_100 - 0.000979126534765326*x_101 + 0.177319014956717*x_102 - 0.0227609500205341*x_103 + 0.134094513588996*x_104 - 0.111184731813321*x_105 + 0.00132521317863843*x_106 + 0.0392210574210399*x_107 - 2.09630306891473e-5*x_110 + 0.18258388666963*x_111 - 0.0132018868238121*x_114 + 0.163226773391472*x_115 - 0.0029935546730878*x_116 - 0.144198220670447*x_117 - 0.150578784067679*x_118 + 0.000737800678316313*x_119 + 0.0662831899561336*x_120 + 0.00550931330905303*x_13 + 0.0962688639992693*x_17 + 0.174102301805015*x_18 - 0.0148550833645239*x_2 - 0.0327535368454001*x_20 + 0.182584012935014*x_21 + 0.120882892795689*x_24 + 0.00179319154980661*x_26 + 0.015510982667423*x_28 + 0.0203051755034123*x_3 + 0.082051257153331*x_32 + 0.0332030267208981*x_34 + 0.002413448873639*x_36 + 0.0335973620337296*x_37 + 0.0101167945463572*x_38 + 0.00265032629329769*x_39 - 0.215966888361759*x_40 + 0.150549314672298*x_41 + 0.00460644215142386*x_42 + 0.00143066680087395*x_43 + 0.208748568784877*x_45 + 0.161040369881168*x_46 + 0.0367977778652095*x_47 - 0.174942966877396*x_48 + 0.00506600332747338*x_49 + 0.235005476662194*x_50 - 0.00834231049310267*x_51 + 0.010892732242303*x_52 + 0.2873747762135*x_54 - 0.235392774632744*x_55 + 0.0208646323882349*x_56 + 0.226143124953115*x_58 - 0.293831957308796*x_59 - 0.00137390341054489*x_6 - 0.00306026137361953*x_61 - 0.000389829729918293*x_62 + 0.0884173042423545*x_63 - 0.0591159349975549*x_64 - 0.076914174081989*x_65 + 0.00145858674630335*x_66 - 0.00125470921617994*x_67 - 0.127279326072323*x_68 + 0.0704161244836704*x_69 + 0.162864170893932*x_70 + 0.00362513280710497*x_71 - 0.0892650520296566*x_72 - 0.0759454446267194*x_73 + 0.13333174074915*x_74 - 0.00212932301991378*x_75 + 0.00349201504308309*x_76 + 0.0458882603786584*x_77 + 0.110961505614756*x_78 + 0.0146522104391392*x_79 + 0.0118852388854917*x_8 - 0.112042780070982*x_80 - 0.0876696248265637*x_81 - 5.24209157265702e-5*x_82 + 0.104023686475703*x_83 - 0.0884445821229767*x_84 + 0.0848407115884228*x_85 - 0.000142996784892631*x_86 + 0.0782736379670179*x_87 - 0.0363545267698974*x_88 - 0.00184941590003767*x_89 + 0.0203624460429115*x_9 - 0.107494388256755*x_90 + 0.00101657235525193*x_92 + 0.00940353722305588*x_96 + 0.0105690386914215*x_98 + 0.0508445824728492*x_99 - 0.000351778064732827*std::pow(-8.66760063171387*x_23 - 8.67360019683838, 2) + 1.28722044410401*std::sin(0.437119841575623*x_1 - 7.18616008758545) - 0.914112660145022*std::sin(0.257359951734543*x_108 - 7.42712020874023) - 1.36615727178585*std::sin(0.243679970502853*x_109 - 7.43919992446899) - 0.820521307054506*std::sin(0.37407985329628*x_11 + 5.032639503479) + 0.330905275857738*std::sin(0.297039926052094*x_112 - 1.24703979492188) + 0.496156973887501*std::sin(0.182320013642311*x_113 - 0.98695981502533) - 0.895225225573569*std::sin(0.357359826564789*x_12 - 1.35935986042023) - 1.02288363129331*std::sin(0.405359864234924*x_14 - 7.59216022491455) + 1.78327281713237*std::sin(0.282559931278229*x_15 - 7.42799949645996) + 1.30888963868631*std::sin(0.194240003824234*x_16 + 8.20448017120361) + 1.08330966077216*std::sin(0.322959929704666*x_19 + 1.99087977409363) - 1.66001131127436*std::sin(0.400479853153229*x_22 + 2.00727987289429) - 1.39557638249141*std::sin(0.349199831485748*x_25 + 2.03151988983154) + 1.38064604788218*std::sin(0.298239946365356*x_27 + 5.1923999786377) - 0.632222833950806*std::sin(0.232639983296394*x_29 - 1.37055993080139) + 1.54569836311845*std::sin(0.311679929494858*x_30 - 1.0311998128891) - 0.728626429684326*std::sin(0.295199930667877*x_31 + 5.3310399055481) - 1.21679743023826*std::sin(0.248399972915649*x_33 - 1.19327986240387) - 0.525298626692447*std::sin(0.226879999041557*x_35 - 1.20903992652893) + 2.03798144143991*std::sin(0.288719952106476*x_4 - 7.37999963760376) - 1.33990000141083*std::sin(0.280639946460724*x_44 - 7.47559976577759) - 0.93482700093017*std::sin(0.376479834318161*x_5 + 2.00879979133606) + 0.559187253337782*std::sin(0.240399971604347*x_53 - 1.20711994171143) - 1.40633982921568*std::sin(0.23471999168396*x_57 + 1.97623980045319) - 0.713965675853217*std::sin(0.490879863500595*x_60 - 7.56831979751587) - 0.979612875468803*std::sin(0.429519861936569*x_7 + 8.19087982177734) - 1.07648213737383*std::sin(0.373839855194092*x_91 + 5.19048023223877) + 1.18944410406569*std::sin(0.2483199685812*x_93 - 1.21671986579895) + 0.131717578534349*std::sin(0.337679862976074*x_94 + 1.8290399312973) - 1.20223874925954*std::sin(0.285919934511185*x_95 - 1.22239983081818) - 0.881405015669031*std::sin(0.277999937534332*x_97 + 8.18935966491699) - 6.49337216332083, 2) + 0.000105947690554836*std::exp(0.343279838562012*x_23) - 0.000775024350705337*std::exp(0.148799866437912*x_49) + 0.0039888803115977*std::exp(0.172799870371819*x_49) + 0.000114026178308793*std::log(6.24751996994019 - 0.6004798412323*x_15) - 0.00212068023763083*std::sin(0.273519963026047*x_1 - 4.31824016571045) - 0.0115261090884846*std::sin(0.381679862737656*x_1 - 4.22352027893066) - 0.0101484483828931*std::sin(0.338639855384827*x_10 - 4.34327983856201) - 0.00116855816382396*std::sin(0.356239855289459*x_10 - 1.16279983520508) - 0.00021843574384974*std::sin(0.249999970197678*x_100 - 1.20175993442535) + 0.00149952835314761*std::sin(0.253279983997345*x_100 + 8.16903972625732) + 0.0035306832772808*std::sin(0.220319986343384*x_101 + 4.9814395904541) - 0.000132425591462017*std::sin(0.241359978914261*x_102 - 1.21223986148834) - 9.23629949734386e-5*std::sin(0.183360010385513*x_104 - 1.39951992034912) - 0.00017916354297317*std::sin(0.250479966402054*x_106 - 7.61360025405884) - 0.000178256476744506*std::sin(0.247279971837997*x_108 + 1.95583975315094) + 0.00628728285324042*std::sin(0.287599951028824*x_109 + 4.77304029464722) - 0.000619065718012642*std::sin(0.243759974837303*x_11 - 7.41639995574951) + 0.00119919395937249*std::sin(0.233999982476234*x_110 - 1.21967995166779) + 8.27123639014738e-5*std::sin(0.284559935331345*x_110 + 7.94407987594604) - 0.00263719328273591*std::sin(0.248159974813461*x_112 + 1.98031985759735) + 0.000419768535447984*std::sin(0.270559966564178*x_113 + 1.98671984672546) + 0.000232942130544122*std::sin(0.282879948616028*x_113 + 1.97383987903595) - 0.00128882598873901*std::sin(0.219999983906746*x_116 - 4.20359992980957) - 0.000189593598581397*std::sin(0.239839985966682*x_116 + 4.99567985534668) + 0.00963384342814141*std::sin(0.253439962863922*x_119 - 1.2267199754715) + 0.0106211329220443*std::sin(0.303039938211441*x_12 + 5.12728023529053) - 0.0001545722565577*std::sin(0.38087984919548*x_13 - 7.3758397102356) + 0.00135051965007813*std::sin(0.442479848861694*x_13 + 1.92767989635468) + 0.00366567227426988*std::sin(0.111040063202381*x_14 + 8.12263965606689) + 0.000135948884698899*std::sin(0.260159969329834*x_14 + 2.13895988464355) + 0.0104652387792486*std::sin(0.313599914312363*x_14 - 7.46143960952759) + 0.00130695764121622*std::sin(0.378799855709076*x_14 + 5.03047943115234) + 0.0130281963915468*std::sin(0.252079963684082*x_15 - 7.4113597869873) - 0.000675151458205576*std::sin(0.290639936923981*x_15 + 5.16328001022339) - 0.000916392770512029*std::sin(0.337679862976074*x_16 - 1.15767979621887) + 0.0165241900831282*std::sin(0.447039842605591*x_16 - 1.24167990684509) - 0.000112358096637069*std::sin(0.315039932727814*x_17 + 1.82631993293762) - 0.00118365663397958*std::sin(0.345279842615128*x_17 - 1.17911994457245) + 0.000242232023082379*std::sin(0.178240016102791*x_18 + 1.95119976997375) - 0.0116887192448131*std::sin(0.443679869174957*x_18 + 1.94863975048065) - 0.000398385546779282*std::sin(0.390159845352173*x_19 - 1.16807985305786) + 0.0014768449436159*std::sin(0.367999851703644*x_2 - 7.41447973251343) - 0.00017219636264861*std::sin(0.404399842023849*x_2 + 1.97687971591949) - 0.00978841825312784*std::sin(0.405919849872589*x_2 + 2.01239991188049) - 0.000974050480707893*std::sin(0.269759953022003*x_21 - 1.17471981048584) + 0.0011011411154947*std::sin(0.298719942569733*x_21 - 7.41016006469727) + 0.000186009646364193*std::sin(0.315119922161102*x_22 - 4.36552000045776) + 0.010816755879725*std::sin(0.398959845304489*x_22 - 1.17631983757019) - 0.00128822430519419*std::sin(0.273519963026047*x_23 - 4.36448001861572) + 0.0104624492491774*std::sin(0.422159850597382*x_23 + 5.19608020782471) - 0.000163476881043255*std::sin(0.388799846172333*x_24 + 5.20887994766235) - 0.000214199622897168*std::sin(0.24551996588707*x_25 - 7.39271974563599) + 0.00162208473942987*std::sin(0.342239856719971*x_25 - 1.15543985366821) + 0.000844542278934245*std::sin(0.369199842214584*x_26 - 1.15751981735229) - 0.000158173085813683*std::sin(0.442559868097305*x_26 - 7.44799947738647) - 0.000507222806855222*std::sin(0.319439917802811*x_27 + 1.80935990810394) - 0.000140333734123358*std::sin(0.369999825954437*x_27 - 4.38503980636597) - 0.00154387621722081*std::sin(0.234079986810684*x_28 - 1.18439984321594) + 0.000677140666321028*std::sin(0.31687992811203*x_28 + 1.99743974208832) + 0.00255602836957206*std::sin(0.685199856758118*x_28 + 4.94039964675903) + 0.00208531591160713*std::sin(0.278799951076508*x_29 - 1.16959989070892) + 0.00129207571823136*std::sin(0.350799858570099*x_3 - 4.20911979675293) - 0.000117888538884241*std::sin(0.458639860153198*x_3 - 4.39296007156372) - 0.00479896487072662*std::sin(0.554639875888824*x_3 + 8.19847965240479) - 0.0103381227100604*std::sin(0.24679996073246*x_30 + 8.22175979614258) + 0.000464277501475072*std::sin(0.329039841890335*x_30 - 1.17311990261078) + 0.0119858118631619*std::sin(0.328239858150482*x_31 - 4.25680017471313) + 4.38768144960472e-5*std::sin(0.404639840126038*x_31 - 1.20063984394073) + 0.000642658614986605*std::sin(0.513359844684601*x_31 + 8.15312004089355) + 0.000335317307853834*std::sin(0.257599949836731*x_32 + 8.03176021575928) + 0.0196612115199583*std::sin(0.305119931697845*x_32 - 1.15055990219116) + 0.000581991292171294*std::sin(0.233999997377396*x_35 - 1.21071982383728) + 0.00330210204701535*std::sin(0.24975997209549*x_36 - 7.42927980422974) + 0.00321509896708295*std::sin(0.218239992856979*x_37 + 1.97247982025146) + 0.00819772685707369*std::sin(0.240559980273247*x_39 - 1.21007990837097) + 0.000125601518593296*std::sin(0.3713598549366*x_4 - 1.20103991031647) + 0.00162805613304397*std::sin(0.380799859762192*x_4 + 1.98911988735199) - 0.000358045202000189*std::sin(1.04431986808777*x_4 + 6.76743984222412) - 0.0179847128232833*std::sin(0.232239991426468*x_41 - 4.4125599861145) + 0.000416533005216542*std::sin(0.248079970479012*x_41 + 1.96991980075836) + 0.0110988986503359*std::sin(0.249439969658852*x_42 + 1.97775983810425) - 0.00395649763859505*std::sin(0.221519991755486*x_45 + 1.96543979644775) + 0.000314687026202327*std::sin(0.199280008673668*x_47 + 1.97479975223541) + 0.00100810143678605*std::sin(0.219679996371269*x_48 - 7.40263986587524) + 5.35865804632157e-5*std::sin(0.364319831132889*x_49 + 1.84487986564636) - 0.000219709117922353*std::sin(0.308079928159714*x_5 + 2.01263976097107) + 0.00764820395763781*std::sin(0.31399992108345*x_5 - 1.18407988548279) + 0.00250448172846851*std::sin(0.230079978704453*x_50 - 7.44495964050293) - 0.00033953372351147*std::sin(0.199359998106956*x_51 - 4.39431953430176) - 0.0155672771757258*std::sin(0.208000004291534*x_51 + 8.20343971252441) + 0.00110032263351118*std::sin(0.210879996418953*x_51 + 8.1988000869751) - 0.00739585517569364*std::sin(0.22639998793602*x_53 + 1.97503972053528) + 0.000211943905969264*std::sin(0.253679990768433*x_53 - 7.42943954467773) + 0.00324964846572067*std::sin(0.254559963941574*x_53 + 5.15840005874634) + 0.00265790706525494*std::sin(0.193759992718697*x_54 - 4.3953595161438) + 0.000231458416073635*std::sin(0.226559996604919*x_55 - 7.41791963577271) + 0.00165497114562503*std::sin(0.18792000412941*x_56 + 8.20448017120361) - 0.0115398154691008*std::sin(0.245999976992607*x_57 - 7.43856000900269) - 0.00236515711154445*std::sin(0.0536801069974899*x_59 + 8.01991939544678) - 0.000876956043124331*std::sin(0.385519832372665*x_59 + 1.81727981567383) - 0.000868016511662883*std::sin(0.24415996670723*x_6 - 1.15775990486145) + 0.00686155728446844*std::sin(0.397839844226837*x_6 + 1.98791980743408) - 0.00171335598571101*std::sin(0.355519831180573*x_60 + 8.25080013275146) - 0.000934213822020697*std::sin(0.410879880189896*x_60 - 1.20055997371674) + 0.000133652226797774*std::sin(0.417359858751297*x_60 - 1.23583984375) - 1.05110753188274e-5*std::sin(1.03327977657318*x_64 - 4.59127998352051) - 0.000131453888861668*std::sin(0.312879920005798*x_7 - 7.39871978759766) - 0.00204145660735934*std::sin(0.350159853696823*x_7 + 2.01959991455078) + 0.00081155707195594*std::sin(0.366479843854904*x_7 + 2.00175976753235) - 0.000418001918200746*std::sin(0.355759829282761*x_8 - 1.14231991767883) - 0.00244825099800823*std::sin(0.494479864835739*x_8 - 1.44279980659485) + 0.000283220960890569*std::sin(0.312239944934845*x_9 - 7.42360019683838) - 0.00161126597640627*std::sin(0.365279853343964*x_91 + 1.97591972351074) + 0.00281850788404409*std::sin(0.263279944658279*x_92 - 7.39527988433838) + 0.000192419216406719*std::sin(0.292799949645996*x_92 - 1.16527986526489) + 0.00270281417645113*std::sin(0.236319988965988*x_93 + 1.98023986816406) - 0.000941794257526142*std::sin(0.236479982733727*x_93 - 1.18967986106873) + 0.000594379555558046*std::sin(0.291119933128357*x_94 + 1.8025598526001) + 9.69066566963053e-5*std::sin(0.267839968204498*x_95 + 1.96391975879669) - 0.000268769381759092*std::sin(0.276799947023392*x_97 + 1.95687973499298) + 0.00331304463302619*std::sin(0.279599964618683*x_97 - 1.20447981357574) + 0.000756187865825612*std::sin(0.291679948568344*x_97 + 8.16464042663574) + 0.000217508648102643*std::sin(0.230719983577728*x_98 + 5.18800020217896) + 0.0143786613979797*std::sin(0.232399985194206*x_98 + 1.98495984077454) + 0.299192487559498);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-5.51576210356254e-5*x_1 + 0.000141478913310692*x_10 - 0.000880405001706721*x_100 - 0.000583195620655767*x_101 + 0.00179120759907914*x_102 - 0.000681063791874695*x_103 + 0.0013659419435732*x_104 - 0.00082038618123882*x_105 + 0.000630438865556398*x_106 - 0.000665985894291983*x_107 - 0.000583265219422578*x_108 - 0.000160977697019157*x_109 + 0.000208304729532427*x_11 + 0.000347299456339191*x_110 + 0.000758070651981101*x_111 - 0.000273239634962427*x_112 + 0.000124900599571606*x_113 - 0.00101486507257314*x_114 - 0.000100130969695185*x_115 + 4.02018624859906e-5*x_116 - 0.00156403550347983*x_117 - 0.00199120305797983*x_118 - 5.85697460481005e-5*x_119 - 9.85083236642125e-5*x_12 + 0.000590054595836525*x_120 + 0.000106551487026345*x_13 - 0.000291219055534315*x_15 - 0.000509509422282074*x_16 + 0.000447116072701195*x_17 + 0.00114209878796862*x_18 + 2.48244283500898e-5*x_19 - 0.000177596895931482*x_2 - 0.000190144644627347*x_20 + 0.0010956304086165*x_21 - 3.02458802312453e-5*x_22 + 0.000955412287968437*x_24 - 6.53394674252356e-6*x_25 - 0.000166075766612703*x_26 - 3.52514851839927e-6*x_27 + 9.30766281492606e-5*x_28 - 2.82778267435893e-5*x_29 + 0.000325003963502854*x_3 - 6.45435981654565e-5*x_30 - 2.17599871202022e-5*x_31 + 0.000418456148389652*x_32 + 2.24075873087436e-5*x_33 + 0.000710361338688126*x_34 - 6.50640258393541e-5*x_35 + 3.14724200874237e-5*x_36 - 9.79605141938764e-5*x_37 - 0.000359809435204397*x_38 + 0.000712943899986265*x_39 + 5.98086805301175e-5*x_4 - 0.00117362620715926*x_40 + 0.00101293790065361*x_41 - 9.6388686471908e-5*x_42 - 0.000384406823948668*x_43 - 0.00077778793405136*x_44 + 0.000678743616731911*x_45 + 0.000219095831763634*x_46 + 0.000109385383823697*x_47 - 0.00105980467109783*x_48 + 3.03995251638364e-5*x_49 + 3.45061782115815e-6*x_5 + 0.00114814682480741*x_50 + 4.28865108037966e-5*x_51 - 0.000791504602437376*x_52 - 0.000161715004104284*x_53 + 0.0012768338417597*x_54 - 0.00282952302154877*x_55 - 0.000477817023194459*x_56 - 0.000241475290543878*x_57 + 0.00138113002169017*x_58 - 0.00180053293170093*x_59 - 6.80027926334494e-5*x_6 - 0.000119373164576762*x_61 - 9.40390340283502e-5*x_62 + 0.000724807252782752*x_63 - 0.000213419361990545*x_64 - 0.000313209928798006*x_65 - 0.00020181621837133*x_66 - 7.86342748761037e-5*x_67 - 0.000619799746280916*x_68 + 0.000325393956191583*x_69 + 0.00127730039437951*x_70 + 0.000251983859466404*x_71 - 0.000548167326174515*x_72 - 0.000671887890089236*x_73 + 0.000807678975707543*x_74 - 0.000155358042816432*x_75 - 0.000153074737452083*x_76 + 0.000344940514115594*x_77 + 0.000713477408341078*x_78 - 2.17587077799951e-5*x_79 + 8.23564574652452e-5*x_8 - 0.0005790528683437*x_80 - 0.000376701508723709*x_81 - 7.42869845167263e-6*x_82 + 0.000333518948716411*x_83 - 0.000330061187051993*x_84 + 0.000235242070067062*x_85 - 0.000231738564943455*x_86 + 0.000307776356789136*x_87 - 0.000381442829335931*x_88 + 8.75900438843866e-5*x_89 + 0.000328544399713205*x_9 - 0.000484263270631059*x_90 + 0.000135645771005814*x_91 - 4.64399423728518e-5*x_92 - 0.000341845411586485*x_94 + 0.000109855200535095*x_95 + 9.50771302712607e-5*x_96 - 0.000441000503842282*x_98 + 4.77914568452934e-7*x_99 - 2.11091178581297e-6*std::pow(-8.66760063171387*x_23 - 8.67360019683838, 2) + 2.91906306063574e-6*std::pow(-2.82407999038696*x_43 - 9.27255916595459, 2) + 7.28374112295303e-6*std::pow(-1.9560798406601*x_49 - 6.25687980651855, 2) - 7.32827782111267e-6*std::pow(-2.78144001960754*x_57 - 8.74015998840332, 2) + 0.00203542225062847*std::pow(-0.071070235510317*x_1 - 0.0770205550751531*x_101 + 0.249462789700615*x_103 - 0.121816126756549*x_105 - 0.149943625370975*x_107 - 0.249289825249736*x_109 + 0.00139606125799482*x_11 - 0.121661652505336*x_111 + 0.052869817303079*x_112 + 0.341792901405734*x_114 + 0.255989648270331*x_115 - 0.126669795760157*x_117 + 0.0606872607340446*x_118 + 0.129997643132559*x_119 - 0.15428903467282*x_12 + 0.413915402933864*x_120 + 0.0279919561994514*x_16 + 0.211045441478201*x_19 - 0.216417267160304*x_20 + 0.142011046654908*x_21 + 0.0131694626907989*x_22 - 0.111482905489158*x_23 - 0.0695574341575998*x_28 - 0.0799806310680199*x_32 - 0.00249933099977962*x_33 - 0.00250434033403891*x_34 - 0.270815538248924*x_35 + 0.339065968376381*x_36 + 0.26426017592245*x_37 - 0.275291489585689*x_38 - 0.0261814824583907*x_39 - 0.204826200832178*x_40 - 0.189104638704057*x_41 + 0.0495595235818161*x_42 + 0.385519174969704*x_43 - 0.00821204653669385*x_44 + 0.00805547846683643*x_45 - 0.161481186049022*x_46 + 0.10207452230886*x_48 - 0.0677391885500215*x_5 - 0.165039443743454*x_50 + 0.0156853088192298*x_52 + 0.0142957542571754*x_54 - 0.197381075609212*x_56 + 0.0244632997798761*x_57 - 0.00702544262867151*x_6 - 0.00527938843728614*x_61 + 0.000167078887153819*x_62 - 0.103249083682048*x_63 + 0.00499841723948513*x_64 + 0.07829472606192*x_65 - 0.0144123851038366*x_66 - 0.0215517836552759*x_67 - 0.0244655211758481*x_68 - 0.0047842735110411*x_69 + 0.0520370680256498*x_70 - 0.0126922548878761*x_71 - 0.0374742055749607*x_72 - 0.0647996004106488*x_73 + 0.0746143173276068*x_74 + 0.0466104469926467*x_75 + 0.0866855247762877*x_76 + 0.0688962312786211*x_77 + 0.0147562046181949*x_78 + 0.151028050635687*x_79 - 0.278814984811414*x_8 - 0.0947094988124721*x_80 + 0.0960502342353868*x_81 - 0.124826267759387*x_82 - 0.0296232014505488*x_83 + 0.0897584976694987*x_84 - 0.0395767955478613*x_85 - 0.161085280805809*x_86 - 0.0534390577846503*x_87 + 0.130387405129205*x_88 - 0.003426829328441*x_89 + 0.00247139810379732*x_90 + 0.0319276391163106*x_91 + 0.00593715389582386*x_93 - 0.0968080461957992*x_94 + 0.102496634352574*x_96 + 0.124595670506736*x_99 + 0.000147742177033332*std::pow(-9.91328048706055*x_10 - 9.80399990081787, 2) - 0.00521258185509876*std::pow(-2.00767993927002*x_29 - 7.99128007888794, 2) + 0.00206620506471217*std::pow(-5.30592012405396*x_30 - 9.79191970825195, 2) + 0.0168062499971342*std::pow(-1.45055985450745*x_58 - 3.72727990150452, 2) + 0.838945113840694*std::log(6.24751996994019 - 0.6004798412323*x_15) - 1.6071362094994*std::sin(0.249999970197678*x_100 - 1.20175993442535) - 0.974318393831112*std::sin(0.241359978914261*x_102 - 1.21223986148834) - 0.679558716094263*std::sin(0.183360010385513*x_104 - 1.39951992034912) - 1.31819185019671*std::sin(0.250479966402054*x_106 - 7.61360025405884) - 1.3115181302514*std::sin(0.247279971837997*x_108 + 1.95583975315094) + 0.608554408983501*std::sin(0.284559935331345*x_110 + 7.94407987594604) + 1.71386663243595*std::sin(0.282879948616028*x_113 + 1.97383987903595) - 1.3949307562917*std::sin(0.239839985966682*x_116 + 4.99567985534668) - 1.13726199805832*std::sin(0.38087984919548*x_13 - 7.3758397102356) + 1.00024094678825*std::sin(0.260159969329834*x_14 + 2.13895988464355) - 0.826672239411891*std::sin(0.315039932727814*x_17 + 1.82631993293762) + 1.78221681367214*std::sin(0.178240016102791*x_18 + 1.95119976997375) - 1.26693097328906*std::sin(0.404399842023849*x_2 + 1.97687971591949) - 1.20277757802025*std::sin(0.388799846172333*x_24 + 5.20887994766235) - 1.57596904220932*std::sin(0.24551996588707*x_25 - 7.39271974563599) - 1.16375502058075*std::sin(0.442559868097305*x_26 - 7.44799947738647) - 1.03250238055844*std::sin(0.369999825954437*x_27 - 4.38503980636597) - 0.867362347327969*std::sin(0.458639860153198*x_3 - 4.39296007156372) + 0.322822703332807*std::sin(0.404639840126038*x_31 - 1.20063984394073) + 0.924110426900896*std::sin(0.3713598549366*x_4 - 1.20103991031647) + 2.31530291497231*std::sin(0.199280008673668*x_47 + 1.97479975223541) + 0.394262094142107*std::sin(0.364319831132889*x_49 + 1.84487986564636) - 2.4981119471766*std::sin(0.199359998106956*x_51 - 4.39431953430176) + 1.55937265423123*std::sin(0.253679990768433*x_53 - 7.42943954467773) + 1.70295023565924*std::sin(0.226559996604919*x_55 - 7.41791963577271) - 17.401591736437*std::sin(0.0536801069974899*x_59 + 8.01991939544678) + 0.983343336494812*std::sin(0.417359858751297*x_60 - 1.23583984375) - 0.967169113194331*std::sin(0.312879920005798*x_7 - 7.39871978759766) + 2.08379202741452*std::sin(0.312239944934845*x_9 - 7.42360019683838) + 1.41572017766225*std::sin(0.292799949645996*x_92 - 1.16527986526489) + 0.712988607877719*std::sin(0.267839968204498*x_95 + 1.96391975879669) - 1.97746484992373*std::sin(0.276799947023392*x_97 + 1.95687973499298) + 1.60031512281014*std::sin(0.230719983577728*x_98 + 5.18800020217896) + 6.70561728977426, 2) - 0.00292805000208318*std::pow(-0.000987524530122112*x_100 + 0.0402231364054737*x_102 + 0.0440403866708099*x_103 - 0.0292726078401024*x_104 - 0.0778756052229955*x_105 + 0.0307512749220561*x_106 + 0.00047132102610798*x_107 - 0.00324229201960306*x_108 + 0.00538592578060096*x_11 - 0.000734644027343299*x_110 - 0.146153278937592*x_111 - 0.165180635153798*x_112 - 0.0242507055594962*x_113 + 0.0119224037785532*x_114 - 0.0952501297307835*x_115 - 0.00406491517782554*x_116 - 0.135370507819356*x_117 - 0.0810294513831012*x_118 + 0.00782227732373182*x_120 - 0.0557433676816359*x_13 + 0.0634273174236829*x_17 + 0.021105102136491*x_19 - 0.000640880880397678*x_20 - 0.0553957475441388*x_21 + 0.180275376200866*x_24 - 0.034453003616412*x_25 - 0.116902200726763*x_26 + 0.0182523789864489*x_27 - 0.0463075602889764*x_29 + 0.0834578602200741*x_33 + 0.0177069088072601*x_34 + 0.00379179757087014*x_35 + 0.131944019398237*x_36 - 0.00653049487836319*x_37 + 0.0121732054488349*x_38 + 0.000219533114556875*x_40 - 0.120774691711331*x_43 + 0.0141255474574608*x_44 + 0.00447546404908697*x_45 - 0.165870302969973*x_46 - 0.0383526495507899*x_47 + 0.0946188194294682*x_48 + 0.00946753510811203*x_50 + 0.194017213169781*x_52 + 0.168762489275821*x_54 + 0.0169416876505709*x_55 + 0.0021371427682477*x_56 - 0.131170918611431*x_58 - 0.130334525360006*x_59 + 0.0047544273022158*x_60 - 0.00297640105200439*x_62 + 0.00135072259038918*x_63 + 0.00473168865579024*x_64 + 0.00571545190374972*x_65 + 0.0177044203496856*x_66 + 0.000227025067813449*x_67 + 0.0400777666793924*x_68 - 0.00575216692589502*x_69 + 0.00709529667365144*x_7 - 0.000569362143122202*x_70 - 0.0471524734882971*x_71 + 0.014573195384018*x_72 - 0.035291347765789*x_73 + 0.0378982785660825*x_74 - 0.00103899332131608*x_75 - 0.00152170697013859*x_76 - 0.00155949107742456*x_77 - 0.00164363528628307*x_78 + 0.0105231601196463*x_79 - 0.000688128825402708*x_80 - 0.0149751417393008*x_81 + 0.0467211585753082*x_82 - 0.00132012309755347*x_83 + 0.0103024184859935*x_84 + 0.0015787363915977*x_85 - 0.00103042102857219*x_86 - 0.0148862856442658*x_87 - 0.00162979644174804*x_88 - 0.0536821911751311*x_89 - 0.00411290230924274*x_9 + 0.0247637018812276*x_90 + 0.0121801916639799*x_91 + 0.00628421847826627*x_92 + 0.00206782064014361*x_93 + 0.0164842749608797*x_94 - 0.0154430198660252*x_95 + 0.00201702066724358*x_96 + 0.00239182164976381*x_97 + 0.015682447787202*x_99 - 0.00203201217000207*std::pow(-3.40543985366821*x_61 - 6.01567983627319, 2) + 0.24128499047079*std::exp(0.172799870371819*x_49) - 0.697207462829681*std::sin(0.381679862737656*x_1 - 4.22352027893066) - 0.613873588595816*std::sin(0.338639855384827*x_10 - 4.34327983856201) + 0.213568925203688*std::sin(0.220319986343384*x_101 + 4.9814395904541) + 0.380313989096265*std::sin(0.287599951028824*x_109 + 4.77304029464722) + 0.582745441871914*std::sin(0.253439962863922*x_119 - 1.2267199754715) + 0.642465994387777*std::sin(0.303039938211441*x_12 + 5.12728023529053) + 0.633036050689157*std::sin(0.313599914312363*x_14 - 7.46143960952759) + 0.788067827717512*std::sin(0.252079963684082*x_15 - 7.4113597869873) + 0.999538400576412*std::sin(0.447039842605591*x_16 - 1.24167990684509) - 0.707043654180445*std::sin(0.443679869174957*x_18 + 1.94863975048065) - 0.592095580823297*std::sin(0.405919849872589*x_2 + 2.01239991188049) + 0.654299110398462*std::sin(0.398959845304489*x_22 - 1.17631983757019) + 0.632867313679249*std::sin(0.422159850597382*x_23 + 5.19608020782471) + 0.15461263126951*std::sin(0.685199856758118*x_28 + 4.94039964675903) - 0.290286522194279*std::sin(0.554639875888824*x_3 + 8.19847965240479) - 0.62534687549541*std::sin(0.24679996073246*x_30 + 8.22175979614258) + 0.725014609432925*std::sin(0.328239858150482*x_31 - 4.25680017471313) + 1.18929495589131*std::sin(0.305119931697845*x_32 - 1.15055990219116) + 0.495875607207402*std::sin(0.240559980273247*x_39 - 1.21007990837097) - 0.0216579406761204*std::sin(1.04431986808777*x_4 + 6.76743984222412) - 1.08788454984945*std::sin(0.232239991426468*x_41 - 4.4125599861145) + 0.671365758279649*std::sin(0.249439969658852*x_42 + 1.97775983810425) + 0.462635294839956*std::sin(0.31399992108345*x_5 - 1.18407988548279) - 0.941655309656724*std::sin(0.208000004291534*x_51 + 8.20343971252441) - 0.447370867559528*std::sin(0.22639998793602*x_53 + 1.97503972053528) - 0.698036553616575*std::sin(0.245999976992607*x_57 - 7.43856000900269) + 0.415051506856223*std::sin(0.397839844226837*x_6 + 1.98791980743408) - 0.148093242358508*std::sin(0.494479864835739*x_8 - 1.44279980659485) + 0.869756650332945*std::sin(0.232399985194206*x_98 + 1.98495984077454) + 3.24952097221124, 2) + 0.000394966500550478*std::exp(0.343279838562012*x_23) - 0.00288924330522389*std::exp(0.148799866437912*x_49) + 0.00229704707166631*std::sin(0.273519963026047*x_1 - 4.31824016571045) + 0.00772421330040079*std::sin(0.437119841575623*x_1 - 7.18616008758545) + 0.00126574155813435*std::sin(0.356239855289459*x_10 - 1.16279983520508) - 0.00162423695536787*std::sin(0.253279983997345*x_100 + 8.16903972625732) - 0.00548530844106638*std::sin(0.257359951734543*x_108 - 7.42712020874023) - 0.00819788888337053*std::sin(0.243679970502853*x_109 - 7.43919992446899) - 0.00230783907580948*std::sin(0.243759974837303*x_11 - 7.41639995574951) - 0.00492369556608794*std::sin(0.37407985329628*x_11 + 5.032639503479) + 0.00447052162377696*std::sin(0.233999982476234*x_110 - 1.21967995166779) + 0.00285651603671006*std::sin(0.248159974813461*x_112 + 1.98031985759735) + 0.00198566061055087*std::sin(0.297039926052094*x_112 - 1.24703979492188) + 0.00297728513740012*std::sin(0.182320013642311*x_113 - 0.98695981502533) + 0.00156487138718024*std::sin(0.270559966564178*x_113 + 1.98671984672546) + 0.0013960114829135*std::sin(0.219999983906746*x_116 - 4.20359992980957) - 0.005371970765305*std::sin(0.357359826564789*x_12 - 1.35935986042023) - 0.00146283591104026*std::sin(0.442479848861694*x_13 + 1.92767989635468) + 0.013665401697302*std::sin(0.111040063202381*x_14 + 8.12263965606689) - 0.00141565105821967*std::sin(0.378799855709076*x_14 + 5.03047943115234) - 0.00613800952726295*std::sin(0.405359864234924*x_14 - 7.59216022491455) + 0.0107008707602721*std::sin(0.282559931278229*x_15 - 7.42799949645996) - 0.00251692327971028*std::sin(0.290639936923981*x_15 + 5.16328001022339) + 0.00785424346094418*std::sin(0.194240003824234*x_16 + 8.20448017120361) + 0.00099260477494357*std::sin(0.337679862976074*x_16 - 1.15767979621887) + 0.00128209569585026*std::sin(0.345279842615128*x_17 - 1.17911994457245) + 0.0065006075132791*std::sin(0.322959929704666*x_19 + 1.99087977409363) - 0.00148515691524074*std::sin(0.390159845352173*x_19 - 1.16807985305786) - 0.00159966707513999*std::sin(0.367999851703644*x_2 - 7.41447973251343) - 0.00363120052650497*std::sin(0.269759953022003*x_21 - 1.17471981048584) - 0.00119271775629136*std::sin(0.298719942569733*x_21 - 7.41016006469727) + 0.000693432567603463*std::sin(0.315119922161102*x_22 - 4.36552000045776) - 0.00996121643972671*std::sin(0.400479853153229*x_22 + 2.00727987289429) + 0.00139535976022557*std::sin(0.273519963026047*x_23 - 4.36448001861572) - 0.00175698577021898*std::sin(0.342239856719971*x_25 - 1.15543985366821) - 0.00837442390286832*std::sin(0.349199831485748*x_25 + 2.03151988983154) + 0.00314840188333258*std::sin(0.369199842214584*x_26 - 1.15751981735229) + 0.00828483156482218*std::sin(0.298239946365356*x_27 + 5.1923999786377) - 0.00189089555396499*std::sin(0.319439917802811*x_27 + 1.80935990810394) + 0.00167227301921963*std::sin(0.234079986810684*x_28 - 1.18439984321594) + 0.00252433892571552*std::sin(0.31687992811203*x_28 + 1.99743974208832) - 0.00379377444258903*std::sin(0.232639983296394*x_29 - 1.37055993080139) - 0.00225874166376335*std::sin(0.278799951076508*x_29 - 1.16959989070892) + 0.00481677913132001*std::sin(0.350799858570099*x_3 - 4.20911979675293) + 0.00927525965695626*std::sin(0.311679929494858*x_30 - 1.0311998128891) + 0.0017307980861274*std::sin(0.329039841890335*x_30 - 1.17311990261078) - 0.00437226271923355*std::sin(0.295199930667877*x_31 + 5.3310399055481) - 0.000696105458730212*std::sin(0.513359844684601*x_31 + 8.15312004089355) - 0.000363204044823452*std::sin(0.257599949836731*x_32 + 8.03176021575928) - 0.00730162649108798*std::sin(0.248399972915649*x_33 - 1.19327986240387) - 0.00315215521751938*std::sin(0.226879999041557*x_35 - 1.20903992652893) + 0.00216962788727115*std::sin(0.233999997377396*x_35 - 1.21071982383728) - 0.0035767220832471*std::sin(0.24975997209549*x_36 - 7.42927980422974) - 0.00348248337321512*std::sin(0.218239992856979*x_37 + 1.97247982025146) + 0.0122292987405879*std::sin(0.288719952106476*x_4 - 7.37999963760376) - 0.00176345377608411*std::sin(0.380799859762192*x_4 + 1.98911988735199) + 0.0015528095286702*std::sin(0.248079970479012*x_41 + 1.96991980075836) - 0.0080403270935528*std::sin(0.280639946460724*x_44 - 7.47559976577759) + 0.00428554062678614*std::sin(0.221519991755486*x_45 + 1.96543979644775) + 0.00375814040496911*std::sin(0.219679996371269*x_48 - 7.40263986587524) - 0.000819062133307282*std::sin(0.308079928159714*x_5 + 2.01263976097107) - 0.00560960881815761*std::sin(0.376479834318161*x_5 + 2.00879979133606) - 0.00271276749711562*std::sin(0.230079978704453*x_50 - 7.44495964050293) + 0.00410193537734042*std::sin(0.210879996418953*x_51 + 8.1988000869751) + 0.00335551042514151*std::sin(0.240399971604347*x_53 - 1.20711994171143) - 0.003519906188435*std::sin(0.254559963941574*x_53 + 5.15840005874634) - 0.00287895248546559*std::sin(0.193759992718697*x_54 - 4.3953595161438) + 0.00616963105544252*std::sin(0.18792000412941*x_56 + 8.20448017120361) - 0.00843901203050921*std::sin(0.23471999168396*x_57 + 1.97623980045319) - 0.00326923841072438*std::sin(0.385519832372665*x_59 + 1.81727981567383) - 0.00323591238502812*std::sin(0.24415996670723*x_6 - 1.15775990486145) + 0.0018558476095841*std::sin(0.355519831180573*x_60 + 8.25080013275146) - 0.00348269190311821*std::sin(0.410879880189896*x_60 - 1.20055997371674) - 0.00428428805238076*std::sin(0.490879863500595*x_60 - 7.56831979751587) - 3.91846449314629e-5*std::sin(1.03327977657318*x_64 - 4.59127998352051) + 0.00221123479092132*std::sin(0.350159853696823*x_7 + 2.01959991455078) + 0.0030254350522301*std::sin(0.366479843854904*x_7 + 2.00175976753235) - 0.00587835505301265*std::sin(0.429519861936569*x_7 + 8.19087982177734) - 0.00155828554629688*std::sin(0.355759829282761*x_8 - 1.14231991767883) + 0.00174526726241124*std::sin(0.365279853343964*x_91 + 1.97591972351074) - 0.00645963764888351*std::sin(0.373839855194092*x_91 + 5.19048023223877) - 0.00305290970634249*std::sin(0.263279944658279*x_92 - 7.39527988433838) - 0.00292759430634918*std::sin(0.236319988965988*x_93 + 1.98023986816406) - 0.00351095130234206*std::sin(0.236479982733727*x_93 - 1.18967986106873) + 0.00713748760811719*std::sin(0.2483199685812*x_93 - 1.21671986579895) + 0.00221581057433246*std::sin(0.291119933128357*x_94 + 1.8025598526001) + 0.000790396607412334*std::sin(0.337679862976074*x_94 + 1.8290399312973) - 0.00721426433197434*std::sin(0.285919934511185*x_95 - 1.22239983081818) - 0.00528903994358917*std::sin(0.277999937534332*x_97 + 8.18935966491699) - 0.00358857471180781*std::sin(0.279599964618683*x_97 - 1.20447981357574) + 0.00281902204342332*std::sin(0.291679948568344*x_97 + 8.16464042663574) - 0.0244679946454054);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000381273515807166*x_1 - 3.93925330779601e-6*x_10 - 1.19699707015032e-5*x_100 + 0.000265511968892666*x_101 - 0.000309272275293686*x_102 + 0.000739158380053526*x_103 - 0.000204292247012036*x_104 - 0.000205549469532425*x_105 - 0.000399240750795997*x_106 - 0.000286211070522198*x_107 - 0.000210665543579004*x_108 - 0.000190848749750426*x_109 - 0.000350524571870765*x_11 - 0.000508118041324187*x_110 + 0.000127039103660345*x_111 + 0.00167793217065961*x_112 + 3.54870996568465e-5*x_113 + 0.00241198594966997*x_114 + 0.00211758698016247*x_115 + 5.69612951489206e-5*x_116 + 0.000437088148544209*x_117 + 0.00134236816524914*x_118 + 0.000684210469137913*x_119 - 0.00147769959805203*x_12 + 0.00160385344247479*x_120 + 0.000532242750740905*x_13 + 0.000431515714686576*x_15 - 3.24120562051959e-5*x_16 - 0.000621743273378741*x_17 - 0.000212092957025082*x_18 + 0.000847176099790402*x_19 - 3.0401797116356e-5*x_2 - 0.00115294232818797*x_20 + 0.00122779508959952*x_21 + 0.000111954974297043*x_22 - 0.000568340066347763*x_23 - 0.00198277191675283*x_24 + 0.000311103258747974*x_25 + 0.00132524978473506*x_26 - 0.000160781374665988*x_27 - 0.000354603932958629*x_28 + 0.000411446830240346*x_29 - 0.000301031953514788*x_3 + 9.56378930620093e-5*x_30 - 7.47876724612351e-6*x_31 - 0.000433143170966067*x_32 - 0.00116255192911941*x_33 - 0.000669134243161941*x_34 - 0.0013186953682428*x_35 + 0.00053437181676316*x_36 + 0.00130363395395181*x_37 - 0.00150849646396165*x_38 - 0.000554682338442169*x_39 + 2.05558578004504e-5*x_4 - 0.00144978597731846*x_40 - 0.00112636422243479*x_41 + 0.00032930210924207*x_42 + 0.00292875058889681*x_43 - 0.000701843443505247*x_44 - 0.000196880412187255*x_45 + 0.000350079699069324*x_46 - 0.000102516318100386*x_47 - 0.000325323106215309*x_48 - 0.000350447488580553*x_5 - 0.00101754274809225*x_50 - 0.000137723551379349*x_51 - 0.0010752691360395*x_52 - 5.55804040333737e-5*x_53 - 0.00161585142919955*x_54 + 0.000602389474188511*x_55 - 0.000132158675226702*x_56 + 0.000482521519203491*x_57 + 0.00140758054505155*x_58 + 0.00124071386918724*x_59 + 5.27317067293164e-5*x_6 - 4.32413598542765e-5*x_60 + 0.000152811077090421*x_61 + 0.000157643133645765*x_62 - 0.000479701313338099*x_63 - 0.000226950211814364*x_64 + 0.000151949961468395*x_65 + 5.16366643776554e-5*x_66 - 3.31931042876257e-6*x_67 - 0.000691200341548663*x_68 + 0.000163562707194739*x_69 - 6.45314897538183e-5*x_7 + 9.64081320313807e-5*x_70 + 0.000137031707048381*x_71 - 0.000316471739931195*x_72 + 0.000164716429373706*x_73 + 3.51467753344691e-5*x_74 + 0.000497471931128584*x_75 + 0.000391326332237922*x_76 + 0.000270396109292956*x_77 - 0.000120931892961131*x_78 + 0.000832614187982729*x_79 - 0.00143775317881345*x_8 - 0.000614641435478278*x_80 + 0.0004113865601731*x_81 - 0.0010534370464021*x_82 - 1.42884082505072e-5*x_83 + 0.000568314599639424*x_84 - 0.000316368982850094*x_85 - 0.000874370936334652*x_86 + 8.35674141159197e-5*x_87 + 0.000931908427973688*x_88 + 0.000316274140311591*x_89 - 2.54101685004327e-5*x_9 - 0.000203000034479191*x_90 + 9.86092999273237e-5*x_91 - 7.5212446888042e-5*x_92 + 1.14608612925013e-5*x_93 - 0.000136919899337959*x_94 - 0.000273195762811628*x_95 + 0.000400251271503372*x_96 - 2.17535391941917e-5*x_97 + 0.000836358759446743*x_98 + 0.000908837373746656*x_99 + 7.53189902335772e-7*std::pow(-9.91328048706055*x_10 - 9.80399990081787, 2) - 2.65737523109146e-5*std::pow(-2.00767993927002*x_29 - 7.99128007888794, 2) + 1.05335173891822e-5*std::pow(-5.30592012405396*x_30 - 9.79191970825195, 2) - 4.32534052592926e-6*std::pow(-2.82407999038696*x_43 - 9.27255916595459, 2) - 1.07927304087171e-5*std::pow(-1.9560798406601*x_49 - 6.25687980651855, 2) - 2.51868182808564e-6*std::pow(-2.78144001960754*x_57 - 8.74015998840332, 2) + 8.56782947710068e-5*std::pow(-1.45055985450745*x_58 - 3.72727990150452, 2) + 1.84810838164206e-5*std::pow(-3.40543985366821*x_61 - 6.01567983627319, 2) + 0.000135747439155905*std::exp(0.343279838562012*x_23) - 0.0009930142916826*std::exp(0.148799866437912*x_49) - 0.00219447904809073*std::exp(0.172799870371819*x_49) + 0.00427694380201388*std::log(6.24751996994019 - 0.6004798412323*x_15) - 0.0034036643205925*std::sin(0.273519963026047*x_1 - 4.31824016571045) + 0.00634107893063267*std::sin(0.381679862737656*x_1 - 4.22352027893066) + 0.00558316008683876*std::sin(0.338639855384827*x_10 - 4.34327983856201) - 0.00187552072121354*std::sin(0.356239855289459*x_10 - 1.16279983520508) - 0.0081931834834141*std::sin(0.249999970197678*x_100 - 1.20175993442535) + 0.00240672358932682*std::sin(0.253279983997345*x_100 + 8.16903972625732) - 0.00194240234657069*std::sin(0.220319986343384*x_101 + 4.9814395904541) - 0.00496707704346363*std::sin(0.241359978914261*x_102 - 1.21223986148834) - 0.00346439164011362*std::sin(0.183360010385513*x_104 - 1.39951992034912) - 0.00672014458461294*std::sin(0.250479966402054*x_106 - 7.61360025405884) - 0.00668612194751121*std::sin(0.247279971837997*x_108 + 1.95583975315094) - 0.00345894321540318*std::sin(0.287599951028824*x_109 + 4.77304029464722) - 0.000793189407426796*std::sin(0.243759974837303*x_11 - 7.41639995574951) + 0.00153648945232828*std::sin(0.233999982476234*x_110 - 1.21967995166779) + 0.00310241154606025*std::sin(0.284559935331345*x_110 + 7.94407987594604) - 0.00423266106963033*std::sin(0.248159974813461*x_112 + 1.98031985759735) + 0.000537836204138833*std::sin(0.270559966564178*x_113 + 1.98671984672546) + 0.00873729538457893*std::sin(0.282879948616028*x_113 + 1.97383987903595) - 0.00206854902284753*std::sin(0.219999983906746*x_116 - 4.20359992980957) - 0.00711135967530433*std::sin(0.239839985966682*x_116 + 4.99567985534668) - 0.0053000506167544*std::sin(0.253439962863922*x_119 - 1.2267199754715) - 0.00584320707659366*std::sin(0.303039938211441*x_12 + 5.12728023529053) - 0.00579776385083646*std::sin(0.38087984919548*x_13 - 7.3758397102356) + 0.0021675665504222*std::sin(0.442479848861694*x_13 + 1.92767989635468) + 0.00469671043711322*std::sin(0.111040063202381*x_14 + 8.12263965606689) + 0.0050992302682376*std::sin(0.260159969329834*x_14 + 2.13895988464355) - 0.00575744204897664*std::sin(0.313599914312363*x_14 - 7.46143960952759) + 0.00209765009028568*std::sin(0.378799855709076*x_14 + 5.03047943115234) - 0.00716745095924156*std::sin(0.252079963684082*x_15 - 7.4113597869873) - 0.000865050299952939*std::sin(0.290639936923981*x_15 + 5.16328001022339) - 0.00147079853025144*std::sin(0.337679862976074*x_16 - 1.15767979621887) - 0.00909076886028929*std::sin(0.447039842605591*x_16 - 1.24167990684509) - 0.00421437666459906*std::sin(0.315039932727814*x_17 + 1.82631993293762) - 0.0018997535703024*std::sin(0.345279842615128*x_17 - 1.17911994457245) + 0.00908574473982499*std::sin(0.178240016102791*x_18 + 1.95119976997375) + 0.00643053876727708*std::sin(0.443679869174957*x_18 + 1.94863975048065) - 0.000510438854200622*std::sin(0.390159845352173*x_19 - 1.16807985305786) + 0.00237031701075716*std::sin(0.367999851703644*x_2 - 7.41447973251343) - 0.00645881653566314*std::sin(0.404399842023849*x_2 + 1.97687971591949) + 0.00538508982282151*std::sin(0.405919849872589*x_2 + 2.01239991188049) - 0.00124802020385936*std::sin(0.269759953022003*x_21 - 1.17471981048584) + 0.00176731723163216*std::sin(0.298719942569733*x_21 - 7.41016006469727) + 0.000238328301636417*std::sin(0.315119922161102*x_22 - 4.36552000045776) - 0.00595082887730495*std::sin(0.398959845304489*x_22 - 1.17631983757019) - 0.00206758332854932*std::sin(0.273519963026047*x_23 - 4.36448001861572) - 0.00575590739142435*std::sin(0.422159850597382*x_23 + 5.19608020782471) - 0.00613176240334094*std::sin(0.388799846172333*x_24 + 5.20887994766235) - 0.00803429320469565*std::sin(0.24551996588707*x_25 - 7.39271974563599) + 0.00260342500232047*std::sin(0.342239856719971*x_25 - 1.15543985366821) + 0.00108208542370141*std::sin(0.369199842214584*x_26 - 1.15751981735229) - 0.00593282533055018*std::sin(0.442559868097305*x_26 - 7.44799947738647) - 0.00064988860777885*std::sin(0.319439917802811*x_27 + 1.80935990810394) - 0.00526369911957379*std::sin(0.369999825954437*x_27 - 4.38503980636597) - 0.00247790133690139*std::sin(0.234079986810684*x_28 - 1.18439984321594) + 0.000867599009662483*std::sin(0.31687992811203*x_28 + 1.99743974208832) - 0.00140619679338152*std::sin(0.685199856758118*x_28 + 4.94039964675903) + 0.00334690503525906*std::sin(0.278799951076508*x_29 - 1.16959989070892) + 0.00165549592470497*std::sin(0.350799858570099*x_3 - 4.20911979675293) - 0.00442181491292288*std::sin(0.458639860153198*x_3 - 4.39296007156372) + 0.00264014636656642*std::sin(0.554639875888824*x_3 + 8.19847965240479) + 0.005687509253626*std::sin(0.24679996073246*x_30 + 8.22175979614258) + 0.000594864140529077*std::sin(0.329039841890335*x_30 - 1.17311990261078) - 0.0065939840139076*std::sin(0.328239858150482*x_31 - 4.25680017471313) + 0.00164575076174863*std::sin(0.404639840126038*x_31 - 1.20063984394073) + 0.00103145875523176*std::sin(0.513359844684601*x_31 + 8.15312004089355) + 0.000538179937063149*std::sin(0.257599949836731*x_32 + 8.03176021575928) - 0.0108165984863423*std::sin(0.305119931697845*x_32 - 1.15055990219116) + 0.000745687113230646*std::sin(0.233999997377396*x_35 - 1.21071982383728) + 0.00529983102635868*std::sin(0.24975997209549*x_36 - 7.42927980422974) + 0.00516019220967486*std::sin(0.218239992856979*x_37 + 1.97247982025146) - 0.00450997232920566*std::sin(0.240559980273247*x_39 - 1.21007990837097) + 0.00471111673160146*std::sin(0.3713598549366*x_4 - 1.20103991031647) + 0.0026130090117472*std::sin(0.380799859762192*x_4 + 1.98911988735199) + 0.000196978257726694*std::sin(1.04431986808777*x_4 + 6.76743984222412) + 0.00989427418061979*std::sin(0.232239991426468*x_41 - 4.4125599861145) + 0.000533690621154158*std::sin(0.248079970479012*x_41 + 1.96991980075836) - 0.00610604947815265*std::sin(0.249439969658852*x_42 + 1.97775983810425) - 0.00635012747703962*std::sin(0.221519991755486*x_45 + 1.96543979644775) + 0.0118034187083374*std::sin(0.199280008673668*x_47 + 1.97479975223541) + 0.0012916486214701*std::sin(0.219679996371269*x_48 - 7.40263986587524) + 0.00200994891333296*std::sin(0.364319831132889*x_49 + 1.84487986564636) - 0.000281506373201458*std::sin(0.308079928159714*x_5 + 2.01263976097107) - 0.0042076527821007*std::sin(0.31399992108345*x_5 - 1.18407988548279) + 0.00401966074352036*std::sin(0.230079978704453*x_50 - 7.44495964050293) - 0.0127353795056998*std::sin(0.199359998106956*x_51 - 4.39431953430176) + 0.00856432405319979*std::sin(0.208000004291534*x_51 + 8.20343971252441) + 0.0014098087363888*std::sin(0.210879996418953*x_51 + 8.1988000869751) + 0.00406882331830917*std::sin(0.22639998793602*x_53 + 1.97503972053528) + 0.00794968478690085*std::sin(0.253679990768433*x_53 - 7.42943954467773) + 0.00521564370760504*std::sin(0.254559963941574*x_53 + 5.15840005874634) + 0.00426590642234946*std::sin(0.193759992718697*x_54 - 4.3953595161438) + 0.00868164357284035*std::sin(0.226559996604919*x_55 - 7.41791963577271) + 0.00212046240667449*std::sin(0.18792000412941*x_56 + 8.20448017120361) + 0.00634861948405563*std::sin(0.245999976992607*x_57 - 7.43856000900269) - 0.0887133481016527*std::sin(0.0536801069974899*x_59 + 8.01991939544678) - 0.00112361615890824*std::sin(0.385519832372665*x_59 + 1.81727981567383) - 0.00111216221879128*std::sin(0.24415996670723*x_6 - 1.15775990486145) - 0.00377487979628277*std::sin(0.397839844226837*x_6 + 1.98791980743408) - 0.00274991417072532*std::sin(0.355519831180573*x_60 + 8.25080013275146) - 0.00119697874771251*std::sin(0.410879880189896*x_60 - 1.20055997371674) + 0.00501308621850052*std::sin(0.417359858751297*x_60 - 1.23583984375) - 1.34675097666915e-5*std::sin(1.03327977657318*x_64 - 4.59127998352051) - 0.0049306299970432*std::sin(0.312879920005798*x_7 - 7.39871978759766) - 0.00327651141987789*std::sin(0.350159853696823*x_7 + 2.01959991455078) + 0.00103982251684725*std::sin(0.366479843854904*x_7 + 2.00175976753235) - 0.000535572693098381*std::sin(0.355759829282761*x_8 - 1.14231991767883) + 0.00134690316577695*std::sin(0.494479864835739*x_8 - 1.44279980659485) + 0.0106231757588242*std::sin(0.312239944934845*x_9 - 7.42360019683838) - 0.00258606102776035*std::sin(0.365279853343964*x_91 + 1.97591972351074) + 0.00452366865687721*std::sin(0.263279944658279*x_92 - 7.39527988433838) + 0.00721734418538889*std::sin(0.292799949645996*x_92 - 1.16527986526489) + 0.00433798175431469*std::sin(0.236319988965988*x_93 + 1.98023986816406) - 0.00120669132098487*std::sin(0.236479982733727*x_93 - 1.18967986106873) + 0.00076155980494798*std::sin(0.291119933128357*x_94 + 1.8025598526001) + 0.00363481729264611*std::sin(0.267839968204498*x_95 + 1.96391975879669) - 0.0100811196037165*std::sin(0.276799947023392*x_97 + 1.95687973499298) + 0.00531739373520993*std::sin(0.279599964618683*x_97 - 1.20447981357574) + 0.000968879696848763*std::sin(0.291679948568344*x_97 + 8.16464042663574) + 0.00815840957036863*std::sin(0.230719983577728*x_98 + 5.18800020217896) - 0.00791040811270143*std::sin(0.232399985194206*x_98 + 1.98495984077454) + 0.055896207690239*std::sin(0.00704350125089761*x_10 - 0.0377386359243034*x_100 - 0.000270586675168556*x_101 + 0.0490030256536773*x_102 - 0.00629010610075043*x_103 + 0.037057711441849*x_104 - 0.0307264749168347*x_105 + 0.000366229506774903*x_106 + 0.0108389417989758*x_107 - 5.79324180708909e-6*x_110 + 0.0504580001451281*x_111 - 0.00364840961282196*x_114 + 0.0451085619092893*x_115 - 0.000827284295916118*x_116 - 0.0398499230804624*x_117 - 0.0416132247315334*x_118 + 0.000203895028266765*x_119 + 0.0183177019036612*x_120 + 0.00152252718910925*x_13 + 0.0266043978044774*x_17 + 0.0481140703595605*x_18 - 0.00410527901577262*x_2 - 0.00905160908250922*x_20 + 0.0504580350392191*x_21 + 0.0334066117962804*x_24 + 0.000495557746802168*x_26 + 0.00428654017591406*x_28 + 0.00561144012862363*x_3 + 0.0226752887172456*x_32 + 0.00917582793126309*x_34 + 0.000666969061934159*x_36 + 0.00928480453174529*x_37 + 0.00279582842713814*x_38 + 0.000732431360352323*x_39 - 0.0596835650892794*x_40 + 0.0416050807119076*x_41 + 0.0012730140812789*x_42 + 0.000395372159958162*x_43 + 0.057688745190868*x_45 + 0.0445043380062248*x_46 + 0.0101692559772416*x_47 - 0.0483463924944317*x_48 + 0.00140001618595947*x_49 + 0.0649449773023111*x_50 - 0.00230544059363424*x_51 + 0.00301026281720832*x_52 + 0.0794175037259673*x_54 - 0.0650520090969054*x_55 + 0.00576604892839492*x_56 + 0.0624958206325773*x_58 - 0.0812019790736364*x_59 - 0.000379685303852156*x_6 - 0.000845719037154818*x_61 - 0.000107731459372336*x_62 + 0.0244345787115651*x_63 - 0.0163369939762716*x_64 - 0.0212556292769341*x_65 + 0.000403087981086876*x_66 - 0.000346745372589504*x_67 - 0.0351742991704937*x_68 + 0.0194598597073648*x_69 + 0.0450083548362161*x_70 + 0.00100182417541579*x_71 - 0.0246688581912879*x_72 - 0.0209879158883862*x_73 + 0.0368469152277599*x_74 - 0.000588449414718836*x_75 + 0.000965036393761818*x_76 + 0.0126814577730815*x_77 + 0.0306647852038758*x_78 + 0.00404921403498367*x_79 + 0.00328454715444927*x_8 - 0.0309636009847442*x_80 - 0.0242279536431726*x_81 - 1.44867908202931e-5*x_82 + 0.028747483050271*x_83 - 0.024442117094768*x_84 + 0.0234461688581935*x_85 - 3.95179000977273e-5*x_86 + 0.0216313241433283*x_87 - 0.010046761247616*x_88 - 0.000511095636392895*x_89 + 0.00562726713802226*x_9 - 0.0297066294139853*x_90 + 0.000280935021071426*x_92 + 0.00259871608179866*x_96 + 0.00292080843251278*x_98 + 0.0140511629837089*x_99 - 9.72156851576887e-5*std::pow(-8.66760063171387*x_23 - 8.67360019683838, 2) + 0.355730018350055*std::sin(0.437119841575623*x_1 - 7.18616008758545) - 0.252619755114091*std::sin(0.257359951734543*x_108 - 7.42712020874023) - 0.377544618396517*std::sin(0.243679970502853*x_109 - 7.43919992446899) - 0.226755301278859*std::sin(0.37407985329628*x_11 + 5.032639503479) + 0.0914473821420225*std::sin(0.297039926052094*x_112 - 1.24703979492188) + 0.137115542434041*std::sin(0.182320013642311*x_113 - 0.98695981502533) - 0.247400115014788*std::sin(0.357359826564789*x_12 - 1.35935986042023) - 0.28267917480383*std::sin(0.405359864234924*x_14 - 7.59216022491455) + 0.4928166537964*std::sin(0.282559931278229*x_15 - 7.42799949645996) + 0.361718412196424*std::sin(0.194240003824234*x_16 + 8.20448017120361) + 0.299378220156775*std::sin(0.322959929704666*x_19 + 1.99087977409363) - 0.458752699994573*std::sin(0.400479853153229*x_22 + 2.00727987289429) - 0.385674741592638*std::sin(0.349199831485748*x_25 + 2.03151988983154) + 0.38154866650671*std::sin(0.298239946365356*x_27 + 5.1923999786377) - 0.174718045656267*std::sin(0.232639983296394*x_29 - 1.37055993080139) + 0.427161726333914*std::sin(0.311679929494858*x_30 - 1.0311998128891) - 0.201359677271407*std::sin(0.295199930667877*x_31 + 5.3310399055481) - 0.336268254726368*std::sin(0.248399972915649*x_33 - 1.19327986240387) - 0.14516898870623*std::sin(0.226879999041557*x_35 - 1.20903992652893) + 0.563206697719224*std::sin(0.288719952106476*x_4 - 7.37999963760376) - 0.370288286106959*std::sin(0.280639946460724*x_44 - 7.47559976577759) - 0.258344270181702*std::sin(0.376479834318161*x_5 + 2.00879979133606) + 0.154534285717803*std::sin(0.240399971604347*x_53 - 1.20711994171143) - 0.388649275689165*std::sin(0.23471999168396*x_57 + 1.97623980045319) - 0.197308102225925*std::sin(0.490879863500595*x_60 - 7.56831979751587) - 0.27072107793396*std::sin(0.429519861936569*x_7 + 8.19087982177734) - 0.297491398800808*std::sin(0.373839855194092*x_91 + 5.19048023223877) + 0.328709021755921*std::sin(0.2483199685812*x_93 - 1.21671986579895) + 0.0364008331623911*std::sin(0.337679862976074*x_94 + 1.8290399312973) - 0.33224488804086*std::sin(0.285919934511185*x_95 - 1.22239983081818) - 0.243580828624907*std::sin(0.277999937534332*x_97 + 8.18935966491699) - 4.3040251275467) + 0.0423635789694691);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.45789753949887e-5*x_1 + 7.18536971113597e-6*x_10 + 3.78131066812109e-5*x_100 - 0.000128913625881656*x_101 - 0.000328641013403584*x_102 + 0.000327767447540392*x_103 + 1.63343643147739e-5*x_104 + 0.000201852861321919*x_105 - 0.000186580589415552*x_106 + 0.000111262152137091*x_107 + 0.000387074911729906*x_108 - 0.000549667776312045*x_109 + 8.95028173525115e-5*x_11 + 0.000145310487220533*x_110 + 0.000418945083112207*x_111 + 0.000103839176250716*x_112 + 4.24437569566529e-5*x_113 - 3.86226465793186e-5*x_114 + 0.000456093300870269*x_115 - 3.81245701255284e-5*x_116 + 0.00033015631194073*x_117 + 0.000264923738480705*x_118 + 1.47768781025656e-5*x_119 + 0.000438391099563903*x_12 + 0.000169855658738396*x_120 - 6.88378945928295e-5*x_13 - 0.000122053750462039*x_15 + 0.000319417579036401*x_16 + 0.000107755014449651*x_17 + 7.96705964614965e-5*x_18 + 1.90233473621611e-5*x_19 + 5.54542028895789e-5*x_2 + 2.87755400233124e-5*x_20 - 2.26230406770787e-5*x_21 - 1.26764476708981e-5*x_22 + 0.000171362823952373*x_24 - 9.97403459642402e-6*x_25 - 0.00012185599686884*x_26 + 5.97664333186522e-6*x_27 - 1.18381121755399e-6*x_29 + 8.51465605651952e-5*x_3 - 2.7051074010095e-5*x_30 + 1.36415973912065e-5*x_31 + 4.6333917526922e-5*x_32 + 0.000248365525561006*x_33 + 7.12979493632285e-5*x_34 - 2.57206618701784e-5*x_35 + 4.3233278950292e-5*x_36 + 0.000185135751108679*x_37 + 0.00018253976016859*x_38 - 5.83421026096914e-5*x_39 - 3.74947804786923e-5*x_4 + 0.000178757608292612*x_40 + 4.59087574913574e-5*x_41 + 9.40827986303727e-6*x_42 + 0.000197048176886233*x_43 + 0.00064475822383467*x_44 + 0.000361607667510429*x_45 + 0.00044567668462123*x_46 + 0.000290871016497646*x_47 + 3.44393748054148e-5*x_48 + 1.44619947932588e-6*x_5 + 0.000168147880987886*x_50 + 3.89549566810337e-5*x_51 + 9.84901820441867e-5*x_52 + 0.000101381079222231*x_53 + 0.000349535202529351*x_54 + 0.000182707542960413*x_55 - 0.000251860542936914*x_56 - 0.000101205481903357*x_57 - 0.000186899797528432*x_58 - 6.88760493196506e-5*x_59 - 2.50455433263249e-5*x_6 + 1.94165810595009e-6*x_60 - 5.95560238940063e-5*x_61 - 3.61207890849749e-5*x_62 - 0.000116744540719219*x_63 + 6.11602552114903e-5*x_64 + 5.04203905300273e-5*x_65 - 6.61923177966104e-5*x_66 - 3.157415228028e-5*x_67 + 7.02003400481985e-5*x_68 - 3.83003670499163e-5*x_69 + 2.89764453735477e-6*x_7 - 2.94862557289418e-5*x_70 + 1.18929579000102e-5*x_71 + 7.25588199208106e-6*x_72 - 2.12279991350591e-5*x_73 + 1.25283081183453e-5*x_74 - 8.26055133227947e-5*x_75 + 0.000111129111418964*x_76 + 2.38952845347149e-5*x_77 + 9.98184142043556e-5*x_78 - 3.92985067821212e-5*x_79 + 4.62566885906482e-6*x_8 + 3.87287573181112e-5*x_80 + 5.25568830750156e-5*x_81 + 1.76382347729813e-5*x_82 + 5.29804876250928e-5*x_83 - 0.000199213837984841*x_84 + 0.000175840406499807*x_85 + 0.000134681183847023*x_86 - 6.28735975908237e-5*x_87 - 7.50699603860737e-5*x_88 + 2.41726304211746e-5*x_89 - 5.44103802839167e-5*x_9 - 6.45316802470329e-5*x_90 - 8.00637015763696e-5*x_91 + 3.55044161234056e-5*x_92 + 8.44476201311259e-7*x_93 - 0.000136539920063392*x_94 + 0.000183489827316497*x_95 + 4.3761204306086e-5*x_96 + 9.76794805987764e-7*x_97 - 0.000262367823825968*x_98 - 0.000101154624892138*x_99 + 1.22341786231021e-6*std::pow(-2.82407999038696*x_43 - 9.27255916595459, 2) + 3.0527120549165e-6*std::pow(-1.9560798406601*x_49 - 6.25687980651855, 2) + 4.59418542181555e-6*std::pow(-2.78144001960754*x_57 - 8.74015998840332, 2) - 8.29852398717916e-7*std::pow(-3.40543985366821*x_61 - 6.01567983627319, 2) - 0.000247609245068031*std::exp(0.343279838562012*x_23) + 0.00181130134486664*std::exp(0.148799866437912*x_49) + 9.85382524144088e-5*std::exp(0.172799870371819*x_49) + 0.00096272275030327*std::sin(0.273519963026047*x_1 - 4.31824016571045) - 0.000284732195000906*std::sin(0.381679862737656*x_1 - 4.22352027893066) - 0.000250699517220556*std::sin(0.338639855384827*x_10 - 4.34327983856201) + 0.000530488995654883*std::sin(0.356239855289459*x_10 - 1.16279983520508) - 0.000680739149016063*std::sin(0.253279983997345*x_100 + 8.16903972625732) + 8.72193028606259e-5*std::sin(0.220319986343384*x_101 + 4.9814395904541) + 0.000155316233227675*std::sin(0.287599951028824*x_109 + 4.77304029464722) + 0.00144681204735908*std::sin(0.243759974837303*x_11 - 7.41639995574951) - 0.00280262372322954*std::sin(0.233999982476234*x_110 - 1.21967995166779) + 0.00119720357892013*std::sin(0.248159974813461*x_112 + 1.98031985759735) - 0.000981036675941438*std::sin(0.270559966564178*x_113 + 1.98671984672546) + 0.000585086840780542*std::sin(0.219999983906746*x_116 - 4.20359992980957) + 0.000237987109486085*std::sin(0.253439962863922*x_119 - 1.2267199754715) + 0.000262376355027857*std::sin(0.303039938211441*x_12 + 5.12728023529053) - 0.000613093840735909*std::sin(0.442479848861694*x_13 + 1.92767989635468) - 0.00856700452596461*std::sin(0.111040063202381*x_14 + 8.12263965606689) + 0.000258525265199951*std::sin(0.313599914312363*x_14 - 7.46143960952759) - 0.000593318046046971*std::sin(0.378799855709076*x_14 + 5.03047943115234) + 0.000321838612405126*std::sin(0.252079963684082*x_15 - 7.4113597869873) + 0.00157788944711671*std::sin(0.290639936923981*x_15 + 5.16328001022339) + 0.000416013764230188*std::sin(0.337679862976074*x_16 - 1.15767979621887) + 0.000408200970237379*std::sin(0.447039842605591*x_16 - 1.24167990684509) + 0.000537343230657249*std::sin(0.345279842615128*x_17 - 1.17911994457245) - 0.000288749192097273*std::sin(0.443679869174957*x_18 + 1.94863975048065) + 0.00093106271564246*std::sin(0.390159845352173*x_19 - 1.16807985305786) - 0.000670441587873601*std::sin(0.367999851703644*x_2 - 7.41447973251343) - 0.000241805607894559*std::sin(0.405919849872589*x_2 + 2.01239991188049) + 0.00227644324216206*std::sin(0.269759953022003*x_21 - 1.17471981048584) - 0.000499883756339136*std::sin(0.298719942569733*x_21 - 7.41016006469727) - 0.000434721208838157*std::sin(0.315119922161102*x_22 - 4.36552000045776) + 0.000267208875152854*std::sin(0.398959845304489*x_22 - 1.17631983757019) + 0.000584813695198852*std::sin(0.273519963026047*x_23 - 4.36448001861572) + 0.000258456354779782*std::sin(0.422159850597382*x_23 + 5.19608020782471) - 0.000736375929693899*std::sin(0.342239856719971*x_25 - 1.15543985366821) - 0.00197377097150323*std::sin(0.369199842214584*x_26 - 1.15751981735229) + 0.00118542514356842*std::sin(0.319439917802811*x_27 + 1.80935990810394) + 0.000700871697484723*std::sin(0.234079986810684*x_28 - 1.18439984321594) - 0.00158253840470296*std::sin(0.31687992811203*x_28 + 1.99743974208832) + 6.31421724855914e-5*std::sin(0.685199856758118*x_28 + 4.94039964675903) - 0.000946668448193965*std::sin(0.278799951076508*x_29 - 1.16959989070892) - 0.00301969671529945*std::sin(0.350799858570099*x_3 - 4.20911979675293) - 0.000118549962600942*std::sin(0.554639875888824*x_3 + 8.19847965240479) - 0.000255385086921055*std::sin(0.24679996073246*x_30 + 8.22175979614258) - 0.00108505811726792*std::sin(0.329039841890335*x_30 - 1.17311990261078) + 0.00029608834121443*std::sin(0.328239858150482*x_31 - 4.25680017471313) - 0.000291746986814567*std::sin(0.513359844684601*x_31 + 8.15312004089355) - 0.000152223609723441*std::sin(0.257599949836731*x_32 + 8.03176021575928) + 0.000485695551679949*std::sin(0.305119931697845*x_32 - 1.15055990219116) - 0.00136016579253434*std::sin(0.233999997377396*x_35 - 1.21071982383728) - 0.00149905144022853*std::sin(0.24975997209549*x_36 - 7.42927980422974) - 0.0014595547528397*std::sin(0.218239992856979*x_37 + 1.97247982025146) + 0.000202510382655015*std::sin(0.240559980273247*x_39 - 1.21007990837097) - 0.000739086756334006*std::sin(0.380799859762192*x_4 + 1.98911988735199) - 8.84487518662377e-6*std::sin(1.04431986808777*x_4 + 6.76743984222412) - 0.00044428060842756*std::sin(0.232239991426468*x_41 - 4.4125599861145) - 0.000973474951907562*std::sin(0.248079970479012*x_41 + 1.96991980075836) + 0.000274178714650549*std::sin(0.249439969658852*x_42 + 1.97775983810425) + 0.00179612664870775*std::sin(0.221519991755486*x_45 + 1.96543979644775) - 0.0023560233772665*std::sin(0.219679996371269*x_48 - 7.40263986587524) + 0.000513479893128577*std::sin(0.308079928159714*x_5 + 2.01263976097107) + 0.000188935388686239*std::sin(0.31399992108345*x_5 - 1.18407988548279) - 0.00113695666839859*std::sin(0.230079978704453*x_50 - 7.44495964050293) - 0.000384562124686143*std::sin(0.208000004291534*x_51 + 8.20343971252441) - 0.0025715525764477*std::sin(0.210879996418953*x_51 + 8.1988000869751) - 0.000182701557127195*std::sin(0.22639998793602*x_53 + 1.97503972053528) - 0.00147523914870471*std::sin(0.254559963941574*x_53 + 5.15840005874634) - 0.0012066069907698*std::sin(0.193759992718697*x_54 - 4.3953595161438) - 0.00386781584224804*std::sin(0.18792000412941*x_56 + 8.20448017120361) - 0.000285070786958384*std::sin(0.245999976992607*x_57 - 7.43856000900269) + 0.00204952484248324*std::sin(0.385519832372665*x_59 + 1.81727981567383) + 0.00202863235653249*std::sin(0.24415996670723*x_6 - 1.15775990486145) + 0.000169502670132026*std::sin(0.397839844226837*x_6 + 1.98791980743408) + 0.000777810231614663*std::sin(0.355519831180573*x_60 + 8.25080013275146) + 0.00218334140169803*std::sin(0.410879880189896*x_60 - 1.20055997371674) + 2.45653247458094e-5*std::sin(1.03327977657318*x_64 - 4.59127998352051) + 0.000926757690663165*std::sin(0.350159853696823*x_7 + 2.01959991455078) - 0.00189668158752951*std::sin(0.366479843854904*x_7 + 2.00175976753235) + 0.000976907933156937*std::sin(0.355759829282761*x_8 - 1.14231991767883) - 6.04797226214429e-5*std::sin(0.494479864835739*x_8 - 1.44279980659485) + 0.000731464548379482*std::sin(0.365279853343964*x_91 + 1.97591972351074) - 0.00127951475839175*std::sin(0.263279944658279*x_92 - 7.39527988433838) - 0.0012269934200069*std::sin(0.236319988965988*x_93 + 1.98023986816406) + 0.00220105755863321*std::sin(0.236479982733727*x_93 - 1.18967986106873) - 0.00138911827397904*std::sin(0.291119933128357*x_94 + 1.8025598526001) - 0.00150401903332099*std::sin(0.279599964618683*x_97 - 1.20447981357574) - 0.0017672787920731*std::sin(0.291679948568344*x_97 + 8.16464042663574) + 0.000355199468406196*std::sin(0.232399985194206*x_98 + 1.98495984077454) + 0.264753460884094*std::sin(0.00656614595946175*x_1 + 0.00711589321283174*x_101 - 0.023047750958852*x_103 + 0.0112545352179631*x_105 + 0.0138532217152109*x_107 + 0.0230317708537896*x_109 - 0.000128981449442545*x_11 + 0.0112402634138364*x_111 - 0.00488461779772347*x_112 - 0.0315780869786506*x_114 - 0.023650764382373*x_115 + 0.0117029634367211*x_117 - 0.00560686775551494*x_118 - 0.0120104217055886*x_119 + 0.0142546920568333*x_12 - 0.0382414513054292*x_120 - 0.00258616379665404*x_16 - 0.0194983900485844*x_19 + 0.0199946905215489*x_20 - 0.0131203344620505*x_21 - 0.00121672052462692*x_22 + 0.0102998537175303*x_23 + 0.00642637894703683*x_28 + 0.00738937325522502*x_32 + 0.000230912027063399*x_33 + 0.000231374837122632*x_34 + 0.0250205214526761*x_35 - 0.0313261469060753*x_36 - 0.0244148745803432*x_37 + 0.0254340525121079*x_38 + 0.00241889497090417*x_39 + 0.0189237973017673*x_40 + 0.0174712894987082*x_41 - 0.00457878130250957*x_42 - 0.0356179370287141*x_43 + 0.000758707154952324*x_44 - 0.000744241903896193*x_45 + 0.0149191715729007*x_46 - 0.00943061757724184*x_48 + 0.00625839208215898*x_5 + 0.0152479173441121*x_50 - 0.00144915837673487*x_52 - 0.00132077807789991*x_54 + 0.0182359456498143*x_56 - 0.00226015287344048*x_57 + 0.000649077372523766*x_6 + 0.000487760238966469*x_61 - 1.54363405709716e-5*x_62 + 0.0095391347554855*x_63 - 0.000461801440857542*x_64 - 0.00723361327688314*x_65 + 0.00133155354750479*x_66 + 0.00199115925466071*x_67 + 0.00226035810717978*x_68 + 0.000442016801519141*x_69 - 0.00480768047981572*x_70 + 0.0011726315179635*x_71 + 0.00346222440031661*x_72 + 0.00598680490300826*x_73 - 0.00689358202798612*x_74 - 0.00430631748990117*x_75 - 0.00800883526228102*x_76 - 0.00636529072098811*x_77 - 0.00136331887231028*x_78 - 0.0139534112603714*x_79 + 0.0257595865950254*x_8 + 0.00875016648650174*x_80 - 0.00887403640780797*x_81 + 0.011532640743311*x_82 + 0.00273687378568776*x_83 - 0.00829274579671795*x_84 + 0.00365648170867971*x_85 + 0.0148825940718641*x_86 + 0.00493720966070511*x_87 - 0.012046431634936*x_88 + 0.000316603165687294*x_89 - 0.000228331319812701*x_90 - 0.00294977970838838*x_91 - 0.000548530883341554*x_93 + 0.00894405030189689*x_94 - 0.00946961631237151*x_96 - 0.0115113359705339*x_99 - 1.36498309285702e-5*std::pow(-9.91328048706055*x_10 - 9.80399990081787, 2) + 0.000481588009951815*std::pow(-2.00767993927002*x_29 - 7.99128007888794, 2) - 0.000190895723641013*std::pow(-5.30592012405396*x_30 - 9.79191970825195, 2) - 0.00155272161010874*std::pow(-1.45055985450745*x_58 - 3.72727990150452, 2) - 0.0775097483482461*std::log(6.24751996994019 - 0.6004798412323*x_15) + 0.148482565908724*std::sin(0.249999970197678*x_100 - 1.20175993442535) + 0.0900168226395524*std::sin(0.241359978914261*x_102 - 1.21223986148834) + 0.0627841132910221*std::sin(0.183360010385513*x_104 - 1.39951992034912) + 0.121787131121974*std::sin(0.250479966402054*x_106 - 7.61360025405884) + 0.121170549244359*std::sin(0.247279971837997*x_108 + 1.95583975315094) - 0.0562240584256906*std::sin(0.284559935331345*x_110 + 7.94407987594604) - 0.158343339976579*std::sin(0.282879948616028*x_113 + 1.97383987903595) + 0.1288770029167*std::sin(0.239839985966682*x_116 + 4.99567985534668) + 0.105071106346848*std::sin(0.38087984919548*x_13 - 7.3758397102356) - 0.0924117952344266*std::sin(0.260159969329834*x_14 + 2.13895988464355) + 0.0763758631955795*std::sin(0.315039932727814*x_17 + 1.82631993293762) - 0.164658181388456*std::sin(0.178240016102791*x_18 + 1.95119976997375) + 0.117051162578057*std::sin(0.404399842023849*x_2 + 1.97687971591949) + 0.111124060267147*std::sin(0.388799846172333*x_24 + 5.20887994766235) + 0.145603045838189*std::sin(0.24551996588707*x_25 - 7.39271974563599) + 0.107518784359176*std::sin(0.442559868097305*x_26 - 7.44799947738647) + 0.0953924140754294*std::sin(0.369999825954437*x_27 - 4.38503980636597) + 0.080135203315459*std::sin(0.458639860153198*x_3 - 4.39296007156372) - 0.0298254392136287*std::sin(0.404639840126038*x_31 - 1.20063984394073) - 0.0853781319580817*std::sin(0.3713598549366*x_4 - 1.20103991031647) - 0.213909758014922*std::sin(0.199280008673668*x_47 + 1.97479975223541) - 0.0364256912592378*std::sin(0.364319831132889*x_49 + 1.84487986564636) + 0.230799399361151*std::sin(0.199359998106956*x_51 - 4.39431953430176) - 0.14406971328228*std::sin(0.253679990768433*x_53 - 7.42943954467773) - 0.157334779162441*std::sin(0.226559996604919*x_55 - 7.41791963577271) + 1.60772495613613*std::sin(0.0536801069974899*x_59 + 8.01991939544678) - 0.090850632889091*std::sin(0.417359858751297*x_60 - 1.23583984375) + 0.089356303931134*std::sin(0.312879920005798*x_7 - 7.39871978759766) - 0.192520574934358*std::sin(0.312239944934845*x_9 - 7.42360019683838) - 0.130797727874928*std::sin(0.292799949645996*x_92 - 1.16527986526489) - 0.0658726854236882*std::sin(0.267839968204498*x_95 + 1.96391975879669) + 0.182697056525435*std::sin(0.276799947023392*x_97 + 1.95687973499298) - 0.147852368886269*std::sin(0.230719983577728*x_98 + 5.18800020217896) - 2.11234264993576) - 0.0913387611508369*std::sin(0.00791134462249369*x_10 - 0.0423884860305713*x_100 - 0.000303926181207165*x_101 + 0.055040782940407*x_102 - 0.00706512220307265*x_103 + 0.0416236635295598*x_104 - 0.034512343143335*x_105 + 0.00041135335053045*x_106 + 0.0121744287195124*x_107 - 6.50703830165135e-6*x_110 + 0.0566750276446779*x_111 - 0.00409793719669958*x_114 + 0.0506664748081078*x_115 - 0.000929215589325748*x_116 - 0.0447599089485824*x_117 - 0.046740470396379*x_118 + 0.000229017327884467*x_119 + 0.020574661278509*x_120 + 0.0017101207000744*x_13 + 0.0298823769610763*x_17 + 0.0540422977502678*x_18 - 0.00461109835980082*x_2 - 0.0101668752924121*x_20 + 0.0566750668381371*x_21 + 0.0375227048559915*x_24 + 0.000556616372404109*x_26 + 0.00481469305702178*x_28 + 0.00630283648780134*x_3 + 0.0254691547664327*x_32 + 0.0103063993850607*x_34 + 0.000749147606217863*x_36 + 0.0104288032026355*x_37 + 0.0031403078390361*x_38 + 0.00082267564065963*x_39 - 0.0670372922358961*x_40 + 0.0467313229363905*x_41 + 0.0014298646010748*x_42 + 0.000444086726210222*x_43 + 0.0647966867310516*x_45 + 0.0499878033127798*x_46 + 0.0114222296162806*x_47 - 0.0543032447433794*x_48 + 0.00157251487998005*x_49 + 0.0729469731936423*x_50 - 0.00258949837491724*x_51 + 0.00338116310381557*x_52 + 0.0892026875063358*x_54 - 0.0730671925820454*x_55 + 0.00647649493593536*x_56 + 0.0701960512077516*x_58 - 0.091207031502719*x_59 - 0.00042646706231334*x_6 - 0.000949921710581461*x_61 - 0.000121005260227662*x_62 + 0.0274452102735134*x_63 - 0.018349906507849*x_64 - 0.0238745763488524*x_65 + 0.000452753228539159*x_66 - 0.000389468538599458*x_67 - 0.0395081924003359*x_68 + 0.0218575465477092*x_69 + 0.0505539210283251*x_70 + 0.00112526086395595*x_71 - 0.0277083557797102*x_72 - 0.0235738774774511*x_73 + 0.0413868947074397*x_74 - 0.000660953401854248*x_75 + 0.00108394038878396*x_76 + 0.0142439646398393*x_77 + 0.0344430525218818*x_78 + 0.00454812550461486*x_79 + 0.00368924254316953*x_8 - 0.0347786859713383*x_80 - 0.0272131265319948*x_81 - 1.62717362531469e-5*x_82 + 0.0322895158726644*x_83 - 0.0274536774754475*x_84 + 0.0263350165360884*x_85 - 4.43869767738816e-5*x_86 + 0.0242965613042136*x_87 - 0.0112846420748027*x_88 - 0.000574068715334101*x_89 + 0.00632061357354831*x_9 - 0.0333668405094406*x_90 + 0.000315549566764162*x_92 + 0.0029189089015219*x_96 + 0.00328068687188057*x_98 + 0.0157824338707658*x_99 - 0.00010919381719373*std::pow(-8.66760063171387*x_23 - 8.67360019683838, 2) + 0.399560199889883*std::sin(0.437119841575623*x_1 - 7.18616008758545) - 0.28374552228593*std::sin(0.257359951734543*x_108 - 7.42712020874023) - 0.424062618874679*std::sin(0.243679970502853*x_109 - 7.43919992446899) - 0.254694259217434*std::sin(0.37407985329628*x_11 + 5.032639503479) + 0.102714790440084*std::sin(0.297039926052094*x_112 - 1.24703979492188) + 0.15400981282677*std::sin(0.182320013642311*x_113 - 0.98695981502533) - 0.277882760264596*std::sin(0.357359826564789*x_12 - 1.35935986042023) - 0.317508621041309*std::sin(0.405359864234924*x_14 - 7.59216022491455) + 0.553537544043259*std::sin(0.282559931278229*x_15 - 7.42799949645996) + 0.4062864352899*std::sin(0.194240003824234*x_16 + 8.20448017120361) + 0.336265187974121*std::sin(0.322959929704666*x_19 + 1.99087977409363) - 0.51527650480562*std::sin(0.400479853153229*x_22 + 2.00727987289429) - 0.433194470227676*std::sin(0.349199831485748*x_25 + 2.03151988983154) + 0.428560013473813*std::sin(0.298239946365356*x_27 + 5.1923999786377) - 0.196245392982526*std::sin(0.232639983296394*x_29 - 1.37055993080139) + 0.47979314636116*std::sin(0.311679929494858*x_30 - 1.0311998128891) - 0.226169591403877*std::sin(0.295199930667877*x_31 + 5.3310399055481) - 0.377700514840651*std::sin(0.248399972915649*x_33 - 1.19327986240387) - 0.163055539744175*std::sin(0.226879999041557*x_35 - 1.20903992652893) + 0.632600481015828*std::sin(0.288719952106476*x_4 - 7.37999963760376) - 0.415912219890835*std::sin(0.280639946460724*x_44 - 7.47559976577759) - 0.290175365894001*std::sin(0.376479834318161*x_5 + 2.00879979133606) + 0.173574753060297*std::sin(0.240399971604347*x_53 - 1.20711994171143) - 0.436535502406237*std::sin(0.23471999168396*x_57 + 1.97623980045319) - 0.221618813984108*std::sin(0.490879863500595*x_60 - 7.56831979751587) - 0.304077143996473*std::sin(0.429519861936569*x_7 + 8.19087982177734) - 0.334145887720396*std::sin(0.373839855194092*x_91 + 5.19048023223877) + 0.369209894198921*std::sin(0.2483199685812*x_93 - 1.21671986579895) + 0.0408858500105858*std::sin(0.337679862976074*x_94 + 1.8290399312973) - 0.373181421387283*std::sin(0.285919934511185*x_95 - 1.22239983081818) - 0.273592892233623*std::sin(0.277999937534332*x_97 + 8.18935966491699) + 4.59129948659513) + 0.21561119458574);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (7.44839793973189e-5*x_1 + 9.84267971841132e-6*x_10 + 6.25670389500301e-5*x_100 + 0.00086757068238396*x_101 - 0.00111792556685871*x_102 - 6.12489544814143e-5*x_103 - 0.000444335143787168*x_104 + 0.000887779641602598*x_105 - 0.000986043983311086*x_106 + 0.00114306487369182*x_107 + 0.000518564636877482*x_108 + 0.000687197994161186*x_109 - 0.000387139638055309*x_11 - 0.00054426699290112*x_110 + 0.00166220285686117*x_111 + 0.00192350516723353*x_112 + 5.25099203054193e-5*x_113 + 0.000989246639981996*x_114 + 0.00194178375111867*x_115 - 7.89250054795363e-6*x_116 + 0.00208568911545051*x_117 + 0.00201697347829339*x_118 + 2.17405436126164e-5*x_119 - 0.000119271461043919*x_12 - 0.000604372334906184*x_120 + 0.000513633546335904*x_13 + 0.000462587163512655*x_15 + 0.000426864963122372*x_16 - 0.000544124069084905*x_17 - 0.000181769631156981*x_18 - 0.000338319608870954*x_19 + 7.59624041663451e-5*x_2 + 6.06551367056067e-5*x_20 + 0.000518964115406702*x_21 + 4.30192717514932e-5*x_22 + 4.25364267771731e-5*x_23 - 0.00223152971298031*x_24 + 0.000362076896168746*x_25 + 0.00149041675291124*x_26 - 0.000183247556266137*x_27 + 2.6539716487211e-5*x_28 + 0.000503402047197037*x_29 - 0.000322707870799616*x_3 + 0.000102524334966607*x_30 + 1.86865644172864e-5*x_31 + 9.3985932704658e-5*x_32 - 0.00104106025987752*x_33 - 0.000889394223732559*x_34 + 0.00016744938598802*x_35 - 0.00150911177443745*x_36 + 0.000223994964483456*x_37 + 0.000400244545705864*x_38 - 0.000852733799088926*x_39 - 5.13611867169414e-5*x_4 - 0.000207298833147178*x_40 - 0.000101842402729185*x_41 + 0.000135281312119254*x_42 + 0.00143997730691593*x_43 + 0.000419311872253646*x_44 + 0.000443455899156386*x_45 + 0.00238813604039082*x_46 + 0.00032739780522453*x_47 - 0.00100198873003316*x_48 + 2.03648259536725e-5*x_5 + 0.000190052112264197*x_50 - 0.000147640386695388*x_51 - 0.000916231006304981*x_52 + 0.000138874063883561*x_53 - 0.0013671531191419*x_54 + 0.00153864062988845*x_55 + 0.00101106561851854*x_56 + 0.000374237637217118*x_57 + 0.00141890665265678*x_58 + 0.0014078072941105*x_59 + 9.76038824595009e-5*x_6 - 4.91913805296254e-5*x_60 + 0.000174476515568869*x_61 + 0.000173931382019924*x_62 - 0.000144510304173754*x_63 - 0.000275338619842435*x_64 - 0.000314798185179519*x_65 + 0.000146454638570055*x_66 + 0.000120122774655042*x_67 - 0.000629470074648935*x_68 + 0.000212335416952472*x_69 - 7.34110370099695e-5*x_7 - 0.00038238538598531*x_70 + 0.00017257536559731*x_71 - 0.000121171400722687*x_72 + 0.000674783195573209*x_73 - 0.000428369573215022*x_74 + 0.000235090456088719*x_75 + 0.000130270022481906*x_76 - 0.000117445997636246*x_77 - 0.000120459201071521*x_78 + 6.06702415078811e-6*x_79 + 8.88507523461428e-5*x_8 - 0.000104856869250927*x_80 - 0.000116242800205123*x_81 - 0.00042554333343046*x_82 + 0.00036439190303222*x_83 - 0.00025901870612758*x_84 + 0.000231498717494073*x_85 + 0.00027711849229455*x_86 + 0.000423889913898295*x_87 + 0.000230654694547461*x_88 + 0.000396663418806697*x_89 - 0.000188115980974238*x_9 - 0.000413468711885259*x_90 - 0.000254690506517174*x_91 - 1.99000506142309e-5*x_92 - 2.36599027830495e-5*x_93 + 0.000409388355580089*x_94 - 0.000115000756575863*x_95 - 0.000140022114567247*x_96 - 2.4746830996384e-5*x_97 + 0.000836797164277666*x_98 + 0.000260053785536762*x_99 - 5.63711922263243e-8*std::pow(-9.91328048706055*x_10 - 9.80399990081787, 2) + 1.98886641343406e-6*std::pow(-2.00767993927002*x_29 - 7.99128007888794, 2) - 7.88362844116051e-7*std::pow(-5.30592012405396*x_30 - 9.79191970825195, 2) - 4.63678827217042e-6*std::pow(-2.82407999038696*x_43 - 9.27255916595459, 2) - 1.156986495834e-5*std::pow(-1.9560798406601*x_49 - 6.25687980651855, 2) + 6.29321767588991e-6*std::pow(-2.78144001960754*x_57 - 8.74015998840332, 2) - 6.41244340794015e-6*std::pow(-1.45055985450745*x_58 - 3.72727990150452, 2) + 2.10240850351874e-5*std::pow(-3.40543985366821*x_61 - 6.01567983627319, 2) - 0.000339180667453359*std::exp(0.343279838562012*x_23) + 0.00248116098791965*std::exp(0.148799866437912*x_49) - 0.00249643985024317*std::exp(0.172799870371819*x_49) + 0.0247475944758133*std::exp(-0.0102134299533171*x_10 + 0.0547229141895147*x_100 + 0.000392364245379075*x_101 - 0.0710568440590044*x_102 + 0.00912096921268524*x_103 - 0.0537355395504941*x_104 + 0.044554929160473*x_105 - 0.000531051146446047*x_106 - 0.0157170090397602*x_107 + 8.40049107562695e-6*x_110 - 0.0731666300195595*x_111 + 0.00529037685864217*x_114 - 0.0654096763731932*x_115 + 0.00119960370657161*x_116 + 0.0577843864193975*x_117 + 0.0603412622199785*x_118 - 0.000295658013657176*x_119 - 0.0265615861536115*x_120 - 0.00220774075904458*x_13 - 0.0385777106792712*x_17 - 0.0697678143130474*x_18 + 0.00595286039894902*x_2 + 0.0131252869895118*x_20 - 0.0731666806177409*x_21 - 0.0484412620094993*x_24 - 0.00071858357860625*x_26 - 0.00621569816903186*x_28 - 0.00813686952687435*x_3 - 0.0328803055093255*x_32 - 0.0133054105481564*x_34 - 0.000967138579584412*x_36 - 0.0134634320826076*x_37 - 0.00405409139359905*x_38 - 0.0010620621943693*x_39 + 0.0865441617300649*x_40 - 0.060329452983205*x_41 - 0.00184593424286982*x_42 - 0.000573309454684879*x_43 - 0.0836515728632267*x_45 - 0.0645335214198193*x_46 - 0.0147459310222557*x_47 + 0.0701046930565289*x_48 - 0.00203009366215204*x_49 - 0.0941734732300065*x_50 + 0.00334300444847885*x_51 - 0.0043650320102824*x_52 - 0.115159362152324*x_54 + 0.0943286746984136*x_55 - 0.00836106003815301*x_56 - 0.0906220732657007*x_58 + 0.117746940874557*x_59 + 0.000550562726840394*x_6 + 0.00122633500562902*x_61 + 0.000156216017414316*x_62 - 0.0354313642064846*x_63 + 0.0236894603522857*x_64 + 0.0308217281435106*x_65 - 0.000584497782169084*x_66 + 0.000502798175002585*x_67 + 0.0510044973285232*x_68 - 0.0282177722332654*x_69 - 0.0652643710931623*x_70 - 0.00145269528273951*x_71 + 0.0357710811981361*x_72 + 0.0304335303077891*x_73 - 0.0534298744713902*x_74 + 0.000853281154388291*x_75 - 0.00139935115491489*x_76 - 0.0183887495803044*x_77 - 0.0444654759837499*x_78 - 0.00587156336587913*x_79 - 0.00476275805105587*x_8 + 0.0448987738477144*x_80 + 0.0351317474977693*x_81 + 2.10065730126142e-5*x_82 - 0.0416852917333828*x_83 + 0.0354422952400802*x_84 - 0.0339981203632621*x_85 + 5.73029364478193e-5*x_86 - 0.0313665045359687*x_87 + 0.0145683075227892*x_88 + 0.000741114297534856*x_89 - 0.00815981948402001*x_9 + 0.0430761020494208*x_90 - 0.000407369865772511*x_92 - 0.00376826861024932*x_96 - 0.00423531866750581*x_98 - 0.0203748908085257*x_99 + 0.000140967617574463*std::pow(-8.66760063171387*x_23 - 8.67360019683838, 2) - 0.515826361817922*std::sin(0.437119841575623*x_1 - 7.18616008758545) + 0.366311310493924*std::sin(0.257359951734543*x_108 - 7.42712020874023) + 0.547458625602324*std::sin(0.243679970502853*x_109 - 7.43919992446899) + 0.328806555668574*std::sin(0.37407985329628*x_11 + 5.032639503479) - 0.132603288996753*std::sin(0.297039926052094*x_112 - 1.24703979492188) - 0.198824411081448*std::sin(0.182320013642311*x_113 - 0.98695981502533) + 0.358742570653213*std::sin(0.357359826564789*x_12 - 1.35935986042023) + 0.409898976131007*std::sin(0.405359864234924*x_14 - 7.59216022491455) - 0.714608856317902*std::sin(0.282559931278229*x_15 - 7.42799949645996) - 0.524509833134829*std::sin(0.194240003824234*x_16 + 8.20448017120361) - 0.434113429131614*std::sin(0.322959929704666*x_19 + 1.99087977409363) + 0.665214415443252*std::sin(0.400479853153229*x_22 + 2.00727987289429) + 0.559247711856102*std::sin(0.349199831485748*x_25 + 2.03151988983154) - 0.553264696112777*std::sin(0.298239946365356*x_27 + 5.1923999786377) + 0.253349926027674*std::sin(0.232639983296394*x_29 - 1.37055993080139) - 0.619405919760922*std::sin(0.311679929494858*x_30 - 1.0311998128891) + 0.291981627599196*std::sin(0.295199930667877*x_31 + 5.3310399055481) + 0.487605828810533*std::sin(0.248399972915649*x_33 - 1.19327986240387) + 0.210502311951178*std::sin(0.226879999041557*x_35 - 1.20903992652893) - 0.816677949146566*std::sin(0.288719952106476*x_4 - 7.37999963760376) + 0.536936579972256*std::sin(0.280639946460724*x_44 - 7.47559976577759) + 0.374612144351559*std::sin(0.376479834318161*x_5 + 2.00879979133606) - 0.224082462165182*std::sin(0.240399971604347*x_53 - 1.20711994171143) + 0.563560935430068*std::sin(0.23471999168396*x_57 + 1.97623980045319) + 0.28610664064972*std::sin(0.490879863500595*x_60 - 7.56831979751587) + 0.392559136127453*std::sin(0.429519861936569*x_7 + 8.19087982177734) + 0.431377443566035*std::sin(0.373839855194092*x_91 + 5.19048023223877) - 0.476644562006665*std::sin(0.2483199685812*x_93 - 1.21671986579895) - 0.052783033111421*std::sin(0.337679862976074*x_94 + 1.8290399312973) + 0.4817717453973*std::sin(0.285919934511185*x_95 - 1.22239983081818) + 0.353204413900599*std::sin(0.277999937534332*x_97 + 8.18935966491699)) - 0.00032010044273938*std::log(6.24751996994019 - 0.6004798412323*x_15) - 0.00364874643037211*std::sin(0.273519963026047*x_1 - 4.31824016571045) + 0.00721361279331489*std::sin(0.381679862737656*x_1 - 4.22352027893066) + 0.00635140414906124*std::sin(0.338639855384827*x_10 - 4.34327983856201) - 0.00201056828524899*std::sin(0.356239855289459*x_10 - 1.16279983520508) + 0.000613204611024094*std::sin(0.249999970197678*x_100 - 1.20175993442535) + 0.00258002061258495*std::sin(0.253279983997345*x_100 + 8.16903972625732) - 0.00220967733886719*std::sin(0.220319986343384*x_101 + 4.9814395904541) + 0.000371752268520492*std::sin(0.241359978914261*x_102 - 1.21223986148834) + 0.000259286385128746*std::sin(0.183360010385513*x_104 - 1.39951992034912) + 0.000502957568858949*std::sin(0.250479966402054*x_106 - 7.61360025405884) + 0.000500411203579541*std::sin(0.247279971837997*x_108 + 1.95583975315094) - 0.00393489456651388*std::sin(0.287599951028824*x_109 + 4.77304029464722) + 0.00198187541732533*std::sin(0.243759974837303*x_11 - 7.41639995574951) - 0.0038390964957889*std::sin(0.233999982476234*x_110 - 1.21967995166779) - 0.000232194612654494*std::sin(0.284559935331345*x_110 + 7.94407987594604) - 0.00453743539730153*std::sin(0.248159974813461*x_112 + 1.98031985759735) - 0.00134384592324337*std::sin(0.270559966564178*x_113 + 1.98671984672546) - 0.000653927722789232*std::sin(0.282879948616028*x_113 + 1.97383987903595) - 0.00221749566122043*std::sin(0.219999983906746*x_116 - 4.20359992980957) + 0.000532237383963761*std::sin(0.239839985966682*x_116 + 4.99567985534668) - 0.00602933875330604*std::sin(0.253439962863922*x_119 - 1.2267199754715) - 0.0066472336620952*std::sin(0.303039938211441*x_12 + 5.12728023529053) + 0.000433923582226461*std::sin(0.38087984919548*x_13 - 7.3758397102356) + 0.00232364298253426*std::sin(0.442479848861694*x_13 + 1.92767989635468) - 0.0117352739086711*std::sin(0.111040063202381*x_14 + 8.12263965606689) - 0.000381643047478043*std::sin(0.260159969329834*x_14 + 2.13895988464355) - 0.00654966734771794*std::sin(0.313599914312363*x_14 - 7.46143960952759) + 0.00224869216179557*std::sin(0.378799855709076*x_14 + 5.03047943115234) - 0.00815369379574706*std::sin(0.252079963684082*x_15 - 7.4113597869873) + 0.00216142816353087*std::sin(0.290639936923981*x_15 + 5.16328001022339) - 0.00157670392305822*std::sin(0.337679862976074*x_16 - 1.15767979621887) - 0.0103416606651683*std::sin(0.447039842605591*x_16 - 1.24167990684509) + 0.000315417713829547*std::sin(0.315039932727814*x_17 + 1.82631993293762) - 0.00203654602960991*std::sin(0.345279842615128*x_17 - 1.17911994457245) - 0.000680006810579442*std::sin(0.178240016102791*x_18 + 1.95119976997375) + 0.00731538232325852*std::sin(0.443679869174957*x_18 + 1.94863975048065) + 0.00127539047762849*std::sin(0.390159845352173*x_19 - 1.16807985305786) + 0.00254099256484403*std::sin(0.367999851703644*x_2 - 7.41447973251343) + 0.000483398924172137*std::sin(0.404399842023849*x_2 + 1.97687971591949) + 0.00612607937292768*std::sin(0.405919849872589*x_2 + 2.01239991188049) + 0.00311832273501773*std::sin(0.269759953022003*x_21 - 1.17471981048584) + 0.0018945735633326*std::sin(0.298719942569733*x_21 - 7.41016006469727) - 0.000595490809437851*std::sin(0.315119922161102*x_22 - 4.36552000045776) - 0.0067696642463764*std::sin(0.398959845304489*x_22 - 1.17631983757019) - 0.00221646043174668*std::sin(0.273519963026047*x_23 - 4.36448001861572) - 0.00654792152094719*std::sin(0.422159850597382*x_23 + 5.19608020782471) + 0.000458921124742838*std::sin(0.388799846172333*x_24 + 5.20887994766235) + 0.000601312743625506*std::sin(0.24551996588707*x_25 - 7.39271974563599) + 0.00279088558365964*std::sin(0.342239856719971*x_25 - 1.15543985366821) - 0.00270371550678811*std::sin(0.369199842214584*x_26 - 1.15751981735229) + 0.00044403202448213*std::sin(0.442559868097305*x_26 - 7.44799947738647) + 0.00162382180560771*std::sin(0.319439917802811*x_27 + 1.80935990810394) + 0.000393952433471088*std::sin(0.369999825954437*x_27 - 4.38503980636597) - 0.00265632354023071*std::sin(0.234079986810684*x_28 - 1.18439984321594) - 0.00216779640933943*std::sin(0.31687992811203*x_28 + 1.99743974208832) - 0.00159968978301982*std::sin(0.685199856758118*x_28 + 4.94039964675903) + 0.0035879001716803*std::sin(0.278799951076508*x_29 - 1.16959989070892) - 0.004136447922696*std::sin(0.350799858570099*x_3 - 4.20911979675293) + 0.000330943069832184*std::sin(0.458639860153198*x_3 - 4.39296007156372) + 0.00300343109026514*std::sin(0.554639875888824*x_3 + 8.19847965240479) + 0.00647011178426695*std::sin(0.24679996073246*x_30 + 8.22175979614258) - 0.00148633681403738*std::sin(0.329039841890335*x_30 - 1.17311990261078) - 0.00750131767195838*std::sin(0.328239858150482*x_31 - 4.25680017471313) - 0.000123173362069044*std::sin(0.404639840126038*x_31 - 1.20063984394073) + 0.00110572932485093*std::sin(0.513359844684601*x_31 + 8.15312004089355) + 0.000576931782719166*std::sin(0.257599949836731*x_32 + 8.03176021575928) - 0.0123049648292967*std::sin(0.305119931697845*x_32 - 1.15055990219116) - 0.0018631854445995*std::sin(0.233999997377396*x_35 - 1.21071982383728) + 0.00568144732193665*std::sin(0.24975997209549*x_36 - 7.42927980422974) + 0.00553175376054932*std::sin(0.218239992856979*x_37 + 1.97247982025146) - 0.00513054551872738*std::sin(0.240559980273247*x_39 - 1.21007990837097) - 0.000352595362808471*std::sin(0.3713598549366*x_4 - 1.20103991031647) + 0.00280115969323411*std::sin(0.380799859762192*x_4 + 1.98911988735199) + 0.000224082509536021*std::sin(1.04431986808777*x_4 + 6.76743984222412) + 0.0112557284952078*std::sin(0.232239991426468*x_41 - 4.4125599861145) - 0.00133348770497812*std::sin(0.248079970479012*x_41 + 1.96991980075836) - 0.00694624323621548*std::sin(0.249439969658852*x_42 + 1.97775983810425) - 0.00680737075747317*std::sin(0.221519991755486*x_45 + 1.96543979644775) - 0.00088340640636849*std::sin(0.199280008673668*x_47 + 1.97479975223541) - 0.00322733337932277*std::sin(0.219679996371269*x_48 - 7.40263986587524) - 0.00015043114121314*std::sin(0.364319831132889*x_49 + 1.84487986564636) + 0.000703376212093288*std::sin(0.308079928159714*x_5 + 2.01263976097107) - 0.00478662673510677*std::sin(0.31399992108345*x_5 - 1.18407988548279) + 0.00430909790383608*std::sin(0.230079978704453*x_50 - 7.44495964050293) + 0.000953157396248458*std::sin(0.199359998106956*x_51 - 4.39431953430176) + 0.00974277693624175*std::sin(0.208000004291534*x_51 + 8.20343971252441) - 0.00352257008429266*std::sin(0.210879996418953*x_51 + 8.1988000869751) + 0.00462869430640639*std::sin(0.22639998793602*x_53 + 1.97503972053528) - 0.000594980373304708*std::sin(0.253679990768433*x_53 - 7.42943954467773) + 0.00559119806412163*std::sin(0.254559963941574*x_53 + 5.15840005874634) + 0.00457307459395394*std::sin(0.193759992718697*x_54 - 4.3953595161438) - 0.000649762559438622*std::sin(0.226559996604919*x_55 - 7.41791963577271) - 0.00529822042226219*std::sin(0.18792000412941*x_56 + 8.20448017120361) + 0.00722219092855585*std::sin(0.245999976992607*x_57 - 7.43856000900269) + 0.00663959671175956*std::sin(0.0536801069974899*x_59 + 8.01991939544678) + 0.00280748484914087*std::sin(0.385519832372665*x_59 + 1.81727981567383) + 0.00277886585582506*std::sin(0.24415996670723*x_6 - 1.15775990486145) - 0.00429430409076684*std::sin(0.397839844226837*x_6 + 1.98791980743408) - 0.00294792275888036*std::sin(0.355519831180573*x_60 + 8.25080013275146) + 0.00299078975707479*std::sin(0.410879880189896*x_60 - 1.20055997371674) - 0.000375195745447275*std::sin(0.417359858751297*x_60 - 1.23583984375) + 3.36501298293724e-5*std::sin(1.03327977657318*x_64 - 4.59127998352051) + 0.000369024452529497*std::sin(0.312879920005798*x_7 - 7.39871978759766) - 0.00351243783795689*std::sin(0.350159853696823*x_7 + 2.01959991455078) - 0.00259811674894451*std::sin(0.366479843854904*x_7 + 2.00175976753235) + 0.00133819027927496*std::sin(0.355759829282761*x_8 - 1.14231991767883) + 0.00153223733914877*std::sin(0.494479864835739*x_8 - 1.44279980659485) - 0.000795073169326351*std::sin(0.312239944934845*x_9 - 7.42360019683838) - 0.00277227130968146*std::sin(0.365279853343964*x_91 + 1.97591972351074) + 0.0048493970936281*std::sin(0.263279944658279*x_92 - 7.39527988433838) - 0.000540169610846333*std::sin(0.292799949645996*x_92 - 1.16527986526489) + 0.00465033973688679*std::sin(0.236319988965988*x_93 + 1.98023986816406) + 0.00301505774404892*std::sin(0.236479982733727*x_93 - 1.18967986106873) - 0.00190284519954179*std::sin(0.291119933128357*x_94 + 1.8025598526001) - 0.000272041597578372*std::sin(0.267839968204498*x_95 + 1.96391975879669) + 0.000754503916310245*std::sin(0.276799947023392*x_97 + 1.95687973499298) + 0.0057002746401422*std::sin(0.279599964618683*x_97 - 1.20447981357574) - 0.00242085791306713*std::sin(0.291679948568344*x_97 + 8.16464042663574) - 0.000610602017799372*std::sin(0.230719983577728*x_98 + 5.18800020217896) - 0.00899888201776911*std::sin(0.232399985194206*x_98 + 1.98495984077454) - 0.0144607463577853);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000293811250321253*x_1 + 0.000263525974910236*x_10 - 0.00144573629895124*x_100 + 0.000423646899526368*x_101 + 0.00228293278163666*x_102 - 0.00104682542529042*x_103 + 0.00110252052542978*x_104 - 0.00137224381299301*x_105 + 0.000310127412156555*x_106 + 0.00107555442238443*x_107 - 0.000159340623777965*x_108 + 0.00133425285848366*x_109 - 1.74358791246128e-5*x_11 - 9.92401680585269e-5*x_110 + 0.00103282668592104*x_111 - 0.00164337284665602*x_112 - 0.000232932144894367*x_113 - 0.00141697077122464*x_114 - 0.000323853271858947*x_115 - 5.24805164382239e-5*x_116 - 0.00219643168925903*x_117 - 0.0025513950286011*x_118 - 0.000552808385271582*x_119 + 0.000470446179407802*x_12 - 0.00111331128849527*x_120 - 0.000385699084678121*x_13 + 7.79357994142322e-5*x_15 - 0.000227101990095459*x_16 + 0.00149888634381872*x_17 + 0.00177276851570571*x_18 - 0.000739839145102588*x_19 - 0.000173541816633499*x_2 + 0.000569149378555633*x_20 + 0.000839128239354597*x_21 - 4.84923958626665e-5*x_22 + 0.000479021658702438*x_23 + 0.00268220059704633*x_24 - 0.000284808820892938*x_25 - 0.000895699499403744*x_26 + 0.000151102555466944*x_27 + 0.000460714905082075*x_28 - 0.000386893107990086*x_29 + 0.000157492034542758*x_3 + 1.72731036122157e-5*x_30 - 4.56228122069679e-6*x_31 + 0.00118427712594053*x_32 + 0.000597847698622415*x_33 + 0.00043459341671784*x_34 + 0.00121225168690581*x_35 - 0.000342680112896818*x_36 - 0.000901461474319659*x_37 + 0.00133968115361758*x_38 + 0.000113527113951491*x_39 + 1.25397142245493e-5*x_4 - 0.00146232704405808*x_40 + 0.00235404320905785*x_41 - 0.000159704005593278*x_42 - 0.00271756663373031*x_43 - 8.0654139120605e-5*x_44 + 0.00205993364243278*x_45 + 0.000832357151909731*x_46 - 6.29326126723113e-5*x_47 - 0.00148282921826997*x_48 + 5.28579395700423e-5*x_49 + 0.000290139454708523*x_5 + 0.00318410282706178*x_50 - 0.000111916620117105*x_51 + 0.00169906831356968*x_52 - 3.39057795509864e-5*x_53 + 0.00423153161956338*x_54 - 0.00228864880609933*x_55 + 0.00124477032828311*x_56 - 4.04909109582971e-5*x_57 + 0.00133941852929715*x_58 - 0.0041280469870821*x_59 + 3.18444332100338e-5*x_6 + 3.9113849314846e-5*x_60 + 2.56442400101657e-5*x_61 - 6.34050962737721e-6*x_62 + 0.00141597079790916*x_63 - 0.00063717672031483*x_64 - 0.00112518035935784*x_65 + 0.00027238304181493*x_66 + 0.00010126073053901*x_67 - 0.000928736996021112*x_68 + 0.000731771492214163*x_69 + 5.83717758830785e-5*x_7 + 0.00146145539837329*x_70 - 0.000327354004806476*x_71 - 0.00065010673665971*x_72 - 0.000784686094317062*x_73 + 0.00138310773208251*x_74 - 0.000182652347314954*x_75 - 0.000386252058958265*x_76 + 0.000153418828847971*x_77 + 0.00103133953004913*x_78 - 0.00038121847540292*x_79 + 0.00131907219366299*x_8 - 0.000792674527789549*x_80 - 0.00148882170635457*x_81 + 0.000921377030209481*x_82 + 0.00119957776006587*x_83 - 0.00114624798565854*x_84 + 0.00100923805265097*x_85 + 0.000638176066485167*x_86 + 0.000962129137496106*x_87 - 0.000906554337349057*x_88 - 0.000474777181447962*x_89 + 0.000186920246750633*x_9 - 0.000906695072147922*x_90 - 8.54289577132198e-6*x_91 + 5.12901918759877e-5*x_92 - 8.49926261568067e-6*x_93 + 0.000643064127012319*x_94 - 0.000222039209531532*x_95 - 0.000348244336737043*x_96 + 1.96771021303129e-5*x_97 + 0.000268520001484804*x_98 + 0.000196503097101506*x_99 - 6.34821118020634e-7*std::pow(-9.91328048706055*x_10 - 9.80399990081787, 2) - 3.67040100168823e-6*std::pow(-8.66760063171387*x_23 - 8.67360019683838, 2) + 2.2397511038986e-5*std::pow(-2.00767993927002*x_29 - 7.99128007888794, 2) - 8.87810532901889e-6*std::pow(-5.30592012405396*x_30 - 9.79191970825195, 2) - 7.8119720824517e-7*std::pow(-2.82407999038696*x_43 - 9.27255916595459, 2) - 1.94926869089023e-6*std::pow(-1.9560798406601*x_49 - 6.25687980651855, 2) - 1.53647445187461e-6*std::pow(-2.78144001960754*x_57 - 8.74015998840332, 2) - 7.22133829834389e-5*std::pow(-1.45055985450745*x_58 - 3.72727990150452, 2) - 1.67170119072706e-5*std::pow(-3.40543985366821*x_61 - 6.01567983627319, 2) + 8.28101707189352e-5*std::exp(0.343279838562012*x_23) - 0.000605769681784831*std::exp(0.148799866437912*x_49) + 0.00198500979388414*std::exp(0.172799870371819*x_49) - 0.00360479374150649*std::log(6.24751996994019 - 0.6004798412323*x_15) - 0.000614733810924471*std::sin(0.273519963026047*x_1 - 4.31824016571045) - 0.00573580494744274*std::sin(0.381679862737656*x_1 - 4.22352027893066) + 0.0134306703035086*std::sin(0.437119841575623*x_1 - 7.18616008758545) - 0.00505023160865456*std::sin(0.338639855384827*x_10 - 4.34327983856201) - 0.000338736694286795*std::sin(0.356239855289459*x_10 - 1.16279983520508) + 0.00690557040523154*std::sin(0.249999970197678*x_100 - 1.20175993442535) + 0.000434676931845957*std::sin(0.253279983997345*x_100 + 8.16903972625732) + 0.00175699452904823*std::sin(0.220319986343384*x_101 + 4.9814395904541) + 0.00418646797075687*std::sin(0.241359978914261*x_102 - 1.21223986148834) + 0.00291993953638777*std::sin(0.183360010385513*x_104 - 1.39951992034912) + 0.00566402933076296*std::sin(0.250479966402054*x_106 - 7.61360025405884) + 0.00563535357653955*std::sin(0.247279971837997*x_108 + 1.95583975315094) - 0.0095377181235004*std::sin(0.257359951734543*x_108 - 7.42712020874023) - 0.0142542856463629*std::sin(0.243679970502853*x_109 - 7.43919992446899) + 0.00312877726722345*std::sin(0.287599951028824*x_109 + 4.77304029464722) - 0.000483870271512275*std::sin(0.243759974837303*x_11 - 7.41639995574951) - 0.00856119960068208*std::sin(0.37407985329628*x_11 + 5.032639503479) + 0.000937306476249744*std::sin(0.233999982476234*x_110 - 1.21967995166779) - 0.00261484701284817*std::sin(0.284559935331345*x_110 + 7.94407987594604) - 0.000764458426156597*std::sin(0.248159974813461*x_112 + 1.98031985759735) + 0.00345261736798344*std::sin(0.297039926052094*x_112 - 1.24703979492188) + 0.00517682947438577*std::sin(0.182320013642311*x_113 - 0.98695981502533) + 0.000328096855163571*std::sin(0.270559966564178*x_113 + 1.98671984672546) - 0.0073641715154623*std::sin(0.282879948616028*x_113 + 1.97383987903595) - 0.000373599422306662*std::sin(0.219999983906746*x_116 - 4.20359992980957) + 0.00599376237748739*std::sin(0.239839985966682*x_116 + 4.99567985534668) + 0.00479414574110083*std::sin(0.253439962863922*x_119 - 1.2267199754715) + 0.00528545637508952*std::sin(0.303039938211441*x_12 + 5.12728023529053) - 0.00934064938692913*std::sin(0.357359826564789*x_12 - 1.35935986042023) + 0.0048866068416393*std::sin(0.38087984919548*x_13 - 7.3758397102356) + 0.000391482919720326*std::sin(0.442479848861694*x_13 + 1.92767989635468) + 0.00286513981798256*std::sin(0.111040063202381*x_14 + 8.12263965606689) - 0.00429785244051793*std::sin(0.260159969329834*x_14 + 2.13895988464355) + 0.00520787786280405*std::sin(0.313599914312363*x_14 - 7.46143960952759) + 0.000378855348979569*std::sin(0.378799855709076*x_14 + 5.03047943115234) - 0.0106726185663705*std::sin(0.405359864234924*x_14 - 7.59216022491455) + 0.00648329742024977*std::sin(0.252079963684082*x_15 - 7.4113597869873) + 0.0186064083877918*std::sin(0.282559931278229*x_15 - 7.42799949645996) - 0.000527707656696908*std::sin(0.290639936923981*x_15 + 5.16328001022339) + 0.0136567635181639*std::sin(0.194240003824234*x_16 + 8.20448017120361) - 0.000265640057432628*std::sin(0.337679862976074*x_16 - 1.15767979621887) + 0.00822302916827172*std::sin(0.447039842605591*x_16 - 1.24167990684509) + 0.00355205944435002*std::sin(0.315039932727814*x_17 + 1.82631993293762) - 0.000343113374907098*std::sin(0.345279842615128*x_17 - 1.17911994457245) - 0.00765785974546231*std::sin(0.178240016102791*x_18 + 1.95119976997375) - 0.00581672558874616*std::sin(0.443679869174957*x_18 + 1.94863975048065) + 0.0113030949415693*std::sin(0.322959929704666*x_19 + 1.99087977409363) - 0.000311383617405738*std::sin(0.390159845352173*x_19 - 1.16807985305786) + 0.000428101561104651*std::sin(0.367999851703644*x_2 - 7.41447973251343) + 0.00544377071644804*std::sin(0.404399842023849*x_2 + 1.97687971591949) - 0.0048710677135636*std::sin(0.405919849872589*x_2 + 2.01239991188049) - 0.000761331239726579*std::sin(0.269759953022003*x_21 - 1.17471981048584) + 0.000319194125678234*std::sin(0.298719942569733*x_21 - 7.41016006469727) + 0.000145387695476147*std::sin(0.315119922161102*x_22 - 4.36552000045776) + 0.00538280536943661*std::sin(0.398959845304489*x_22 - 1.17631983757019) - 0.0173203158199836*std::sin(0.400479853153229*x_22 + 2.00727987289429) - 0.000373425008827478*std::sin(0.273519963026047*x_23 - 4.36448001861572) + 0.00520648969267128*std::sin(0.422159850597382*x_23 + 5.19608020782471) + 0.0051681153083097*std::sin(0.388799846172333*x_24 + 5.20887994766235) + 0.00677165078673181*std::sin(0.24551996588707*x_25 - 7.39271974563599) + 0.000470203058347985*std::sin(0.342239856719971*x_25 - 1.15543985366821) - 0.0145612403551065*std::sin(0.349199831485748*x_25 + 2.03151988983154) + 0.000660105849704253*std::sin(0.369199842214584*x_26 - 1.15751981735229) + 0.00500044251480419*std::sin(0.442559868097305*x_26 - 7.44799947738647) + 0.0144054594221854*std::sin(0.298239946365356*x_27 + 5.1923999786377) - 0.00039645231536669*std::sin(0.319439917802811*x_27 + 1.80935990810394) + 0.004436473921981*std::sin(0.369999825954437*x_27 - 4.38503980636597) - 0.000447532302969016*std::sin(0.234079986810684*x_28 - 1.18439984321594) + 0.000529262449092792*std::sin(0.31687992811203*x_28 + 1.99743974208832) + 0.0012719713179396*std::sin(0.685199856758118*x_28 + 4.94039964675903) - 0.00659652080576889*std::sin(0.232639983296394*x_29 - 1.37055993080139) + 0.000604482549785917*std::sin(0.278799951076508*x_29 - 1.16959989070892) + 0.00100990413522181*std::sin(0.350799858570099*x_3 - 4.20911979675293) + 0.00372689739731884*std::sin(0.458639860153198*x_3 - 4.39296007156372) - 0.00238813690177702*std::sin(0.554639875888824*x_3 + 8.19847965240479) - 0.00514462035127506*std::sin(0.24679996073246*x_30 + 8.22175979614258) + 0.0161275911976111*std::sin(0.311679929494858*x_30 - 1.0311998128891) + 0.000362885674588746*std::sin(0.329039841890335*x_30 - 1.17311990261078) - 0.0076023818580076*std::sin(0.295199930667877*x_31 + 5.3310399055481) + 0.00596456952264367*std::sin(0.328239858150482*x_31 - 4.25680017471313) - 0.00138711012364426*std::sin(0.404639840126038*x_31 - 1.20063984394073) + 0.000186291159083707*std::sin(0.513359844684601*x_31 + 8.15312004089355) + 9.72003618783213e-5*std::sin(0.257599949836731*x_32 + 8.03176021575928) + 0.00978412345772109*std::sin(0.305119931697845*x_32 - 1.15055990219116) - 0.0126958868518143*std::sin(0.248399972915649*x_33 - 1.19327986240387) - 0.00548088922787654*std::sin(0.226879999041557*x_35 - 1.20903992652893) + 0.000454892390851068*std::sin(0.233999997377396*x_35 - 1.21071982383728) + 0.000957199364337458*std::sin(0.24975997209549*x_36 - 7.42927980422974) + 0.000931979279791021*std::sin(0.218239992856979*x_37 + 1.97247982025146) + 0.00407948266874935*std::sin(0.240559980273247*x_39 - 1.21007990837097) + 0.0212640010108767*std::sin(0.288719952106476*x_4 - 7.37999963760376) - 0.00397073351807589*std::sin(0.3713598549366*x_4 - 1.20103991031647) + 0.000471934020653284*std::sin(0.380799859762192*x_4 + 1.98911988735199) - 0.000178176123900526*std::sin(1.04431986808777*x_4 + 6.76743984222412) - 0.00894983762501307*std::sin(0.232239991426468*x_41 - 4.4125599861145) + 0.000325567920276658*std::sin(0.248079970479012*x_41 + 1.96991980075836) + 0.00552320972333706*std::sin(0.249439969658852*x_42 + 1.97775983810425) - 0.0139803211183037*std::sin(0.280639946460724*x_44 - 7.47559976577759) - 0.001146892788516*std::sin(0.221519991755486*x_45 + 1.96543979644775) - 0.00994843324061453*std::sin(0.199280008673668*x_47 + 1.97479975223541) + 0.000787945934876688*std::sin(0.219679996371269*x_48 - 7.40263986587524) - 0.00169407212227543*std::sin(0.364319831132889*x_49 + 1.84487986564636) - 0.000171727665495831*std::sin(0.308079928159714*x_5 + 2.01263976097107) + 0.00380602038055477*std::sin(0.31399992108345*x_5 - 1.18407988548279) - 0.00975384853295291*std::sin(0.376479834318161*x_5 + 2.00879979133606) + 0.000725988562543564*std::sin(0.230079978704453*x_50 - 7.44495964050293) + 0.0107339302228474*std::sin(0.199359998106956*x_51 - 4.39431953430176) - 0.00774683501234151*std::sin(0.208000004291534*x_51 + 8.20343971252441) + 0.00086002728940853*std::sin(0.210879996418953*x_51 + 8.1988000869751) - 0.00368044258315195*std::sin(0.22639998793602*x_53 + 1.97503972053528) + 0.00583447821381672*std::sin(0.240399971604347*x_53 - 1.20711994171143) - 0.00670033914246801*std::sin(0.253679990768433*x_53 - 7.42943954467773) + 0.000941994342215907*std::sin(0.254559963941574*x_53 + 5.15840005874634) + 0.000770462849756455*std::sin(0.193759992718697*x_54 - 4.3953595161438) - 0.00731726575472627*std::sin(0.226559996604919*x_55 - 7.41791963577271) + 0.00129354818766141*std::sin(0.18792000412941*x_56 + 8.20448017120361) - 0.0146735445878005*std::sin(0.23471999168396*x_57 + 1.97623980045319) - 0.00574262573363749*std::sin(0.245999976992607*x_57 - 7.43856000900269) + 0.0747714575707877*std::sin(0.0536801069974899*x_59 + 8.01991939544678) - 0.000685440893178702*std::sin(0.385519832372665*x_59 + 1.81727981567383) - 0.000678453632554209*std::sin(0.24415996670723*x_6 - 1.15775990486145) + 0.00341455680466669*std::sin(0.397839844226837*x_6 + 1.98791980743408) - 0.000496660380889415*std::sin(0.355519831180573*x_60 + 8.25080013275146) - 0.000730194359918414*std::sin(0.410879880189896*x_60 - 1.20055997371674) - 0.00422524649904775*std::sin(0.417359858751297*x_60 - 1.23583984375) - 0.00744941369159258*std::sin(0.490879863500595*x_60 - 7.56831979751587) - 8.21560089732368e-6*std::sin(1.03327977657318*x_64 - 4.59127998352051) + 0.00415574881920504*std::sin(0.312879920005798*x_7 - 7.39871978759766) - 0.000591768800317085*std::sin(0.350159853696823*x_7 + 2.01959991455078) + 0.000634324158694583*std::sin(0.366479843854904*x_7 + 2.00175976753235) - 0.0102211378134626*std::sin(0.429519861936569*x_7 + 8.19087982177734) - 0.000326716042848808*std::sin(0.355759829282761*x_8 - 1.14231991767883) - 0.00121833743539586*std::sin(0.494479864835739*x_8 - 1.44279980659485) - 0.00895367329173258*std::sin(0.312239944934845*x_9 - 7.42360019683838) - 0.000467066961116084*std::sin(0.365279853343964*x_91 + 1.97591972351074) - 0.0112318575585924*std::sin(0.373839855194092*x_91 + 5.19048023223877) + 0.000817017135320099*std::sin(0.263279944658279*x_92 - 7.39527988433838) - 0.00608309071948467*std::sin(0.292799949645996*x_92 - 1.16527986526489) + 0.000783480333068358*std::sin(0.236319988965988*x_93 + 1.98023986816406) - 0.000736119332468947*std::sin(0.236479982733727*x_93 - 1.18967986106873) + 0.0124104862374821*std::sin(0.2483199685812*x_93 - 1.21671986579895) + 0.000464575227735908*std::sin(0.291119933128357*x_94 + 1.8025598526001) + 0.00137432199634052*std::sin(0.337679862976074*x_94 + 1.8290399312973) - 0.00306358166826522*std::sin(0.267839968204498*x_95 + 1.96391975879669) - 0.0125439836986482*std::sin(0.285919934511185*x_95 - 1.22239983081818) + 0.00849680485344329*std::sin(0.276799947023392*x_97 + 1.95687973499298) - 0.00919645133320546*std::sin(0.277999937534332*x_97 + 8.18935966491699) + 0.000960371354852788*std::sin(0.279599964618683*x_97 - 1.20447981357574) + 0.000591046826378867*std::sin(0.291679948568344*x_97 + 8.16464042663574) - 0.00687626144305743*std::sin(0.230719983577728*x_98 + 5.18800020217896) + 0.0071553372045153*std::sin(0.232399985194206*x_98 + 1.98495984077454) + 0.107631685463038);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
