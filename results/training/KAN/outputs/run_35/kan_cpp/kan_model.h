
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-2762.00409260295*x_1 - 125.241587161459*x_10 - 25.8126210832135*x_100 + 24.688146041008*x_101 - 271.977283850845*x_102 - 69.6494995872499*x_103 + 138.982431391178*x_104 + 28.6167948234113*x_105 - 22.0547512062941*x_106 + 32.9034818750337*x_107 + 199.548048499126*x_108 - 58.2279390949529*x_109 + 190.171215128658*x_11 - 102.159895733834*x_110 + 34.9048537390769*x_111 + 79.1391606969167*x_112 - 315.221654763724*x_113 + 120.685703770022*x_114 - 250.598431501145*x_115 + 953.237727485463*x_116 - 6.59838051796154*x_117 - 153.940882213287*x_118 - 53.7403499178139*x_119 - 496.489664072088*x_12 + 776.116258128599*x_120 + 305.420949013605*x_13 + 94.0838421161886*x_14 + 147.84635973372*x_15 + 52.8546090665795*x_16 - 134.899094685021*x_17 + 55.4906608010718*x_18 + 52.0370736061806*x_19 - 300.148317309556*x_2 + 592.001775826518*x_20 + 254.977992689792*x_21 + 560.999434420059*x_22 - 249.133158148404*x_23 - 58.947263108676*x_24 + 420.608105323885*x_25 - 88.9187173166395*x_26 + 97.2606610013794*x_27 + 2.22854913009216*x_28 + 355.37185932786*x_29 - 790.064438954594*x_3 - 1319.41264193914*x_30 - 6599.56451271894*x_31 + 41.7043257597808*x_32 + 2.51514389467958*x_33 - 314.702550292796*x_34 - 552.147329697666*x_35 - 219.527213823282*x_36 - 1601.56159385495*x_37 - 1.51783178672816*x_38 - 37.9678499941535*x_39 - 18.9190416535811*x_4 + 205.794486629966*x_40 - 312.418407641951*x_41 - 12587.666883705*x_42 + 167.043521288962*x_43 + 231.514551427969*x_44 - 199.276928383903*x_45 + 80.3386667128073*x_46 + 645.575973228057*x_47 + 207.296753663924*x_48 + 976.770109933778*x_49 + 66.8220697573562*x_5 + 1034.10428023301*x_50 - 354.272742234979*x_51 + 483.196894343967*x_52 - 0.547986279129599*x_53 + 176.106886*x_54 + 244.71188523184*x_55 + 25.3429588419742*x_56 + 1773.63849286615*x_57 + 97.4488936363942*x_58 - 126.366520934484*x_59 - 26.2598481780211*x_6 - 11.3467038516074*x_60 - 143.292554121963*x_61 - 278.115693040708*x_62 + 106.720305739171*x_63 + 237.221519738954*x_64 - 162.549535050932*x_65 + 261.647060984961*x_66 - 203.678860031676*x_67 + 28.7101718620184*x_68 - 245.143931844831*x_69 + 176.497575576455*x_7 - 157.273966730143*x_70 - 88.899374714787*x_72 + 446.155885965125*x_73 + 215.380551163527*x_74 + 1.25966220617701*x_75 + 467.357879845096*x_76 - 132.183577651013*x_77 - 132.971339158617*x_78 + 166.116046197208*x_79 - 840.17810559766*x_8 - 0.68263625186786*x_80 - 224.984678356282*x_81 + 57.7273975819578*x_82 - 25.5360637502812*x_83 + 748.813064691564*x_84 + 251.815177405807*x_85 + 196.607717045884*x_86 + 1.4175506410478*x_87 + 539.579847553351*x_88 - 17.8964654188739*x_89 - 746.844587416231*x_9 + 1350.21477148461*x_90 + 84.2754725500856*x_91 + 123.676839137376*x_92 + 78.8775400167655*x_93 + 15.5313068720442*x_94 + 69.8581815516957*x_95 - 7.12685078474952*x_96 + 599.249123699979*x_97 + 187.848396747344*x_98 + 67.7928395064286*x_99 + 0.000450887472038023*std::pow(-6.07103967666626*x_108 - 7.07919979095459, 2) - 0.0664258567171711*std::pow(-4.9137601852417*x_15 - 7.16799974441528, 2) - 0.0350188831420473*std::pow(-3.83136010169983*x_5 - 5.6496000289917, 2) - 0.000307002639380777*std::pow(-6.97944021224976*x_66 - 9.56559944152832, 2) - 0.000790044106214994*std::pow(-6.47760009765625*x_66 - 9.91936016082764, 2) - 0.165466655540673*std::pow(-2.56959986686707*x_78 - 3.36103987693787, 2) + 0.00023362277894181*std::pow(-5.75359964370728*x_80 - 9.53351974487305, 2) + 0.000588929898752977*std::pow(-4.86624002456665*x_80 - 8.31335926055908, 2) - 0.163621384726427*std::exp(1.07743978500366*x_38) + 0.00234093870348274*std::exp(1.24855983257294*x_38) + 0.368485009189818*std::exp(2.51327991485596*x_71) - 0.0168794937345451*std::exp(2.54871988296509*x_71) + 0.00482092485169151*std::exp(2.56639981269836*x_71) - 0.00262473756419477*std::exp(2.57943987846375*x_71) + 0.200074243024041*std::exp(2.59703993797302*x_71) - 0.00241260259438903*std::exp(2.60055994987488*x_71) - 16.8910240617339*std::exp(2.62087988853455*x_71) - 0.000750295139394903*std::exp(2.62655997276306*x_71) - 0.0100773721366858*std::exp(2.64127993583679*x_71) - 0.000384359182524116*std::exp(2.66215991973877*x_71) + 0.0145959088875233*std::exp(2.08487987518311*x_89) - 0.0671194976064393*std::sin(0.391359835863113*x_103 - 1.19543993473053) + 0.522325928413373*std::sin(0.400079846382141*x_103 - 4.20904016494751) + 0.0367777950098051*std::sin(0.538159847259521*x_106 - 1.01255977153778) - 11.7379049038627*std::sin(0.284559935331345*x_112 - 7.52672004699707) + 0.290147332369976*std::sin(0.471759855747223*x_114 + 8.24191951751709) + 7.78476971870104*std::sin(0.317359834909439*x_16 - 4.27519989013672) - 0.338107878460836*std::sin(0.344799846410751*x_18 + 1.95295989513397) - 4.02817445831343*std::sin(0.531999886035919*x_22 + 8.51503944396973) + 0.171157677869385*std::sin(0.334559857845306*x_26 + 5.13928031921387) - 5.92238608657727*std::sin(0.296879917383194*x_28 + 5.12831974029541) + 0.0839347322188706*std::sin(0.303199917078018*x_28 + 5.13359975814819) + 1936.05747167499*std::sin(0.326479852199554*x_28 - 4.28679990768433) + 0.775908277446565*std::sin(0.330159842967987*x_28 - 4.26823997497559) - 0.115990639491698*std::sin(0.336159855127335*x_28 + 5.13064002990723) + 22.1443159381408*std::sin(0.3781598508358*x_34 + 1.97439980506897) + 17.5083225855921*std::sin(0.33943983912468*x_36 + 5.15008020401001) - 0.153685991208157*std::sin(0.343679845333099*x_36 + 5.15984010696411) - 2.00676300849911*std::sin(0.392479836940765*x_36 - 7.40767955780029) - 0.0294777496971677*std::sin(0.438079863786697*x_36 + 8.22991943359375) - 983.637049211016*std::sin(0.521199882030487*x_38 + 5.15520000457764) - 0.31013784858493*std::sin(0.35471984744072*x_40 + 5.15056037902832) + 0.941717378124277*std::sin(0.622799813747406*x_52 + 5.21663999557495) - 0.21116559660819*std::sin(0.145520031452179*x_53 + 4.93263959884644) + 9.69137643920245*std::sin(0.209680005908012*x_53 - 4.39447975158691) + 1409.39773196195*std::sin(0.416639864444733*x_53 + 5.20344018936157) + 0.322268420272602*std::sin(0.5204798579216*x_53 - 1.03647983074188) + 2409.46529465781*std::sin(0.310239911079407*x_60 - 7.48520040512085) - 1.68635899668459*std::sin(0.312479853630066*x_66 - 1.27471995353699) - 0.738837059349472*std::sin(0.287519931793213*x_80 + 1.90727996826172) + 2.48728031987328*std::sin(0.423599869012833*x_80 - 7.37215995788574) + 808.876760113342*std::sin(0.549839854240417*x_80 + 2.13167977333069) + 0.0273063750727803*std::sin(0.61959981918335*x_80 + 2.20671987533569) + 0.422810006744349*std::sin(0.339919835329056*x_83 + 5.14775991439819) - 7762.85743006219*std::sin(0.145120039582253*x_87 - 7.65576028823853) + 0.0167432195839837*std::sin(0.663759827613831*x_87 + 5.43271970748901) - 0.285675675435403*std::sin(0.686799824237823*x_88 + 8.46360015869141) - 5.34760254046483*std::sin(0.348319828510284*x_92 + 1.99511981010437) + 0.064648168875247*std::sin(0.432319849729538*x_94 - 1.16055989265442) + 0.125946153662804*std::sin(0.359359860420227*x_95 + 5.1800799369812) + 0.180436686588203*std::sin(0.378639847040176*x_95 - 7.41328001022339) + 0.182442709519495*std::sin(0.396399825811386*x_96 + 5.18255996704102) - 0.428690455326674*std::sin(0.444879859685898*x_96 - 7.36631965637207) - 0.170952765957508*std::sin(0.496719866991043*x_98 - 1.12415993213654) - 0.45300021436363*std::sin(0.414719849824905*x_99 + 5.21799993515015) - 9951.53269667869 - 4.30461496011885e-6*std::exp(-4.15696001052856*x_74) - 0.00114560291572568*std::exp(-2.77735996246338*x_74) - 0.00039276159203945*std::exp(-2.6898398399353*x_74) - 0.00262740270407614*std::exp(-2.56887984275818*x_74) - 1.56764780529422e-5*std::exp(-4.01143980026245*x_45) - 4.84981495858071e-5*std::exp(-3.89863991737366*x_45) + 0.00156182117491137*std::exp(-3.8931999206543*x_45) + 1.30047167772678e-5*std::exp(-4.58256006240845*x_111) + 8.42532243102873e-6*std::exp(-4.382399559021*x_111));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-608.78775664165*x_1 - 25.6218936121641*x_10 - 14.3913526235623*x_100 + 10.7423582145052*x_101 - 55.5256891668745*x_102 - 16.629760416393*x_103 + 16.2603717383491*x_104 + 5.5482928083708*x_105 - 4.54357663671514*x_106 + 7.89663054810229*x_107 + 34.2138753537832*x_108 - 18.6873398103682*x_109 + 37.2655020453648*x_11 - 22.3356439399823*x_110 + 10.596848603627*x_111 + 13.2849148878204*x_112 - 54.3389554507347*x_113 + 21.0570407089768*x_114 - 45.469557282018*x_115 + 207.295121835551*x_116 - 2.23223506841079*x_117 - 30.1233953182487*x_118 - 9.46563128378069*x_119 - 54.1693352996933*x_12 + 147.515540727435*x_120 + 56.7531574844282*x_13 + 17.201514331488*x_14 + 27.5708594460366*x_15 + 9.04333524263816*x_16 - 29.6086748192153*x_17 + 6.73932052938608*x_18 + 11.7770225497537*x_19 - 59.8388455297908*x_2 + 118.507805165724*x_20 + 57.5220385524874*x_21 + 105.340767377435*x_22 - 46.6243499744064*x_23 - 11.7443031926849*x_24 + 75.4064211501672*x_25 - 17.9789488961648*x_26 + 16.709768300113*x_27 + 1.76310499822991*x_28 + 68.9776806736881*x_29 - 150.010985262316*x_3 - 236.351777443981*x_30 - 1162.58929198495*x_31 + 6.35251887897931*x_32 + 2.37285708482764*x_33 - 61.1252756331773*x_34 - 107.662877239897*x_35 - 41.2619595728936*x_36 - 288.657861576578*x_37 - 4.68799258815453*x_38 - 9.73581504374418*x_39 - 4.30014601912049*x_4 + 38.9078947208552*x_40 - 55.6128309848002*x_41 - 5229.44500654922*x_42 + 34.6220157510111*x_43 + 43.3694071173837*x_44 - 37.8894129434317*x_45 + 15.4254727718525*x_46 + 120.052443761651*x_47 + 44.5716538477773*x_48 + 175.533353480603*x_49 + 12.8326234279257*x_5 + 175.382691750001*x_50 - 61.558549838673*x_51 + 102.538978416091*x_52 - 0.35949476474056*x_53 + 42.3648104889839*x_54 + 41.9585668226513*x_55 + 1.07991543464309*x_56 + 323.409333185043*x_57 + 19.9900453058*x_58 - 25.0327365552029*x_59 - 6.00022197042421*x_6 - 7.2922157849049*x_60 - 29.1118165580775*x_61 - 56.8361308166977*x_62 + 23.4462461705591*x_63 + 45.2751040367048*x_64 - 33.3225591626402*x_65 + 48.4615322911893*x_66 - 39.2344781882312*x_67 + 6.59849499821426*x_68 - 50.6890696484372*x_69 + 33.0054012011387*x_7 - 22.7542066379124*x_70 - 15.4145797146012*x_72 + 86.5536959231483*x_73 + 41.6493751065472*x_74 + 2.81486916568737*x_75 + 93.2327986383389*x_76 - 20.0323301275159*x_77 - 26.0149752114174*x_78 + 33.2763828910872*x_79 - 165.636137406263*x_8 - 0.668567864258466*x_80 - 45.4304890689754*x_81 + 13.2614260618519*x_82 - 6.61887201579301*x_83 + 144.517861587023*x_84 + 48.0650481473855*x_85 + 41.4744789049139*x_86 + 1.35763649438094*x_87 + 107.38841625719*x_88 - 8.31064402536011*x_89 - 136.671582512662*x_9 + 259.304863168393*x_90 + 11.6071504733067*x_91 + 24.6530971314044*x_92 + 14.8061514080046*x_93 + 2.98193632343733*x_94 + 12.1382888853113*x_95 - 2.58124743986128*x_96 + 106.640564135629*x_97 + 35.9885857759234*x_98 + 8.93612574652913*x_99 - 0.00708936221778397*std::pow(-6.07103967666626*x_108 - 7.07919979095459, 2) - 0.0537345037891136*std::pow(-4.9137601852417*x_15 - 7.16799974441528, 2) - 0.0293263484425301*std::pow(-3.83136010169983*x_5 - 5.6496000289917, 2) + 0.00482704232732042*std::pow(-6.97944021224976*x_66 - 9.56559944152832, 2) + 0.0135375662451289*std::pow(-6.47760009765625*x_66 - 9.91936016082764, 2) - 0.133852524732645*std::pow(-2.56959986686707*x_78 - 3.36103987693787, 2) + 0.000114493626740541*std::pow(-5.75359964370728*x_80 - 9.53351974487305, 2) - 7.19268925243512e-5*std::pow(-4.86624002456665*x_80 - 8.31335926055908, 2) + 0.03513241140411*std::exp(1.07743978500366*x_38) + 0.00069049718163171*std::exp(1.24855983257294*x_38) + 0.298082103883855*std::exp(2.51327991485596*x_71) + 0.00362432648499249*std::exp(2.54871988296509*x_71) - 0.000588786788393355*std::exp(2.56639981269836*x_71) + 0.0412690892365969*std::exp(2.57943987846375*x_71) + 0.167550945057223*std::exp(2.59703993797302*x_71) - 0.00118236595834706*std::exp(2.60055994987488*x_71) - 3.23717715550075*std::exp(2.62087988853455*x_71) + 0.00112993937229655*std::exp(2.62655997276306*x_71) + 0.172677818623047*std::exp(2.64127993583679*x_71) - 0.00011337286699234*std::exp(2.66215991973877*x_71) - 0.00313400034299154*std::exp(2.08487987518311*x_89) - 0.0197979656027864*std::sin(0.391359835863113*x_103 - 1.19543993473053) - 8.95016088572687*std::sin(0.400079846382141*x_103 - 4.20904016494751) + 0.0180240263953095*std::sin(0.538159847259521*x_106 - 1.01255977153778) - 9.82983631430103*std::sin(0.284559935331345*x_112 - 7.52672004699707) - 4.56202414850208*std::sin(0.471759855747223*x_114 + 8.24191951751709) + 6.51930755156966*std::sin(0.317359834909439*x_16 - 4.27519989013672) + 5.31611403674843*std::sin(0.344799846410751*x_18 + 1.95295989513397) - 3.37336994080085*std::sin(0.531999886035919*x_22 + 8.51503944396973) + 0.0838807901032462*std::sin(0.334559857845306*x_26 + 5.13928031921387) - 4.95966582605307*std::sin(0.296879917383194*x_28 + 5.12831974029541) + 0.0247578870612533*std::sin(0.303199917078018*x_28 + 5.13359975814819) + 371.046835060839*std::sin(0.326479852199554*x_28 - 4.28679990768433) - 13.2953459477088*std::sin(0.330159842967987*x_28 - 4.26823997497559) - 0.0568445810100856*std::sin(0.336159855127335*x_28 + 5.13064002990723) + 17.9134133527518*std::sin(0.3781598508358*x_34 + 1.97439980506897) + 14.1631748962197*std::sin(0.33943983912468*x_36 + 5.15008020401001) + 0.0187699007904574*std::sin(0.343679845333099*x_36 + 5.15984010696411) + 0.430887586748026*std::sin(0.392479836940765*x_36 - 7.40767955780029) + 0.0443932903742314*std::sin(0.438079863786697*x_36 + 8.22991943359375) - 188.514762241314*std::sin(0.521199882030487*x_38 + 5.15520000457764) + 4.87633762837703*std::sin(0.35471984744072*x_40 + 5.15056037902832) - 0.202203412530577*std::sin(0.622799813747406*x_52 + 5.21663999557495) - 0.0622866583813603*std::sin(0.145520031452179*x_53 + 4.93263959884644) + 8.11598363062936*std::sin(0.209680005908012*x_53 - 4.39447975158691) + 270.112109499503*std::sin(0.416639864444733*x_53 + 5.20344018936157) - 5.52213484517301*std::sin(0.5204798579216*x_53 - 1.03647983074188) + 461.775791706348*std::sin(0.310239911079407*x_60 - 7.48520040512085) + 0.362091166418154*std::sin(0.312479853630066*x_66 - 1.27471995353699) + 12.6601230951755*std::sin(0.287519931793213*x_80 + 1.90727996826172) + 2.0829576157233*std::sin(0.423599869012833*x_80 - 7.37215995788574) + 155.02182460248*std::sin(0.549839854240417*x_80 + 2.13167977333069) - 0.0411232149715311*std::sin(0.61959981918335*x_80 + 2.20671987533569) - 7.24493535282117*std::sin(0.339919835329056*x_83 + 5.14775991439819) - 1487.75732259699*std::sin(0.145120039582253*x_87 - 7.65576028823853) + 0.00493867947801514*std::sin(0.663759827613831*x_87 + 5.43271970748901) + 4.89511072914236*std::sin(0.686799824237823*x_88 + 8.46360015869141) - 4.47831687828816*std::sin(0.348319828510284*x_92 + 1.99511981010437) - 0.0973597022338834*std::sin(0.432319849729538*x_94 - 1.16055989265442) + 0.0617235698170837*std::sin(0.359359860420227*x_95 + 5.1800799369812) - 0.022037003370283*std::sin(0.378639847040176*x_95 - 7.41328001022339) - 0.022282001961942*std::sin(0.396399825811386*x_96 + 5.18255996704102) + 7.34569803380069*std::sin(0.444879859685898*x_96 - 7.36631965637207) + 2.68791251734452*std::sin(0.496719866991043*x_98 - 1.12415993213654) + 7.76225069304725*std::sin(0.414719849824905*x_99 + 5.21799993515015) + 770.341962958745 - 2.10960155828107e-6*std::exp(-4.15696001052856*x_74) + 0.01801246326632*std::exp(-2.77735996246338*x_74) - 0.000115851291600649*std::exp(-2.6898398399353*x_74) + 0.0450210790502148*std::exp(-2.56887984275818*x_74) - 7.68271328219626e-6*std::exp(-4.01143980026245*x_45) + 5.92315180512071e-6*std::exp(-3.89863991737366*x_45) + 0.00126341894540441*std::exp(-3.8931999206543*x_45) - 0.000204474849028339*std::exp(-4.58256006240845*x_111) - 1.26884782257691e-5*std::exp(-4.382399559021*x_111));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (390.917168194218*x_1 + 20.8050951362448*x_10 + 16.1067832921577*x_100 - 10.4935901665035*x_101 + 46.9440156161002*x_102 + 15.4961071710494*x_103 - 18.9818780681892*x_104 - 8.0403256220464*x_105 + 4.06701679489214*x_106 - 4.59873411305189*x_107 - 29.4255748932536*x_108 + 20.1712192461352*x_109 - 29.0329351953039*x_11 + 20.7547769686846*x_110 - 9.80393273383254*x_111 - 11.5180850247851*x_112 + 31.0690194498946*x_113 - 13.972688411363*x_114 + 41.1644557700296*x_115 - 185.484853163877*x_116 + 5.2203040369943*x_117 + 26.3234184597321*x_118 + 10.9053416964849*x_119 + 15.5378294499124*x_12 - 119.408003077981*x_120 - 51.6814127308363*x_13 - 13.7098240776731*x_14 - 23.384980588246*x_15 - 6.36081088576621*x_16 + 23.7698236424126*x_17 - 0.815006295932945*x_18 - 11.1974152823834*x_19 + 52.8216495756625*x_2 - 93.2083760002758*x_20 - 61.6906271310894*x_21 - 88.9132476953637*x_22 + 35.813930352485*x_23 + 10.2164609037797*x_24 - 61.5629815901424*x_25 + 16.9523998022407*x_26 - 9.02020950895574*x_27 - 2.35866859178347*x_28 - 59.4450099904515*x_29 + 115.824536737896*x_3 + 220.006792141178*x_30 + 1151.50586829561*x_31 - 4.11847083138974*x_32 - 4.98761025357794*x_33 + 50.6858508786672*x_34 + 93.1349648677025*x_35 + 35.0114334488114*x_36 + 199.129396009807*x_37 + 1.92580123102802*x_38 + 13.1983022100998*x_39 + 0.287976702740302*x_4 - 32.0392811373825*x_40 + 50.383724901527*x_41 + 7223.55459718952*x_42 - 29.9578490275388*x_43 - 41.4065990723699*x_44 + 30.1390588188519*x_45 - 13.017737754346*x_46 - 85.5824441156107*x_47 - 41.0729389725905*x_48 - 129.592579589807*x_49 - 13.3560872865955*x_5 - 115.498604196604*x_50 + 46.575653249037*x_51 - 104.169649909248*x_52 + 1.01328171634181*x_53 - 50.3102531242818*x_54 - 32.5036361694419*x_55 + 1.74093395551869*x_56 - 169.008323867425*x_57 - 17.2137801835255*x_58 + 16.8906425932015*x_59 + 5.98636862013645*x_6 + 9.11935650125043*x_60 + 23.0283965197271*x_61 + 47.9015465876454*x_62 - 21.5386405112566*x_63 - 37.3921187095332*x_64 + 28.299998494854*x_65 - 38.7262793078829*x_66 + 33.0474420718822*x_67 - 2.52602938943281*x_68 + 42.9723294343749*x_69 - 26.6639667261366*x_7 + 22.5960830792349*x_70 + 11.448438692607*x_72 - 72.3700564502359*x_73 - 36.5170261572159*x_74 - 4.74524365404862*x_75 - 78.2951966136031*x_76 + 16.5026998062061*x_77 + 21.394321043331*x_78 - 29.6340779290844*x_79 + 145.886912586983*x_8 + 0.988174010783414*x_80 + 45.9820752008911*x_81 - 11.4995649084273*x_82 + 7.20363680381793*x_83 - 141.993738066868*x_84 - 42.7982837672843*x_85 - 36.6128818689321*x_86 - 3.14182874207433*x_87 - 91.0668001987287*x_88 + 4.40909674182867*x_89 + 109.345364413531*x_9 - 221.206493491962*x_90 - 10.8478659559018*x_91 - 16.5297261888744*x_92 - 10.5459905186401*x_93 - 5.01595248687316*x_94 - 9.44135388344319*x_95 + 4.18424066436522*x_96 - 89.2040294411357*x_97 - 30.982358954007*x_98 - 5.56781759839298*x_99 + 0.00730061077585096*std::pow(-6.07103967666626*x_108 - 7.07919979095459, 2) + 0.0878531462291967*std::pow(-4.9137601852417*x_15 - 7.16799974441528, 2) - 0.00326159999094966*std::pow(-3.83136010169983*x_5 - 5.6496000289917, 2) - 0.00497087835939913*std::pow(-6.97944021224976*x_66 - 9.56559944152832, 2) + 0.00290345173960864*std::pow(-6.47760009765625*x_66 - 9.91936016082764, 2) + 0.218841984186455*std::pow(-2.56959986686707*x_78 - 3.36103987693787, 2) + 2.47629532726121e-5*std::pow(-5.75359964370728*x_80 - 9.53351974487305, 2) + 0.00111450989988007*std::pow(-4.86624002456665*x_80 - 8.31335926055908, 2) - 0.587855741774699*std::exp(1.07743978500366*x_38) + 0.00182453432631618*std::exp(1.24855983257294*x_38) - 0.487348887850349*std::exp(2.51327991485596*x_71) - 0.0606443181415011*std::exp(2.54871988296509*x_71) + 0.00912327338986353*std::exp(2.56639981269836*x_71) - 0.0424988240598649*std::exp(2.57943987846375*x_71) + 0.0186345791380462*std::exp(2.59703993797302*x_71) - 0.000255724915099648*std::exp(2.60055994987488*x_71) + 2.70238278322878*std::exp(2.62087988853455*x_71) - 0.000249359347390264*std::exp(2.62655997276306*x_71) + 0.0370348483467856*std::exp(2.64127993583679*x_71) - 0.000299570647068524*std::exp(2.66215991973877*x_71) + 0.0524398987351015*std::exp(2.08487987518311*x_89) - 0.0523131285607146*std::sin(0.391359835863113*x_103 - 1.19543993473053) - 1.91957400044423*std::sin(0.400079846382141*x_103 - 4.20904016494751) + 0.0038982791978703*std::sin(0.538159847259521*x_106 - 1.01255977153778) - 1.09324875876005*std::sin(0.284559935331345*x_112 - 7.52672004699707) + 4.69796317850682*std::sin(0.471759855747223*x_114 + 8.24191951751709) + 0.725060383595548*std::sin(0.317359834909439*x_16 - 4.27519989013672) - 5.4745234098745*std::sin(0.344799846410751*x_18 + 1.95295989513397) - 0.375177407100215*std::sin(0.531999886035919*x_22 + 8.51503944396973) + 0.0181419363237009*std::sin(0.334559857845306*x_26 + 5.13928031921387) - 0.551601098413886*std::sin(0.296879917383194*x_28 + 5.12831974029541) + 0.0654189705504244*std::sin(0.303199917078018*x_28 + 5.13359975814819) - 309.748441519825*std::sin(0.326479852199554*x_28 - 4.28679990768433) - 2.8515018594619*std::sin(0.330159842967987*x_28 - 4.26823997497559) - 0.0122944808669908*std::sin(0.336159855127335*x_28 + 5.13064002990723) - 29.2875082446037*std::sin(0.3781598508358*x_34 + 1.97439980506897) - 23.1560615151593*std::sin(0.33943983912468*x_36 + 5.15008020401001) - 0.290840317391012*std::sin(0.343679845333099*x_36 + 5.15984010696411) - 7.20985926686598*std::sin(0.392479836940765*x_36 - 7.40767955780029) - 0.00979688130853057*std::sin(0.438079863786697*x_36 + 8.22991943359375) + 157.371383583296*std::sin(0.521199882030487*x_38 + 5.15520000457764) - 5.02164256004752*std::sin(0.35471984744072*x_40 + 5.15056037902832) + 3.38338395549564*std::sin(0.622799813747406*x_52 + 5.21663999557495) - 0.164583070447542*std::sin(0.145520031452179*x_53 + 4.93263959884644) + 0.902638532993045*std::sin(0.209680005908012*x_53 - 4.39447975158691) - 225.488528798217*std::sin(0.416639864444733*x_53 + 5.20344018936157) - 1.18435261791167*std::sin(0.5204798579216*x_53 - 1.03647983074188) - 385.488618408973*std::sin(0.310239911079407*x_60 - 7.48520040512085) - 6.05871793929603*std::sin(0.312479853630066*x_66 - 1.27471995353699) + 2.71526327249353*std::sin(0.287519931793213*x_80 + 1.90727996826172) + 0.231661113687753*std::sin(0.423599869012833*x_80 - 7.37215995788574) - 129.411610704898*std::sin(0.549839854240417*x_80 + 2.13167977333069) + 0.00907522854704038*std::sin(0.61959981918335*x_80 + 2.20671987533569) - 1.55384799399003*std::sin(0.339919835329056*x_83 + 5.14775991439819) + 1241.97397333565*std::sin(0.145120039582253*x_87 - 7.65576028823853) + 0.0130497132703982*std::sin(0.663759827613831*x_87 + 5.43271970748901) + 1.04987244418614*std::sin(0.686799824237823*x_88 + 8.46360015869141) - 0.498066723796799*std::sin(0.348319828510284*x_92 + 1.99511981010437) + 0.0214857118942662*std::sin(0.432319849729538*x_94 - 1.16055989265442) + 0.0133497201434885*std::sin(0.359359860420227*x_95 + 5.1800799369812) + 0.341464194516061*std::sin(0.378639847040176*x_95 - 7.41328001022339) + 0.345260456891336*std::sin(0.396399825811386*x_96 + 5.18255996704102) + 1.57545893764713*std::sin(0.444879859685898*x_96 - 7.36631965637207) - 2.7680068369823*std::sin(0.496719866991043*x_98 - 1.12415993213654) + 1.66479852212105*std::sin(0.414719849824905*x_99 + 5.21799993515015) - 3447.58875435541 - 4.56269630884583e-7*std::exp(-4.15696001052856*x_74) - 0.0185491979929925*std::exp(-2.77735996246338*x_74) - 0.000306119509096258*std::exp(-2.6898398399353*x_74) + 0.00965583679669444*std::exp(-2.56887984275818*x_74) - 1.66163545893283e-6*std::exp(-4.01143980026245*x_45) - 9.17794595820279e-5*std::exp(-3.89863991737366*x_45) - 0.00206562490639093*std::exp(-3.8931999206543*x_45) + 0.000210567783158555*std::exp(-4.58256006240845*x_111) + 2.80014196099981e-6*std::exp(-4.382399559021*x_111));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1614.32164161433*x_1 - 76.0878793932236*x_10 - 16.3562501993143*x_100 + 1.1356375854356*x_101 - 160.469056685683*x_102 - 42.7383570315902*x_103 + 79.4522613344409*x_104 + 17.2566992848545*x_105 - 13.0416975616372*x_106 + 21.373138704572*x_107 + 118.124401471618*x_108 - 30.2608050090828*x_109 + 111.546007799974*x_11 - 58.3046452404856*x_110 + 20.4505433303463*x_111 + 45.0218300755078*x_112 - 187.528622986167*x_113 + 73.1742708204913*x_114 - 147.775357404543*x_115 + 575.202862524989*x_116 + 0.355688524290983*x_117 - 90.2055227912016*x_118 - 33.074731526365*x_119 - 270.005547116092*x_12 + 456.972492093828*x_120 + 175.558580602771*x_13 + 54.6007380663142*x_14 + 86.2318818297298*x_15 + 29.4852361427752*x_16 - 83.0967098465921*x_17 + 32.2642935769604*x_18 + 29.3552025367397*x_19 - 178.338753977941*x_2 + 347.786288797614*x_20 + 152.677278124189*x_21 + 334.224667889309*x_22 - 145.823933691117*x_23 - 35.3516595254477*x_24 + 248.571205338962*x_25 - 56.1258444111993*x_26 + 58.1747984457729*x_27 + 1.81529635323952*x_28 + 208.02133426395*x_29 - 476.302785955386*x_3 - 791.825277408443*x_30 - 3943.40331380168*x_31 + 25.9815506502025*x_32 + 1.97125153436775*x_33 - 186.784302043409*x_34 - 326.487053544791*x_35 - 129.201709514209*x_36 - 956.274292425151*x_37 - 1.00733371936262*x_38 - 22.0564935116879*x_39 - 11.4410518366956*x_4 + 121.692724492808*x_40 - 179.340051855687*x_41 - 6240.21740401147*x_42 + 98.5057064641489*x_43 + 132.826744200098*x_44 - 114.740762155019*x_45 + 46.6452478333066*x_46 + 392.628159557129*x_47 + 140.923232252791*x_48 + 573.051791868809*x_49 + 39.4469619444659*x_5 + 621.821262588014*x_50 - 207.783733517483*x_51 + 295.16711084805*x_52 + 0.513371021530491*x_53 + 102.55058192691*x_54 + 142.389946535524*x_55 + 13.2659815806235*x_56 + 1040.20643063596*x_57 + 55.7475711199877*x_58 - 77.1613267850303*x_59 - 14.8466573475259*x_6 - 14.0259362510638*x_60 - 85.8674537557911*x_61 - 166.30231322571*x_62 + 64.8330344253506*x_63 + 139.605880478809*x_64 - 96.0527082013664*x_65 + 154.919591324708*x_66 - 118.932908004562*x_67 + 16.4594935784902*x_68 - 143.673493411011*x_69 + 102.442938248268*x_7 - 90.6155947574402*x_70 - 47.4436718624168*x_72 + 264.26891433124*x_73 + 125.63467080266*x_74 - 0.0463150895162264*x_75 + 278.736054807313*x_76 - 77.7402696181715*x_77 - 82.9275629507191*x_78 + 101.764918680915*x_79 - 490.128045303095*x_8 - 0.825409460546567*x_80 - 127.368268494718*x_81 + 33.0338777480498*x_82 - 15.641995837237*x_83 + 444.750495991574*x_84 + 148.890305244311*x_85 + 116.311035797154*x_86 - 0.50991843393574*x_87 + 322.451483072131*x_88 - 11.3002750543168*x_89 - 420.269665345918*x_9 + 788.593981771217*x_90 + 44.2502697776954*x_91 + 75.6281814884772*x_92 + 48.9979075639916*x_93 + 5.49821345711686*x_94 + 38.8628887370783*x_95 - 5.45201360158636*x_96 + 344.487764233133*x_97 + 112.692192166125*x_98 + 35.7231346742137*x_99 - 0.0260506774054252*std::pow(-6.07103967666626*x_108 - 7.07919979095459, 2) - 0.0360976974688421*std::pow(-4.9137601852417*x_15 - 7.16799974441528, 2) - 0.063244430412138*std::pow(-3.83136010169983*x_5 - 5.6496000289917, 2) + 0.017737522590666*std::pow(-6.97944021224976*x_66 - 9.56559944152832, 2) - 0.00119587889983707*std::pow(-6.47760009765625*x_66 - 9.91936016082764, 2) - 0.0899192809559099*std::pow(-2.56959986686707*x_78 - 3.36103987693787, 2) + 0.000247104359466958*std::pow(-5.75359964370728*x_80 - 9.53351974487305, 2) + 0.00120977658420021*std::pow(-4.86624002456665*x_80 - 8.31335926055908, 2) - 0.254352368294232*std::exp(1.07743978500366*x_38) + 0.00214200198562555*std::exp(1.24855983257294*x_38) + 0.200245221377764*std::exp(2.51327991485596*x_71) - 0.0262394748349527*std::exp(2.54871988296509*x_71) + 0.00990311752233106*std::exp(2.56639981269836*x_71) + 0.151648018184399*std::exp(2.57943987846375*x_71) + 0.361335953772951*std::exp(2.59703993797302*x_71) - 0.00255182573135693*std::exp(2.60055994987488*x_71) - 9.99600080650064*std::exp(2.62087988853455*x_71) - 0.00242143891253855*std::exp(2.62655997276306*x_71) - 0.0152539796313461*std::exp(2.64127993583679*x_71) - 0.000351695723999609*std::exp(2.66215991973877*x_71) + 0.0226896013571554*std::exp(2.08487987518311*x_89) - 0.0614155752704193*std::sin(0.391359835863113*x_103 - 1.19543993473053) + 0.790637575438577*std::sin(0.400079846382141*x_103 - 4.20904016494751) + 0.0389001171874964*std::sin(0.538159847259521*x_106 - 1.01255977153778) - 21.1987660161922*std::sin(0.284559935331345*x_112 - 7.52672004699707) - 16.7636827908528*std::sin(0.471759855747223*x_114 + 8.24191951751709) + 14.0593669064719*std::sin(0.317359834909439*x_16 - 4.27519989013672) + 19.5346728757041*std::sin(0.344799846410751*x_18 + 1.95295989513397) - 7.2749207387161*std::sin(0.531999886035919*x_22 + 8.51503944396973) + 0.181034608651328*std::sin(0.334559857845306*x_26 + 5.13928031921387) - 10.6958846519185*std::sin(0.296879917383194*x_28 + 5.12831974029541) + 0.0768018243315335*std::sin(0.303199917078018*x_28 + 5.13359975814819) + 1145.74652061139*std::sin(0.326479852199554*x_28 - 4.28679990768433) + 1.17448169020929*std::sin(0.330159842967987*x_28 - 4.26823997497559) - 0.122684067048521*std::sin(0.336159855127335*x_28 + 5.13064002990723) + 12.033850324174*std::sin(0.3781598508358*x_34 + 1.97439980506897) + 9.51451984387014*std::sin(0.33943983912468*x_36 + 5.15008020401001) - 0.315700924468114*std::sin(0.343679845333099*x_36 + 5.15984010696411) - 3.11954897992357*std::sin(0.392479836940765*x_36 - 7.40767955780029) - 0.0951339898434616*std::sin(0.438079863786697*x_36 + 8.22991943359375) - 582.110161070241*std::sin(0.521199882030487*x_38 + 5.15520000457764) + 17.9186638479441*std::sin(0.35471984744072*x_40 + 5.15056037902832) + 1.46391650327512*std::sin(0.622799813747406*x_52 + 5.21663999557495) - 0.1932204062232*std::sin(0.145520031452179*x_53 + 4.93263959884644) + 17.5027164721605*std::sin(0.209680005908012*x_53 - 4.39447975158691) + 834.072630166252*std::sin(0.416639864444733*x_53 + 5.20344018936157) + 0.487813276317199*std::sin(0.5204798579216*x_53 - 1.03647983074188) + 1425.90626480716*std::sin(0.310239911079407*x_60 - 7.48520040512085) - 2.62147521436869*std::sin(0.312479853630066*x_66 - 1.27471995353699) - 1.11836749713472*std::sin(0.287519931793213*x_80 + 1.90727996826172) + 4.49205151596705*std::sin(0.423599869012833*x_80 - 7.37215995788574) + 478.688131453802*std::sin(0.549839854240417*x_80 + 2.13167977333069) + 0.0881262794997286*std::sin(0.61959981918335*x_80 + 2.20671987533569) + 0.640001693231971*std::sin(0.339919835329056*x_83 + 5.14775991439819) - 4594.00974434973*std::sin(0.145120039582253*x_87 - 7.65576028823853) + 0.0153203539850492*std::sin(0.663759827613831*x_87 + 5.43271970748901) - 0.432423341636743*std::sin(0.686799824237823*x_88 + 8.46360015869141) - 9.65782019290373*std::sin(0.348319828510284*x_92 + 1.99511981010437) + 0.208640018466779*std::sin(0.432319849729538*x_94 - 1.16055989265442) + 0.133214080275649*std::sin(0.359359860420227*x_95 + 5.1800799369812) + 0.370652056938003*std::sin(0.378639847040176*x_95 - 7.41328001022339) + 0.3747728182965*std::sin(0.396399825811386*x_96 + 5.18255996704102) - 0.648902847390149*std::sin(0.444879859685898*x_96 - 7.36631965637207) + 9.87704390497826*std::sin(0.496719866991043*x_98 - 1.12415993213654) - 0.685700195365692*std::sin(0.414719849824905*x_99 + 5.21799993515015) - 2266.90621952331 - 4.55301973245081e-6*std::exp(-4.15696001052856*x_74) + 0.0661888693810668*std::exp(-2.77735996246338*x_74) - 0.000359384083305689*std::exp(-2.6898398399353*x_74) - 0.00397706334426407*std::exp(-2.56887984275818*x_74) - 1.65811145878672e-5*std::exp(-4.01143980026245*x_45) - 9.96246342224819e-5*std::exp(-3.89863991737366*x_45) + 0.000848737992381938*std::exp(-3.8931999206543*x_45) - 0.000751366366384551*std::exp(-4.58256006240845*x_111) + 2.71911711991499e-5*std::exp(-4.382399559021*x_111));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1565.58768925751*x_1 - 74.0286744734464*x_10 + 5.20497716974293*x_100 - 7.95984508397268*x_101 - 154.852529112633*x_102 - 32.1185248080346*x_103 + 90.9329356805572*x_104 + 14.4798725009333*x_105 - 12.7914334805762*x_106 + 18.0066940380266*x_107 + 122.297801683857*x_108 - 15.4483820715986*x_109 + 113.478444060009*x_11 - 48.6336873482816*x_110 + 13.0262538842725*x_111 + 47.9687980350034*x_112 - 219.083841487791*x_113 + 78.9784718692555*x_114 - 150.063238686798*x_115 + 508.667591563643*x_116 + 2.30583325244636*x_117 - 86.982686415778*x_118 - 31.0123968554649*x_119 - 368.950007353768*x_12 + 461.989778013197*x_120 + 183.828532561294*x_13 + 54.8187202390226*x_14 + 88.1079470126002*x_15 + 32.0358666565777*x_16 - 75.1692879925061*x_17 + 46.575159094396*x_18 + 26.3979715197884*x_19 - 167.769052436555*x_2 + 340.507801643709*x_20 + 123.147992025873*x_21 + 332.592968831754*x_22 - 153.333341392102*x_23 - 32.8382682977112*x_24 + 262.163653838551*x_25 - 49.8360354937612*x_26 + 66.4385076127594*x_27 - 2.63009386944888*x_28 + 205.77867177154*x_29 - 493.223665776873*x_3 - 802.51062294103*x_30 - 3851.40483076568*x_31 + 27.7661657544993*x_32 - 3.41049950805091*x_33 - 187.877581740848*x_34 - 319.974310364886*x_35 - 129.616612465664*x_36 - 1030.76328661407*x_37 + 3.43472983601755*x_38 - 11.44895993386*x_39 - 15.7290406108571*x_4 + 121.716878897599*x_40 - 184.678713895614*x_41 + 2672.41356644074*x_42 + 92.7640570974203*x_43 + 134.034896916131*x_44 - 118.23271882983*x_45 + 49.4125317237601*x_46 + 411.167588218095*x_47 + 109.673146804703*x_48 + 610.810826542803*x_49 + 35.5707591493457*x_5 + 700.975173974552*x_50 - 229.754742359877*x_51 + 257.112058480228*x_52 + 1.35921606958534*x_53 + 60.7484139376337*x_54 + 154.387300641925*x_55 + 24.5384950502583*x_56 + 1169.10560714033*x_57 + 55.5341646293182*x_58 - 78.1979758979269*x_59 - 12.0970478983199*x_6 + 9.17060011740736*x_60 - 85.7775391989229*x_61 - 158.948500238167*x_62 + 60.1411700410081*x_63 + 141.994644122902*x_64 - 92.7428000823809*x_65 + 160.26081848481*x_66 - 119.942455104863*x_67 + 16.8827085786549*x_68 - 134.16426679762*x_69 + 106.72634285638*x_7 - 96.7557054588582*x_70 - 53.3132559162453*x_72 + 258.994760907075*x_73 + 123.9797575208*x_74 - 6.61739306735683*x_75 + 275.143119515442*x_76 - 89.4393790740815*x_77 - 78.4680096445831*x_78 + 95.1087022275411*x_79 - 481.807888523459*x_8 + 0.803139538863304*x_80 - 113.334033777801*x_81 + 25.821057916862*x_82 - 10.1916587284154*x_83 + 402.68511107282*x_84 + 143.922143732579*x_85 + 107.272673630521*x_86 - 3.35758029816682*x_87 + 309.423091500369*x_88 - 4.11902397608413*x_89 - 438.815257119712*x_9 + 780.670445339224*x_90 + 52.6378077168576*x_91 + 77.8980850147836*x_92 + 50.1464668633095*x_93 + 5.89401752752329*x_94 + 43.4707882374714*x_95 - 2.111544961357*x_96 + 357.889942451766*x_97 + 109.266946175749*x_98 + 47.9004467732886*x_99 - 0.00966595051160309*std::pow(-6.07103967666626*x_108 - 7.07919979095459, 2) + 0.0964278137601796*std::pow(-4.9137601852417*x_15 - 7.16799974441528, 2) + 0.00960154797159556*std::pow(-3.83136010169983*x_5 - 5.6496000289917, 2) + 0.00658140335053683*std::pow(-6.97944021224976*x_66 - 9.56559944152832, 2) - 0.00406871581371597*std::pow(-6.47760009765625*x_66 - 9.91936016082764, 2) + 0.240201461185992*std::pow(-2.56959986686707*x_78 - 3.36103987693787, 2) - 0.000102756344634475*std::pow(-5.75359964370728*x_80 - 9.53351974487305, 2) + 9.11201467850329e-5*std::pow(-4.86624002456665*x_80 - 8.31335926055908, 2) - 0.284410213495255*std::exp(1.07743978500366*x_38) - 0.00196209812834929*std::exp(1.24855983257294*x_38) - 0.534915251313406*std::exp(2.51327991485596*x_71) - 0.029340299403776*std::exp(2.54871988296509*x_71) + 0.000745900965557868*std::exp(2.56639981269836*x_71) + 0.0562681045156936*std::exp(2.57943987846375*x_71) - 0.0548567592656723*std::exp(2.59703993797302*x_71) + 0.00106115604299364*std::exp(2.60055994987488*x_71) - 9.98716110963777*std::exp(2.62087988853455*x_71) + 0.000344085416151495*std::exp(2.62655997276306*x_71) - 0.0518983219426442*std::exp(2.64127993583679*x_71) + 0.000322157274567865*std::exp(2.66215991973877*x_71) + 0.0253709230599569*std::exp(2.08487987518311*x_89) + 0.0562573639512258*std::sin(0.391359835863113*x_103 - 1.19543993473053) + 2.68997103849167*std::sin(0.400079846382141*x_103 - 4.20904016494751) - 0.0161762983731348*std::sin(0.538159847259521*x_106 - 1.01255977153778) + 3.21832242802577*std::sin(0.284559935331345*x_112 - 7.52672004699707) - 6.22006582503879*std::sin(0.471759855747223*x_114 + 8.24191951751709) - 2.1344438541555*std::sin(0.317359834909439*x_16 - 4.27519989013672) + 7.24822538540162*std::sin(0.344799846410751*x_18 + 1.95295989513397) + 1.10445299304857*std::sin(0.531999886035919*x_22 + 8.51503944396973) - 0.0752817743785322*std::sin(0.334559857845306*x_26 + 5.13928031921387) + 1.62381175567261*std::sin(0.296879917383194*x_28 + 5.12831974029541) - 0.0703513427092856*std::sin(0.303199917078018*x_28 + 5.13359975814819) + 1144.73331021656*std::sin(0.326479852199554*x_28 - 4.28679990768433) + 3.99591649833897*std::sin(0.330159842967987*x_28 - 4.26823997497559) + 0.051017174694899*std::sin(0.336159855127335*x_28 + 5.13064002990723) - 32.1460358760813*std::sin(0.3781598508358*x_34 + 1.97439980506897) - 25.4161459554077*std::sin(0.33943983912468*x_36 + 5.15008020401001) - 0.0237785347752643*std::sin(0.343679845333099*x_36 + 5.15984010696411) - 3.48819866447097*std::sin(0.392479836940765*x_36 - 7.40767955780029) + 0.013518498573694*std::sin(0.438079863786697*x_36 + 8.22991943359375) - 581.59538746585*std::sin(0.521199882030487*x_38 + 5.15520000457764) + 6.64861474781492*std::sin(0.35471984744072*x_40 + 5.15056037902832) + 1.63691342065301*std::sin(0.622799813747406*x_52 + 5.21663999557495) + 0.176992084953047*std::sin(0.145520031452179*x_53 + 4.93263959884644) - 2.65720112815549*std::sin(0.209680005908012*x_53 - 4.39447975158691) + 833.335040268551*std::sin(0.416639864444733*x_53 + 5.20344018936157) + 1.65967774141914*std::sin(0.5204798579216*x_53 - 1.03647983074188) + 1424.6453026104*std::sin(0.310239911079407*x_60 - 7.48520040512085) - 2.93126551323732*std::sin(0.312479853630066*x_66 - 1.27471995353699) - 3.80500025693066*std::sin(0.287519931793213*x_80 + 1.90727996826172) - 0.681967532008296*std::sin(0.423599869012833*x_80 - 7.37215995788574) + 478.264816364516*std::sin(0.549839854240417*x_80 + 2.13167977333069) - 0.0125227059821871*std::sin(0.61959981918335*x_80 + 2.20671987533569) + 2.17746546946576*std::sin(0.339919835329056*x_83 + 5.14775991439819) - 4589.94715428884*std::sin(0.145120039582253*x_87 - 7.65576028823853) - 0.0140336181205429*std::sin(0.663759827613831*x_87 + 5.43271970748901) - 1.47122563043551*std::sin(0.686799824237823*x_88 + 8.46360015869141) + 1.46621644434025*std::sin(0.348319828510284*x_92 + 1.99511981010437) - 0.0296476558662118*std::sin(0.432319849729538*x_94 - 1.16055989265442) - 0.0553959953296559*std::sin(0.359359860420227*x_95 + 5.1800799369812) + 0.0279174438284349*std::sin(0.378639847040176*x_95 - 7.41328001022339) + 0.0282278188057292*std::sin(0.396399825811386*x_96 + 5.18255996704102) - 2.20774969530889*std::sin(0.444879859685898*x_96 - 7.36631965637207) + 3.66481900261712*std::sin(0.496719866991043*x_98 - 1.12415993213654) - 2.33294460562238*std::sin(0.414719849824905*x_99 + 5.21799993515015) - 7162.42051093401 + 1.89333634487271e-6*std::exp(-4.15696001052856*x_74) + 0.024558990382458*std::exp(-2.77735996246338*x_74) + 0.000329199898947194*std::exp(-2.6898398399353*x_74) - 0.0135310862355394*std::exp(-2.56887984275818*x_74) + 6.89512207995843e-6*std::exp(-4.01143980026245*x_45) - 7.50370887675854e-6*std::exp(-3.89863991737366*x_45) - 0.0022672346104966*std::exp(-3.8931999206543*x_45) - 0.000278790067549016*std::exp(-4.58256006240845*x_111) - 3.86385359930367e-6*std::exp(-4.382399559021*x_111));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1823.22144076647*x_1 - 85.2509876518172*x_10 + 9.14544006867584*x_100 - 14.3392529425349*x_101 - 175.181006955294*x_102 - 35.7587632839085*x_103 + 103.621952480068*x_104 + 14.4598117865214*x_105 - 14.4954227720594*x_106 + 23.0258542340732*x_107 + 138.536031767195*x_108 - 12.6873482314807*x_109 + 128.941962831042*x_11 - 53.9968885441627*x_110 + 13.8244456140941*x_111 + 54.7891525744656*x_112 - 255.874729034994*x_113 + 93.1642175141039*x_114 - 169.765632982762*x_115 + 565.666811562963*x_116 + 5.54174979492356*x_117 - 97.1806168739016*x_118 - 34.5067243076541*x_119 - 451.199345547424*x_12 + 527.008763083626*x_120 + 207.246954547871*x_13 + 63.8389031765201*x_14 + 99.2536776091642*x_15 + 36.8804286205298*x_16 - 84.8284025628014*x_17 + 54.9216004525524*x_18 + 29.5039387203096*x_19 - 188.431622738577*x_2 + 387.824430147533*x_20 + 126.377785126091*x_21 + 377.882427329552*x_22 - 175.396513581413*x_23 - 37.8872177536922*x_24 + 300.492084281497*x_25 - 56.1833019200534*x_26 + 80.1703044140717*x_27 - 3.8645878494833*x_28 + 232.400372491176*x_29 - 565.801792041212*x_3 - 905.168236299266*x_30 - 4278.6676816742*x_31 + 31.7506011457126*x_32 - 6.80630620311332*x_33 - 212.149847802563*x_34 - 361.297038967766*x_35 - 147.415206712563*x_36 - 1187.62904894663*x_37 + 4.2596996705519*x_38 - 9.63896298616014*x_39 - 18.4656857189017*x_4 + 137.844009349563*x_40 - 206.848212989321*x_41 + 2996.95211667831*x_42 + 104.421278591635*x_43 + 148.292631449044*x_44 - 133.484679283816*x_45 + 56.2209038051582*x_46 + 474.632132976923*x_47 + 126.571871467862*x_48 + 704.990753016006*x_49 + 39.2739163292653*x_5 + 811.598285750113*x_50 - 263.032640894504*x_51 + 278.827665420239*x_52 + 1.87447140629343*x_53 + 64.7249366961762*x_54 + 177.371736733877*x_55 + 29.023145099403*x_56 + 1373.67270057862*x_57 + 60.9057522117492*x_58 - 92.4394013820241*x_59 - 13.3382786397225*x_6 + 9.77530426588776*x_60 - 97.7868151781006*x_61 - 178.840534114486*x_62 + 64.9838154375356*x_63 + 162.237263284852*x_64 - 104.666313893865*x_65 + 183.389324511258*x_66 - 135.695495014719*x_67 + 19.3599225018593*x_68 - 150.840998891714*x_69 + 121.884875115516*x_7 - 108.392239124639*x_70 - 60.9577451308441*x_72 + 294.262049192166*x_73 + 137.991571526337*x_74 - 9.94430590269906*x_75 + 312.67076328353*x_76 - 101.614298788904*x_77 - 90.8386748852939*x_78 + 107.778702523945*x_79 - 537.139519758297*x_8 + 1.23276628860176*x_80 - 121.041328178496*x_81 + 30.4931741991082*x_82 - 11.3003556691907*x_83 + 459.157796410889*x_84 + 163.900628152971*x_85 + 120.894853362494*x_86 - 5.01650253942532*x_87 + 351.8353344823*x_88 - 5.93924525215439*x_89 - 498.782641873144*x_9 + 884.877273686484*x_90 + 55.619156866532*x_91 + 89.9331694660262*x_92 + 58.1445141455549*x_93 + 5.19912854375551*x_94 + 48.6206629103237*x_95 - 1.13299127006766*x_96 + 408.234188897275*x_97 + 125.444369653597*x_98 + 55.2433120544514*x_99 - 0.0096521050539484*std::pow(-6.07103967666626*x_108 - 7.07919979095459, 2) + 0.138933131742874*std::pow(-4.9137601852417*x_15 - 7.16799974441528, 2) - 0.0321422973525373*std::pow(-3.83136010169983*x_5 - 5.6496000289917, 2) + 0.00657197618232519*std::pow(-6.97944021224976*x_66 - 9.56559944152832, 2) - 0.00162282107292945*std::pow(-6.47760009765625*x_66 - 9.91936016082764, 2) + 0.346082110030845*std::pow(-2.56959986686707*x_78 - 3.36103987693787, 2) + 0.000409875470168334*std::pow(-5.75359964370728*x_80 - 9.53351974487305, 2) + 0.000347128185898479*std::pow(-4.86624002456665*x_80 - 8.31335926055908, 2) - 0.390955497260139*std::exp(1.07743978500366*x_38) - 0.00203566467101976*std::exp(1.24855983257294*x_38) - 0.770705548368328*std::exp(2.51327991485596*x_71) - 0.0403317138375412*std::exp(2.54871988296509*x_71) + 0.00284155873502781*std::exp(2.56639981269836*x_71) + 0.0561875063730229*std::exp(2.57943987846375*x_71) + 0.183639374955994*std::exp(2.59703993797302*x_71) - 0.00423274916591438*std::exp(2.60055994987488*x_71) - 11.3606374365678*std::exp(2.62087988853455*x_71) - 0.000193125491569079*std::exp(2.62655997276306*x_71) - 0.0206998213574617*std::exp(2.64127993583679*x_71) + 0.000334236179564343*std::exp(2.66215991973877*x_71) + 0.034875336293152*std::exp(2.08487987518311*x_89) + 0.0583666671027088*std::sin(0.391359835863113*x_103 - 1.19543993473053) + 1.07290405294916*std::sin(0.400079846382141*x_103 - 4.20904016494751) + 0.0645241705011699*std::sin(0.538159847259521*x_106 - 1.01255977153778) - 10.7737082357934*std::sin(0.284559935331345*x_112 - 7.52672004699707) - 6.21115623483485*std::sin(0.471759855747223*x_114 + 8.24191951751709) + 7.14529878364616*std::sin(0.317359834909439*x_16 - 4.27519989013672) + 7.23784306474679*std::sin(0.344799846410751*x_18 + 1.95295989513397) - 3.69728471070357*std::sin(0.531999886035919*x_22 + 8.51503944396973) + 0.300284646931231*std::sin(0.334559857845306*x_26 + 5.13928031921387) - 5.43589850821747*std::sin(0.296879917383194*x_28 + 5.12831974029541) - 0.0729890828816905*std::sin(0.303199917078018*x_28 + 5.13359975814819) + 1302.16184120455*std::sin(0.326479852199554*x_28 - 4.28679990768433) + 1.59378481960097*std::sin(0.330159842967987*x_28 - 4.26823997497559) - 0.203497784386114*std::sin(0.336159855127335*x_28 + 5.13064002990723) - 46.315987713776*std::sin(0.3781598508358*x_34 + 1.97439980506897) - 36.6195666657019*std::sin(0.33943983912468*x_36 + 5.15008020401001) - 0.0905858905093115*std::sin(0.343679845333099*x_36 + 5.15984010696411) - 4.79494187867186*std::sin(0.392479836940765*x_36 - 7.40767955780029) - 0.0075875540193516*std::sin(0.438079863786697*x_36 + 8.22991943359375) - 661.578826980527*std::sin(0.521199882030487*x_38 + 5.15520000457764) + 6.6390913063445*std::sin(0.35471984744072*x_40 + 5.15056037902832) + 2.250131218842*std::sin(0.622799813747406*x_52 + 5.21663999557495) + 0.183628193301505*std::sin(0.145520031452179*x_53 + 4.93263959884644) + 8.89528949283357*std::sin(0.209680005908012*x_53 - 4.39447975158691) + 947.938773766513*std::sin(0.416639864444733*x_53 + 5.20344018936157) + 0.66196808436888*std::sin(0.5204798579216*x_53 - 1.03647983074188) + 1620.56850600392*std::sin(0.310239911079407*x_60 - 7.48520040512085) - 4.0293713514909*std::sin(0.312479853630066*x_66 - 1.27471995353699) - 1.51763723055643*std::sin(0.287519931793213*x_80 + 1.90727996826172) + 2.28296554508013*std::sin(0.423599869012833*x_80 - 7.37215995788574) + 544.037801907554*std::sin(0.549839854240417*x_80 + 2.13167977333069) + 0.00702864357238586*std::sin(0.61959981918335*x_80 + 2.20671987533569) + 0.868489472160499*std::sin(0.339919835329056*x_83 + 5.14775991439819) - 5221.17595785665*std::sin(0.145120039582253*x_87 - 7.65576028823853) - 0.0145597919909367*std::sin(0.663759827613831*x_87 + 5.43271970748901) - 0.586803322084106*std::sin(0.686799824237823*x_88 + 8.46360015869141) - 4.90832989394864*std::sin(0.348319828510284*x_92 + 1.99511981010437) + 0.0166403975416154*std::sin(0.432319849729538*x_94 - 1.16055989265442) + 0.220964065157761*std::sin(0.359359860420227*x_95 + 5.1800799369812) + 0.10635333647947*std::sin(0.378639847040176*x_95 - 7.41328001022339) + 0.107535730347542*std::sin(0.396399825811386*x_96 + 5.18255996704102) - 0.880568438135441*std::sin(0.444879859685898*x_96 - 7.36631965637207) + 3.65956953478135*std::sin(0.496719866991043*x_98 - 1.12415993213654) - 0.930502851838004*std::sin(0.414719849824905*x_99 + 5.21799993515015) - 7613.96592459927 - 7.5521577504727e-6*std::exp(-4.15696001052856*x_74) + 0.0245238122113124*std::exp(-2.77735996246338*x_74) + 0.000341542858793645*std::exp(-2.6898398399353*x_74) - 0.00539691954120633*std::exp(-2.56887984275818*x_74) - 2.75033275506653e-5*std::exp(-4.01143980026245*x_45) - 2.85858719701641e-5*std::exp(-3.89863991737366*x_45) - 0.00326663016145459*std::exp(-3.8931999206543*x_45) - 0.000278390730094291*std::exp(-4.58256006240845*x_111) + 2.16867263385535e-6*std::exp(-4.382399559021*x_111));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1471.68177989237*x_1 - 68.2013347669025*x_10 - 6.33290090143154*x_100 - 3.18092691447636*x_101 - 140.837545635086*x_102 - 34.9443265675441*x_103 + 76.2534071165225*x_104 + 12.5009174263986*x_105 - 11.6168090397162*x_106 + 21.360955529346*x_107 + 105.547011043212*x_108 - 19.2101253304314*x_109 + 99.2079254895615*x_11 - 49.8443947712164*x_110 + 15.7599312825854*x_111 + 42.0079032968369*x_112 - 178.41833287347*x_113 + 69.9920878209049*x_114 - 131.669104283125*x_115 + 479.005030124363*x_116 + 2.58731339771503*x_117 - 77.6593989351281*x_118 - 28.2424653414561*x_119 - 312.591826583122*x_12 + 410.435815823769*x_120 + 158.515611010183*x_13 + 51.5467503179917*x_14 + 76.2260973395159*x_15 + 27.9258436576344*x_16 - 69.7796677307253*x_17 + 33.0835823841044*x_18 + 25.8037447750309*x_19 - 153.699867835619*x_2 + 308.962380452511*x_20 + 111.53616711465*x_21 + 296.038866285363*x_22 - 132.461538955087*x_23 - 31.9612732486292*x_24 + 226.796614737237*x_25 - 47.2686340866128*x_26 + 59.1830351855894*x_27 - 0.543479951336395*x_28 + 183.637727713998*x_29 - 428.403539536336*x_3 - 696.588606226391*x_30 - 3381.9600849697*x_31 + 22.7601633208803*x_32 - 3.37457852095522*x_33 - 163.420489711217*x_34 - 286.382816545085*x_35 - 115.694126157419*x_36 - 875.15749612038*x_37 + 1.21670468234707*x_38 - 14.0464764933913*x_39 - 10.6458072128209*x_4 + 107.318592936103*x_40 - 159.217146842274*x_41 - 5693.13341965053*x_42 + 85.6178329110649*x_43 + 114.737595808522*x_44 - 102.001885862044*x_45 + 42.3278428053383*x_46 + 355.246418013566*x_47 + 116.565160707947*x_48 + 530.851068552983*x_49 + 33.4614145767494*x_5 + 576.208198185147*x_50 - 190.916880937248*x_51 + 235.217724680764*x_52 + 0.481904268797506*x_53 + 82.9047208888486*x_54 + 132.2257717528*x_55 + 15.4914190163658*x_56 + 991.900509046026*x_57 + 46.7762067335257*x_58 - 72.5817603144367*x_59 - 12.61081135961*x_6 - 7.90416407416827*x_60 - 75.8153138666744*x_61 - 142.96378445568*x_62 + 50.7669907075074*x_63 + 126.246058815383*x_64 - 83.7534044033094*x_65 + 140.320277471335*x_66 - 105.684794857241*x_67 + 14.2373919417142*x_68 - 124.33755271785*x_69 + 93.3292585946166*x_7 - 81.3486359750591*x_70 - 45.7124703071968*x_72 + 233.99452079454*x_73 + 107.84597687463*x_74 - 4.08068832850456*x_75 + 246.467764850416*x_76 - 71.0469400195194*x_77 - 73.9757681418112*x_78 + 87.9921553824403*x_79 - 421.564995651213*x_8 + 0.116666696145819*x_80 - 102.748281346405*x_81 + 30.8358258856707*x_82 - 12.9232397419863*x_83 + 398.389630449149*x_84 + 133.224019934258*x_85 + 100.838436239936*x_86 - 1.69884599507665*x_87 + 283.98904386952*x_88 - 9.89511933457017*x_89 - 384.307508859353*x_9 + 702.523281420844*x_90 + 36.2408148555587*x_91 + 67.5182927921842*x_92 + 44.0411887128179*x_93 + 4.7606215808365*x_94 + 34.8338621308924*x_95 - 2.16377841152847*x_96 + 315.576849560012*x_97 + 101.664491304321*x_98 + 36.3173892394518*x_99 - 0.00683630542442458*std::pow(-6.07103967666626*x_108 - 7.07919979095459, 2) + 0.0240386694273504*std::pow(-4.9137601852417*x_15 - 7.16799974441528, 2) - 0.0922127576058842*std::pow(-3.83136010169983*x_5 - 5.6496000289917, 2) + 0.00465473968355121*std::pow(-6.97944021224976*x_66 - 9.56559944152832, 2) - 0.00118363012096165*std::pow(-6.47760009765625*x_66 - 9.91936016082764, 2) + 0.0598802699787127*std::pow(-2.56959986686707*x_78 - 3.36103987693787, 2) + 8.43337529324298e-6*std::pow(-5.75359964370728*x_80 - 9.53351974487305, 2) + 0.00022473875178914*std::pow(-4.86624002456665*x_80 - 8.31335926055908, 2) - 0.110732348658655*std::exp(1.07743978500366*x_38) - 0.00279815587726699*std::exp(1.24855983257294*x_38) - 0.133350020046613*std::exp(2.51327991485596*x_71) - 0.0114233600242435*std::exp(2.54871988296509*x_71) + 0.00183969031956525*std::exp(2.56639981269836*x_71) + 0.0397959774013915*std::exp(2.57943987846375*x_71) + 0.526841407257915*std::exp(2.59703993797302*x_71) - 8.7090750328769e-5*std::exp(2.60055994987488*x_71) - 8.90748267110685*std::exp(2.62087988853455*x_71) - 7.84669819834356e-5*std::exp(2.62655997276306*x_71) - 0.0150977408821719*std::exp(2.64127993583679*x_71) + 0.000459429759506866*std::exp(2.66215991973877*x_71) + 0.00987792197594172*std::exp(2.08487987518311*x_89) + 0.0802288485500494*std::sin(0.391359835863113*x_103 - 1.19543993473053) + 0.782539477183427*std::sin(0.400079846382141*x_103 - 4.20904016494751) + 0.00132761432417042*std::sin(0.538159847259521*x_106 - 1.01255977153778) - 30.9085979501495*std::sin(0.284559935331345*x_112 - 7.52672004699707) - 4.39918140372709*std::sin(0.471759855747223*x_114 + 8.24191951751709) + 20.4990855983718*std::sin(0.317359834909439*x_16 - 4.27519989013672) + 5.12635383971721*std::sin(0.344799846410751*x_18 + 1.95295989513397) - 10.6071079826264*std::sin(0.531999886035919*x_22 + 8.51503944396973) + 0.00617849397362078*std::sin(0.334559857845306*x_26 + 5.13928031921387) - 15.5950020003432*std::sin(0.296879917383194*x_28 + 5.12831974029541) - 0.10032832722858*std::sin(0.303199917078018*x_28 + 5.13359975814819) + 1020.98003745557*std::sin(0.326479852199554*x_28 - 4.28679990768433) + 1.16245207206103*std::sin(0.330159842967987*x_28 - 4.26823997497559) - 0.00418706000231417*std::sin(0.336159855127335*x_28 + 5.13064002990723) - 8.01374520163572*std::sin(0.3781598508358*x_34 + 1.97439980506897) - 6.33603839924075*std::sin(0.33943983912468*x_36 + 5.15008020401001) - 0.0586473838477763*std::sin(0.343679845333099*x_36 + 5.15984010696411) - 1.35809620181344*std::sin(0.392479836940765*x_36 - 7.40767955780029) - 0.00308282692097044*std::sin(0.438079863786697*x_36 + 8.22991943359375) - 518.721063831485*std::sin(0.521199882030487*x_38 + 5.15520000457764) + 4.70227537486722*std::sin(0.35471984744072*x_40 + 5.15056037902832) + 0.637316309397604*std::sin(0.622799813747406*x_52 + 5.21663999557495) + 0.252409110220068*std::sin(0.145520031452179*x_53 + 4.93263959884644) + 25.5196187391403*std::sin(0.209680005908012*x_53 - 4.39447975158691) + 743.245988417571*std::sin(0.416639864444733*x_53 + 5.20344018936157) + 0.482816853222088*std::sin(0.5204798579216*x_53 - 1.03647983074188) + 1270.63168463657*std::sin(0.310239911079407*x_60 - 7.48520040512085) - 1.14125969962151*std::sin(0.312479853630066*x_66 - 1.27471995353699) - 1.10691262810432*std::sin(0.287519931793213*x_80 + 1.90727996826172) + 6.5495800167016*std::sin(0.423599869012833*x_80 - 7.37215995788574) + 426.561213662201*std::sin(0.549839854240417*x_80 + 2.13167977333069) + 0.00285574133213337*std::sin(0.61959981918335*x_80 + 2.20671987533569) + 0.633446481645449*std::sin(0.339919835329056*x_83 + 5.14775991439819) - 4093.74338606288*std::sin(0.145120039582253*x_87 - 7.65576028823853) - 0.0200133981353695*std::sin(0.663759827613831*x_87 + 5.43271970748901) - 0.4279942494494*std::sin(0.686799824237823*x_88 + 8.46360015869141) - 14.0814649866548*std::sin(0.348319828510284*x_92 + 1.99511981010437) + 0.00676100168593278*std::sin(0.432319849729538*x_94 - 1.16055989265442) + 0.00454643671901291*std::sin(0.359359860420227*x_95 + 5.1800799369812) + 0.0688555901248444*std::sin(0.378639847040176*x_95 - 7.41328001022339) + 0.0696210990429574*std::sin(0.396399825811386*x_96 + 5.18255996704102) - 0.642256465812221*std::sin(0.444879859685898*x_96 - 7.36631965637207) + 2.59196671833266*std::sin(0.496719866991043*x_98 - 1.12415993213654) - 0.678676917282093*std::sin(0.414719849824905*x_99 + 5.21799993515015) - 2567.03457342671 - 1.55389100395183e-7*std::exp(-4.15696001052856*x_74) + 0.017369503285626*std::exp(-2.77735996246338*x_74) + 0.000469473273902846*std::exp(-2.6898398399353*x_74) - 0.00393632830873158*std::exp(-2.56887984275818*x_74) - 5.65893545550531e-7*std::exp(-4.01143980026245*x_45) - 1.85071493654442e-5*std::exp(-3.89863991737366*x_45) - 0.000565203142026246*std::exp(-3.8931999206543*x_45) - 0.00019717606134784*std::exp(-4.58256006240845*x_111) + 8.81132755215951e-7*std::exp(-4.382399559021*x_111));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-467.742197443581*x_1 - 20.2335165369269*x_10 + 2.34240974262365*x_100 + 2.16609661605789*x_101 - 45.0013655189894*x_102 - 9.31682058406311*x_103 + 26.4014233859629*x_104 + 4.19534859307393*x_105 - 3.43451572308542*x_106 + 3.81545229762201*x_107 + 37.1938074687975*x_108 - 5.29509003897717*x_109 + 34.0847477719738*x_11 - 14.8578486644694*x_110 + 3.35694728318536*x_111 + 14.1938682379445*x_112 - 64.579762290194*x_113 + 22.2016809480713*x_114 - 43.4507168153352*x_115 + 151.805361097535*x_116 + 0.0692727052086111*x_117 - 26.8472847134084*x_118 - 8.3897771786616*x_119 - 102.572779659739*x_12 + 136.44682253511*x_120 + 51.561255947124*x_13 + 15.6481472521001*x_14 + 26.6345082580417*x_15 + 10.123666496014*x_16 - 22.7074770374836*x_17 + 14.449623699863*x_18 + 6.85985428435644*x_19 - 50.4964048682719*x_2 + 102.663768471593*x_20 + 40.7258525077501*x_21 + 98.7572155725998*x_22 - 45.3405212496941*x_23 - 9.03691599306497*x_24 + 75.706968562471*x_25 - 14.1525173725801*x_26 + 17.5980722849798*x_27 - 0.352249117804638*x_28 + 60.7360258045742*x_29 - 142.409920237081*x_3 - 231.214803943236*x_30 - 1177.13707217341*x_31 + 9.51481777611895*x_32 - 0.142570005583443*x_33 - 55.9940149353119*x_34 - 94.2644711685739*x_35 - 37.9955996667753*x_36 - 310.962728965557*x_37 + 0.855875306009453*x_38 - 3.95120188435761*x_39 - 5.14493317856153*x_4 + 37.033166598853*x_40 - 56.1672242911497*x_41 + 2691.52967539528*x_42 + 27.1095838829584*x_43 + 40.1097818987186*x_44 - 36.563216308313*x_45 + 13.6878892148634*x_46 + 121.343518822187*x_47 + 30.1165560147673*x_48 + 180.518045189711*x_49 + 10.4503872924816*x_5 + 209.569625846597*x_50 - 67.9630655019234*x_51 + 76.940675455081*x_52 + 0.539712054324605*x_53 + 15.6108276573684*x_54 + 45.8179435167179*x_55 + 7.99688168825366*x_56 + 358.994366416749*x_57 + 17.5884237369647*x_58 - 21.3576712102176*x_59 - 3.33371644489079*x_6 + 4.05895866088912*x_60 - 24.6966364840005*x_61 - 47.7003438646755*x_62 + 18.6024273063358*x_63 + 40.6338178167023*x_64 - 27.0531709207628*x_65 + 46.7868569997169*x_66 - 35.4507499055406*x_67 + 6.58254346886528*x_68 - 40.7442897898376*x_69 + 31.0719944049235*x_7 - 30.8516303211042*x_70 - 16.5235876365042*x_72 + 76.7692472848254*x_73 + 38.5024384710912*x_74 - 1.27115372155547*x_75 + 78.5623255594826*x_76 - 27.0236127668361*x_77 - 21.8387866006511*x_78 + 27.1057934860091*x_79 - 146.285299429067*x_8 + 0.216652939256224*x_80 - 37.7838806211644*x_81 + 6.540181036592*x_82 - 2.0091215491317*x_83 + 108.878167856637*x_84 + 41.1404322519474*x_85 + 30.7282341860434*x_86 - 1.20335528328403*x_87 + 89.9467259084008*x_88 - 0.474382557700184*x_89 - 134.642240153322*x_9 + 230.6752830396*x_90 + 20.8047531705309*x_91 + 23.1632680577378*x_92 + 14.691571389423*x_93 + 1.50224220908102*x_94 + 14.1034587622461*x_95 - 0.210170113028162*x_96 + 106.598752455843*x_97 + 30.658330266892*x_98 + 14.7841983389363*x_99 + 0.000291349672064715*std::pow(-6.07103967666626*x_108 - 7.07919979095459, 2) + 0.0249542269218946*std::pow(-4.9137601852417*x_15 - 7.16799974441528, 2) + 0.0270696858882406*std::pow(-3.83136010169983*x_5 - 5.6496000289917, 2) - 0.000198375700931093*std::pow(-6.97944021224976*x_66 - 9.56559944152832, 2) - 0.00110653803780733*std::pow(-6.47760009765625*x_66 - 9.91936016082764, 2) + 0.0621609215813328*std::pow(-2.56959986686707*x_78 - 3.36103987693787, 2) + 7.8194229241381e-5*std::pow(-5.75359964370728*x_80 - 9.53351974487305, 2) + 0.000668087178051918*std::pow(-4.86624002456665*x_80 - 8.31335926055908, 2) - 0.510500030563174*std::exp(1.07743978500366*x_38) - 0.00273003173185658*std::exp(1.24855983257294*x_38) - 0.138428903909976*std::exp(2.51327991485596*x_71) - 0.0526641556162335*std::exp(2.54871988296509*x_71) + 0.00546889890730082*std::exp(2.56639981269836*x_71) - 0.00169602500847395*std::exp(2.57943987846375*x_71) - 0.154657899597185*std::exp(2.59703993797302*x_71) - 0.000807505163616751*std::exp(2.60055994987488*x_71) - 2.92287602952563*std::exp(2.62087988853455*x_71) + 0.000190143979085244*std::exp(2.62655997276306*x_71) - 0.0141143962756784*std::exp(2.64127993583679*x_71) + 0.000448244442778518*std::exp(2.66215991973877*x_71) + 0.0455393526074618*std::exp(2.08487987518311*x_89) + 0.078275590052502*std::sin(0.391359835863113*x_103 - 1.19543993473053) + 0.731571191248332*std::sin(0.400079846382141*x_103 - 4.20904016494751) + 0.0123096358455077*std::sin(0.538159847259521*x_106 - 1.01255977153778) + 9.07343039595939*std::sin(0.284559935331345*x_112 - 7.52672004699707) + 0.187484317881681*std::sin(0.471759855747223*x_114 + 8.24191951751709) - 6.01764682622041*std::sin(0.317359834909439*x_16 - 4.27519989013672) - 0.218474953555051*std::sin(0.344799846410751*x_18 + 1.95295989513397) + 3.11378911906679*std::sin(0.531999886035919*x_22 + 8.51503944396973) + 0.0572869767253075*std::sin(0.334559857845306*x_26 + 5.13928031921387) + 4.57801953369666*std::sin(0.296879917383194*x_28 + 5.12831974029541) - 0.0978857250817761*std::sin(0.303199917078018*x_28 + 5.13359975814819) + 335.021485675507*std::sin(0.326479852199554*x_28 - 4.28679990768433) + 1.08673935555004*std::sin(0.330159842967987*x_28 - 4.26823997497559) - 0.0388224071956924*std::sin(0.336159855127335*x_28 + 5.13064002990723) - 8.31896361236762*std::sin(0.3781598508358*x_34 + 1.97439980506897) - 6.57735822185726*std::sin(0.33943983912468*x_36 + 5.15008020401001) - 0.174342719549099*std::sin(0.343679845333099*x_36 + 5.15984010696411) - 6.26111665589872*std::sin(0.392479836940765*x_36 - 7.40767955780029) + 0.00747041574388795*std::sin(0.438079863786697*x_36 + 8.22991943359375) - 170.211654567797*std::sin(0.521199882030487*x_38 + 5.15520000457764) - 0.200401577075656*std::sin(0.35471984744072*x_40 + 5.15056037902832) + 2.93816576065603*std::sin(0.622799813747406*x_52 + 5.21663999557495) + 0.246263936154804*std::sin(0.145520031452179*x_53 + 4.93263959884644) - 7.49145867872955*std::sin(0.209680005908012*x_53 - 4.39447975158691) + 243.886624740057*std::sin(0.416639864444733*x_53 + 5.20344018936157) + 0.451370072392732*std::sin(0.5204798579216*x_53 - 1.03647983074188) + 416.941467136024*std::sin(0.310239911079407*x_60 - 7.48520040512085) - 5.2614535733661*std::sin(0.312479853630066*x_66 - 1.27471995353699) - 1.03481730131333*std::sin(0.287519931793213*x_80 + 1.90727996826172) - 1.92267402423606*std::sin(0.423599869012833*x_80 - 7.37215995788574) + 139.970583449216*std::sin(0.549839854240417*x_80 + 2.13167977333069) - 0.0069201338754772*std::sin(0.61959981918335*x_80 + 2.20671987533569) + 0.592188906350602*std::sin(0.339919835329056*x_83 + 5.14775991439819) - 1343.30931150332*std::sin(0.145120039582253*x_87 - 7.65576028823853) - 0.0195261502104747*std::sin(0.663759827613831*x_87 + 5.43271970748901) - 0.400118169174155*std::sin(0.686799824237823*x_88 + 8.46360015869141) + 4.13371038814568*std::sin(0.348319828510284*x_92 + 1.99511981010437) - 0.0163834995391652*std::sin(0.432319849729538*x_94 - 1.16055989265442) + 0.0421545469846179*std::sin(0.359359860420227*x_95 + 5.1800799369812) + 0.204688940084385*std::sin(0.378639847040176*x_95 - 7.41328001022339) + 0.206964589872436*std::sin(0.396399825811386*x_96 + 5.18255996704102) - 0.600425079476285*std::sin(0.444879859685898*x_96 - 7.36631965637207) - 0.110464440440421*std::sin(0.496719866991043*x_98 - 1.12415993213654) - 0.634473397605252*std::sin(0.414719849824905*x_99 + 5.21799993515015) - 6134.10388214139 - 1.44076725100188e-6*std::exp(-4.15696001052856*x_74) - 0.000740253510048534*std::exp(-2.77735996246338*x_74) + 0.000458043436902879*std::exp(-2.6898398399353*x_74) - 0.00367994775206503*std::exp(-2.56887984275818*x_74) - 5.24696317765556e-6*std::exp(-4.01143980026245*x_45) - 5.50167209478221e-5*std::exp(-3.89863991737366*x_45) - 0.000586729956319607*std::exp(-3.8931999206543*x_45) + 8.40324959845405e-6*std::exp(-4.58256006240845*x_111) - 2.13519220370261e-6*std::exp(-4.382399559021*x_111));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1854.76142078602*x_1 + 85.4580208000379*x_10 + 10.4251124035696*x_100 - 5.54146899138034*x_101 + 180.792267010523*x_102 + 45.3078557898381*x_103 - 100.042553943672*x_104 - 17.4809436667444*x_105 + 14.8269079770031*x_106 - 25.0499800669821*x_107 - 135.731014657135*x_108 + 29.9980210993606*x_109 - 126.739585360833*x_11 + 66.5635637587911*x_110 - 20.9404848372827*x_111 - 54.5502222972214*x_112 + 219.584731428675*x_113 - 86.2572005654534*x_114 + 169.555813926374*x_115 - 618.734993626537*x_116 + 0.606303419467874*x_117 + 101.17032341158*x_118 + 36.5837437227599*x_119 + 388.527155568492*x_12 - 524.475103613774*x_120 - 205.412161982591*x_13 - 65.8777025572829*x_14 - 98.5027334355877*x_15 - 36.2098160363274*x_16 + 88.2587662220391*x_17 - 39.9372003524986*x_18 - 34.025438167992*x_19 + 198.799061271786*x_2 - 395.677561963089*x_20 - 152.209845343869*x_21 - 378.552097596547*x_22 + 168.502562721759*x_23 + 40.6939028376168*x_24 - 287.996669217431*x_25 + 59.8229660659976*x_26 - 71.7769698214788*x_27 + 0.0277459968931528*x_28 - 237.081702852643*x_29 + 537.465853631286*x_3 + 892.686171534772*x_30 + 4409.30533200746*x_31 - 28.4663861003869*x_32 + 2.56328191993031*x_33 + 209.013951226682*x_34 + 368.419139792792*x_35 + 148.471522854669*x_36 + 1096.29538454156*x_37 - 2.0462854587105*x_38 + 21.331458172497*x_39 + 12.0453171770486*x_4 - 137.728991932808*x_40 + 208.613331680078*x_41 + 8744.51410103014*x_42 - 110.505592641197*x_43 - 151.310453804315*x_44 + 132.009369839089*x_45 - 54.0367424861466*x_46 - 442.342400773193*x_47 - 143.354609917925*x_48 - 671.921372568209*x_49 - 44.2525619765387*x_5 - 715.143025804801*x_50 + 241.817981439557*x_51 - 307.834526605131*x_52 + 0.0849657836683338*x_53 - 114.806080595273*x_54 - 168.559533220474*x_55 - 19.0850940398689*x_56 - 1227.67945347941*x_57 - 61.6526052838266*x_58 + 89.0742889464214*x_59 + 16.9914752656611*x_6 + 8.79711107490682*x_60 + 95.7399565563309*x_61 + 183.218085352321*x_62 - 65.9253054899649*x_63 - 160.977986453837*x_64 + 107.505801258784*x_65 - 178.22076263489*x_66 + 136.0594682357*x_67 - 17.854751853986*x_68 + 161.256672183061*x_69 - 119.508407079965*x_7 + 107.478996515303*x_70 + 60.2886522988667*x_72 - 299.878374057132*x_73 - 140.704810395163*x_74 + 3.0445505970064*x_75 - 313.639781613005*x_76 + 90.6058691020054*x_77 + 92.2160833166592*x_78 - 111.78049010971*x_79 + 548.79872517772*x_8 - 0.0603615388720728*x_80 + 140.760099782376*x_81 - 40.1051145214627*x_82 + 16.9200621066492*x_83 - 515.813215744764*x_84 - 171.30168361361*x_85 - 130.098621283019*x_86 + 0.605464865530046*x_87 - 362.760425566965*x_88 + 11.3182909088294*x_89 + 501.266776086162*x_9 - 906.68933095767*x_90 - 51.3366684148279*x_91 - 83.5564157779807*x_92 - 54.3637114622927*x_93 - 8.81069104558187*x_94 - 45.7871253034685*x_95 + 3.08996650845966*x_96 - 408.152879743619*x_97 - 129.190512082159*x_98 - 47.2956432441615*x_99 - 0.00333582588352463*std::pow(-6.07103967666626*x_108 - 7.07919979095459, 2) - 5.47184594970902e-5*std::pow(-4.9137601852417*x_15 - 7.16799974441528, 2) + 0.0784962856487371*std::pow(-3.83136010169983*x_5 - 5.6496000289917, 2) + 0.00227131471656949*std::pow(-6.97944021224976*x_66 - 9.56559944152832, 2) + 0.00692426235423746*std::pow(-6.47760009765625*x_66 - 9.91936016082764, 2) - 0.000136303556126824*std::pow(-2.56959986686707*x_78 - 3.36103987693787, 2) + 0.000103612097489863*std::pow(-5.75359964370728*x_80 - 9.53351974487305, 2) - 0.000328023398323031*std::pow(-4.86624002456665*x_80 - 8.31335926055908, 2) + 0.0268785590816661*std::exp(1.07743978500366*x_38) - 0.00218294984537762*std::exp(1.24855983257294*x_38) + 0.000303540414036179*std::exp(2.51327991485596*x_71) + 0.00277284335645465*std::exp(2.54871988296509*x_71) - 0.00268516873784175*std::exp(2.56639981269836*x_71) + 0.0194187420300779*std::exp(2.57943987846375*x_71) - 0.448474751969255*std::exp(2.59703993797302*x_71) - 0.00106999333004422*std::exp(2.60055994987488*x_71) + 11.3885770836781*std::exp(2.62087988853455*x_71) - 0.000652853654101422*std::exp(2.62655997276306*x_71) + 0.0883221176726384*std::exp(2.64127993583679*x_71) + 0.000358418961082666*std::exp(2.66215991973877*x_71) - 0.00239771225527678*std::exp(2.08487987518311*x_89) + 0.0625896341086661*std::sin(0.391359835863113*x_103 - 1.19543993473053) - 4.57787322796714*std::sin(0.400079846382141*x_103 - 4.20904016494751) + 0.0163110142738575*std::sin(0.538159847259521*x_106 - 1.01255977153778) + 26.3110029098847*std::sin(0.284559935331345*x_112 - 7.52672004699707) - 2.14661316044232*std::sin(0.471759855747223*x_114 + 8.24191951751709) - 17.44988568225*std::sin(0.317359834909439*x_16 - 4.27519989013672) + 2.50144233836274*std::sin(0.344799846410751*x_18 + 1.95295989513397) + 9.02932088496733*std::sin(0.531999886035919*x_22 + 8.51503944396973) + 0.0759087195429619*std::sin(0.334559857845306*x_26 + 5.13928031921387) + 13.2752751733503*std::sin(0.296879917383194*x_28 + 5.12831974029541) - 0.0782700164025659*std::sin(0.303199917078018*x_28 + 5.13359975814819) - 1305.36429727507*std::sin(0.326479852199554*x_28 - 4.28679990768433) - 6.80037030034174*std::sin(0.330159842967987*x_28 - 4.26823997497559) - 0.0514420447413594*std::sin(0.336159855127335*x_28 + 5.13064002990723) + 0.0182414336018447*std::sin(0.3781598508358*x_34 + 1.97439980506897) + 0.0144225229091259*std::sin(0.33943983912468*x_36 + 5.15008020401001) + 0.0856003426171581*std::sin(0.343679845333099*x_36 + 5.15984010696411) + 0.329656775469971*std::sin(0.392479836940765*x_36 - 7.40767955780029) - 0.0256494485889958*std::sin(0.438079863786697*x_36 + 8.22991943359375) + 663.20587291564*std::sin(0.521199882030487*x_38 + 5.15520000457764) + 2.29451010934943*std::sin(0.35471984744072*x_40 + 5.15056037902832) - 0.154698643019471*std::sin(0.622799813747406*x_52 + 5.21663999557495) + 0.196914129267512*std::sin(0.145520031452179*x_53 + 4.93263959884644) - 21.7236240863335*std::sin(0.209680005908012*x_53 - 4.39447975158691) - 950.270075594342*std::sin(0.416639864444733*x_53 + 5.20344018936157) - 2.82448925686423*std::sin(0.5204798579216*x_53 - 1.03647983074188) - 1624.55403167786*std::sin(0.310239911079407*x_60 - 7.48520040512085) + 0.277023079844191*std::sin(0.312479853630066*x_66 - 1.27471995353699) + 6.47546332631823*std::sin(0.287519931793213*x_80 + 1.90727996826172) - 5.57534247124025*std::sin(0.423599869012833*x_80 - 7.37215995788574) - 545.375774735647*std::sin(0.549839854240417*x_80 + 2.13167977333069) + 0.0237600722842291*std::sin(0.61959981918335*x_80 + 2.20671987533569) - 3.70567591057768*std::sin(0.339919835329056*x_83 + 5.14775991439819) + 5234.0165941834*std::sin(0.145120039582253*x_87 - 7.65576028823853) - 0.0156132275260364*std::sin(0.663759827613831*x_87 + 5.43271970748901) + 2.50377581375238*std::sin(0.686799824237823*x_88 + 8.46360015869141) + 11.9868739059877*std::sin(0.348319828510284*x_92 + 1.99511981010437) + 0.0562522546996758*std::sin(0.432319849729538*x_94 - 1.16055989265442) + 0.0558573321098713*std::sin(0.359359860420227*x_95 + 5.1800799369812) - 0.100500000496045*std::sin(0.378639847040176*x_95 - 7.41328001022339) - 0.101617319315194*std::sin(0.396399825811386*x_96 + 5.18255996704102) + 3.75721451256751*std::sin(0.444879859685898*x_96 - 7.36631965637207) + 1.26476936465668*std::sin(0.496719866991043*x_98 - 1.12415993213654) + 3.97027495820088*std::sin(0.414719849824905*x_99 + 5.21799993515015) + 5328.09884423655 - 1.90910401342006e-6*std::exp(-4.15696001052856*x_74) + 0.00847557782265622*std::exp(-2.77735996246338*x_74) + 0.000366254295910104*std::exp(-2.6898398399353*x_74) + 0.0230276075603118*std::exp(-2.56887984275818*x_74) - 6.95254452359593e-6*std::exp(-4.01143980026245*x_45) + 2.70126000958696e-5*std::exp(-3.89863991737366*x_45) + 1.28655395541167e-6*std::exp(-3.8931999206543*x_45) - 9.62135200550854e-5*std::exp(-4.58256006240845*x_111) + 7.3311184456237e-6*std::exp(-4.382399559021*x_111));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-3542.05966219249*x_1 - 163.942494033388*x_10 - 10.0608135019801*x_100 + 6.75085202847782*x_101 - 348.859240155934*x_102 - 79.0828260725123*x_103 + 188.660575043091*x_104 + 34.3600694234127*x_105 - 28.7706486731057*x_106 + 40.7596846873192*x_107 + 263.867649467891*x_108 - 55.4062382444844*x_109 + 250.251949060063*x_11 - 118.298896534947*x_110 + 37.2012470198459*x_111 + 104.276263434584*x_112 - 453.432555716805*x_113 + 166.161229638125*x_114 - 329.034027128024*x_115 + 1176.29143209864*x_116 - 2.25571010585827*x_117 - 195.6786684182*x_118 - 68.5384565005897*x_119 - 735.587386261286*x_12 + 1016.37288294827*x_120 + 405.560276944792*x_13 + 121.058869386603*x_14 + 193.904791805061*x_15 + 69.5951802790191*x_16 - 170.418478418428*x_17 + 89.6888962637965*x_18 + 63.640722294705*x_19 - 378.70084630424*x_2 + 760.777029168072*x_20 + 299.154377047875*x_21 + 730.889803809362*x_22 - 333.515591292147*x_23 - 74.0725121313854*x_24 + 565.645205803902*x_25 - 111.56793851341*x_26 + 138.048723497586*x_27 - 2.17296624433376*x_28 + 459.106543980012*x_29 - 1064.93766907882*x_3 - 1745.9319513126*x_30 - 8456.73949053334*x_31 + 56.8751097043992*x_32 - 2.50346726501263*x_33 - 414.017527538088*x_34 - 712.827324601072*x_35 - 285.941680578707*x_36 - 2189.68933371653*x_37 + 1.70293348081842*x_38 - 35.6814343543632*x_39 - 31.3016343057329*x_4 + 267.93320968398*x_40 - 407.300406219568*x_41 - 4338.74050461227*x_42 + 211.075194406287*x_43 + 300.01505668777*x_44 - 261.1230193015*x_45 + 108.341574918686*x_46 + 877.880573976191*x_47 + 248.119898688981*x_48 + 1314.59459553703*x_49 + 81.8159356854862*x_5 + 1458.37835388114*x_50 - 488.490584255761*x_51 + 595.043272505438*x_52 + 1.17580587632357*x_53 + 173.283784919872*x_54 + 330.710006717053*x_55 + 44.810325063089*x_56 + 2463.28570845343*x_57 + 125.763333621005*x_58 - 169.083162727938*x_59 - 30.3007502404028*x_6 + 8.13102574480726*x_60 - 189.414489868091*x_61 - 356.458063069766*x_62 + 137.187734025039*x_63 + 312.445490694301*x_64 - 208.796885265737*x_65 + 348.313092268625*x_66 - 265.840049777972*x_67 + 37.2890342907517*x_68 - 306.534281620082*x_69 + 234.058715174722*x_7 - 206.667613978358*x_70 - 117.393674381967*x_72 + 575.299731005333*x_73 + 277.048364822446*x_74 - 6.89720444086247*x_75 + 610.639485437015*x_76 - 186.043731006801*x_77 - 172.023387547086*x_78 + 212.25408568614*x_79 - 1081.46960769124*x_8 + 0.632416300232016*x_80 - 268.538456370198*x_81 + 64.7589434821484*x_82 - 27.4506640234761*x_83 + 920.147707323659*x_84 + 321.382809966195*x_85 + 246.330219307852*x_86 - 2.80840973385794*x_87 + 691.577723635127*x_88 - 16.2507372206357*x_89 - 972.218805461047*x_9 + 1739.8955494098*x_90 + 112.463967229965*x_91 + 167.744770333319*x_92 + 106.737209027457*x_93 + 17.3830325861426*x_94 + 94.2043439463242*x_95 - 7.15437309946762*x_96 + 784.849229346545*x_97 + 241.917414178332*x_98 + 98.7702708943891*x_99 - 0.0110946089458023*std::pow(-6.07103967666626*x_108 - 7.07919979095459, 2) + 0.080380921486817*std::pow(-4.9137601852417*x_15 - 7.16799974441528, 2) + 0.00660824237994788*std::pow(-3.83136010169983*x_5 - 5.6496000289917, 2) + 0.00755415583818144*std::pow(-6.97944021224976*x_66 - 9.56559944152832, 2) + 0.00137054485499916*std::pow(-6.47760009765625*x_66 - 9.91936016082764, 2) + 0.200228689625058*std::pow(-2.56959986686707*x_78 - 3.36103987693787, 2) + 0.000107360345148453*std::pow(-5.75359964370728*x_80 - 9.53351974487305, 2) + 0.0010079994457525*std::pow(-4.86624002456665*x_80 - 8.31335926055908, 2) - 0.166813669919428*std::exp(1.07743978500366*x_38) + 0.00194337839453685*std::exp(1.24855983257294*x_38) - 0.445898119445696*std::exp(2.51327991485596*x_71) - 0.0172088159561131*std::exp(2.54871988296509*x_71) + 0.00825138881352291*std::exp(2.56639981269836*x_71) + 0.0645847105231681*std::exp(2.57943987846375*x_71) - 0.0377550330924165*std::exp(2.59703993797302*x_71) - 0.00110870116524115*std::exp(2.60055994987488*x_71) - 22.0429875840609*std::exp(2.62087988853455*x_71) + 0.000795289396014419*std::exp(2.62655997276306*x_71) + 0.0174819233827537*std::exp(2.64127993583679*x_71) - 0.000319083677820323*std::exp(2.66215991973877*x_71) + 0.0148806779224384*std::exp(2.08487987518311*x_89) - 0.0557206309188964*std::sin(0.391359835863113*x_103 - 1.19543993473053) - 0.90611537784803*std::sin(0.400079846382141*x_103 - 4.20904016494751) + 0.0169010778141425*std::sin(0.538159847259521*x_106 - 1.01255977153778) + 2.2150026979121*std::sin(0.284559935331345*x_112 - 7.52672004699707) - 7.13941146947892*std::sin(0.471759855747223*x_114 + 8.24191951751709) - 1.46902586711815*std::sin(0.317359834909439*x_16 - 4.27519989013672) + 8.31953630483996*std::sin(0.344799846410751*x_18 + 1.95295989513397) + 0.760137125483842*std::sin(0.531999886035919*x_22 + 8.51503944396973) + 0.0786547761057233*std::sin(0.334559857845306*x_26 + 5.13928031921387) + 1.11758454914121*std::sin(0.296879917383194*x_28 + 5.12831974029541) + 0.069680143654642*std::sin(0.303199917078018*x_28 + 5.13359975814819) + 2526.57806028721*std::sin(0.326479852199554*x_28 - 4.28679990768433) - 1.34602244259546*std::sin(0.330159842967987*x_28 - 4.26823997497559) - 0.053303000444662*std::sin(0.336159855127335*x_28 + 5.13064002990723) - 26.7965007720079*std::sin(0.3781598508358*x_34 + 1.97439980506897) - 21.1865555473453*std::sin(0.33943983912468*x_36 + 5.15008020401001) - 0.26304555819932*std::sin(0.343679845333099*x_36 + 5.15984010696411) - 2.04591534698228*std::sin(0.392479836940765*x_36 - 7.40767955780029) + 0.0312454933020508*std::sin(0.438079863786697*x_36 + 8.22991943359375) - 1283.6580650016*std::sin(0.521199882030487*x_38 + 5.15520000457764) + 7.63130129517568*std::sin(0.35471984744072*x_40 + 5.15056037902832) + 0.960090468213963*std::sin(0.622799813747406*x_52 + 5.21663999557495) - 0.175303461601666*std::sin(0.145520031452179*x_53 + 4.93263959884644) - 1.82881230808499*std::sin(0.209680005908012*x_53 - 4.39447975158691) + 1839.28082708869*std::sin(0.416639864444733*x_53 + 5.20344018936157) - 0.559061604103818*std::sin(0.5204798579216*x_53 - 1.03647983074188) + 3144.38090788651*std::sin(0.310239911079407*x_60 - 7.48520040512085) - 1.7192601902798*std::sin(0.312479853630066*x_66 - 1.27471995353699) + 1.28171240365986*std::sin(0.287519931793213*x_80 + 1.90727996826172) - 0.469362519470575*std::sin(0.423599869012833*x_80 - 7.37215995788574) + 1055.59380621612*std::sin(0.549839854240417*x_80 + 2.13167977333069) - 0.0289439040701883*std::sin(0.61959981918335*x_80 + 2.20671987533569) - 0.733478137267357*std::sin(0.339919835329056*x_83 + 5.14775991439819) - 10130.6214071032*std::sin(0.145120039582253*x_87 - 7.65576028823853) + 0.0138997279792465*std::sin(0.663759827613831*x_87 + 5.43271970748901) + 0.495581606250037*std::sin(0.686799824237823*x_88 + 8.46360015869141) + 1.00911995381674*std::sin(0.348319828510284*x_92 + 1.99511981010437) - 0.0685250383198506*std::sin(0.432319849729538*x_94 - 1.16055989265442) + 0.0578780142441793*std::sin(0.359359860420227*x_95 + 5.1800799369812) + 0.30883145932894*std::sin(0.378639847040176*x_95 - 7.41328001022339) + 0.312264924003072*std::sin(0.396399825811386*x_96 + 5.18255996704102) + 0.743679363358649*std::sin(0.444879859685898*x_96 - 7.36631965637207) + 4.206490985276*std::sin(0.496719866991043*x_98 - 1.12415993213654) + 0.785851205300476*std::sin(0.414719849824905*x_99 + 5.21799993515015) - 12703.8873209595 - 1.97816732573267e-6*std::exp(-4.15696001052856*x_74) + 0.0281888877943264*std::exp(-2.77735996246338*x_74) - 0.000326059110833522*std::exp(-2.6898398399353*x_74) + 0.00455793952483776*std::exp(-2.56887984275818*x_74) - 7.20405819201061e-6*std::exp(-4.01143980026245*x_45) - 8.30083648427915e-5*std::exp(-3.89863991737366*x_45) - 0.0018899361098424*std::exp(-3.8931999206543*x_45) - 0.000319996132166951*std::exp(-4.58256006240845*x_111) - 8.93057842918113e-6*std::exp(-4.382399559021*x_111));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (902.69682144246*x_1 + 40.1724085238011*x_10 + 1.31955990066261*x_100 - 6.00519014229544*x_101 + 86.3698893493035*x_102 + 19.2299094591236*x_103 - 48.8110298882655*x_104 - 7.54766884546063*x_105 + 7.10713247839838*x_106 - 10.7803250484771*x_107 - 65.3214678852775*x_108 + 13.6565339490519*x_109 - 61.9903705495907*x_11 + 30.6358463398483*x_110 - 9.14147644474064*x_111 - 26.9464638303732*x_112 + 112.080162166184*x_113 - 41.7995256203598*x_114 + 81.4267925722465*x_115 - 282.415901575585*x_116 + 1.34937460265416*x_117 + 48.2819169339557*x_118 + 16.2837674401291*x_119 + 209.476366105161*x_12 - 253.491378612012*x_120 - 101.557396206844*x_13 - 31.6705265366354*x_14 - 48.0602205962015*x_15 - 18.3936193971651*x_16 + 40.3085895523393*x_17 - 22.3003443064237*x_18 - 16.388284026069*x_19 + 93.041670144851*x_2 - 190.267098088411*x_20 - 67.5526604455297*x_21 - 180.177909879271*x_22 + 83.1968807628722*x_23 + 18.7112843370866*x_24 - 140.387799163982*x_25 + 26.1313196627419*x_26 - 35.8941449219887*x_27 + 0.961377674224446*x_28 - 114.130294405928*x_29 + 259.552736265699*x_3 + 423.677132312656*x_30 + 2049.07814895967*x_31 - 13.447259046542*x_32 + 2.31396937031022*x_33 + 100.935295766484*x_34 + 175.734905389021*x_35 + 71.37046037679*x_36 + 540.186992134114*x_37 - 0.921980343854338*x_38 + 8.15287154013039*x_39 + 7.10135538096424*x_4 - 66.1351799520812*x_40 + 102.301218718606*x_41 + 2708.72882478656*x_42 - 52.256040089064*x_43 - 74.14779617856*x_44 + 65.338781830482*x_45 - 26.8703399936202*x_46 - 213.599870415463*x_47 - 55.7329798210806*x_48 - 331.226210603643*x_49 - 20.2669869803122*x_5 - 356.30311917502*x_50 + 121.125408636464*x_51 - 137.442587620906*x_52 + 0.117071314752045*x_53 - 45.9530075254102*x_54 - 83.6271173938854*x_55 - 11.7722948946711*x_56 - 623.42591961341*x_57 - 30.5798356739283*x_58 + 42.4245888219352*x_59 + 7.82876389389709*x_6 - 3.09142723505063*x_60 + 46.0781385723533*x_61 + 86.4291953072236*x_62 - 30.947613279515*x_63 - 78.0391333326639*x_64 + 51.3452831574306*x_65 - 86.5412411797604*x_66 + 66.120297497418*x_67 - 9.22500073473649*x_68 + 76.3630137949073*x_69 - 58.9564290138905*x_7 + 52.1347015250822*x_70 + 31.6977554053812*x_72 - 142.75772644973*x_73 - 67.9104281754895*x_74 + 2.22679496157784*x_75 - 149.796123491497*x_76 + 45.5742174378284*x_77 + 41.8165542732598*x_78 - 51.1249511586993*x_79 + 265.247887182812*x_8 - 0.446495684200575*x_80 + 66.4611762304166*x_81 - 18.0797954347939*x_82 + 6.92585309423411*x_83 - 234.799422360661*x_84 - 80.7308900069156*x_85 - 61.0201330106247*x_86 + 0.433591760244277*x_87 - 170.691650657835*x_88 + 4.50821091879541*x_89 + 251.199837602082*x_9 - 436.369995248582*x_90 - 27.8362736511872*x_91 - 40.3912214850534*x_92 - 25.611572565847*x_93 - 5.4246287842861*x_94 - 23.727221171926*x_95 + 0.557766001941304*x_96 - 200.544365183254*x_97 - 60.4450623297659*x_98 - 26.3302161479453*x_99 - 0.012103627971607*std::pow(-6.07103967666626*x_108 - 7.07919979095459, 2) - 0.024074228067326*std::pow(-4.9137601852417*x_15 - 7.16799974441528, 2) + 0.00858296687287647*std::pow(-3.83136010169983*x_5 - 5.6496000289917, 2) + 0.00824118203278223*std::pow(-6.97944021224976*x_66 - 9.56559944152832, 2) - 4.08381137086999e-5*std::pow(-6.47760009765625*x_66 - 9.91936016082764, 2) - 0.0599688464686991*std::pow(-2.56959986686707*x_78 - 3.36103987693787, 2) + 0.000295463062729376*std::pow(-5.75359964370728*x_80 - 9.53351974487305, 2) - 0.000206816632834139*std::pow(-4.86624002456665*x_80 - 8.31335926055908, 2) - 0.0164513456013654*std::exp(1.07743978500366*x_38) + 0.00281035627675813*std::exp(1.24855983257294*x_38) + 0.133547274947427*std::exp(2.51327991485596*x_71) - 0.00169715215078627*std::exp(2.54871988296509*x_71) - 0.00169298153665563*std::exp(2.56639981269836*x_71) + 0.0704584823714873*std::exp(2.57943987846375*x_71) - 0.0490372749189507*std::exp(2.59703993797302*x_71) - 0.00305122195239606*std::exp(2.60055994987488*x_71) + 5.46461681566285*std::exp(2.62087988853455*x_71) - 0.000318384110013012*std::exp(2.62655997276306*x_71) - 0.000520908726443771*std::exp(2.64127993583679*x_71) - 0.000461432945480041*std::exp(2.66215991973877*x_71) + 0.00146754864516132*std::exp(2.08487987518311*x_89) - 0.080578658941592*std::sin(0.391359835863113*x_103 - 1.19543993473053) + 0.0269995124193014*std::sin(0.400079846382141*x_103 - 4.20904016494751) + 0.0465129299602107*std::sin(0.538159847259521*x_106 - 1.01255977153778) + 2.87690639756188*std::sin(0.284559935331345*x_112 - 7.52672004699707) - 7.78871799672501*std::sin(0.471759855747223*x_114 + 8.24191951751709) - 1.90801118178313*std::sin(0.317359834909439*x_16 - 4.27519989013672) + 9.07617139296827*std::sin(0.344799846410751*x_18 + 1.95295989513397) + 0.987286995808229*std::sin(0.531999886035919*x_22 + 8.51503944396973) + 0.216463360045608*std::sin(0.334559857845306*x_26 + 5.13928031921387) + 1.45154953638266*std::sin(0.296879917383194*x_28 + 5.12831974029541) + 0.100765774506771*std::sin(0.303199917078018*x_28 + 5.13359975814819) - 626.357062611327*std::sin(0.326479852199554*x_28 - 4.28679990768433) + 0.0401074195891304*std::sin(0.330159842967987*x_28 - 4.26823997497559) - 0.146693527691887*std::sin(0.336159855127335*x_28 + 5.13064002990723) + 8.025599346947*std::sin(0.3781598508358*x_34 + 1.97439980506897) + 6.34541083597197*std::sin(0.33943983912468*x_36 + 5.15008020401001) + 0.0539704628390417*std::sin(0.343679845333099*x_36 + 5.15984010696411) - 0.201770397237829*std::sin(0.392479836940765*x_36 - 7.40767955780029) - 0.0125087403739388*std::sin(0.438079863786697*x_36 + 8.22991943359375) + 318.228163075374*std::sin(0.521199882030487*x_38 + 5.15520000457764) + 8.32534362114639*std::sin(0.35471984744072*x_40 + 5.15056037902832) + 0.0946851664422564*std::sin(0.622799813747406*x_52 + 5.21663999557495) - 0.253509653618992*std::sin(0.145520031452179*x_53 + 4.93263959884644) - 2.37531170234195*std::sin(0.209680005908012*x_53 - 4.39447975158691) - 455.971083688443*std::sin(0.416639864444733*x_53 + 5.20344018936157) + 0.01665835399351*std::sin(0.5204798579216*x_53 - 1.03647983074188) - 779.514878305816*std::sin(0.310239911079407*x_60 - 7.48520040512085) - 0.169555310320933*std::sin(0.312479853630066*x_66 - 1.27471995353699) - 0.0381911738908718*std::sin(0.287519931793213*x_80 + 1.90727996826172) - 0.609620943718708*std::sin(0.423599869012833*x_80 - 7.37215995788574) - 261.689375905165*std::sin(0.549839854240417*x_80 + 2.13167977333069) + 0.0115873280643136*std::sin(0.61959981918335*x_80 + 2.20671987533569) + 0.0218554419895933*std::sin(0.339919835329056*x_83 + 5.14775991439819) + 2511.45466934801*std::sin(0.145120039582253*x_87 - 7.65576028823853) + 0.0201006596973183*std::sin(0.663759827613831*x_87 + 5.43271970748901) - 0.0147668410225009*std::sin(0.686799824237823*x_88 + 8.46360015869141) + 1.31067273813223*std::sin(0.348319828510284*x_92 + 1.99511981010437) + 0.0274331374822928*std::sin(0.432319849729538*x_94 - 1.16055989265442) + 0.159284280705631*std::sin(0.359359860420227*x_95 + 5.1800799369812) - 0.0633646008445798*std::sin(0.378639847040176*x_95 - 7.41328001022339) - 0.0640690631395256*std::sin(0.396399825811386*x_96 + 5.18255996704102) - 0.0221594078390617*std::sin(0.444879859685898*x_96 - 7.36631965637207) + 4.58905782082231*std::sin(0.496719866991043*x_98 - 1.12415993213654) - 0.0234160018646011*std::sin(0.414719849824905*x_99 + 5.21799993515015) + 4531.123067338 - 5.44405269789296e-6*std::exp(-4.15696001052856*x_74) + 0.0307525765407883*std::exp(-2.77735996246338*x_74) - 0.000471520251177614*std::exp(-2.6898398399353*x_74) - 0.000135812886323094*std::exp(-2.56887984275818*x_74) - 1.98260642190454e-5*std::exp(-4.01143980026245*x_45) + 1.70312697950324e-5*std::exp(-3.89863991737366*x_45) + 0.000566039205565501*std::exp(-3.8931999206543*x_45) - 0.000349098751927382*std::exp(-4.58256006240845*x_111) + 3.57524478425799e-6*std::exp(-4.382399559021*x_111));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-744.271844847997*x_1 - 31.9798101439116*x_10 + 2.49021726410979*x_100 + 1.61279783969879*x_101 - 68.3842177017223*x_102 - 14.9608599177508*x_103 + 40.4056856015799*x_104 + 5.29241976311799*x_105 - 5.39005255224045*x_106 + 8.76349181351477*x_107 + 54.5849025225249*x_108 - 7.16883250745523*x_109 + 50.5075457930878*x_11 - 23.6166051468939*x_110 + 5.77513969861304*x_111 + 21.8370395295421*x_112 - 95.7449395927175*x_113 + 35.3291330774203*x_114 - 65.30077776929*x_115 + 224.577084741315*x_116 + 1.02027833624627*x_117 - 39.1635643777029*x_118 - 12.7291061026458*x_119 - 177.462076194592*x_12 + 206.462872140514*x_120 + 78.4804275453604*x_13 + 25.6856511626263*x_14 + 39.0086398396851*x_15 + 15.3766218251208*x_16 - 33.3398717996278*x_17 + 20.2555861450709*x_18 + 11.464988792744*x_19 - 75.2293634573921*x_2 + 155.245745493004*x_20 + 51.8971221267542*x_21 + 147.698378038901*x_22 - 67.9243969018671*x_23 - 14.9057161936797*x_24 + 114.549250587364*x_25 - 21.3827261591296*x_26 + 29.8307347707537*x_27 - 0.898698476964414*x_28 + 91.2563826718995*x_29 - 213.421392704497*x_3 - 341.9592868839*x_30 - 1690.29945918768*x_31 + 12.8248484610821*x_32 - 2.53338176499992*x_33 - 81.906397062721*x_34 - 141.122478828311*x_35 - 57.6796381476569*x_36 - 458.517608698469*x_37 + 1.49544944656272*x_38 - 5.06839609141107*x_39 - 6.56562036852106*x_4 + 54.5573107593638*x_40 - 82.4089528106637*x_41 + 492.053580189841*x_42 + 41.2702010068437*x_43 + 57.8687849907081*x_44 - 53.3979227124431*x_45 + 20.8527205128481*x_46 + 180.64778877791*x_47 + 48.5126690766976*x_48 + 274.647772082863*x_49 + 15.7896053787237*x_5 + 305.724908430607*x_50 - 100.072373791791*x_51 + 107.791879306834*x_52 + 0.469271320920855*x_53 + 30.9454832333596*x_54 + 69.138032991807*x_55 + 10.9790481716296*x_56 + 539.944864794967*x_57 + 24.2904740826451*x_58 - 34.9663305840614*x_59 - 5.59974562767306*x_6 + 2.44930551007364*x_60 - 37.0750084706583*x_61 - 70.0996984681796*x_62 + 24.462780222116*x_63 + 62.418801963952*x_64 - 40.6587192927488*x_65 + 70.7423740486531*x_66 - 53.0080619624807*x_67 + 8.70776851938629*x_68 - 61.2190374933654*x_69 + 47.274881193129*x_7 - 44.2411859410414*x_70 - 25.384146989819*x_72 + 116.039091018958*x_73 + 55.0864293677353*x_74 - 2.9684915464757*x_75 + 119.367935075341*x_76 - 38.3587595228151*x_77 - 34.6132156537396*x_78 + 41.2690210918729*x_79 - 211.665768656146*x_8 + 0.472651412702935*x_80 - 52.3146352398497*x_81 + 13.3502434959202*x_82 - 4.36079053138691*x_83 + 181.68822033107*x_84 + 64.3467719525558*x_85 + 47.5014461854226*x_86 - 1.64158246002015*x_87 + 137.525612419374*x_88 - 2.85734889359203*x_89 - 202.992647408828*x_9 + 350.3437995597*x_90 + 24.6276038235336*x_91 + 34.1938317086116*x_92 + 21.9874727887272*x_93 + 2.45122428864275*x_94 + 19.6676938961321*x_95 + 0.356510373691374*x_96 + 162.555909945662*x_97 + 48.5947798231316*x_98 + 21.7931330130033*x_99 + 0.00642543809766203*std::pow(-6.07103967666626*x_108 - 7.07919979095459, 2) + 0.0379929974826007*std::pow(-4.9137601852417*x_15 - 7.16799974441528, 2) - 0.0109975466671754*std::pow(-3.83136010169983*x_5 - 5.6496000289917, 2) - 0.00437498617170205*std::pow(-6.97944021224976*x_66 - 9.56559944152832, 2) - 0.000976971622672515*std::pow(-6.47760009765625*x_66 - 9.91936016082764, 2) + 0.0946404689092414*std::pow(-2.56959986686707*x_78 - 3.36103987693787, 2) + 6.15873064616627e-5*std::pow(-5.75359964370728*x_80 - 9.53351974487305, 2) + 0.000812896556301318*std::pow(-4.86624002456665*x_80 - 8.31335926055908, 2) - 0.465540913127368*std::exp(1.07743978500366*x_38) + 0.00317039791539442*std::exp(1.24855983257294*x_38) - 0.21075904351725*std::exp(2.51327991485596*x_71) - 0.0480260874178912*std::exp(2.54871988296509*x_71) + 0.00665429488029989*std::exp(2.56639981269836*x_71) - 0.0374042078949568*std::exp(2.57943987846375*x_71) + 0.0628325528153338*std::exp(2.59703993797302*x_71) - 0.000636006882650124*std::exp(2.60055994987488*x_71) - 4.42048294640444*std::exp(2.62087988853455*x_71) + 0.00122829987490109*std::exp(2.62655997276306*x_71) - 0.0124617176828524*std::exp(2.64127993583679*x_71) - 0.000520548252384492*std::exp(2.66215991973877*x_71) + 0.0415287571534894*std::exp(2.08487987518311*x_89) - 0.0909017886616118*std::sin(0.391359835863113*x_103 - 1.19543993473053) + 0.645910279985146*std::sin(0.400079846382141*x_103 - 4.20904016494751) + 0.00969531028828849*std::sin(0.538159847259521*x_106 - 1.01255977153778) - 3.68624425946071*std::sin(0.284559935331345*x_112 - 7.52672004699707) + 4.13478714526766*std::sin(0.471759855747223*x_114 + 8.24191951751709) + 2.44477723425259*std::sin(0.317359834909439*x_16 - 4.27519989013672) - 4.81825594657183*std::sin(0.344799846410751*x_18 + 1.95295989513397) - 1.26503282269545*std::sin(0.531999886035919*x_22 + 8.51503944396973) + 0.0451203448908289*std::sin(0.334559857845306*x_26 + 5.13928031921387) - 1.85990275886212*std::sin(0.296879917383194*x_28 + 5.12831974029541) + 0.113675125136765*std::sin(0.303199917078018*x_28 + 5.13359975814819) + 506.677925833212*std::sin(0.326479852199554*x_28 - 4.28679990768433) + 0.959491201692126*std::sin(0.330159842967987*x_28 - 4.26823997497559) - 0.0305772882824869*std::sin(0.336159855127335*x_28 + 5.13064002990723) - 12.6656844378224*std::sin(0.3781598508358*x_34 + 1.97439980506897) - 10.0140771800841*std::sin(0.33943983912468*x_36 + 5.15008020401001) - 0.212131890857297*std::sin(0.343679845333099*x_36 + 5.15984010696411) - 5.70970771925029*std::sin(0.392479836940765*x_36 - 7.40767955780029) + 0.0482576980234701*std::sin(0.438079863786697*x_36 + 8.22991943359375) - 257.423752733825*std::sin(0.521199882030487*x_38 + 5.15520000457764) - 4.41966493062486*std::sin(0.35471984744072*x_40 + 5.15056037902832) + 2.67940507197699*std::sin(0.622799813747406*x_52 + 5.21663999557495) - 0.285987397403275*std::sin(0.145520031452179*x_53 + 4.93263959884644) + 3.04353980185395*std::sin(0.209680005908012*x_53 - 4.39447975158691) + 368.847893180927*std::sin(0.416639864444733*x_53 + 5.20344018936157) + 0.398518385256016*std::sin(0.5204798579216*x_53 - 1.03647983074188) + 630.571610463672*std::sin(0.310239911079407*x_60 - 7.48520040512085) - 4.79808374980889*std::sin(0.312479853630066*x_66 - 1.27471995353699) - 0.913648788827004*std::sin(0.287519931793213*x_80 + 1.90727996826172) + 0.781120896437427*std::sin(0.423599869012833*x_80 - 7.37215995788574) + 211.687930273238*std::sin(0.549839854240417*x_80 + 2.13167977333069) - 0.0447029646399521*std::sin(0.61959981918335*x_80 + 2.20671987533569) + 0.522848503167991*std::sin(0.339919835329056*x_83 + 5.14775991439819) - 2031.58664386133*std::sin(0.145120039582253*x_87 - 7.65576028823853) + 0.0226758045339158*std::sin(0.663759827613831*x_87 + 5.43271970748901) - 0.353267654289977*std::sin(0.686799824237823*x_88 + 8.46360015869141) - 1.6793941787839*std::sin(0.348319828510284*x_92 + 1.99511981010437) - 0.105834802296721*std::sin(0.432319849729538*x_94 - 1.16055989265442) + 0.0332017468434909*std::sin(0.359359860420227*x_95 + 5.1800799369812) + 0.249055722028291*std::sin(0.378639847040176*x_95 - 7.41328001022339) + 0.2518246239573*std::sin(0.396399825811386*x_96 + 5.18255996704102) - 0.53012028881682*std::sin(0.444879859685898*x_96 - 7.36631965637207) - 2.43618748225377*std::sin(0.496719866991043*x_98 - 1.12415993213654) - 0.560181831642444*std::sin(0.414719849824905*x_99 + 5.21799993515015) - 6458.05181158652 - 1.13477650573761e-6*std::exp(-4.15696001052856*x_74) - 0.0163255824922892*std::exp(-2.77735996246338*x_74) - 0.000531927867567099*std::exp(-2.6898398399353*x_74) - 0.00324905642991645*std::exp(-2.56887984275818*x_74) - 4.13261096567368e-6*std::exp(-4.01143980026245*x_45) - 6.69417172888771e-5*std::exp(-3.89863991737366*x_45) - 0.000893300755146168*std::exp(-3.8931999206543*x_45) + 0.000185325625154905*std::exp(-4.58256006240845*x_111) - 1.37930021729583e-5*std::exp(-4.382399559021*x_111));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
