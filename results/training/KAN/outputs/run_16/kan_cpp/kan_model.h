
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (14614.1603189445*x_1 - 392.146054031632*x_10 - 77.7250226816768*x_100 + 788.897791497138*x_101 - 15.9741750594947*x_102 - 65.2676576325319*x_103 - 371.958207651897*x_104 + 110.328084206809*x_105 + 33.0401493753043*x_106 - 335.155710992183*x_107 + 270.040801929877*x_108 + 390.42600888229*x_109 + 85.9562018781507*x_11 + 244.373724975381*x_110 + 48.7573685269321*x_111 - 336.219182176646*x_112 + 825.610584513956*x_113 - 158.740050452054*x_114 + 4.46791127579624*x_115 + 1983.0794965733*x_116 - 185.30324428973*x_117 + 90.7733084991007*x_118 - 266.076274249497*x_119 - 2113.76634789906*x_12 - 172.797547762146*x_120 + 736.684063292942*x_13 - 206.043323825781*x_14 + 163.381153349047*x_15 - 99.6945896564891*x_16 - 386.239600205348*x_17 - 2.35082741058275*x_18 + 66.9769923907621*x_19 - 60.0598477813465*x_2 + 448.671611304692*x_20 + 1662.30433578197*x_21 + 183.748881399197*x_22 + 59.5144587017764*x_23 + 302.266799562405*x_24 + 640.800975174319*x_25 + 274.787986780734*x_26 + 319.238305402351*x_27 - 1.35625921712718*x_28 + 261.361080032491*x_29 - 476.976262210349*x_3 - 1405.2390028956*x_30 + 25293.4652200383*x_31 - 18.6166277020604*x_32 + 75.5903081192146*x_33 + 117.534181699494*x_34 - 353.016663391133*x_35 - 0.360690026089588*x_36 - 2682.12577861168*x_37 + 233.829414410836*x_38 - 299.343642823125*x_39 - 61.2567244440265*x_4 - 157.197875049574*x_40 + 24.5789605705653*x_41 + 379423.099004358*x_42 + 538.287461295556*x_43 + 607.021886886921*x_44 - 9.65057025919631*x_45 - 261.328638622514*x_46 + 2210.92804443262*x_47 + 989.535151804514*x_48 + 216.020071856406*x_49 + 135.111190891574*x_5 - 2225.85349626351*x_50 - 232.108935079514*x_51 - 43.4259370155106*x_52 - 3.83660530682982*x_53 + 748.033218428149*x_54 - 18.0721651590888*x_55 + 142.541294190222*x_56 + 6333.6114335726*x_57 + 309.015690896281*x_58 + 237.831556292337*x_59 - 97.143001715659*x_6 + 338.482192529596*x_60 + 129.592118407344*x_61 + 20.0118098083388*x_62 - 24.17848876932*x_63 - 167.946283451887*x_64 + 13.6869804811968*x_65 - 123.330266554926*x_66 - 249.128294228411*x_67 + 479.391863211333*x_68 + 2.27777681361827*x_69 - 57.8472087652573*x_7 + 186.109031916751*x_70 - 183.492688446391*x_72 - 114.604409993825*x_73 + 689.043789115784*x_74 - 272.53028140663*x_75 + 126.159414766791*x_76 + 3.03113577907538*x_77 - 16.8454968309958*x_78 + 100.959609890365*x_79 + 1378.61520116256*x_8 - 94.2958147279962*x_80 + 84.3885761718601*x_81 - 351.760330903973*x_82 - 200.555661638899*x_83 - 587.696450063407*x_84 - 562.432587095167*x_85 + 284.911418453206*x_86 + 21.0795681421855*x_87 - 368.847800359813*x_88 + 0.0438761534779334*x_89 - 46.4387579964165*x_9 - 296.32207210489*x_90 + 587.557307364399*x_91 - 174.620226854402*x_92 - 545.771460427305*x_93 + 37.2953799232775*x_94 - 1.02270474412871*x_95 + 226.741096146004*x_96 + 1351.99181539367*x_97 - 160.898311567706*x_98 + 75.2742107317687*x_99 - 1.51485693283884*std::pow(-6.09583950042725*x_77 - 9.12215995788574, 2) - 0.124651570005617*std::exp(0.830399870872498*x_50) + 0.0123893453693097*std::exp(2.49247980117798*x_71) + 4.92657920675243*std::exp(2.52639985084534*x_71) + 0.234080211794054*std::exp(2.59511995315552*x_71) - 0.0543005390421425*std::exp(2.64567995071411*x_71) + 0.00860994166408941*std::exp(2.73368000984192*x_71) - 0.246085848536758*std::exp(1.85903990268707*x_89) - 16.9994716246242*std::exp(1.88391983509064*x_89) - 102.454398210737*std::sin(0.200719982385635*x_107 + 1.78663992881775) - 7.78183722545458*std::sin(0.119360059499741*x_108 + 1.71591985225677) - 0.644403970064519*std::sin(0.386799842119217*x_11 - 7.41039991378784) + 4233.48795723822*std::sin(0.22639998793602*x_115 + 5.03599977493286) + 0.401609967453271*std::sin(0.599919855594635*x_14 - 4.00559997558594) - 1.51078128827006*std::sin(0.429279863834381*x_24 + 2.03871965408325) + 0.755322240614056*std::sin(0.322639852762222*x_26 - 4.27967977523804) + 2086.26005590848*std::sin(0.319519847631454*x_28 - 4.29392004013062) - 47.078809581252*std::sin(0.335359841585159*x_28 - 4.26592016220093) - 2137.02038434728*std::sin(0.362799853086472*x_36 + 5.17072010040283) - 0.624477509197123*std::sin(0.467839866876602*x_45 + 5.23816013336182) - 2616.29808103368*std::sin(0.328719854354858*x_53 - 4.28424024581909) + 1.9572191620828*std::sin(0.372079849243164*x_53 - 4.23120021820068) + 0.518544009172153*std::sin(0.418559849262238*x_66 + 2.02839994430542) + 4.38318658925735*std::sin(0.283759921789169*x_75 + 1.88519990444183) + 1.21985649356787*std::sin(0.367359846830368*x_75 + 1.98055982589722) + 0.686737117583073*std::sin(0.395039826631546*x_80 + 2.00567984580994) - 20.1139846391324*std::sin(0.424879848957062*x_80 - 4.18488025665283) - 0.204861035797612*std::sin(0.589679837226868*x_80 + 5.40136003494263) - 0.536733984451964*std::sin(0.639519810676575*x_86 - 0.96319979429245) + 1.97075430773936*std::sin(0.377279847860336*x_87 + 5.17512035369873) + 6.98309277617527*std::sin(0.413919866085052*x_92 - 4.38631963729858) - 0.647047286777936*std::sin(0.378879845142365*x_95 - 7.4159197807312) - 979.097645404182*std::sin(0.383839845657349*x_95 + 5.18136024475098) - 30.095799621492*std::sin(0.372159838676453*x_96 + 5.18296003341675) + 0.917012243254457*std::sin(0.411359876394272*x_96 - 7.37935972213745) + 96092.2074342044 - 0.000111259759727738*std::exp(-4.69999980926514*x_111));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (22215.8995352641*x_1 - 599.817237221833*x_10 - 131.208499150431*x_100 + 1253.59162133144*x_101 - 33.2277812650122*x_102 - 102.13788086085*x_103 - 596.260703698147*x_104 + 169.251060436149*x_105 + 64.5443659981197*x_106 - 517.221456267057*x_107 + 399.412605348047*x_108 + 600.110456458573*x_109 + 121.600746423258*x_11 + 375.448977925336*x_110 + 75.6388893103282*x_111 - 495.276343233359*x_112 + 1219.83953654495*x_113 - 235.058783672143*x_114 - 4.19017634245604*x_115 + 2941.75745320767*x_116 - 278.323788037195*x_117 + 132.784465528231*x_118 - 409.976312381273*x_119 - 3256.58484615571*x_12 - 262.847525225909*x_120 + 1124.57007130121*x_13 - 313.15148379602*x_14 + 246.209991788769*x_15 - 150.35772922604*x_16 - 594.349668482072*x_17 - 2.45990006208125*x_18 + 101.613414760536*x_19 - 102.430125258445*x_2 + 730.274693518897*x_20 + 2524.48332850706*x_21 + 308.234213479029*x_22 + 93.6027766735018*x_23 + 471.705270857764*x_24 + 962.372395726508*x_25 + 412.387517279838*x_26 + 496.236274200779*x_27 + 4.56663059673362*x_28 + 389.856627730413*x_29 - 749.25583793801*x_3 - 2139.90574863139*x_30 + 38737.1744361616*x_31 - 32.0220619170587*x_32 + 109.815954099182*x_33 + 167.960189453451*x_34 - 539.185398339724*x_35 - 3.02408668773634*x_36 - 4198.96318760978*x_37 + 381.822251073244*x_38 - 465.838566736895*x_39 - 92.3067056584477*x_4 - 241.903480120243*x_40 + 36.2838445426425*x_41 + 572128.87117871*x_42 + 804.973846525048*x_43 + 972.534438184128*x_44 - 8.53451548775203*x_45 - 402.176543629273*x_46 + 3286.89384596117*x_47 + 1505.30593862584*x_48 + 327.019426462695*x_49 + 199.570738238907*x_5 - 3366.97503618156*x_50 - 366.12243986675*x_51 - 93.942631405132*x_52 + 0.563165235445313*x_53 + 1132.12083320991*x_54 - 29.8632345153746*x_55 + 210.312308411566*x_56 + 9427.17110875403*x_57 + 461.42504007522*x_58 + 355.942819930465*x_59 - 147.364924667736*x_6 + 508.49182529018*x_60 + 191.366026625014*x_61 + 40.2782914415779*x_62 - 64.4579199663217*x_63 - 263.439274195564*x_64 + 23.3488263640032*x_65 - 190.884663861002*x_66 - 384.788452418549*x_67 + 716.635351116681*x_68 - 3.19944747751894*x_69 - 91.1345799944255*x_7 + 279.792966790911*x_70 - 281.886329875434*x_72 - 162.409830049335*x_73 + 1052.9000199797*x_74 - 419.29378436556*x_75 + 215.637845960005*x_76 + 0.889778319984208*x_77 - 33.2979334231286*x_78 + 160.650507071814*x_79 + 2021.50601228572*x_8 - 149.008227292379*x_80 + 120.901587582236*x_81 - 523.702157578424*x_82 - 314.623010449588*x_83 - 838.373941538313*x_84 - 852.184306280503*x_85 + 440.615971402242*x_86 + 40.4993063473114*x_87 - 549.481285709556*x_88 - 0.210670423466272*x_89 - 126.706639672175*x_9 - 483.33432525915*x_90 + 871.426051949851*x_91 - 264.760015864735*x_92 - 812.094008503048*x_93 + 75.0434507736062*x_94 - 4.33439607109564*x_95 + 342.254491961701*x_96 + 2032.10428118383*x_97 - 256.383458157626*x_98 + 110.907801172553*x_99 - 2.30059536998493*std::pow(-6.09583950042725*x_77 - 9.12215995788574, 2) + 0.296092175876121*std::exp(0.830399870872498*x_50) - 0.0294291377791259*std::exp(2.49247980117798*x_71) + 7.48193777723855*std::exp(2.52639985084534*x_71) - 0.0259468077967804*std::exp(2.59511995315552*x_71) + 0.163105229836898*std::exp(2.64567995071411*x_71) + 0.00041145374670855*std::exp(2.73368000984192*x_71) + 0.739180302686222*std::exp(1.85903990268707*x_89) - 25.8168972026358*std::exp(1.88391983509064*x_89) + 11.3566394952156*std::sin(0.200719982385635*x_107 + 1.78663992881775) + 18.4846537937294*std::sin(0.119360059499741*x_108 + 1.71591985225677) + 1.530690496967*std::sin(0.386799842119217*x_11 - 7.41039991378784) + 6429.34826528951*std::sin(0.22639998793602*x_115 + 5.03599977493286) - 0.953967680562861*std::sin(0.599919855594635*x_14 - 4.00559997558594) - 0.0721975416057163*std::sin(0.429279863834381*x_24 + 2.03871965408325) - 1.79416116219768*std::sin(0.322639852762222*x_26 - 4.27967977523804) + 3168.37855850388*std::sin(0.319519847631454*x_28 - 4.29392004013062) + 5.21848820173101*std::sin(0.335359841585159*x_28 - 4.26592016220093) - 3245.46767104891*std::sin(0.362799853086472*x_36 + 5.17072010040283) + 1.48335800724808*std::sin(0.467839866876602*x_45 + 5.23816013336182) - 3973.34106029857*std::sin(0.328719854354858*x_53 - 4.28424024581909) - 5.87899654227999*std::sin(0.372079849243164*x_53 - 4.23120021820068) - 1.23172795943438*std::sin(0.418559849262238*x_66 + 2.02839994430542) + 0.20946466480657*std::sin(0.283759921789169*x_75 + 1.88519990444183) - 2.89759658398889*std::sin(0.367359846830368*x_75 + 1.98055982589722) - 1.63124690199173*std::sin(0.395039826631546*x_80 + 2.00567984580994) + 2.22955067179334*std::sin(0.424879848957062*x_80 - 4.18488025665283) - 0.0097899433029941*std::sin(0.589679837226868*x_80 + 5.40136003494263) - 0.0256495592542351*std::sin(0.639519810676575*x_86 - 0.96319979429245) + 0.0941788313320859*std::sin(0.377279847860336*x_87 + 5.17512035369873) - 20.9754630860384*std::sin(0.413919866085052*x_92 - 4.38631963729858) + 1.53696932199239*std::sin(0.378879845142365*x_95 - 7.4159197807312) - 1486.94405455095*std::sin(0.383839845657349*x_95 + 5.18136024475098) + 3.33599291578009*std::sin(0.372159838676453*x_96 + 5.18296003341675) + 0.0438223785926851*std::sin(0.411359876394272*x_96 - 7.37935972213745) + 133994.108855241 - 5.31690536171737e-6*std::exp(-4.69999980926514*x_111));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (15866.5140723641*x_1 - 444.962163985837*x_10 - 108.868024830921*x_100 + 973.906759347195*x_101 - 33.5317271965406*x_102 - 72.364018755496*x_103 - 459.177635261485*x_104 + 120.858081681558*x_105 + 63.261975409702*x_106 - 375.85243005766*x_107 + 257.263663857917*x_108 + 456.360594983442*x_109 + 77.7498742853268*x_11 + 290.473411207023*x_110 + 62.8840577152779*x_111 - 343.167000297575*x_112 + 837.391852591712*x_113 - 160.824200043352*x_114 - 12.2291597559723*x_115 + 2072.01591410987*x_116 - 196.191176886907*x_117 + 88.8566507705623*x_118 - 298.080523802426*x_119 - 2363.40188081636*x_12 - 198.48358400856*x_120 + 821.243491177855*x_13 - 223.751134899793*x_14 + 171.011502501766*x_15 - 117.582350026961*x_16 - 446.396788669887*x_17 - 9.03219581031722*x_18 + 80.7516895903896*x_19 - 83.3523832975757*x_2 + 573.150946027096*x_20 + 1792.06166992799*x_21 + 251.220800994905*x_22 + 67.83664097478*x_23 + 355.507450161903*x_24 + 690.976635978477*x_25 + 283.047026574796*x_26 + 364.793108889643*x_27 + 4.5964543327517*x_28 + 278.309637583558*x_29 - 564.266809897218*x_3 - 1456.98561904116*x_30 + 28189.7266069053*x_31 - 36.8465261997204*x_32 + 70.5608558275676*x_33 + 95.4203380233626*x_34 - 401.288270048474*x_35 + 1.12380324023651*x_36 - 3120.6744710163*x_37 + 292.83740051759*x_38 - 342.541545361827*x_39 - 60.5136215841926*x_4 - 181.757440055791*x_40 + 37.2182047755208*x_41 + 400748.228780274*x_42 + 568.409757124262*x_43 + 745.217561453333*x_44 + 8.56831606571034*x_45 - 301.854833924242*x_46 + 2293.51709271314*x_47 + 1074.50136659609*x_48 + 229.733959458685*x_49 + 133.687994715102*x_5 - 2508.65083356522*x_50 - 293.237989348582*x_51 - 88.2386173737276*x_52 + 11.2426097655657*x_53 + 849.188288903654*x_54 - 23.8979280382289*x_55 + 141.518200689962*x_56 + 6652.49825886465*x_57 + 314.379346780597*x_58 + 241.735359439933*x_59 - 108.134199307508*x_6 + 365.620564350658*x_60 + 139.42916686441*x_61 + 30.0355701314282*x_62 - 78.2740647050902*x_63 - 203.060046521858*x_64 + 26.7755602631278*x_65 - 140.765271355594*x_66 - 280.889976410258*x_67 + 509.578953510409*x_68 - 16.2369423271615*x_69 - 63.2210040023643*x_7 + 193.579809397122*x_70 - 204.744415074065*x_72 - 98.996084940659*x_73 + 762.823612471545*x_74 - 300.207630259093*x_75 + 160.162767980974*x_76 - 7.78078091115858*x_77 - 30.0990693911274*x_78 + 119.416331258667*x_79 + 1376.85514091508*x_8 - 108.027549649574*x_80 + 71.0005211250123*x_81 - 369.827284888659*x_82 - 243.123552917378*x_83 - 574.511557352045*x_84 - 625.459829431832*x_85 + 332.714174357493*x_86 + 36.0465438021406*x_87 - 390.103196895853*x_88 - 1.29337704163231*x_89 - 42.4971424076823*x_9 - 378.436771907733*x_90 + 622.577335423436*x_91 - 191.642514092264*x_92 - 576.063581101485*x_93 + 69.1368058839966*x_94 + 2.99444798002036*x_95 + 247.188219979004*x_96 + 1420.84693408893*x_97 - 196.734075806771*x_98 + 62.3978592651444*x_99 - 1.66565901080943*std::pow(-6.09583950042725*x_77 - 9.12215995788574, 2) + 1.6061350506112*std::exp(0.830399870872498*x_50) - 0.159636672453297*std::exp(2.49247980117798*x_71) + 5.41701389108442*std::exp(2.52639985084534*x_71) - 0.626024301562286*std::exp(2.59511995315552*x_71) + 0.124175469999734*std::exp(2.64567995071411*x_71) - 0.00204410732410971*std::exp(2.73368000984192*x_71) + 0.562753638202734*std::exp(1.85903990268707*x_89) - 18.6917473701569*std::exp(1.88391983509064*x_89) + 274.004122733326*std::sin(0.200719982385635*x_107 + 1.78663992881775) + 100.268945873609*std::sin(0.119360059499741*x_108 + 1.71591985225677) + 8.30314293696419*std::sin(0.386799842119217*x_11 - 7.41039991378784) + 4654.92629057216*std::sin(0.22639998793602*x_115 + 5.03599977493286) - 5.17474304874344*std::sin(0.599919855594635*x_14 - 4.00559997558594) + 0.358678283426829*std::sin(0.429279863834381*x_24 + 2.03871965408325) - 9.73232447133845*std::sin(0.322639852762222*x_26 - 4.27967977523804) + 2293.94458690141*std::sin(0.319519847631454*x_28 - 4.29392004013062) + 125.907605177738*std::sin(0.335359841585159*x_28 - 4.26592016220093) - 2349.75804137549*std::sin(0.362799853086472*x_36 + 5.17072010040283) + 8.04639055725236*std::sin(0.467839866876602*x_45 + 5.23816013336182) - 2876.74722224133*std::sin(0.328719854354858*x_53 - 4.28424024581909) - 4.47580472738025*std::sin(0.372079849243164*x_53 - 4.23120021820068) - 6.68143777393515*std::sin(0.418559849262238*x_66 + 2.02839994430542) - 1.04062305641509*std::sin(0.283759921789169*x_75 + 1.88519990444183) - 15.7178467222415*std::sin(0.367359846830368*x_75 + 1.98055982589722) - 8.84860539707745*std::sin(0.395039826631546*x_80 + 2.00567984580994) + 53.7928562557259*std::sin(0.424879848957062*x_80 - 4.18488025665283) + 0.0486365599252742*std::sin(0.589679837226868*x_80 + 5.40136003494263) + 0.127427328955414*std::sin(0.639519810676575*x_86 - 0.96319979429245) - 0.467881603806061*std::sin(0.377279847860336*x_87 + 5.17512035369873) - 15.9690648164715*std::sin(0.413919866085052*x_92 - 4.38631963729858) + 8.33720206372122*std::sin(0.378879845142365*x_95 - 7.4159197807312) - 1076.56556878515*std::sin(0.383839845657349*x_95 + 5.18136024475098) + 80.4882300541459*std::sin(0.372159838676453*x_96 + 5.18296003341675) - 0.217710121144352*std::sin(0.411359876394272*x_96 - 7.37935972213745) + 97232.59297824 + 2.64144518756397e-5*std::exp(-4.69999980926514*x_111));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-14139.0793304668*x_1 + 375.803410356971*x_10 + 75.3482698875462*x_100 - 758.187298310671*x_101 + 14.1928376286277*x_102 + 62.3578589492276*x_103 + 351.440917888513*x_104 - 111.324991837215*x_105 - 30.8429287873055*x_106 + 321.880575778956*x_107 - 261.991550535417*x_108 - 375.588917155486*x_109 - 83.4365259211471*x_11 - 233.127412642212*x_110 - 49.6390089721189*x_111 + 325.014221669404*x_112 - 798.542955578396*x_113 + 150.439363773835*x_114 - 4.84832850999063*x_115 - 1910.28789987024*x_116 + 181.758668356274*x_117 - 86.5410517411482*x_118 + 258.613611176852*x_119 + 2026.15964576744*x_12 + 162.96819161952*x_120 - 709.827403140799*x_13 + 198.864313061502*x_14 - 155.72850786336*x_15 + 96.6845275327518*x_16 + 369.243090350427*x_17 + 0.396878379686416*x_18 - 63.4080820444766*x_19 + 58.3625466947873*x_2 - 435.277464913766*x_20 - 1596.42295845598*x_21 - 177.960085512048*x_22 - 55.5657843845835*x_23 - 292.378013644237*x_24 - 617.984194732134*x_25 - 265.806719015327*x_26 - 309.029851214361*x_27 + 2.74785351712867*x_28 - 250.450197761196*x_29 + 464.422411499054*x_3 + 1368.64467214741*x_30 - 24366.5862700439*x_31 + 20.4230007606022*x_32 - 76.0221386202373*x_33 - 118.18926781347*x_34 + 342.941764294729*x_35 + 1.28515344903822*x_36 + 2579.50251428065*x_37 - 225.469682114366*x_38 + 291.829764249974*x_39 + 61.6576623487199*x_4 + 149.223523353993*x_40 - 21.8553097205777*x_41 - 366556.746669064*x_42 - 522.064016628363*x_43 - 583.392200910382*x_44 + 9.9755182288176*x_45 + 252.141089522722*x_46 - 2126.38200172083*x_47 - 969.14990944217*x_48 - 203.092500306722*x_49 - 129.563150014327*x_5 + 2143.2748237898*x_50 + 222.492618049836*x_51 + 40.0453883928444*x_52 + 4.88018904347871*x_53 - 719.233193601715*x_54 + 16.6748103674856*x_55 - 137.07684729242*x_56 - 6121.26299429033*x_57 - 302.152017315582*x_58 - 232.136842521965*x_59 + 92.4439600669373*x_6 - 330.49487914893*x_60 - 124.723186596949*x_61 - 20.8922934261007*x_62 + 23.8940411167044*x_63 + 162.618420726433*x_64 - 14.8328830667918*x_65 + 118.884775550425*x_66 + 238.089073702044*x_67 - 463.2730708372*x_68 - 5.06140595328563*x_69 + 57.0663957349231*x_7 - 173.768382683984*x_70 + 179.938917309267*x_72 + 108.814629077005*x_73 - 666.46827096216*x_74 + 263.043482063546*x_75 - 117.47194096651*x_76 - 2.71932807491398*x_77 + 14.3386424152882*x_78 - 96.9398468844201*x_79 - 1324.1481913365*x_8 + 90.9548179631866*x_80 - 84.2163840622128*x_81 + 339.280697043597*x_82 + 192.25767458072*x_83 + 576.247474258309*x_84 + 542.273945438021*x_85 - 273.399846481781*x_86 - 19.5759636699047*x_87 + 360.751871006682*x_88 - 1.16369214095246*x_89 + 56.2551849784238*x_9 + 285.471271357629*x_90 - 564.639037379647*x_91 + 168.082742118811*x_92 + 523.772189679874*x_93 - 34.0488643379751*x_94 + 1.28472532364159*x_95 - 219.362643777987*x_96 - 1304.6228072428*x_97 + 157.259274247149*x_98 - 72.4355930547548*x_99 + 1.46108246442802*std::pow(-6.09583950042725*x_77 - 9.12215995788574, 2) + 1.78814874745467*std::exp(0.830399870872498*x_50) - 0.177727343529779*std::exp(2.49247980117798*x_71) - 4.75169524762472*std::exp(2.52639985084534*x_71) - 0.256371926000039*std::exp(2.59511995315552*x_71) + 0.0521054572067806*std::exp(2.64567995071411*x_71) - 0.0067307756384735*std::exp(2.73368000984192*x_71) + 0.236137907216259*std::exp(1.85903990268707*x_89) + 16.3960235167121*std::exp(1.88391983509064*x_89) + 112.211242441848*std::sin(0.200719982385635*x_107 + 1.78663992881775) + 111.631826915343*std::sin(0.119360059499741*x_108 + 1.71591985225677) + 9.24408855719801*std::sin(0.386799842119217*x_11 - 7.41039991378784) - 4083.20738651958*std::sin(0.22639998793602*x_115 + 5.03599977493286) - 5.76116578583423*std::sin(0.599919855594635*x_14 - 4.00559997558594) + 1.18104515534196*std::sin(0.429279863834381*x_24 + 2.03871965408325) - 10.8352307028128*std::sin(0.322639852762222*x_26 - 4.27967977523804) - 2012.20189038721*std::sin(0.319519847631454*x_28 - 4.29392004013062) + 51.5621760320078*std::sin(0.335359841585159*x_28 - 4.26592016220093) + 2061.16032610666*std::sin(0.362799853086472*x_36 + 5.17072010040283) + 8.95823996307574*std::sin(0.467839866876602*x_45 + 5.23816013336182) + 2523.42459875163*std::sin(0.328719854354858*x_53 - 4.28424024581909) - 1.87809920662203*std::sin(0.372079849243164*x_53 - 4.23120021820068) - 7.43860522943697*std::sin(0.418559849262238*x_66 + 2.02839994430542) - 3.42653256721888*std::sin(0.283759921789169*x_75 + 1.88519990444183) - 17.4990564575284*std::sin(0.367359846830368*x_75 + 1.98055982589722) - 9.8513650215675*std::sin(0.395039826631546*x_80 + 2.00567984580994) + 22.0294613626139*std::sin(0.424879848957062*x_80 - 4.18488025665283) + 0.160149014106572*std::sin(0.589679837226868*x_80 + 5.40136003494263) + 0.419588908709774*std::sin(0.639519810676575*x_86 - 0.96319979429245) - 1.54062659207943*std::sin(0.377279847860336*x_87 + 5.17512035369873) - 6.70080349547894*std::sin(0.413919866085052*x_92 - 4.38631963729858) + 9.28200740146134*std::sin(0.378879845142365*x_95 - 7.4159197807312) + 944.341587414449*std::sin(0.383839845657349*x_95 + 5.18136024475098) + 32.9618554867915*std::sin(0.372159838676453*x_96 + 5.18296003341675) - 0.716869394460852*std::sin(0.411359876394272*x_96 - 7.37935972213745) - 94671.5432976929 + 8.69767194174214e-5*std::exp(-4.69999980926514*x_111));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-2105.70053077026*x_1 + 99.3661128055263*x_10 + 52.8092072872543*x_100 - 319.900530711645*x_101 + 22.6664009676066*x_102 + 0.498879794309766*x_103 + 105.543288644713*x_104 - 33.4445524693764*x_105 - 46.2382960491961*x_106 + 53.2737160210862*x_107 + 48.0021839783738*x_108 - 143.686094722083*x_109 + 9.14409080268345*x_11 - 99.8922146076401*x_110 - 48.8477221971165*x_111 + 28.153641431264*x_112 - 36.8461128616521*x_113 - 8.54546421337358*x_114 + 18.2786206354845*x_115 - 235.158101301666*x_116 + 32.2326695051472*x_117 + 8.13900134160868*x_118 + 56.9596633375083*x_119 + 315.750589442599*x_12 + 47.2456212941466*x_120 - 157.407929559543*x_13 + 28.5490350830109*x_14 + 1.50851234781733*x_15 + 54.9183577931707*x_16 + 110.220185853229*x_17 + 20.7760976144917*x_18 - 34.7497121198417*x_19 + 34.2301460114903*x_2 - 204.036465101979*x_20 - 156.83850500453*x_21 - 107.829804479066*x_22 + 0.215715683230325*x_23 - 98.2948881180423*x_24 - 113.229075793815*x_25 - 3.67780251924268*x_26 - 72.6035111987401*x_27 + 9.37431288477926*x_28 - 36.6619636822625*x_29 + 161.11523494743*x_3 - 27.9090861301869*x_30 - 4856.55339954307*x_31 + 60.6557403011761*x_32 - 0.212863910760274*x_33 + 41.9035692650379*x_34 + 114.573768285075*x_35 - 10.9976127310319*x_36 + 632.031668297998*x_37 - 73.0208387438885*x_38 + 76.2798791094507*x_39 + 0.00915195265459667*x_4 + 41.0127415483468*x_40 - 38.6412482650127*x_41 - 29470.1868445444*x_42 - 76.0142025112004*x_43 - 198.7072903787*x_44 - 42.7413896738328*x_45 + 84.0031675619697*x_46 - 159.345875094518*x_47 - 190.584287547307*x_48 + 5.78190126135158*x_49 + 10.9920560951418*x_5 + 689.73396275593*x_50 + 127.027755695257*x_51 + 43.2775915080215*x_52 - 27.2234129824745*x_53 - 248.61236776359*x_54 + 5.77734163956977*x_55 + 7.37225201597885*x_56 - 843.017020950569*x_57 - 12.5712974804651*x_58 - 3.52684621448813*x_59 + 18.7479096037379*x_6 - 79.0100259109424*x_60 - 33.4351929036643*x_61 - 2.01697016954319*x_62 + 91.4408542211366*x_63 + 70.7274020795564*x_64 - 43.4722969139846*x_65 + 28.2771911328145*x_66 + 39.0397095063796*x_67 - 74.0536379055462*x_68 + 31.5531006178356*x_69 + 2.2726491195754*x_7 + 18.9214560872056*x_70 + 46.5467426429989*x_72 - 41.3045665864872*x_73 - 133.169228706928*x_74 + 33.7065273353836*x_75 + 7.60222409633743*x_76 + 27.323087380258*x_77 + 8.11317131623013*x_78 - 20.2242657183247*x_79 - 1.55002128524132*x_8 + 11.5850354786571*x_80 + 25.1925875154059*x_81 + 44.5228479949407*x_82 + 78.6558736413611*x_83 + 93.7613471412871*x_84 + 140.474828984266*x_85 - 90.0699150872709*x_86 - 15.7486366749329*x_87 + 76.1294009159134*x_88 - 0.740660326875597*x_89 - 193.631773738865*x_9 + 121.585096159026*x_90 - 96.1122027375791*x_91 + 32.3989983934882*x_92 + 68.9846527382566*x_93 - 32.1625187537728*x_94 - 24.6780496812958*x_95 - 46.3313976316993*x_96 - 97.1636542726999*x_97 + 66.5881320929645*x_98 + 48.8747964797993*x_99 + 0.288869231381693*std::pow(-6.09583950042725*x_77 - 9.12215995788574, 2) + 2.50583618120331*std::exp(0.830399870872498*x_50) - 0.249059597776755*std::exp(2.49247980117798*x_71) - 0.939453170754973*std::exp(2.52639985084534*x_71) + 1.63625389922244*std::exp(2.59511995315552*x_71) + 0.281066253950366*std::exp(2.64567995071411*x_71) - 0.00802982773320287*std::exp(2.73368000984192*x_71) + 1.27377055216236*std::exp(1.85903990268707*x_89) + 3.24164229350528*std::exp(1.88391983509064*x_89) - 716.170782997666*std::sin(0.200719982385635*x_107 + 1.78663992881775) + 156.436130526877*std::sin(0.119360059499741*x_108 + 1.71591985225677) + 12.9542755332*std::sin(0.386799842119217*x_11 - 7.41039991378784) - 807.287068343343*std::sin(0.22639998793602*x_115 + 5.03599977493286) - 8.07345456724648*std::sin(0.599919855594635*x_14 - 4.00559997558594) + 1.40898904553006*std::sin(0.429279863834381*x_24 + 2.03871965408325) - 15.1840349777622*std::sin(0.322639852762222*x_26 - 4.27967977523804) - 397.830531549425*std::sin(0.319519847631454*x_28 - 4.29392004013062) - 329.087560019164*std::sin(0.335359841585159*x_28 - 4.26592016220093) + 407.510057544875*std::sin(0.362799853086472*x_36 + 5.17072010040283) + 12.5536993783822*std::sin(0.467839866876602*x_45 + 5.23816013336182) + 498.903889436797*std::sin(0.328719854354858*x_53 - 4.28424024581909) - 10.1308065766999*std::sin(0.372079849243164*x_53 - 4.23120021820068) - 10.4241474028065*std::sin(0.418559849262238*x_66 + 2.02839994430542) - 4.08785966355835*std::sin(0.283759921789169*x_75 + 1.88519990444183) - 24.5224391262817*std::sin(0.367359846830368*x_75 + 1.98055982589722) - 13.805287138681*std::sin(0.395039826631546*x_80 + 2.00567984580994) - 140.599607042549*std::sin(0.424879848957062*x_80 - 4.18488025665283) + 0.191058068785918*std::sin(0.589679837226868*x_80 + 5.40136003494263) + 0.500570340874739*std::sin(0.639519810676575*x_86 - 0.96319979429245) - 1.83797036182221*std::sin(0.377279847860336*x_87 + 5.17512035369873) - 36.1453451882713*std::sin(0.413919866085052*x_92 - 4.38631963729858) + 13.0074134010869*std::sin(0.378879845142365*x_95 - 7.4159197807312) + 186.704881592683*std::sin(0.383839845657349*x_95 + 5.18136024475098) - 210.373910308186*std::sin(0.372159838676453*x_96 + 5.18296003341675) - 0.855226507896436*std::sin(0.411359876394272*x_96 - 7.37935972213745) - 44539.9352627497 + 0.000103763386455623*std::exp(-4.69999980926514*x_111));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (18062.802861145*x_1 - 473.407482030417*x_10 - 80.8423122398524*x_100 + 907.350972478761*x_101 - 12.3804741838928*x_102 - 82.1960986649913*x_103 - 440.119415500668*x_104 + 128.858360767317*x_105 + 26.9637063818762*x_106 - 411.23072245399*x_107 + 357.536638127621*x_108 + 457.920163013205*x_109 + 114.093690540227*x_11 + 285.822922868527*x_110 + 47.5922790380272*x_111 - 424.325997274716*x_112 + 1049.25755265828*x_113 - 206.929359704293*x_114 + 13.5845608466886*x_115 + 2484.92538983726*x_116 - 226.473269595767*x_117 + 119.642871769406*x_118 - 320.864831473287*x_119 - 2600.45225296051*x_12 - 209.696347872059*x_120 + 894.774769351044*x_13 - 254.558772026636*x_14 + 209.82786569458*x_15 - 113.036032541477*x_16 - 463.023887158749*x_17 + 0.780121551863378*x_18 + 76.8522261397964*x_19 - 64.1031740078323*x_2 + 502.48727968226*x_20 + 2074.84458579623*x_21 + 197.557198031504*x_22 + 76.0800029056473*x_23 + 355.247539681916*x_24 + 789.353783370102*x_25 + 349.526681961963*x_26 + 383.57009955377*x_27 - 0.638067952615879*x_28 + 325.971077448036*x_29 - 556.03557284311*x_3 - 1786.79837071431*x_30 + 30842.9699020685*x_31 - 5.58832008042618*x_32 + 95.834050525846*x_33 + 160.142281443786*x_34 - 417.938941498801*x_35 - 1.60456870993683*x_36 - 3215.53304089155*x_37 + 271.920174460695*x_38 - 356.726333484039*x_39 - 76.5580788907724*x_4 - 189.428548801697*x_40 + 23.1731160205306*x_41 + 476011.806056573*x_42 + 667.5301167473*x_43 + 709.349400997672*x_44 - 24.1300700629741*x_45 - 308.952672858339*x_46 + 2794.57474373114*x_47 + 1201.87116259107*x_48 + 278.896522560361*x_49 + 176.65436250853*x_5 - 2661.66249341535*x_50 - 259.939735609445*x_51 - 35.8433933025946*x_52 - 13.2909630696291*x_53 + 889.451130526249*x_54 - 21.3231921332816*x_55 + 185.331005675323*x_56 + 7892.68676846461*x_57 + 389.431319443452*x_58 + 301.889262939387*x_59 - 119.573014879284*x_6 + 409.553567006*x_60 + 157.926495050921*x_61 + 21.1823069812665*x_62 + 0.347560195212558*x_63 - 192.765040295399*x_64 + 4.44732198807104*x_65 - 149.008257530962*x_66 - 306.288717878165*x_67 + 594.047246485425*x_68 + 11.5570547521488*x_69 - 71.2445858447573*x_7 + 245.366056493977*x_70 - 218.384393721478*x_72 - 161.214032563351*x_73 + 840.211216248914*x_74 - 336.431762896366*x_75 + 157.881988517517*x_76 + 12.0618551313629*x_77 - 18.3496202375365*x_78 + 121.370016072872*x_79 + 1777.8827679562*x_8 - 115.328972097728*x_80 + 114.707716892526*x_81 - 439.588703077055*x_82 - 232.465846014675*x_83 - 736.989551571448*x_84 - 680.146278676098*x_85 + 337.878852686504*x_86 + 20.7607236630461*x_87 - 449.164063662502*x_88 - 0.508752048909857*x_89 - 86.1562754874041*x_9 - 336.44684188158*x_90 + 731.592972098122*x_91 - 213.866825809787*x_92 - 682.272440558967*x_93 + 34.9808812151494*x_94 - 6.50878174777478*x_95 + 276.821126580109*x_96 + 1701.36643671711*x_97 - 183.005113934969*x_98 + 108.975998263955*x_99 - 1.85321338821722*std::pow(-6.09583950042725*x_77 - 9.12215995788574, 2) + 1.27100029137244*std::exp(0.830399870872498*x_50) - 0.126327021581813*std::exp(2.49247980117798*x_71) + 6.02697346934045*std::exp(2.52639985084534*x_71) + 0.810208181520272*std::exp(2.59511995315552*x_71) - 0.0676408313629833*std::exp(2.64567995071411*x_71) + 0.00334007823356195*std::exp(2.73368000984192*x_71) - 0.306543022874468*std::exp(1.85903990268707*x_89) - 20.7964512848975*std::exp(1.88391983509064*x_89) - 354.619431633578*std::sin(0.200719982385635*x_107 + 1.78663992881775) + 79.3469138055782*std::sin(0.119360059499741*x_108 + 1.71591985225677) + 6.57061626802339*std::sin(0.386799842119217*x_11 - 7.41039991378784) + 5179.07426842457*std::sin(0.22639998793602*x_115 + 5.03599977493286) - 4.094985611719*std::sin(0.599919855594635*x_14 - 4.00559997558594) - 0.586081519886486*std::sin(0.429279863834381*x_24 + 2.03871965408325) - 7.70158601177099*std::sin(0.322639852762222*x_26 - 4.27967977523804) + 2552.24436255308*std::sin(0.319519847631454*x_28 - 4.29392004013062) - 162.95113716201*std::sin(0.335359841585159*x_28 - 4.26592016220093) - 2614.3424512992*std::sin(0.362799853086472*x_36 + 5.17072010040283) + 6.36743761919176*std::sin(0.467839866876602*x_45 + 5.23816013336182) - 3200.67098498366*std::sin(0.328719854354858*x_53 - 4.28424024581909) + 2.438059246154*std::sin(0.372079849243164*x_53 - 4.23120021820068) - 5.2872947105082*std::sin(0.418559849262238*x_66 + 2.02839994430542) + 1.70038156953848*std::sin(0.283759921789169*x_75 + 1.88519990444183) - 12.4381743341658*std::sin(0.367359846830368*x_75 + 1.98055982589722) - 7.00226300001697*std::sin(0.395039826631546*x_80 + 2.00567984580994) - 69.6193616397441*std::sin(0.424879848957062*x_80 - 4.18488025665283) - 0.0794723022835866*std::sin(0.589679837226868*x_80 + 5.40136003494263) - 0.208216683529712*std::sin(0.639519810676575*x_86 - 0.96319979429245) + 0.764520112189965*std::sin(0.377279847860336*x_87 + 5.17512035369873) + 8.69866504453583*std::sin(0.413919866085052*x_92 - 4.38631963729858) + 6.59756864666403*std::sin(0.378879845142365*x_95 - 7.4159197807312) - 1197.78760984026*std::sin(0.383839845657349*x_95 + 5.18136024475098) - 104.168835527971*std::sin(0.372159838676453*x_96 + 5.18296003341675) + 0.355739069217952*std::sin(0.411359876394272*x_96 - 7.37935972213745) + 111987.782582498 - 4.31613030884863e-5*std::exp(-4.69999980926514*x_111));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-7047.08283940502*x_1 + 177.085991015588*x_10 + 33.7779273847742*x_100 - 352.640395845946*x_101 + 6.53048525297254*x_102 + 34.9813814562591*x_103 + 177.338907270969*x_104 - 52.3191779415741*x_105 - 12.3954299410996*x_106 + 163.036224944635*x_107 - 147.388839182129*x_108 - 166.799707243932*x_109 - 42.1383584156083*x_11 - 100.491414300649*x_110 - 14.6798015533259*x_111 + 157.970771744483*x_112 - 399.095321760501*x_113 + 79.162305923646*x_114 - 1.29503140702393*x_115 - 921.163213768527*x_116 + 87.3462849366632*x_117 - 45.596468034425*x_118 + 127.02273702851*x_119 + 1027.57819990517*x_12 + 74.5750708784711*x_120 - 341.61472217744*x_13 + 99.1594974521162*x_14 - 82.6717634645914*x_15 + 36.5939330361942*x_16 + 172.676748683098*x_17 - 6.19470747657394*x_18 - 24.4392026146744*x_19 + 28.6425781750795*x_2 - 207.144451831527*x_20 - 812.930883513458*x_21 - 83.5149484532979*x_22 - 31.5966920644805*x_23 - 137.859661285871*x_24 - 294.857923576112*x_25 - 138.863761015266*x_26 - 153.020241418115*x_27 - 4.69664461174814*x_28 - 120.228652793737*x_29 + 220.766571112229*x_3 + 747.098688429789*x_30 - 11950.1610263162*x_31 - 2.96747698352092*x_32 - 38.1956994035652*x_33 - 69.0324841926805*x_34 + 155.311364121402*x_35 + 5.09736728356563*x_36 + 1285.56975978475*x_37 - 117.006910778689*x_38 + 143.011971900467*x_39 + 32.9181637385619*x_4 + 70.5036155222504*x_40 - 0.609225143405447*x_41 - 186474.645955138*x_42 - 252.786845767775*x_43 - 289.044281336094*x_44 + 13.2852515727726*x_45 + 115.671221662361*x_46 - 1056.22355522934*x_47 - 471.993435517275*x_48 - 109.231785560898*x_49 - 69.1332541998612*x_5 + 956.341582254986*x_50 + 93.0028434965209*x_51 + 25.5931197053619*x_52 + 6.43325792304731*x_53 - 316.272297676498*x_54 + 8.73236410632213*x_55 - 71.9551355063311*x_56 - 2948.70259798967*x_57 - 154.548276912628*x_58 - 120.942180981198*x_59 + 44.3378293279948*x_6 - 153.247611678429*x_60 - 54.7129947974203*x_61 - 16.5782311965208*x_62 + 4.48308430476736*x_63 + 73.14309918234*x_64 + 2.13318190704297*x_65 + 58.3332604160214*x_66 + 120.75213687297*x_67 - 222.22201308851*x_68 - 7.7259506733921*x_69 + 32.0348697531224*x_7 - 96.0217743202589*x_70 + 86.0918070950273*x_72 + 62.7056586326691*x_73 - 325.886790713465*x_74 + 135.249886789328*x_75 - 78.6001061895854*x_76 - 6.65175741984566*x_77 + 9.81462837514109*x_78 - 50.7753836013775*x_79 - 667.845853575483*x_8 + 49.0637878527964*x_80 - 48.1681494824375*x_81 + 164.08691029392*x_82 + 87.6151040464099*x_83 + 254.241962846632*x_84 + 251.981025173532*x_85 - 126.897627946163*x_86 - 11.1062569488504*x_87 + 167.236353672602*x_88 - 0.4244273706733*x_89 + 116.279633319932*x_9 + 139.747244246472*x_90 - 265.120690919673*x_91 + 81.1189984345333*x_92 + 252.335881318571*x_93 - 20.0806372465361*x_94 + 8.95723771429592*x_95 - 104.097388245537*x_96 - 661.890701835301*x_97 + 73.6579243926977*x_98 - 49.9675972709609*x_99 + 0.706282636332043*std::pow(-6.09583950042725*x_77 - 9.12215995788574, 2) + 0.184913722385669*std::exp(0.830399870872498*x_50) - 0.018378909868985*std::exp(2.49247980117798*x_71) - 2.29695443497957*std::exp(2.52639985084534*x_71) - 0.360643997368691*std::exp(2.59511995315552*x_71) - 0.190512901744878*std::exp(2.64567995071411*x_71) + 0.0083349274482531*std::exp(2.73368000984192*x_71) - 0.863389754689227*std::exp(1.85903990268707*x_89) + 7.92578584486605*std::exp(1.88391983509064*x_89) + 157.850009770294*std::sin(0.200719982385635*x_107 + 1.78663992881775) + 11.5439259071774*std::sin(0.119360059499741*x_108 + 1.71591985225677) + 0.955937713575241*std::sin(0.386799842119217*x_11 - 7.41039991378784) - 1973.80951989626*std::sin(0.22639998793602*x_115 + 5.03599977493286) - 0.595766214782737*std::sin(0.599919855594635*x_14 - 4.00559997558594) - 1.46252470913124*std::sin(0.429279863834381*x_24 + 2.03871965408325) - 1.12047884440072*std::sin(0.322639852762222*x_26 - 4.27967977523804) - 972.69202154949*std::sin(0.319519847631454*x_28 - 4.29392004013062) + 72.5336411335792*std::sin(0.335359841585159*x_28 - 4.26592016220093) + 996.358374334143*std::sin(0.362799853086472*x_36 + 5.17072010040283) + 0.926377908971122*std::sin(0.467839866876602*x_45 + 5.23816013336182) + 1219.815459827*std::sin(0.328719854354858*x_53 - 4.28424024581909) + 6.86688398488429*std::sin(0.372079849243164*x_53 - 4.23120021820068) - 0.769231410021475*std::sin(0.418559849262238*x_66 + 2.02839994430542) + 4.24318115487252*std::sin(0.283759921789169*x_75 + 1.88519990444183) - 1.80958976282289*std::sin(0.367359846830368*x_75 + 1.98055982589722) - 1.0187366008063*std::sin(0.395039826631546*x_80 + 2.00567984580994) + 30.9893252730448*std::sin(0.424879848957062*x_80 - 4.18488025665283) - 0.198317472633848*std::sin(0.589679837226868*x_80 + 5.40136003494263) - 0.519589910588791*std::sin(0.639519810676575*x_86 - 0.96319979429245) + 1.90780551299787*std::sin(0.377279847860336*x_87 + 5.17512035369873) + 24.5001116270752*std::sin(0.413919866085052*x_92 - 4.38631963729858) + 0.959858927988345*std::sin(0.378879845142365*x_95 - 7.4159197807312) + 456.491732804532*std::sin(0.383839845657349*x_95 + 5.18136024475098) + 46.368163273243*std::sin(0.372159838676453*x_96 + 5.18296003341675) + 0.887721521803607*std::sin(0.411359876394272*x_96 - 7.37935972213745) - 32653.2018208665 - 0.000107705959159811*std::exp(-4.69999980926514*x_111));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (19797.0017817669*x_1 - 525.927685165016*x_10 - 111.659151290483*x_100 + 1085.30830574419*x_101 - 26.0376499420232*x_102 - 91.9909496451902*x_103 - 519.022887359406*x_104 + 151.917333506913*x_105 + 50.885097273143*x_106 - 458.94066157909*x_107 + 369.611360360112*x_108 + 520.929399153588*x_109 + 111.487768817626*x_11 + 322.583351735776*x_110 + 63.2410632201856*x_111 - 444.032649769315*x_112 + 1098.79435870835*x_113 - 211.79050133551*x_114 - 1.07608415139742*x_115 + 2621.53222787327*x_116 - 249.35118367166*x_117 + 120.357193319658*x_118 - 364.149553735132*x_119 - 2890.20880424803*x_12 - 227.738564324912*x_120 + 993.598532477237*x_13 - 279.139516283736*x_14 + 221.39241655505*x_15 - 128.066859384987*x_16 - 518.573575379454*x_17 + 2.48173185255906*x_18 + 85.8283163430392*x_19 - 88.202552141428*x_2 + 633.589076945121*x_20 + 2256.03600976243*x_21 + 263.938623546547*x_22 + 83.2246887821976*x_23 + 412.969550624289*x_24 + 853.201954142012*x_25 + 372.982649254893*x_26 + 439.211540625717*x_27 + 4.65145859625965*x_28 + 345.693173635527*x_29 - 657.717195050476*x_3 - 1950.00760979732*x_30 + 34303.2762056244*x_31 - 22.0077346433127*x_32 + 101.63415306151*x_33 + 161.948873440913*x_34 - 472.413949934092*x_35 - 5.38149101913937*x_36 - 3702.07865113871*x_37 + 334.749789588319*x_38 - 412.543709169336*x_39 - 85.5837556156111*x_4 - 211.054955783081*x_40 + 25.3361163100474*x_41 + 513446.200470276*x_42 + 718.611787181075*x_43 + 849.012791012835*x_44 - 14.6896089562036*x_45 - 351.603711050242*x_46 + 2942.94076367933*x_47 + 1344.53421639289*x_48 + 292.713488396041*x_49 + 181.443579762945*x_5 - 2938.78786147381*x_50 - 311.283126900061*x_51 - 78.3391838343554*x_52 - 4.21857974885175*x_53 + 985.334312628665*x_54 - 25.5718652085213*x_55 + 190.798003321664*x_56 + 8404.4519480521*x_57 + 418.737415892417*x_58 + 323.363207530882*x_59 - 129.468127870581*x_6 + 451.25747947031*x_60 + 167.774614143667*x_61 + 37.6702092483857*x_62 - 45.554335073936*x_63 - 228.440097627308*x_64 + 16.0685952801705*x_65 - 168.317563956187*x_66 - 340.634557236513*x_67 + 637.383976809115*x_68 + 3.81497796948145*x_69 - 83.2401620909387*x_7 + 251.372271809827*x_70 - 250.692347824673*x_72 - 151.1638185587*x_73 + 933.831967866459*x_74 - 374.496539868424*x_75 + 193.458438401705*x_76 + 4.61718139694586*x_77 - 27.5216333503741*x_78 + 142.141757814667*x_79 + 1821.65418449836*x_8 - 133.200552039007*x_80 + 115.010382992721*x_81 - 466.55596675125*x_82 - 272.275959460814*x_83 - 749.043566361931*x_84 - 749.624767293184*x_85 + 384.173369449439*x_86 + 33.9007177370016*x_87 - 489.702430322806*x_88 + 0.509992518851124*x_89 - 154.143081743937*x_9 - 419.609916740425*x_90 + 770.957514938673*x_91 - 234.480690419289*x_92 - 721.983686275114*x_93 + 62.0254066570631*x_94 - 7.98402467602717*x_95 + 303.120452345572*x_96 + 1823.21448380494*x_97 - 223.919763611823*x_98 + 107.564052963063*x_99 - 2.03769292602244*std::pow(-6.09583950042725*x_77 - 9.12215995788574, 2) - 0.672169694956769*std::exp(0.830399870872498*x_50) + 0.0668081637257174*std::exp(2.49247980117798*x_71) + 6.62693313240863*std::exp(2.52639985084534*x_71) + 0.235135237011697*std::exp(2.59511995315552*x_71) + 0.196115840004056*std::exp(2.64567995071411*x_71) + 0.00199043439431919*std::exp(2.73368000984192*x_71) + 0.888781838085284*std::exp(1.85903990268707*x_89) - 22.8666498629022*std::exp(1.88391983509064*x_89) - 102.916171433438*std::sin(0.200719982385635*x_107 + 1.78663992881775) - 41.9626897102166*std::sin(0.119360059499741*x_108 + 1.71591985225677) - 3.47487656968686*std::sin(0.386799842119217*x_11 - 7.41039991378784) + 5694.62915992953*std::sin(0.22639998793602*x_115 + 5.03599977493286) + 2.16563697755672*std::sin(0.599919855594635*x_14 - 4.00559997558594) - 0.349260326699857*std::sin(0.429279863834381*x_24 + 2.03871965408325) + 4.07299097833053*std::sin(0.322639852762222*x_26 - 4.27967977523804) + 2806.30947095525*std::sin(0.319519847631454*x_28 - 4.29392004013062) - 47.2909989455052*std::sin(0.335359841585159*x_28 - 4.26592016220093) - 2874.58916122838*std::sin(0.362799853086472*x_36 + 5.17072010040283) - 3.3674253508839*std::sin(0.467839866876602*x_45 + 5.23816013336182) - 3519.28421524117*std::sin(0.328719854354858*x_53 - 4.28424024581909) - 7.06883737831782*std::sin(0.372079849243164*x_53 - 4.23120021820068) + 2.79619076158608*std::sin(0.418559849262238*x_66 + 2.02839994430542) + 1.01329900763029*std::sin(0.283759921789169*x_75 + 1.88519990444183) + 6.57794015057817*std::sin(0.367359846830368*x_75 + 1.98055982589722) + 3.70315334833332*std::sin(0.395039826631546*x_80 + 2.00567984580994) - 20.2046405765093*std::sin(0.424879848957062*x_80 - 4.18488025665283) - 0.0473594906465081*std::sin(0.589679837226868*x_80 + 5.40136003494263) - 0.124081419472214*std::sin(0.639519810676575*x_86 - 0.96319979429245) + 0.455596252555097*std::sin(0.377279847860336*x_87 + 5.17512035369873) - 25.2206539710961*std::sin(0.413919866085052*x_92 - 4.38631963729858) - 3.48913036038401*std::sin(0.378879845142365*x_95 - 7.4159197807312) - 1317.02228948215*std::sin(0.383839845657349*x_95 + 5.18136024475098) - 30.2314446950437*std::sin(0.372159838676453*x_96 + 5.18296003341675) + 0.211993620885759*std::sin(0.411359876394272*x_96 - 7.37935972213745) + 113169.760951533 - 2.57208772260827e-5*std::exp(-4.69999980926514*x_111));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (7738.28270807391*x_1 - 208.509700488288*x_10 - 43.4824782456031*x_100 + 429.495027959853*x_101 - 10.1651401407158*x_102 - 34.5631252818894*x_103 - 201.790401032259*x_104 + 58.6421468861289*x_105 + 20.9277017331927*x_106 - 178.259186785539*x_107 + 138.139666036792*x_108 + 208.71286826267*x_109 + 43.5240571887228*x_11 + 131.532344154127*x_110 + 26.695119911766*x_111 - 174.257074823707*x_112 + 427.909625268563*x_113 - 81.9350774756196*x_114 + 0.513956174855076*x_115 + 1034.81537137008*x_116 - 96.9200935098154*x_117 + 46.7326325316424*x_118 - 141.228983247925*x_119 - 1121.62943045015*x_12 - 92.0559900663701*x_120 + 389.860573033901*x_13 - 108.538305995196*x_14 + 85.431260997402*x_15 - 53.5426622506215*x_16 - 206.638230785815*x_17 - 1.88342995181982*x_18 + 35.8779052759374*x_19 - 33.8588565062415*x_2 + 246.488273829001*x_20 + 872.107560425215*x_21 + 103.295408298519*x_22 + 31.9941715830154*x_23 + 162.482920392348*x_24 + 336.732882102143*x_25 + 143.135248445157*x_26 + 170.51031426038*x_27 + 0.0145762274757348*x_28 + 136.796188766547*x_29 - 257.088623538958*x_3 - 735.922477311785*x_30 + 13404.1159003092*x_31 - 11.4446930590965*x_32 + 38.5964001315416*x_33 + 58.1797307701679*x_34 - 188.234948018999*x_35 + 0.147698512498729*x_36 - 1437.17925038569*x_37 + 128.886744187761*x_38 - 160.35410990943*x_39 - 31.6297880717541*x_4 - 83.6136993084582*x_40 + 14.1923267703542*x_41 + 198797.887352573*x_42 + 281.806260493492*x_43 + 331.635235179681*x_44 - 2.66157974784398*x_45 - 139.325171453371*x_46 + 1150.95573695694*x_47 + 522.53752286566*x_48 + 112.807043140045*x_49 + 69.668701660382*x_5 - 1181.29078920076*x_50 - 127.047387178564*x_51 - 27.0631810055594*x_52 - 0.512696189183778*x_53 + 396.622115029955*x_54 - 10.1050142350286*x_55 + 73.6909006618059*x_56 + 3310.281561806*x_57 + 160.244126950487*x_58 + 123.836577111986*x_59 - 51.4568721097775*x_6 + 177.840195107828*x_60 + 67.8104885940417*x_61 + 11.8440183505786*x_62 - 19.4490701961299*x_63 - 90.8402668745039*x_64 + 8.28703932162662*x_65 - 66.1037620037995*x_66 - 132.570111179298*x_67 + 251.379568252898*x_68 - 0.596916583901751*x_69 - 30.6396253055191*x_7 + 96.9098923991775*x_70 - 96.9781912472273*x_72 - 57.9007024397299*x_73 + 365.422153828127*x_74 - 144.362242181177*x_75 + 69.8882860217655*x_76 + 0.421701520084479*x_77 - 10.4702750925339*x_78 + 54.4800949443708*x_79 + 712.345765829378*x_8 - 50.5433577780734*x_80 + 42.5821300153041*x_81 - 184.128880650934*x_82 - 108.284171361516*x_83 - 303.615761480767*x_84 - 297.61409908813*x_85 + 152.684771825906*x_86 + 12.7528222675831*x_87 - 192.24847569296*x_88 + 0.0395304218215344*x_89 - 27.1361137834664*x_9 - 163.135037557228*x_90 + 308.414777806151*x_91 - 91.9573975985429*x_92 - 284.696042252715*x_93 + 23.2247999392383*x_94 - 0.217344445999063*x_95 + 119.499648209673*x_96 + 707.722232282489*x_97 - 87.4649202093019*x_98 + 37.4584857067584*x_99 - 0.800389785022369*std::pow(-6.09583950042725*x_77 - 9.12215995788574, 2) + 0.0959734362566829*std::exp(0.830399870872498*x_50) - 0.0095389737009321*std::exp(2.49247980117798*x_71) + 2.60300731158732*std::exp(2.52639985084534*x_71) + 0.0243920509442551*std::exp(2.59511995315552*x_71) + 0.00183416151816708*std::exp(2.64567995071411*x_71) - 0.00541222341297449*std::exp(2.73368000984192*x_71) + 0.00831227832197602*std::exp(1.85903990268707*x_89) - 8.9818405581237*std::exp(1.88391983509064*x_89) - 10.676139095508*std::sin(0.200719982385635*x_107 + 1.78663992881775) + 5.99149821284557*std::sin(0.119360059499741*x_108 + 1.71591985225677) + 0.496148290324412*std::sin(0.386799842119217*x_11 - 7.41039991378784) + 2236.80562998035*std::sin(0.22639998793602*x_115 + 5.03599977493286) - 0.309213021622498*std::sin(0.599919855594635*x_14 - 4.00559997558594) + 0.949679588929448*std::sin(0.429279863834381*x_24 + 2.03871965408325) - 0.58154799742644*std::sin(0.322639852762222*x_26 - 4.27967977523804) + 1102.29633006999*std::sin(0.319519847631454*x_28 - 4.29392004013062) - 4.90579153572841*std::sin(0.335359841585159*x_28 - 4.26592016220093) - 1129.11605639931*std::sin(0.362799853086472*x_36 + 5.17072010040283) + 0.480806237899463*std::sin(0.467839866876602*x_45 + 5.23816013336182) - 1382.34721262338*std::sin(0.328719854354858*x_53 - 4.28424024581909) - 0.0661108735389424*std::sin(0.372079849243164*x_53 - 4.23120021820068) - 0.399244473281211*std::sin(0.418559849262238*x_66 + 2.02839994430542) - 2.75527825940541*std::sin(0.283759921789169*x_75 + 1.88519990444183) - 0.939208542840349*std::sin(0.367359846830368*x_75 + 1.98055982589722) - 0.528742004424713*std::sin(0.395039826631546*x_80 + 2.00567984580994) - 2.09595392215954*std::sin(0.424879848957062*x_80 - 4.18488025665283) + 0.12877598218516*std::sin(0.589679837226868*x_80 + 5.40136003494263) + 0.337391860540234*std::sin(0.639519810676575*x_86 - 0.96319979429245) - 1.23881938132682*std::sin(0.377279847860336*x_87 + 5.17512035369873) - 0.235874639069621*std::sin(0.413919866085052*x_92 - 4.38631963729858) + 0.498183468766929*std::sin(0.378879845142365*x_95 - 7.4159197807312) - 517.316016405841*std::sin(0.383839845657349*x_95 + 5.18136024475098) - 3.13609711794602*std::sin(0.372159838676453*x_96 + 5.18296003341675) - 0.576435396029007*std::sin(0.411359876394272*x_96 - 7.37935972213745) + 49315.2393364124 + 6.99380669478743e-5*std::exp(-4.69999980926514*x_111));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-14092.1588400625*x_1 + 395.625145018214*x_10 + 103.750225957641*x_100 - 889.702882016827*x_101 + 31.9736042118573*x_102 + 63.0862452990079*x_103 + 408.58338136782*x_104 - 115.401257376997*x_105 - 61.5330496298539*x_106 + 332.979163320144*x_107 - 219.270239470208*x_108 - 412.588101245533*x_109 - 65.5306812854142*x_11 - 260.677408494495*x_110 - 63.4462647673868*x_111 + 299.544386145132*x_112 - 729.054110333168*x_113 + 134.64692182503*x_114 + 14.3336665393014*x_115 - 1810.71485403459*x_116 + 177.568755340036*x_117 - 74.1860867824839*x_118 + 269.503012486304*x_119 + 2086.17376063299*x_12 + 172.993087500085*x_120 - 732.206885530645*x_13 + 198.163420515096*x_14 - 146.087898009942*x_15 + 108.346169846391*x_16 + 397.489228197884*x_17 + 7.19421324991842*x_18 - 72.3141757045355*x_19 + 79.1673407360714*x_2 - 534.364295197823*x_20 - 1569.92379493517*x_21 - 237.162770809976*x_22 - 57.3826436995814*x_23 - 323.63314517211*x_24 - 611.134983519341*x_25 - 247.059599035458*x_26 - 329.280451410285*x_27 - 2.739199838721*x_28 - 242.579808546776*x_29 + 519.199144166435*x_3 + 1285.80321131826*x_30 - 25097.0365717474*x_31 + 42.2401132626834*x_32 - 64.4804425784284*x_33 - 83.0951445458167*x_34 + 364.999787312817*x_35 - 0.171611557472078*x_36 + 2802.63743319816*x_37 - 268.234370470443*x_38 + 312.672655749869*x_39 + 55.997640676337*x_4 + 160.247230889426*x_40 - 33.5033900633112*x_41 - 352164.204936715*x_42 - 503.997963758355*x_43 - 677.660601028212*x_44 - 12.0807886547876*x_45 + 272.923082198519*x_46 - 1991.84134401976*x_47 - 975.289176477548*x_48 - 192.783139243564*x_49 - 113.239722833741*x_5 + 2247.69241436106*x_50 + 269.423854872838*x_51 + 85.4568709201248*x_52 - 12.4686039106542*x_53 - 761.46105402934*x_54 + 20.9388421620691*x_55 - 120.705006380303*x_56 - 5855.96955129607*x_57 - 279.049022907069*x_58 - 213.438779642226*x_59 + 94.4510882001906*x_6 - 330.662170810604*x_60 - 123.331075728976*x_61 - 30.6861867467906*x_62 + 84.1166933192249*x_63 + 186.764222450533*x_64 - 30.4180286800992*x_65 + 126.147210679315*x_66 + 247.340616941863*x_67 - 450.126073965251*x_68 + 15.1136115485434*x_69 + 57.7707349218774*x_7 - 158.830507123202*x_70 + 187.862062557902*x_72 + 77.198202205153*x_73 - 681.990975617174*x_74 + 266.52207470249*x_75 - 138.763556123061*x_76 + 10.6034595497738*x_77 + 26.2397547517086*x_78 - 107.195587291039*x_79 - 1176.9460548428*x_8 + 96.6359500826818*x_80 - 61.3494830774655*x_81 + 324.36291301699*x_82 + 220.56440490342*x_83 + 509.491984609699*x_84 + 558.556982361931*x_85 - 298.962416086228*x_86 - 33.9057386734209*x_87 + 352.030613364013*x_88 - 0.300622076413062*x_89 + 45.3627729336713*x_9 + 349.028847965127*x_90 - 544.502154707537*x_91 + 169.836716443466*x_92 + 502.069070915777*x_93 - 65.0831425009313*x_94 - 4.0084470515051*x_95 - 220.507635923703*x_96 - 1244.27869669201*x_97 + 183.534700203911*x_98 - 48.667568928201*x_99 + 1.48081747214864*std::pow(-6.09583950042725*x_77 - 9.12215995788574, 2) + 0.917365212474461*std::exp(0.830399870872498*x_50) - 0.0911785904230822*std::exp(2.49247980117798*x_71) - 4.81587693803642*std::exp(2.52639985084534*x_71) + 0.754006040816605*std::exp(2.59511995315552*x_71) - 0.135638477740549*std::exp(2.64567995071411*x_71) + 0.00306175604203578*std::exp(2.73368000984192*x_71) - 0.614703103833133*std::exp(1.85903990268707*x_89) + 16.6174864789799*std::exp(1.88391983509064*x_89) - 330.02035741104*std::sin(0.200719982385635*x_107 + 1.78663992881775) + 57.2699305708636*std::sin(0.119360059499741*x_108 + 1.71591985225677) + 4.742449572765*std::sin(0.386799842119217*x_11 - 7.41039991378784) - 4138.35973504181*std::sin(0.22639998793602*x_115 + 5.03599977493286) - 2.95562272587526*std::sin(0.599919855594635*x_14 - 4.00559997558594) - 0.537244492241824*std::sin(0.429279863834381*x_24 + 2.03871965408325) - 5.55874545115138*std::sin(0.322639852762222*x_26 - 4.27967977523804) - 2039.38093113888*std::sin(0.319519847631454*x_28 - 4.29392004013062) - 151.647619192817*std::sin(0.335359841585159*x_28 - 4.26592016220093) + 2089.00065404125*std::sin(0.362799853086472*x_36 + 5.17072010040283) + 4.59580206558431*std::sin(0.467839866876602*x_45 + 5.23816013336182) + 2557.5087830131*std::sin(0.328719854354858*x_53 - 4.28424024581909) + 4.88897960190617*std::sin(0.372079849243164*x_53 - 4.23120021820068) - 3.81619128527732*std::sin(0.418559849262238*x_66 + 2.02839994430542) + 1.55869209648683*std::sin(0.283759921789169*x_75 + 1.88519990444183) - 8.97745540918434*std::sin(0.367359846830368*x_75 + 1.98055982589722) - 5.05399764926594*std::sin(0.395039826631546*x_80 + 2.00567984580994) - 64.7900384511848*std::sin(0.424879848957062*x_80 - 4.18488025665283) - 0.0728500306508619*std::sin(0.589679837226868*x_80 + 5.40136003494263) - 0.190866394219122*std::sin(0.639519810676575*x_86 - 0.96319979429245) + 0.700814145379831*std::sin(0.377279847860336*x_87 + 5.17512035369873) + 17.4432167854971*std::sin(0.413919866085052*x_92 - 4.38631963729858) + 4.76190289211214*std::sin(0.378879845142365*x_95 - 7.4159197807312) + 957.09691709108*std::sin(0.383839845657349*x_95 + 5.18136024475098) - 96.9429006573868*std::sin(0.372159838676453*x_96 + 5.18296003341675) + 0.3260960278181*std::sin(0.411359876394272*x_96 - 7.37935972213745) - 88966.1780574411 - 3.95647560543462e-5*std::exp(-4.69999980926514*x_111));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (12252.8566288619*x_1 - 327.913256863209*x_10 - 65.9851911157485*x_100 + 664.726005551415*x_101 - 14.1330343936115*x_102 - 55.0089158345224*x_103 - 313.85363815665*x_104 + 92.6346046425278*x_105 + 29.1794825334552*x_106 - 281.430648371919*x_107 + 225.377923491031*x_108 + 326.166861947173*x_109 + 71.0754965342936*x_11 + 204.266591359759*x_110 + 40.545406018749*x_111 - 279.39519251443*x_112 + 687.181566929445*x_113 - 132.073540933048*x_114 + 2.72639985565538*x_115 + 1650.66483729705*x_116 - 154.526893915247*x_117 + 75.5292441029581*x_118 - 223.08152366432*x_119 - 1773.21996862995*x_12 - 144.20952681205*x_120 + 615.924111354794*x_13 - 172.363908928123*x_14 + 136.689697131577*x_15 - 82.8980345800078*x_16 - 323.499172917232*x_17 - 1.58751281901439*x_18 + 55.5668851384266*x_19 - 51.3988732423951*x_2 + 379.884974678574*x_20 + 1389.5260034147*x_21 + 156.728978666735*x_22 + 50.3886423718479*x_23 + 253.887444912668*x_24 + 534.353259928832*x_25 + 229.662862991462*x_26 + 268.2688320281*x_27 - 0.290204979416605*x_28 + 217.610541090603*x_29 - 401.382000839371*x_3 - 1180.41114621707*x_30 + 21179.312933045*x_31 - 15.3520292443937*x_32 + 62.8329692069511*x_33 + 97.5998658618029*x_34 - 295.235142218505*x_35 - 0.572968812012346*x_36 - 2255.76656431633*x_37 + 199.13386559399*x_38 - 251.839907075073*x_39 - 51.2783089709586*x_4 - 131.350853146002*x_40 + 20.1555579723033*x_41 + 317231.702983124*x_42 + 448.87725658973*x_43 + 513.889432930695*x_44 - 7.58457571692466*x_45 - 218.507574606092*x_46 + 1841.38535489396*x_47 + 828.482806024691*x_48 + 180.524856935117*x_49 + 112.601265769562*x_5 - 1855.8084806923*x_50 - 194.928370068409*x_51 - 38.8378043798797*x_52 - 2.89564907462009*x_53 + 622.867143031549*x_54 - 15.422832079436*x_55 + 118.826989371596*x_56 + 5275.80982639537*x_57 + 257.77612095766*x_58 + 198.896425714225*x_59 - 81.1654432725499*x_6 + 282.075841977883*x_60 + 107.431120049086*x_61 + 18.1233424409833*x_62 - 23.1670305466765*x_63 - 141.036901914814*x_64 + 11.2108357665346*x_65 - 103.708748074238*x_66 - 209.15342542354*x_67 + 399.682126747189*x_68 + 1.67003338932149*x_69 - 48.8987856662291*x_7 + 155.562752668312*x_70 - 153.47940890666*x_72 - 95.2947373819998*x_73 + 577.28848209916*x_74 - 228.810302285111*x_75 + 108.966661701896*x_76 + 2.405195837606*x_77 - 15.0717120260202*x_78 + 85.34320679647*x_79 + 1146.31863650125*x_8 - 79.6973856788944*x_80 + 70.4203971760684*x_81 - 293.202229623728*x_82 - 168.276996904603*x_83 - 486.247523574273*x_84 - 469.438936354563*x_85 + 238.723802218183*x_86 + 18.5820313060091*x_87 - 306.539239497419*x_88 + 0.12327213116057*x_89 - 49.4469048527609*x_9 - 251.344248883811*x_90 + 489.372578779037*x_91 - 145.75707750581*x_92 - 453.998436932582*x_93 + 33.2548596563241*x_94 - 1.4836708122093*x_95 + 189.254248489983*x_96 + 1129.80454870989*x_97 - 135.721869148*x_98 + 63.0802952111428*x_99 - 1.26640295640786*std::pow(-6.09583950042725*x_77 - 9.12215995788574, 2) - 0.0672243612497409*std::exp(0.830399870872498*x_50) + 0.00668155105239952*std::exp(2.49247980117798*x_71) + 4.11856350072401*std::exp(2.52639985084534*x_71) + 0.167764852142965*std::exp(2.59511995315552*x_71) - 0.00869327700755715*std::exp(2.64567995071411*x_71) - 0.00017322130991525*std::exp(2.73368000984192*x_71) - 0.0393972598929356*std::exp(1.85903990268707*x_89) - 14.2113625756406*std::exp(1.88391983509064*x_89) - 73.4288765183753*std::sin(0.200719982385635*x_107 + 1.78663992881775) - 4.19673042872278*std::sin(0.119360059499741*x_108 + 1.71591985225677) - 0.347525869689668*std::sin(0.386799842119217*x_11 - 7.41039991378784) + 3539.14719518528*std::sin(0.22639998793602*x_115 + 5.03599977493286) + 0.216587512955985*std::sin(0.599919855594635*x_14 - 4.00559997558594) + 0.0303950391256532*std::sin(0.429279863834381*x_24 + 2.03871965408325) + 0.4073438879327*std::sin(0.322639852762222*x_26 - 4.27967977523804) + 1744.08938914577*std::sin(0.319519847631454*x_28 - 4.29392004013062) - 33.7412952078769*std::sin(0.335359841585159*x_28 - 4.26592016220093) - 1786.52443935389*std::sin(0.362799853086472*x_36 + 5.17072010040283) - 0.336779566183676*std::sin(0.467839866876602*x_45 + 5.23816013336182) - 2187.19507620839*std::sin(0.328719854354858*x_53 - 4.28424024581909) + 0.313342162722908*std::sin(0.372079849243164*x_53 - 4.23120021820068) + 0.279649825468761*std::sin(0.418559849262238*x_66 + 2.02839994430542) - 0.0881842586414802*std::sin(0.283759921789169*x_75 + 1.88519990444183) + 0.657866351725485*std::sin(0.367359846830368*x_75 + 1.98055982589722) + 0.370356057881422*std::sin(0.395039826631546*x_80 + 2.00567984580994) - 14.4156553564586*std::sin(0.424879848957062*x_80 - 4.18488025665283) + 0.00412154905990416*std::sin(0.589679837226868*x_80 + 5.40136003494263) + 0.0107984197210741*std::sin(0.639519810676575*x_86 - 0.96319979429245) - 0.0396491237718321*std::sin(0.377279847860336*x_87 + 5.17512035369873) + 1.1179623801828*std::sin(0.413919866085052*x_92 - 4.38631963729858) - 0.348951405506282*std::sin(0.378879845142365*x_95 - 7.4159197807312) - 818.514359919257*std::sin(0.383839845657349*x_95 + 5.18136024475098) - 21.5696035770254*std::sin(0.372159838676453*x_96 + 5.18296003341675) - 0.0184491449747423*std::sin(0.411359876394272*x_96 - 7.37935972213745) + 77917.8002336301 + 2.23840788623195e-6*std::exp(-4.69999980926514*x_111));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-3497.19456298563*x_1 + 83.7336102966442*x_10 + 16.0037179059308*x_100 - 164.503953783723*x_101 + 2.94944115888168*x_102 + 19.3610241145792*x_103 + 89.1637684061021*x_104 - 25.9263147810655*x_105 - 4.09043090588919*x_106 + 82.4618939150809*x_107 - 82.7558449944325*x_108 - 74.8041800347856*x_109 - 21.4241256903208*x_11 - 42.1363540187398*x_110 - 3.62420035898658*x_111 + 78.0111670165955*x_112 - 201.827431634638*x_113 + 41.3959831305418*x_114 + 0.140583414589333*x_115 - 446.781521365042*x_116 + 43.5828648220725*x_117 - 23.637347153475*x_118 + 63.8248104346443*x_119 + 521.809685652838*x_12 + 33.2806643283394*x_120 - 166.869908412782*x_13 + 49.9840996410022*x_14 - 43.2214307482735*x_15 + 12.9473824592767*x_16 + 80.161673767663*x_17 - 6.8056473297649*x_18 - 8.86942751389992*x_19 + 14.3674041441269*x_2 - 100.948548714716*x_20 - 418.526268619003*x_21 - 39.4459505530347*x_22 - 16.7801361865347*x_23 - 65.8827200846527*x_24 - 142.100302172134*x_25 - 72.969640089993*x_26 - 76.7442889844165*x_27 - 4.92128440190614*x_28 - 57.912845635588*x_29 + 107.118955863519*x_3 + 407.058437044736*x_30 - 5919.99780925294*x_31 - 6.55248292815872*x_32 - 20.2298806872188*x_33 - 41.310866673478*x_34 + 71.0801962255125*x_35 + 5.42124524217359*x_36 + 646.346610329287*x_37 - 59.6904491662569*x_38 + 71.0636024983496*x_39 + 18.4782186221721*x_4 + 33.5382539529515*x_40 + 5.51038514171663*x_41 - 95482.3194245457*x_42 - 124.184370462389*x_43 - 141.704295755475*x_44 + 11.2764090819991*x_45 + 54.1117499816681*x_46 - 528.375431316522*x_47 - 235.407609684675*x_48 - 57.7016749741912*x_49 - 36.66102449919*x_5 + 427.490918350209*x_50 + 37.7100560114292*x_51 + 16.4596270302018*x_52 + 5.07133935088872*x_53 - 140.209074513298*x_54 + 4.22672167695935*x_55 - 37.5187298101106*x_56 - 1434.54086319431*x_57 - 81.2199439444999*x_58 - 63.5970057920514*x_59 + 21.0353420969887*x_6 - 73.2090951234962*x_60 - 24.1543515495734*x_61 - 11.5983562744426*x_62 - 1.80858212940166*x_63 + 33.334747579309*x_64 + 4.64540561829137*x_65 + 28.3840242367043*x_66 + 60.9076033514006*x_67 - 107.468489547665*x_68 - 6.76961506202504*x_69 + 18.2262753704532*x_7 - 51.0750651344366*x_70 + 43.2100917269154*x_72 + 34.1196758691216*x_73 - 160.471577772358*x_74 + 69.7901536236915*x_75 - 47.1701911736434*x_76 - 5.64577945775816*x_77 + 5.33528410344839*x_78 - 26.4824274765902*x_79 - 336.577248673424*x_8 + 26.29213257444*x_80 - 27.3448727321588*x_81 + 79.5225078368511*x_82 + 40.2892817294111*x_83 + 111.763823179753*x_84 + 118.271039879066*x_85 - 59.0449464686816*x_86 - 5.93782944861966*x_87 + 80.9546794376501*x_88 - 0.257819178989269*x_89 + 101.484693490733*x_9 + 68.8077536950038*x_90 - 123.099525137329*x_91 + 39.8132420132754*x_92 + 122.864948615765*x_93 - 10.86382163494*x_94 + 8.52773438253225*x_95 - 50.0976547628713*x_96 - 337.076963145392*x_97 + 35.4595333216412*x_98 - 31.8016372107823*x_99 + 0.344620275946096*std::pow(-6.09583950042725*x_77 - 9.12215995788574, 2) + 0.275304230039554*std::exp(0.830399870872498*x_50) - 0.0273629861817082*std::exp(2.49247980117798*x_71) - 1.12076530060145*std::exp(2.52639985084534*x_71) - 0.295582166873048*std::exp(2.59511995315552*x_71) - 0.192509390217249*std::exp(2.64567995071411*x_71) - 0.00334249102672983*std::exp(2.73368000984192*x_71) - 0.872437686228839*std::exp(1.85903990268707*x_89) + 3.86727120906212*std::exp(1.88391983509064*x_89) + 129.373144345271*std::sin(0.200719982385635*x_107 + 1.78663992881775) + 17.1868890664624*std::sin(0.119360059499741*x_108 + 1.71591985225677) + 1.42322426267916*std::sin(0.386799842119217*x_11 - 7.41039991378784) - 963.091468515013*std::sin(0.22639998793602*x_115 + 5.03599977493286) - 0.886991819364578*std::sin(0.599919855594635*x_14 - 4.00559997558594) + 0.586504891253297*std::sin(0.429279863834381*x_24 + 2.03871965408325) - 1.66819726277522*std::sin(0.322639852762222*x_26 - 4.27967977523804) - 474.610836559431*std::sin(0.319519847631454*x_28 - 4.29392004013062) + 59.448239743021*std::sin(0.335359841585159*x_28 - 4.26592016220093) + 486.158487043437*std::sin(0.362799853086472*x_36 + 5.17072010040283) + 1.37921487742822*std::sin(0.467839866876602*x_45 + 5.23816013336182) + 595.191101613413*std::sin(0.328719854354858*x_53 - 4.28424024581909) + 6.93884580264764*std::sin(0.372079849243164*x_53 - 4.23120021820068) - 1.14525119242646*std::sin(0.418559849262238*x_66 + 2.02839994430542) - 1.70160988478947*std::sin(0.283759921789169*x_75 + 1.88519990444183) - 2.6941630394653*std::sin(0.367359846830368*x_75 + 1.98055982589722) - 1.51672083542367*std::sin(0.395039826631546*x_80 + 2.00567984580994) + 25.3987089234041*std::sin(0.424879848957062*x_80 - 4.18488025665283) + 0.0795297111867849*std::sin(0.589679837226868*x_80 + 5.40136003494263) + 0.208367094315426*std::sin(0.639519810676575*x_86 - 0.96319979429245) - 0.765072383356808*std::sin(0.377279847860336*x_87 + 5.17512035369873) + 24.7568616423617*std::sin(0.413919866085052*x_92 - 4.38631963729858) + 1.42906226594302*std::sin(0.378879845142365*x_95 - 7.4159197807312) + 222.738460261751*std::sin(0.383839845657349*x_95 + 5.18136024475098) + 38.0031340441722*std::sin(0.372159838676453*x_96 + 5.18296003341675) - 0.355996046670495*std::sin(0.411359876394272*x_96 - 7.37935972213745) - 11034.5055080443 + 4.31924817884826e-5*std::exp(-4.69999980926514*x_111));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
