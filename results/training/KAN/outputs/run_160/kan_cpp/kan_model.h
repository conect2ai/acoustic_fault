
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (879538.029197339*x_1 + 5876682.42680783*x_10 - 378437.655822941*x_100 - 54910.9575790626*x_101 - 95119.9466689601*x_102 + 37912.8368166274*x_103 - 6533905.65406746*x_104 - 203776.0851676*x_105 + 970322.055650217*x_106 + 98175.0370304037*x_107 + 198682.79671967*x_108 + 80727.3811349787*x_109 - 2366971.85087061*x_11 + 320463.641572601*x_110 - 129822.566735606*x_111 + 325170.068974619*x_112 + 13780.2951543605*x_113 + 287760.073003944*x_114 - 284180.948507222*x_115 + 499689.833076328*x_116 - 113904.85328015*x_117 - 291.08048591294*x_118 - 152689.563173148*x_119 - 567732.690514298*x_12 + 185381.414783286*x_120 + 405.392206723596*x_13 - 387922.520817293*x_14 - 2173902.68152628*x_15 + 505050.493128661*x_16 + 1002116.37463648*x_17 - 2576233.91912905*x_18 + 355242.23565774*x_19 - 248035.569926934*x_2 - 752934.796825892*x_20 + 1003958.45960476*x_21 + 133585.240702965*x_22 + 2777900.83333025*x_23 + 11652329.3632815*x_24 + 891854.218253563*x_25 - 1345616.46546427*x_26 - 3643198.5235101*x_27 - 1776702.2700352*x_28 + 1053283.07063206*x_29 + 64855.935125099*x_3 + 2202156.95000115*x_30 + 221753.19337606*x_31 - 213831.070088262*x_32 - 229264.442357486*x_33 + 3678894.65956985*x_34 + 402028.115024434*x_35 + 1562642.74765472*x_36 + 11223489.1223385*x_37 - 123798.784390566*x_38 + 7622597.09087897*x_39 - 3645.65359893306*x_4 - 376184.106119708*x_40 - 360044652.063423*x_41 + 8525782.58869459*x_42 - 10697225.9365742*x_43 + 23838.4525364729*x_44 + 26058875.6440972*x_45 + 17824296.8779768*x_46 + 4585310.07242173*x_47 + 556139.815545553*x_48 + 3438154.07669704*x_49 - 155.45314133641*x_5 - 4173386.12309869*x_50 + 756170.888473373*x_51 - 3875019.53505679*x_52 - 53988.1123100154*x_53 + 353339.244783571*x_54 - 2990597.71839024*x_55 + 6155773.91798222*x_56 + 2107535.88780915*x_57 + 5338026.18629908*x_58 + 24203894.2408869*x_59 - 66.2683570142276*x_6 + 1085856.20927765*x_60 + 305380.731348571*x_61 + 984510.583643685*x_62 + 269230.956093641*x_63 - 64111.2389767033*x_64 + 5431.8879348908*x_65 - 647467.842364251*x_66 - 201104.229490713*x_67 - 190373.652334941*x_68 - 36940.5241298167*x_69 + 188169.483578775*x_7 + 93778.9166519469*x_70 - 221231.010483849*x_71 + 13739.1264756587*x_72 - 601950.932317301*x_73 + 324725.859718284*x_74 - 63040.5153548949*x_75 - 815904.365678253*x_76 - 161190.981611674*x_77 + 365349.970096006*x_78 - 132468.678416426*x_79 - 496731.12403244*x_8 - 99468.6940837543*x_80 + 19622.3062598333*x_81 - 174250.148730197*x_82 + 667179.35913477*x_83 + 868657.251502897*x_84 + 8068904.31627369*x_85 + 538565.417760229*x_86 + 15143340.4410076*x_87 - 167355.891112331*x_88 - 739789.628172711*x_89 - 202105.877303297*x_9 + 831708.298924358*x_90 + 112523.153180586*x_91 - 289079.840848068*x_92 - 334712.897567485*x_93 - 243092.161761482*x_94 - 290233.155380766*x_95 + 127398.081033141*x_96 - 256786.044143996*x_97 - 4810.44824129118*x_98 + 318736.3879675*x_99 + 0.322289822329083*std::pow(-4.41967964172363*x_3 - 7.02008008956909, 2) - 245.592764510649*std::exp(1.08199977874756*x_1) + 0.000565496560941429*std::exp(0.801279902458191*x_13) + 0.616512366044107*std::exp(0.647039830684662*x_22) - 0.00331406541257844*std::exp(0.950159847736359*x_23) - 0.945239362156679*std::exp(0.962879776954651*x_23) + 0.00250514499920833*std::exp(0.975839853286743*x_23) - 20.016651240096*std::exp(0.986719846725464*x_23) - 0.734302912364139*std::exp(0.98831981420517*x_23) - 0.873159575555218*std::exp(0.990399777889252*x_23) + 57.950438755666*std::exp(0.99375981092453*x_23) + 17.6616507575048*std::exp(0.89711982011795*x_24) + 0.944497543302226*std::exp(0.718399822711945*x_3) + 0.0406306104127074*std::exp(0.794319868087769*x_3) + 33752.807806223*std::exp(0.923119843006134*x_4) + 0.000929544390032315*std::exp(1.00055980682373*x_4) - 0.00414395941514125*std::exp(1.02503991127014*x_4) + 1.65522755364152*std::exp(1.15319991111755*x_5) - 7327.32499890027*std::exp(1.24023985862732*x_5) - 0.0036033472550925*std::exp(1.30663979053497*x_5) - 0.000153849615332373*std::exp(1.31983983516693*x_5) - 2.28527893909598*std::exp(1.36055982112885*x_5) - 0.000144238981831857*std::exp(1.37151992321014*x_6) + 0.00151770795666872*std::exp(1.41087985038757*x_6) + 839.602432273689*std::exp(1.4119998216629*x_6) + 0.016267402979156*std::exp(1.42991983890533*x_6) - 0.552201152635287*std::exp(1.55943989753723*x_6) - 7.64331658849897e-5*std::exp(1.5648797750473*x_6) + 0.00197351660910304*std::exp(1.57063984870911*x_6) + 0.259255405474424*std::exp(1.59999990463257*x_6) + 3.39794354467522e-5*std::exp(1.60359990596771*x_6) + 3.24550978573601e-6*std::exp(1.62815988063812*x_6) - 0.000719125484030474*std::exp(0.824719905853271*x_8) - 0.00230620531172694*std::exp(0.893279850482941*x_8) + 0.0793204621654227*std::sin(0.265359938144684*x_112 - 7.43232011795044) - 0.552970876501017*std::sin(0.280159950256348*x_112 + 1.97079980373383) + 9.45904155403562*std::sin(0.237199977040291*x_119 - 7.42303991317749) - 0.941667708448363*std::sin(0.259919971227646*x_13 + 1.96463978290558) + 945436.467330544*std::sin(0.418079853057861*x_13 + 1.95319974422455) - 0.0884252308837542*std::sin(0.146480038762093*x_16 + 4.95879936218262) + 413.63071452959*std::sin(0.340079843997955*x_16 + 2.02335977554321) - 87.0867308569061*std::sin(0.37679985165596*x_17 - 1.17199981212616) + 80.0097125438796*std::sin(0.254799991846085*x_30 - 4.37439966201782) + 0.0563077380780585*std::sin(0.341839849948883*x_91 - 7.40503978729248) + 0.00793554008304731*std::sin(0.362159848213196*x_91 + 2.00823974609375) + 378.714444921388*std::sin(0.379199832677841*x_91 + 1.98599982261658) - 3.48665031287223*std::sin(0.298959940671921*x_94 + 1.94983983039856) - 0.0622360638035039*std::sin(0.275999963283539*x_97 + 1.97351980209351) - 448999951.837364 - 6.78066504581799e-6*std::exp(-6.1448802947998*x_93) - 0.000187357591135091*std::exp(-6.05551958084106*x_93) - 0.0836712077797445*std::exp(-6.03623962402344*x_93) + 0.022917851875334*std::exp(-5.91943979263306*x_93) + 6.10375840087731e-5*std::exp(-5.78344011306763*x_93) + 0.000154508573305086*std::exp(-7.94063997268677*x_113));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (313539.340757743*x_1 + 2119327.31188908*x_10 - 134603.594600135*x_100 - 19374.3982168452*x_101 - 33953.0425126941*x_102 + 12822.5238645004*x_103 - 2332155.27174503*x_104 - 73444.2778151206*x_105 + 344129.274818952*x_106 + 34615.5160023397*x_107 + 69900.1972784661*x_108 + 28272.5652149335*x_109 - 840321.947172783*x_11 + 113488.060807662*x_110 - 46816.4368533677*x_111 + 116516.658032638*x_112 + 4647.93925499795*x_113 + 102779.664558373*x_114 - 102018.787290678*x_115 + 174769.559690221*x_116 - 41731.4828695844*x_117 - 1204.45855611026*x_118 - 54923.7861212425*x_119 - 203918.534167334*x_12 + 66487.4279513588*x_120 - 508.715562629787*x_13 - 140102.380306495*x_14 - 778581.954098161*x_15 + 179656.784153625*x_16 + 358884.5646713*x_17 - 931619.19038442*x_18 + 124229.713654692*x_19 - 89099.1261742642*x_2 - 274237.141819887*x_20 + 356739.163177878*x_21 + 54323.1935500444*x_22 + 993678.256036933*x_23 + 4177996.04854477*x_24 + 316888.395313938*x_25 - 485369.875386833*x_26 - 1300196.03225889*x_27 - 688487.444537062*x_28 + 343710.830874587*x_29 + 22519.5632879781*x_3 + 790654.471002751*x_30 + 79012.0092378214*x_31 - 76792.2579014981*x_32 - 79169.8676527493*x_33 + 1368462.0404957*x_34 + 144329.133653372*x_35 + 553406.120257769*x_36 + 4015939.84379765*x_37 - 41481.3485786105*x_38 + 2721598.05081349*x_39 + 5749.90272333578*x_4 - 135128.619389011*x_40 - 128339460.011169*x_41 + 3012504.6378902*x_42 - 3829793.41404593*x_43 + 6998.71147177392*x_44 + 9347605.43386386*x_45 + 6358342.91277205*x_46 + 1682281.39999414*x_47 + 198569.645937178*x_48 + 1272576.69060673*x_49 - 31.186133613205*x_5 - 1493226.69344148*x_50 + 265287.377289198*x_51 - 1389437.43685349*x_52 - 10402.4946277458*x_53 + 127731.354781613*x_54 - 1093729.81196272*x_55 + 2171333.19756422*x_56 + 752472.013547645*x_57 + 1919732.26503426*x_58 + 8650105.04338654*x_59 - 47.1538961003285*x_6 + 392848.822685866*x_60 + 109112.730731783*x_61 + 351398.752167242*x_62 + 96003.8722361402*x_63 - 22670.3012833265*x_64 + 2347.96863694198*x_65 - 232726.751095866*x_66 - 71428.0542201442*x_67 - 67789.1419571729*x_68 - 12879.7590566593*x_69 + 68144.1731790225*x_7 + 32971.7237424261*x_70 - 78741.7508026803*x_71 + 4625.65434869189*x_72 - 214653.499921255*x_73 + 116902.319900286*x_74 - 22871.4415351437*x_75 - 290142.937413037*x_76 - 57544.483628241*x_77 + 129364.689840355*x_78 - 46906.4174588305*x_79 - 178481.527255881*x_8 - 36340.9368606661*x_80 + 6649.60242134402*x_81 - 62437.7293401274*x_82 + 236791.63479171*x_83 + 309294.537545718*x_84 + 2906323.87131355*x_85 + 192817.488735336*x_86 + 5442177.45807362*x_87 - 59901.8484538128*x_88 - 260861.498692547*x_89 - 72048.6510896622*x_9 + 298362.555245928*x_90 + 39771.4095675065*x_91 - 103858.680279587*x_92 - 119526.124898126*x_93 - 87760.0970662572*x_94 - 104672.15660823*x_95 + 45134.4991222933*x_96 - 91307.1224791552*x_97 - 1139.33436787096*x_98 + 113817.871235011*x_99 - 0.00402187001797425*std::pow(-4.41967964172363*x_3 - 7.02008008956909, 2) - 21.5798607776814*std::exp(1.08199977874756*x_1) - 0.000784618239380987*std::exp(0.801279902458191*x_13) - 1.50341522788171*std::exp(0.647039830684662*x_22) + 0.0131390295958065*std::exp(0.950159847736359*x_23) + 0.607542451083325*std::exp(0.962879776954651*x_23) + 0.000191182431210157*std::exp(0.975839853286743*x_23) - 14.7007745794144*std::exp(0.986719846725464*x_23) + 0.249924204966167*std::exp(0.98831981420517*x_23) + 2.12927018915065*std::exp(0.990399777889252*x_23) - 186.87315093304*std::exp(0.99375981092453*x_23) + 1.55190225253749*std::exp(0.89711982011795*x_24) - 0.607065654979462*std::exp(0.718399822711945*x_3) - 0.0300301316215724*std::exp(0.794319868087769*x_3) + 12051.8149618847*std::exp(0.923119843006134*x_4) - 0.00357295941940973*std::exp(1.00055980682373*x_4) - 0.000316250051822664*std::exp(1.02503991127014*x_4) - 0.0206556633492393*std::exp(1.15319991111755*x_5) - 2616.30278462513*std::exp(1.24023985862732*x_5) + 8.49330228639315e-5*std::exp(1.30663979053497*x_5) + 0.000591363293855449*std::exp(1.31983983516693*x_5) + 7.36935362837137*std::exp(1.36055982112885*x_5) + 0.000571853604326799*std::exp(1.37151992321014*x_6) - 0.00112173972379246*std::exp(1.41087985038757*x_6) + 299.789374958169*std::exp(1.4119998216629*x_6) - 0.0104556986033327*std::exp(1.42991983890533*x_6) + 1.78068659284695*std::exp(1.55943989753723*x_6) + 0.000106049904082806*std::exp(1.5648797750473*x_6) - 4.6516951994124e-5*std::exp(1.57063984870911*x_6) + 0.0227803761529661*std::exp(1.59999990463257*x_6) + 2.59317168543601e-6*std::exp(1.60359990596771*x_6) - 1.23474360230097e-5*std::exp(1.62815988063812*x_6) + 0.000997776131891332*std::exp(0.824719905853271*x_8) - 0.000176000167058221*std::exp(0.893279850482941*x_8) + 0.00605341359733312*std::sin(0.265359938144684*x_112 - 7.43232011795044) + 0.408701420814201*std::sin(0.280159950256348*x_112 + 1.97079980373383) - 6.07969739804939*std::sin(0.237199977040291*x_119 - 7.42303991317749) + 0.695987703390363*std::sin(0.259919971227646*x_13 + 1.96463978290558) + 337578.592806282*std::sin(0.418079853057861*x_13 + 1.95319974422455) + 0.339886685334743*std::sin(0.146480038762093*x_16 + 4.95879936218262) + 36.3450985647193*std::sin(0.340079843997955*x_16 + 2.02335977554321) + 1.08675945540455*std::sin(0.37679985165596*x_17 - 1.17199981212616) - 0.998445007358613*std::sin(0.254799991846085*x_30 - 4.37439966201782) - 0.0781261662153732*std::sin(0.341839849948883*x_91 - 7.40503978729248) - 0.0301905031727505*std::sin(0.362159848213196*x_91 + 2.00823974609375) + 33.2770593310622*std::sin(0.379199832677841*x_91 + 1.98599982261658) + 1.18670141813016*std::sin(0.298959940671921*x_94 + 1.94983983039856) + 0.0863516317874932*std::sin(0.275999963283539*x_97 + 1.97351980209351) - 160939603.327922 - 5.17472652916649e-7*std::exp(-6.1448802947998*x_93) + 6.37682300047767e-5*std::exp(-6.05551958084106*x_93) + 0.269815079504383*std::exp(-6.03623962402344*x_93) + 0.0168314954495894*std::exp(-5.91943979263306*x_93) - 1.4386919026052e-6*std::exp(-5.78344011306763*x_93) - 0.000376781642573778*std::exp(-7.94063997268677*x_113));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-635297.06226276*x_1 - 4342314.52420368*x_10 + 272211.157633231*x_100 + 38958.5685780275*x_101 + 68820.8471757423*x_102 - 24868.8574387271*x_103 + 4732784.30968734*x_104 + 150136.571780082*x_105 - 693655.512974151*x_106 - 69584.8626179262*x_107 - 140016.733819038*x_108 - 56467.7066809943*x_109 + 1696784.26412962*x_11 - 228578.913721917*x_110 + 95899.2090537208*x_111 - 237271.468627926*x_112 - 8786.82232024089*x_113 - 208872.608199763*x_114 + 208190.969283074*x_115 - 347449.546297264*x_116 + 86616.5289527475*x_117 + 4431.20694144743*x_118 + 112302.605696337*x_119 + 416258.334930462*x_12 - 135622.221726983*x_120 + 2315.26416743913*x_13 + 288609.510881686*x_14 + 1583062.5065688*x_15 - 363440.985969906*x_16 - 730279.238560321*x_17 + 1913071.06429275*x_18 - 248987.445004771*x_19 + 181676.289578529*x_2 + 567383.769653507*x_20 - 721721.49623393*x_21 - 119129.751111687*x_22 - 2017779.20220815*x_23 - 8509657.12255843*x_24 - 640465.252127551*x_25 + 993955.515563729*x_26 + 2637472.03653358*x_27 + 1484911.85677953*x_28 - 642243.250470122*x_29 - 44278.178566746*x_3 - 1612303.08942161*x_30 - 160055.611627523*x_31 + 156388.441847705*x_32 + 155622.58489852*x_33 - 2888260.97237963*x_34 - 294247.859512705*x_35 - 1114511.44523444*x_36 - 8161542.92488717*x_37 + 79870.3894368983*x_38 - 5523522.03438974*x_39 - 25335.6989447161*x_4 + 275262.163133809*x_40 + 260242542.59554*x_41 - 6062195.16624733*x_42 + 7793522.82703155*x_43 - 11673.0748571333*x_44 - 19047619.7674004*x_45 - 12889491.0927031*x_46 - 3500453.71398275*x_47 - 402593.997091335*x_48 - 2656820.94860252*x_49 + 23.6926287398101*x_5 + 3033642.68029414*x_50 - 529320.628515685*x_51 + 2829096.51432161*x_52 + 6981.01582516444*x_53 - 261385.978338211*x_54 + 2265066.80946054*x_55 - 4357214.38379946*x_56 - 1526928.77458753*x_57 - 3916749.05033677*x_58 - 17576408.5904157*x_59 + 15.6671971762929*x_6 - 806094.455211527*x_60 - 221641.466021679*x_61 - 713154.277597071*x_62 - 194706.155445004*x_63 + 45646.2352142826*x_64 - 5453.91358692712*x_65 + 475133.968893189*x_66 + 144167.798211816*x_67 + 137215.35660826*x_68 + 25509.5853143784*x_69 - 139870.102483778*x_7 - 66017.4114878153*x_70 + 159253.969717145*x_71 - 8842.72421449386*x_72 + 435047.027826725*x_73 - 239310.58606422*x_74 + 47035.2481031796*x_75 + 586694.313331901*x_76 + 116802.802758891*x_77 - 260424.495172101*x_78 + 94568.27030857*x_79 + 364138.659277977*x_8 + 75411.9991950324*x_80 - 12820.5402771796*x_81 + 127197.587599771*x_82 - 478163.338948451*x_83 - 625929.391979375*x_84 - 5941589.25400645*x_85 - 390736.566043809*x_86 - 11111814.3854991*x_87 + 121892.217737844*x_88 + 523703.496773437*x_89 + 146150.075035348*x_9 - 608185.263110898*x_90 - 79932.6694534621*x_91 + 211576.24020052*x_92 + 242639.519871891*x_93 + 179810.714785992*x_94 + 214351.389911218*x_95 - 91054.2278124603*x_96 + 184504.827451011*x_97 + 1345.65402604434*x_98 - 231083.972520739*x_99 - 0.27341305007167*std::pow(-4.41967964172363*x_3 - 7.02008008956909, 2) - 3.18678708082967*std::exp(1.08199977874756*x_1) - 8.75967698319022e-5*std::exp(0.801279902458191*x_13) - 5.4891323403167*std::exp(0.647039830684662*x_22) + 0.00514663129112534*std::exp(0.950159847736359*x_23) + 2.99993672089331*std::exp(0.962879776954651*x_23) + 0.000420331409554111*std::exp(0.975839853286743*x_23) + 5.5778746288298*std::exp(0.986719846725464*x_23) - 0.222308162541583*std::exp(0.98831981420517*x_23) + 7.77419680190884*std::exp(0.990399777889252*x_23) + 761.818410998509*std::exp(0.99375981092453*x_23) + 0.229175808873234*std::exp(0.89711982011795*x_24) - 2.99758238641379*std::exp(0.718399822711945*x_3) - 0.00686079613903728*std::exp(0.794319868087769*x_3) - 24462.0133851899*std::exp(0.923119843006134*x_4) - 0.00361301795447243*std::exp(1.00055980682373*x_4) - 0.000695303586280154*std::exp(1.02503991127014*x_4) - 1.40420448506034*std::exp(1.15319991111755*x_5) + 5310.40626989524*std::exp(1.24023985862732*x_5) - 0.00178113321186807*std::exp(1.30663979053497*x_5) + 0.000597993413165793*std::exp(1.31983983516693*x_5) - 30.0423535602695*std::exp(1.36055982112885*x_5) + 0.000223998251355675*std::exp(1.37151992321014*x_6) - 0.000256276850963634*std::exp(1.41087985038757*x_6) - 608.493552726905*std::exp(1.4119998216629*x_6) - 0.0516283827192654*std::exp(1.42991983890533*x_6) - 7.25925486821321*std::exp(1.55943989753723*x_6) + 1.18396802067281e-5*std::exp(1.5648797750473*x_6) + 0.000975508527988496*std::exp(1.57063984870911*x_6) + 0.00336407213969582*std::exp(1.59999990463257*x_6) + 5.70131629175149e-6*std::exp(1.60359990596771*x_6) + 7.35002195499415e-6*std::exp(1.62815988063812*x_6) + 0.000111394257464631*std::exp(0.824719905853271*x_8) - 0.000386951864944223*std::exp(0.893279850482941*x_8) + 0.0133089628261086*std::sin(0.265359938144684*x_112 - 7.43232011795044) + 0.0933734545447956*std::sin(0.280159950256348*x_112 + 1.97079980373383) - 30.0204659671204*std::sin(0.237199977040291*x_119 - 7.42303991317749) + 0.159007952692683*std::sin(0.259919971227646*x_13 + 1.96463978290558) - 685195.722129598*std::sin(0.418079853057861*x_13 + 1.95319974422455) + 0.343697353496229*std::sin(0.146480038762093*x_16 + 4.95879936218262) + 5.36723066709112*std::sin(0.340079843997955*x_16 + 2.02335977554321) + 73.8796172100179*std::sin(0.37679985165596*x_17 - 1.17199981212616) - 67.8758621165607*std::sin(0.254799991846085*x_30 - 4.37439966201782) - 0.00872220330388463*std::sin(0.341839849948883*x_91 - 7.40503978729248) + 0.0179714121003357*std::sin(0.362159848213196*x_91 + 2.00823974609375) + 4.91416065454456*std::sin(0.379199832677841*x_91 + 1.98599982261658) - 1.05557367596996*std::sin(0.298959940671921*x_94 + 1.94983983039856) + 0.0096405151379935*std::sin(0.275999963283539*x_97 + 1.97351980209351) + 327081286.182343 - 1.13770919340942e-6*std::exp(-6.1448802947998*x_93) - 5.67219891439089e-5*std::exp(-6.05551958084106*x_93) - 1.09994450302343*std::exp(-6.03623962402344*x_93) - 0.00638632821191583*std::exp(-5.91943979263306*x_93) + 3.01708551393619e-5*std::exp(-5.78344011306763*x_93) - 0.00137567071367465*std::exp(-7.94063997268677*x_113));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (42525.5863773402*x_1 + 515196.017873103*x_10 - 15514.7867648625*x_100 - 1036.521412334*x_101 - 4841.11787618726*x_102 - 4302.12586220626*x_103 - 348740.15632104*x_104 - 16889.8470998702*x_105 + 29690.6594860818*x_106 + 1562.06035034816*x_107 + 1080.74700476685*x_108 - 684.980503279206*x_109 - 82733.1740338029*x_11 + 8367.17460522007*x_110 - 11353.3628386001*x_111 + 21338.5615892486*x_112 - 2142.07680802491*x_113 + 16293.9786504572*x_114 - 20835.4150381372*x_115 - 7701.57595051627*x_116 - 16193.3974737618*x_117 - 9983.53062333381*x_118 - 12242.7720188952*x_119 - 41980.7254240255*x_12 + 13021.9773050448*x_120 - 6021.30935581926*x_13 - 37853.0632197028*x_14 - 135316.446899828*x_15 + 21145.0082256148*x_16 + 63926.5502982343*x_17 - 249270.699009416*x_18 - 257.543469554423*x_19 - 17999.9861833287*x_2 - 92328.0525921399*x_20 + 40308.2237588154*x_21 + 60959.597844077*x_22 + 155792.271821438*x_23 + 787630.194293833*x_24 + 34084.31885537*x_25 - 118138.996582259*x_26 - 189045.531325935*x_27 - 567770.235045916*x_28 - 233667.287711007*x_29 - 2867.31318077697*x_3 + 158453.932398089*x_30 + 10489.6143718399*x_31 - 15074.6282670025*x_32 + 13095.6016656787*x_33 + 723277.885046485*x_34 + 28622.1744367101*x_35 + 42247.912646805*x_36 + 669543.504617028*x_37 + 17072.563115129*x_38 + 406515.047808799*x_39 + 66049.3281458426*x_4 - 26886.5951251964*x_40 - 17745851.4928401*x_41 + 195532.698846178*x_42 - 678176.254583717*x_43 - 12296.5956663036*x_44 + 1812088.6590775*x_45 + 902075.443853114*x_46 + 665824.494277063*x_47 + 29757.1851300472*x_48 + 582847.275159516*x_49 + 90.4412255082838*x_5 - 242161.46753556*x_50 - 4377.29877542362*x_51 - 261128.14020422*x_52 + 76638.0697388079*x_53 + 32893.5538225789*x_54 - 391837.795119398*x_55 + 77036.1238267909*x_56 + 113332.345114561*x_57 + 404492.022137166*x_58 + 1387144.0111165*x_59 + 0.880101255255631*x_6 + 104927.94609204*x_60 + 17137.0340347742*x_61 + 52312.3521022763*x_62 + 13608.028740558*x_63 - 1517.85815862483*x_64 + 3935.18861216098*x_65 - 49588.4036573877*x_66 - 7082.63330376018*x_67 - 8566.27083251829*x_68 + 1041.28495914899*x_69 + 18572.7555841494*x_7 + 422.009319362766*x_70 - 9344.4436009712*x_71 - 1862.94388472224*x_72 - 29522.6399320335*x_73 + 26529.6962647615*x_74 - 6614.11674290637*x_75 - 32992.626905777*x_76 - 8751.5266202972*x_77 + 9170.75886066681*x_78 - 3699.47754059719*x_79 - 37068.0971350211*x_8 - 13246.6742307831*x_80 - 2171.71329644512*x_81 - 11537.1454487852*x_82 + 22745.4969112634*x_83 + 38484.1849539207*x_84 + 666264.141085451*x_85 + 29780.7744289561*x_86 + 1151849.99840249*x_87 - 10459.2031476369*x_88 - 10328.4850567528*x_89 - 9932.73180567765*x_9 + 58219.628660299*x_90 + 2245.22681065318*x_91 - 20593.2144817048*x_92 - 18190.250999599*x_93 - 21844.4600945186*x_94 - 25305.1953220683*x_95 + 3987.88030978525*x_96 - 10277.1620145158*x_97 + 5014.37494060975*x_98 + 17596.9649128829*x_99 + 0.181534741071066*std::pow(-4.41967964172363*x_3 - 7.02008008956909, 2) + 207.524355731028*std::exp(1.08199977874756*x_1) + 0.000578018540614966*std::exp(0.801279902458191*x_13) + 2.45283024611601*std::exp(0.647039830684662*x_22) + 0.0114638985909685*std::exp(0.950159847736359*x_23) + 0.333829322769395*std::exp(0.962879776954651*x_23) - 0.00031253387533508*std::exp(0.975839853286743*x_23) - 0.330891295905536*std::exp(0.986719846725464*x_23) + 0.0695710194686278*std::exp(0.98831981420517*x_23) - 3.4739160713841*std::exp(0.990399777889252*x_23) - 1923.13588089275*std::exp(0.99375981092453*x_23) - 14.9239848409242*std::exp(0.89711982011795*x_24) - 0.33356733528166*std::exp(0.718399822711945*x_3) + 0.0567362600793337*std::exp(0.794319868087769*x_3) + 1827.26162592108*std::exp(0.923119843006134*x_4) - 0.00293930902421306*std::exp(1.00055980682373*x_4) + 0.000516987118771435*std::exp(1.02503991127014*x_4) + 0.932332591803633*std::exp(1.15319991111755*x_5) - 396.676325952184*std::exp(1.24023985862732*x_5) - 0.00114338060115469*std::exp(1.30663979053497*x_5) + 0.000486487323862425*std::exp(1.31983983516693*x_5) + 75.8389758558006*std::exp(1.36055982112885*x_5) + 0.000498946416177841*std::exp(1.37151992321014*x_6) + 0.0021193152768165*std::exp(1.41087985038757*x_6) + 45.4532053846158*std::exp(1.4119998216629*x_6) - 0.00574514386214098*std::exp(1.42991983890533*x_6) + 18.3252771317357*std::exp(1.55943989753723*x_6) - 7.81256510665132e-5*std::exp(1.5648797750473*x_6) + 0.000626217915499535*std::exp(1.57063984870911*x_6) - 0.219069202213949*std::exp(1.59999990463257*x_6) - 4.23916565517271e-6*std::exp(1.60359990596771*x_6) - 1.30875969606855e-5*std::exp(1.62815988063812*x_6) - 0.000735049320381946*std::exp(0.824719905853271*x_8) + 0.00028771479639707*std::exp(0.893279850482941*x_8) - 0.00989576708803813*std::sin(0.265359938144684*x_112 - 7.43232011795044) - 0.772164118303441*std::sin(0.280159950256348*x_112 + 1.97079980373383) - 3.3406410719361*std::sin(0.237199977040291*x_119 - 7.42303991317749) - 1.31493727197677*std::sin(0.259919971227646*x_13 + 1.96463978290558) + 51182.6982341003*std::sin(0.418079853057861*x_13 + 1.95319974422455) + 0.279609109464591*std::sin(0.146480038762093*x_16 + 4.95879936218262) - 349.515376458071*std::sin(0.340079843997955*x_16 + 2.02335977554321) - 49.0529518511804*std::sin(0.37679985165596*x_17 - 1.17199981212616) + 45.0667115233719*std::sin(0.254799991846085*x_30 - 4.37439966201782) + 0.0575545791737894*std::sin(0.341839849948883*x_91 - 7.40503978729248) - 0.032000257934436*std::sin(0.362159848213196*x_91 + 2.00823974609375) - 320.011346201272*std::sin(0.379199832677841*x_91 + 1.98599982261658) + 0.330340262462205*std::sin(0.298959940671921*x_94 + 1.94983983039856) - 0.0636141778005387*std::sin(0.275999963283539*x_97 + 1.97351980209351) - 28626149.3115409 + 8.45934077583656e-7*std::exp(-6.1448802947998*x_93) + 1.7751064854814e-5*std::exp(-6.05551958084106*x_93) + 2.77670204633483*std::exp(-6.03623962402344*x_93) + 0.000378850468814184*std::exp(-5.91943979263306*x_93) + 1.93678778525578e-5*std::exp(-5.78344011306763*x_93) + 0.000614721330439356*std::exp(-7.94063997268677*x_113));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1733944.40924942*x_1 - 11643552.2790502*x_10 + 745605.909246661*x_100 + 107871.049515988*x_101 + 187747.829035961*x_102 - 73486.5369799517*x_103 + 12891247.0372921*x_104 + 403331.37381619*x_105 - 1909255.61856532*x_106 - 192859.995351879*x_107 - 389959.126855375*x_108 - 158427.429520424*x_109 + 4659871.84997192*x_11 - 630499.718921128*x_110 + 257254.094021528*x_111 - 642614.671506469*x_112 - 26511.3203310902*x_113 - 568081.792838737*x_114 + 561924.808736629*x_115 - 976883.137940219*x_116 + 226482.109944958*x_117 + 2983.94286943382*x_118 + 302285.513082333*x_119 + 1123397.65856627*x_12 - 366494.689302591*x_120 + 921.167251483576*x_13 + 771494.730356455*x_14 + 4294067.21114733*x_15 - 995169.320766272*x_16 - 1979388.71786528*x_17 + 5108519.568373*x_18 - 695766.043750651*x_19 + 490471.3979544*x_2 + 1498904.74750783*x_20 - 1977348.50757985*x_21 - 272011.837766645*x_22 - 5489862.87925769*x_23 - 23023445.4048187*x_24 - 1756747.10515071*x_25 + 2663808.85092557*x_26 + 7189018.59390802*x_27 + 3605422.78057271*x_28 - 2013729.70059803*x_29 - 126171.194910495*x_3 - 4353707.18048367*x_30 - 437211.280546932*x_31 + 422548.400636177*x_32 + 447059.710705597*x_33 - 7392309.63402568*x_34 - 794806.830535841*x_35 - 3072814.17279324*x_36 - 22160347.0944553*x_37 + 239328.778866129*x_38 - 15044298.1357121*x_39 - 12129.8308612057*x_4 + 743499.213804666*x_40 + 710241087.533461*x_41 - 16748075.05465*x_42 + 21127769.9595057*x_43 - 44374.0094678059*x_44 - 51496618.2984797*x_45 - 35148488.6973775*x_46 - 9153960.00089055*x_47 - 1096017.98785386*x_48 - 6868076.51603949*x_49 + 78.449867115788*x_5 + 8244984.74258088*x_50 - 1481893.16188996*x_51 + 7654267.17676939*x_52 + 93399.6845574834*x_53 - 698759.368314388*x_54 + 5959181.76895313*x_55 - 12099311.3131723*x_56 - 4157958.41251398*x_57 - 10558014.454331*x_58 - 47788082.7846646*x_59 - 23.718675305231*x_6 - 2152118.35603385*x_60 - 602931.46353924*x_61 - 1942428.77184671*x_62 - 530966.482352422*x_63 + 126171.074122651*x_64 - 11567.0062177799*x_65 + 1280287.07132931*x_66 + 395981.17415234*x_67 + 375221.020806663*x_68 + 72199.5455509107*x_69 - 373148.405245749*x_7 - 184019.219166675*x_70 + 435896.893860357*x_71 - 26445.745551175*x_72 + 1187145.25881676*x_73 - 643422.042340695*x_74 + 125096.319840073*x_75 + 1607710.92811233*x_76 + 318028.217806331*x_77 - 718507.777124859*x_78 + 260647.424241535*x_79 + 981956.096094911*x_8 + 198114.912016618*x_80 - 37770.525884497*x_81 + 344412.211785103*x_82 - 1314133.96301341*x_83 - 1711687.09108479*x_84 - 15969992.4285672*x_85 - 1062994.58124667*x_86 - 29952556.8406501*x_87 + 330657.629461786*x_88 + 1453258.93028184*x_89 + 398876.885379187*x_9 - 1643684.21159564*x_90 - 221115.579379681*x_91 + 571581.927303586*x_92 + 660508.748399443*x_93 + 481701.296240307*x_94 + 574913.686337759*x_95 - 250500.325237791*x_96 + 505581.779447359*x_97 + 8510.22250296056*x_98 - 628799.460289607*x_99 + 0.269259315681126*std::pow(-4.41967964172363*x_3 - 7.02008008956909, 2) + 187.578670347181*std::exp(1.08199977874756*x_1) - 8.33034311343084e-5*std::exp(0.801279902458191*x_13) + 0.314305084929138*std::exp(0.647039830684662*x_22) - 0.00349131236849758*std::exp(0.950159847736359*x_23) - 0.514053835503374*std::exp(0.962879776954651*x_23) - 0.00128592321204973*std::exp(0.975839853286743*x_23) - 8.26835147336836*std::exp(0.986719846725464*x_23) + 0.00491200459452731*std::exp(0.98831981420517*x_23) - 0.445146779962461*std::exp(0.990399777889252*x_23) + 323.353507461031*std::exp(0.99375981092453*x_23) - 13.4896032944219*std::exp(0.89711982011795*x_24) + 0.513650408770794*std::exp(0.718399822711945*x_3) - 0.0153341395918767*std::exp(0.794319868087769*x_3) - 66601.1375609984*std::exp(0.923119843006134*x_4) + 0.00350820617895124*std::exp(1.00055980682373*x_4) + 0.00212714777124923*std::exp(1.02503991127014*x_4) + 1.38287158796774*std::exp(1.15319991111755*x_5) + 14458.2987882841*std::exp(1.24023985862732*x_5) + 0.00721156362755864*std::exp(1.30663979053497*x_5) - 0.000580645934638514*std::exp(1.31983983516693*x_5) - 12.7514644643007*std::exp(1.36055982112885*x_5) - 0.000151953349918117*std::exp(1.37151992321014*x_6) - 0.00057278848215338*std::exp(1.41087985038757*x_6) - 1656.70593716056*std::exp(1.4119998216629*x_6) + 0.00884677599125211*std::exp(1.42991983890533*x_6) - 3.08118770733528*std::exp(1.55943989753723*x_6) + 1.12593876080829e-5*std::exp(1.5648797750473*x_6) - 0.00394969998422341*std::exp(1.57063984870911*x_6) - 0.198013912731143*std::exp(1.59999990463257*x_6) - 1.74420821098709e-5*std::exp(1.60359990596771*x_6) + 2.43957134097473e-5*std::exp(1.62815988063812*x_6) + 0.000105934543856693*std::exp(0.824719905853271*x_8) + 0.00118380490671767*std::exp(0.893279850482941*x_8) - 0.0407162154371357*std::sin(0.265359938144684*x_112 - 7.43232011795044) + 0.208693212442042*std::sin(0.280159950256348*x_112 + 1.97079980373383) + 5.14415373048316*std::sin(0.237199977040291*x_119 - 7.42303991317749) + 0.355388805234236*std::sin(0.259919971227646*x_13 + 1.96463978290558) - 1865537.95990438*std::sin(0.418079853057861*x_13 + 1.95319974422455) - 0.333726871667519*std::sin(0.146480038762093*x_16 + 4.95879936218262) - 315.922578585783*std::sin(0.340079843997955*x_16 + 2.02335977554321) - 72.757226356015*std::sin(0.37679985165596*x_17 - 1.17199981212616) + 66.8446812614864*std::sin(0.254799991846085*x_30 - 4.37439966201782) - 0.00829470611369474*std::sin(0.341839849948883*x_91 - 7.40503978729248) + 0.0596495387160517*std::sin(0.362159848213196*x_91 + 2.00823974609375) - 289.254254542766*std::sin(0.379199832677841*x_91 + 1.98599982261658) + 0.0233234024650654*std::sin(0.298959940671921*x_94 + 1.94983983039856) + 0.00916800916789764*std::sin(0.275999963283539*x_97 + 1.97351980209351) + 885970287.566728 + 3.48060275086156e-6*std::exp(-6.1448802947998*x_93) + 1.25329933053399e-6*std::exp(-6.05551958084106*x_93) - 0.466870986484736*std::exp(-6.03623962402344*x_93) + 0.00946676105043369*std::exp(-5.91943979263306*x_93) - 0.000122157646651911*std::exp(-5.78344011306763*x_93) + 7.87702452207758e-5*std::exp(-7.94063997268677*x_113));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-124133.559283419*x_1 - 823834.443083936*x_10 + 53392.5455673208*x_100 + 7823.31071790901*x_101 + 13403.3717157341*x_102 - 5398.73896705506*x_103 + 922024.895433753*x_104 + 28627.2909688184*x_105 - 137168.90677398*x_106 - 13903.9398562716*x_107 - 28091.2820976811*x_108 - 11387.9873473143*x_109 + 334128.033022549*x_11 - 45222.1971522489*x_110 + 18231.5729489373*x_111 - 45719.6312781334*x_112 - 1973.61947608476*x_113 - 40529.7987345666*x_114 + 40048.4378415517*x_115 - 71215.6338204936*x_116 + 16064.6519973887*x_117 - 208.074884455484*x_118 + 21485.7705337226*x_119 + 79683.3401670145*x_12 - 26069.1695456763*x_120 - 266.957797133055*x_13 + 53833.5268014071*x_14 + 305924.887791889*x_15 - 71286.4798604456*x_16 - 141164.331262103*x_17 + 361452.502855263*x_18 - 51036.4712248205*x_19 + 34879.6454529831*x_2 + 105069.801823228*x_20 - 141919.418720077*x_21 - 17876.6088544021*x_22 - 388196.147071372*x_23 - 1640977.26198453*x_24 - 125903.91134335*x_25 + 189183.88553743*x_26 + 512990.533397227*x_27 + 242030.964849463*x_28 - 152804.25024346*x_29 - 9332.68985018186*x_3 - 309914.958980547*x_30 - 31320.1702109065*x_31 + 30121.0972257224*x_32 + 32565.1025208895*x_33 - 506811.484630893*x_34 - 56505.2714325083*x_35 - 221348.326748322*x_36 - 1579012.63367224*x_37 + 17792.5409431372*x_38 - 1072221.60545089*x_39 + 2123.96955030969*x_4 + 52958.6954384028*x_40 + 50746090.0502118*x_41 - 1215195.37592612*x_42 + 1506919.16909962*x_43 - 3515.27579998716*x_44 - 3675680.33361203*x_45 - 2516467.32086718*x_46 - 634825.930209098*x_47 - 78845.7071500887*x_48 - 479049.512770305*x_49 + 117.833754996632*x_5 + 584702.179273157*x_50 - 107059.417627009*x_51 + 546500.513088435*x_52 + 7696.45374207207*x_53 - 50105.8137960873*x_54 + 414832.84464916*x_55 - 867314.381566831*x_56 - 297443.559906716*x_57 - 750063.298881584*x_58 - 3407459.2109575*x_59 + 46.0213987270021*x_6 - 152486.493075844*x_60 - 42947.873121913*x_61 - 138738.596190265*x_62 - 37981.792609147*x_63 + 9080.57217824395*x_64 - 709.33802829486*x_65 + 91299.5841586013*x_66 + 28396.2917884906*x_67 + 26907.180056258*x_68 + 5242.2854873787*x_69 - 26397.5842958562*x_7 - 13310.3334304331*x_70 + 31204.0866658137*x_71 - 2022.13960767405*x_72 + 84836.336098537*x_73 - 45340.7832409489*x_74 + 8814.73708192596*x_75 + 115134.156620827*x_76 + 22757.9391919652*x_77 - 51575.2926754177*x_78 + 18712.4249755247*x_79 + 69987.742480781*x_8 + 13851.5851036899*x_80 - 2892.02805666991*x_81 + 24486.7889672432*x_82 - 93987.1846081979*x_83 - 122647.621708153*x_84 - 1136076.17339046*x_85 - 75659.9886902617*x_86 - 2132075.61398632*x_87 + 23547.0259589138*x_88 + 104817.356300452*x_89 + 28375.4603929247*x_9 - 117161.409363334*x_90 - 15931.2822821167*x_91 + 40653.2078280298*x_92 + 47146.8121259388*x_93 + 34117.8999456238*x_94 + 40746.3013524734*x_95 - 18105.841906703*x_96 + 36364.7777342812*x_97 + 681.198728684481*x_98 - 45021.6832195172*x_99 - 0.0480008693972196*std::pow(-4.41967964172363*x_3 - 7.02008008956909, 2) + 169.226590837465*std::exp(1.08199977874756*x_1) - 0.000115899006346687*std::exp(0.801279902458191*x_13) - 2.24015001054713*std::exp(0.647039830684662*x_22) + 0.0103132608050844*std::exp(0.950159847736359*x_23) - 0.400291242154888*std::exp(0.962879776954651*x_23) - 0.000931599080433837*std::exp(0.975839853286743*x_23) + 13.5104923580688*std::exp(0.986719846725464*x_23) + 0.129026793885833*std::exp(0.98831981420517*x_23) + 3.17269943008639*std::exp(0.990399777889252*x_23) - 39.0501816601448*std::exp(0.99375981092453*x_23) - 12.1698249222032*std::exp(0.89711982011795*x_24) + 0.399977095704168*std::exp(0.718399822711945*x_3) - 0.0133255738450307*std::exp(0.794319868087769*x_3) - 4758.21505080413*std::exp(0.923119843006134*x_4) + 0.00289068822735*std::exp(1.00055980682373*x_4) + 0.00154103206869092*std::exp(1.02503991127014*x_4) - 0.246524575460837*std::exp(1.15319991111755*x_5) + 1032.95074863291*std::exp(1.24023985862732*x_5) - 0.00115339848461314*std::exp(1.30663979053497*x_5) - 0.000478440057938658*std::exp(1.31983983516693*x_5) + 1.53994619595655*std::exp(1.36055982112885*x_5) + 0.000448866890872379*std::exp(1.37151992321014*x_6) - 0.000497760906034883*std::exp(1.41087985038757*x_6) - 118.360788023089*std::exp(1.4119998216629*x_6) + 0.00688894179174179*std::exp(1.42991983890533*x_6) + 0.372103400532769*std::exp(1.55943989753723*x_6) + 1.56650430610122e-5*std::exp(1.5648797750473*x_6) + 0.000631704608286461*std::exp(1.57063984870911*x_6) - 0.178640883464297*std::exp(1.59999990463257*x_6) - 1.2636079279187e-5*std::exp(1.60359990596771*x_6) - 2.09507056802328e-5*std::exp(1.62815988063812*x_6) + 0.000147385386215186*std::exp(0.824719905853271*x_8) + 0.000857618520435101*std::exp(0.893279850482941*x_8) - 0.0294972425293732*std::sin(0.265359938144684*x_112 - 7.43232011795044) + 0.181357212557679*std::sin(0.280159950256348*x_112 + 1.97079980373383) + 4.00572769697249*std::sin(0.237199977040291*x_119 - 7.42303991317749) + 0.308837658576868*std::sin(0.259919971227646*x_13 + 1.96463978290558) - 133280.468228243*std::sin(0.418079853057861*x_13 + 1.95319974422455) - 0.274983934772053*std::sin(0.146480038762093*x_16 + 4.95879936218262) - 285.013753662406*std::sin(0.340079843997955*x_16 + 2.02335977554321) + 12.9704337663658*std::sin(0.37679985165596*x_17 - 1.17199981212616) - 11.9164041066316*std::sin(0.254799991846085*x_30 - 4.37439966201782) - 0.0115403193292848*std::sin(0.341839849948883*x_91 - 7.40503978729248) - 0.0512262096464181*std::sin(0.362159848213196*x_91 + 2.00823974609375) - 260.954570639115*std::sin(0.379199832677841*x_91 + 1.98599982261658) + 0.612650860695278*std::sin(0.298959940671921*x_94 + 1.94983983039856) + 0.0127553347835517*std::sin(0.275999963283539*x_97 + 1.97351980209351) + 63436153.7347009 + 2.52155516882661e-6*std::exp(-6.1448802947998*x_93) + 3.29212221377458e-5*std::exp(-6.05551958084106*x_93) + 0.0563822454787416*std::exp(-6.03623962402344*x_93) - 0.0154686944839614*std::exp(-5.91943979263306*x_93) + 1.95375721284345e-5*std::exp(-5.78344011306763*x_93) - 0.000561420015530148*std::exp(-7.94063997268677*x_113));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1847768.0136376*x_1 + 12710530.9186805*x_10 - 790961.90889769*x_100 - 112723.483688122*x_101 - 200372.956076093*x_102 + 70318.0011930584*x_103 - 13778170.8769619*x_104 - 439049.902642423*x_105 + 2012199.95041668*x_106 + 201324.881324747*x_107 + 404507.755350342*x_108 + 162855.490441643*x_109 - 4924692.1572468*x_11 + 662690.049756427*x_110 - 280719.369290391*x_111 + 692166.78392676*x_112 + 24651.1803799919*x_113 + 608438.505358738*x_114 - 607879.266598093*x_115 + 999487.621538763*x_116 - 255133.536446064*x_117 - 16337.0733004025*x_118 - 328375.01978238*x_119 - 1216214.65288084*x_12 + 395818.745051671*x_120 - 8960.06844106217*x_13 - 847289.077595588*x_14 - 4615840.85255815*x_15 + 1056194.884836*x_16 + 2129429.40780246*x_17 - 5606064.9250987*x_18 + 717152.885550072*x_19 - 530542.077637321*x_2 - 1670109.88935909*x_20 + 2095921.22607831*x_21 + 363068.777413549*x_22 + 5882848.1158935*x_23 + 24826978.6283331*x_24 + 1860232.57338529*x_25 - 2908005.76462131*x_26 - 7678294.0093186*x_27 - 4477156.28226562*x_28 + 1773358.03163917*x_29 + 126596.4868968*x_3 + 4707204.52625313*x_30 + 465527.11012292*x_31 - 456508.582063742*x_32 - 445006.825989912*x_33 + 8588550.43618839*x_34 + 859100.812693477*x_35 + 3230562.64217482*x_36 + 23785269.7338043*x_37 - 224707.281190141*x_38 + 16084249.1114065*x_39 + 99024.2859239666*x_4 - 803787.625631191*x_40 - 757251990.525613*x_41 + 17549022.2718546*x_42 - 22724011.4726046*x_43 + 29678.8596200208*x_44 + 55583915.3115775*x_45 + 37506074.4245715*x_46 + 10340083.9214092*x_47 + 1171273.57748941*x_48 + 7864701.27039622*x_49 + 201.538432762549*x_5 - 8844075.95605696*x_50 + 1526221.88827774*x_51 - 8252106.437136*x_52 + 3689.44736378817*x_53 + 764762.078600917*x_54 - 6678437.45435097*x_55 + 12611010.2277873*x_56 + 4445190.73063909*x_57 + 11444791.3576529*x_58 + 51208659.4951872*x_59 + 33.7536327223601*x_6 + 2361910.28187535*x_60 + 645690.77042455*x_61 + 2076116.33837597*x_62 + 566548.234036914*x_63 - 132310.866847236*x_64 + 17122.0873441199*x_65 - 1387826.91574906*x_66 - 418555.114892043*x_67 - 398934.966542456*x_68 - 73280.8942268331*x_69 + 410035.511017673*x_7 + 190667.389787966*x_70 - 462814.510127703*x_71 + 24818.9334641378*x_72 - 1265708.32061062*x_73 + 700076.06076679*x_74 - 138019.540242518*x_75 - 1704813.14172324*x_76 - 340082.465118543*x_77 + 754770.423055805*x_78 - 274214.096370887*x_79 - 1063350.91315366*x_8 - 222148.005772658*x_80 + 36101.8017248844*x_81 - 371105.811745527*x_82 + 1388218.95340164*x_83 + 1819490.00477793*x_84 + 17376012.1313015*x_85 + 1138378.76854537*x_86 + 32461037.5510164*x_87 - 355444.0409934*x_88 - 1515205.77275777*x_89 - 425392.151376753*x_9 + 1774931.33968693*x_90 + 231465.395895613*x_91 - 617819.498364783*x_92 - 706517.882629685*x_93 - 526496.756456645*x_94 - 627371.188267397*x_95 + 263934.127601788*x_96 - 535867.953465865*x_97 - 2281.39461251076*x_98 + 672764.669407572*x_99 + 0.104684878517024*std::pow(-4.41967964172363*x_3 - 7.02008008956909, 2) + 285.093168501104*std::exp(1.08199977874756*x_1) - 3.42631393520655e-5*std::exp(0.801279902458191*x_13) - 10.2470929525731*std::exp(0.647039830684662*x_22) + 0.0067858953021646*std::exp(0.950159847736359*x_23) - 0.716877256311698*std::exp(0.962879776954651*x_23) - 0.000176278046287986*std::exp(0.975839853286743*x_23) + 7.90772155812878*std::exp(0.986719846725464*x_23) + 0.291265139240805*std::exp(0.98831981420517*x_23) + 14.5128432549616*std::exp(0.990399777889252*x_23) - 2858.60626849546*std::exp(0.99375981092453*x_23) - 20.5022977181343*std::exp(0.89711982011795*x_24) + 0.716314654830685*std::exp(0.718399822711945*x_3) - 0.0530546223496585*std::exp(0.794319868087769*x_3) + 71225.2392390134*std::exp(0.923119843006134*x_4) - 0.000140915158415331*std::exp(1.00055980682373*x_4) + 0.000291595524342364*std::exp(1.02503991127014*x_4) + 0.537644329314451*std::exp(1.15319991111755*x_5) - 15462.1351510927*std::exp(1.24023985862732*x_5) + 0.000376319893319005*std::exp(1.30663979053497*x_5) + 2.33229775244466e-5*std::exp(1.31983983516693*x_5) + 112.729305262106*std::exp(1.36055982112885*x_5) + 0.00029534439045374*std::exp(1.37151992321014*x_6) - 0.00198179209370055*std::exp(1.41087985038757*x_6) + 1771.73064971874*std::exp(1.4119998216629*x_6) + 0.012337331348968*std::exp(1.42991983890533*x_6) + 27.2392359797157*std::exp(1.55943989753723*x_6) + 4.63104534088967e-6*std::exp(1.5648797750473*x_6) - 0.000206106574588763*std::exp(1.57063984870911*x_6) - 0.300953267678768*std::exp(1.59999990463257*x_6) - 2.39101069854842e-6*std::exp(1.60359990596771*x_6) + 4.11072686184884e-5*std::exp(1.62815988063812*x_6) + 4.3571435040981e-5*std::exp(0.824719905853271*x_8) + 0.000162279375772129*std::exp(0.893279850482941*x_8) - 0.00558149572403973*std::sin(0.265359938144684*x_112 - 7.43232011795044) + 0.722058091796367*std::sin(0.280159950256348*x_112 + 1.97079980373383) + 7.17381440942512*std::sin(0.237199977040291*x_119 - 7.42303991317749) + 1.22961048685035*std::sin(0.259919971227646*x_13 + 1.96463978290558) + 1995061.83181864*std::sin(0.418079853057861*x_13 + 1.95319974422455) + 0.0134049062653837*std::sin(0.146480038762093*x_16 + 4.95879936218262) - 480.157838646355*std::sin(0.340079843997955*x_16 + 2.02335977554321) - 28.2871602159722*std::sin(0.37679985165596*x_17 - 1.17199981212616) + 25.9884317081713*std::sin(0.254799991846085*x_30 - 4.37439966201782) - 0.00341165624978566*std::sin(0.341839849948883*x_91 - 7.40503978729248) + 0.100510674551126*std::sin(0.362159848213196*x_91 + 2.00823974609375) - 439.625740908559*std::sin(0.379199832677841*x_91 + 1.98599982261658) + 1.38299831277139*std::sin(0.298959940671921*x_94 + 1.94983983039856) + 0.0037708503890342*std::sin(0.275999963283539*x_97 + 1.97351980209351) - 953190147.306262 + 4.77131019237513e-7*std::exp(-6.1448802947998*x_93) + 7.43163808163172e-5*std::exp(-6.05551958084106*x_93) + 4.12737235795955*std::exp(-6.03623962402344*x_93) - 0.00905386166580938*std::exp(-5.91943979263306*x_93) - 6.37453330931926e-6*std::exp(-5.78344011306763*x_93) - 0.00256809725129408*std::exp(-7.94063997268677*x_113));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-281356.362682451*x_1 - 1949118.29599017*x_10 + 120269.051728669*x_100 + 17037.8262725832*x_101 + 30517.8350680967*x_102 - 10312.0164283915*x_103 + 2099088.30131755*x_104 + 67321.2853713246*x_105 - 305373.236489801*x_106 - 30432.8007692021*x_107 - 61070.0538585382*x_108 - 24493.3848007487*x_109 + 748029.941860361*x_11 - 100478.204759864*x_110 + 43027.3849824248*x_111 - 105726.893276217*x_112 - 3614.706956239*x_113 - 92734.7127560999*x_114 + 92941.9498053842*x_115 - 150371.909739121*x_116 + 39510.4283257578*x_117 + 3121.8926888556*x_118 + 50245.9250963011*x_119 + 185998.720309414*x_12 - 60499.9901413227*x_120 + 1723.15770413982*x_13 + 129860.28115482*x_14 + 704862.545343335*x_15 - 160589.975896112*x_16 - 325155.134691539*x_17 + 861051.03785878*x_18 - 107726.510513075*x_19 + 81167.0130486421*x_2 + 257418.77555783*x_20 - 318472.424658176*x_21 - 59765.4141240399*x_22 - 897724.51247445*x_23 - 3794028.11023001*x_24 - 282618.747218794*x_25 + 446150.184498017*x_26 + 1169812.16992045*x_27 + 714709.180265267*x_28 - 251984.199599392*x_29 - 18961.2395708918*x_3 - 719928.299355037*x_30 - 70842.2685337082*x_31 + 69841.5149327861*x_32 + 66296.0211641577*x_33 - 1339243.19556212*x_34 - 131401.412322223*x_35 - 489800.609879382*x_36 - 3630650.69073153*x_37 + 32651.1932454626*x_38 - 2451450.76916719*x_39 - 18578.0849266026*x_4 + 122984.584328301*x_40 + 115270738.530701*x_41 - 2655603.78077076*x_42 + 3469086.12154519*x_43 - 3617.34320019163*x_44 - 8494653.21713642*x_45 - 5712713.8844109*x_46 - 1601260.85030981*x_47 - 178549.447390668*x_48 - 1224915.77006689*x_49 - 35.2642323116326*x_5 + 1349859.58734136*x_50 - 230046.471282835*x_51 + 1261154.16389158*x_52 - 5899.26460775485*x_53 - 117543.125315462*x_54 + 1032449.62258276*x_55 - 1906945.65817209*x_56 - 677406.896810961*x_57 - 1752356.79600624*x_58 - 7808251.92064361*x_59 + 21.7797251794596*x_6 - 362974.89210763*x_60 - 98448.5971504256*x_61 - 316354.391963578*x_62 - 86278.321274973*x_63 + 20019.6232119898*x_64 - 2836.65619918952*x_65 + 212386.532905626*x_66 + 63579.7569484135*x_67 + 60685.1207240374*x_68 + 11001.8587242597*x_69 - 63043.8354178714*x_7 - 28759.7859186344*x_70 + 70410.8003095283*x_71 - 3621.31912572618*x_72 + 192763.692979092*x_73 - 107249.868690906*x_74 + 21251.3158703075*x_75 + 259123.475652663*x_76 + 51817.1233214498*x_77 - 114458.866176114*x_78 + 41569.5315414851*x_79 + 162733.562764292*x_8 + 34336.6176847816*x_80 - 5305.75755746661*x_81 + 56684.6617509048*x_82 - 210762.758832255*x_83 - 276849.08062398*x_84 - 2662095.61509823*x_85 - 173882.065186339*x_86 - 4966701.65307109*x_87 + 54243.4605287277*x_88 + 228983.229843689*x_89 + 64767.1172780384*x_9 - 271309.963109649*x_90 - 35049.366585679*x_91 + 94527.4528776082*x_92 + 107694.516941126*x_93 + 80781.2538554531*x_94 + 96199.5564835655*x_95 - 40027.5851454146*x_96 + 81458.2670987564*x_97 + 20.8341375217688*x_98 - 102538.837097618*x_99 - 0.0993900453060428*std::pow(-4.41967964172363*x_3 - 7.02008008956909, 2) - 92.0578281134527*std::exp(1.08199977874756*x_1) - 0.00037323253115432*std::exp(0.801279902458191*x_13) + 0.741163803845916*std::exp(0.647039830684662*x_22) + 0.0166820557130898*std::exp(0.950159847736359*x_23) - 0.452675013255235*std::exp(0.962879776954651*x_23) - 0.000205174577713321*std::exp(0.975839853286743*x_23) + 7.01102032720147*std::exp(0.986719846725464*x_23) + 0.02732172635237*std::exp(0.98831981420517*x_23) - 1.04970201414693*std::exp(0.990399777889252*x_23) + 552.895444153989*std::exp(0.99375981092453*x_23) + 6.6202813949908*std::exp(0.89711982011795*x_24) + 0.452319756297879*std::exp(0.718399822711945*x_3) + 0.0290637062129797*std::exp(0.794319868087769*x_3) - 10855.1910764687*std::exp(0.923119843006134*x_4) + 0.000895556020194643*std::exp(1.00055980682373*x_4) + 0.00033939557324284*std::exp(1.02503991127014*x_4) - 0.510450936239185*std::exp(1.15319991111755*x_5) + 2356.53025961839*std::exp(1.24023985862732*x_5) + 0.000846048537551196*std::exp(1.30663979053497*x_5) - 0.000148224173792008*std::exp(1.31983983516693*x_5) - 21.8034641527833*std::exp(1.36055982112885*x_5) + 0.000726057705978196*std::exp(1.37151992321014*x_6) + 0.00108564005614658*std::exp(1.41087985038757*x_6) - 270.023308369575*std::exp(1.4119998216629*x_6) + 0.00779045726832216*std::exp(1.42991983890533*x_6) - 5.26845884352827*std::exp(1.55943989753723*x_6) + 5.04465383837187e-5*std::exp(1.5648797750473*x_6) - 0.00046337217114029*std::exp(1.57063984870911*x_6) + 0.0971791233434856*std::exp(1.59999990463257*x_6) - 2.78295919834085e-6*std::exp(1.60359990596771*x_6) + 1.30856366476569e-5*std::exp(1.62815988063812*x_6) + 0.000474628924666562*std::exp(0.824719905853271*x_8) + 0.000188881163007859*std::exp(0.893279850482941*x_8) - 0.0064964472451531*std::sin(0.265359938144684*x_112 - 7.43232011795044) - 0.395548650037831*std::sin(0.280159950256348*x_112 + 1.97079980373383) + 4.52993382658682*std::sin(0.237199977040291*x_119 - 7.42303991317749) - 0.673589526482562*std::sin(0.259919971227646*x_13 + 1.96463978290558) - 304060.43735545*std::sin(0.418079853057861*x_13 + 1.95319974422455) - 0.0851920023446049*std::sin(0.146480038762093*x_16 + 4.95879936218262) + 155.04506126832*std::sin(0.340079843997955*x_16 + 2.02335977554321) + 26.856430224424*std::sin(0.37679985165596*x_17 - 1.17199981212616) - 24.6739685950736*std::sin(0.254799991846085*x_30 - 4.37439966201782) - 0.0371635851709892*std::sin(0.341839849948883*x_91 - 7.40503978729248) + 0.0319954648068101*std::sin(0.362159848213196*x_91 + 2.00823974609375) + 141.957070046919*std::sin(0.379199832677841*x_91 + 1.98599982261658) + 0.129730257269442*std::sin(0.298959940671921*x_94 + 1.94983983039856) + 0.041076330479876*std::sin(0.275999963283539*x_97 + 1.97351980209351) + 145698952.667387 + 5.55345134844821e-7*std::exp(-6.1448802947998*x_93) + 6.97114603365992e-6*std::exp(-6.05551958084106*x_93) - 0.798292999701566*std::exp(-6.03623962402344*x_93) - 0.00802719313168132*std::exp(-5.91943979263306*x_93) - 1.43313300191366e-5*std::exp(-5.78344011306763*x_93) + 0.000185748361630447*std::exp(-7.94063997268677*x_113));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-125600.339354691*x_1 - 1027863.24514521*x_10 + 51622.2753170487*x_100 + 6791.52862820485*x_101 + 13722.4616988296*x_102 - 413.762875746844*x_103 + 966227.736935314*x_104 + 34547.9867123822*x_105 - 124009.469999844*x_106 - 11615.1259370191*x_107 - 21187.0965621535*x_108 - 7687.45360242272*x_109 + 310412.447066592*x_11 - 39553.9896947386*x_110 + 22822.313284875*x_111 - 50910.5400162729*x_112 + 603.668067213088*x_113 - 43338.0619099278*x_114 + 46851.9924838403*x_115 - 44907.979701969*x_116 + 25407.4813581051*x_117 + 7863.8990145881*x_118 + 26144.1230434127*x_119 + 93031.6202027263*x_12 - 29883.5327294004*x_120 + 4683.41343010689*x_13 + 71775.1166960985*x_14 + 332613.22742524*x_15 - 69573.7308963105*x_16 - 155959.407757906*x_17 + 471022.952606037*x_18 - 40653.4172234299*x_19 + 40142.3606869337*x_2 + 154678.348125372*x_20 - 138005.043577561*x_21 - 56656.4477026143*x_22 - 401193.490526583*x_23 - 1848240.22682688*x_24 - 120232.053540318*x_25 + 235630.913568269*x_26 + 529045.574569544*x_27 + 623788.826328265*x_28 + 78857.6141635594*x_29 - 4167.40650324801*x_3 - 356979.944051356*x_30 - 31678.327086911*x_31 + 34179.8096279384*x_32 + 12300.1451325199*x_33 - 975969.441122113*x_34 - 64616.0585028338*x_35 - 196969.484097903*x_36 - 1691550.45042905*x_37 - 347.833421150864*x_38 - 1112481.02487697*x_39 - 55532.7627329247*x_4 + 60498.761592563*x_40 + 51898782.2659923*x_41 - 1079936.16696388*x_42 + 1665882.8590752*x_43 + 7333.02086313589*x_44 - 4204699.52046346*x_45 - 2585585.51871479*x_46 - 1010982.86656423*x_47 - 82497.8094981445*x_48 - 820758.412993102*x_49 + 132.157631692427*x_5 + 615336.918933649*x_50 - 72553.1711259639*x_51 + 614712.08373963*x_52 - 57374.5246078049*x_53 - 63869.1546294755*x_54 + 619969.184450508*x_55 - 685029.666363817*x_56 - 311444.152510767*x_57 - 875666.112483983*x_58 - 3637061.70471878*x_59 - 100.386922923433*x_6 - 197462.496631759*x_60 - 45377.0494733759*x_61 - 144579.848210984*x_62 - 39114.1558918835*x_63 + 8031.77613124688*x_64 - 3735.51365273707*x_65 + 108282.58655952*x_66 + 26393.8596164444*x_67 + 26833.0889616502*x_68 + 2806.83856095983*x_69 - 34390.6624225454*x_7 - 10156.0552789208*x_70 + 30242.6461632044*x_71 + 16.1400881380841*x_72 + 85899.9544950465*x_73 - 54622.5280062669*x_74 + 11766.1097298811*x_75 + 111307.808679107*x_76 + 24024.3489393528*x_77 - 44576.6460216121*x_78 + 16779.1738902794*x_79 + 81767.4461898928*x_8 + 21073.6465900502*x_80 - 421.347539516701*x_81 + 27403.306624713*x_82 - 86919.6278287012*x_83 - 121071.930977585*x_84 - 1385981.33083469*x_85 - 76939.6369691162*x_86 - 2521235.99584058*x_87 + 25901.5963251132*x_88 + 85870.4659946627*x_89 + 28774.3671810416*x_9 - 134118.542413623*x_90 - 13445.044074731*x_91 + 46185.6681225592*x_92 + 49358.3331779945*x_93 + 42920.6235564866*x_94 + 50728.5969486773*x_95 - 16825.7223730961*x_96 + 35154.6485186528*x_97 - 3764.23744277772*x_98 - 47705.3948384786*x_99 - 0.201149312353853*std::pow(-4.41967964172363*x_3 - 7.02008008956909, 2) + 397.197384695306*std::exp(1.08199977874756*x_1) - 0.000590199295721352*std::exp(0.801279902458191*x_13) + 3.58626509257767*std::exp(0.647039830684662*x_22) - 0.00224725457507624*std::exp(0.950159847736359*x_23) - 0.142477277467268*std::exp(0.962879776954651*x_23) + 0.000199488873197671*std::exp(0.975839853286743*x_23) - 28.5255451926766*std::exp(0.986719846725464*x_23) - 0.142419721780737*std::exp(0.98831981420517*x_23) - 5.07918718022857*std::exp(0.990399777889252*x_23) + 1574.54827662613*std::exp(0.99375981092453*x_23) - 28.5642026313792*std::exp(0.89711982011795*x_24) + 0.142365462053111*std::exp(0.718399822711945*x_3) + 0.0606034640631094*std::exp(0.794319868087769*x_3) - 4987.5954945366*std::exp(0.923119843006134*x_4) - 0.00267052624006568*std::exp(1.00055980682373*x_4) - 0.000329990397587625*std::exp(1.02503991127014*x_4) - 1.033069805922*std::exp(1.15319991111755*x_5) + 1082.74645953403*std::exp(1.24023985862732*x_5) + 0.000831884387521874*std::exp(1.30663979053497*x_5) + 0.000442000876101063*std::exp(1.31983983516693*x_5) - 62.0924033092285*std::exp(1.36055982112885*x_5) - 9.78078798914798e-5*std::exp(1.37151992321014*x_6) + 0.00226377006586889*std::exp(1.41087985038757*x_6) - 124.066635654476*std::exp(1.4119998216629*x_6) + 0.00245200885693638*std::exp(1.42991983890533*x_6) - 15.003637451284*std::exp(1.55943989753723*x_6) + 7.97720159428988e-5*std::exp(1.5648797750473*x_6) - 0.000455614610361992*std::exp(1.57063984870911*x_6) - 0.419293985422348*std::exp(1.59999990463257*x_6) + 2.705839099656e-6*std::exp(1.60359990596771*x_6) - 2.30673602187812e-5*std::exp(1.62815988063812*x_6) + 0.000750539231403074*std::exp(0.824719905853271*x_8) - 0.000183646974184839*std::exp(0.893279850482941*x_8) + 0.00631642065584994*std::sin(0.265359938144684*x_112 - 7.43232011795044) - 0.824795647950552*std::sin(0.280159950256348*x_112 + 1.97079980373383) + 1.42577482701716*std::sin(0.237199977040291*x_119 - 7.42303991317749) - 1.40456479852669*std::sin(0.259919971227646*x_13 + 1.96463978290558) - 139705.552554328*std::sin(0.418079853057861*x_13 + 1.95319974422455) + 0.254040476055933*std::sin(0.146480038762093*x_16 + 4.95879936218262) - 668.965302655242*std::sin(0.340079843997955*x_16 + 2.02335977554321) + 54.3530537217059*std::sin(0.37679985165596*x_17 - 1.17199981212616) - 49.9361057805843*std::sin(0.254799991846085*x_30 - 4.37439966201782) - 0.0587674437878227*std::sin(0.341839849948883*x_91 - 7.40503978729248) - 0.0564016052056725*std::sin(0.362159848213196*x_91 + 2.00823974609375) - 612.495190437858*std::sin(0.379199832677841*x_91 + 1.98599982261658) - 0.676243766904379*std::sin(0.298959940671921*x_94 + 1.94983983039856) + 0.0649547381228045*std::sin(0.275999963283539*x_97 + 1.97351980209351) + 69199619.8611969 - 5.39955663224497e-7*std::exp(-6.1448802947998*x_93) - 3.6338431393469e-5*std::exp(-6.05551958084106*x_93) - 2.27339704136307*std::exp(-6.03623962402344*x_93) + 0.0326600194781519*std::exp(-5.91943979263306*x_93) - 1.40914015759077e-5*std::exp(-5.78344011306763*x_93) + 0.000898779543553173*std::exp(-7.94063997268677*x_113));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (34085.1599822474*x_1 + 144558.005113681*x_10 - 15669.9642131978*x_100 - 2625.88007719785*x_101 - 3603.97719838468*x_102 + 3618.43709574655*x_103 - 239288.386432953*x_104 - 5490.39803523087*x_105 + 43862.8375904096*x_106 + 4864.00420129183*x_107 + 10761.2732374331*x_108 + 4742.49389050427*x_109 - 103348.867205143*x_11 + 15020.5120610291*x_110 - 3164.5372092262*x_111 + 10593.0189981426*x_112 + 1625.11061931695*x_113 + 10168.1883170057*x_114 - 8336.2468330947*x_115 + 30965.9333773912*x_116 - 556.332124646369*x_117 + 3462.17773410722*x_118 - 4056.84875103958*x_119 - 16679.3231092964*x_12 + 5687.14082511555*x_120 + 2158.65365715309*x_13 - 7609.35603440738*x_14 - 74128.8188882738*x_15 + 20658.99985401*x_16 + 33229.9000067447*x_17 - 54892.021161028*x_18 + 18755.26085414*x_19 - 7521.56937580129*x_2 - 8567.72510308581*x_20 + 41372.3740191726*x_21 - 11604.6488035452*x_22 + 102772.817738071*x_23 + 371346.848346412*x_24 + 37607.5954800999*x_25 - 33330.175791309*x_26 - 136607.053250761*x_27 + 94258.364024987*x_28 + 140562.9917367*x_29 + 4763.14492813953*x_3 + 66781.5854693974*x_30 + 8606.88778295036*x_31 - 6693.26939845439*x_32 - 17619.9488550115*x_33 - 55555.5397337262*x_34 + 12376.3281516489*x_35 + 72154.974143403*x_36 + 393511.496512602*x_37 - 12660.0852180328*x_38 + 282722.145792745*x_39 - 24793.0709103768*x_4 - 11612.3814885674*x_40 - 13713066.4070484*x_41 + 397302.528141604*x_42 - 354701.549622131*x_43 + 5569.87927479227*x_44 + 804745.578851295*x_45 + 674415.504276444*x_46 + 19424.0167770401*x_47 + 20477.284582404*x_48 - 10760.9770848816*x_49 - 17.5370806865611*x_5 - 150304.241690828*x_50 + 44397.4465745278*x_51 - 123923.126501925*x_52 - 29648.6893105861*x_53 + 8158.5686897125*x_54 - 29634.6685710405*x_55 + 319164.876170884*x_56 + 77233.5020945358*x_57 + 156607.058735569*x_58 + 856312.743466564*x_59 - 62.2321047672071*x_6 + 23639.6934483211*x_60 + 10985.6129086549*x_61 + 36345.7709290084*x_62 + 10150.5468813475*x_63 - 2982.15094325255*x_64 - 1081.67337793149*x_65 - 18371.6237174594*x_66 - 8772.43718294939*x_67 - 7552.16452868345*x_68 - 2484.61877145299*x_69 + 3994.41796416647*x_7 + 5051.13399906352*x_70 - 9120.26037644213*x_71 + 1419.73868472742*x_72 - 23251.3476932214*x_73 + 8772.71502815291*x_74 - 1217.09146243907*x_75 - 33804.6324776885*x_76 - 5834.32301519044*x_77 + 17346.4516390819*x_78 - 6052.57948242001*x_79 - 14595.128322028*x_8 - 833.322753984821*x_80 + 1849.6527294626*x_81 - 5620.98172579488*x_82 + 29256.3226595306*x_83 + 34944.3655140369*x_84 + 212352.333349512*x_85 + 20469.9610067337*x_86 + 432373.190245866*x_87 - 5595.38713797564*x_88 - 37329.4945027463*x_89 - 7771.87227330328*x_9 + 25630.0623420598*x_90 + 5500.6260817139*x_91 - 8999.59042377011*x_92 - 12248.9452695374*x_93 - 5824.24082762292*x_94 - 7189.56276693757*x_95 + 5607.01685862547*x_96 - 10672.7139926454*x_97 - 2064.89153744491*x_98 + 11460.7397554302*x_99 - 0.00633414535082634*std::pow(-4.41967964172363*x_3 - 7.02008008956909, 2) + 39.0621648783321*std::exp(1.08199977874756*x_1) + 0.000485017654770816*std::exp(0.801279902458191*x_13) + 1.08045470864336*std::exp(0.647039830684662*x_22) + 0.0130317232827972*std::exp(0.950159847736359*x_23) + 0.0269974777347799*std::exp(0.962879776954651*x_23) - 0.000303524721195516*std::exp(0.975839853286743*x_23) - 18.5267160908624*std::exp(0.986719846725464*x_23) + 0.0235542222883227*std::exp(0.98831981420517*x_23) - 1.530235931615*std::exp(0.990399777889252*x_23) + 690.299027193827*std::exp(0.99375981092453*x_23) - 2.80913126772208*std::exp(0.89711982011795*x_24) - 0.0269762902569746*std::exp(0.718399822711945*x_3) - 0.0215543910803486*std::exp(0.794319868087769*x_3) + 1233.79639908842*std::exp(0.923119843006134*x_4) - 0.00152479899988175*std::exp(1.00055980682373*x_4) + 0.000502084360994579*std::exp(1.02503991127014*x_4) - 0.0325311293967969*std::exp(1.15319991111755*x_5) - 267.842226652532*std::exp(1.24023985862732*x_5) + 0.00112875793016582*std::exp(1.30663979053497*x_5) + 0.000252370669014353*std::exp(1.31983983516693*x_5) - 27.221982480163*std::exp(1.36055982112885*x_5) + 0.000567183282107497*std::exp(1.37151992321014*x_6) - 0.00080513855222719*std::exp(1.41087985038757*x_6) + 30.6907343398605*std::exp(1.4119998216629*x_6) - 0.000464621837933639*std::exp(1.42991983890533*x_6) - 6.57775724678495*std::exp(1.55943989753723*x_6) - 6.55555443211371e-5*std::exp(1.5648797750473*x_6) - 0.000618209227459487*std::exp(1.57063984870911*x_6) - 0.0412352432874775*std::exp(1.59999990463257*x_6) - 4.11696675187095e-6*std::exp(1.60359990596771*x_6) - 1.84908011120789e-5*std::exp(1.62815988063812*x_6) - 0.000616782806193784*std::exp(0.824719905853271*x_8) + 0.000279421081207972*std::exp(0.893279850482941*x_8) - 0.00961051003892698*std::sin(0.265359938144684*x_112 - 7.43232011795044) + 0.29334903923615*std::sin(0.280159950256348*x_112 + 1.97079980373383) - 0.270164652437639*std::sin(0.237199977040291*x_119 - 7.42303991317749) + 0.499551295180238*std::sin(0.259919971227646*x_13 + 1.96463978290558) + 34559.3799382889*std::sin(0.418079853057861*x_13 + 1.95319974422455) + 0.145050311810471*std::sin(0.146480038762093*x_16 + 4.95879936218262) - 65.7890357718441*std::sin(0.340079843997955*x_16 + 2.02335977554321) + 1.71156509811436*std::sin(0.37679985165596*x_17 - 1.17199981212616) - 1.5724764284157*std::sin(0.254799991846085*x_30 - 4.37439966201782) + 0.0482942761360099*std::sin(0.341839849948883*x_91 - 7.40503978729248) - 0.0452115393512152*std::sin(0.362159848213196*x_91 + 2.00823974609375) - 60.2355127147234*std::sin(0.379199832677841*x_91 + 1.98599982261658) + 0.111841224007452*std::sin(0.298959940671921*x_94 + 1.94983983039856) - 0.053378909427654*std::sin(0.275999963283539*x_97 + 1.97351980209351) - 15244733.1073722 + 8.21549039357993e-7*std::exp(-6.1448802947998*x_93) + 6.00986632994884e-6*std::exp(-6.05551958084106*x_93) - 0.996681898786194*std::exp(-6.03623962402344*x_93) + 0.0212119664780009*std::exp(-5.91943979263306*x_93) - 1.91201824610979e-5*std::exp(-5.78344011306763*x_93) + 0.000270780481865151*std::exp(-7.94063997268677*x_113));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2015209.21085583*x_1 + 13761221.8017007*x_10 - 863725.161183492*x_100 - 123807.646019856*x_101 - 218417.353380237*x_102 + 79281.7250155213*x_103 - 15015796.4924493*x_104 - 475704.281057241*x_105 + 2201708.36246246*x_106 + 221000.234596584*x_107 + 444663.035747417*x_108 + 179504.938242747*x_109 - 5383729.17747631*x_11 + 725565.763797877*x_110 - 304040.480135475*x_111 + 752379.575322332*x_112 + 27972.3566059512*x_113 + 662615.349736374*x_114 - 660203.621466755*x_115 + 1103686.59475108*x_116 - 273981.285987093*x_117 - 13310.4544837596*x_118 - 356202.567833701*x_119 - 1319987.08589928*x_12 + 429975.514941072*x_120 - 7002.64436691961*x_13 - 915468.562760371*x_14 - 5020065.60338305*x_15 + 1153320.58079681*x_16 + 2315856.58401044*x_17 - 6061262.29844246*x_18 + 792050.568895827*x_19 - 575960.984715758*x_2 - 1797707.67067085*x_20 + 2290106.08022341*x_21 + 369537.487879525*x_22 + 6398365.94490379*x_23 + 26981163.3832607*x_24 + 2032680.39507881*x_25 - 3148813.54643341*x_26 - 8367174.92292613*x_27 - 4666274.31687985*x_28 + 2057317.83052384*x_29 + 140674.422026597*x_3 + 5111560.31704723*x_30 + 507925.479601299*x_31 - 495775.287161285*x_32 - 495326.2580875*x_33 + 9132666.80009801*x_34 + 932788.955958329*x_35 + 3538319.69896614*x_36 + 25877858.0039463*x_37 - 255278.046740111*x_38 + 17520001.1299627*x_39 + 79878.6561558829*x_4 - 872711.757535961*x_40 - 825770053.323008*x_41 + 19257572.6952644*x_42 - 24715833.7639723*x_43 + 38188.4415601014*x_44 + 60405345.7968066*x_45 + 40891430.5441968*x_46 + 11077605.7398537*x_47 + 1276915.22962081*x_48 + 8395495.35642895*x_49 - 50.0512971774828*x_5 - 9619158.236136*x_50 + 1681119.16856339*x_51 - 8969681.06009078*x_52 - 29027.5012447441*x_53 + 828066.17621346*x_54 - 7169369.72605848*x_55 + 13838168.7411007*x_56 + 4843948.24217193*x_57 + 12415045.1201681*x_58 + 55753212.0224616*x_59 + 29.9433059673415*x_6 + 2553352.90783115*x_60 + 703013.452758684*x_61 + 2262145.58721319*x_62 + 617698.800887996*x_63 - 145078.087505424*x_64 + 17090.3384563492*x_65 - 1506344.06915243*x_66 - 457542.684029361*x_67 - 435475.103834413*x_68 - 81066.8836396138*x_69 + 443062.924716308*x_7 + 209789.481924173*x_70 - 505205.604235662*x_71 + 28246.909006691*x_72 - 1380011.21173908*x_73 + 758346.016965733*x_74 - 148907.084882984*x_75 - 1862003.40198348*x_76 - 370602.30697555*x_77 + 826457.793350616*x_78 - 300228.79681247*x_79 - 1154277.5211133*x_8 - 238616.966420145*x_80 + 40848.5940950255*x_81 - 403343.092051315*x_82 + 1517592.55331728*x_83 + 1985819.14418574*x_84 + 18836798.2361271*x_85 + 1238592.29946012*x_86 + 35230992.9672961*x_87 - 386636.941292202*x_88 - 1663792.95920962*x_89 - 463642.072530241*x_9 + 1928331.8507183*x_90 + 253799.988632766*x_91 - 670780.53551298*x_92 - 769603.158945734*x_93 - 569851.051403186*x_94 - 679374.827422479*x_95 + 289059.013281827*x_96 - 585528.069645077*x_97 - 4608.2809731587*x_98 + 733046.278987356*x_99 - 0.0906206996475441*std::pow(-4.41967964172363*x_3 - 7.02008008956909, 2) - 127.053002288126*std::exp(1.08199977874756*x_1) + 0.000242601336470037*std::exp(0.801279902458191*x_13) + 0.508627934274787*std::exp(0.647039830684662*x_22) + 0.00127525784781472*std::exp(0.950159847736359*x_23) + 0.22519689324059*std::exp(0.962879776954651*x_23) + 0.00160611784178614*std::exp(0.975839853286743*x_23) + 9.17543963944962*std::exp(0.986719846725464*x_23) + 0.169745434110813*std::exp(0.98831981420517*x_23) - 0.720364060264652*std::exp(0.990399777889252*x_23) - 2293.56046958012*std::exp(0.99375981092453*x_23) + 9.13693755830516*std::exp(0.89711982011795*x_24) - 0.225020159909269*std::exp(0.718399822711945*x_3) - 0.0260365794727874*std::exp(0.794319868087769*x_3) + 77597.9384484604*std::exp(0.923119843006134*x_4) - 0.00515744919398426*std::exp(1.00055980682373*x_4) - 0.0026568071526396*std::exp(1.02503991127014*x_4) - 0.465413018328974*std::exp(1.15319991111755*x_5) - 16845.5708194949*std::exp(1.24023985862732*x_5) - 0.00168767057434861*std::exp(1.30663979053497*x_5) + 0.000853613429438425*std::exp(1.31983983516693*x_5) + 90.4466911592117*std::exp(1.36055982112885*x_5) + 5.55033985882518e-5*std::exp(1.37151992321014*x_6) - 0.000972565349840966*std::exp(1.41087985038757*x_6) + 1930.25179519256*std::exp(1.4119998216629*x_6) - 0.00387559887861656*std::exp(1.42991983890533*x_6) + 21.854998204255*std::exp(1.55943989753723*x_6) - 3.27902757948958e-5*std::exp(1.5648797750473*x_6) + 0.000924319992880048*std::exp(1.57063984870911*x_6) + 0.134121124010243*std::exp(1.59999990463257*x_6) + 2.1785157163396e-5*std::exp(1.60359990596771*x_6) + 2.84816580005992e-5*std::exp(1.62815988063812*x_6) - 0.000308509044201818*std::exp(0.824719905853271*x_8) - 0.00147857209828459*std::exp(0.893279850482941*x_8) + 0.0508545451632013*std::sin(0.265359938144684*x_112 - 7.43232011795044) + 0.35435032912163*std::sin(0.280159950256348*x_112 + 1.97079980373383) - 2.25355275741192*std::sin(0.237199977040291*x_119 - 7.42303991317749) + 0.603431892332716*std::sin(0.259919971227646*x_13 + 1.96463978290558) + 2173564.9733211*std::sin(0.418079853057861*x_13 + 1.95319974422455) + 0.49061523111708*std::sin(0.146480038762093*x_16 + 4.95879936218262) + 213.984415315658*std::sin(0.340079843997955*x_16 + 2.02335977554321) + 24.4868436218007*std::sin(0.37679985165596*x_17 - 1.17199981212616) - 22.4969441384404*std::sin(0.254799991846085*x_30 - 4.37439966201782) + 0.0241563494013125*std::sin(0.341839849948883*x_91 - 7.40503978729248) + 0.0696400114671492*std::sin(0.362159848213196*x_91 + 2.00823974609375) + 195.921110839799*std::sin(0.379199832677841*x_91 + 1.98599982261658) + 0.805992950573515*std::sin(0.298959940671921*x_94 + 1.94983983039856) - 0.0266996358567216*std::sin(0.275999963283539*x_97 + 1.97351980209351) - 1036563664.47139 - 4.34727215897902e-6*std::exp(-6.1448802947998*x_93) + 4.33105944504428e-5*std::exp(-6.05551958084106*x_93) + 3.3115361803345*std::exp(-6.03623962402344*x_93) - 0.0105053219954571*std::exp(-5.91943979263306*x_93) + 2.85876789463893e-5*std::exp(-5.78344011306763*x_93) + 0.000127470884277913*std::exp(-7.94063997268677*x_113));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-2163571.31361739*x_1 - 14525393.9890149*x_10 + 930397.612140866*x_100 + 134542.444943944*x_101 + 234222.904368296*x_102 - 91770.5238091185*x_103 + 16082659.2722294*x_104 + 503227.146704485*x_105 - 2382554.89665028*x_106 - 240651.065905835*x_107 - 486719.487624105*x_108 - 197711.470970051*x_109 + 5815181.91643509*x_11 - 786848.700215777*x_110 + 320856.859673507*x_111 - 801752.605740802*x_112 - 33176.7969853683*x_113 - 708722.759495944*x_114 + 700914.065069672*x_115 - 1219562.02891475*x_116 + 282422.362364082*x_117 + 3677.38399602705*x_118 + 377003.206651531*x_119 + 1401464.77895726*x_12 - 457226.223543847*x_120 + 1084.1527349018*x_13 + 962066.337914462*x_14 + 5357752.71412506*x_15 - 1241726.39963149*x_16 - 2469512.48493562*x_17 + 6372101.15419367*x_18 - 867429.087165408*x_19 + 611927.420464728*x_2 + 1869060.53556054*x_20 - 2467065.73479498*x_21 - 341106.320757662*x_22 - 6851951.55318957*x_23 - 28724444.3474382*x_24 - 2192001.46882065*x_25 + 3323387.85291404*x_26 + 8969880.66736459*x_27 + 4499099.66482978*x_28 - 2515631.29600147*x_29 - 157562.727815926*x_3 - 5431622.44511206*x_30 - 545460.290759513*x_31 + 527224.625121843*x_32 + 558188.854251421*x_33 - 9214167.10424299*x_34 - 991696.345462531*x_35 - 3834311.00714366*x_36 - 27652055.7643091*x_37 + 298672.328070885*x_38 - 18772137.4443278*x_39 - 13133.860860386*x_4 + 927691.358580936*x_40 + 886118275.305294*x_41 - 20890323.4117581*x_42 + 26359031.9716151*x_43 - 55412.4156038789*x_44 - 64238490.5257363*x_45 - 43853969.2760923*x_46 - 11417916.4414145*x_47 - 1367393.8564704*x_48 - 8566973.3032607*x_49 + 47.3135425847292*x_5 + 10289749.7050742*x_50 - 1849945.44824823*x_51 + 9549442.65269251*x_52 + 116971.850882702*x_53 - 871694.011927246*x_54 + 7434729.63008174*x_55 - 15101936.1418539*x_56 - 5187469.31705347*x_57 - 13173611.8977284*x_58 - 59621816.9991054*x_59 - 6.03317967374837*x_6 - 2684815.35278315*x_60 - 752293.903561315*x_61 - 2423583.14264481*x_62 - 662474.854352493*x_63 + 157373.035153583*x_64 - 14380.4693801378*x_65 + 1597036.16355742*x_66 + 494133.032659161*x_67 + 468124.535865538*x_68 + 90156.227943355*x_69 - 465502.504180189*x_7 - 229613.006574367*x_70 + 543966.886275824*x_71 - 32996.8341077143*x_72 + 1481300.419548*x_73 - 802804.979190233*x_74 + 156087.945537924*x_75 + 2005998.51843043*x_76 + 396749.178213217*x_77 - 896775.175987685*x_78 + 325241.257730276*x_79 + 1225069.73443232*x_8 + 247105.284501558*x_80 - 47145.9266438214*x_81 + 429700.851408053*x_82 - 1639892.36216931*x_83 - 2135849.5042663*x_84 - 19920747.6483826*x_85 - 1326863.53087832*x_86 - 37363592.9750176*x_87 + 412511.485581063*x_88 + 1813304.046684*x_89 + 497733.175918692*x_9 - 2050571.01545662*x_90 - 275939.794729064*x_91 + 713154.579877745*x_92 + 824133.93897325*x_93 + 600896.045625319*x_94 + 717176.284533117*x_95 - 312505.432324302*x_96 + 630815.075070734*x_97 + 10709.7421990406*x_98 - 784459.425895215*x_99 + 0.00313964447287446*std::pow(-4.41967964172363*x_3 - 7.02008008956909, 2) + 122.685223071002*std::exp(1.08199977874756*x_1) + 0.000636588371396301*std::exp(0.801279902458191*x_13) + 3.33502292638065*std::exp(0.647039830684662*x_22) + 0.0111173231326746*std::exp(0.950159847736359*x_23) - 0.759448887506648*std::exp(0.962879776954651*x_23) + 0.00262372554288459*std::exp(0.975839853286743*x_23) - 0.294980417583816*std::exp(0.986719846725464*x_23) - 0.689501807021055*std::exp(0.98831981420517*x_23) - 4.72335570744596*std::exp(0.990399777889252*x_23) + 378.056982792778*std::exp(0.99375981092453*x_23) - 8.82283143521781*std::exp(0.89711982011795*x_24) + 0.758852876034527*std::exp(0.718399822711945*x_3) - 0.0800147638683842*std::exp(0.794319868087769*x_3) - 83095.8056892632*std::exp(0.923119843006134*x_4) + 0.00174124389115739*std::exp(1.00055980682373*x_4) - 0.00434011291546761*std::exp(1.02503991127014*x_4) + 0.0161246979584535*std::exp(1.15319991111755*x_5) + 18039.0910832147*std::exp(1.24023985862732*x_5) + 0.00827441207608623*std::exp(1.30663979053497*x_5) - 0.000288194631399039*std::exp(1.31983983516693*x_5) - 14.9086992110139*std::exp(1.36055982112885*x_5) + 0.000483862317040122*std::exp(1.37151992321014*x_6) - 0.00298885600143567*std::exp(1.41087985038757*x_6) - 2067.01146076459*std::exp(1.4119998216629*x_6) + 0.0130699816255584*std::exp(1.42991983890533*x_6) - 3.60244902614443*std::exp(1.55943989753723*x_6) - 8.60420167903168e-5*std::exp(1.5648797750473*x_6) - 0.00453181125955614*std::exp(1.57063984870911*x_6) - 0.129510359624677*std::exp(1.59999990463257*x_6) + 3.55878453113953e-5*std::exp(1.60359990596771*x_6) - 2.59559624004924e-5*std::exp(1.62815988063812*x_6) - 0.000809530866016975*std::exp(0.824719905853271*x_8) - 0.00241536908459441*std::exp(0.893279850482941*x_8) + 0.0830750805732196*std::sin(0.265359938144684*x_112 - 7.43232011795044) + 1.08897783370452*std::sin(0.280159950256348*x_112 + 1.97079980373383) + 7.59983013054081*std::sin(0.237199977040291*x_119 - 7.42303991317749) + 1.85444714141959*std::sin(0.259919971227646*x_13 + 1.96463978290558) - 2327563.54469444*std::sin(0.418079853057861*x_13 + 1.95319974422455) - 0.165640172488337*std::sin(0.146480038762093*x_16 + 4.95879936218262) - 206.628141436472*std::sin(0.340079843997955*x_16 + 2.02335977554321) - 0.848371106539026*std::sin(0.37679985165596*x_17 - 1.17199981212616) + 0.77942905534314*std::sin(0.254799991846085*x_30 - 4.37439966201782) + 0.06338650622463*std::sin(0.341839849948883*x_91 - 7.40503978729248) - 0.0634644766527692*std::sin(0.362159848213196*x_91 + 2.00823974609375) - 189.185810290337*std::sin(0.379199832677841*x_91 + 1.98599982261658) - 3.27392367740435*std::sin(0.298959940671921*x_94 + 1.94983983039856) - 0.0700601157199474*std::sin(0.275999963283539*x_97 + 1.97351980209351) + 1105558641.30992 - 7.10162648632295e-6*std::exp(-6.1448802947998*x_93) - 0.000175926576718649*std::exp(-6.05551958084106*x_93) - 0.545854096001043*std::exp(-6.03623962402344*x_93) + 0.000337734690744287*std::exp(-5.91943979263306*x_93) - 0.000140161379534972*std::exp(-5.78344011306763*x_93) + 0.000835813947417175*std::exp(-7.94063997268677*x_113));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
