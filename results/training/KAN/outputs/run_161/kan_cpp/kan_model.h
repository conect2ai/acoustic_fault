
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-7492292416.97162*x_1 - 28302078271.7827*x_10 + 3603731174.12281*x_100 + 792012612.468704*x_101 + 483147799.235313*x_102 - 383359604.23339*x_103 + 59227330319.2727*x_104 + 1626973290.02979*x_105 - 8329814017.72002*x_106 + 228218269.724239*x_107 - 1730795955.95054*x_108 - 640697278.38439*x_109 + 10838233143.6872*x_11 - 2750541284.36321*x_110 + 950560698.185268*x_111 - 3021334688.48115*x_112 - 161516479.916542*x_113 - 2615301246.28949*x_114 + 2566560303.35172*x_115 - 3655123709.3397*x_116 + 2095603552.94922*x_117 + 303476727.875628*x_118 + 1574032513.37633*x_119 + 9716266746.15315*x_12 - 1399324636.86827*x_120 - 3279.45901170548*x_13 + 1724985037.78984*x_14 + 14971781563.9967*x_15 - 5620066528.80107*x_16 - 9141501034.88688*x_17 + 22810144275.4067*x_18 - 4656086602.00106*x_19 + 2548410542.97037*x_2 + 2591357645.29198*x_20 - 7599650197.4234*x_21 - 5937367165.47422*x_22 - 18052357819.2383*x_23 - 125895166480.119*x_24 - 8558089087.3087*x_25 + 7082086404.18466*x_26 + 25989868906.7192*x_27 + 24166338533.8692*x_28 - 3769745836.69947*x_29 + 484394880.308157*x_3 - 19974822561.009*x_30 - 1817203740.15512*x_31 + 2351019719.38815*x_32 + 5450099016.5986*x_33 - 259661739.928893*x_34 - 4030436096.46411*x_35 - 13439535209.6928*x_36 - 117491667527.271*x_37 + 1001920752.7631*x_38 - 82412586957.1599*x_39 + 108318.250454447*x_4 + 2181325804.18407*x_40 + 3155057254821.21*x_41 + 69016037726.0582*x_42 + 51718387705.8652*x_43 + 287850580.137565*x_44 - 172043712067.744*x_45 - 148006603019.543*x_46 + 12703499754.0124*x_47 + 11552523902.9777*x_48 + 44565498996.828*x_49 + 104.041581311039*x_5 + 41700889271.9934*x_50 - 2548893140.11363*x_51 + 35456533152.2941*x_52 + 8295217610.4948*x_53 - 3741026657.83565*x_54 + 9880080739.0336*x_55 - 31326029569.5997*x_56 - 17565579625.2532*x_57 - 63722573484.868*x_58 + 43162417176.9435*x_59 - 52.566395552554*x_6 + 13761466304.771*x_60 - 2426104679.65787*x_61 - 9501166203.05454*x_62 - 2171657720.4868*x_63 + 546531223.853583*x_64 + 192366913.380729*x_65 + 6392254282.66161*x_66 + 1928907127.01295*x_67 + 1813277924.70986*x_68 + 426103853.888979*x_69 - 1454604006.26321*x_7 - 934631765.959354*x_70 + 2043078187.8301*x_71 + 17287178.8262011*x_72 + 5173169005.26924*x_73 - 2983416676.87716*x_74 + 504967805.449365*x_75 + 7702728270.65944*x_76 + 1366844822.09863*x_77 - 2967587130.5007*x_78 + 1199739587.2761*x_79 + 5184811956.69267*x_8 + 1199254515.55471*x_80 + 288630646.774868*x_81 + 1814414546.2058*x_82 - 5810197879.56904*x_83 - 7583088421.29456*x_84 - 67324139801.2734*x_85 - 4714404047.28547*x_86 - 120112680270.45*x_87 + 1521291959.04353*x_88 + 6674680309.35773*x_89 + 2787937729.68097*x_9 - 7308504762.83966*x_90 - 942635724.174545*x_91 + 3638229995.61066*x_92 + 2861760492.2925*x_93 + 1934586458.58807*x_94 + 2431423854.97599*x_95 - 1149369436.19231*x_96 + 1944442030.32054*x_97 + 232271915.456581*x_98 - 2537002016.39206*x_99 - 39.9287733150289*std::exp(1.02479982376099*x_1) + 9.41059761012945e-5*std::exp(0.983519792556763*x_13) - 1.8112838651336*std::exp(0.301039844751358*x_16) + 425.403675149051*std::exp(0.385279834270477*x_18) - 11.1861142464799*std::exp(0.316879838705063*x_20) - 30.1002646622268*std::exp(0.957519829273224*x_23) - 0.000179952936999594*std::exp(0.975119829177856*x_23) + 2.76778853875205*std::exp(0.976639807224274*x_23) + 0.00158086677166816*std::exp(0.977119863033295*x_23) - 6.95427506626632*std::exp(0.98991984128952*x_23) - 0.0573602760512292*std::exp(0.994559824466705*x_23) - 109.181860796052*std::exp(0.997679829597473*x_23) - 0.00120604715707626*std::exp(0.916079819202423*x_24) - 99.347926708536*std::exp(0.69599986076355*x_3) + 0.000570786102217085*std::exp(0.743999838829041*x_3) + 17.0037919790925*std::exp(0.807439863681793*x_3) - 4.57704459683994*std::exp(0.713839828968048*x_4) - 409938333.96195*std::exp(0.738399803638458*x_4) + 0.1350178099702*std::exp(1.01455986499786*x_4) + 106533421.350023*std::exp(1.04143977165222*x_5) + 0.00141496220512746*std::exp(1.13007986545563*x_5) - 9.92354894840229*std::exp(1.25863993167877*x_5) - 1.91458413280535*std::exp(1.26903986930847*x_5) + 203.277876037219*std::exp(1.30655980110168*x_5) - 0.0236410880906647*std::exp(1.31783986091614*x_5) - 0.595513267250433*std::exp(1.35319983959198*x_5) + 1.1840312225843e-5*std::exp(1.38263988494873*x_5) - 7.96321492127793e-5*std::exp(1.41631984710693*x_5) - 0.999569722039445*std::exp(1.38239991664886*x_6) + 0.0590231283161135*std::exp(1.39495980739594*x_6) + 1.58544904442603e-5*std::exp(1.45247983932495*x_6) + 46.9598744382543*std::exp(1.46871984004974*x_6) + 0.411205914711278*std::exp(1.47207987308502*x_6) - 7.26133877500071e-5*std::exp(1.5525598526001*x_6) + 0.334977675822006*std::exp(1.56399989128113*x_6) + 1.12707981295e-5*std::exp(1.56935977935791*x_6) - 2709432.32509875*std::exp(1.57631981372833*x_6) - 5.26153712945079e-5*std::exp(1.65167987346649*x_6) - 0.000234032414384754*std::exp(1.00479984283447*x_8) - 174.602073160762*std::exp(1.01079976558685*x_8) - 0.0310191117314484*std::sin(0.269519954919815*x_112 + 1.9722398519516) + 145.199965047191*std::sin(0.220639988780022*x_119 - 7.42039966583252) - 10026169229.7772*std::sin(0.375439822673798*x_13 + 8.22991943359375) - 0.179473692286329*std::sin(0.127600058913231*x_16 + 4.94623994827271) + 2235.22309137774*std::sin(0.262719959020615*x_17 + 5.04127979278564) - 5.0136438431055*std::sin(0.318879932165146*x_6 + 1.99967980384827) - 17.0400714885015*std::sin(0.306959927082062*x_8 - 7.41688013076782) - 0.0323244133149048*std::sin(0.342959851026535*x_91 + 2.01231980323792) - 0.167141708873391*std::sin(0.361199855804443*x_91 + 1.99959981441498) + 81.3519546942017*std::sin(0.376159846782684*x_91 + 2.00047969818115) + 89.7805707484502*std::sin(0.406799852848053*x_91 - 1.17383992671967) - 0.435479006619329*std::sin(0.288879930973053*x_94 + 1.97015976905823) + 0.824806267994496*std::sin(0.283439934253693*x_95 + 1.95063984394073) - 207.04526445483*std::sin(0.265279948711395*x_96 + 1.97727978229523) + 6333381362441.62 - 0.00551419205048051*std::exp(-4.160560131073*x_94) + 0.00951492906948153*std::exp(-6.41871976852417*x_93) - 0.00355551811249352*std::exp(-6.35647964477539*x_93) + 0.138876272949241*std::exp(-6.33199977874756*x_93) + 0.000704514232777464*std::exp(-7.98184013366699*x_113) + 0.972447098764403*std::exp(-7.9015998840332*x_113));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-6117485184.39971*x_1 - 23109627865.5033*x_10 + 2942429695.05987*x_100 + 646665445.870203*x_101 + 394475839.718746*x_102 - 312998994.37058*x_103 + 48359368718.2409*x_104 + 1328449038.12244*x_105 - 6801256061.62165*x_106 + 186344609.159*x_107 - 1413170209.61228*x_108 - 523117638.022689*x_109 + 8849506144.35622*x_11 - 2245798098.96498*x_110 + 776146002.645456*x_111 - 2466963212.76927*x_112 - 131879608.290736*x_113 - 2135426407.77413*x_114 + 2095624741.25997*x_115 - 2984257853.44515*x_116 + 1711108393.14522*x_117 + 247822137.106351*x_118 + 1285207424.91978*x_119 + 7933409324.99513*x_12 - 1142583112.79957*x_120 + 7099.20631263835*x_13 + 1408480250.05628*x_14 + 12224727150.2262*x_15 - 4588798449.07886*x_16 - 7464126532.7523*x_17 + 18625218892.3601*x_18 - 3801642668.61138*x_19 + 2080803987.9452*x_2 + 2116039653.99154*x_20 - 6205108029.89723*x_21 - 4848128454.61283*x_22 - 14739565742.9971*x_23 - 102795055941.467*x_24 - 6987646885.79575*x_25 + 5782773811.0972*x_26 + 21220677143.9077*x_27 + 19734774970.0928*x_28 - 3076433188.72571*x_29 + 395529475.711469*x_3 - 16309704195.419*x_30 - 1483755508.65751*x_31 + 1919618919.29268*x_32 + 4449848845.3349*x_33 - 213736148.886165*x_34 - 3290919821.67554*x_35 - 10973252500.9164*x_36 - 95932477582.075*x_37 + 817979177.478361*x_38 - 67290158386.1523*x_39 - 225183.299582196*x_4 + 1780977571.07978*x_40 + 2576116791131.55*x_41 + 56355213816.7864*x_42 + 42228695576.7348*x_43 + 235083771.584932*x_44 - 140475895340.534*x_45 - 120848846061.442*x_46 + 10370549902.1507*x_47 + 9432672011.79501*x_48 + 36386079075.9226*x_49 + 51.8706460057241*x_5 + 34049331885.5117*x_50 - 2080789814.09938*x_51 + 28950894481.2521*x_52 + 6772849764.74345*x_53 - 3054511785.20745*x_54 + 8067831584.08064*x_55 - 25576578624.6632*x_56 - 14342378600.387*x_57 - 52030067590.4447*x_58 + 35241102186.436*x_59 - 31.4236305544313*x_6 + 11235807594.9819*x_60 - 1980926277.67658*x_61 - 7757747654.94014*x_62 - 1773166491.40552*x_63 + 446231018.982298*x_64 + 157045564.875641*x_65 + 5219376129.09312*x_66 + 1574948955.28527*x_67 + 1480545100.08734*x_68 + 347902339.128405*x_69 - 1187751085.15823*x_7 - 763115549.736861*x_70 + 1668175694.11282*x_71 + 14128274.6653095*x_72 + 4223912583.25829*x_73 - 2436018120.4492*x_74 + 412317016.568511*x_75 + 6289276471.00178*x_76 + 1116037371.29415*x_77 - 2423012734.99965*x_78 + 979576350.401268*x_79 + 4233427565.77762*x_8 + 979226675.376416*x_80 + 235680331.087562*x_81 + 1481483492.10051*x_82 - 4744007382.36751*x_83 - 6191605228.37734*x_84 - 54971533132.3058*x_85 - 3849361994.36431*x_86 - 98074134785.1561*x_87 + 1242143238.70178*x_88 + 5449794302.64776*x_89 + 2276339325.86074*x_9 - 5967502908.11283*x_90 - 769661024.154041*x_91 + 2970649937.6188*x_92 + 2336638777.99723*x_93 + 1579626755.65392*x_94 + 1985306230.29289*x_95 - 938465439.470034*x_96 + 1587624427.59516*x_97 + 189615145.186476*x_98 - 2071482128.40021*x_99 + 205.505646262892*std::exp(1.02479982376099*x_1) + 0.000130542205607306*std::exp(0.983519792556763*x_13) - 1.67026614944062*std::exp(0.301039844751358*x_16) - 223.583141196339*std::exp(0.385279834270477*x_18) + 6.11922662978064*std::exp(0.316879838705063*x_20) + 2.7630175688189*std::exp(0.957519829273224*x_23) + 0.000833274304106106*std::exp(0.975119829177856*x_23) - 1.5140847803573*std::exp(0.976639807224274*x_23) + 0.00219295143299644*std::exp(0.977119863033295*x_23) + 67.3250235723738*std::exp(0.98991984128952*x_23) + 0.00384389200281012*std::exp(0.994559824466705*x_23) + 93.3595910580019*std::exp(0.997679829597473*x_23) + 0.00207510568881172*std::exp(0.916079819202423*x_24) + 52.215161321903*std::exp(0.69599986076355*x_3) - 0.00264303211744442*std::exp(0.743999838829041*x_3) - 1.56084262055451*std::exp(0.807439863681793*x_3) + 23.5571601568244*std::exp(0.713839828968048*x_4) - 334716931.6071*std::exp(0.738399803638458*x_4) + 0.124505982693219*std::exp(1.01455986499786*x_4) + 86985131.5519952*std::exp(1.04143977165222*x_5) - 9.4821055249288e-5*std::exp(1.13007986545563*x_5) + 5.21560667035144*std::exp(1.25863993167877*x_5) + 1.6371290100902*std::exp(1.26903986930847*x_5) - 429.563400511835*std::exp(1.30655980110168*x_5) - 0.0218005084315531*std::exp(1.31783986091614*x_5) - 0.25775759861788*std::exp(1.35319983959198*x_5) - 5.48267124443242e-5*std::exp(1.38263988494873*x_5) + 0.000137013818136543*std::exp(1.41631984710693*x_5) + 0.854715424367794*std::exp(1.38239991664886*x_6) - 0.0322878785793358*std::exp(1.39495980739594*x_6) - 7.34144144139626e-5*std::exp(1.45247983932495*x_6) - 99.2348195708808*std::exp(1.46871984004974*x_6) - 0.0377461520521214*std::exp(1.47207987308502*x_6) + 0.000124937448025843*std::exp(1.5525598526001*x_6) + 0.144989282454002*std::exp(1.56399989128113*x_6) + 1.56346590060967e-5*std::exp(1.56935977935791*x_6) - 2212266.57553407*std::exp(1.57631981372833*x_6) - 2.84800701510391e-5*std::exp(1.65167987346649*x_6) - 0.000324645775147201*std::exp(1.00479984283447*x_8) + 368.966174506961*std::exp(1.01079976558685*x_8) - 0.0430291829399242*std::sin(0.269519954919815*x_112 + 1.9722398519516) - 13.3284560424726*std::sin(0.220639988780022*x_119 - 7.42039966583252) - 8186422986.91693*std::sin(0.375439822673798*x_13 + 8.22991943359375) + 0.308799600140226*std::sin(0.127600058913231*x_16 + 4.94623994827271) - 1174.78580755026*std::sin(0.262719959020615*x_17 + 5.04127979278564) - 4.62330601938689*std::sin(0.318879932165146*x_6 + 1.99967980384827) + 9.32156215538539*std::sin(0.306959927082062*x_8 - 7.41688013076782) + 0.0556168749817954*std::sin(0.342959851026535*x_91 + 2.01231980323792) - 0.0904718046601639*std::sin(0.361199855804443*x_91 + 1.99959981441498) - 418.702720774264*std::sin(0.376159846782684*x_91 + 2.00047969818115) + 38.8599643220566*std::sin(0.406799852848053*x_91 - 1.17383992671967) + 0.0291828140687594*std::sin(0.288879930973053*x_94 + 1.97015976905823) - 0.0552728549384964*std::sin(0.283439934253693*x_95 + 1.95063984394073) + 1065.62178962423*std::sin(0.265279948711395*x_96 + 1.97727978229523) + 5171284027542.64 + 0.0533834377046742*std::exp(-4.160560131073*x_94) + 0.00411837217211425*std::exp(-6.41871976852417*x_93) + 0.00194500258420697*std::exp(-6.35647964477539*x_93) - 0.118750788415482*std::exp(-6.33199977874756*x_93) - 0.00682047185031481*std::exp(-7.98184013366699*x_113) - 2.05495890997317*std::exp(-7.9015998840332*x_113));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-18838248503.8231*x_1 - 71162133709.2449*x_10 + 9061014589.55113*x_100 + 1991382883.37717*x_101 + 1214789032.68198*x_102 - 963885643.224538*x_103 + 148918307449.249*x_104 + 4090798895.21967*x_105 - 20944010633.4559*x_106 + 573824681.804314*x_107 - 4351798968.78802*x_108 - 1610925298.0235*x_109 + 27251162299.8435*x_11 - 6915798348.83799*x_110 + 2390052148.2531*x_111 - 7596724031.18455*x_112 - 406110093.110232*x_113 - 6575805278.94969*x_114 + 6453249228.86314*x_115 - 9190109136.55056*x_116 + 5269118305.69274*x_117 + 763076071.552014*x_118 + 3957673345.38891*x_119 + 24430140558.3484*x_12 - 3518419176.03451*x_120 + 591.274269783891*x_13 + 4337238148.65583*x_14 + 37644511426.8001*x_15 - 14130810556.0356*x_16 - 22984990287.0632*x_17 + 57353297450.304*x_18 - 11706964891.9589*x_19 + 6407613690.82906*x_2 + 6515761344.1735*x_20 - 19108147059.7421*x_21 - 14928826761.9013*x_22 - 45389738520.7536*x_23 - 316545661633.531*x_24 - 21517975662.7646*x_25 + 17807048121.9425*x_26 + 65347507436.3373*x_27 + 60765265261.8951*x_28 - 9476980404.83649*x_29 + 1217955913.37669*x_3 - 50223879065.9401*x_30 - 4569089410.29762*x_31 + 5911289216.08847*x_32 + 13703295678.9492*x_33 - 654463698.929103*x_34 - 10133977042.9343*x_35 - 33791541290.2221*x_36 - 295415332590.111*x_37 + 2519093809.16067*x_38 - 207214097536.615*x_39 - 31555.1720959124*x_4 + 5484538761.46139*x_40 + 7932920335523.33*x_41 + 173533574156.614*x_42 + 130038566986.972*x_43 + 723804912.562461*x_44 - 432579649108.392*x_45 - 372141352744.023*x_46 + 31939299643.4313*x_47 + 29047090245.8271*x_48 + 112051594161.794*x_49 + 108.571448739164*x_5 + 104851022418.46*x_50 - 6408449959.72547*x_51 + 89150612748.1598*x_52 + 20856892386.352*x_53 - 9406207138.0962*x_54 + 24842627134.465*x_55 - 78763489514.0477*x_56 - 44166043610.5048*x_57 - 160221193319.617*x_58 + 108524442205.485*x_59 - 26.8353605609527*x_6 + 34600704512.4301*x_60 - 6100079749.47394*x_61 - 23889268815.6813*x_62 - 5460307702.28292*x_63 + 1374159111.46597*x_64 + 483656618.36476*x_65 + 16072439036.6286*x_66 + 4849939029.4844*x_67 + 4559214115.56021*x_68 + 1071362404.8826*x_69 - 3657442046.15152*x_7 - 2349978733.52918*x_70 + 5137009715.13783*x_71 + 43477837.945299*x_72 + 13007161443.7023*x_73 - 7501397039.38371*x_74 + 1269674016.77136*x_75 + 19367332516.9238*x_76 + 3436730348.53464*x_77 - 7461522895.90958*x_78 + 3016551118.81471*x_79 + 13036441273.3237*x_8 + 3015373517.41823*x_80 + 725730048.059433*x_81 + 4562080491.25061*x_82 - 14608835546.8056*x_83 - 19066527635.2464*x_84 - 169277539428.213*x_85 - 11853697773.7619*x_86 - 302006944253.25*x_87 + 3825064053.32246*x_88 + 16782389503.441*x_89 + 7009831113.95241*x_9 - 18376217474.6883*x_90 - 2370112731.88572*x_91 + 9147806618.96525*x_92 + 7195469132.03794*x_93 + 4864256094.63703*x_94 + 6113488293.1555*x_95 - 2889918338.07423*x_96 + 4888990893.63822*x_97 + 583979700.249317*x_98 - 6378922253.38387*x_99 + 343.583864378719*std::exp(1.02479982376099*x_1) - 6.66999809837855e-5*std::exp(0.983519792556763*x_13) - 0.693027789996058*std::exp(0.301039844751358*x_16) - 583.125935842801*std::exp(0.385279834270477*x_18) - 3.22420259453472*std::exp(0.316879838705063*x_20) - 8.08815419370037*std::exp(0.957519829273224*x_23) + 0.00240989522322175*std::exp(0.975119829177856*x_23) + 0.79776683762872*std::exp(0.976639807224274*x_23) - 0.00112047914464716*std::exp(0.977119863033295*x_23) + 73.2026134777811*std::exp(0.98991984128952*x_23) - 0.00148940301713359*std::exp(0.994559824466705*x_23) - 59.9875299644344*std::exp(0.997679829597473*x_23) - 0.000872756132805726*std::exp(0.916079819202423*x_24) + 136.182069220862*std::exp(0.69599986076355*x_3) - 0.00764385802281972*std::exp(0.743999838829041*x_3) + 4.56903927416601*std::exp(0.807439863681793*x_3) + 39.3850985004864*std::exp(0.713839828968048*x_4) - 1030729345.31441*std::exp(0.738399803638458*x_4) + 0.0516600938455627*std::exp(1.01455986499786*x_4) + 267862540.643505*std::exp(1.04143977165222*x_5) + 3.67405654666767e-5*std::exp(1.13007986545563*x_5) + 13.6027944878272*std::exp(1.25863993167877*x_5) - 1.05192540407998*std::exp(1.26903986930847*x_5) - 36.9948354900551*std::exp(1.30655980110168*x_5) - 0.00904547947892588*std::exp(1.31783986091614*x_5) - 0.644999955573895*std::exp(1.35319983959198*x_5) - 0.000158563190744575*std::exp(1.38263988494873*x_5) - 5.76258118815491e-5*std::exp(1.41631984710693*x_5) - 0.549191213771204*std::exp(1.38239991664886*x_6) + 0.0170123886866482*std::exp(1.39495980739594*x_6) - 0.00021232029565777*std::exp(1.45247983932495*x_6) - 8.54629565865188*std::exp(1.46871984004974*x_6) + 0.110493940198477*std::exp(1.47207987308502*x_6) - 5.25466845228934e-5*std::exp(1.5525598526001*x_6) + 0.362814059577584*std::exp(1.56399989128113*x_6) - 7.98846207280767e-6*std::exp(1.56935977935791*x_6) - 6812467.08409063*std::exp(1.57631981372833*x_6) - 3.12161269130121e-5*std::exp(1.65167987346649*x_6) + 0.000165876368704259*std::exp(1.00479984283447*x_8) + 31.7760845337752*std::exp(1.01079976558685*x_8) + 0.0219855767756397*std::sin(0.269519954919815*x_112 + 1.9722398519516) + 39.0162584748086*std::sin(0.220639988780022*x_119 - 7.42039966583252) - 25209320500.3339*std::sin(0.375439822673798*x_13 + 8.22991943359375) - 0.129876153433258*std::sin(0.127600058913231*x_16 + 4.94623994827271) - 3063.95227196943*std::sin(0.262719959020615*x_17 + 5.04127979278564) - 1.91830478882915*std::sin(0.318879932165146*x_6 + 1.99967980384827) - 4.91150380674619*std::sin(0.306959927082062*x_8 - 7.41688013076782) - 0.0233915645788851*std::sin(0.342959851026535*x_91 + 2.01231980323792) - 0.0991633560361114*std::sin(0.361199855804443*x_91 + 1.99959981441498) - 700.026989260792*std::sin(0.376159846782684*x_91 + 2.00047969818115) + 97.2412661963363*std::sin(0.406799852848053*x_91 - 1.17383992671967) - 0.0113075422750387*std::sin(0.288879930973053*x_94 + 1.97015976905823) + 0.0214167195256266*std::sin(0.283439934253693*x_95 + 1.95063984394073) + 1781.60775191982*std::sin(0.265279948711395*x_96 + 1.97727978229523) + 15924495751128.4 + 0.0580439032777999*std::exp(-4.160560131073*x_94) + 0.0103056122585485*std::exp(-6.41871976852417*x_93) - 0.00102481616677787*std::exp(-6.35647964477539*x_93) + 0.0763024601719628*std::exp(-6.33199977874756*x_93) - 0.00741591072831878*std::exp(-7.98184013366699*x_113) - 0.176977057921362*std::exp(-7.9015998840332*x_113));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1549976649.33014*x_1 + 5854001009.38935*x_10 - 745560433.914121*x_100 - 163866416.970672*x_101 - 99970666.2225561*x_102 + 79325326.3874283*x_103 - 12252684957.8769*x_104 - 336560617.596534*x_105 + 1723319950.2501*x_106 - 47209667.9482404*x_107 + 358096113.492588*x_108 + 132561133.949171*x_109 - 2242118662.56523*x_11 + 569055012.980775*x_110 - 196637152.645809*x_111 + 625005234.07893*x_112 + 33413699.9461281*x_113 + 541016366.132523*x_114 - 530938132.833034*x_115 + 756349187.868729*x_116 - 433484775.279241*x_117 - 62744765.5442214*x_118 - 325624683.488314*x_119 - 2010017060.53073*x_12 + 289452991.513065*x_120 + 12183.7372727632*x_13 - 356827539.712057*x_14 - 3097069327.41643*x_15 + 1162665566.64495*x_16 + 1891094664.23246*x_17 - 4718128423.72303*x_18 + 963305916.859431*x_19 - 527186315.205021*x_2 - 535879437.093939*x_20 + 1572221673.33455*x_21 + 1228018623.55491*x_22 + 3734899621.08289*x_23 + 26043369936.9599*x_24 + 1770537705.84456*x_25 - 1464855938.12137*x_26 - 5376852715.84692*x_27 - 4996194338.16185*x_28 + 781644461.037936*x_29 - 100186358.72826*x_3 + 4132101139.88487*x_30 + 375934208.665278*x_31 - 486367110.539591*x_32 - 1127700207.83674*x_33 + 51702353.6043768*x_34 + 833739181.820915*x_35 + 2780526977.07303*x_36 + 24306142736.8135*x_37 - 207376685.022947*x_38 + 17049220157.5882*x_39 - 384419.679116817*x_4 - 451357552.011338*x_40 - 652704623330.092*x_41 - 14273917996.9166*x_42 - 10698822739.7321*x_43 - 59490223.0380283*x_44 + 35589969266.5076*x_45 + 30618023697.2336*x_46 - 2630266845.86176*x_47 - 2389949567.0992*x_48 - 9221584458.55042*x_49 + 38.5207504526803*x_5 - 8626456656.44139*x_50 + 527754677.384072*x_51 - 7334539623.17478*x_52 - 1716344012.80469*x_53 + 773984761.332643*x_54 - 2043131536.56437*x_55 + 6482010480.63835*x_56 + 3633882532.96219*x_57 + 13182268985.4187*x_58 - 8930693887.05111*x_59 - 31.8419738006288*x_6 - 2847468836.41704*x_60 + 501899691.813513*x_61 + 1965552016.11034*x_62 + 449263773.395824*x_63 - 113080129.3446*x_64 - 39821897.274398*x_65 - 1322318541.17693*x_66 - 399057964.920999*x_67 - 375128005.637049*x_68 - 88165894.3291738*x_69 + 300853548.848627*x_7 + 193369949.963381*x_70 - 422670696.385507*x_71 - 3560836.55284813*x_72 - 1070205529.08297*x_73 + 617141581.906901*x_74 - 104455704.698116*x_75 - 1593545429.70556*x_76 - 282763737.337434*x_77 + 613961549.427885*x_78 - 248214873.468054*x_79 - 1072603452.6775*x_8 - 248061060.52665*x_80 - 59696481.7203607*x_81 - 375350437.671081*x_82 + 1202037315.8546*x_83 + 1568777899.43051*x_84 + 13926489404.3877*x_85 + 975263885.335534*x_86 + 24846530569.4*x_87 - 314716043.731285*x_88 - 1380954770.95793*x_89 - 576781995.982421*x_9 + 1511862377.6553*x_90 + 195014509.159358*x_91 - 752639764.941567*x_92 - 592029161.993388*x_93 - 400186028.042519*x_94 - 502958286.806314*x_95 + 237775950.890232*x_96 - 402282023.619623*x_97 - 48091791.1446719*x_98 + 524833459.018125*x_99 + 199.153976266971*std::exp(1.02479982376099*x_1) + 0.000123571076430438*std::exp(0.983519792556763*x_13) - 0.437055083238039*std::exp(0.301039844751358*x_16) - 252.050318420042*std::exp(0.385279834270477*x_18) + 12.2491257030321*std::exp(0.316879838705063*x_20) - 0.505506629368284*std::exp(0.957519829273224*x_23) + 0.000134228418342304*std::exp(0.975119829177856*x_23) - 3.03081025131263*std::exp(0.976639807224274*x_23) + 0.00207584488000926*std::exp(0.977119863033295*x_23) + 26.7119255746385*std::exp(0.98991984128952*x_23) - 0.0363072132886444*std::exp(0.994559824466705*x_23) - 27.6278043687759*std::exp(0.997679829597473*x_23) - 0.000814822858726396*std::exp(0.916079819202423*x_24) + 58.8633291719538*std::exp(0.69599986076355*x_3) - 0.00042575418323148*std::exp(0.743999838829041*x_3) + 0.28556325554895*std::exp(0.807439863681793*x_3) + 22.8290667439271*std::exp(0.713839828968048*x_4) + 84805608.0043054*std::exp(0.738399803638458*x_4) + 0.0325792225675189*std::exp(1.01455986499786*x_4) - 22039001.5323771*std::exp(1.04143977165222*x_5) + 0.000895625650947898*std::exp(1.13007986545563*x_5) + 5.87967104756511*std::exp(1.25863993167877*x_5) - 0.484473844675685*std::exp(1.26903986930847*x_5) - 725.133980343334*std::exp(1.30655980110168*x_5) - 0.00570449387983766*std::exp(1.31783986091614*x_5) - 0.175545458679534*std::exp(1.35319983959198*x_5) - 8.83178907359281e-6*std::exp(1.38263988494873*x_5) - 5.38006288455442e-5*std::exp(1.41631984710693*x_5) - 0.252935025398065*std::exp(1.38239991664886*x_6) - 0.0646320699216692*std::exp(1.39495980739594*x_6) - 1.18259985718434e-5*std::exp(1.45247983932495*x_6) - 167.515527669129*std::exp(1.46871984004974*x_6) + 0.0069058301730767*std::exp(1.47207987308502*x_6) - 4.90586523430009e-5*std::exp(1.5525598526001*x_6) + 0.0987447517686441*std::exp(1.56399989128113*x_6) + 1.4799747208332e-5*std::exp(1.56935977935791*x_6) + 560511.268745717*std::exp(1.57631981372833*x_6) - 2.2904176982201e-5*std::exp(1.65167987346649*x_6) - 0.000307309254557964*std::exp(1.00479984283447*x_8) + 622.841495372963*std::exp(1.01079976558685*x_8) - 0.0407313667566155*std::sin(0.269519954919815*x_112 + 1.9722398519516) + 2.43850164571836*std::sin(0.220639988780022*x_119 - 7.42039966583252) + 2074154347.23466*std::sin(0.375439822673798*x_13 + 8.22991943359375) - 0.121255015740385*std::sin(0.127600058913231*x_16 + 4.94623994827271) - 1324.36254041339*std::sin(0.262719959020615*x_17 + 5.04127979278564) - 1.20977090855537*std::sin(0.318879932165146*x_6 + 1.99967980384827) + 18.6593818954595*std::sin(0.306959927082062*x_8 - 7.41688013076782) - 0.0218388399735175*std::sin(0.342959851026535*x_91 + 2.01231980323792) - 0.0727590281500732*std::sin(0.361199855804443*x_91 + 1.99959981441498) - 405.761657805366*std::sin(0.376159846782684*x_91 + 2.00047969818115) + 26.4655253531391*std::sin(0.406799852848053*x_91 - 1.17383992671967) - 0.275644230894808*std::sin(0.288879930973053*x_94 + 1.97015976905823) + 0.52207588867148*std::sin(0.283439934253693*x_95 + 1.95063984394073) + 1032.68606220632*std::sin(0.265279948711395*x_96 + 1.97727978229523) - 1310224793242.19 + 0.0211804517729236*std::exp(-4.160560131073*x_94) + 0.00280481171396463*std::exp(-6.41871976852417*x_93) + 0.00389339741573316*std::exp(-6.35647964477539*x_93) + 0.0351417943652146*std::exp(-6.33199977874756*x_93) - 0.00270609539785271*std::exp(-7.98184013366699*x_113) - 3.46891874879315*std::exp(-7.9015998840332*x_113));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (6214074563.05174*x_1 + 23473927464.3394*x_10 - 2988908722.75302*x_100 - 656886338.27126*x_101 - 400715220.480566*x_102 + 317951606.838446*x_103 - 49122899998.8695*x_104 - 1349411246.29643*x_105 + 6908688033.95099*x_106 - 189284530.931562*x_107 + 1435504185.0444*x_108 + 531386789.17602*x_109 - 8989202583.57792*x_11 + 2281277294.85453*x_110 - 788394278.271307*x_111 + 2505892982.80453*x_112 + 133961260.332089*x_113 + 2169127553.41872*x_114 - 2128700199.5628*x_115 + 3031486270.67967*x_116 - 1738097914.78656*x_117 - 251713527.507913*x_118 - 1305497072.93859*x_119 - 8058643902.07312*x_12 + 1160603802.61109*x_120 - 850.213342111694*x_13 - 1430704341.72662*x_14 - 12417604023.3538*x_15 + 4661256352.65889*x_16 + 7581940404.43953*x_17 - 18918858783.6458*x_18 + 3861712598.47098*x_19 - 2113646511.09163*x_2 - 2149323529.06819*x_20 + 6303105835.19099*x_21 + 4924509067.88358*x_22 + 14972473332.0893*x_23 + 104417304462.844*x_24 + 7098019846.03495*x_25 - 5873927962.86031*x_26 - 21555836484.4429*x_27 - 20044438255.8257*x_28 + 3126071863.39096*x_29 - 401761762.384428*x_3 + 16567095286.6991*x_30 + 1507181483.97892*x_31 - 1949926348.82424*x_32 - 4520228211.98116*x_33 + 215965310.58716*x_34 + 3342844480.85557*x_35 + 11146628266.5869*x_36 + 97447120530.3352*x_37 - 830957026.484217*x_38 + 68352642411.9765*x_39 + 16610.6629033262*x_4 - 1809153134.15756*x_40 - 2616791083493.33*x_41 - 57242777105.1704*x_42 - 42895154343.8888*x_43 - 238759678.730757*x_44 + 142692830469.935*x_45 + 122756326916.332*x_46 - 10535573296.4552*x_47 - 9581610904.86244*x_48 - 36961819406.4232*x_49 + 43.4612459678692*x_5 - 34586679390.0183*x_50 + 2113906268.76506*x_51 - 29407662117.6069*x_52 - 6879942091.36479*x_53 + 3102773541.71571*x_54 - 8194748136.30473*x_55 + 25981263402.838*x_56 + 14568820942.6476*x_57 + 52851336173.3248*x_58 - 35798285934.2863*x_59 - 71.1496674759631*x_6 - 11413536113.5642*x_60 + 2012201891.20741*x_61 + 7880229768.4796*x_62 + 1801163380.28047*x_63 - 453285908.493357*x_64 - 159540550.234139*x_65 - 5301733332.62639*x_66 - 1599823446.30248*x_67 - 1503923584.85759*x_68 - 353404147.322587*x_69 + 1206463225.41265*x_7 + 775174470.015005*x_70 - 1694518378.05916*x_71 - 14342605.6363955*x_72 - 4290604360.68956*x_73 + 2474449711.06175*x_74 - 418821280.069217*x_75 - 6388599357.26502*x_76 - 1133656282.12393*x_77 + 2461292763.50754*x_78 - 995053590.363827*x_79 - 4300263179.71768*x_8 - 994667287.635276*x_80 - 239393461.103831*x_81 - 1504870173.12679*x_82 + 4818939729.73893*x_83 + 6289375360.28318*x_84 + 55838722888.6536*x_85 + 3910117446.17249*x_86 + 99621506079.9145*x_87 - 1261753963.77922*x_88 - 5535914246.28348*x_89 - 2312296405.49761*x_9 + 6061669870.08432*x_90 + 781816310.774427*x_91 - 3017539251.09734*x_92 - 2373532103.26776*x_93 - 1604547776.04071*x_94 - 2016625962.70494*x_95 + 953282339.204294*x_96 - 1612704687.55231*x_97 - 192633313.137088*x_98 + 2104181827.95878*x_99 + 257.783943488567*std::exp(1.02479982376099*x_1) + 8.23844297528276e-5*std::exp(0.983519792556763*x_13) - 2.06416871593798*std::exp(0.301039844751358*x_16) - 200.973554423775*std::exp(0.385279834270477*x_18) - 5.12253330293873*std::exp(0.316879838705063*x_20) - 9.54038505706085*std::exp(0.957519829273224*x_23) + 0.00162303064798559*std::exp(0.975119829177856*x_23) + 1.26747221178357*std::exp(0.976639807224274*x_23) + 0.00138395894601728*std::exp(0.977119863033295*x_23) - 25.9444671346046*std::exp(0.98991984128952*x_23) - 0.0289118759538408*std::exp(0.994559824466705*x_23) + 89.6690189689599*std::exp(0.997679829597473*x_23) + 0.000774548682941898*std::exp(0.916079819202423*x_24) + 46.9349634749898*std::exp(0.69599986076355*x_3) - 0.00514803121743246*std::exp(0.743999838829041*x_3) + 5.38941184508189*std::exp(0.807439863681793*x_3) + 29.5498335595583*std::exp(0.713839828968048*x_4) + 340001330.057015*std::exp(0.738399803638458*x_4) + 0.153868504434775*std::exp(1.01455986499786*x_4) - 88358423.5815678*std::exp(1.04143977165222*x_5) + 0.000713197609395772*std::exp(1.13007986545563*x_5) + 4.68818447315939*std::exp(1.25863993167877*x_5) + 1.57241211745679*std::exp(1.26903986930847*x_5) + 35.2513257729737*std::exp(1.30655980110168*x_5) - 0.0269417706339943*std::exp(1.31783986091614*x_5) - 0.60578091206833*std::exp(1.35319983959198*x_5) - 0.000106790086034022*std::exp(1.38263988494873*x_5) + 5.1141430026762e-5*std::exp(1.41631984710693*x_5) + 0.820927906090366*std::exp(1.38239991664886*x_6) + 0.0270288621929695*std::exp(1.39495980739594*x_6) - 0.000142994742560313*std::exp(1.45247983932495*x_6) + 8.14352188419041*std::exp(1.46871984004974*x_6) + 0.130333165110326*std::exp(1.47207987308502*x_6) + 4.66338347681715e-5*std::exp(1.5525598526001*x_6) + 0.34075325125653*std::exp(1.56399989128113*x_6) + 9.86694273016867e-6*std::exp(1.56935977935791*x_6) + 2247193.09689772*std::exp(1.57631981372833*x_6) + 2.04586605088525e-5*std::exp(1.65167987346649*x_6) - 0.00020488206808473*std::exp(1.00479984283447*x_8) - 30.2785265254329*std::exp(1.01079976558685*x_8) - 0.0271554680935877*std::sin(0.269519954919815*x_112 + 1.9722398519516) + 46.0216410841186*std::sin(0.220639988780022*x_119 - 7.42039966583252) + 8315667482.36179*std::sin(0.375439822673798*x_13 + 8.22991943359375) + 0.115261755037913*std::sin(0.127600058913231*x_16 + 4.94623994827271) - 1055.9869503875*std::sin(0.262719959020615*x_17 + 5.04127979278564) - 5.71363052087373*std::sin(0.318879932165146*x_6 + 1.99967980384827) - 7.80327571853418*std::sin(0.306959927082062*x_8 - 7.41688013076782) + 0.0207594136042111*std::sin(0.342959851026535*x_91 + 2.01231980323792) + 0.0649904275989988*std::sin(0.361199855804443*x_91 + 1.99959981441498) - 525.215927023762*std::sin(0.376159846782684*x_91 + 2.00047969818115) + 91.328537960414*std::sin(0.406799852848053*x_91 - 1.17383992671967) - 0.219498856815736*std::sin(0.288879930973053*x_94 + 1.97015976905823) + 0.415735386017136*std::sin(0.283439934253693*x_95 + 1.95063984394073) + 1336.70384338379*std::sin(0.265279948711395*x_96 + 1.97727978229523) - 5252940996303.47 - 0.0205719177145518*std::exp(-4.160560131073*x_94) + 0.00967898236186911*std::exp(-6.41871976852417*x_93) - 0.00162820256785607*std::exp(-6.35647964477539*x_93) - 0.114056483949156*std::exp(-6.33199977874756*x_93) + 0.00262834676281643*std::exp(-7.98184013366699*x_113) + 0.16863640128378*std::exp(-7.9015998840332*x_113));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-985956476.733771*x_1 - 3724300257.19918*x_10 + 474241755.417185*x_100 + 104228388.646292*x_101 + 63583305.4289599*x_102 - 50450844.0361983*x_103 + 7794089318.13796*x_104 + 214100556.010863*x_105 - 1096183136.28134*x_106 + 30032421.1111425*x_107 - 227770915.293917*x_108 - 84315818.6039859*x_109 + 1426263710.07392*x_11 - 361965491.851184*x_110 + 125088777.245388*x_111 - 397591196.049912*x_112 - 21255116.0614558*x_113 - 344159881.748655*x_114 + 337746692.058107*x_115 - 481025707.425613*x_116 + 275767066.502761*x_117 + 39931069.5594397*x_118 + 207136052.200601*x_119 + 1278617876.31135*x_12 - 184141152.772417*x_120 - 2064.69774996756*x_13 + 226996685.809528*x_14 + 1970201169.44415*x_15 - 739580480.672677*x_16 - 1202978149.24261*x_17 + 3001626883.5491*x_18 - 612732594.972187*x_19 + 335358709.58455*x_2 + 340986446.167259*x_20 - 1000087573.68304*x_21 - 781290277.101526*x_22 - 2375666610.18521*x_23 - 16567140701.9228*x_24 - 1126221854.68416*x_25 + 931938228.503765*x_26 + 3420192214.38625*x_27 + 3179751885.96775*x_28 - 496322137.455887*x_29 + 63741203.3362541*x_3 - 2628582434.33769*x_30 - 239137049.094763*x_31 + 309384698.445302*x_32 + 717240059.84551*x_33 - 33898008.4845059*x_34 - 530381291.071459*x_35 - 1768622384.80059*x_36 - 15461443470.7659*x_37 + 131862783.479493*x_38 - 10845181089.9301*x_39 + 56467.6322734092*x_4 + 287066509.838816*x_40 + 415193350135.849*x_41 + 9081716116.08129*x_42 + 6805878851.44384*x_43 + 37871854.816016*x_44 - 22640063679.2347*x_45 - 19476981053.6061*x_46 + 1672035336.88542*x_47 + 1520270305.83948*x_48 + 5864914983.27076*x_49 + 173.051347689142*x_5 + 5487614097.9745*x_50 - 335485130.950273*x_51 + 4665866426.8667*x_52 + 1091660993.84528*x_53 - 492314570.189002*x_54 + 1300057223.38494*x_55 - 4122586774.84684*x_56 - 2311562594.72635*x_57 - 8385590092.40858*x_58 + 5680247641.23561*x_59 + 35.3274144322513*x_6 + 1811030981.7779*x_60 - 319265510.636416*x_61 - 1250314407.97995*x_62 - 285781603.378921*x_63 + 71923902.487137*x_64 + 25318132.6401425*x_65 + 841184886.854225*x_66 + 253838787.031113*x_67 + 238621326.546322*x_68 + 56075781.2438179*x_69 - 191411405.839868*x_7 - 122996546.064886*x_70 + 268862113.156977*x_71 + 2272620.43335043*x_72 + 680769374.170848*x_73 - 392597915.595753*x_74 + 66450328.5789971*x_75 + 1013654733.18012*x_76 + 179871121.438078*x_77 - 390528192.719756*x_78 + 157883412.076187*x_79 + 682299671.053739*x_8 + 157812085.160176*x_80 + 37980770.5002842*x_81 + 238768770.516281*x_82 - 764605877.450506*x_83 - 997907432.987055*x_84 - 8859436966.91054*x_85 - 620394418.528638*x_86 - 15806116844.2959*x_87 + 200195882.275773*x_88 + 878379434.570708*x_89 + 366884824.548582*x_9 - 961758363.741387*x_90 - 124048124.42054*x_91 + 478774685.686388*x_92 + 376596449.444099*x_93 + 254579741.130825*x_94 + 319959906.051632*x_95 - 151252566.233004*x_96 + 255884439.851094*x_97 + 30571516.4276933*x_98 - 333858360.855144*x_99 + 64.3370504259091*std::exp(1.02479982376099*x_1) - 0.000108398386377323*std::exp(0.983519792556763*x_13) + 0.670508394624765*std::exp(0.301039844751358*x_16) - 324.577797356068*std::exp(0.385279834270477*x_18) - 3.24977610498326*std::exp(0.316879838705063*x_20) - 35.5085988348713*std::exp(0.957519829273224*x_23) + 0.000675215734718605*std::exp(0.975119829177856*x_23) + 0.804094510273166*std::exp(0.976639807224274*x_23) - 0.00182096200715142*std::exp(0.977119863033295*x_23) + 53.9263921856612*std::exp(0.98991984128952*x_23) - 0.0341665420912455*std::exp(0.994559824466705*x_23) + 13.8311839303132*std::exp(0.997679829597473*x_23) - 0.00019930560422902*std::exp(0.916079819202423*x_24) + 75.8012520969651*std::exp(0.69599986076355*x_3) - 0.00214169195458337*std::exp(0.743999838829041*x_3) + 20.0589873488684*std::exp(0.807439863681793*x_3) + 7.37497109428325*std::exp(0.713839828968048*x_4) - 53946207.6820901*std::exp(0.738399803638458*x_4) - 0.049981439547684*std::exp(1.01455986499786*x_4) + 14019362.4189471*std::exp(1.04143977165222*x_5) + 0.000842819614323891*std::exp(1.13007986545563*x_5) + 7.57154638708514*std::exp(1.25863993167877*x_5) + 0.242539970447614*std::exp(1.26903986930847*x_5) + 119.821485298534*std::exp(1.30655980110168*x_5) + 0.00875155370618017*std::exp(1.31783986091614*x_5) + 0.0529721748663604*std::exp(1.35319983959198*x_5) - 4.4426977698554e-5*std::exp(1.38263988494873*x_5) - 1.31596293907642e-5*std::exp(1.41631984710693*x_5) + 0.126625728632017*std::exp(1.38239991664886*x_6) + 0.0171473263920424*std::exp(1.39495980739594*x_6) - 5.94888952211681e-5*std::exp(1.45247983932495*x_6) + 27.6803458119271*std::exp(1.46871984004974*x_6) + 0.48509028169219*std::exp(1.47207987308502*x_6) - 1.19997423282481e-5*std::exp(1.5525598526001*x_6) - 0.0297969784987311*std::exp(1.56399989128113*x_6) - 1.29825583989193e-5*std::exp(1.56935977935791*x_6) - 356550.209632047*std::exp(1.57631981372833*x_6) - 3.33582247080068e-5*std::exp(1.65167987346649*x_6) + 0.000269576249355193*std::exp(1.00479984283447*x_8) - 102.918626218306*std::exp(1.01079976558685*x_8) + 0.0357301608021965*std::sin(0.269519954919815*x_112 + 1.9722398519516) + 171.289102190792*std::sin(0.220639988780022*x_119 - 7.42039966583252) - 1319402853.3461*std::sin(0.375439822673798*x_13 + 8.22991943359375) - 0.0296589668774272*std::sin(0.127600058913231*x_16 + 4.94623994827271) - 1705.44786042247*std::sin(0.262719959020615*x_17 + 5.04127979278564) + 1.85597097681487*std::sin(0.318879932165146*x_6 + 1.99967980384827) - 4.95046053798037*std::sin(0.306959927082062*x_8 - 7.41688013076782) - 0.0053417784613776*std::sin(0.342959851026535*x_91 + 2.01231980323792) - 0.105968095358871*std::sin(0.361199855804443*x_91 + 1.99959981441498) - 131.082033753266*std::sin(0.376159846782684*x_91 + 2.00047969818115) - 7.98617319685767*std::sin(0.406799852848053*x_91 - 1.17383992671967) - 0.259392262970014*std::sin(0.288879930973053*x_94 + 1.97015976905823) + 0.49129432444482*std::sin(0.283439934253693*x_95 + 1.95063984394073) + 333.611090793574*std::sin(0.265279948711395*x_96 + 1.97727978229523) + 833443335626.427 + 0.0427593789816711*std::exp(-4.160560131073*x_94) - 0.00084637322831908*std::exp(-6.41871976852417*x_93) - 0.00103294473382057*std::exp(-6.35647964477539*x_93) - 0.0175928790800274*std::exp(-6.33199977874756*x_93) - 0.00546310153899841*std::exp(-7.98184013366699*x_113) + 0.5732057911057*std::exp(-7.9015998840332*x_113));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (11388519731.8577*x_1 + 43020500972.6334*x_10 - 5477768849.36729*x_100 - 1203875669.67526*x_101 - 734391706.840383*x_102 + 582710550.470258*x_103 - 90027415729.553*x_104 - 2473060756.51385*x_105 + 12661543939.8177*x_106 - 346901118.731285*x_107 + 2630848272.10951*x_108 + 973872842.089944*x_109 - 16474483932.8964*x_11 + 4180894411.51847*x_110 - 1444887140.85258*x_111 + 4592540401.93802*x_112 + 245510717.30995*x_113 + 3975351897.30766*x_114 - 3901261533.16462*x_115 + 5555817190.6529*x_116 - 3185403753.5257*x_117 - 461311021.356095*x_118 - 2392580703.57336*x_119 - 14769052585.4234*x_12 + 2127032481.69032*x_120 - 248.289669599491*x_13 - 2622044331.63234*x_14 - 22757692241.1966*x_15 + 8542673957.97556*x_16 + 13895397950.9387*x_17 - 34672473276.5994*x_18 + 7077357734.8394*x_19 - 3873673238.03147*x_2 - 3939041485.76838*x_20 + 11551687413.594*x_21 + 9025111226.05094*x_22 + 27440038027.2551*x_23 + 191365215945.325*x_24 + 13008530371.1317*x_25 - 10765107876.9434*x_26 - 39505342931.8156*x_27 - 36735091274.1606*x_28 + 5729306623.77406*x_29 - 736305240.225466*x_3 + 30362454962.8605*x_30 + 2762207780.3885*x_31 - 3573625183.44821*x_32 - 8284230795.1349*x_33 + 395588876.546539*x_34 + 6126416948.46224*x_35 + 20428421703.9232*x_36 + 178591088203.507*x_37 - 1522901748.05075*x_38 + 125269715783.635*x_39 - 1436.49525849438*x_4 - 3315639165.33282*x_40 - 4795786361951.54*x_41 - 104908316359.307*x_42 - 78613804003.3276*x_43 - 437569117.689095*x_44 + 261512640026.533*x_45 + 224975134016.843*x_46 - 19308739247.7433*x_47 - 17560195756.4395*x_48 - 67740007571.2212*x_49 - 19.0194320606462*x_5 - 63386873021.4917*x_50 + 3874193195.70003*x_51 - 53895298029.4486*x_52 - 12608877103.5699*x_53 + 5686449734.83986*x_54 - 15018405732.2377*x_55 + 47615921167.8853*x_56 + 26700241887.6994*x_57 + 96860474135.9121*x_58 - 65607608874.2233*x_59 - 108.411846149658*x_6 - 20917611882.8775*x_60 + 3687756853.02942*x_61 + 14442075822.9178*x_62 + 3300987549.23378*x_63 - 830737528.755071*x_64 - 292391910.936116*x_65 - 9716466219.02402*x_66 - 2931993960.24184*x_67 - 2756237769.96066*x_68 - 647684549.930608*x_69 + 2211075975.74024*x_7 + 1420661978.06619*x_70 - 3105540447.03385*x_71 - 26283986.1287694*x_72 - 7863380272.57152*x_73 + 4534911760.48798*x_74 - 767571703.696899*x_75 - 11708373719.5349*x_76 - 2077648806.93628*x_77 + 4510808801.97307*x_78 - 1823633792.91558*x_79 - 7881081119.48822*x_8 - 1822920420.28146*x_80 - 438734284.934168*x_81 - 2757970872.89525*x_82 + 8831662692.41111*x_83 + 11526524754.4386*x_84 + 102335381703.83*x_85 + 7166061452.26326*x_86 + 182575910762.644*x_87 - 2312413045.59445*x_88 - 10145668011.073*x_89 - 4237741567.23054*x_9 + 11109198642.4096*x_90 + 1432833569.67288*x_91 - 5530235348.8127*x_92 - 4349966241.64176*x_93 - 2940647645.06361*x_94 - 3695861155.24395*x_95 + 1747078107.75922*x_96 - 2955602577.75818*x_97 - 353042189.866636*x_98 + 3856327900.98271*x_99 + 334.729015390864*std::exp(1.02479982376099*x_1) - 9.44576293749694e-5*std::exp(0.983519792556763*x_13) - 1.7655406090157*std::exp(0.301039844751358*x_16) - 170.733603746801*std::exp(0.385279834270477*x_18) + 15.2027421112743*std::exp(0.316879838705063*x_20) + 5.9457243078453*std::exp(0.957519829273224*x_23) + 0.00201331036983632*std::exp(0.975119829177856*x_23) - 3.76162574831824*std::exp(0.976639807224274*x_23) - 0.00158677412206749*std::exp(0.977119863033295*x_23) - 46.9844777086098*std::exp(0.98991984128952*x_23) + 0.0296378109229448*std::exp(0.994559824466705*x_23) + 57.9106263118303*std::exp(0.997679829597473*x_23) + 0.000622744617056214*std::exp(0.916079819202423*x_24) + 39.8727856447839*std::exp(0.69599986076355*x_3) - 0.00638594511271969*std::exp(0.743999838829041*x_3) - 3.35876977927395*std::exp(0.807439863681793*x_3) + 38.3700650959805*std::exp(0.713839828968048*x_4) + 623119525.423911*std::exp(0.738399803638458*x_4) + 0.131607988693241*std::exp(1.01455986499786*x_4) - 161934245.845799*std::exp(1.04143977165222*x_5) - 0.000731104959488459*std::exp(1.13007986545563*x_5) + 3.98276595359658*std::exp(1.25863993167877*x_5) + 1.01550537286189*std::exp(1.26903986930847*x_5) - 0.769718619928759*std::exp(1.30655980110168*x_5) - 0.0230440417809979*std::exp(1.31783986091614*x_5) + 0.1123404987679*std::exp(1.35319983959198*x_5) - 0.000132469209915942*std::exp(1.38263988494873*x_5) + 4.11182033603846e-5*std::exp(1.41631984710693*x_5) + 0.530176974669581*std::exp(1.38239991664886*x_6) - 0.080216720356928*std::exp(1.39495980739594*x_6) - 0.00017737976691079*std::exp(1.45247983932495*x_6) - 0.177815168326644*std::exp(1.46871984004974*x_6) - 0.0812257642935864*std::exp(1.47207987308502*x_6) + 3.7494053265011e-5*std::exp(1.5525598526001*x_6) - 0.0631918065431291*std::exp(1.56399989128113*x_6) - 1.13129146158632e-5*std::exp(1.56935977935791*x_6) + 4118424.75980898*std::exp(1.57631981372833*x_6) + 1.10848511291813e-5*std::exp(1.65167987346649*x_6) + 0.000234906941891656*std::exp(1.00479984283447*x_8) + 0.661136713005575*std::exp(1.01079976558685*x_8) + 0.0311350233094242*std::sin(0.269519954919815*x_112 + 1.9722398519516) - 28.681440889879*std::sin(0.220639988780022*x_119 - 7.42039966583252) + 15240101485.2601*std::sin(0.375439822673798*x_13 + 8.22991943359375) + 0.0926715635609658*std::sin(0.127600058913231*x_16 + 4.94623994827271) - 897.095431616271*std::sin(0.262719959020615*x_17 + 5.04127979278564) - 4.88702625498815*std::sin(0.318879932165146*x_6 + 1.99967980384827) + 23.1586953869069*std::sin(0.306959927082062*x_8 - 7.41688013076782) + 0.0166907689083705*std::sin(0.342959851026535*x_91 + 2.01231980323792) + 0.0352129219039055*std::sin(0.361199855804443*x_91 + 1.99959981441498) - 681.985882212486*std::sin(0.376159846782684*x_91 + 2.00047969818115) - 16.9366404616241*std::sin(0.406799852848053*x_91 - 1.17383992671967) + 0.225010152454085*std::sin(0.288879930973053*x_94 + 1.97015976905823) - 0.426173894230357*std::sin(0.283439934253693*x_95 + 1.95063984394073) + 1735.69212771736*std::sin(0.265279948711395*x_96 + 1.97727978229523) - 9626971919140.88 - 0.037254987904281*std::exp(-4.160560131073*x_94) - 0.00179494217205615*std::exp(-6.41871976852417*x_93) + 0.00483220748019928*std::exp(-6.35647964477539*x_93) - 0.0736606968200164*std::exp(-6.33199977874756*x_93) + 0.00475983951596882*std::exp(-7.98184013366699*x_113) - 0.00368220415033072*std::exp(-7.9015998840332*x_113));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-6262057626.65674*x_1 - 23654781946.7143*x_10 + 3012000959.51918*x_100 + 661965446.128358*x_101 + 403816492.839694*x_102 - 320413160.424882*x_103 + 49502196131.1673*x_104 + 1359822616.28339*x_105 - 6962065419.68396*x_106 + 190744823.321389*x_107 - 1446601931.90011*x_108 - 535495904.333495*x_109 + 9058589577.96795*x_11 - 2298904891.06716*x_110 + 794477511.148227*x_111 - 2525228178.46453*x_112 - 134995726.81452*x_113 - 2185866157.67682*x_114 + 2145128850.43974*x_115 - 3054969483.21349*x_116 + 1751501761.9126*x_117 + 253642522.76167*x_118 + 1315575673.44553*x_119 + 8120851144.13764*x_12 - 1169552473.46836*x_120 - 3936.93305059275*x_13 + 1441738057.58049*x_14 + 12513396120.5156*x_15 - 4697251898.61965*x_16 - 7640461136.33026*x_17 + 19064654263.6167*x_18 - 3891560293.59248*x_19 + 2129960015.52445*x_2 + 2165840678.78862*x_20 - 6351788007.22333*x_21 - 4962428459.16465*x_22 - 15088183062.8269*x_23 - 105223069336.275*x_24 - 7152855774.09196*x_25 + 5919185289.2074*x_26 + 21722343090.7661*x_27 + 20197973389.9483*x_28 - 3150884847.1305*x_29 + 404854719.63604*x_3 - 16694937838.3415*x_30 - 1518818695.24165*x_31 + 1964981970.31507*x_32 + 4555209429.53181*x_33 - 216836305.473465*x_34 - 3368633146.62788*x_35 - 11232781337.2081*x_36 - 98199527072.2843*x_37 + 837412434.409108*x_38 - 68880427870.383*x_39 + 121626.939154701*x_4 + 1823159288.07877*x_40 + 2636996221754.51*x_41 + 57683276727.9874*x_42 + 43226192968.0381*x_43 + 240581231.766474*x_44 - 143793987074.546*x_45 - 123703840106.537*x_46 + 10617774262.2316*x_47 + 9655598913.22336*x_48 + 37247996234.2476*x_49 + 46.9178731082552*x_5 + 34853555724.4168*x_50 - 2130402854.18117*x_51 + 29634524325.8597*x_52 + 6933162217.68196*x_53 - 3126753394.89967*x_54 + 8257701067.73309*x_55 - 26182392870.9638*x_56 - 14681309572.2959*x_57 - 53259291493.2513*x_58 + 36075297965.2993*x_59 - 82.5256938559052*x_6 + 11501876868.009*x_60 - 2027737618.66466*x_61 - 7941072543.40061*x_62 - 1815071138.76108*x_63 + 456792057.358638*x_64 + 160782254.545171*x_65 + 5342639370.52861*x_66 + 1612181703.08904*x_67 + 1515538086.836*x_68 + 356138856.461248*x_69 - 1215752543.11688*x_7 - 781166514.218034*x_70 + 1707605289.25756*x_71 + 14447236.9132587*x_72 + 4323734500.80492*x_73 - 2493533637.66231*x_74 + 422051248.900969*x_75 + 6437942625.04962*x_76 + 1142408565.83948*x_77 - 2480312316.26*x_78 + 1002743484.09574*x_79 + 4333464912.53192*x_8 + 1002333503.6498*x_80 + 241236139.183958*x_81 + 1516486628.78543*x_82 - 4856166032.90142*x_83 - 6337946670.36873*x_84 - 56269418975.6367*x_85 - 3940297035.87253*x_86 - 100390017809.624*x_87 + 1271495472.7752*x_88 + 5578707738.07694*x_89 + 2330159471.61309*x_9 - 6108440451.3744*x_90 - 787855582.069295*x_91 + 3040830898.90564*x_92 + 2391859055.05114*x_93 + 1616924521.43914*x_94 + 2032180196.30841*x_95 - 960642737.106275*x_96 + 1625166784.7133*x_97 + 194135754.218447*x_98 - 2120425318.04143*x_99 + 95.9666134437359*std::exp(1.02479982376099*x_1) - 7.60828537967854e-5*std::exp(0.983519792556763*x_13) + 0.809209486341848*std::exp(0.301039844751358*x_16) + 229.074430847934*std::exp(0.385279834270477*x_18) + 12.3085763579799*std::exp(0.316879838705063*x_20) - 19.6749634155903*std::exp(0.957519829273224*x_23) + 0.000973573213051412*std::exp(0.975119829177856*x_23) - 3.04552017092905*std::exp(0.976639807224274*x_23) - 0.00127810007869809*std::exp(0.977119863033295*x_23) - 58.9253567404041*std::exp(0.98991984128952*x_23) - 0.0449027927806016*std::exp(0.994559824466705*x_23) + 26.1501208402176*std::exp(0.997679829597473*x_23) + 0.000677345497615788*std::exp(0.916079819202423*x_24) - 53.4975861661428*std::exp(0.69599986076355*x_3) - 0.00308804106654749*std::exp(0.743999838829041*x_3) + 11.1144864960201*std::exp(0.807439863681793*x_3) + 11.0006752793067*std::exp(0.713839828968048*x_4) - 342626359.930034*std::exp(0.738399803638458*x_4) - 0.0603205796485842*std::exp(1.01455986499786*x_4) + 89040607.6818346*std::exp(1.04143977165222*x_5) + 0.00110766124333985*std::exp(1.13007986545563*x_5) - 5.34370401607458*std::exp(1.25863993167877*x_5) + 0.45856157851299*std::exp(1.26903986930847*x_5) + 225.983567515035*std::exp(1.30655980110168*x_5) + 0.0105618965191843*std::exp(1.31783986091614*x_5) - 0.155544698020011*std::exp(1.35319983959198*x_5) - 6.40579198619685e-5*std::exp(1.38263988494873*x_5) + 4.47233571409463e-5*std::exp(1.41631984710693*x_5) + 0.239406700242824*std::exp(1.38239991664886*x_6) - 0.0649457591579976*std::exp(1.39495980739594*x_6) - 8.57752446860382e-5*std::exp(1.45247983932495*x_6) + 52.2051890864491*std::exp(1.46871984004974*x_6) + 0.268783727286343*std::exp(1.47207987308502*x_6) + 4.07814495233594e-5*std::exp(1.5525598526001*x_6) + 0.0874942747619216*std::exp(1.56399989128113*x_6) - 9.11222136771435e-6*std::exp(1.56935977935791*x_6) - 2264542.87905536*std::exp(1.57631981372833*x_6) - 1.10524397755057e-6*std::exp(1.65167987346649*x_6) + 0.000189210661267441*std::exp(1.00479984283447*x_8) - 194.104740553102*std::exp(1.01079976558685*x_8) + 0.0250783493306487*std::sin(0.269519954919815*x_112 + 1.9722398519516) + 94.9095973841557*std::sin(0.220639988780022*x_119 - 7.42039966583252) - 8379869806.36926*std::sin(0.375439822673798*x_13 + 8.22991943359375) + 0.100796802759628*std::sin(0.127600058913231*x_16 + 4.94623994827271) + 1203.6390078109*std::sin(0.262719959020615*x_17 + 5.04127979278564) + 2.23989637244471*std::sin(0.318879932165146*x_6 + 1.99967980384827) + 18.7499444793941*std::sin(0.306959927082062*x_8 - 7.41688013076782) + 0.0181541788755596*std::sin(0.342959851026535*x_91 + 2.01231980323792) - 0.00351099617060211*std::sin(0.361199855804443*x_91 + 1.99959981441498) - 195.524954584374*std::sin(0.376159846782684*x_91 + 2.00047969818115) + 23.4501774068104*std::sin(0.406799852848053*x_91 - 1.17383992671967) - 0.340901839054362*std::sin(0.288879930973053*x_94 + 1.97015976905823) + 0.645675151612254*std::sin(0.283439934253693*x_95 + 1.95063984394073) + 497.621920476432*std::sin(0.265279948711395*x_96 + 1.97727978229523) + 5293560561242.89 - 0.0467231638975296*std::exp(-4.160560131073*x_94) + 0.00248524566988689*std::exp(-6.41871976852417*x_93) + 0.00391229386858612*std::exp(-6.35647964477539*x_93) - 0.0332622222499528*std::exp(-6.33199977874756*x_93) + 0.00596952983589597*std::exp(-7.98184013366699*x_113) + 1.08106730000558*std::exp(-7.9015998840332*x_113));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-6363274416.46151*x_1 - 24037488349.5243*x_10 + 3060672682.28071*x_100 + 672658633.626464*x_101 + 410337305.597864*x_102 - 325585553.436616*x_103 + 50302346077.7178*x_104 + 1381810049.34419*x_105 - 7074569218.79979*x_106 + 193829598.352852*x_107 - 1469971169.18667*x_108 - 544145932.245359*x_109 + 9205029552.46619*x_11 - 2336051373.86595*x_110 + 807323400.403706*x_111 - 2566058304.79156*x_112 - 137178086.822979*x_113 - 2221207245.43691*x_114 + 2179809502.41296*x_115 - 3104278625.63277*x_116 + 1779828458.21247*x_117 + 257755622.610069*x_118 + 1336841973.11685*x_119 + 8252131670.96891*x_12 - 1188468633.65166*x_120 + 45.4422148726451*x_13 + 1465052942.32078*x_14 + 12715749889.895*x_15 - 4773173331.05434*x_16 - 7763981616.5604*x_17 + 19373077540.8846*x_18 - 3954431161.94572*x_19 + 2164395071.94802*x_2 + 2200929730.22608*x_20 - 6454438458.83442*x_21 - 5042730547.60513*x_22 - 15331966141.7496*x_23 - 106924333851.63*x_24 - 7268444674.10913*x_25 + 6014950623.86173*x_26 + 22073394316.2209*x_27 + 20525615295.4873*x_28 - 3201151597.12477*x_29 + 411406901.756218*x_3 - 16964866301.4478*x_30 - 1543369294.78418*x_31 + 1996743904.03933*x_32 + 4628763587.38721*x_33 - 221068092.756832*x_34 - 3423103998.85822*x_35 - 11414269791.5966*x_36 - 99786821528.5584*x_37 + 850909431.701149*x_38 - 69993772260.2806*x_39 - 17842.3744641856*x_4 + 1852592438.80156*x_40 + 2679619894826.59*x_41 + 58617038743.9605*x_42 + 43925059910.799*x_43 + 244491022.327062*x_44 - 146118857830.485*x_45 - 125703723384.283*x_46 + 10788592326.8229*x_47 + 9811666119.24691*x_48 + 37849293896.736*x_49 - 26.2101379467796*x_5 + 35417080905.2465*x_50 - 2164672636.11062*x_51 + 30113728258.1701*x_52 + 7045139946.27084*x_53 - 3177271453.04557*x_54 + 8391469109.02426*x_55 - 26605093966.4401*x_56 - 14918620117.7208*x_57 - 54120290006.0827*x_58 + 36657930423.114*x_59 - 0.521033644190055*x_6 + 11687587465.852*x_60 - 2060514176.83638*x_61 - 8069431692.4325*x_62 - 1844408760.04783*x_63 + 464170062.148119*x_64 + 163371509.700623*x_65 + 5429027129.39089*x_66 + 1638235933.74016*x_67 + 1540033558.90701*x_68 + 361889883.391494*x_69 - 1235429347.51312*x_7 - 793787019.865179*x_70 + 1735203937.53813*x_71 + 14686204.6534529*x_72 + 4393621822.05042*x_73 - 2533857447.32675*x_74 + 428876683.595296*x_75 + 6541991041.73218*x_76 + 1160875490.17736*x_77 - 2520388703.14906*x_78 + 1018944821.01975*x_79 + 4403511988.27291*x_8 + 1018547066.76807*x_80 + 245140686.728317*x_81 + 1541001415.47979*x_82 - 4934641906.58492*x_83 - 6440383628.76301*x_84 - 57179410170.3065*x_85 - 4004001099.74583*x_86 - 102013382512.878*x_87 + 1292048674.09741*x_88 + 5668836401.00409*x_89 + 2367813780.20297*x_9 - 6207208273.84849*x_90 - 800588350.384579*x_91 + 3089991010.91083*x_92 + 2430520116.12759*x_93 + 1643072290.6193*x_94 + 2065044051.84814*x_95 - 976170411.305236*x_96 + 1651427023.78225*x_97 + 197258798.670712*x_98 - 2154703259.41247*x_99 + 167.212799466134*std::exp(1.02479982376099*x_1) - 1.60198028222936e-5*std::exp(0.983519792556763*x_13) - 1.42618263339194*std::exp(0.301039844751358*x_16) - 508.508266030192*std::exp(0.385279834270477*x_18) - 11.2808044466099*std::exp(0.316879838705063*x_20) - 4.53477546688268*std::exp(0.957519829273224*x_23) + 0.00303989791791418*std::exp(0.975119829177856*x_23) + 2.79121780515119*std::exp(0.976639807224274*x_23) - 0.000269113344546578*std::exp(0.977119863033295*x_23) - 92.5286481100543*std::exp(0.98991984128952*x_23) - 0.0333952170802724*std::exp(0.994559824466705*x_23) + 55.9787276634937*std::exp(0.997679829597473*x_23) + 0.00133780466972873*std::exp(0.916079819202423*x_24) + 118.756007283086*std::exp(0.69599986076355*x_3) - 0.00964214039867538*std::exp(0.743999838829041*x_3) + 2.56171763192266*std::exp(0.807439863681793*x_3) + 19.1676421982861*std::exp(0.713839828968048*x_4) - 348164733.557925*std::exp(0.738399803638458*x_4) + 0.106311362611243*std::exp(1.01455986499786*x_4) + 90479901.9424898*std::exp(1.04143977165222*x_5) + 0.000823792583536562*std::exp(1.13007986545563*x_5) + 11.8621604922659*std::exp(1.25863993167877*x_5) + 0.981628110912656*std::exp(1.26903986930847*x_5) - 18.4821781786116*std::exp(1.30655980110168*x_5) - 0.0186147019351427*std::exp(1.31783986091614*x_5) - 0.178350242615872*std::exp(1.35319983959198*x_5) - 0.000200015298904931*std::exp(1.38263988494873*x_5) + 8.83317542372474e-5*std::exp(1.41631984710693*x_5) + 0.512490269379467*std::exp(1.38239991664886*x_6) + 0.0595227577414352*std::exp(1.39495980739594*x_6) - 0.000267825762083593*std::exp(1.45247983932495*x_6) - 4.2696272881862*std::exp(1.46871984004974*x_6) + 0.0619505015917624*std::exp(1.47207987308502*x_6) + 8.05462113540225e-5*std::exp(1.5525598526001*x_6) + 0.100322449623329*std::exp(1.56399989128113*x_6) - 1.9186450336599e-6*std::exp(1.56935977935791*x_6) - 2301148.01522512*std::exp(1.57631981372833*x_6) - 2.460596882062e-5*std::exp(1.65167987346649*x_6) + 3.98396923106511e-5*std::exp(1.00479984283447*x_8) + 15.8749525005925*std::exp(1.01079976558685*x_8) + 0.00528043036422702*std::sin(0.269519954919815*x_112 + 1.9722398519516) + 21.875197666103*std::sin(0.220639988780022*x_119 - 7.42039966583252) - 8515325963.18753*std::sin(0.375439822673798*x_13 + 8.22991943359375) + 0.199080726010887*std::sin(0.127600058913231*x_16 + 4.94623994827271) - 2671.88434135858*std::sin(0.262719959020615*x_17 + 5.04127979278564) - 3.94768148532152*std::sin(0.318879932165146*x_6 + 1.99967980384827) - 17.1843153022086*std::sin(0.306959927082062*x_8 - 7.41688013076782) + 0.0358557713313251*std::sin(0.342959851026535*x_91 + 2.01231980323792) - 0.0781650604372544*std::sin(0.361199855804443*x_91 + 1.99959981441498) - 340.683846687057*std::sin(0.376159846782684*x_91 + 2.00047969818115) + 26.8883792448637*std::sin(0.406799852848053*x_91 - 1.17383992671967) - 0.253536366299308*std::sin(0.288879930973053*x_94 + 1.97015976905823) + 0.48020313473117*std::sin(0.283439934253693*x_95 + 1.95063984394073) + 867.05940131317*std::sin(0.265279948711395*x_96 + 1.97727978229523) + 5379054453444.89 - 0.0733679256268048*std::exp(-4.160560131073*x_94) + 0.00284962569490698*std::exp(-6.41871976852417*x_93) - 0.00358561549163873*std::exp(-6.35647964477539*x_93) - 0.071203375777487*std::exp(-6.33199977874756*x_93) + 0.00937376633970125*std::exp(-7.98184013366699*x_113) - 0.0884156254434045*std::exp(-7.9015998840332*x_113));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-4410289623.48032*x_1 - 16658969627.6865*x_10 + 2121342064.9095*x_100 + 466228576.793815*x_101 + 284418531.345175*x_102 - 225676675.01983*x_103 + 34863769012.5996*x_104 + 957689446.970234*x_105 - 4903359982.24911*x_106 + 134336771.352547*x_107 - 1018852307.32888*x_108 - 377156768.431972*x_109 + 6379813120.18889*x_11 - 1619117382.26888*x_110 + 559532592.531009*x_111 - 1778458624.96662*x_112 - 95075513.951716*x_113 - 1539457815.80339*x_114 + 1510771264.45435*x_115 - 2151724319.7982*x_116 + 1233524945.76084*x_117 + 178607964.019891*x_118 + 926540250.602071*x_119 + 5719380997.88384*x_12 - 823674960.583028*x_120 - 11517.7463290776*x_13 + 1015375784.75408*x_14 + 8812851903.72011*x_15 - 3308222999.49186*x_16 - 5381032933.26792*x_17 + 13426420281.128*x_18 - 2740837055.14464*x_19 + 1500089858.72744*x_2 + 1525213324.61087*x_20 - 4473514199.78803*x_21 - 3494741501.22565*x_22 - 10626664215.715*x_23 - 74106261128.2426*x_24 - 5037726827.85298*x_25 + 4168604611.50706*x_26 + 15298917502.4234*x_27 + 14222603201.7272*x_28 - 2220523635.30264*x_29 + 285116345.510692*x_3 - 11757874380.4253*x_30 - 1069684158.33008*x_31 + 1383909831.68765*x_32 + 3208338598.74997*x_33 - 151165794.054279*x_34 - 2372437465.89869*x_35 - 7911274391.46746*x_36 - 69160662235.5882*x_37 + 589862157.103815*x_38 - 48511663455.8662*x_39 + 358525.125398264*x_4 + 1284101030.23064*x_40 + 1857203370213.84*x_41 + 40622577581.4903*x_42 + 30443304250.1089*x_43 + 169390585.99294*x_44 - 101270962115.238*x_45 - 87122322164.6532*x_46 + 7479704700.49365*x_47 + 6800329040.63235*x_48 + 26234920659.3592*x_49 + 46.0726979293322*x_5 + 24546583099.0696*x_50 - 1500768256.03847*x_51 + 20870780824.383*x_52 + 4883161503.09476*x_53 - 2202182085.59272*x_54 + 5815140584.27201*x_55 - 18441070315.0553*x_56 - 10339855695.3664*x_57 - 37509532534.2694*x_58 + 25408520587.216*x_59 + 76.945449847531*x_6 + 8101062314.57773*x_60 - 1428108122.2283*x_61 - 5592789324.83028*x_62 - 1278331832.98164*x_63 + 321726064.349728*x_64 + 113257159.161611*x_65 + 3762687452.53133*x_66 + 1135450176.27746*x_67 + 1067378396.11582*x_68 + 250836107.393139*x_69 - 856185693.10334*x_7 - 550179789.903287*x_70 + 1202650399.82285*x_71 + 10162662.9736975*x_72 + 3045153823.68234*x_73 - 1756121643.45198*x_74 + 297237354.00652*x_75 + 4534192271.36191*x_76 + 804581366.199972*x_77 - 1746883380.36036*x_78 + 706233598.70064*x_79 + 3051996529.30872*x_8 + 705902830.375642*x_80 + 169888620.614511*x_81 + 1068036286.38106*x_82 - 3420174837.73357*x_83 - 4463750992.19168*x_84 - 39628863313.9777*x_85 - 2775076707.39901*x_86 - 70701962247.3983*x_87 + 895496612.155433*x_88 + 3929112488.389*x_89 + 1641121883.30157*x_9 - 4302026314.11778*x_90 - 554881315.451705*x_91 + 2141602200.73805*x_92 + 1684556276.61822*x_93 + 1138753780.59368*x_94 + 1431203997.79075*x_95 - 676568071.585187*x_96 + 1144603155.89192*x_97 + 136759368.532585*x_98 - 1493380509.89439*x_99 - 13.6582909329118*std::exp(1.02479982376099*x_1) + 4.35537828544422e-5*std::exp(0.983519792556763*x_13) - 0.527749288818654*std::exp(0.301039844751358*x_16) - 311.098161049106*std::exp(0.385279834270477*x_18) + 8.00624605985216*std::exp(0.316879838705063*x_20) + 10.1632446243087*std::exp(0.957519829273224*x_23) + 0.00177326553862477*std::exp(0.975119829177856*x_23) - 1.98099139653083*std::exp(0.976639807224274*x_23) + 0.000731650963600078*std::exp(0.977119863033295*x_23) + 135.058490918493*std::exp(0.98991984128952*x_23) - 0.0287370946985119*std::exp(0.994559824466705*x_23) - 55.8065442759995*std::exp(0.997679829597473*x_23) - 0.00104394485196062*std::exp(0.916079819202423*x_24) + 72.6532446910288*std::exp(0.69599986076355*x_3) - 0.00562455574142588*std::exp(0.743999838829041*x_3) - 5.74126836968452*std::exp(0.807439863681793*x_3) - 1.56565307487225*std::exp(0.713839828968048*x_4) - 241306886.474921*std::exp(0.738399803638458*x_4) + 0.0393398045227822*std::exp(1.01455986499786*x_4) + 62710037.2952218*std::exp(1.04143977165222*x_5) + 0.000708886108693886*std::exp(1.13007986545563*x_5) + 7.25710192289022*std::exp(1.25863993167877*x_5) - 0.978608748728997*std::exp(1.26903986930847*x_5) + 695.919362724477*std::exp(1.30655980110168*x_5) - 0.00688824522037424*std::exp(1.31783986091614*x_5) - 0.110971073797463*std::exp(1.35319983959198*x_5) - 0.000116675048413866*std::exp(1.38263988494873*x_5) - 6.89289566610077e-5*std::exp(1.41631984710693*x_5) - 0.510913915033401*std::exp(1.38239991664886*x_6) - 0.042244668533556*std::exp(1.39495980739594*x_6) - 0.000156230967974288*std::exp(1.45247983932495*x_6) + 160.76656510671*std::exp(1.46871984004974*x_6) - 0.138842177936656*std::exp(1.47207987308502*x_6) - 6.2853572416528e-5*std::exp(1.5525598526001*x_6) + 0.0624215016330007*std::exp(1.56399989128113*x_6) + 5.21630947008204e-6*std::exp(1.56935977935791*x_6) - 1594885.43597577*std::exp(1.57631981372833*x_6) - 2.75420714695858e-5*std::exp(1.65167987346649*x_6) - 0.000108314024032255*std::exp(1.00479984283447*x_8) - 597.748096611173*std::exp(1.01079976558685*x_8) - 0.0143561515714473*std::sin(0.269519954919815*x_112 + 1.9722398519516) - 49.0262388313004*std::sin(0.220639988780022*x_119 - 7.42039966583252) - 5901823468.72873*std::sin(0.375439822673798*x_13 + 8.22991943359375) - 0.155351004332935*std::sin(0.127600058913231*x_16 + 4.94623994827271) - 1634.62102911657*std::sin(0.262719959020615*x_17 + 5.04127979278564) - 1.46081297554859*std::sin(0.318879932165146*x_6 + 1.99967980384827) + 12.1961033302825*std::sin(0.306959927082062*x_8 - 7.41688013076782) - 0.0279797557456607*std::sin(0.342959851026535*x_91 + 2.01231980323792) - 0.0874920917230159*std::sin(0.361199855804443*x_91 + 1.99959981441498) + 27.827768622089*std::sin(0.376159846782684*x_91 + 2.00047969818115) + 16.7301836751772*std::sin(0.406799852848053*x_91 - 1.17383992671967) - 0.21817191816261*std::sin(0.288879930973053*x_94 + 1.97015976905823) + 0.413222136694651*std::sin(0.283439934253693*x_95 + 1.95063984394073) - 70.82322404183*std::sin(0.265279948711395*x_96 + 1.97727978229523) + 3728118920750.79 + 0.107090739131849*std::exp(-4.160560131073*x_94) + 0.00177306191820413*std::exp(-6.41871976852417*x_93) + 0.00254479368363703*std::exp(-6.35647964477539*x_93) + 0.0709843633248266*std::exp(-6.33199977874756*x_93) - 0.0136823217665173*std::exp(-7.98184013366699*x_113) + 3.32916094189946*std::exp(-7.9015998840332*x_113));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (14021423968.153*x_1 + 52965932591.3146*x_10 - 6744185249.72645*x_100 - 1482206642.73291*x_101 - 904183277.638088*x_102 + 717434414.02625*x_103 - 110840781617.325*x_104 - 3044796625.03632*x_105 + 15588792930.8032*x_106 - 427099543.516615*x_107 + 3239087462.49631*x_108 + 1199028511.96174*x_109 - 20283181321.538*x_11 + 5147486713.3102*x_110 - 1778924680.4683*x_111 + 5654270459.90261*x_112 + 302270088.684484*x_113 + 4894399138.13291*x_114 - 4803181973.81295*x_115 + 6840346915.64756*x_116 - 3921815485.80201*x_117 - 567944685.212115*x_118 - 2945717741.16486*x_119 - 18183479335.0378*x_12 + 2618764779.42424*x_120 + 5059.01921155371*x_13 - 3228218044.17755*x_14 - 28018923218.984*x_15 + 10517652428.4588*x_16 + 17107838257.5679*x_17 - 42688053843.5738*x_18 + 8713598716.9859*x_19 - 4769216801.26919*x_2 - 4849616819.20694*x_20 + 14222329183.7519*x_21 + 11111495430.5692*x_22 + 33783999151.1893*x_23 + 235606238995.472*x_24 + 16015995165.5856*x_25 - 13253774133.2649*x_26 - 48638626883.4047*x_27 - 45226443014.5217*x_28 + 7054619709.97216*x_29 - 906520759.180848*x_3 + 37381837558.172*x_30 + 3400799965.55284*x_31 - 4399807828.7267*x_32 - 10199544260.7945*x_33 + 486151599.371494*x_34 + 7542752492.73123*x_35 + 25151345903.7627*x_36 + 219879402446.105*x_37 - 1875025011.72647*x_38 + 154230731694.806*x_39 - 159649.871823671*x_4 - 4082220739.53262*x_40 - 5904520159199.0*x_41 - 129160300780.403*x_42 - 96788269771.9919*x_43 - 538705081.411127*x_44 + 321970822111.518*x_45 + 276986577922.228*x_46 - 23773665849.3953*x_47 - 21619928297.5914*x_48 - 83401666891.4806*x_49 + 80.1044115404228*x_5 - 78041031018.28*x_50 + 4770062907.47543*x_51 - 66355075112.7993*x_52 - 15524024896.7692*x_53 + 7001120703.39815*x_54 - 18490146811.3917*x_55 + 58624795835.8025*x_56 + 32873045511.0058*x_57 + 119253424401.902*x_58 - 80776032896.743*x_59 + 41.5951490013001*x_6 - 25753777191.9479*x_60 + 4540325125.57017*x_61 + 17780924086.4484*x_62 + 4064140452.59882*x_63 - 1022802046.89539*x_64 - 360000926.500228*x_65 - 11962773150.2084*x_66 - 3609845293.27788*x_67 - 3393452387.20601*x_68 - 797428706.279935*x_69 + 2722222947.53701*x_7 + 1749111156.05405*x_70 - 3823510973.88841*x_71 - 32353789.1177172*x_72 - 9681309597.07691*x_73 + 5583309267.09521*x_74 - 945021613.005623*x_75 - 14415239697.1545*x_76 - 2557977477.06452*x_77 + 5553675899.00672*x_78 - 2245245776.61987*x_79 - 9703098904.02299*x_8 - 2244344191.44346*x_80 - 540158484.243199*x_81 - 3395580328.61356*x_82 + 10873467598.607*x_83 + 14191342322.4511*x_84 + 125993697042.483*x_85 + 8822762284.3514*x_86 + 224784693409.795*x_87 - 2847016981.85691*x_88 - 12491292670.1958*x_89 - 5217472038.96045*x_9 + 13677487258.6333*x_90 + 1764092075.61691*x_91 - 6808756467.02911*x_92 - 5355631488.52077*x_93 - 3620479340.85656*x_94 - 4550285233.12228*x_95 + 2150983254.37505*x_96 - 3638916770.71205*x_97 - 434678723.804105*x_98 + 4747864998.0588*x_99 + 50.1724100168726*std::exp(1.02479982376099*x_1) + 7.88246183890934e-5*std::exp(0.983519792556763*x_13) + 0.659399979143331*std::exp(0.301039844751358*x_16) - 274.363124709811*std::exp(0.385279834270477*x_18) - 16.4101302465555*std::exp(0.316879838705063*x_20) - 3.1659349875435*std::exp(0.957519829273224*x_23) - 0.000760665451086756*std::exp(0.975119829177856*x_23) + 4.06037068950351*std::exp(0.976639807224274*x_23) + 0.00132415841334679*std::exp(0.977119863033295*x_23) + 103.130211203536*std::exp(0.98991984128952*x_23) - 0.00230314385474516*std::exp(0.994559824466705*x_23) - 2.79167813897845*std::exp(0.997679829597473*x_23) - 0.000555045860621678*std::exp(0.916079819202423*x_24) + 64.0742174962284*std::exp(0.69599986076355*x_3) + 0.00241272676709906*std::exp(0.743999838829041*x_3) + 1.78845271135027*std::exp(0.807439863681793*x_3) + 5.75127506087771*std::exp(0.713839828968048*x_4) + 767177737.108899*std::exp(0.738399803638458*x_4) - 0.0491533893676909*std::exp(1.01455986499786*x_4) - 199371618.47705*std::exp(1.04143977165222*x_5) + 5.68139090635729e-5*std::exp(1.13007986545563*x_5) + 6.40017013661308*std::exp(1.25863993167877*x_5) - 0.0489541269018285*std::exp(1.26903986930847*x_5) - 296.172681522697*std::exp(1.30655980110168*x_5) + 0.00860656537276677*std::exp(1.31783986091614*x_5) - 0.546017194502326*std::exp(1.35319983959198*x_5) + 5.00492883886591e-5*std::exp(1.38263988494873*x_5) - 3.66482309863495e-5*std::exp(1.41631984710693*x_5) - 0.0255580635927683*std::exp(1.38239991664886*x_6) + 0.0865874602998423*std::exp(1.39495980739594*x_6) + 6.70173175643202e-5*std::exp(1.45247983932495*x_6) - 68.4198015420055*std::exp(1.46871984004974*x_6) + 0.0432504898903089*std::exp(1.47207987308502*x_6) - 3.34180633484216e-5*std::exp(1.5525598526001*x_6) + 0.30713601330451*std::exp(1.56399989128113*x_6) + 9.44059451168187e-6*std::exp(1.56935977935791*x_6) + 5070558.14939204*std::exp(1.57631981372833*x_6) + 2.15976418659879e-6*std::exp(1.65167987346649*x_6) - 0.000196029163277577*std::exp(1.00479984283447*x_8) + 254.392485869819*std::exp(1.01079976558685*x_8) - 0.0259820868588434*std::sin(0.269519954919815*x_112 + 1.9722398519516) + 15.2720799863887*std::sin(0.220639988780022*x_119 - 7.42039966583252) + 18763441191.8288*std::sin(0.375439822673798*x_13 + 8.22991943359375) - 0.0825972097438615*std::sin(0.127600058913231*x_16 + 4.94623994827271) - 1441.60200675052*std::sin(0.262719959020615*x_17 + 5.04127979278564) + 1.82522282079293*std::sin(0.318879932165146*x_6 + 1.99967980384827) - 24.9979381915326*std::sin(0.306959927082062*x_8 - 7.41688013076782) - 0.0148763103517084*std::sin(0.342959851026535*x_91 + 2.01231980323792) + 0.00686085963151514*std::sin(0.361199855804443*x_91 + 1.99959981441498) - 102.222615114881*std::sin(0.376159846782684*x_91 + 2.00047969818115) + 82.3184604890945*std::sin(0.406799852848053*x_91 - 1.17383992671967) - 0.0174854597469173*std::sin(0.288879930973053*x_94 + 1.97015976905823) + 0.0331178233136503*std::sin(0.283439934253693*x_95 + 1.95063984394073) + 260.162259890154*std::sin(0.265279948711395*x_96 + 1.97727978229523) - 11852740625497.3 + 0.0817741296345117*std::exp(-4.160560131073*x_94) + 0.00872409593894427*std::exp(-6.41871976852417*x_93) - 0.00521597706177251*std::exp(-6.35647964477539*x_93) + 0.00355093650528091*std::exp(-6.33199977874756*x_93) - 0.0104477750635259*std::exp(-7.98184013366699*x_113) - 1.41684019183321*std::exp(-7.9015998840332*x_113));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-21555102628.7959*x_1 - 81425014943.9728*x_10 + 10367798836.5143*x_100 + 2278582071.61516*x_101 + 1389987060.26091*x_102 - 1102899509.2431*x_103 + 170395292454.576*x_104 + 4680771575.91371*x_105 - 23964565028.7935*x_106 + 656580800.708485*x_107 - 4979419500.04078*x_108 - 1843253651.66198*x_109 + 31181312774.1762*x_11 - 7913198071.10122*x_110 + 2734743348.47009*x_111 - 8692318701.42264*x_112 - 464679201.372513*x_113 - 7524164465.64841*x_114 + 7383934014.46951*x_115 - 10515534991.8081*x_116 + 6029026487.07108*x_117 + 873122422.946719*x_118 + 4528447895.21978*x_119 + 27953446365.0754*x_12 - 4025841628.42141*x_120 - 1044.09414530682*x_13 + 4962747055.05227*x_14 + 43073562081.2825*x_15 - 16168757049.0646*x_16 - 26299878524.6243*x_17 + 65624698043.0942*x_18 - 13395355026.9791*x_19 + 7331717080.61965*x_2 + 7455432538.56926*x_20 - 21863933005.7551*x_21 - 17081852212.3111*x_22 - 51935851474.1351*x_23 - 362197735936.332*x_24 - 24621306108.8869*x_25 + 20375155918.906*x_26 + 74771936238.6977*x_27 + 69528488901.6335*x_28 - 10843968218.3351*x_29 + 1393605999.5718*x_3 - 57467138364.9018*x_30 - 5228042634.62488*x_31 + 6763815623.526*x_32 + 15679609642.2686*x_33 - 748562852.58577*x_34 - 11595493206.1189*x_35 - 38664981154.9189*x_36 - 338020110777.401*x_37 + 2882409252.81251*x_38 - 237098503356.707*x_39 + 31737.9897661164*x_4 + 6275532825.89622*x_40 + 9077005508541.02*x_41 + 198560112146.789*x_42 + 148792679094.957*x_43 + 828186998.623579*x_44 - 494966083045.68*x_45 - 425811447251.459*x_46 + 36545865979.6253*x_47 + 33236258644.1316*x_48 + 128211932225.48*x_49 + 92.3811495583481*x_5 + 119972568195.652*x_50 - 7332736821.3964*x_51 + 102007859879.201*x_52 + 23864882718.5074*x_53 - 10762775193.2322*x_54 + 28425340482.29*x_55 - 90122865565.3798*x_56 - 50535665171.3636*x_57 - 183328272932.684*x_58 + 124175985314.494*x_59 - 349.931218514843*x_6 + 39590884286.4259*x_60 - 6979832688.32425*x_61 - 27334579835.9587*x_62 - 6247793947.44348*x_63 + 1572341347.92701*x_64 + 553412875.133249*x_65 + 18390396920.8713*x_66 + 5549398403.62632*x_67 + 5216743934.65982*x_68 + 1225876069.20949*x_69 - 4184908988.5603*x_7 - 2688894015.45028*x_70 + 5877870313.38893*x_71 + 49746500.7699093*x_72 + 14883053807.3607*x_73 - 8583241393.43859*x_74 + 1452785439.68531*x_75 + 22160491548.2072*x_76 + 3932375037.11902*x_77 - 8537629012.67482*x_78 + 3451600310.06978*x_79 + 14916558262.9849*x_8 + 3450247065.31646*x_80 + 830392514.21664*x_81 + 5220022605.99585*x_82 - 16715726447.8006*x_83 - 21816306331.8531*x_84 - 193690586170.568*x_85 - 13563230980.416*x_86 - 345562151713.313*x_87 + 4376713966.73515*x_88 + 19202758563.8499*x_89 + 8020791672.65164*x_9 - 21026425601.4255*x_90 - 2711931036.75163*x_91 + 10467099291.7244*x_92 + 8233199854.78605*x_93 + 5565774668.96481*x_94 + 6995169990.35523*x_95 - 3306702312.85487*x_96 + 5594084349.8989*x_97 + 668205674.189507*x_98 - 7298889202.82401*x_99 + 712.479273595808*std::exp(1.02479982376099*x_1) + 3.57970138231828e-5*std::exp(0.983519792556763*x_13) + 2.22212815877156*std::exp(0.301039844751358*x_16) + 518.986713620938*std::exp(0.385279834270477*x_18) - 1.36332297031866*std::exp(0.316879838705063*x_20) - 5.48557313197833*std::exp(0.957519829273224*x_23) - 0.00149306752929948*std::exp(0.975119829177856*x_23) + 0.337328012991895*std::exp(0.976639807224274*x_23) + 0.000601346609668044*std::exp(0.977119863033295*x_23) + 7.27898537108927*std::exp(0.98991984128952*x_23) - 0.0319149942550936*std::exp(0.994559824466705*x_23) + 90.4658556668064*std::exp(0.997679829597473*x_23) - 0.00220908258749785*std::exp(0.916079819202423*x_24) - 121.203123055887*std::exp(0.69599986076355*x_3) + 0.00473580598130316*std::exp(0.743999838829041*x_3) + 3.0988280491537*std::exp(0.807439863681793*x_3) + 81.6716652886681*std::exp(0.713839828968048*x_4) - 1179381025.73245*std::exp(0.738399803638458*x_4) - 0.165643212113701*std::exp(1.01455986499786*x_4) + 306493648.769718*std::exp(1.04143977165222*x_5) + 0.000787278474871458*std::exp(1.13007986545563*x_5) - 12.1065951167049*std::exp(1.25863993167877*x_5) + 1.58638523430066*std::exp(1.26903986930847*x_5) + 39.6883007411636*std::exp(1.30655980110168*x_5) + 0.0290034756900958*std::exp(1.31783986091614*x_5) - 0.668014827052152*std::exp(1.35319983959198*x_5) + 9.82389396690633e-5*std::exp(1.38263988494873*x_5) - 0.000145859963434131*std::exp(1.41631984710693*x_5) + 0.828223017483137*std::exp(1.38239991664886*x_6) + 0.0071935244751094*std::exp(1.39495980739594*x_6) + 0.000131544531979311*std::exp(1.45247983932495*x_6) + 9.16852170932498*std::exp(1.46871984004974*x_6) + 0.0749395443117637*std::exp(1.47207987308502*x_6) - 0.000133003895873059*std::exp(1.5525598526001*x_6) + 0.375759981324591*std::exp(1.56399989128113*x_6) + 4.28730387967853e-6*std::exp(1.56935977935791*x_6) - 7794960.38793047*std::exp(1.57631981372833*x_6) - 1.68825808313836e-5*std::exp(1.65167987346649*x_6) - 8.90236934983413e-5*std::exp(1.00479984283447*x_8) - 34.089590686033*std::exp(1.01079976558685*x_8) - 0.0117993736151071*std::sin(0.269519954919815*x_112 + 1.9722398519516) + 26.4617283590403*std::sin(0.220639988780022*x_119 - 7.42039966583252) - 28845006116.162*std::sin(0.375439822673798*x_13 + 8.22991943359375) - 0.328736904040152*std::sin(0.127600058913231*x_16 + 4.94623994827271) + 2726.94185351669*std::sin(0.262719959020615*x_17 + 5.04127979278564) + 6.15086313982853*std::sin(0.318879932165146*x_6 + 1.99967980384827) - 2.07678201422417*std::sin(0.306959927082062*x_8 - 7.41688013076782) - 0.0592077168675126*std::sin(0.342959851026535*x_91 + 2.01231980323792) - 0.0536304000318846*std::sin(0.361199855804443*x_91 + 1.99959981441498) - 1451.62439949808*std::sin(0.376159846782684*x_91 + 2.00047969818115) + 100.711026503374*std::sin(0.406799852848053*x_91 - 1.17383992671967) - 0.242298520008115*std::sin(0.288879930973053*x_94 + 1.97015976905823) + 0.458918420844061*std::sin(0.283439934253693*x_95 + 1.95063984394073) + 3694.46510305655*std::sin(0.265279948711395*x_96 + 1.97727978229523) + 18221592493803.2 + 0.00577166173128868*std::exp(-4.160560131073*x_94) + 0.0106733368445513*std::exp(-6.41871976852417*x_93) - 0.000433333631977864*std::exp(-6.35647964477539*x_93) - 0.115070037940078*std::exp(-6.33199977874756*x_93) - 0.000737409542367238*std::exp(-7.98184013366699*x_113) + 0.189862141729418*std::exp(-7.9015998840332*x_113));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
