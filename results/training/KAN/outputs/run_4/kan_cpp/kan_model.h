
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0177363079049126*x_1 + 0.0104875899308513*x_10 + 0.00432998400333628*x_100 + 0.0849204750631695*x_101 + 0.000345649034189744*x_102 - 0.0281327238347127*x_103 + 0.0171686442549524*x_104 - 0.03166746146408*x_105 + 0.0264877474684096*x_106 - 0.0472323856928183*x_107 - 0.0278167357385684*x_108 - 0.011478104098257*x_11 + 0.0514626245900343*x_110 - 0.00787127053961969*x_111 - 0.000476731781776651*x_112 - 0.0135094927370309*x_113 - 0.024153864373704*x_114 - 0.000422814293832187*x_115 + 0.0112882261050903*x_116 - 0.00837513350645315*x_117 - 0.0623782084595882*x_118 + 0.0203081205893499*x_119 - 0.207362132739087*x_12 + 0.021040767531656*x_120 - 0.00798479719285354*x_13 - 0.0391708105021861*x_14 - 0.0195429710682278*x_15 - 0.0277943726428468*x_16 + 0.0143278812782254*x_17 + 0.0430432869289697*x_18 + 0.00584897518399514*x_19 - 0.0437331263024781*x_2 - 0.0134304352679026*x_20 - 0.0977566296636678*x_21 + 0.0286886338733699*x_22 + 0.0226661409307618*x_23 + 0.00130951277607196*x_24 - 0.0475107950567412*x_25 - 0.00415651982597032*x_26 + 0.034628640370794*x_27 - 0.000872774373152891*x_28 + 0.00271160866472299*x_29 - 0.0635940915787712*x_3 + 0.0371402727700648*x_30 - 0.0602347108962507*x_31 - 0.15350435594264*x_32 + 0.0130265400708807*x_33 - 0.000280158468278024*x_34 + 0.00139864666400428*x_35 - 0.00607646351432342*x_36 - 0.0656492503470315*x_37 - 0.0077480593939698*x_38 + 0.00822154362346356*x_39 - 0.031011019128966*x_4 - 0.00407124338724351*x_40 - 0.0230877515592888*x_41 + 0.0255133762032672*x_42 + 0.0005936542719662*x_43 - 0.0827074339082518*x_44 - 0.0209956390173417*x_45 - 0.0425223970758648*x_46 - 0.0191797950053548*x_47 + 0.0457752832176296*x_48 - 0.0239254090568964*x_49 + 0.0295436424248183*x_5 - 0.00971273143813467*x_50 - 0.0404021484228372*x_51 + 0.00343094899162568*x_52 + 0.00110106105605475*x_53 - 0.00253584142811582*x_54 - 0.044663018864092*x_55 - 0.042766060821088*x_56 - 0.0450501078586481*x_57 - 0.00338313922781334*x_58 + 0.00405254711505992*x_59 - 0.000846313429212278*x_6 - 0.0213459443180319*x_60 - 0.00847099270910198*x_61 + 0.00333929160769717*x_62 + 0.0377234716853966*x_63 - 0.00592536941864143*x_64 - 0.016556904739072*x_65 + 0.000292511152306454*x_66 + 0.000678475367664825*x_67 - 0.00880130015484331*x_68 + 0.022331463862959*x_69 - 0.0230196519292259*x_7 - 5.07912627549608e-5*x_70 + 0.0343716870408293*x_71 - 0.0230250187745295*x_72 - 0.0310613916154254*x_73 - 0.00964841056107197*x_74 - 0.00309928547920933*x_75 - 0.0493904275719355*x_76 + 0.00143901931281928*x_77 + 0.0027868434722202*x_78 + 0.046957960845246*x_79 + 0.0289089476728436*x_8 + 0.0197753427963598*x_80 - 0.00211414380193108*x_81 + 0.00909350965695391*x_82 + 0.00310015692622232*x_83 + 0.0563521638490561*x_84 - 0.0464705141478201*x_85 - 0.022324541234495*x_86 - 0.00202168765179513*x_87 + 0.0120364651422924*x_88 + 0.0124238272030008*x_89 + 0.107462503934466*x_9 + 0.0172960269274423*x_90 + 0.0179063463473957*x_91 - 0.0112469593547887*x_92 - 0.00196511037527739*x_93 - 0.0433291194334089*x_94 - 3.86317146132279e-5*x_95 - 0.00291731331653482*x_96 - 0.0323442103141844*x_97 + 0.0106081673564489*x_98 - 0.00359139811195589*x_99 - 1.4821491941154e-5*std::pow(-5.44952011108398*x_114 - 6.8145604133606, 2) - 4.06189244943635e-6*std::pow(-7.48392009735107*x_15 - 9.32503986358643, 2) - 5.08568985299791e-5*std::pow(-4.71783971786499*x_15 - 6.56799983978271, 2) - 3.89726223812447e-6*std::pow(-7.35176038742065*x_23 - 9.59408092498779, 2) + 1.04971319932643e-5*std::pow(-4.51768016815186*x_24 - 6.28480005264282, 2) + 2.67864926852046e-6*std::pow(-9.80399990081787*x_40 - 9.97720050811768, 2) - 7.97072555343608e-6*std::pow(-6.20391988754272*x_50 - 5.59935998916626, 2) - 3.9509934054943e-5*std::pow(-7.59695959091187*x_56 - 6.57599973678589, 2) - 5.83956336535232e-5*std::pow(-5.34607982635498*x_59 - 6.13520002365112, 2) + 0.00100452507736131*std::pow(-5.23920011520386*x_59 - 6.44536018371582, 2) - 1.44442712226812e-5*std::pow(-5.6637601852417*x_67 - 8.90248012542725, 2) - 3.8177448030293e-5*std::pow(-5.33192014694214*x_7 - 7.97664022445679, 2) - 2.02932189800414e-5*std::pow(-7.07024002075195*x_70 - 9.68871974945068, 2) + 0.00217747021786198*std::pow(-3.4670398235321*x_70 - 4.69191980361938, 2) + 7.52938943976371e-5*std::pow(-5.50519990921021*x_77 - 7.96400022506714, 2) + 6.76874337136098e-5*std::pow(-7.53200006484985*x_81 - 9.99948024749756, 2) + 3.90195185603058e-5*std::pow(-7.6625599861145*x_84 - 7.4585599899292, 2) + 6.00878972072927e-5*std::pow(-8.54800033569336*x_88 - 8.59800052642822, 2) + 7.27939262589133e-5*std::pow(-5.06239986419678*x_90 - 7.8996000289917, 2) - 0.0006572746370297*std::exp(0.617359817028046*x_1) - 0.000276438303159234*std::exp(1.14975988864899*x_1) - 0.000157892085201911*std::exp(1.20047986507416*x_1) + 4.6099861727056e-6*std::exp(1.31991982460022*x_1) + 0.000649066905514387*std::exp(1.33495986461639*x_100) + 0.000559287505014002*std::exp(1.53511989116669*x_100) - 0.008971810319812*std::exp(1.60943984985352*x_100) - 0.00129470345847513*std::exp(0.885279893875122*x_104) + 9.30540458953337e-5*std::exp(1.19487988948822*x_106) + 0.00222521517367705*std::exp(0.567839860916138*x_109) - 0.00178063291020925*std::exp(0.605279862880707*x_109) + 0.0344038991683112*std::exp(0.867999851703644*x_109) + 0.00190889286350765*std::exp(0.871279835700989*x_109) - 0.00465758908885887*std::exp(0.886719882488251*x_109) + 0.000340555622697299*std::exp(1.18495988845825*x_110) - 7.2819408406399e-5*std::exp(1.75111997127533*x_110) - 0.00232600326321115*std::exp(0.616399824619293*x_112) + 0.00429903781030898*std::exp(0.721439838409424*x_114) + 0.073547208723352*std::exp(0.60511988401413*x_26) - 0.00753867372775158*std::exp(0.78143984079361*x_26) - 5.94346063809249e-5*std::exp(1.22703981399536*x_26) - 0.00215561142063433*std::exp(0.598719835281372*x_31) - 0.0175907322661234*std::exp(0.628879845142365*x_31) + 0.00269601250991398*std::exp(0.654159843921661*x_31) - 0.00112160373309376*std::exp(0.657919824123383*x_31) - 0.00185985318419738*std::exp(0.81335985660553*x_49) - 0.00190291951520246*std::exp(0.863999843597412*x_50) + 0.00302589281235654*std::exp(1.00015985965729*x_66) - 0.000621278132258894*std::exp(1.11055994033813*x_66) - 0.00190440794841658*std::exp(1.48999989032745*x_66) + 0.00438860972803008*std::exp(1.06511986255646*x_68) + 0.000827670542603466*std::exp(1.17007982730865*x_68) + 0.00193957316170207*std::exp(0.887999892234802*x_72) - 0.00298346266850845*std::exp(0.634559869766235*x_74) + 0.00295929785668296*std::exp(1.08279979228973*x_74) + 0.00281169335954182*std::exp(1.17399990558624*x_74) - 0.000483365858349553*std::exp(0.905119836330414*x_77) + 0.00186610090538856*std::exp(0.957039833068848*x_81) - 0.0576531881594435*std::sin(0.528159856796265*x_10 - 4.05343961715698) + 0.00323378963098962*std::sin(0.329999834299088*x_100 - 7.44367980957031) + 0.0141373135994058*std::sin(0.344559848308563*x_102 - 7.43680000305176) - 0.28840297833463*std::sin(0.360319852828979*x_102 - 4.23464012145996) + 0.0142758773162586*std::sin(0.372879832983017*x_102 + 1.99031984806061) - 0.00619263870946304*std::sin(0.394319832324982*x_102 - 7.41599988937378) - 0.00484730964733012*std::sin(0.302079916000366*x_105 + 1.87591981887817) + 0.11050871449123*std::sin(0.202159985899925*x_108 + 4.98984003067017) + 0.00507265098356831*std::sin(0.260319977998734*x_111 + 5.06303977966309) - 0.479228629452857*std::sin(0.310319930315018*x_111 - 7.49119997024536) + 0.0107766571854761*std::sin(0.407119870185852*x_111 + 1.97735977172852) - 0.00488932597584428*std::sin(0.495199859142303*x_112 - 7.34656000137329) + 0.219175421051426*std::sin(0.157280027866364*x_114 - 7.63944053649902) - 0.0870479827944327*std::sin(0.154240027070045*x_115 - 7.65759992599487) + 0.00858535952312237*std::sin(0.424319863319397*x_115 - 4.16856002807617) - 0.0292456666117568*std::sin(0.433519870042801*x_115 - 4.18584012985229) - 0.313943196121489*std::sin(0.438559859991074*x_115 - 7.3557596206665) - 0.180443743063364*std::sin(0.416879862546921*x_117 + 5.20480012893677) - 0.00262831602629775*std::sin(0.526559829711914*x_118 - 4.02767992019653) + 0.0578147670568597*std::sin(0.26623997092247*x_120 + 5.06559944152832) + 0.00488065479756002*std::sin(0.598879814147949*x_120 - 4.00255966186523) - 0.0472156010120767*std::sin(0.452239871025085*x_2 - 4.13647985458374) - 0.265174194799766*std::sin(0.315839856863022*x_24 + 5.1191201210022) - 0.0449762096566114*std::sin(0.384239852428436*x_24 + 5.1701602935791) + 0.0266555828310563*std::sin(0.278319954872131*x_28 - 4.29287958145142) + 0.39676811431773*std::sin(0.343279838562012*x_28 - 4.25920009613037) - 0.00639786473889358*std::sin(0.348079830408096*x_28 + 8.34904003143311) + 0.00356557295544916*std::sin(0.367599844932556*x_28 + 5.1799201965332) - 0.0669530047575199*std::sin(0.281519949436188*x_3 + 1.88359987735748) + 0.00928022153592311*std::sin(0.309279918670654*x_35 - 1.13063991069794) + 0.0529945092492345*std::sin(0.321199834346771*x_35 + 1.9799998998642) - 0.145990548063636*std::sin(0.32287985086441*x_35 + 1.98631989955902) + 0.0577355076871573*std::sin(0.287839949131012*x_36 - 7.49151992797852) - 0.00563055832510924*std::sin(0.403199851512909*x_36 + 5.21271991729736) + 0.0374040935958018*std::sin(0.410559862852097*x_36 + 5.20024013519287) + 0.0226171580267497*std::sin(0.614959836006165*x_38 + 2.18871974945068) + 0.0254075013369831*std::sin(0.417519867420197*x_41 + 1.98311984539032) - 0.0503135654218596*std::sin(0.271999955177307*x_43 - 1.33087992668152) - 0.0572006365559284*std::sin(0.397759854793549*x_43 + 8.20655918121338) + 0.210880811463143*std::sin(0.434879869222641*x_43 - 4.36527967453003) - 0.00679311584719526*std::sin(0.438959866762161*x_45 + 5.22911977767944) + 0.00385763038732494*std::sin(0.594159841537476*x_46 + 2.18767976760864) - 0.0285649851670046*std::sin(0.153040036559105*x_49 + 1.74503993988037) - 0.0321316758583548*std::sin(0.412159860134125*x_51 + 1.99223983287811) - 0.0176150076100422*std::sin(0.232959985733032*x_53 + 5.03399991989136) + 0.0566922986107485*std::sin(0.250639975070953*x_53 + 5.05167961120605) - 0.00771342718792303*std::sin(0.423519849777222*x_53 + 5.22088003158569) - 0.00802825156562928*std::sin(0.30703991651535*x_55 + 5.13463973999023) + 0.0327388381626201*std::sin(0.153440043330193*x_56 + 1.72919988632202) + 0.0128068807929799*std::sin(0.72655987739563*x_57 + 2.35935997962952) - 0.0263590332205757*std::sin(0.447759836912155*x_58 + 5.23080015182495) + 0.0298901436219975*std::sin(0.490319848060608*x_58 + 5.28128004074097) - 0.0788703524489066*std::sin(0.537279844284058*x_58 + 8.55719947814941) + 0.0357458537717621*std::sin(0.202960014343262*x_59 - 7.60008001327515) + 0.0315141322738618*std::sin(0.264799952507019*x_63 + 1.86583995819092) + 0.00739869913889207*std::sin(0.281759947538376*x_64 - 7.50191974639893) + 0.00828373539016813*std::sin(0.426319867372513*x_64 - 7.37799978256226) + 0.0111311523866073*std::sin(0.530159831047058*x_64 + 8.52952003479004) - 0.0317654265311482*std::sin(0.235039979219437*x_66 + 5.03575992584229) + 0.0887446271353424*std::sin(0.233679994940758*x_70 + 5.0449595451355) + 0.00129517212346753*std::sin(0.683279812335968*x_70 + 5.45639991760254) - 0.00808912939014868*std::sin(0.282959938049316*x_71 - 4.2960000038147) + 0.0265374439012993*std::sin(0.23463998734951*x_73 + 5.05839967727661) - 0.0927581230695767*std::sin(0.25095996260643*x_73 - 7.52400016784668) - 0.06722241440667*std::sin(0.186240002512932*x_75 - 4.40799999237061) + 0.0159926186256747*std::sin(0.468879848718643*x_75 + 5.25735998153687) + 0.00344261833765912*std::sin(0.317759931087494*x_76 + 5.14647960662842) + 0.0613354770202759*std::sin(0.282799959182739*x_78 + 5.10743999481201) - 0.0336491218270779*std::sin(0.336639851331711*x_79 + 8.31711959838867) + 0.00476136108834189*std::sin(0.376399844884872*x_81 - 7.40743970870972) + 0.0697701225529794*std::sin(0.266319960355759*x_84 - 7.53360033035278) - 0.00656028188748259*std::sin(0.277999937534332*x_84 - 7.50880002975464) + 0.0206057543886399*std::sin(0.282879948616028*x_84 - 7.50984001159668) - 0.0311906241668851*std::sin(0.172720015048981*x_85 + 4.94823980331421) - 0.3702168136642*std::sin(0.125600054860115*x_86 + 4.900559425354) - 0.013126977982546*std::sin(0.254159986972809*x_86 - 4.33599996566772) + 0.00839462811736641*std::sin(0.30895984172821*x_87 - 4.30751991271973) - 0.00888505180733746*std::sin(0.346319854259491*x_87 + 5.14383983612061) - 0.00675280654315745*std::sin(0.510159850120544*x_87 + 5.31903982162476) - 0.049187080565607*std::sin(1.01335978507996*x_87 - 6.99656009674072) + 0.00590233363591985*std::sin(0.336639851331711*x_92 + 8.38432025909424) - 0.0437660190932841*std::sin(0.348559856414795*x_92 + 1.99535977840424) - 0.0194617517832838*std::sin(0.375519841909409*x_92 - 1.20735991001129) + 0.0119256573961284*std::sin(0.364159852266312*x_95 - 7.40639972686768) + 0.00281811461194614*std::sin(0.377039849758148*x_95 - 1.2163999080658) + 0.0185548380312207*std::sin(0.396079838275909*x_95 + 8.39648056030273) - 0.0878431822660959*std::sin(0.428159862756729*x_95 - 1.16703987121582) + 0.00458545835470861*std::sin(0.407679855823517*x_96 + 5.20000028610229) - 0.00677070548404033*std::sin(0.400159865617752*x_97 + 5.19280004501343) - 0.031813690669748*std::sin(0.439679861068726*x_98 + 2.02647995948792) + 0.026170643100588*std::sin(0.441519856452942*x_98 + 1.99927973747253) + 0.181225369891525*std::sin(0.164400026202202*x_99 - 1.41487991809845) - 0.744608535596637);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0052806338058229*x_1 - 0.00172743004821361*x_10 - 0.0029492810493994*x_100 + 0.000139837365522894*x_101 - 0.000118814109269516*x_102 - 0.00477930377927097*x_103 + 6.95289070462124e-5*x_104 + 7.4422138394955e-5*x_105 + 0.00670898792440589*x_106 - 0.00225446658625622*x_107 + 0.00110022876266273*x_108 + 0.00229950245209744*x_11 + 0.00733141272848395*x_110 + 0.00108641513441275*x_111 - 0.00147889426479748*x_112 - 9.8621963172094e-5*x_113 - 0.00349838319807502*x_114 + 0.000145339054182091*x_115 - 0.00659595392089879*x_116 + 0.0012446734919525*x_117 - 0.00854283415504849*x_118 - 0.000866203553525038*x_119 - 0.00941762617160853*x_12 - 0.00534046308104031*x_120 + 0.0066134148565415*x_13 - 0.00134715773629873*x_14 - 8.04914506218465e-5*x_15 + 0.00113830964850663*x_16 - 0.00365477464732858*x_17 + 0.0060856630640837*x_18 - 0.00288617521335709*x_19 - 0.00130223527009871*x_2 + 0.00550357754363022*x_20 - 0.0142312791214492*x_21 - 0.00228897210594699*x_22 + 0.00590471192467555*x_23 + 0.000884756538367905*x_24 - 0.0148614998941902*x_25 - 0.000995992068157003*x_26 - 0.00212557862744182*x_27 + 0.000594472616332516*x_28 + 0.00460045223089014*x_29 - 0.0064621269185303*x_3 - 0.0097129311782948*x_30 + 0.0410276553505703*x_31 + 0.00234353219316386*x_32 + 0.0100916328147772*x_33 - 0.00204249346865259*x_34 + 0.000546023648993248*x_35 - 0.00019210520000709*x_36 - 0.00809977013375*x_37 + 0.000471606551073509*x_38 + 0.00392838082596614*x_39 - 0.0118043059262424*x_4 + 0.00594898868126938*x_40 - 0.00418058977156652*x_41 - 0.00904315074147992*x_42 + 0.00021901116163792*x_43 - 0.00558625816086487*x_44 - 0.00423310258708021*x_45 - 0.00159130445501058*x_46 + 0.00250601791542222*x_47 + 0.00500077196567148*x_48 - 0.00245716212097446*x_49 + 0.0041036326286326*x_5 + 0.00242325787088175*x_50 - 0.00390982214747393*x_51 + 0.000138173140791528*x_52 + 0.00110040486610975*x_53 - 0.00464955037245969*x_54 - 0.00834611795614472*x_55 - 0.00394960874799857*x_56 - 0.0134431557681447*x_57 - 0.00503512817375414*x_58 - 0.00269057425009457*x_59 - 0.00245331083465439*x_6 - 0.00224643607853984*x_60 - 0.00838504237074765*x_61 + 0.00529176039442176*x_62 + 0.0107038144181231*x_63 - 0.000816592778947777*x_64 + 0.000667162211489826*x_65 + 0.000511419209860211*x_66 + 0.00529510761266939*x_67 - 0.000629987143147754*x_68 - 0.000130825939862629*x_69 + 0.00261987849432524*x_7 - 1.51220908309779e-5*x_70 + 0.00430486630551679*x_71 - 0.000551863017464133*x_72 - 0.003218443267491*x_73 - 0.000898915884714867*x_74 - 0.000152381195869992*x_75 - 0.0118275099125991*x_76 + 0.000171414465550522*x_77 - 0.00337028282573359*x_78 - 0.00557996433402903*x_79 + 0.0157845119275823*x_8 + 0.0098193351362602*x_80 - 0.000166351639376424*x_81 + 0.00604505303437527*x_82 - 0.0024933108012572*x_83 + 0.0052641193021453*x_84 - 0.00357209047522779*x_85 - 0.00206381011747532*x_86 + 0.00137703166447035*x_87 + 0.00327422251974209*x_88 + 0.000610092243870649*x_89 + 0.00345616271964208*x_9 + 0.00621613578973451*x_90 + 0.00295692778324539*x_91 - 0.000732455975022053*x_92 - 0.0256606462825326*x_93 + 0.00222757726117129*x_94 - 1.15018266065966e-5*x_95 - 0.00075083464748845*x_96 - 0.00674479785708252*x_97 + 0.0020017122911081*x_98 - 0.000929666380588952*x_99 + 5.09477009580422e-6*std::pow(-5.44952011108398*x_114 - 6.8145604133606, 2) + 1.39624325715148e-6*std::pow(-7.48392009735107*x_15 - 9.32503986358643, 2) - 8.89169341307503e-5*std::pow(-4.71783971786499*x_15 - 6.56799983978271, 2) + 1.33965293002465e-6*std::pow(-7.35176038742065*x_23 - 9.59408092498779, 2) - 3.60830572140289e-6*std::pow(-4.51768016815186*x_24 - 6.28480005264282, 2) - 9.20764403785344e-7*std::pow(-9.80399990081787*x_40 - 9.97720050811768, 2) + 2.73987358038849e-6*std::pow(-6.20391988754272*x_50 - 5.59935998916626, 2) + 2.69113926706148e-5*std::pow(-7.59695959091187*x_56 - 6.57599973678589, 2) - 1.73861414019449e-5*std::pow(-5.34607982635498*x_59 - 6.13520002365112, 2) + 9.3837387742392e-5*std::pow(-5.23920011520386*x_59 - 6.44536018371582, 2) - 4.30049519482228e-6*std::pow(-5.6637601852417*x_67 - 8.90248012542725, 2) - 6.67484988253589e-5*std::pow(-5.33192014694214*x_7 - 7.97664022445679, 2) - 3.54801583955336e-5*std::pow(-7.07024002075195*x_70 - 9.68871974945068, 2) + 0.000203407681635738*std::pow(-3.4670398235321*x_70 - 4.69191980361938, 2) - 5.12849136882099e-5*std::pow(-5.50519990921021*x_77 - 7.96400022506714, 2) - 4.61039267997784e-5*std::pow(-7.53200006484985*x_81 - 9.99948024749756, 2) + 1.16172875381473e-5*std::pow(-7.6625599861145*x_84 - 7.4585599899292, 2) - 4.09276561749838e-5*std::pow(-8.54800033569336*x_88 - 8.59800052642822, 2) + 2.16729473756444e-5*std::pow(-5.06239986419678*x_90 - 7.8996000289917, 2) - 0.00114916259732457*std::exp(0.617359817028046*x_1) + 0.000188290360474188*std::exp(1.14975988864899*x_1) - 1.47494384704319e-5*std::exp(1.20047986507416*x_1) - 1.58464611983879e-6*std::exp(1.31991982460022*x_1) + 0.00113481240406455*std::exp(1.33495986461639*x_100) + 0.000166516758842084*std::exp(1.53511989116669*x_100) - 0.000838098781906843*std::exp(1.60943984985352*x_100) + 0.000881861081179611*std::exp(0.885279893875122*x_104) + 0.00016269337511012*std::exp(1.19487988948822*x_106) + 0.00389051076144477*std::exp(0.567839860916138*x_109) + 0.000612078415489975*std::exp(0.605279862880707*x_109) + 0.00321382920034936*std::exp(0.867999851703644*x_109) + 0.000568334979341476*std::exp(0.871279835700989*x_109) + 0.00317242262906209*std::exp(0.886719882488251*x_109) - 0.000117063289536903*std::exp(1.18495988845825*x_110) - 2.16805341795147e-5*std::exp(1.75111997127533*x_110) - 0.000692521325747004*std::exp(0.616399824619293*x_112) + 0.00127995321886245*std::exp(0.721439838409424*x_114) + 0.0068703889010642*std::exp(0.60511988401413*x_26) + 0.00513481517385091*std::exp(0.78143984079361*x_26) - 0.000103913984796861*std::exp(1.22703981399536*x_26) - 0.000641790535045158*std::exp(0.598719835281372*x_31) - 0.00164323260964755*std::exp(0.628879845142365*x_31) + 0.00471364109272981*std::exp(0.654159843921661*x_31) + 0.000385542371941781*std::exp(0.657919824123383*x_31) + 0.00126680138924117*std::exp(0.81335985660553*x_49) - 0.00332701706317454*std::exp(0.863999843597412*x_50) + 0.0009008995538074*std::exp(1.00015985965729*x_66) + 0.00021355942181643*std::exp(1.11055994033813*x_66) - 0.00017789965736314*std::exp(1.48999989032745*x_66) + 0.00130662148033526*std::exp(1.06511986255646*x_68) + 0.00144707855268155*std::exp(1.17007982730865*x_68) + 0.00339110138537395*std::exp(0.887999892234802*x_72) - 0.00521621178729452*std::exp(0.634559869766235*x_74) + 0.000881072226941374*std::exp(1.08279979228973*x_74) - 0.00191512807798583*std::exp(1.17399990558624*x_74) - 0.000845104822162627*std::exp(0.905119836330414*x_77) + 0.00326264432322701*std::exp(0.957039833068848*x_81) - 0.00538565407059209*std::sin(0.528159856796265*x_10 - 4.05343961715698) - 0.00111158949271101*std::sin(0.329999834299088*x_100 - 7.44367980957031) + 0.00420910465226329*std::sin(0.344559848308563*x_102 - 7.43680000305176) - 0.0269410716705415*std::sin(0.360319852828979*x_102 - 4.23464012145996) + 0.0249595881715077*std::sin(0.372879832983017*x_102 + 1.99031984806061) + 0.00421799063865457*std::sin(0.394319832324982*x_102 - 7.41599988937378) + 0.00166622417867051*std::sin(0.302079916000366*x_105 + 1.87591981887817) - 0.0752707763334344*std::sin(0.202159985899925*x_108 + 4.98984003067017) - 0.00174368347263181*std::sin(0.260319977998734*x_111 + 5.06303977966309) - 0.0447669886324281*std::sin(0.310319930315018*x_111 - 7.49119997024536) + 0.0188416388888875*std::sin(0.407119870185852*x_111 + 1.97735977172852) - 0.00854837570328123*std::sin(0.495199859142303*x_112 - 7.34656000137329) - 0.14928690621098*std::sin(0.157280027866364*x_114 - 7.63944053649902) - 0.152192524044396*std::sin(0.154240027070045*x_115 - 7.65759992599487) + 0.00255612047197186*std::sin(0.424319863319397*x_115 - 4.16856002807617) + 0.0199200944503832*std::sin(0.433519870042801*x_115 - 4.18584012985229) - 0.0293269029190615*std::sin(0.438559859991074*x_115 - 7.3557596206665) - 0.0168560943525705*std::sin(0.416879862546921*x_117 + 5.20480012893677) - 0.00459528224764532*std::sin(0.526559829711914*x_118 - 4.02767992019653) + 0.0172131998966745*std::sin(0.26623997092247*x_120 + 5.06559944152832) + 0.00853321523123862*std::sin(0.598879814147949*x_120 - 4.00255966186523) + 0.0321599519059715*std::sin(0.452239871025085*x_2 - 4.13647985458374) - 0.0247711623109157*std::sin(0.315839856863022*x_24 + 5.1191201210022) + 0.0306346357658256*std::sin(0.384239852428436*x_24 + 5.1701602935791) + 0.00793617096445427*std::sin(0.278319954872131*x_28 - 4.29287958145142) + 0.0370639660732521*std::sin(0.343279838562012*x_28 - 4.25920009613037) - 0.011185867286624*std::sin(0.348079830408096*x_28 + 8.34904003143311) - 0.00122563737442591*std::sin(0.367599844932556*x_28 + 5.1799201965332) + 0.0456036853668638*std::sin(0.281519949436188*x_3 + 1.88359987735748) + 0.0162253080875946*std::sin(0.309279918670654*x_35 - 1.13063991069794) - 0.0360961383992554*std::sin(0.321199834346771*x_35 + 1.9799998998642) - 0.0136376601979487*std::sin(0.32287985086441*x_35 + 1.98631989955902) + 0.0171896019917823*std::sin(0.287839949131012*x_36 - 7.49151992797852) + 0.00193545968862934*std::sin(0.403199851512909*x_36 + 5.21271991729736) - 0.0254770420230331*std::sin(0.410559862852097*x_36 + 5.20024013519287) - 0.0154052198595117*std::sin(0.614959836006165*x_38 + 2.18871974945068) - 0.01730580578312*std::sin(0.417519867420197*x_41 + 1.98311984539032) - 0.014979865927145*std::sin(0.271999955177307*x_43 - 1.33087992668152) + 0.0389610569641821*std::sin(0.397759854793549*x_43 + 8.20655918121338) + 0.019699363329662*std::sin(0.434879869222641*x_43 - 4.36527967453003) - 0.0118769144754582*std::sin(0.438959866762161*x_45 + 5.22911977767944) + 0.006744584844244*std::sin(0.594159841537476*x_46 + 2.18767976760864) + 0.00981898669808374*std::sin(0.153040036559105*x_49 + 1.74503993988037) + 0.0218858412921324*std::sin(0.412159860134125*x_51 + 1.99223983287811) + 0.0060550189120853*std::sin(0.232959985733032*x_53 + 5.03399991989136) - 0.0386148128516739*std::sin(0.250639975070953*x_53 + 5.05167961120605) - 0.0134859638911444*std::sin(0.423519849777222*x_53 + 5.22088003158569) + 0.00275964769002715*std::sin(0.30703991651535*x_55 + 5.13463973999023) - 0.011253715503441*std::sin(0.153440043330193*x_56 + 1.72919988632202) + 0.00381299467877539*std::sin(0.72655987739563*x_57 + 2.35935997962952) - 0.00784787920121906*std::sin(0.447759836912155*x_58 + 5.23080015182495) - 0.0203590669342565*std::sin(0.490319848060608*x_58 + 5.28128004074097) - 0.00736764866395182*std::sin(0.537279844284058*x_58 + 8.55719947814941) + 0.0624971600145375*std::sin(0.202960014343262*x_59 - 7.60008001327515) + 0.0550985235942163*std::sin(0.264799952507019*x_63 + 1.86583995819092) - 0.0025432440452243*std::sin(0.281759947538376*x_64 - 7.50191974639893) + 0.0144830765409329*std::sin(0.426319867372513*x_64 - 7.37799978256226) - 0.00758175937058955*std::sin(0.530159831047058*x_64 + 8.52952003479004) + 0.0216363779686528*std::sin(0.235039979219437*x_66 + 5.03575992584229) - 0.0604466083118584*std::sin(0.233679994940758*x_70 + 5.0449595451355) - 0.000445205127105974*std::sin(0.683279812335968*x_70 + 5.45639991760254) + 0.00278057395852228*std::sin(0.282959938049316*x_71 - 4.2960000038147) + 0.0463974056534211*std::sin(0.23463998734951*x_73 + 5.05839967727661) + 0.0631803199125383*std::sin(0.25095996260643*x_73 - 7.52400016784668) + 0.0457871883017826*std::sin(0.186240002512932*x_75 - 4.40799999237061) + 0.00476148491620284*std::sin(0.468879848718643*x_75 + 5.25735998153687) - 0.00118337270145338*std::sin(0.317759931087494*x_76 + 5.14647960662842) - 0.0417774199379006*std::sin(0.282799959182739*x_78 + 5.10743999481201) - 0.0100183584548115*std::sin(0.336639851331711*x_79 + 8.31711959838867) - 0.00163668004439244*std::sin(0.376399844884872*x_81 - 7.40743970870972) - 0.0475225081896901*std::sin(0.266319960355759*x_84 - 7.53360033035278) + 0.00225504477640259*std::sin(0.277999937534332*x_84 - 7.50880002975464) + 0.0360265875161275*std::sin(0.282879948616028*x_84 - 7.50984001159668) - 0.0545329100811969*std::sin(0.172720015048981*x_85 + 4.94823980331421) + 0.25216569665559*std::sin(0.125600054860115*x_86 + 4.900559425354) - 0.0229508812048734*std::sin(0.254159986972809*x_86 - 4.33599996566772) - 0.00288558671877035*std::sin(0.30895984172821*x_87 - 4.30751991271973) - 0.0155344031810281*std::sin(0.346319854259491*x_87 + 5.14383983612061) - 0.00201051417843859*std::sin(0.510159850120544*x_87 + 5.31903982162476) - 0.00459479534654861*std::sin(1.01335978507996*x_87 - 6.99656009674072) - 0.00202888029242504*std::sin(0.336639851331711*x_92 + 8.38432025909424) + 0.0298103389342823*std::sin(0.348559856414795*x_92 + 1.99535977840424) - 0.0057943504893077*std::sin(0.375519841909409*x_92 - 1.20735991001129) + 0.0208505222262494*std::sin(0.364159852266312*x_95 - 7.40639972686768) - 0.000968704507514933*std::sin(0.377039849758148*x_95 - 1.2163999080658) - 0.0126382527367283*std::sin(0.396079838275909*x_95 + 8.39648056030273) - 0.008205842681879*std::sin(0.428159862756729*x_95 - 1.16703987121582) + 0.00801710112630205*std::sin(0.407679855823517*x_96 + 5.20000028610229) - 0.0118377327549426*std::sin(0.400159865617752*x_97 + 5.19280004501343) + 0.0216692521107347*std::sin(0.439679861068726*x_98 + 2.02647995948792) + 0.00779178978048823*std::sin(0.441519856452942*x_98 + 1.99927973747253) - 0.123437996232699*std::sin(0.164400026202202*x_99 - 1.41487991809845) - 0.540766710829932);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00220852111265529*x_1 - 0.000809396564286654*x_10 - 0.00123272154868501*x_100 + 0.0635851904591298*x_101 + 0.000475918580057891*x_102 - 0.0366525118239732*x_103 + 0.0158928528469865*x_104 - 0.0248304458180124*x_105 + 0.0226253239976908*x_106 - 0.0336622541819432*x_107 - 0.0294774238316289*x_108 - 0.0185894657607975*x_11 + 0.0374571938209495*x_110 + 0.000453758997782087*x_111 - 0.00302490747978506*x_112 + 0.00648078173723518*x_113 - 0.0133666510868521*x_114 - 0.000582166181428797*x_115 + 0.0289350466664091*x_116 - 0.000648926538143887*x_117 - 0.0448036084025816*x_118 + 0.0101544754954836*x_119 - 0.139313476537274*x_12 + 0.00635309431686002*x_120 + 0.00207252704937375*x_13 - 0.0334310836372321*x_14 - 0.0111384664107284*x_15 - 0.0306114083542971*x_16 + 0.0103873287838622*x_17 + 0.0364295114114344*x_18 - 0.00979394716190747*x_19 - 0.0375428785907895*x_2 - 0.0113377688820149*x_20 - 0.068442272111481*x_21 + 0.0191145835815015*x_22 + 0.0107022249841257*x_23 - 0.00118196293069081*x_24 - 0.0237849512103652*x_25 - 0.000989113209695637*x_26 + 0.0231246134071446*x_27 + 0.000248473845653157*x_28 + 0.00383009814017017*x_29 - 0.0432056931177172*x_3 + 0.0252780841462864*x_30 + 0.017148475847349*x_31 - 0.0971866391960833*x_32 - 0.00663642273665723*x_33 - 0.00231579831320117*x_34 - 7.88710203119975e-5*x_35 - 0.00523831090666547*x_36 - 0.0440042388983273*x_37 - 0.0086407136566223*x_38 + 0.0118548908782598*x_39 - 0.0129201146652551*x_4 - 0.00700091743131377*x_40 - 0.010740570119026*x_41 + 0.0125293567725411*x_42 - 0.000233173549823428*x_43 - 0.0565629682467807*x_44 - 0.0199493934588601*x_45 - 0.0230543114940426*x_46 - 0.00254195643410008*x_47 + 0.0198256019342724*x_48 - 0.0159964803121994*x_49 + 0.0271701303590356*x_5 - 0.00158415097668014*x_50 - 0.0277202664195958*x_51 + 8.53439943710481e-5*x_52 - 0.00201472546170914*x_53 + 0.00590570868358154*x_54 - 0.0428961069453411*x_55 - 0.0297819312754084*x_56 - 0.0267603447906406*x_57 + 0.0107326228495285*x_58 - 0.000810297380820337*x_59 + 0.00226191870678259*x_6 - 0.0175260301496927*x_60 - 0.00518883472131097*x_61 - 0.00800480711253058*x_62 + 0.0350776759756933*x_63 - 0.00337702194809243*x_64 - 0.0131070581339541*x_65 - 0.00111686444446183*x_66 + 0.00118832848846819*x_67 - 0.00505634841166569*x_68 + 0.0248192496691499*x_69 - 0.0129679015907335*x_7 - 6.32451673336608e-6*x_70 + 0.0238554778329543*x_71 - 0.0149780809589482*x_72 - 0.0202177969677261*x_73 - 0.006695728655437*x_74 - 0.00187460051029696*x_75 - 0.0363609362561227*x_76 + 0.000772337880135923*x_77 + 0.0113720230214024*x_78 + 0.023326886074164*x_79 + 0.0370267458602203*x_8 + 0.0105274332101002*x_80 - 0.00155307264060485*x_81 + 0.0106142114840522*x_82 + 0.00426614631198217*x_83 + 0.0390850410111422*x_84 - 0.0311616805674413*x_85 - 0.0154867717231465*x_86 + 0.000575562849922311*x_87 + 0.00292418974815394*x_88 + 0.00827738339164368*x_89 + 0.0578687264598408*x_9 + 0.000804046017005004*x_90 + 0.00538128998727796*x_91 - 0.00866814155904021*x_92 + 0.00594970389185838*x_93 - 0.0294071426222754*x_94 - 4.81041250517284e-6*x_95 - 0.00295121361306465*x_96 - 0.0307061351427598*x_97 + 0.00524954909789307*x_98 - 0.000635461134835778*x_99 - 2.04074731917268e-5*std::pow(-5.44952011108398*x_114 - 6.8145604133606, 2) - 5.59275419766522e-6*std::pow(-7.48392009735107*x_15 - 9.32503986358643, 2) + 0.000194181525305501*std::pow(-4.71783971786499*x_15 - 6.56799983978271, 2) - 5.36607751509949e-6*std::pow(-7.35176038742065*x_23 - 9.59408092498779, 2) + 1.44533317288894e-5*std::pow(-4.51768016815186*x_24 - 6.28480005264282, 2) + 3.68818897277045e-6*std::pow(-9.80399990081787*x_40 - 9.97720050811768, 2) - 1.0974763451357e-5*std::pow(-6.20391988754272*x_50 - 5.59935998916626, 2) + 1.1248251046453e-5*std::pow(-7.59695959091187*x_56 - 6.57599973678589, 2) - 7.27141130510977e-6*std::pow(-5.34607982635498*x_59 - 6.13520002365112, 2) + 0.000696723979411933*std::pow(-5.23920011520386*x_59 - 6.44536018371582, 2) - 1.79859743770995e-6*std::pow(-5.6637601852417*x_67 - 8.90248012542725, 2) + 0.000145768918378374*std::pow(-5.33192014694214*x_7 - 7.97664022445679, 2) + 7.7483455122221e-5*std::pow(-7.07024002075195*x_70 - 9.68871974945068, 2) + 0.00151026166437266*std::pow(-3.4670398235321*x_70 - 4.69191980361938, 2) - 2.14357388010822e-5*std::pow(-5.50519990921021*x_77 - 7.96400022506714, 2) - 1.92702231808857e-5*std::pow(-7.53200006484985*x_81 - 9.99948024749756, 2) + 4.85870176634738e-6*std::pow(-7.6625599861145*x_84 - 7.4585599899292, 2) - 1.71066788342698e-5*std::pow(-8.54800033569336*x_88 - 8.59800052642822, 2) + 9.06428349562834e-6*std::pow(-5.06239986419678*x_90 - 7.8996000289917, 2) + 0.00250960234013899*std::exp(0.617359817028046*x_1) + 7.87003954111008e-5*std::exp(1.14975988864899*x_1) - 0.000109511653216753*std::exp(1.20047986507416*x_1) + 6.34741560480155e-6*std::exp(1.31991982460022*x_1) - 0.00247826362560841*std::exp(1.33495986461639*x_100) + 6.96423556407472e-5*std::exp(1.53511989116669*x_100) - 0.00622271711221812*std::exp(1.60943984985352*x_100) + 0.000368594630185599*std::exp(0.885279893875122*x_104) - 0.000355298437185516*std::exp(1.19487988948822*x_106) - 0.00849630412092162*std::exp(0.567839860916138*x_109) - 0.00245172473349351*std::exp(0.605279862880707*x_109) + 0.0238620439410007*std::exp(0.867999851703644*x_109) + 0.00023769491449153*std::exp(0.871279835700989*x_109) + 0.00132598883283001*std::exp(0.886719882488251*x_109) + 0.000468905543927711*std::exp(1.18495988845825*x_110) - 9.06745652696156e-6*std::exp(1.75111997127533*x_110) - 0.000289633408624128*std::exp(0.616399824619293*x_112) + 0.000535315231279951*std::exp(0.721439838409424*x_114) + 0.0510112739753364*std::exp(0.60511988401413*x_26) + 0.00214621706351445*std::exp(0.78143984079361*x_26) + 0.000226932881409919*std::exp(1.22703981399536*x_26) - 0.000268416254311481*std::exp(0.598719835281372*x_31) - 0.0122006759825421*std::exp(0.628879845142365*x_31) - 0.0102938998749443*std::exp(0.654159843921661*x_31) - 0.00154431808928067*std::exp(0.657919824123383*x_31) + 0.000529489507532595*std::exp(0.81335985660553*x_49) + 0.00726571664172165*std::exp(0.863999843597412*x_50) + 0.00037678349950557*std::exp(1.00015985965729*x_66) - 0.000855427839452198*std::exp(1.11055994033813*x_66) - 0.00132086964690804*std::exp(1.48999989032745*x_66) + 0.000546468706538084*std::exp(1.06511986255646*x_68) - 0.00316020703304257*std::exp(1.17007982730865*x_68) - 0.00740566738962475*std::exp(0.887999892234802*x_72) + 0.011391440461543*std::exp(0.634559869766235*x_74) + 0.00036849111044749*std::exp(1.08279979228973*x_74) - 0.000800472932447589*std::exp(1.17399990558624*x_74) + 0.00184558481480324*std::exp(0.905119836330414*x_77) - 0.00712513603181526*std::exp(0.957039833068848*x_81) - 0.0399874125449877*std::sin(0.528159856796265*x_10 - 4.05343961715698) + 0.00445255278376293*std::sin(0.329999834299088*x_100 - 7.44367980957031) + 0.00176037514278089*std::sin(0.344559848308563*x_102 - 7.43680000305176) - 0.200032109967209*std::sin(0.360319852828979*x_102 - 4.23464012145996) - 0.0545080748624728*std::sin(0.372879832983017*x_102 + 1.99031984806061) + 0.00176300863340237*std::sin(0.394319832324982*x_102 - 7.41599988937378) - 0.00667418246912238*std::sin(0.302079916000366*x_105 + 1.87591981887817) - 0.0314611955993037*std::sin(0.202159985899925*x_108 + 4.98984003067017) + 0.006984451320364*std::sin(0.260319977998734*x_111 + 5.06303977966309) - 0.332386005372394*std::sin(0.310319930315018*x_111 - 7.49119997024536) - 0.0411473721453281*std::sin(0.407119870185852*x_111 + 1.97735977172852) + 0.0186683970739109*std::sin(0.495199859142303*x_112 - 7.34656000137329) - 0.0623979821320415*std::sin(0.157280027866364*x_114 - 7.63944053649902) + 0.332366120671434*std::sin(0.154240027070045*x_115 - 7.65759992599487) + 0.00106904705693004*std::sin(0.424319863319397*x_115 - 4.16856002807617) + 0.00832607312410211*std::sin(0.433519870042801*x_115 - 4.18584012985229) - 0.217746433454533*std::sin(0.438559859991074*x_115 - 7.3557596206665) - 0.12515315501862*std::sin(0.416879862546921*x_117 + 5.20480012893677) + 0.0100354215401188*std::sin(0.526559829711914*x_118 - 4.02767992019653) + 0.0071990819257798*std::sin(0.26623997092247*x_120 + 5.06559944152832) - 0.0186352888295212*std::sin(0.598879814147949*x_120 - 4.00255966186523) + 0.0134420101221747*std::sin(0.452239871025085*x_2 - 4.13647985458374) - 0.183920963649368*std::sin(0.315839856863022*x_24 + 5.1191201210022) + 0.0128044682795965*std::sin(0.384239852428436*x_24 + 5.1701602935791) + 0.00331914724124821*std::sin(0.278319954872131*x_28 - 4.29287958145142) + 0.275192591744315*std::sin(0.343279838562012*x_28 - 4.25920009613037) + 0.0244282913352314*std::sin(0.348079830408096*x_28 + 8.34904003143311) + 0.00490937989173914*std::sin(0.367599844932556*x_28 + 5.1799201965332) + 0.0190611354799952*std::sin(0.281519949436188*x_3 + 1.88359987735748) - 0.0354336899242143*std::sin(0.309279918670654*x_35 - 1.13063991069794) - 0.0150872320690292*std::sin(0.321199834346771*x_35 + 1.9799998998642) - 0.101256920206125*std::sin(0.32287985086441*x_35 + 1.98631989955902) + 0.00718921256670564*std::sin(0.287839949131012*x_36 - 7.49151992797852) - 0.00775262494021065*std::sin(0.403199851512909*x_36 + 5.21271991729736) - 0.0106487303761512*std::sin(0.410559862852097*x_36 + 5.20024013519287) - 0.00643897484334958*std::sin(0.614959836006165*x_38 + 2.18871974945068) - 0.00723336953952016*std::sin(0.417519867420197*x_41 + 1.98311984539032) - 0.00626503396777195*std::sin(0.271999955177307*x_43 - 1.33087992668152) + 0.0162846923283463*std::sin(0.397759854793549*x_43 + 8.20655918121338) + 0.14626386284966*std::sin(0.434879869222641*x_43 - 4.36527967453003) + 0.0259374369046072*std::sin(0.438959866762161*x_45 + 5.22911977767944) - 0.0147291827525432*std::sin(0.594159841537476*x_46 + 2.18767976760864) - 0.0393306673398451*std::sin(0.153040036559105*x_49 + 1.74503993988037) + 0.00914770336228415*std::sin(0.412159860134125*x_51 + 1.99223983287811) - 0.0242538198584355*std::sin(0.232959985733032*x_53 + 5.03399991989136) - 0.0161399714382564*std::sin(0.250639975070953*x_53 + 5.05167961120605) + 0.029451364514509*std::sin(0.423519849777222*x_53 + 5.22088003158569) - 0.0110539700896847*std::sin(0.30703991651535*x_55 + 5.13463973999023) + 0.0450775782076858*std::sin(0.153440043330193*x_56 + 1.72919988632202) + 0.00159470994584625*std::sin(0.72655987739563*x_57 + 2.35935997962952) - 0.00328222094975579*std::sin(0.447759836912155*x_58 + 5.23080015182495) - 0.0085095520232259*std::sin(0.490319848060608*x_58 + 5.28128004074097) - 0.0547033290200867*std::sin(0.537279844284058*x_58 + 8.55719947814941) - 0.13648461879083*std::sin(0.202960014343262*x_59 - 7.60008001327515) - 0.120327083453791*std::sin(0.264799952507019*x_63 + 1.86583995819092) + 0.0101871495076249*std::sin(0.281759947538376*x_64 - 7.50191974639893) - 0.0316289121001313*std::sin(0.426319867372513*x_64 - 7.37799978256226) - 0.00316897508122311*std::sin(0.530159831047058*x_64 + 8.52952003479004) + 0.00904343428473303*std::sin(0.235039979219437*x_66 + 5.03575992584229) - 0.0252650850708597*std::sin(0.233679994940758*x_70 + 5.0449595451355) + 0.00178330160642908*std::sin(0.683279812335968*x_70 + 5.45639991760254) - 0.0111377917843416*std::sin(0.282959938049316*x_71 - 4.2960000038147) - 0.101325119765725*std::sin(0.23463998734951*x_73 + 5.05839967727661) + 0.0264077042860527*std::sin(0.25095996260643*x_73 - 7.52400016784668) + 0.0191378348580241*std::sin(0.186240002512932*x_75 - 4.40799999237061) + 0.00199139731170678*std::sin(0.468879848718643*x_75 + 5.25735998153687) + 0.00474008566169054*std::sin(0.317759931087494*x_76 + 5.14647960662842) - 0.017461857633541*std::sin(0.282799959182739*x_78 + 5.10743999481201) - 0.00418998116044363*std::sin(0.336639851331711*x_79 + 8.31711959838867) + 0.00655584128455177*std::sin(0.376399844884872*x_81 - 7.40743970870972) - 0.0198631527181584*std::sin(0.266319960355759*x_84 - 7.53360033035278) - 0.00903274631734198*std::sin(0.277999937534332*x_84 - 7.50880002975464) - 0.0786767760699749*std::sin(0.282879948616028*x_84 - 7.50984001159668) + 0.119091866610507*std::sin(0.172720015048981*x_85 + 4.94823980331421) + 0.105398598132862*std::sin(0.125600054860115*x_86 + 4.900559425354) + 0.0501213538572336*std::sin(0.254159986972809*x_86 - 4.33599996566772) + 0.0115584280543308*std::sin(0.30895984172821*x_87 - 4.30751991271973) + 0.0339248550784147*std::sin(0.346319854259491*x_87 + 5.14383983612061) - 0.000840857967745878*std::sin(0.510159850120544*x_87 + 5.31903982162476) - 0.0341154434863339*std::sin(1.01335978507996*x_87 - 6.99656009674072) + 0.00812682798208802*std::sin(0.336639851331711*x_92 + 8.38432025909424) + 0.012459933984717*std::sin(0.348559856414795*x_92 + 1.99535977840424) - 0.00242337300034884*std::sin(0.375519841909409*x_92 - 1.20735991001129) - 0.0455344783183337*std::sin(0.364159852266312*x_95 - 7.40639972686768) + 0.00388021655463835*std::sin(0.377039849758148*x_95 - 1.2163999080658) - 0.00528245569864049*std::sin(0.396079838275909*x_95 + 8.39648056030273) - 0.0609267532408537*std::sin(0.428159862756729*x_95 - 1.16703987121582) - 0.0175081714237311*std::sin(0.407679855823517*x_96 + 5.20000028610229) + 0.0258518697814468*std::sin(0.400159865617752*x_97 + 5.19280004501343) + 0.00905717480747741*std::sin(0.439679861068726*x_98 + 2.02647995948792) + 0.00325876265394591*std::sin(0.441519856452942*x_98 + 1.99927973747253) - 0.0515938207766039*std::sin(0.164400026202202*x_99 - 1.41487991809845) - 0.590417871560022);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00395574255241072*x_1 - 0.00120627603315898*x_10 + 6.89044320045651e-5*x_100 + 0.026816290935955*x_101 - 0.000749544173354618*x_102 - 0.0149039660070296*x_103 + 0.0037323929632126*x_104 - 0.00600353031896068*x_105 + 0.0166747216859358*x_106 - 0.0220293608557805*x_107 - 0.00894801474176715*x_108 - 0.000776107472971556*x_11 + 0.0299624519170679*x_110 + 0.000918274354369226*x_111 + 0.000503080700172353*x_112 - 0.0166007956166271*x_113 - 0.0161052877380282*x_114 + 0.000916877986064302*x_115 - 0.0173922966145013*x_116 + 0.00226824913109445*x_117 - 0.0306836007001887*x_118 + 0.000778873409515171*x_119 - 0.105859390284261*x_12 + 0.00444907062528723*x_120 + 0.00165023284276983*x_13 - 0.0166080301824728*x_14 - 0.0090788820259229*x_15 - 0.0152828501626866*x_16 - 0.00201963055373174*x_17 + 0.0175534845991969*x_18 + 0.00387602672867968*x_19 - 0.0113470211666273*x_2 + 0.00164753874161741*x_20 - 0.0518865293546714*x_21 - 0.00380616460753643*x_22 + 0.0198948018719624*x_23 + 0.00139927503506063*x_24 - 0.0388543981132324*x_25 + 0.00165955100283991*x_26 + 0.0153947422863467*x_27 - 1.38887400978626e-5*x_28 + 0.0148312716538557*x_29 - 0.0386177683000326*x_3 + 0.006036178048109*x_30 - 0.000958534382128756*x_31 - 0.0772699594534247*x_32 + 0.0177422793347535*x_33 - 0.00236514734076911*x_34 + 8.11277894659697e-5*x_35 - 0.00230626388696323*x_36 - 0.0406101449623558*x_37 - 0.00599927654146068*x_38 - 0.000165998623305633*x_39 - 0.0292907840402145*x_4 + 0.008184236667738*x_40 - 0.0269059546295286*x_41 + 0.00963508548076734*x_42 + 0.000108673905135895*x_43 - 0.041487493516553*x_44 - 0.011653595134615*x_45 - 0.0181973237591001*x_46 - 0.00735532900092053*x_47 + 0.0277511897034754*x_48 - 0.014229259763809*x_49 + 0.00814355496397402*x_5 - 0.00194607863851458*x_50 - 0.0235032101539225*x_51 + 0.00140369934271538*x_52 - 0.00311694323857425*x_53 - 0.0198051455604359*x_54 - 0.0238497345665069*x_55 - 0.0224321815996523*x_56 - 0.0368908044010574*x_57 - 0.0131153381763867*x_58 - 0.000387019822263401*x_59 + 0.000341106771180711*x_6 - 0.0172061266965114*x_60 - 0.00852900039037702*x_61 + 0.00956212345655087*x_62 + 0.0253263759745074*x_63 - 0.00220016899301714*x_64 - 0.00538902018794095*x_65 + 0.00138499482531745*x_66 + 0.00828690823200368*x_67 - 0.0061629865594547*x_68 + 0.00666654152352377*x_69 - 0.00885201189382533*x_7 + 1.13280148522242e-5*x_70 + 0.0240541119214675*x_71 - 0.0128074262886623*x_72 - 0.0118880578881426*x_73 - 0.00515989317570844*x_74 + 0.000722111966642769*x_75 - 0.0348441707993312*x_76 - 0.000360171185716864*x_77 - 0.00964548955268824*x_78 + 0.0175719255062672*x_79 + 0.0279704388108022*x_8 + 0.0192639645331095*x_80 - 0.00124959958600383*x_81 + 0.00503702103897832*x_82 - 0.00251483456643347*x_83 + 0.0302229595376443*x_84 - 0.0239096463822933*x_85 - 0.011588014763456*x_86 - 3.21717676624792e-5*x_87 + 0.0108771614321745*x_88 + 0.0102423009544842*x_89 + 0.0534643939767523*x_9 + 0.0201912942267927*x_90 - 0.00291057678154368*x_91 - 0.00522481400966118*x_92 - 0.0343813233164282*x_93 - 0.0129623508492003*x_94 + 8.6160613689958e-6*x_95 - 0.00273285103204432*x_96 - 0.0195060212610418*x_97 + 0.010285413396111*x_98 - 0.00469297045166229*x_99 + 3.21405872027286e-5*std::pow(-5.44952011108398*x_114 - 6.8145604133606, 2) + 8.80826363483146e-6*std::pow(-7.48392009735107*x_15 - 9.32503986358643, 2) - 0.000240799507096816*std::pow(-4.71783971786499*x_15 - 6.56799983978271, 2) + 8.45126100082664e-6*std::pow(-7.35176038742065*x_23 - 9.59408092498779, 2) - 2.27631595758096e-5*std::pow(-4.51768016815186*x_24 - 6.28480005264282, 2) - 5.80868381821649e-6*std::pow(-9.80399990081787*x_40 - 9.97720050811768, 2) + 1.72846162003367e-5*std::pow(-6.20391988754272*x_50 - 5.59935998916626, 2) - 6.28734323844161e-7*std::pow(-7.59695959091187*x_56 - 6.57599973678589, 2) + 1.30240236105873e-5*std::pow(-5.34607982635498*x_59 - 6.13520002365112, 2) + 0.000538749866801228*std::pow(-5.23920011520386*x_59 - 6.44536018371582, 2) + 3.22151704968402e-6*std::pow(-5.6637601852417*x_67 - 8.90248012542725, 2) - 0.000180764280434634*std::pow(-5.33192014694214*x_7 - 7.97664022445679, 2) - 9.60852365961951e-5*std::pow(-7.07024002075195*x_70 - 9.68871974945068, 2) + 0.0011678272810454*std::pow(-3.4670398235321*x_70 - 4.69191980361938, 2) + 1.19817602625863e-6*std::pow(-5.50519990921021*x_77 - 7.96400022506714, 2) + 1.07713196406484e-6*std::pow(-7.53200006484985*x_81 - 9.99948024749756, 2) - 8.70255358505751e-6*std::pow(-7.6625599861145*x_84 - 7.4585599899292, 2) + 9.56198088544219e-7*std::pow(-8.54800033569336*x_88 - 8.59800052642822, 2) - 1.62352860134816e-5*std::pow(-5.06239986419678*x_90 - 7.8996000289917, 2) - 0.00311209321053451*std::exp(0.617359817028046*x_1) - 4.39905187844027e-6*std::exp(1.14975988864899*x_1) - 8.46811511116727e-5*std::exp(1.20047986507416*x_1) - 9.99681160138873e-6*std::exp(1.31991982460022*x_1) + 0.00307323087798182*std::exp(1.33495986461639*x_100) - 0.000124738327417214*std::exp(1.53511989116669*x_100) - 0.00481178790226065*std::exp(1.60943984985352*x_100) - 2.06030337183318e-5*std::exp(0.885279893875122*x_104) + 0.000440596438883353*std::exp(1.19487988948822*x_106) + 0.0105360478616274*std::exp(0.567839860916138*x_109) + 0.0038613243223997*std::exp(0.605279862880707*x_109) + 0.0184516011716289*std::exp(0.867999851703644*x_109) - 0.000425741860631481*std::exp(0.871279835700989*x_109) - 7.41177173936908e-5*std::exp(0.886719882488251*x_109) - 0.000738499048013509*std::exp(1.18495988845825*x_110) + 1.62409693166626e-5*std::exp(1.75111997127533*x_110) + 0.000518770317625236*std::exp(0.616399824619293*x_112) - 0.0009588177478556*std::exp(0.721439838409424*x_114) + 0.0394450569690019*std::exp(0.60511988401413*x_26) - 0.000119965346495096*std::exp(0.78143984079361*x_26) - 0.000281413620073262*std::exp(1.22703981399536*x_26) + 0.000480767692395771*std::exp(0.598719835281372*x_31) - 0.00943431366612*std::exp(0.628879845142365*x_31) + 0.0127652000471764*std::exp(0.654159843921661*x_31) + 0.00243221146248516*std::exp(0.657919824123383*x_31) - 2.95964435827616e-5*std::exp(0.81335985660553*x_49) - 0.00901002803062308*std::exp(0.863999843597412*x_50) - 0.000674867228345597*std::exp(1.00015985965729*x_66) + 0.00134724925576289*std::exp(1.11055994033813*x_66) - 0.00102137771536747*std::exp(1.48999989032745*x_66) - 0.000978795042359619*std::exp(1.06511986255646*x_68) + 0.00391889132956041*std::exp(1.17007982730865*x_68) + 0.00918357734773693*std::exp(0.887999892234802*x_72) - 0.014126231854172*std::exp(0.634559869766235*x_74) - 0.000660014503565096*std::exp(1.08279979228973*x_74) + 4.47433832921692e-5*std::exp(1.17399990558624*x_74) - 0.00228866218354605*std::exp(0.905119836330414*x_77) + 0.00883569763786521*std::exp(0.957039833068848*x_81) - 0.0309207287518959*std::sin(0.528159856796265*x_10 - 4.05343961715698) - 0.00701251250837364*std::sin(0.329999834299088*x_100 - 7.44367980957031) - 0.00315305605212539*std::sin(0.344559848308563*x_102 - 7.43680000305176) - 0.15467714013771*std::sin(0.360319852828979*x_102 - 4.23464012145996) + 0.0675940594195548*std::sin(0.372879832983017*x_102 + 1.99031984806061) - 9.854545710937e-5*std::sin(0.394319832324982*x_102 - 7.41599988937378) + 0.0105114504691699*std::sin(0.302079916000366*x_105 + 1.87591981887817) + 0.00175856081632307*std::sin(0.202159985899925*x_108 + 4.98984003067017) - 0.0110001059227841*std::sin(0.260319977998734*x_111 + 5.06303977966309) - 0.257021318933382*std::sin(0.310319930315018*x_111 - 7.49119997024536) + 0.0510257961736362*std::sin(0.407119870185852*x_111 + 1.97735977172852) - 0.0231501982828335*std::sin(0.495199859142303*x_112 - 7.34656000137329) + 0.00348780916633263*std::sin(0.157280027866364*x_114 - 7.63944053649902) - 0.412158663948321*std::sin(0.154240027070045*x_115 - 7.65759992599487) - 0.00191479941459254*std::sin(0.424319863319397*x_115 - 4.16856002807617) - 0.000465395725463485*std::sin(0.433519870042801*x_115 - 4.18584012985229) - 0.168374945439782*std::sin(0.438559859991074*x_115 - 7.3557596206665) - 0.0967761230967615*std::sin(0.416879862546921*x_117 + 5.20480012893677) - 0.0124446677229851*std::sin(0.526559829711914*x_118 - 4.02767992019653) - 0.0128944724815691*std::sin(0.26623997092247*x_120 + 5.06559944152832) + 0.0231091416018885*std::sin(0.598879814147949*x_120 - 4.00255966186523) - 0.000751357087459117*std::sin(0.452239871025085*x_2 - 4.13647985458374) - 0.142219010104525*std::sin(0.315839856863022*x_24 + 5.1191201210022) - 0.000715720930543669*std::sin(0.384239852428436*x_24 + 5.1701602935791) - 0.0059450153791541*std::sin(0.278319954872131*x_28 - 4.29287958145142) + 0.212795851051477*std::sin(0.343279838562012*x_28 - 4.25920009613037) - 0.0302928947719751*std::sin(0.348079830408096*x_28 + 8.34904003143311) - 0.00773198871998186*std::sin(0.367599844932556*x_28 + 5.1799201965332) - 0.00106544475920956*std::sin(0.281519949436188*x_3 + 1.88359987735748) + 0.043940406045057*std::sin(0.309279918670654*x_35 - 1.13063991069794) + 0.000843318718121274*std::sin(0.321199834346771*x_35 + 1.9799998998642) - 0.0782980834387194*std::sin(0.32287985086441*x_35 + 1.98631989955902) - 0.0128767952026738*std::sin(0.287839949131012*x_36 - 7.49151992797852) + 0.012209934841022*std::sin(0.403199851512909*x_36 + 5.21271991729736) + 0.000595223405416389*std::sin(0.410559862852097*x_36 + 5.20024013519287) + 0.000359914130442491*std::sin(0.614959836006165*x_38 + 2.18871974945068) + 0.000404317763513937*std::sin(0.417519867420197*x_41 + 1.98311984539032) + 0.0112214736443329*std::sin(0.271999955177307*x_43 - 1.33087992668152) - 0.000910252178564391*std::sin(0.397759854793549*x_43 + 8.20655918121338) + 0.113100221833326*std::sin(0.434879869222641*x_43 - 4.36527967453003) - 0.0321643473144932*std::sin(0.438959866762161*x_45 + 5.22911977767944) + 0.0182652800835263*std::sin(0.594159841537476*x_46 + 2.18767976760864) + 0.0619435209592861*std::sin(0.153040036559105*x_49 + 1.74503993988037) - 0.00051132172143565*std::sin(0.412159860134125*x_51 + 1.99223983287811) + 0.0381983602200853*std::sin(0.232959985733032*x_53 + 5.03399991989136) + 0.000902162832887363*std::sin(0.250639975070953*x_53 + 5.05167961120605) - 0.0365218784189946*std::sin(0.423519849777222*x_53 + 5.22088003158569) + 0.0174093620638882*std::sin(0.30703991651535*x_55 + 5.13463973999023) - 0.0709945724127813*std::sin(0.153440043330193*x_56 + 1.72919988632202) - 0.0028563285881167*std::sin(0.72655987739563*x_57 + 2.35935997962952) + 0.00587887568878742*std::sin(0.447759836912155*x_58 + 5.23080015182495) + 0.000475651495992064*std::sin(0.490319848060608*x_58 + 5.28128004074097) - 0.0422999811891514*std::sin(0.537279844284058*x_58 + 8.55719947814941) + 0.169251059694904*std::sin(0.202960014343262*x_59 - 7.60008001327515) + 0.149214516368049*std::sin(0.264799952507019*x_63 + 1.86583995819092) - 0.0160441698989852*std::sin(0.281759947538376*x_64 - 7.50191974639893) + 0.039222199082728*std::sin(0.426319867372513*x_64 - 7.37799978256226) + 0.000177133618083685*std::sin(0.530159831047058*x_64 + 8.52952003479004) - 0.000505493477764593*std::sin(0.235039979219437*x_66 + 5.03575992584229) + 0.0014122218746088*std::sin(0.233679994940758*x_70 + 5.0449595451355) - 0.00280859664749852*std::sin(0.683279812335968*x_70 + 5.45639991760254) + 0.0175413763736113*std::sin(0.282959938049316*x_71 - 4.2960000038147) + 0.125650670720225*std::sin(0.23463998734951*x_73 + 5.05839967727661) - 0.00147608992989214*std::sin(0.25095996260643*x_73 - 7.52400016784668) - 0.00106973196184978*std::sin(0.186240002512932*x_75 - 4.40799999237061) - 0.00356684617572155*std::sin(0.468879848718643*x_75 + 5.25735998153687) - 0.00746536012208166*std::sin(0.317759931087494*x_76 + 5.14647960662842) + 0.000976051228492942*std::sin(0.282799959182739*x_78 + 5.10743999481201) + 0.00750478982301362*std::sin(0.336639851331711*x_79 + 8.31711959838867) - 0.0103250699640172*std::sin(0.376399844884872*x_81 - 7.40743970870972) + 0.00111027446330004*std::sin(0.266319960355759*x_84 - 7.53360033035278) + 0.0142260517980418*std::sin(0.277999937534332*x_84 - 7.50880002975464) + 0.0975650431616001*std::sin(0.282879948616028*x_84 - 7.50984001159668) - 0.147682755781904*std::sin(0.172720015048981*x_85 + 4.94823980331421) - 0.00589137956269962*std::sin(0.125600054860115*x_86 + 4.900559425354) - 0.0621541997100846*std::sin(0.254159986972809*x_86 - 4.33599996566772) - 0.0182038541134669*std::sin(0.30895984172821*x_87 - 4.30751991271973) - 0.042069338822841*std::sin(0.346319854259491*x_87 + 5.14383983612061) + 0.00150608369758661*std::sin(0.510159850120544*x_87 + 5.31903982162476) - 0.0263801608344822*std::sin(1.01335978507996*x_87 - 6.99656009674072) - 0.0127992829384563*std::sin(0.336639851331711*x_92 + 8.38432025909424) - 0.000696462777783959*std::sin(0.348559856414795*x_92 + 1.99535977840424) + 0.00434056964314807*std::sin(0.375519841909409*x_92 - 1.20735991001129) + 0.0564661335197309*std::sin(0.364159852266312*x_95 - 7.40639972686768) - 0.00611111612732062*std::sin(0.377039849758148*x_95 - 1.2163999080658) + 0.000295269122124439*std::sin(0.396079838275909*x_95 + 8.39648056030273) - 0.0471123158712672*std::sin(0.428159862756729*x_95 - 1.16703987121582) + 0.0217114323433609*std::sin(0.407679855823517*x_96 + 5.20000028610229) - 0.0320582377294113*std::sin(0.400159865617752*x_97 + 5.19280004501343) - 0.000506261520568872*std::sin(0.439679861068726*x_98 + 2.02647995948792) - 0.00583685889374279*std::sin(0.441519856452942*x_98 + 1.99927973747253) + 0.0028838977621098*std::sin(0.164400026202202*x_99 - 1.41487991809845) - 0.898980316634084);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0204204841986306*x_1 + 9.47693817331102e-5*x_10 + 0.00485776369084294*x_100 + 0.0719229193383825*x_101 - 0.000380448219513955*x_102 - 0.0326339435560492*x_103 + 0.012658258112484*x_104 - 0.0184767865071546*x_105 + 0.0262192741180864*x_106 - 0.0503368007115933*x_107 - 0.0288687785995344*x_108 - 0.0130869774221559*x_11 + 0.055465144122703*x_110 + 0.00109709281323083*x_111 + 0.00116450492554296*x_112 - 0.0290525546651482*x_113 - 0.0283012262415976*x_114 + 0.000465382307954613*x_115 - 0.0123203516826471*x_116 + 0.00351391106687647*x_117 - 0.0575743117219395*x_118 + 0.00533200603820234*x_119 - 0.224102337635697*x_12 + 0.0212067527822122*x_120 - 0.00716230278128245*x_13 - 0.0410741473723058*x_14 - 0.0204040339865052*x_15 - 0.041364194165852*x_16 + 0.0063181256493579*x_17 + 0.0335014045023996*x_18 + 0.00951420012299515*x_19 - 0.0318924888316249*x_2 - 0.0102396488537671*x_20 - 0.0940100505698196*x_21 + 0.00315689966232297*x_22 + 0.0303610255997362*x_23 + 0.000402924511909145*x_24 - 0.055472501775564*x_25 + 0.00476648424931364*x_26 + 0.0406383094280063*x_27 - 0.000979156425735888*x_28 + 0.0211763483368109*x_29 - 0.0734693188030485*x_3 + 0.0368216658610795*x_30 - 0.0675766911135868*x_31 - 0.182062883263713*x_32 + 0.0128860996935855*x_33 + 0.000249992591571836*x_34 - 0.00162055044548489*x_35 - 0.00571357608334645*x_36 - 0.0743123412851119*x_37 - 0.0160355509783302*x_38 - 0.00268210043297312*x_39 - 0.0349169525152975*x_4 + 0.00253448633316603*x_40 - 0.0474910245726591*x_41 + 0.0379143667949418*x_42 + 0.000468917370534914*x_43 - 0.0862185325785815*x_44 - 0.0232849209264923*x_45 - 0.0374242542927227*x_46 - 0.0168188863824453*x_47 + 0.0490551923692826*x_48 - 0.0276929875695807*x_49 + 0.0156485957038609*x_5 - 0.00807779687182612*x_50 - 0.0462248542816278*x_51 + 0.000993113335361208*x_52 - 0.00965445921636791*x_53 - 0.0277037380135086*x_54 - 0.0442245421490737*x_55 - 0.044718778694161*x_56 - 0.055091483006976*x_57 - 0.01271854042205*x_58 + 0.00408711714546932*x_59 + 0.00695247120730002*x_6 - 0.0355813403955412*x_60 - 0.0045857221215508*x_61 + 0.00365531617762842*x_62 + 0.0399516870004847*x_63 - 0.00346417832252122*x_64 - 0.0134503581557059*x_65 + 0.00130147552407654*x_66 + 0.00486591330979428*x_67 - 0.0108343344520577*x_68 + 0.0202899300338217*x_69 - 0.0277307195114692*x_7 + 5.84779078079091e-5*x_70 + 0.0460483101772333*x_71 - 0.0280235712466039*x_72 - 0.0239532377168994*x_73 - 0.0102791442067721*x_74 - 0.00139995682228756*x_75 - 0.056358582381224*x_76 - 0.000454512919196628*x_77 - 0.00662696201052368*x_78 + 0.0495679968667318*x_79 + 0.0413038449267599*x_8 + 0.022513142879638*x_80 - 0.00259298578130361*x_81 - 0.000196868068490801*x_82 - 0.00163889846381833*x_83 + 0.0601051297231038*x_84 - 0.0487869350788343*x_85 - 0.0233028184847758*x_86 - 0.00226811019660785*x_87 + 0.0132767460432873*x_88 + 0.0226958907569774*x_89 + 0.112070345162708*x_9 + 0.0270302994426989*x_90 - 0.014579006296086*x_91 - 0.0113456427765784*x_92 - 0.0152622004647714*x_93 - 0.0398315897857497*x_94 + 4.44781587044348e-5*x_95 - 0.00466566704869023*x_96 - 0.0375762378064996*x_97 + 0.0150023612870978*x_98 - 0.00865523731123432*x_99 + 1.63136871849526e-5*std::pow(-5.44952011108398*x_114 - 6.8145604133606, 2) + 4.47083485671458e-6*std::pow(-7.48392009735107*x_15 - 9.32503986358643, 2) - 0.000226278581672222*std::pow(-4.71783971786499*x_15 - 6.56799983978271, 2) + 4.28963003744282e-6*std::pow(-7.35176038742065*x_23 - 9.59408092498779, 2) - 1.15539601787172e-5*std::pow(-4.51768016815186*x_24 - 6.28480005264282, 2) - 2.94832979151778e-6*std::pow(-9.80399990081787*x_40 - 9.97720050811768, 2) + 8.77320068938621e-6*std::pow(-6.20391988754272*x_50 - 5.59935998916626, 2) - 4.43257810956848e-5*std::pow(-7.59695959091187*x_56 - 6.57599973678589, 2) + 6.72331085299043e-5*std::pow(-5.34607982635498*x_59 - 6.13520002365112, 2) + 0.00107142487459111*std::pow(-5.23920011520386*x_59 - 6.44536018371582, 2) + 1.66302374679568e-5*std::pow(-5.6637601852417*x_67 - 8.90248012542725, 2) - 0.000169863657475442*std::pow(-5.33192014694214*x_7 - 7.97664022445679, 2) - 9.0291011467417e-5*std::pow(-7.07024002075195*x_70 - 9.68871974945068, 2) + 0.00232248632480829*std::pow(-3.4670398235321*x_70 - 4.69191980361938, 2) + 8.44714313182644e-5*std::pow(-5.50519990921021*x_77 - 7.96400022506714, 2) + 7.59378227649252e-5*std::pow(-7.53200006484985*x_81 - 9.99948024749756, 2) - 4.49246521018164e-5*std::pow(-7.6625599861145*x_84 - 7.4585599899292, 2) + 6.74119823740189e-5*std::pow(-8.54800033569336*x_88 - 8.59800052642822, 2) - 8.38104090713653e-5*std::pow(-5.06239986419678*x_90 - 7.8996000289917, 2) - 0.00292442474738277*std::exp(0.617359817028046*x_1) - 0.000310133236245323*std::exp(1.14975988864899*x_1) - 0.0001684074508431*std::exp(1.20047986507416*x_1) - 5.07410945180601e-6*std::exp(1.31991982460022*x_1) + 0.00288790592889964*std::exp(1.33495986461639*x_100) - 0.000643928923644055*std::exp(1.53511989116669*x_100) - 0.00956931883871952*std::exp(1.60943984985352*x_100) - 0.0014525142462751*std::exp(0.885279893875122*x_104) + 0.000414027165098278*std::exp(1.19487988948822*x_106) + 0.00990069288472904*std::exp(0.567839860916138*x_109) + 0.00195990311931606*std::exp(0.605279862880707*x_109) + 0.0366951449820248*std::exp(0.867999851703644*x_109) - 0.00219778077631026*std::exp(0.871279835700989*x_109) - 0.00522530040417974*std::exp(0.886719882488251*x_109) - 0.00037484201454337*std::exp(1.18495988845825*x_110) + 8.3839747634547e-5*std::exp(1.75111997127533*x_110) + 0.00267801580447362*std::exp(0.616399824619293*x_112) - 0.00494964533460845*std::exp(0.721439838409424*x_114) + 0.0784453376613914*std::exp(0.60511988401413*x_26) - 0.00845755907725443*std::exp(0.78143984079361*x_26) - 0.000264443543016976*std::exp(1.22703981399536*x_26) + 0.00248183721152351*std::exp(0.598719835281372*x_31) - 0.018762247490829*std::exp(0.628879845142365*x_31) + 0.0119954205731655*std::exp(0.654159843921661*x_31) + 0.00123452433262546*std::exp(0.657919824123383*x_31) - 0.00208654980284716*std::exp(0.81335985660553*x_49) - 0.00846669658163647*std::exp(0.863999843597412*x_50) - 0.00348382519590572*std::exp(1.00015985965729*x_66) + 0.000683827049582032*std::exp(1.11055994033813*x_66) - 0.00203123853578882*std::exp(1.48999989032745*x_66) - 0.00505277288179983*std::exp(1.06511986255646*x_68) + 0.00368257054373442*std::exp(1.17007982730865*x_68) + 0.00862978035950699*std::exp(0.887999892234802*x_72) - 0.0132743781200924*std::exp(0.634559869766235*x_74) - 0.00340715189685546*std::exp(1.08279979228973*x_74) + 0.00315440932373941*std::exp(1.17399990558624*x_74) - 0.00215064905681653*std::exp(0.905119836330414*x_77) + 0.00830287882930299*std::exp(0.957039833068848*x_81) - 0.061492800215371*std::sin(0.528159856796265*x_10 - 4.05343961715698) - 0.00355936046596133*std::sin(0.329999834299088*x_100 - 7.44367980957031) - 0.0162768255104428*std::sin(0.344559848308563*x_102 - 7.43680000305176) - 0.307610165099681*std::sin(0.360319852828979*x_102 - 4.23464012145996) + 0.0635179368900255*std::sin(0.372879832983017*x_102 + 1.99031984806061) - 0.0069474564917929*std::sin(0.394319832324982*x_102 - 7.41599988937378) + 0.00533532613242373*std::sin(0.302079916000366*x_105 + 1.87591981887817) + 0.1239785690579*std::sin(0.202159985899925*x_108 + 4.98984003067017) - 0.00558335433928877*std::sin(0.260319977998734*x_111 + 5.06303977966309) - 0.51114450578053*std::sin(0.310319930315018*x_111 - 7.49119997024536) + 0.0479487891236593*std::sin(0.407119870185852*x_111 + 1.97735977172852) - 0.0217541725729702*std::sin(0.495199859142303*x_112 - 7.34656000137329) + 0.245890608715522*std::sin(0.157280027866364*x_114 - 7.63944053649902) - 0.387304272448726*std::sin(0.154240027070045*x_115 - 7.65759992599487) - 0.0098846501437271*std::sin(0.424319863319397*x_115 - 4.16856002807617) - 0.0328104069834034*std::sin(0.433519870042801*x_115 - 4.18584012985229) - 0.334851321399328*std::sin(0.438559859991074*x_115 - 7.3557596206665) - 0.192461013805906*std::sin(0.416879862546921*x_117 + 5.20480012893677) - 0.0116942173000669*std::sin(0.526559829711914*x_118 - 4.02767992019653) - 0.0665643347793429*std::sin(0.26623997092247*x_120 + 5.06559944152832) + 0.0217155917318197*std::sin(0.598879814147949*x_120 - 4.00255966186523) - 0.0529706881275008*std::sin(0.452239871025085*x_2 - 4.13647985458374) - 0.282834380953882*std::sin(0.315839856863022*x_24 + 5.1191201210022) - 0.0504583384264892*std::sin(0.384239852428436*x_24 + 5.1701602935791) - 0.0306895838144593*std::sin(0.278319954872131*x_28 - 4.29287958145142) + 0.423192249457123*std::sin(0.343279838562012*x_28 - 4.25920009613037) - 0.028466143250835*std::sin(0.348079830408096*x_28 + 8.34904003143311) - 0.0039245470065543*std::sin(0.367599844932556*x_28 + 5.1799201965332) - 0.075113874613235*std::sin(0.281519949436188*x_3 + 1.88359987735748) + 0.0412906690626217*std::sin(0.309279918670654*x_35 - 1.13063991069794) + 0.0594539847368066*std::sin(0.321199834346771*x_35 + 1.9799998998642) - 0.155713289967282*std::sin(0.32287985086441*x_35 + 1.98631989955902) - 0.066473080459939*std::sin(0.287839949131012*x_36 - 7.49151992797852) + 0.00619743056617761*std::sin(0.403199851512909*x_36 + 5.21271991729736) + 0.0419632607461311*std::sin(0.410559862852097*x_36 + 5.20024013519287) + 0.0253739526445702*std::sin(0.614959836006165*x_38 + 2.18871974945068) + 0.0285044095716615*std::sin(0.417519867420197*x_41 + 1.98311984539032) + 0.0579279167446834*std::sin(0.271999955177307*x_43 - 1.33087992668152) - 0.0641727948972546*std::sin(0.397759854793549*x_43 + 8.20655918121338) + 0.224925143301626*std::sin(0.434879869222641*x_43 - 4.36527967453003) - 0.0302247416470419*std::sin(0.438959866762161*x_45 + 5.22911977767944) + 0.0171638294487226*std::sin(0.594159841537476*x_46 + 2.18767976760864) + 0.0314408451124551*std::sin(0.153040036559105*x_49 + 1.74503993988037) - 0.0360481905222707*std::sin(0.412159860134125*x_51 + 1.99223983287811) + 0.0193884478736501*std::sin(0.232959985733032*x_53 + 5.03399991989136) + 0.063602495882092*std::sin(0.250639975070953*x_53 + 5.05167961120605) - 0.034319500684579*std::sin(0.423519849777222*x_53 + 5.22088003158569) + 0.00883651829409455*std::sin(0.30703991651535*x_55 + 5.13463973999023) - 0.0360349124571456*std::sin(0.153440043330193*x_56 + 1.72919988632202) - 0.0147450477443705*std::sin(0.72655987739563*x_57 + 2.35935997962952) + 0.0303481549969515*std::sin(0.447759836912155*x_58 + 5.23080015182495) + 0.033533438989415*std::sin(0.490319848060608*x_58 + 5.28128004074097) - 0.084122994423893*std::sin(0.537279844284058*x_58 + 8.55719947814941) + 0.15904471813925*std::sin(0.202960014343262*x_59 - 7.60008001327515) + 0.140216437881219*std::sin(0.264799952507019*x_63 + 1.86583995819092) - 0.00814358391224587*std::sin(0.281759947538376*x_64 - 7.50191974639893) + 0.0368569839926495*std::sin(0.426319867372513*x_64 - 7.37799978256226) + 0.012487923248501*std::sin(0.530159831047058*x_64 + 8.52952003479004) - 0.0356372992390399*std::sin(0.235039979219437*x_66 + 5.03575992584229) + 0.099561667461888*std::sin(0.233679994940758*x_70 + 5.0449595451355) - 0.00142556720718866*std::sin(0.683279812335968*x_70 + 5.45639991760254) + 0.00890352516422969*std::sin(0.282959938049316*x_71 - 4.2960000038147) + 0.118073562107851*std::sin(0.23463998734951*x_73 + 5.05839967727661) - 0.104064366503651*std::sin(0.25095996260643*x_73 - 7.52400016784668) - 0.0754161224761822*std::sin(0.186240002512932*x_75 - 4.40799999237061) - 0.0184129085766412*std::sin(0.468879848718643*x_75 + 5.25735998153687) - 0.0037892135879932*std::sin(0.317759931087494*x_76 + 5.14647960662842) + 0.0688116290961013*std::sin(0.282799959182739*x_78 + 5.10743999481201) + 0.0387415105923661*std::sin(0.336639851331711*x_79 + 8.31711959838867) - 0.00524072446135725*std::sin(0.376399844884872*x_81 - 7.40743970870972) + 0.0782743695548021*std::sin(0.266319960355759*x_84 - 7.53360033035278) + 0.0072207566540814*std::sin(0.277999937534332*x_84 - 7.50880002975464) + 0.091681581302074*std::sin(0.282879948616028*x_84 - 7.50984001159668) - 0.138777047007569*std::sin(0.172720015048981*x_85 + 4.94823980331421) - 0.415342364722784*std::sin(0.125600054860115*x_86 + 4.900559425354) - 0.0584061168767899*std::sin(0.254159986972809*x_86 - 4.33599996566772) - 0.00923978083208137*std::sin(0.30895984172821*x_87 - 4.30751991271973) - 0.0395324327507583*std::sin(0.346319854259491*x_87 + 5.14383983612061) + 0.00777476237164113*std::sin(0.510159850120544*x_87 + 5.31903982162476) - 0.052462863112329*std::sin(1.01335978507996*x_87 - 6.99656009674072) - 0.00649656761815325*std::sin(0.336639851331711*x_92 + 8.38432025909424) - 0.0491006383118923*std::sin(0.348559856414795*x_92 + 1.99535977840424) + 0.0224070531983796*std::sin(0.375519841909409*x_92 - 1.20735991001129) + 0.0530610579706125*std::sin(0.364159852266312*x_95 - 7.40639972686768) - 0.00310183619929519*std::sin(0.377039849758148*x_95 - 1.2163999080658) + 0.0208164783999401*std::sin(0.396079838275909*x_95 + 8.39648056030273) - 0.0936934006569188*std::sin(0.428159862756729*x_95 - 1.16703987121582) + 0.020402168492616*std::sin(0.407679855823517*x_96 + 5.20000028610229) - 0.0301250307850736*std::sin(0.400159865617752*x_97 + 5.19280004501343) - 0.0356914462705021*std::sin(0.439679861068726*x_98 + 2.02647995948792) - 0.0301312543043715*std::sin(0.441519856452942*x_98 + 1.99927973747253) + 0.203314843897879*std::sin(0.164400026202202*x_99 - 1.41487991809845) - 0.990658323564742);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00967765407029044*x_1 - 0.00173438064551324*x_10 + 0.00192256871286525*x_100 + 0.00181108087212765*x_101 - 0.000393765052582146*x_102 - 0.00183099450524583*x_103 + 0.00123838549941401*x_104 - 0.00203842778983028*x_105 - 0.00530163669737135*x_106 + 0.00298572503973932*x_107 - 0.006260985619892*x_108 - 0.00675271464492353*x_11 - 0.00690086830848079*x_110 + 0.000827135431266825*x_111 + 0.00199505669862465*x_112 + 0.0061633338036988*x_113 + 0.00500451564212562*x_114 + 0.000481672089822534*x_115 + 0.0171380226078709*x_116 + 1.13285582532797e-5*x_117 + 0.00939207850255328*x_118 - 0.000527849935406881*x_119 + 0.00509788322056106*x_12 + 0.00207336718083229*x_120 - 0.00551663213701799*x_13 - 0.000919165326265682*x_14 + 0.000622580221222359*x_15 - 0.00761221722448586*x_16 + 0.00422621476764357*x_17 - 0.00381934919347896*x_18 - 0.00270499745105349*x_19 - 0.0011544178300332*x_2 - 0.00791497853296705*x_20 + 0.0151336494229273*x_21 + 0.00118143998097248*x_22 - 0.00858429262017403*x_23 - 0.00185443831010499*x_24 + 0.0220975689834472*x_25 + 0.00249145768403829*x_26 + 0.00300348531132249*x_27 - 0.00038752307212254*x_28 - 0.00360294067132576*x_29 + 0.00484746496034637*x_3 + 0.0125533255721747*x_30 - 0.0267449880896526*x_31 - 0.00290096859743708*x_32 - 0.0191465258745102*x_33 - 7.90137475486361e-5*x_34 - 0.000643233872842272*x_35 - 0.000319859250138374*x_36 + 0.00698155351670594*x_37 - 0.00184496544360385*x_38 - 0.00333145806798539*x_39 + 0.0145944936643336*x_4 - 0.00890112237244624*x_40 + 0.00614036358360418*x_41 + 0.0105490705309117*x_42 - 0.00123198525795633*x_43 + 0.00511180005173243*x_44 + 0.00435228444410011*x_45 + 0.00311788553830284*x_46 - 0.000436235918838322*x_47 - 0.00991274831072753*x_48 + 0.00265175012454513*x_49 - 0.00129601786310741*x_5 - 0.00106541907980971*x_50 + 0.00370384306180251*x_51 - 3.64924988296493e-5*x_52 - 0.00232679983058013*x_53 + 0.00802011717355868*x_54 + 0.00418265768146961*x_55 + 0.00370616461828407*x_56 + 0.0179124990255865*x_57 + 0.0119949749486164*x_58 + 0.00147214035882604*x_59 + 0.00379633654252752*x_6 + 0.00144348521996715*x_60 + 0.0124202922179833*x_61 - 0.00912583053376002*x_62 - 0.00815310373249447*x_63 + 0.00111618301648342*x_64 - 0.00363379707070985*x_65 - 0.00113702394309214*x_66 - 0.00436636116326876*x_67 - 0.000228033925236095*x_68 + 0.00528777312397442*x_69 - 0.00065150306167769*x_7 + 2.77137876366924e-5*x_70 - 0.00442583370668645*x_71 + 0.000356775184281686*x_72 + 0.00516007111885083*x_73 + 0.000866221587548781*x_74 + 0.00258186436319251*x_75 + 0.0121955372755467*x_76 - 0.00067648817081359*x_77 + 0.00625507193346731*x_78 + 0.00467347882036445*x_79 - 0.0145150375196354*x_8 - 0.0133259473036237*x_80 + 0.000118978495148758*x_81 - 0.00381530668584889*x_82 + 0.00627572110749689*x_83 - 0.00502573257921641*x_84 + 0.0038423351066835*x_85 + 0.00216059550938228*x_86 - 0.00089765537783338*x_87 - 0.00412485258100863*x_88 - 0.00158315326970357*x_89 - 0.00842640133592326*x_9 - 0.0116825250134151*x_90 - 0.00379939048144006*x_91 + 0.000272880626769891*x_92 + 0.0324805316581295*x_93 - 0.00132647380845718*x_94 + 2.10790414878539e-5*x_95 + 0.000224825538879868*x_96 + 0.00613200892801639*x_97 - 0.000651417645076776*x_98 + 0.00273382552271032*x_99 + 1.68847153507467e-5*std::pow(-5.44952011108398*x_114 - 6.8145604133606, 2) + 4.6273275366866e-6*std::pow(-7.48392009735107*x_15 - 9.32503986358643, 2) + 0.000197686518425157*std::pow(-4.71783971786499*x_15 - 6.56799983978271, 2) + 4.43978000320138e-6*std::pow(-7.35176038742065*x_23 - 9.59408092498779, 2) - 1.19583835695615e-5*std::pow(-4.51768016815186*x_24 - 6.28480005264282, 2) - 3.05153021052297e-6*std::pow(-9.80399990081787*x_40 - 9.97720050811768, 2) + 9.08028912629244e-6*std::pow(-6.20391988754272*x_50 - 5.59935998916626, 2) - 1.75429200206916e-5*std::pow(-7.59695959091187*x_56 - 6.57599973678589, 2) + 3.18630430157156e-5*std::pow(-5.34607982635498*x_59 - 6.13520002365112, 2) - 8.95879423806578e-5*std::pow(-5.23920011520386*x_59 - 6.44536018371582, 2) + 7.88138438619694e-6*std::pow(-5.6637601852417*x_67 - 8.90248012542725, 2) + 0.000148400059807365*std::pow(-5.33192014694214*x_7 - 7.97664022445679, 2) + 7.88820381061754e-5*std::pow(-7.07024002075195*x_70 - 9.68871974945068, 2) - 0.000194196323028431*std::pow(-3.4670398235321*x_70 - 4.69191980361938, 2) + 3.34314596837172e-5*std::pow(-5.50519990921021*x_77 - 7.96400022506714, 2) + 3.00540930894104e-5*std::pow(-7.53200006484985*x_81 - 9.99948024749756, 2) - 2.12906431620599e-5*std::pow(-7.6625599861145*x_84 - 7.4585599899292, 2) + 2.66798009192627e-5*std::pow(-8.54800033569336*x_88 - 8.59800052642822, 2) - 3.97193395902237e-5*std::pow(-5.06239986419678*x_90 - 7.8996000289917, 2) + 0.00255490087676044*std::exp(0.617359817028046*x_1) - 0.000122742170013099*std::exp(1.14975988864899*x_1) + 1.40815071223383e-5*std::exp(1.20047986507416*x_1) - 5.25171855883708e-6*std::exp(1.31991982460022*x_1) - 0.00252299649575549*std::exp(1.33495986461639*x_100) - 0.000305170108028072*std::exp(1.53511989116669*x_100) + 0.000800145306568993*std::exp(1.60943984985352*x_100) - 0.000574865024855703*std::exp(0.885279893875122*x_104) - 0.000361711604327966*std::exp(1.19487988948822*x_106) - 0.0086496631360982*std::exp(0.567839860916138*x_109) + 0.0020285056290166*std::exp(0.605279862880707*x_109) - 0.003068290285452*std::exp(0.867999851703644*x_109) - 0.00104156991913499*std::exp(0.871279835700989*x_109) - 0.00206802959380984*std::exp(0.886719882488251*x_109) - 0.000387962613559436*std::exp(1.18495988845825*x_110) + 3.97332436907647e-5*std::exp(1.75111997127533*x_110) + 0.00126916239097819*std::exp(0.616399824619293*x_112) - 0.00234573063268401*std::exp(0.721439838409424*x_114) - 0.00655926192970086*std::exp(0.60511988401413*x_26) - 0.00334726831191685*std::exp(0.78143984079361*x_26) + 0.000231029039305034*std::exp(1.22703981399536*x_26) + 0.00117618964164961*std::exp(0.598719835281372*x_31) + 0.00156881848368651*std::exp(0.628879845142365*x_31) - 0.01047970564704*std::exp(0.654159843921661*x_31) + 0.0012777364009516*std::exp(0.657919824123383*x_31) - 0.00082579878810305*std::exp(0.81335985660553*x_49) + 0.00739686344777615*std::exp(0.863999843597412*x_50) - 0.00165105071747507*std::exp(1.00015985965729*x_66) + 0.000707763055061127*std::exp(1.11055994033813*x_66) + 0.000169843434869914*std::exp(1.48999989032745*x_66) - 0.0023946047297489*std::exp(1.06511986255646*x_68) - 0.00321724903994862*std::exp(1.17007982730865*x_68) - 0.00753934031863414*std::exp(0.887999892234802*x_72) + 0.0115970569349838*std::exp(0.634559869766235*x_74) - 0.0016147137894464*std::exp(1.08279979228973*x_74) + 0.00124842809559134*std::exp(1.17399990558624*x_74) + 0.00187889777836891*std::exp(0.905119836330414*x_77) - 0.0072537453458519*std::exp(0.957039833068848*x_81) + 0.00514176362073205*std::sin(0.528159856796265*x_10 - 4.05343961715698) - 0.0036839487981535*std::sin(0.329999834299088*x_100 - 7.44367980957031) - 0.00771389576859828*std::sin(0.344559848308563*x_102 - 7.43680000305176) + 0.0257210397109475*std::sin(0.360319852828979*x_102 - 4.23464012145996) - 0.0554919502700746*std::sin(0.372879832983017*x_102 + 1.99031984806061) - 0.00274961141281778*std::sin(0.394319832324982*x_102 - 7.41599988937378) + 0.00552207860970071*std::sin(0.302079916000366*x_105 + 1.87591981887817) + 0.0490672937396756*std::sin(0.202159985899925*x_108 + 4.98984003067017) - 0.00577878855052482*std::sin(0.260319977998734*x_111 + 5.06303977966309) + 0.0427397063648833*std::sin(0.310319930315018*x_111 - 7.49119997024536) - 0.0418900857275518*std::sin(0.407119870185852*x_111 + 1.97735977172852) + 0.0190053632358366*std::sin(0.495199859142303*x_112 - 7.34656000137329) + 0.0973167122136856*std::sin(0.157280027866364*x_114 - 7.63944053649902) + 0.338365357541819*std::sin(0.154240027070045*x_115 - 7.65759992599487) - 0.00468452284315828*std::sin(0.424319863319397*x_115 - 4.16856002807617) - 0.012985452965029*std::sin(0.433519870042801*x_115 - 4.18584012985229) + 0.027998828101745*std::sin(0.438559859991074*x_115 - 7.3557596206665) + 0.0160927626605148*std::sin(0.416879862546921*x_117 + 5.20480012893677) + 0.0102165617561905*std::sin(0.526559829711914*x_118 - 4.02767992019653) - 0.0315460984738395*std::sin(0.26623997092247*x_120 + 5.06559944152832) - 0.0189716573848074*std::sin(0.598879814147949*x_120 - 4.00255966186523) - 0.0209643354790698*std::sin(0.452239871025085*x_2 - 4.13647985458374) + 0.023649395141993*std::sin(0.315839856863022*x_24 + 5.1191201210022) - 0.0199700168505111*std::sin(0.384239852428436*x_24 + 5.1701602935791) - 0.0145443747968248*std::sin(0.278319954872131*x_28 - 4.29287958145142) - 0.0353855167631558*std::sin(0.343279838562012*x_28 - 4.25920009613037) + 0.024869224080611*std::sin(0.348079830408096*x_28 + 8.34904003143311) - 0.00406191796710531*std::sin(0.367599844932556*x_28 + 5.1799201965332) - 0.0297279971657967*std::sin(0.281519949436188*x_3 + 1.88359987735748) - 0.0360732710542575*std::sin(0.309279918670654*x_35 - 1.13063991069794) + 0.0235302452290177*std::sin(0.321199834346771*x_35 + 1.9799998998642) + 0.0130200759570897*std::sin(0.32287985086441*x_35 + 1.98631989955902) - 0.0315028513242117*std::sin(0.287839949131012*x_36 - 7.49151992797852) + 0.00641435929410524*std::sin(0.403199851512909*x_36 + 5.21271991729736) + 0.0166078997116302*std::sin(0.410559862852097*x_36 + 5.20024013519287) + 0.0100423097089167*std::sin(0.614959836006165*x_38 + 2.18871974945068) + 0.0112812581074037*std::sin(0.417519867420197*x_41 + 1.98311984539032) + 0.0274531364591847*std::sin(0.271999955177307*x_43 - 1.33087992668152) - 0.0253978199720068*std::sin(0.397759854793549*x_43 + 8.20655918121338) - 0.0188072736184675*std::sin(0.434879869222641*x_43 - 4.36527967453003) + 0.0264056098564323*std::sin(0.438959866762161*x_45 + 5.22911977767944) - 0.0149950457594621*std::sin(0.594159841537476*x_46 + 2.18767976760864) + 0.0325413693478434*std::sin(0.153040036559105*x_49 + 1.74503993988037) - 0.0142668782724376*std::sin(0.412159860134125*x_51 + 1.99223983287811) + 0.0200671019204862*std::sin(0.232959985733032*x_53 + 5.03399991989136) + 0.0251721113716489*std::sin(0.250639975070953*x_53 + 5.05167961120605) + 0.0299829641598689*std::sin(0.423519849777222*x_53 + 5.22088003158569) + 0.00914582303779085*std::sin(0.30703991651535*x_55 + 5.13463973999023) - 0.0372962428805913*std::sin(0.153440043330193*x_56 + 1.72919988632202) - 0.00698795728504338*std::sin(0.72655987739563*x_57 + 2.35935997962952) + 0.0143825652161445*std::sin(0.447759836912155*x_58 + 5.23080015182495) + 0.0132716090651659*std::sin(0.490319848060608*x_58 + 5.28128004074097) + 0.00703400318217576*std::sin(0.537279844284058*x_58 + 8.55719947814941) - 0.138948177819158*std::sin(0.202960014343262*x_59 - 7.60008001327515) - 0.122498997589033*std::sin(0.264799952507019*x_63 + 1.86583995819092) - 0.00842863386641502*std::sin(0.281759947538376*x_64 - 7.50191974639893) - 0.0321998166654279*std::sin(0.426319867372513*x_64 - 7.37799978256226) + 0.00494237514506689*std::sin(0.530159831047058*x_64 + 8.52952003479004) - 0.0141042588500441*std::sin(0.235039979219437*x_66 + 5.03575992584229) + 0.0394037584050748*std::sin(0.233679994940758*x_70 + 5.0449595451355) - 0.0014754663512821*std::sin(0.683279812335968*x_70 + 5.45639991760254) + 0.00921517535011297*std::sin(0.282959938049316*x_71 - 4.2960000038147) - 0.103154046833161*std::sin(0.23463998734951*x_73 + 5.05839967727661) - 0.0411858023355895*std::sin(0.25095996260643*x_73 - 7.52400016784668) - 0.0298476185228273*std::sin(0.186240002512932*x_75 - 4.40799999237061) - 0.00872622597482617*std::sin(0.468879848718643*x_75 + 5.25735998153687) - 0.00392184747145701*std::sin(0.317759931087494*x_76 + 5.14647960662842) + 0.0272337424380756*std::sin(0.282799959182739*x_78 + 5.10743999481201) + 0.0183603353390884*std::sin(0.336639851331711*x_79 + 8.31711959838867) - 0.00542416559533717*std::sin(0.376399844884872*x_81 - 7.40743970870972) + 0.0309788337808588*std::sin(0.266319960355759*x_84 - 7.53360033035278) + 0.00747350487593214*std::sin(0.277999937534332*x_84 - 7.50880002975464) - 0.0800968985989754*std::sin(0.282879948616028*x_84 - 7.50984001159668) + 0.121241484976209*std::sin(0.172720015048981*x_85 + 4.94823980331421) - 0.164381037523241*std::sin(0.125600054860115*x_86 + 4.900559425354) + 0.0510260485759566*std::sin(0.254159986972809*x_86 - 4.33599996566772) - 0.00956320097867767*std::sin(0.30895984172821*x_87 - 4.30751991271973) + 0.0345372016105995*std::sin(0.346319854259491*x_87 + 5.14383983612061) + 0.00368460708274976*std::sin(0.510159850120544*x_87 + 5.31903982162476) + 0.00438671909631122*std::sin(1.01335978507996*x_87 - 6.99656009674072) - 0.00672396704348817*std::sin(0.336639851331711*x_92 + 8.38432025909424) - 0.0194326766405091*std::sin(0.348559856414795*x_92 + 1.99535977840424) + 0.0106191267297694*std::sin(0.375519841909409*x_92 - 1.20735991001129) - 0.0463563795417473*std::sin(0.364159852266312*x_95 - 7.40639972686768) - 0.00321040980472212*std::sin(0.377039849758148*x_95 - 1.2163999080658) + 0.00823858726582383*std::sin(0.396079838275909*x_95 + 8.39648056030273) + 0.00783423941198237*std::sin(0.428159862756729*x_95 - 1.16703987121582) - 0.0178241954135591*std::sin(0.407679855823517*x_96 + 5.20000028610229) + 0.0263184982393892*std::sin(0.400159865617752*x_97 + 5.19280004501343) - 0.0141256887497282*std::sin(0.439679861068726*x_98 + 2.02647995948792) - 0.0142797718714825*std::sin(0.441519856452942*x_98 + 1.99927973747253) + 0.0804664003059639*std::sin(0.164400026202202*x_99 - 1.41487991809845) + 0.756446156600164);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0138694795976299*x_1 + 0.00125043472829325*x_10 - 0.00186908288364286*x_100 + 0.0394202021652177*x_101 - 0.000189688822496981*x_102 - 0.0215673641050425*x_103 + 0.00949765259533288*x_104 - 0.0174195683203394*x_105 + 0.0174246924459206*x_106 - 0.0197666715561568*x_107 - 0.0157710000465164*x_108 - 0.0076118623222644*x_11 + 0.0260842650958269*x_110 - 0.00190258455812744*x_111 - 0.00152048575373687*x_112 + 0.00444561329683879*x_113 - 0.00991626955957057*x_114 + 0.000232036365210536*x_115 + 0.0156820299859451*x_116 - 0.00320397843656299*x_117 - 0.032101439198588*x_118 + 0.00899324451130147*x_119 - 0.0908881804120626*x_12 + 0.000926018796181487*x_120 + 0.00327566400073642*x_13 - 0.0191695941230311*x_14 - 0.00709635536276517*x_15 - 0.0144473146765686*x_16 + 0.00527044218901199*x_17 + 0.0265433438243669*x_18 - 0.00674486262253089*x_19 - 0.0240098233198856*x_2 - 0.00428203282660912*x_20 - 0.0503000305913625*x_21 + 0.0140920548618753*x_22 + 0.00920809838213578*x_23 + 0.000312700830215705*x_24 - 0.021602556377637*x_25 - 0.00274925819162903*x_26 + 0.0119347790414637*x_27 + 0.000376742186780663*x_28 + 0.00184454724108678*x_29 - 0.0298433321146815*x_3 + 0.0103069982443795*x_30 + 0.0260009429712932*x_31 - 0.0543347448023134*x_32 + 0.00340248380488024*x_33 - 0.00370930866336821*x_34 + 0.00136258900019186*x_35 - 0.00322991166568608*x_36 - 0.0316398606487278*x_37 - 0.00267685052572383*x_38 + 0.00965349586256495*x_39 - 0.0171513198469777*x_4 - 0.00153776243989548*x_40 - 0.005334326941833*x_41 + 0.001858466691329*x_42 - 0.000478334966566848*x_43 - 0.0373319734357401*x_44 - 0.0117616136046976*x_45 - 0.0174412081556659*x_46 - 0.00341350233877373*x_47 + 0.0161520183601912*x_48 - 0.0105507991169753*x_49 + 0.0209206575848412*x_5 - 0.000754731714625362*x_50 - 0.0182723599944591*x_51 + 0.00178152092256542*x_52 + 0.00205773584320469*x_53 + 0.00428287575280385*x_54 - 0.0292518715212365*x_55 - 0.0201189885251199*x_56 - 0.0219821790260331*x_57 + 0.00409139485030706*x_58 - 0.00177353446386702*x_59 - 0.00225191245087516*x_6 - 0.00848204607492512*x_60 - 0.00699758978910529*x_61 + 0.000768903815305429*x_62 + 0.0259372465695179*x_63 - 0.00316576284952978*x_64 - 0.00948590360306464*x_65 - 0.000381177333492598*x_66 + 0.00416808488574321*x_67 - 0.00420551197296836*x_68 + 0.0147584231038856*x_69 - 0.00452811969659543*x_7 - 3.9717870612895e-5*x_70 + 0.0147128526584842*x_71 - 0.00881020338310049*x_72 - 0.0146700818898897*x_73 - 0.0044857986509751*x_74 + 0.00030125171829062*x_75 - 0.0273374196714161*x_76 + 0.000649719846413196*x_77 + 0.00406591082867736*x_78 + 0.0126054906067816*x_79 + 0.0240049999400291*x_8 + 0.0114456853214737*x_80 - 0.000935898370663617*x_81 + 0.0123387094246097*x_82 + 0.00372367704474716*x_83 + 0.0262319470241491*x_84 - 0.0207104186102929*x_85 - 0.0103223244443688*x_86 + 0.000872682620335523*x_87 + 0.00568281511062211*x_88 + 0.00261630452630588*x_89 + 0.0392154192453547*x_9 + 0.00380664631190186*x_90 + 0.0143779520716828*x_91 - 0.00557548950484798*x_92 - 0.0104940252248741*x_93 - 0.0158797321600599*x_94 - 3.02093186768153e-5*x_95 - 0.00193221366892538*x_96 - 0.0185879373963323*x_97 + 0.00574416602822569*x_98 + 0.000568579785031825*x_99 + 8.13389037975046e-6*std::pow(-5.44952011108398*x_114 - 6.8145604133606, 2) + 2.22912700349106e-6*std::pow(-7.48392009735107*x_15 - 9.32503986358643, 2) + 6.62726765065406e-5*std::pow(-4.71783971786499*x_15 - 6.56799983978271, 2) + 2.13877954742371e-6*std::pow(-7.35176038742065*x_23 - 9.59408092498779, 2) - 5.76072377018312e-6*std::pow(-4.51768016815186*x_24 - 6.28480005264282, 2) - 1.47001662197361e-6*std::pow(-9.80399990081787*x_40 - 9.97720050811768, 2) + 4.37425652937859e-6*std::pow(-6.20391988754272*x_50 - 5.59935998916626, 2) + 1.70548762810792e-5*std::pow(-7.59695959091187*x_56 - 6.57599973678589, 2) - 4.56643543791815e-5*std::pow(-5.34607982635498*x_59 - 6.13520002365112, 2) + 0.000467606686485963*std::pow(-5.23920011520386*x_59 - 6.44536018371582, 2) - 1.12951650422194e-5*std::pow(-5.6637601852417*x_67 - 8.90248012542725, 2) + 4.97498222717105e-5*std::pow(-5.33192014694214*x_7 - 7.97664022445679, 2) + 2.64445134409424e-5*std::pow(-7.07024002075195*x_70 - 9.68871974945068, 2) + 0.00101361295645392*std::pow(-3.4670398235321*x_70 - 4.69191980361938, 2) - 3.25013970381884e-5*std::pow(-5.50519990921021*x_77 - 7.96400022506714, 2) - 2.92179887256718e-5*std::pow(-7.53200006484985*x_81 - 9.99948024749756, 2) + 3.05125745156693e-5*std::pow(-7.6625599861145*x_84 - 7.4585599899292, 2) - 2.5937569306886e-5*std::pow(-8.54800033569336*x_88 - 8.59800052642822, 2) + 5.692356495456e-5*std::pow(-5.06239986419678*x_90 - 7.8996000289917, 2) + 0.000856508175978248*std::exp(0.617359817028046*x_1) + 0.000119327484909896*std::exp(1.14975988864899*x_1) - 7.34988069960041e-5*std::exp(1.20047986507416*x_1) - 2.52991549904883e-6*std::exp(1.31991982460022*x_1) - 0.000845812511254489*std::exp(1.33495986461639*x_100) + 0.000437352953139275*std::exp(1.53511989116669*x_100) - 0.0041763800525996*std::exp(1.60943984985352*x_100) + 0.000558872289542992*std::exp(0.885279893875122*x_104) - 0.00012126065213377*std::exp(1.19487988948822*x_106) - 0.00289972392389625*std::exp(0.567839860916138*x_109) + 0.000977193993406475*std::exp(0.605279862880707*x_109) + 0.0160150240694337*std::exp(0.867999851703644*x_109) + 0.00149272051243243*std::exp(0.871279835700989*x_109) + 0.00201049704532864*std::exp(0.886719882488251*x_109) - 0.000186893607892204*std::exp(1.18495988845825*x_110) - 5.69434915439354e-5*std::exp(1.75111997127533*x_110) - 0.00181889347975245*std::exp(0.616399824619293*x_112) + 0.00336177165615199*std::exp(0.721439838409424*x_114) + 0.0342362449146187*std::exp(0.60511988401413*x_26) + 0.00325414736383596*std::exp(0.78143984079361*x_26) + 7.74504650466389e-5*std::exp(1.22703981399536*x_26) - 0.00168565006760086*std::exp(0.598719835281372*x_31) - 0.00818849047495218*std::exp(0.628879845142365*x_31) - 0.00351322967171882*std::exp(0.654159843921661*x_31) + 0.000615525201560329*std::exp(0.657919824123383*x_31) + 0.000802825079721669*std::exp(0.81335985660553*x_49) + 0.00247973378428997*std::exp(0.863999843597412*x_50) + 0.00236619474868101*std::exp(1.00015985965729*x_66) + 0.000340951386216286*std::exp(1.11055994033813*x_66) - 0.000886502398542213*std::exp(1.48999989032745*x_66) + 0.00343181531416772*std::exp(1.06511986255646*x_68) - 0.00107855460536231*std::exp(1.17007982730865*x_68) - 0.0025274979092655*std::exp(0.887999892234802*x_72) + 0.00388781191961298*std::exp(0.634559869766235*x_74) + 0.00231411866926406*std::exp(1.08279979228973*x_74) - 0.00121369684699128*std::exp(1.17399990558624*x_74) + 0.000629884048981534*std::exp(0.905119836330414*x_77) - 0.00243175469220713*std::exp(0.957039833068848*x_81) - 0.0268375741812291*std::sin(0.528159856796265*x_10 - 4.05343961715698) - 0.0017746722444728*std::sin(0.329999834299088*x_100 - 7.44367980957031) + 0.0110551296010115*std::sin(0.344559848308563*x_102 - 7.43680000305176) - 0.134251661915686*std::sin(0.360319852828979*x_102 - 4.23464012145996) - 0.0186031910433893*std::sin(0.372879832983017*x_102 + 1.99031984806061) + 0.00267311726960731*std::sin(0.394319832324982*x_102 - 7.41599988937378) + 0.00266015630981211*std::sin(0.302079916000366*x_105 + 1.87591981887817) - 0.0477022424539644*std::sin(0.202159985899925*x_108 + 4.98984003067017) - 0.00278382143976429*std::sin(0.260319977998734*x_111 + 5.06303977966309) - 0.223081052467402*std::sin(0.310319930315018*x_111 - 7.49119997024536) - 0.0140432849056641*std::sin(0.407119870185852*x_111 + 1.97735977172852) + 0.00637138182032759*std::sin(0.495199859142303*x_112 - 7.34656000137329) - 0.0946093629183838*std::sin(0.157280027866364*x_114 - 7.63944053649902) + 0.113434027064818*std::sin(0.154240027070045*x_115 - 7.65759992599487) + 0.00671359954860061*std::sin(0.424319863319397*x_115 - 4.16856002807617) + 0.0126241978821728*std::sin(0.433519870042801*x_115 - 4.18584012985229) - 0.146140639981634*std::sin(0.438559859991074*x_115 - 7.3557596206665) - 0.0839966096343008*std::sin(0.416879862546921*x_117 + 5.20480012893677) + 0.00342501298354064*std::sin(0.526559829711914*x_118 - 4.02767992019653) + 0.0452101269574113*std::sin(0.26623997092247*x_120 + 5.06559944152832) - 0.0063600822285323*std::sin(0.598879814147949*x_120 - 4.00255966186523) + 0.0203811080190103*std::sin(0.452239871025085*x_2 - 4.13647985458374) - 0.123438657099152*std::sin(0.315839856863022*x_24 + 5.1191201210022) + 0.0194144513179571*std::sin(0.384239852428436*x_24 + 5.1701602935791) + 0.0208441950951849*std::sin(0.278319954872131*x_28 - 4.29287958145142) + 0.184695661084691*std::sin(0.343279838562012*x_28 - 4.25920009613037) + 0.0083371898882775*std::sin(0.348079830408096*x_28 + 8.34904003143311) - 0.00195675170055575*std::sin(0.367599844932556*x_28 + 5.1799201965332) + 0.0289009647851627*std::sin(0.281519949436188*x_3 + 1.88359987735748) - 0.0120932486552777*std::sin(0.309279918670654*x_35 - 1.13063991069794) - 0.0228756342029158*std::sin(0.321199834346771*x_35 + 1.9799998998642) - 0.0679586383424375*std::sin(0.32287985086441*x_35 + 1.98631989955902) + 0.0451481475298494*std::sin(0.287839949131012*x_36 - 7.49151992797852) + 0.00308999555342093*std::sin(0.403199851512909*x_36 + 5.21271991729736) - 0.0161458682212732*std::sin(0.410559862852097*x_36 + 5.20024013519287) - 0.00976293282189303*std::sin(0.614959836006165*x_38 + 2.18871974945068) - 0.0109674136967938*std::sin(0.417519867420197*x_41 + 1.98311984539032) - 0.0393443197334893*std::sin(0.271999955177307*x_43 - 1.33087992668152) + 0.0246912530479986*std::sin(0.397759854793549*x_43 + 8.20655918121338) + 0.0981650729425079*std::sin(0.434879869222641*x_43 - 4.36527967453003) + 0.00885224978371899*std::sin(0.438959866762161*x_45 + 5.22911977767944) - 0.00502695795714484*std::sin(0.594159841537476*x_46 + 2.18767976760864) + 0.0156761855668845*std::sin(0.153040036559105*x_49 + 1.74503993988037) + 0.0138699739591041*std::sin(0.412159860134125*x_51 + 1.99223983287811) + 0.00966694456316646*std::sin(0.232959985733032*x_53 + 5.03399991989136) - 0.0244718236571025*std::sin(0.250639975070953*x_53 + 5.05167961120605) + 0.0100515265294961*std::sin(0.423519849777222*x_53 + 5.22088003158569) + 0.00440582624442627*std::sin(0.30703991651535*x_55 + 5.13463973999023) - 0.0179667554273494*std::sin(0.153440043330193*x_56 + 1.72919988632202) + 0.0100147546388904*std::sin(0.72655987739563*x_57 + 2.35935997962952) - 0.0206122985362*std::sin(0.447759836912155*x_58 + 5.23080015182495) - 0.0129023931244218*std::sin(0.490319848060608*x_58 + 5.28128004074097) - 0.0367141697124083*std::sin(0.537279844284058*x_58 + 8.55719947814941) - 0.0465811614931577*std::sin(0.202960014343262*x_59 - 7.60008001327515) - 0.0410667176713269*std::sin(0.264799952507019*x_63 + 1.86583995819092) - 0.00406033400601213*std::sin(0.281759947538376*x_64 - 7.50191974639893) - 0.0107947069453081*std::sin(0.426319867372513*x_64 - 7.37799978256226) - 0.00480487835174394*std::sin(0.530159831047058*x_64 + 8.52952003479004) + 0.0137118786063037*std::sin(0.235039979219437*x_66 + 5.03575992584229) - 0.0383075465096711*std::sin(0.233679994940758*x_70 + 5.0449595451355) - 0.000710777843217132*std::sin(0.683279812335968*x_70 + 5.45639991760254) + 0.00443923540142372*std::sin(0.282959938049316*x_71 - 4.2960000038147) - 0.0345814921046465*std::sin(0.23463998734951*x_73 + 5.05839967727661) + 0.0400400140080424*std::sin(0.25095996260643*x_73 - 7.52400016784668) + 0.0290172582780547*std::sin(0.186240002512932*x_75 - 4.40799999237061) + 0.012505945370966*std::sin(0.468879848718643*x_75 + 5.25735998153687) - 0.00188927540419105*std::sin(0.317759931087494*x_76 + 5.14647960662842) - 0.0264761001819721*std::sin(0.282799959182739*x_78 + 5.10743999481201) - 0.0263130190996263*std::sin(0.336639851331711*x_79 + 8.31711959838867) - 0.00261298857798839*std::sin(0.376399844884872*x_81 - 7.40743970870972) - 0.0301170031466536*std::sin(0.266319960355759*x_84 - 7.53360033035278) + 0.00360021878667171*std::sin(0.277999937534332*x_84 - 7.50880002975464) - 0.0268517847970333*std::sin(0.282879948616028*x_84 - 7.50984001159668) + 0.0406451475649966*std::sin(0.172720015048981*x_85 + 4.94823980331421) + 0.159807959826963*std::sin(0.125600054860115*x_86 + 4.900559425354) + 0.017106036555354*std::sin(0.254159986972809*x_86 - 4.33599996566772) - 0.00460689012661658*std::sin(0.30895984172821*x_87 - 4.30751991271973) + 0.0115782948074276*std::sin(0.346319854259491*x_87 + 5.14383983612061) - 0.00528057547710491*std::sin(0.510159850120544*x_87 + 5.31903982162476) - 0.0228965988799588*std::sin(1.01335978507996*x_87 - 6.99656009674072) - 0.00323914319623806*std::sin(0.336639851331711*x_92 + 8.38432025909424) + 0.0188920599035504*std::sin(0.348559856414795*x_92 + 1.99535977840424) - 0.0152187462429894*std::sin(0.375519841909409*x_92 - 1.20735991001129) - 0.0155405708485262*std::sin(0.364159852266312*x_95 - 7.40639972686768) - 0.00154655384371232*std::sin(0.377039849758148*x_95 - 1.2163999080658) - 0.00800938990679843*std::sin(0.396079838275909*x_95 + 8.39648056030273) - 0.0408910243413039*std::sin(0.428159862756729*x_95 - 1.16703987121582) - 0.00597540563738232*std::sin(0.407679855823517*x_96 + 5.20000028610229) + 0.00882304637590824*std::sin(0.400159865617752*x_97 + 5.19280004501343) + 0.0137327123265394*std::sin(0.439679861068726*x_98 + 2.02647995948792) + 0.0204649807889229*std::sin(0.441519856452942*x_98 + 1.99927973747253) - 0.0782278264042328*std::sin(0.164400026202202*x_99 - 1.41487991809845) - 0.601292814485205);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0150488964465126*x_1 - 0.0038129091312064*x_10 - 0.00778856430688013*x_100 - 0.0736108588871272*x_101 + 0.000671981711108678*x_102 + 0.0268628195786231*x_103 - 0.0136424160226811*x_104 + 0.0231416355045689*x_105 - 0.018521865824854*x_106 + 0.043969669351617*x_107 + 0.0310298775017034*x_108 + 0.0159980131507153*x_11 - 0.0443872860062313*x_110 + 0.00259729660507999*x_111 - 0.00360429059224725*x_112 + 0.021413476219672*x_113 + 0.0217150266695648*x_114 - 0.000821999903215675*x_115 - 0.0071751623481391*x_116 + 0.00182570897088139*x_117 + 0.046494441435192*x_118 - 0.010324447561399*x_119 + 0.20677714060877*x_12 - 0.0248770483509998*x_120 + 0.0152318650949404*x_13 + 0.0379932569721916*x_14 + 0.0194383497031478*x_15 + 0.0403407323167491*x_16 - 0.012804256102428*x_17 - 0.0292128899600053*x_18 - 0.0092479877700326*x_19 + 0.0333317274458039*x_2 + 0.0185627911406021*x_20 + 0.0755243351753547*x_21 - 0.0122374478879101*x_22 - 0.0193309987984618*x_23 + 0.000658401561232701*x_24 + 0.0303434868924503*x_25 - 0.00393925503314183*x_26 - 0.0406863628876551*x_27 + 0.00156990402862012*x_28 - 0.0104124613559261*x_29 + 0.0629856007004692*x_3 - 0.0488824736130037*x_30 + 0.10834726386063*x_31 + 0.172275177160132*x_32 + 0.00307905776148771*x_33 - 0.00050442421939505*x_34 + 0.000965358706158162*x_35 + 0.00564333736416299*x_36 + 0.0621182141640539*x_37 + 0.0138353990092532*x_38 + 0.00464002563938392*x_39 + 0.0197979919306014*x_4 + 0.00770006046872071*x_40 + 0.0333494372838811*x_41 - 0.0453714511295722*x_42 + 0.000664219586393807*x_43 + 0.0767813519795928*x_44 + 0.015401581886156*x_45 + 0.036259681864393*x_46 + 0.0206629126633533*x_47 - 0.0393276864860345*x_48 + 0.0228883296613158*x_49 - 0.0160172591954722*x_5 + 0.0109274806639712*x_50 + 0.0389149797924458*x_51 - 0.00241913783925952*x_52 + 0.00759313995493533*x_53 + 0.0128120251074119*x_54 + 0.0347753902232119*x_55 + 0.0385165153523584*x_56 + 0.0323878581380699*x_57 + 0.000600017369061805*x_58 - 0.00651589337649759*x_59 - 0.00741142435182509*x_6 + 0.0275184701157803*x_60 - 0.00739014958676804*x_61 + 0.00300427777912478*x_62 - 0.026580645042732*x_63 + 0.00313953084249433*x_64 + 0.0173661073086806*x_65 - 0.000139971427895602*x_66 + 0.00128282591994058*x_67 + 0.0104394802836893*x_68 - 0.0230036305273139*x_69 + 0.0266857974283533*x_7 - 4.30953531977931e-5*x_70 - 0.0360728869611798*x_71 + 0.0253675570041746*x_72 + 0.0201150903435547*x_73 + 0.00878871184406921*x_74 - 0.000927575360589722*x_75 + 0.0386741967103678*x_76 + 0.00052729150422437*x_77 - 0.000167828741837016*x_78 - 0.0546034656153259*x_79 - 0.0154411459537831*x_8 - 0.00773027141262404*x_80 + 0.00219758539908382*x_81 + 0.00250574573764895*x_82 - 0.00601251829136776*x_83 - 0.0514221503919141*x_84 + 0.0425164808576472*x_85 + 0.0198455875541949*x_86 + 0.00363651326940224*x_87 - 0.00979927879855201*x_88 - 0.0170498324804813*x_89 - 0.102552100109933*x_9 - 0.0140678373206707*x_90 + 0.00577411168079235*x_91 + 0.0103464486604068*x_92 - 0.0212512263313031*x_93 + 0.0408526713052602*x_94 - 3.27782239619706e-5*x_95 + 0.00345804714371385*x_96 + 0.0255130588727976*x_97 - 0.013198112068186*x_98 + 0.00438367229263481*x_99 - 2.88146950537484e-5*std::pow(-5.44952011108398*x_114 - 6.8145604133606, 2) - 7.89678884800035e-6*std::pow(-7.48392009735107*x_15 - 9.32503986358643, 2) + 2.43358677077894e-5*std::pow(-4.71783971786499*x_15 - 6.56799983978271, 2) - 7.5767286708994e-6*std::pow(-7.35176038742065*x_23 - 9.59408092498779, 2) + 2.04076390235049e-5*std::pow(-4.51768016815186*x_24 - 6.28480005264282, 2) + 5.20760407486711e-6*std::pow(-9.80399990081787*x_40 - 9.97720050811768, 2) - 1.54960126208117e-5*std::pow(-6.20391988754272*x_50 - 5.59935998916626, 2) + 7.10685448053415e-5*std::pow(-7.59695959091187*x_56 - 6.57599973678589, 2) - 4.9547507209037e-5*std::pow(-5.34607982635498*x_59 - 6.13520002365112, 2) - 0.000916643409450687*std::pow(-5.23920011520386*x_59 - 6.44536018371582, 2) - 1.22556702917446e-5*std::pow(-5.6637601852417*x_67 - 8.90248012542725, 2) + 1.82685407789573e-5*std::pow(-5.33192014694214*x_7 - 7.97664022445679, 2) + 9.71064116645599e-6*std::pow(-7.07024002075195*x_70 - 9.68871974945068, 2) - 0.00198697252011003*std::pow(-3.4670398235321*x_70 - 4.69191980361938, 2) - 0.0001354349895934*std::pow(-5.50519990921021*x_77 - 7.96400022506714, 2) - 0.000121752858634104*std::pow(-7.53200006484985*x_81 - 9.99948024749756, 2) + 3.31072677219465e-5*std::pow(-7.6625599861145*x_84 - 7.4585599899292, 2) - 0.000108083182548389*std::pow(-8.54800033569336*x_88 - 8.59800052642822, 2) + 6.17641655793559e-5*std::pow(-5.06239986419678*x_90 - 7.8996000289917, 2) + 0.00031451679274172*std::exp(0.617359817028046*x_1) + 0.000497243754106613*std::exp(1.14975988864899*x_1) + 0.000144078771716618*std::exp(1.20047986507416*x_1) + 8.96234645580265e-6*std::exp(1.31991982460022*x_1) - 0.000310589257360852*std::exp(1.33495986461639*x_100) + 0.000474544070384167*std::exp(1.53511989116669*x_100) + 0.00818690442462623*std::exp(1.60943984985352*x_100) + 0.00232884951466424*std::exp(0.885279893875122*x_104) - 4.45279011508832e-5*std::exp(1.19487988948822*x_106) - 0.00106480229139511*std::exp(0.567839860916138*x_109) - 0.00346175638148028*std::exp(0.605279862880707*x_109) - 0.031394046940946*std::exp(0.867999851703644*x_109) + 0.00161965676196097*std::exp(0.871279835700989*x_109) + 0.00837784437671125*std::exp(0.886719882488251*x_109) + 0.000662079529903119*std::exp(1.18495988845825*x_110) - 6.17857866631126e-5*std::exp(1.75111997127533*x_110) - 0.0019735664508068*std::exp(0.616399824619293*x_112) + 0.00364764612645582*std::exp(0.721439838409424*x_114) - 0.0671128732165101*std::exp(0.60511988401413*x_26) + 0.0135601990843246*std::exp(0.78143984079361*x_26) + 2.84404428889447e-5*std::exp(1.22703981399536*x_26) - 0.00182899243867213*std::exp(0.598719835281372*x_31) + 0.0160517931931668*std::exp(0.628879845142365*x_31) - 0.00129008660921657*std::exp(0.654159843921661*x_31) - 0.0021805274171155*std::exp(0.657919824123383*x_31) + 0.00334541331222375*std::exp(0.81335985660553*x_49) + 0.000910578484317907*std::exp(0.863999843597412*x_50) + 0.0025674084953604*std::exp(1.00015985965729*x_66) - 0.0012078365656898*std::exp(1.11055994033813*x_66) + 0.00173779931846706*std::exp(1.48999989032745*x_66) + 0.00372364607647512*std::exp(1.06511986255646*x_68) - 0.000396054053877448*std::exp(1.17007982730865*x_68) - 0.000928117860843134*std::exp(0.887999892234802*x_72) + 0.00142763626785363*std::exp(0.634559869766235*x_74) + 0.00251090403021665*std::exp(1.08279979228973*x_74) - 0.00505753705444313*std::exp(1.17399990558624*x_74) + 0.000231298563681045*std::exp(0.905119836330414*x_77) - 0.00089296017011639*std::exp(0.957039833068848*x_81) + 0.0526093535653624*std::sin(0.528159856796265*x_10 - 4.05343961715698) + 0.00628686116451004*std::sin(0.329999834299088*x_100 - 7.44367980957031) + 0.0119952229928532*std::sin(0.344559848308563*x_102 - 7.43680000305176) + 0.263171816527285*std::sin(0.360319852828979*x_102 - 4.23464012145996) - 0.00683124358392217*std::sin(0.372879832983017*x_102 + 1.99031984806061) + 0.0111390168602852*std::sin(0.394319832324982*x_102 - 7.41599988937378) - 0.00942373074677364*std::sin(0.302079916000366*x_105 + 1.87591981887817) - 0.198777692624828*std::sin(0.202159985899925*x_108 + 4.98984003067017) + 0.00986182037449043*std::sin(0.260319977998734*x_111 + 5.06303977966309) + 0.437302935195956*std::sin(0.310319930315018*x_111 - 7.49119997024536) - 0.00515680883377796*std::sin(0.407119870185852*x_111 + 1.97735977172852) + 0.00233962340543171*std::sin(0.495199859142303*x_112 - 7.34656000137329) - 0.39424207110956*std::sin(0.157280027866364*x_114 - 7.63944053649902) + 0.0416539005473662*std::sin(0.154240027070045*x_115 - 7.65759992599487) + 0.00728450290287098*std::sin(0.424319863319397*x_115 - 4.16856002807617) + 0.0526056805123846*std::sin(0.433519870042801*x_115 - 4.18584012985229) + 0.286477628236592*std::sin(0.438559859991074*x_115 - 7.3557596206665) + 0.164657480020434*std::sin(0.416879862546921*x_117 + 5.20480012893677) + 0.00125769272132355*std::sin(0.526559829711914*x_118 - 4.02767992019653) + 0.049054653718373*std::sin(0.26623997092247*x_120 + 5.06559944152832) - 0.00233547410310114*std::sin(0.598879814147949*x_120 - 4.00255966186523) + 0.0849291231762534*std::sin(0.452239871025085*x_2 - 4.13647985458374) + 0.241975221423138*std::sin(0.315839856863022*x_24 + 5.1191201210022) + 0.080901015089278*std::sin(0.384239852428436*x_24 + 5.1701602935791) + 0.0226167197759856*std::sin(0.278319954872131*x_28 - 4.29287958145142) - 0.362056543202364*std::sin(0.343279838562012*x_28 - 4.25920009613037) + 0.0030614841722262*std::sin(0.348079830408096*x_28 + 8.34904003143311) + 0.00693188633175892*std::sin(0.367599844932556*x_28 + 5.1799201965332) + 0.120431803602739*std::sin(0.281519949436188*x_3 + 1.88359987735748) - 0.0044407396071169*std::sin(0.309279918670654*x_35 - 1.13063991069794) - 0.0953239418162259*std::sin(0.321199834346771*x_35 + 1.9799998998642) + 0.133218449932726*std::sin(0.32287985086441*x_35 + 1.98631989955902) + 0.0489874037555588*std::sin(0.287839949131012*x_36 - 7.49151992797852) - 0.0109464567915648*std::sin(0.403199851512909*x_36 + 5.21271991729736) - 0.0672806615652616*std::sin(0.410559862852097*x_36 + 5.20024013519287) - 0.0406826421516756*std::sin(0.614959836006165*x_38 + 2.18871974945068) - 0.0457017757774073*std::sin(0.417519867420197*x_41 + 1.98311984539032) - 0.042690036728483*std::sin(0.271999955177307*x_43 - 1.33087992668152) + 0.102889718730383*std::sin(0.397759854793549*x_43 + 8.20655918121338) - 0.192431737508307*std::sin(0.434879869222641*x_43 - 4.36527967453003) + 0.00325061836957244*std::sin(0.438959866762161*x_45 + 5.22911977767944) - 0.00184593999014998*std::sin(0.594159841537476*x_46 + 2.18767976760864) - 0.0555336358896944*std::sin(0.153040036559105*x_49 + 1.74503993988037) + 0.0577968933644553*std::sin(0.412159860134125*x_51 + 1.99223983287811) - 0.0342456126999929*std::sin(0.232959985733032*x_53 + 5.03399991989136) - 0.101975345196298*std::sin(0.250639975070953*x_53 + 5.05167961120605) + 0.00369100257870244*std::sin(0.423519849777222*x_53 + 5.22088003158569) - 0.015607849843784*std::sin(0.30703991651535*x_55 + 5.13463973999023) + 0.0636480889923468*std::sin(0.153440043330193*x_56 + 1.72919988632202) + 0.0108663778216775*std::sin(0.72655987739563*x_57 + 2.35935997962952) - 0.0223651034642198*std::sin(0.447759836912155*x_58 + 5.23080015182495) - 0.0537649343652159*std::sin(0.490319848060608*x_58 + 5.28128004074097) + 0.0719703175188521*std::sin(0.537279844284058*x_58 + 8.55719947814941) - 0.017104982679563*std::sin(0.202960014343262*x_59 - 7.60008001327515) - 0.0150800339012099*std::sin(0.264799952507019*x_63 + 1.86583995819092) + 0.0143839270923631*std::sin(0.281759947538376*x_64 - 7.50191974639893) - 0.00396390449296925*std::sin(0.426319867372513*x_64 - 7.37799978256226) - 0.020022174702256*std::sin(0.530159831047058*x_64 + 8.52952003479004) + 0.0571381019150868*std::sin(0.235039979219437*x_66 + 5.03575992584229) - 0.159629512441881*std::sin(0.233679994940758*x_70 + 5.0449595451355) + 0.0025179644483838*std::sin(0.683279812335968*x_70 + 5.45639991760254) - 0.0157262033776946*std::sin(0.282959938049316*x_71 - 4.2960000038147) - 0.0126986061429643*std::sin(0.23463998734951*x_73 + 5.05839967727661) + 0.166848793426545*std::sin(0.25095996260643*x_73 - 7.52400016784668) + 0.120916404556387*std::sin(0.186240002512932*x_75 - 4.40799999237061) + 0.0135694115650578*std::sin(0.468879848718643*x_75 + 5.25735998153687) + 0.00669284832997497*std::sin(0.317759931087494*x_76 + 5.14647960662842) - 0.110327268344988*std::sin(0.282799959182739*x_78 + 5.10743999481201) - 0.0285505953441147*std::sin(0.336639851331711*x_79 + 8.31711959838867) + 0.00925663680458564*std::sin(0.376399844884872*x_81 - 7.40743970870972) - 0.12549909786828*std::sin(0.266319960355759*x_84 - 7.53360033035278) - 0.0127539469579014*std::sin(0.277999937534332*x_84 - 7.50880002975464) - 0.00986019453242005*std::sin(0.282879948616028*x_84 - 7.50984001159668) + 0.0149252299174565*std::sin(0.172720015048981*x_85 + 4.94823980331421) + 0.665927970747734*std::sin(0.125600054860115*x_86 + 4.900559425354) + 0.00628147623666023*std::sin(0.254159986972809*x_86 - 4.33599996566772) + 0.0163201282470017*std::sin(0.30895984172821*x_87 - 4.30751991271973) + 0.00425164435131174*std::sin(0.346319854259491*x_87 + 5.14383983612061) - 0.00572961897910906*std::sin(0.510159850120544*x_87 + 5.31903982162476) + 0.0448839100652602*std::sin(1.01335978507996*x_87 - 6.99656009674072) + 0.011474819437865*std::sin(0.336639851331711*x_92 + 8.38432025909424) + 0.0787241832536888*std::sin(0.348559856414795*x_92 + 1.99535977840424) - 0.0165129004764993*std::sin(0.375519841909409*x_92 - 1.20735991001129) - 0.0057066244523252*std::sin(0.364159852266312*x_95 - 7.40639972686768) + 0.00547874083743679*std::sin(0.377039849758148*x_95 - 1.2163999080658) - 0.0333755388238288*std::sin(0.396079838275909*x_95 + 8.39648056030273) + 0.0801581522493243*std::sin(0.428159862756729*x_95 - 1.16703987121582) - 0.00219421771923402*std::sin(0.407679855823517*x_96 + 5.20000028610229) + 0.00323989463987626*std::sin(0.400159865617752*x_97 + 5.19280004501343) + 0.0572249170966003*std::sin(0.439679861068726*x_98 + 2.02647995948792) + 0.022205258279842*std::sin(0.441519856452942*x_98 + 1.99927973747253) - 0.325979367672194*std::sin(0.164400026202202*x_99 - 1.41487991809845) + 0.342800668348544);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00617527677885876*x_10 + 0.00557183637361639*x_100 + 0.0320273562451296*x_101 - 7.12592227960671e-5*x_102 - 0.00416632247516204*x_103 + 0.00561482178431594*x_104 - 0.0113173239151566*x_105 + 0.00343155056566718*x_106 - 0.0166697351773769*x_107 - 0.010962557935755*x_108 - 0.00518567609285948*x_11 + 0.0137723285801066*x_110 - 0.00450896366423523*x_111 + 0.00239866281062001*x_112 - 0.00975189030072448*x_113 - 0.00736158907410156*x_114 + 8.71676613712455e-5*x_115 + 0.0055292981213102*x_116 - 0.00456595974575824*x_117 - 0.0157781533848843*x_118 + 0.00827912641035069*x_119 - 0.0792144119570728*x_12 + 0.0150233410982182*x_120 - 0.0114271862468325*x_13 - 0.0135232225822146*x_14 - 0.00845654738801276*x_15 - 0.0123217200439315*x_16 + 0.00851546712466893*x_17 + 0.00935258143022685*x_18 + 0.00786401897349211*x_19 - 0.0138164475655018*x_2 - 0.0105319999541148*x_20 - 0.0250030776019964*x_21 + 0.0110800433089787*x_22 + 0.00493010452810987*x_23 - 8.37663828267401e-5*x_24 - 0.00618070798269271*x_25 + 7.76242850063883e-5*x_26 + 0.0171588257792899*x_27 - 0.00112308867528069*x_28 - 0.00171929103220309*x_29 - 0.0213155004955937*x_3 + 0.0253083204907578*x_30 - 0.077510206242656*x_31 - 0.0700364369308023*x_32 - 0.00258220569645057*x_33 + 0.00180945677201997*x_34 + 4.16531135834149e-5*x_35 - 0.00208809428387553*x_36 - 0.0204922530541994*x_37 - 0.00384329821953417*x_38 - 0.0032168778121582*x_39 - 0.00339381452596737*x_4 - 0.00635709002962761*x_40 - 0.00871860855405218*x_41 + 0.0222461614585754*x_42 - 0.000130353061001557*x_43 - 0.0287977533332821*x_44 - 0.00293842003880981*x_45 - 0.0166152454363385*x_46 - 0.0125348154966605*x_47 + 0.0160588943627148*x_48 - 0.00780261102021774*x_49 + 0.00551883888185069*x_5 - 0.0072006991179674*x_50 - 0.0133140727790965*x_51 + 0.00176523319400483*x_52 - 0.00121920516046741*x_53 - 0.000323082024620424*x_54 - 0.00774049638608271*x_55 - 0.0137276575771183*x_56 - 0.00623443433557535*x_57 + 0.000814156321281203*x_58 + 0.00490624200660824*x_59 + 0.00233383862547916*x_6 - 0.00730322859874753*x_60 + 0.00612164979986487*x_61 - 0.00174705134148509*x_62 + 0.00334805995586956*x_63 - 0.00149534242762354*x_64 - 0.00752226149507466*x_65 - 7.18253448797086e-5*x_66 - 0.00424762126604228*x_67 - 0.00377646246629306*x_68 + 0.00779043504034375*x_69 - 0.0124924813494611*x_7 + 0.0108728228852348*x_71 - 0.00963046741036896*x_72 - 0.00850376388417712*x_73 - 0.00310802115889497*x_74 - 0.000180364427234393*x_75 - 0.00857335490635507*x_76 + 0.000125733467125073*x_77 + 0.00143901728499275*x_78 + 0.0270737338665126*x_79 - 0.00700024225005827*x_8 - 0.0013055995167311*x_80 - 0.000730799176224852*x_81 - 0.00357289104318536*x_82 + 0.00379986336449853*x_83 + 0.0181694572527439*x_84 - 0.0158104327445746*x_85 - 0.00710115247601958*x_86 - 0.00260151372053195*x_87 + 0.00326817840373739*x_88 + 0.00521275116124224*x_89 + 0.0439932298621706*x_9 + 0.00363864602702199*x_90 + 0.00311271699338092*x_91 - 0.00373551913934974*x_92 + 0.022353765331895*x_93 - 0.0191293650331708*x_94 - 0.000527026178510315*x_96 - 0.0047671266524875*x_97 + 0.00393750044530149*x_98 - 0.00102041320989171*x_99 + 3.05560812250099e-6*std::pow(-5.44952011108398*x_114 - 6.8145604133606, 2) + 8.37402308114526e-7*std::pow(-7.48392009735107*x_15 - 9.32503986358643, 2) + 1.24877778082155e-5*std::pow(-4.71783971786499*x_15 - 6.56799983978271, 2) + 8.03462039962649e-7*std::pow(-7.35176038742065*x_23 - 9.59408092498779, 2) - 2.16409534943795e-6*std::pow(-4.51768016815186*x_24 - 6.28480005264282, 2) - 5.52232021898952e-7*std::pow(-9.80399990081787*x_40 - 9.97720050811768, 2) + 1.64324980508064e-6*std::pow(-6.20391988754272*x_50 - 5.59935998916626, 2) - 5.0841501381274e-5*std::pow(-7.59695959091187*x_56 - 6.57599973678589, 2) + 0.000323885973594807*std::pow(-5.23920011520386*x_59 - 6.44536018371582, 2) + 9.37437205310427e-6*std::pow(-5.33192014694214*x_7 - 7.97664022445679, 2) + 4.98294660038767e-6*std::pow(-7.07024002075195*x_70 - 9.68871974945068, 2) + 0.000702075117266838*std::pow(-3.4670398235321*x_70 - 4.69191980361938, 2) + 9.68884086390939e-5*std::pow(-5.50519990921021*x_77 - 7.96400022506714, 2) + 8.71003922674188e-5*std::pow(-7.53200006484985*x_81 - 9.99948024749756, 2) + 7.7321285948343e-5*std::pow(-8.54800033569336*x_88 - 8.59800052642822, 2) + 0.000161392060142323*std::exp(0.617359817028046*x_1) - 0.000355721635788175*std::exp(1.14975988864899*x_1) - 5.09086660861343e-5*std::exp(1.20047986507416*x_1) - 9.50397655638423e-7*std::exp(1.31991982460022*x_1) - 0.000159376673234443*std::exp(1.33495986461639*x_100) - 0.00289275358657379*std::exp(1.60943984985352*x_100) - 0.00166602828495909*std::exp(0.885279893875122*x_104) - 2.28491764713379e-5*std::exp(1.19487988948822*x_106) - 0.000546395739173286*std::exp(0.567839860916138*x_109) + 0.000367096403333089*std::exp(0.605279862880707*x_109) + 0.0110927448489951*std::exp(0.867999851703644*x_109) - 0.00599339957807396*std::exp(0.886719882488251*x_109) - 7.02091618717456e-5*std::exp(1.18495988845825*x_110) + 0.0237136034125859*std::exp(0.60511988401413*x_26) - 0.00970078791347679*std::exp(0.78143984079361*x_26) + 1.45940114332026e-5*std::exp(1.22703981399536*x_26) - 0.0056717264453217*std::exp(0.628879845142365*x_31) - 0.000661998788072559*std::exp(0.654159843921661*x_31) + 0.000231230532707216*std::exp(0.657919824123383*x_31) - 0.00239326464331337*std::exp(0.81335985660553*x_49) + 0.000467256887062385*std::exp(0.863999843597412*x_50) + 0.000128083091418847*std::exp(1.11055994033813*x_66) - 0.000614032478029151*std::exp(1.48999989032745*x_66) - 0.000203232327042998*std::exp(1.17007982730865*x_68) - 0.000476257093653398*std::exp(0.887999892234802*x_72) + 0.000732581419243983*std::exp(0.634559869766235*x_74) + 0.00361809542947035*std::exp(1.17399990558624*x_74) + 0.000118689216480404*std::exp(0.905119836330414*x_77) - 0.000458216174162986*std::exp(0.957039833068848*x_81) - 0.0185889425746507*std::sin(0.528159856796265*x_10 - 4.05343961715698) - 0.000666680109002713*std::sin(0.329999834299088*x_100 - 7.44367980957031) - 0.0929888974707554*std::sin(0.360319852828979*x_102 - 4.23464012145996) - 0.00350540416533054*std::sin(0.372879832983017*x_102 + 1.99031984806061) - 0.00796870602373245*std::sin(0.394319832324982*x_102 - 7.41599988937378) + 0.000999324412782845*std::sin(0.302079916000366*x_105 + 1.87591981887817) + 0.142202944521133*std::sin(0.202159985899925*x_108 + 4.98984003067017) - 0.00104578092472364*std::sin(0.260319977998734*x_111 + 5.06303977966309) - 0.154516233315512*std::sin(0.310319930315018*x_111 - 7.49119997024536) - 0.00264617985637102*std::sin(0.407119870185852*x_111 + 1.97735977172852) + 0.00120056114672994*std::sin(0.495199859142303*x_112 - 7.34656000137329) + 0.282035587724128*std::sin(0.157280027866364*x_114 - 7.63944053649902) + 0.0213744034577622*std::sin(0.154240027070045*x_115 - 7.65759992599487) - 0.03763341131803*std::sin(0.433519870042801*x_115 - 4.18584012985229) - 0.101223752418777*std::sin(0.438559859991074*x_115 - 7.3557596206665) - 0.0581799287228223*std::sin(0.416879862546921*x_117 + 5.20480012893677) + 0.0006453760943922*std::sin(0.526559829711914*x_118 - 4.02767992019653) - 0.00119843196168565*std::sin(0.598879814147949*x_120 - 4.00255966186523) - 0.060757176682072*std::sin(0.452239871025085*x_2 - 4.13647985458374) - 0.0854993112571636*std::sin(0.315839856863022*x_24 + 5.1191201210022) - 0.0578755211841464*std::sin(0.384239852428436*x_24 + 5.1701602935791) + 0.127928739553957*std::sin(0.343279838562012*x_28 - 4.25920009613037) + 0.00157097887633127*std::sin(0.348079830408096*x_28 + 8.34904003143311) - 0.000735080768339444*std::sin(0.367599844932556*x_28 + 5.1799201965332) - 0.0861553268888342*std::sin(0.281519949436188*x_3 + 1.88359987735748) - 0.00227873401448793*std::sin(0.309279918670654*x_35 - 1.13063991069794) + 0.0681934930958918*std::sin(0.321199834346771*x_35 + 1.9799998998642) - 0.0470712895684362*std::sin(0.32287985086441*x_35 + 1.98631989955902) + 0.00116079945397723*std::sin(0.403199851512909*x_36 + 5.21271991729736) + 0.0481316995764093*std::sin(0.410559862852097*x_36 + 5.20024013519287) + 0.0291038266340418*std::sin(0.614959836006165*x_38 + 2.18871974945068) + 0.0326944487561689*std::sin(0.417519867420197*x_41 + 1.98311984539032) - 0.0736059503016092*std::sin(0.397759854793549*x_43 + 8.20655918121338) + 0.0679936603599954*std::sin(0.434879869222641*x_43 - 4.36527967453003) + 0.00166803174745775*std::sin(0.438959866762161*x_45 + 5.22911977767944) - 0.00094723100573538*std::sin(0.594159841537476*x_46 + 2.18767976760864) + 0.00588897535025235*std::sin(0.153040036559105*x_49 + 1.74503993988037) - 0.0413471366533657*std::sin(0.412159860134125*x_51 + 1.99223983287811) + 0.003631521073915*std::sin(0.232959985733032*x_53 + 5.03399991989136) + 0.0729518195124745*std::sin(0.250639975070953*x_53 + 5.05167961120605) + 0.00189401177906771*std::sin(0.423519849777222*x_53 + 5.22088003158569) + 0.00165510940402051*std::sin(0.30703991651535*x_55 + 5.13463973999023) - 0.00674945951515045*std::sin(0.153440043330193*x_56 + 1.72919988632202) + 0.0384627262635013*std::sin(0.490319848060608*x_58 + 5.28128004074097) - 0.0254299284969384*std::sin(0.537279844284058*x_58 + 8.55719947814941) - 0.00877730047190339*std::sin(0.202960014343262*x_59 - 7.60008001327515) - 0.00773821237688562*std::sin(0.264799952507019*x_63 + 1.86583995819092) - 0.00152532047883565*std::sin(0.281759947538376*x_64 - 7.50191974639893) - 0.00203404945965182*std::sin(0.426319867372513*x_64 - 7.37799978256226) + 0.0143236002027208*std::sin(0.530159831047058*x_64 + 8.52952003479004) - 0.0408758459230605*std::sin(0.235039979219437*x_66 + 5.03575992584229) + 0.114196851779298*std::sin(0.233679994940758*x_70 + 5.0449595451355) - 0.000267013501489387*std::sin(0.683279812335968*x_70 + 5.45639991760254) + 0.00166766001470264*std::sin(0.282959938049316*x_71 - 4.2960000038147) - 0.00651619962318506*std::sin(0.23463998734951*x_73 + 5.05839967727661) - 0.119361430358456*std::sin(0.25095996260643*x_73 - 7.52400016784668) - 0.0865020040316091*std::sin(0.186240002512932*x_75 - 4.40799999237061) - 0.000709732366821573*std::sin(0.317759931087494*x_76 + 5.14647960662842) + 0.0789266753852586*std::sin(0.282799959182739*x_78 + 5.10743999481201) - 0.000981605203677283*std::sin(0.376399844884872*x_81 - 7.40743970870972) + 0.0897804024986768*std::sin(0.266319960355759*x_84 - 7.53360033035278) + 0.00135247184972171*std::sin(0.277999937534332*x_84 - 7.50880002975464) - 0.00505968884878641*std::sin(0.282879948616028*x_84 - 7.50984001159668) + 0.00765877581123071*std::sin(0.172720015048981*x_85 + 4.94823980331421) - 0.476396103752152*std::sin(0.125600054860115*x_86 + 4.900559425354) + 0.00322329495265506*std::sin(0.254159986972809*x_86 - 4.33599996566772) - 0.00173064182490139*std::sin(0.30895984172821*x_87 - 4.30751991271973) + 0.0021817011259369*std::sin(0.346319854259491*x_87 + 5.14383983612061) - 0.0158592411840284*std::sin(1.01335978507996*x_87 - 6.99656009674072) - 0.00121682882338924*std::sin(0.336639851331711*x_92 + 8.38432025909424) - 0.0563182443455809*std::sin(0.348559856414795*x_92 + 1.99535977840424) - 0.00292831383911398*std::sin(0.364159852266312*x_95 - 7.40639972686768) - 0.000580984285022721*std::sin(0.377039849758148*x_95 - 1.2163999080658) + 0.0238764211066964*std::sin(0.396079838275909*x_95 + 8.39648056030273) - 0.028323010796959*std::sin(0.428159862756729*x_95 - 1.16703987121582) - 0.00112594725076819*std::sin(0.407679855823517*x_96 + 5.20000028610229) + 0.00166252894166798*std::sin(0.400159865617752*x_97 + 5.19280004501343) - 0.0409379523610483*std::sin(0.439679861068726*x_98 + 2.02647995948792) + 0.233201348320376*std::sin(0.164400026202202*x_99 - 1.41487991809845) - 1.95284104347229*std::sin(-0.023564367095725*x_1 + 0.00655347696697031*x_10 + 0.00499002948478581*x_101 + 0.00521083541232236*x_103 + 0.00103121160935549*x_104 - 0.00601707604179098*x_105 + 0.00132969629957399*x_106 + 0.00158265139815415*x_107 + 0.00331852113174573*x_108 + 0.00447563610933056*x_11 - 0.0058023269150871*x_111 + 0.00345484000733121*x_113 + 0.00450044591576329*x_116 - 0.00714882788436281*x_117 - 0.00438487483691625*x_118 + 0.00819804253053256*x_119 + 0.00187105567742817*x_12 - 0.00069559073260593*x_13 + 0.00236630370399185*x_14 - 0.000340714558693645*x_15 + 0.00954357037357572*x_16 + 0.00259661229305553*x_17 + 0.0050147214817863*x_18 + 0.000709410227413855*x_19 - 0.0041408257349862*x_2 + 0.00042864734120901*x_20 - 0.00624900402909761*x_21 + 0.0116558309445018*x_22 - 0.000632572968560372*x_23 + 0.00128657316431654*x_24 - 0.00244499261712844*x_25 - 0.00502208383879291*x_26 - 0.00320498580480975*x_27 - 0.00791926912696854*x_29 + 0.00166891030381662*x_3 - 0.00230392223629897*x_30 + 0.0115518137604376*x_32 + 0.00687773809988578*x_33 - 0.00100984995545259*x_34 + 0.00212666674162998*x_35 + 0.000381870583251771*x_37 + 0.00519897363611175*x_38 + 0.00450153840451298*x_39 - 0.00498025922538741*x_4 - 0.000439836419677369*x_40 + 0.00923819814408087*x_41 - 0.00688955220548453*x_42 - 0.000581862679482826*x_44 + 0.00200037413994324*x_45 - 0.00513557048431151*x_46 - 0.00394524368240025*x_47 + 0.00319612051305128*x_48 + 0.000867087242655784*x_49 + 0.00667213992338607*x_5 - 0.00151925351761102*x_50 + 0.00136915113416482*x_51 + 0.00229472267947757*x_52 + 0.00648672942969116*x_53 + 0.00891003038663843*x_54 + 0.000205929252551369*x_55 - 0.000404645033958943*x_56 - 0.0055070067873441*x_6 + 0.00719409484218535*x_60 - 0.00372024538631249*x_61 + 0.00471912249439044*x_62 + 1.72955831513703e-5*x_63 - 0.00171069664232646*x_64 - 0.00176661081406907*x_65 - 0.00101051815695078*x_69 + 0.00297287602123978*x_7 - 6.74810094203322e-5*x_70 - 0.0043958386423416*x_71 + 0.00187260434441437*x_72 - 0.0044196437528927*x_73 + 0.000240542863793453*x_76 + 0.000893476500547312*x_77 + 0.000524922757870695*x_78 - 0.00712219111169567*x_8 + 0.00221365968210191*x_80 + 0.00020249570944031*x_81 + 0.00598035932472772*x_82 + 0.00206874244332282*x_83 - 0.000364546276022677*x_85 - 0.000165009820945513*x_86 + 0.00257510961627796*x_88 - 0.00521493079483885*x_89 + 0.0037205741295336*x_9 + 0.0200009324261843*x_91 - 0.00345344209152323*x_93 - 0.000625092635041027*x_94 - 5.13258965486972e-5*x_95 + 0.000782357598571986*x_96 + 0.00350525319786035*x_97 + 0.00214198555607707*x_99 - 7.75841373287138e-5*std::pow(-5.34607982635498*x_59 - 6.13520002365112, 2) - 1.91905841591304e-5*std::pow(-5.6637601852417*x_67 - 8.90248012542725, 2) + 5.1841130870243e-5*std::pow(-7.6625599861145*x_84 - 7.4585599899292, 2) + 9.67136345343357e-5*std::pow(-5.06239986419678*x_90 - 7.8996000289917, 2) + 0.000743066491112937*std::exp(1.53511989116669*x_100) + 0.00253614520131582*std::exp(0.871279835700989*x_109) - 9.67474899839005e-5*std::exp(1.75111997127533*x_110) - 0.00309031592448732*std::exp(0.616399824619293*x_112) + 0.00571167943540624*std::exp(0.721439838409424*x_114) - 0.0028639342023091*std::exp(0.598719835281372*x_31) + 0.00402018556539242*std::exp(1.00015985965729*x_66) + 0.00583068422275905*std::exp(1.06511986255646*x_68) + 0.00393170785116751*std::exp(1.08279979228973*x_74) + 0.0187827618459144*std::sin(0.344559848308563*x_102 - 7.43680000305176) + 0.0114064643293432*std::sin(0.424319863319397*x_115 - 4.16856002807617) + 0.0768124009678655*std::sin(0.26623997092247*x_120 + 5.06559944152832) + 0.0354144697052501*std::sin(0.278319954872131*x_28 - 4.29287958145142) + 0.0767070973785584*std::sin(0.287839949131012*x_36 - 7.49151992797852) - 0.0668463432103072*std::sin(0.271999955177307*x_43 - 1.33087992668152) + 0.0170151556893856*std::sin(0.72655987739563*x_57 + 2.35935997962952) - 0.0350204754240884*std::sin(0.447759836912155*x_58 + 5.23080015182495) + 0.0212477105233917*std::sin(0.468879848718643*x_75 + 5.25735998153687) - 0.0447060495021296*std::sin(0.336639851331711*x_79 + 8.31711959838867) - 0.00897174390309841*std::sin(0.510159850120544*x_87 + 5.31903982162476) - 0.0258567829226823*std::sin(0.375519841909409*x_92 - 1.20735991001129) + 0.0347701812834815*std::sin(0.441519856452942*x_98 + 1.99927973747253) + 1.26511762863193) + 2.11950235736877);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00183014448173876*x_1 - 0.00673605123488733*x_10 - 0.00435064278576244*x_100 + 0.0490796732039326*x_101 - 0.000472399765982699*x_102 - 0.0391796127285939*x_103 + 0.0130971470933125*x_104 - 0.019988624149868*x_105 + 0.0239419407794124*x_106 - 0.0262603695285501*x_107 - 0.0273388039133983*x_108 - 0.0172993440917066*x_11 + 0.0347451855496929*x_110 + 0.00397136472894199*x_111 - 0.00251131615736527*x_112 + 0.0105761246548003*x_113 - 0.0113992357067842*x_114 + 0.0005778618011437*x_115 + 0.0270501487455366*x_116 + 0.00267127885064261*x_117 - 0.0389623936710048*x_118 + 0.0042836382681513*x_119 - 0.119095028582586*x_12 - 0.00329698225605761*x_120 + 0.00792921003200111*x_13 - 0.0288288398808624*x_14 - 0.00791700816583579*x_15 - 0.0306741473958623*x_16 + 0.00496639985369735*x_17 + 0.0340969347254763*x_18 - 0.0158266341315784*x_19 - 0.0310938636465233*x_2 - 0.00681110552268975*x_20 - 0.0613516346444075*x_21 + 0.0092741183083127*x_22 + 0.0101823514552798*x_23 - 0.00136125624869332*x_24 - 0.0216077188157926*x_25 + 0.000904639720863291*x_26 + 0.0172196217805887*x_27 + 0.000876938466107553*x_28 + 0.00907873658453898*x_29 - 0.0404663227872241*x_3 + 0.0147546542249475*x_30 + 0.0605220966662557*x_31 - 0.0742240955733647*x_32 - 0.00758403437652074*x_33 - 0.00598194680412294*x_34 + 0.000110962381618036*x_35 - 0.00465658459393489*x_36 - 0.0417023460008097*x_37 - 0.00825536257971176*x_38 + 0.0116943137759283*x_39 - 0.0164463170183581*x_4 - 0.00352841777319476*x_40 - 0.0109392685660339*x_41 + 0.00520017638948068*x_42 - 0.0012826691893954*x_43 - 0.0478253565047969*x_44 - 0.0180510169013847*x_45 - 0.0166228112526031*x_46 + 0.0023141172085651*x_47 + 0.0135020278875975*x_48 - 0.0140285519151273*x_49 + 0.0259420533944216*x_5 + 0.00233869853137327*x_50 - 0.0246381493723035*x_51 + 0.000280443138533253*x_52 - 0.00279394868232212*x_53 + 0.00278233451752191*x_54 - 0.0435499709990522*x_55 - 0.0259649680339663*x_56 - 0.0261367446320713*x_57 + 0.0115285889981492*x_58 - 0.00414669175989841*x_59 + 0.00182003907424356*x_6 - 0.0168295581775167*x_60 - 0.0052161089032107*x_61 - 0.00601895693774371*x_62 + 0.0378849576689597*x_63 - 0.00267598490451532*x_64 - 0.0128158527473642*x_65 - 0.00108152835691964*x_66 + 0.00664644048751761*x_67 - 0.00562411938028473*x_68 + 0.0244667300466792*x_69 - 0.00554790660320465*x_7 + 5.24096388887046e-6*x_70 + 0.0220302675625453*x_71 - 0.0123369211770626*x_72 - 0.0148173085306746*x_73 - 0.00583275039775226*x_74 + 0.00173379301704919*x_75 - 0.036722635810749*x_76 - 5.81902399921921e-5*x_77 + 0.00828191615876571*x_78 + 0.0125298072145101*x_79 + 0.0420140621711439*x_8 + 0.0116903035184082*x_80 - 0.00138845831994219*x_81 + 0.0148357124514204*x_82 + 0.00562510359982671*x_83 + 0.0341294628593544*x_84 - 0.0261242113222964*x_85 - 0.0132206553666152*x_86 + 0.00203133332376526*x_87 + 0.00416944388792018*x_88 + 0.00617523061419067*x_89 + 0.0410640385661038*x_9 - 7.45802604771983e-5*x_90 + 0.00349100703851403*x_91 - 0.00763895838900314*x_92 - 0.0088983118850994*x_93 - 0.0188454059237504*x_94 + 3.98626476821157e-6*x_95 - 0.00356955256239663*x_96 - 0.0291271465222588*x_97 + 0.00775517023556323*x_98 + 0.000642995495307266*x_99 + 2.02565858195688e-5*std::pow(-5.44952011108398*x_114 - 6.8145604133606, 2) + 5.55140287621137e-6*std::pow(-7.48392009735107*x_15 - 9.32503986358643, 2) + 0.000188037883244643*std::pow(-4.71783971786499*x_15 - 6.56799983978271, 2) + 5.32640218011592e-6*std::pow(-7.35176038742065*x_23 - 9.59408092498779, 2) - 1.4346467678499e-5*std::pow(-4.51768016815186*x_24 - 6.28480005264282, 2) - 3.66091949472701e-6*std::pow(-9.80399990081787*x_40 - 9.97720050811768, 2) + 1.08936189999262e-5*std::pow(-6.20391988754272*x_50 - 5.59935998916626, 2) + 3.96984398625127e-5*std::pow(-7.59695959091187*x_56 - 6.57599973678589, 2) + 6.02563099725124e-6*std::pow(-5.34607982635498*x_59 - 6.13520002365112, 2) + 0.000608386599153943*std::pow(-5.23920011520386*x_59 - 6.44536018371582, 2) + 1.49045130546059e-6*std::pow(-5.6637601852417*x_67 - 8.90248012542725, 2) + 0.000141156986029475*std::pow(-5.33192014694214*x_7 - 7.97664022445679, 2) + 7.50319829074442e-5*std::pow(-7.07024002075195*x_70 - 9.68871974945068, 2) + 0.00131877613656384*std::pow(-3.4670398235321*x_70 - 4.69191980361938, 2) - 7.56531290232571e-5*std::pow(-5.50519990921021*x_77 - 7.96400022506714, 2) - 6.80103771621299e-5*std::pow(-7.53200006484985*x_81 - 9.99948024749756, 2) - 4.02628083342346e-6*std::pow(-7.6625599861145*x_84 - 7.4585599899292, 2) - 6.03745825146505e-5*std::pow(-8.54800033569336*x_88 - 8.59800052642822, 2) - 7.51133793803545e-6*std::pow(-5.06239986419678*x_90 - 7.8996000289917, 2) + 0.00243020190042853*std::exp(0.617359817028046*x_1) + 0.000277757217675967*std::exp(1.14975988864899*x_1) - 9.5626710486556e-5*std::exp(1.20047986507416*x_1) - 6.30048451972278e-6*std::exp(1.31991982460022*x_1) - 0.00239985470063871*std::exp(1.33495986461639*x_100) - 5.77108238363014e-5*std::exp(1.53511989116669*x_100) - 0.00543374107002148*std::exp(1.60943984985352*x_100) + 0.00130088061687442*std::exp(0.885279893875122*x_104) - 0.000344057272922255*std::exp(1.19487988948822*x_106) - 0.00822749249593821*std::exp(0.567839860916138*x_109) + 0.00243359733972867*std::exp(0.605279862880707*x_109) + 0.0208365840578368*std::exp(0.867999851703644*x_109) - 0.000196971644781346*std::exp(0.871279835700989*x_109) + 0.00467981090758685*std::exp(0.886719882488251*x_109) - 0.000465438582356873*std::exp(1.18495988845825*x_110) + 7.51396734725939e-6*std::exp(1.75111997127533*x_110) + 0.000240011735221012*std::exp(0.616399824619293*x_112) - 0.000443601924792025*std::exp(0.721439838409424*x_114) + 0.0445435730783366*std::exp(0.60511988401413*x_26) + 0.00757464148657088*std::exp(0.78143984079361*x_26) + 0.000219753030530552*std::exp(1.22703981399536*x_26) + 0.000222429626695545*std::exp(0.598719835281372*x_31) - 0.0106537567067278*std::exp(0.628879845142365*x_31) - 0.00996821474015889*std::exp(0.654159843921661*x_31) + 0.00153289981637258*std::exp(0.657919824123383*x_31) + 0.00186872672789808*std::exp(0.81335985660553*x_49) + 0.00703583914800991*std::exp(0.863999843597412*x_50) - 0.000312230767674789*std::exp(1.00015985965729*x_66) + 0.000849103035908262*std::exp(1.11055994033813*x_66) - 0.0011533970641951*std::exp(1.48999989032745*x_66) - 0.000452844522057188*std::exp(1.06511986255646*x_68) - 0.00306022233666803*std::exp(1.17007982730865*x_68) - 0.00717136204264575*std::exp(0.887999892234802*x_72) + 0.0110310306200651*std::exp(0.634559869766235*x_74) - 0.000305359078747699*std::exp(1.08279979228973*x_74) - 0.00282510822696837*std::exp(1.17399990558624*x_74) + 0.00178719299571919*std::exp(0.905119836330414*x_77) - 0.00689970631935667*std::exp(0.957039833068848*x_81) - 0.0349174230342187*std::sin(0.528159856796265*x_10 - 4.05343961715698) - 0.00441963180512802*std::sin(0.329999834299088*x_100 - 7.44367980957031) - 0.00145877747551938*std::sin(0.344559848308563*x_102 - 7.43680000305176) - 0.174670111408044*std::sin(0.360319852828979*x_102 - 4.23464012145996) - 0.0527835127505284*std::sin(0.372879832983017*x_102 + 1.99031984806061) + 0.00622218440192842*std::sin(0.394319832324982*x_102 - 7.41599988937378) + 0.00662483535766922*std::sin(0.302079916000366*x_105 + 1.87591981887817) - 0.111035962510417*std::sin(0.202159985899925*x_108 + 4.98984003067017) - 0.00693281016441123*std::sin(0.260319977998734*x_111 + 5.06303977966309) - 0.290242904493623*std::sin(0.310319930315018*x_111 - 7.49119997024536) - 0.0398455246816826*std::sin(0.407119870185852*x_111 + 1.97735977172852) + 0.0180777541211809*std::sin(0.495199859142303*x_112 - 7.34656000137329) - 0.220221128687569*std::sin(0.157280027866364*x_114 - 7.63944053649902) + 0.321850504032063*std::sin(0.154240027070045*x_115 - 7.65759992599487) - 0.000885891722179318*std::sin(0.424319863319397*x_115 - 4.16856002807617) + 0.0293852005830081*std::sin(0.433519870042801*x_115 - 4.18584012985229) - 0.190138442255307*std::sin(0.438559859991074*x_115 - 7.3557596206665) - 0.109285031956889*std::sin(0.416879862546921*x_117 + 5.20480012893677) + 0.00971791431189355*std::sin(0.526559829711914*x_118 - 4.02767992019653) - 0.00596569350618999*std::sin(0.26623997092247*x_120 + 5.06559944152832) - 0.0180456933770746*std::sin(0.598879814147949*x_120 - 4.00255966186523) + 0.0474408713196985*std::sin(0.452239871025085*x_2 - 4.13647985458374) - 0.160601691479313*std::sin(0.315839856863022*x_24 + 5.1191201210022) + 0.0451907956063362*std::sin(0.384239852428436*x_24 + 5.1701602935791) - 0.00275049170815737*std::sin(0.278319954872131*x_28 - 4.29287958145142) + 0.240301023003394*std::sin(0.343279838562012*x_28 - 4.25920009613037) + 0.0236554130818246*std::sin(0.348079830408096*x_28 + 8.34904003143311) - 0.00487308125624268*std::sin(0.367599844932556*x_28 + 5.1799201965332) + 0.0672724441727689*std::sin(0.281519949436188*x_3 + 1.88359987735748) - 0.0343126156745024*std::sin(0.309279918670654*x_35 - 1.13063991069794) - 0.0532473513002715*std::sin(0.321199834346771*x_35 + 1.9799998998642) - 0.0884185920757346*std::sin(0.32287985086441*x_35 + 1.98631989955902) - 0.00595751502288532*std::sin(0.287839949131012*x_36 - 7.49151992797852) + 0.00769530411496365*std::sin(0.403199851512909*x_36 + 5.21271991729736) - 0.0375825522300249*std::sin(0.410559862852097*x_36 + 5.20024013519287) - 0.0227250667272004*std::sin(0.614959836006165*x_38 + 2.18871974945068) - 0.0255287230416611*std::sin(0.417519867420197*x_41 + 1.98311984539032) + 0.0051916720552598*std::sin(0.271999955177307*x_43 - 1.33087992668152) + 0.0574735464568279*std::sin(0.397759854793549*x_43 + 8.20655918121338) + 0.127719120810698*std::sin(0.434879869222641*x_43 - 4.36527967453003) + 0.0251168113169398*std::sin(0.438959866762161*x_45 + 5.22911977767944) - 0.0142631712381202*std::sin(0.594159841537476*x_46 + 2.18767976760864) + 0.0390398669558691*std::sin(0.153040036559105*x_49 + 1.74503993988037) + 0.0322849792654885*std::sin(0.412159860134125*x_51 + 1.99223983287811) + 0.0240744936327507*std::sin(0.232959985733032*x_53 + 5.03399991989136) - 0.0569627831809769*std::sin(0.250639975070953*x_53 + 5.05167961120605) + 0.0285195629875805*std::sin(0.423519849777222*x_53 + 5.22088003158569) + 0.0109722400056573*std::sin(0.30703991651535*x_55 + 5.13463973999023) - 0.0447442867092672*std::sin(0.153440043330193*x_56 + 1.72919988632202) - 0.00132149499981709*std::sin(0.72655987739563*x_57 + 2.35935997962952) + 0.00271989184283632*std::sin(0.447759836912155*x_58 + 5.23080015182495) - 0.0300327524568794*std::sin(0.490319848060608*x_58 + 5.28128004074097) - 0.0477675138051374*std::sin(0.537279844284058*x_58 + 8.55719947814941) - 0.132166429182709*std::sin(0.202960014343262*x_59 - 7.60008001327515) - 0.116520096513072*std::sin(0.264799952507019*x_63 + 1.86583995819092) - 0.0101118284620184*std::sin(0.281759947538376*x_64 - 7.50191974639893) - 0.0306282158989257*std::sin(0.426319867372513*x_64 - 7.37799978256226) - 0.0111842602168279*std::sin(0.530159831047058*x_64 + 8.52952003479004) + 0.0319169825264765*std::sin(0.235039979219437*x_66 + 5.03575992584229) - 0.0891680365387182*std::sin(0.233679994940758*x_70 + 5.0449595451355) - 0.00177011635362334*std::sin(0.683279812335968*x_70 + 5.45639991760254) + 0.0110554419452314*std::sin(0.282959938049316*x_71 - 4.2960000038147) - 0.098119329376373*std::sin(0.23463998734951*x_73 + 5.05839967727661) + 0.093200681259463*std::sin(0.25095996260643*x_73 - 7.52400016784668) + 0.0675431392020314*std::sin(0.186240002512932*x_75 - 4.40799999237061) - 0.0016502195881604*std::sin(0.468879848718643*x_75 + 5.25735998153687) - 0.00470503874223229*std::sin(0.317759931087494*x_76 + 5.14647960662842) - 0.0616281146544543*std::sin(0.282799959182739*x_78 + 5.10743999481201) + 0.00347212931560151*std::sin(0.336639851331711*x_79 + 8.31711959838867) - 0.00650736915601248*std::sin(0.376399844884872*x_81 - 7.40743970870972) - 0.0701030027161758*std::sin(0.266319960355759*x_84 - 7.53360033035278) + 0.00896596061867219*std::sin(0.277999937534332*x_84 - 7.50880002975464) - 0.0761875487868146*std::sin(0.282879948616028*x_84 - 7.50984001159668) + 0.115323960267907*std::sin(0.172720015048981*x_85 + 4.94823980331421) + 0.371983154740311*std::sin(0.125600054860115*x_86 + 4.900559425354) + 0.0485355816926574*std::sin(0.254159986972809*x_86 - 4.33599996566772) - 0.0114729681436887*std::sin(0.30895984172821*x_87 - 4.30751991271973) + 0.0328515183320877*std::sin(0.346319854259491*x_87 + 5.14383983612061) + 0.000696797309646721*std::sin(0.510159850120544*x_87 + 5.31903982162476) - 0.0297899587994628*std::sin(1.01335978507996*x_87 - 6.99656009674072) - 0.00806674040011852*std::sin(0.336639851331711*x_92 + 8.38432025909424) + 0.0439748311040007*std::sin(0.348559856414795*x_92 + 1.99535977840424) + 0.00200818669940213*std::sin(0.375519841909409*x_92 - 1.20735991001129) - 0.0440938287211303*std::sin(0.364159852266312*x_95 - 7.40639972686768) - 0.00385152727626306*std::sin(0.377039849758148*x_95 - 1.2163999080658) - 0.0186433650007301*std::sin(0.396079838275909*x_95 + 8.39648056030273) - 0.0532018723296716*std::sin(0.428159862756729*x_95 - 1.16703987121582) - 0.0169542364487209*std::sin(0.407679855823517*x_96 + 5.20000028610229) + 0.025033951422369*std::sin(0.400159865617752*x_97 + 5.19280004501343) + 0.0319654769380605*std::sin(0.439679861068726*x_98 + 2.02647995948792) - 0.0027004525581578*std::sin(0.441519856452942*x_98 + 1.99927973747253) - 0.182090014075846*std::sin(0.164400026202202*x_99 - 1.41487991809845) - 0.92310602109485);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00265832081311169*x_10 - 0.00269758824908837*x_100 - 0.0302095231286258*x_101 - 0.000575647155241788*x_102 + 0.0113153275194597*x_103 - 0.008711178191981*x_104 + 0.0146959304739776*x_105 + 8.06328668091715e-5*x_106 + 0.00915035393193749*x_107 + 0.0165500526688248*x_108 + 0.0139666733882791*x_11 - 0.00285907983654239*x_110 + 0.00218300154214916*x_111 + 1.05977328716091e-5*x_112 - 0.0121115160969005*x_113 - 0.00240954614057469*x_114 + 0.000704158905030976*x_115 - 0.0354286106699227*x_116 + 0.00397064361111571*x_117 + 0.00612259718530911*x_118 - 0.00833495051728572*x_119 + 0.0353647943400682*x_12 - 0.00818642723931369*x_120 + 0.00754620814287788*x_13 + 0.0126367779666343*x_14 + 0.00334433006767109*x_15 + 0.0140442553347701*x_16 - 0.0122695385995897*x_17 - 0.00970613214511031*x_18 + 0.00485319687028483*x_19 + 0.0184574189733537*x_2 + 0.0148489369646842*x_20 + 0.00609517312483382*x_21 - 0.0179509209051162*x_22 + 0.00880738615778128*x_23 + 0.00228566947801419*x_24 - 0.0193678330118847*x_25 + 0.000627065481327021*x_26 - 0.0107119649401178*x_27 + 0.000543740090334892*x_28 + 0.0101634582020564*x_29 + 0.00429780774445863*x_3 - 0.0255473486172668*x_30 + 0.0375263391679421*x_31 + 0.0319169329353859*x_32 + 0.0237390227788896*x_33 - 0.00127923668365982*x_34 + 0.000336482709190861*x_35 + 0.00222566855778606*x_36 + 0.00216353753544596*x_37 + 0.00291536892436215*x_38 - 0.00335469654465286*x_39 - 0.0170582527764504*x_4 + 0.0154219398029621*x_40 - 0.0107385555033743*x_41 - 0.01444912241531*x_42 + 0.000703017326034498*x_43 + 0.0126361065718884*x_44 + 0.0021187450814657*x_45 + 0.00617819227081001*x_46 + 0.00242275596349658*x_47 + 0.0046787346491539*x_48 + 0.00128698529714884*x_49 - 0.0104312422051966*x_5 + 0.00331083307874465*x_50 + 0.00323810839529937*x_51 + 0.000106254394970965*x_52 + 0.000423140764889638*x_53 - 0.0191293416673797*x_54 + 0.00788754766987087*x_55 + 0.00519442116256331*x_56 - 0.0149354732131077*x_57 - 0.0191490366989017*x_58 - 0.00274020470650058*x_59 - 0.00349373253813642*x_6 + 0.000323999292347776*x_60 - 0.0106494400320051*x_61 + 0.0148060335552503*x_62 + 0.000664101594745666*x_63 + 0.00051897773985305*x_64 + 0.00793811534616863*x_65 + 0.00195984347180127*x_66 + 0.00865507205186541*x_67 + 0.000287039897222015*x_68 - 0.0138161786976629*x_69 + 0.00687663217329687*x_7 + 0.000505993661622587*x_71 + 0.00345816507534723*x_72 + 0.00439291077484082*x_73 + 0.00108816400096783*x_74 + 0.00059753037734993*x_75 - 0.00543763352429734*x_76 - 0.00044260832076229*x_77 - 0.0153243407781117*x_78 - 0.0146611475552036*x_79 + 0.00865508033750006*x_8 + 0.0132209391028125*x_80 + 0.000253633213207489*x_81 + 0.00118357357876635*x_82 - 0.00796660112408269*x_83 - 0.0063059428296778*x_84 + 0.00584548701904974*x_85 + 0.00265131329036584*x_86 + 0.00125951524269085*x_87 + 0.00586640304467224*x_88 + 0.000743208888112063*x_89 - 0.0112101050736844*x_9 + 0.0158178331743525*x_90 - 0.0045851245940918*x_91 + 0.00256819938534867*x_92 - 0.0489988442107539*x_93 + 0.0158629255374432*x_94 - 0.000169965601287035*x_96 + 0.00252290305390334*x_97 + 0.00266022907947016*x_98 - 0.00334256678004442*x_99 + 2.46838521981252e-5*std::pow(-5.44952011108398*x_114 - 6.8145604133606, 2) + 6.7647139211521e-6*std::pow(-7.48392009735107*x_15 - 9.32503986358643, 2) - 0.000340744480318537*std::pow(-4.71783971786499*x_15 - 6.56799983978271, 2) + 6.49053721751775e-6*std::pow(-7.35176038742065*x_23 - 9.59408092498779, 2) - 1.74820224343605e-5*std::pow(-4.51768016815186*x_24 - 6.28480005264282, 2) - 4.46104770675519e-6*std::pow(-9.80399990081787*x_40 - 9.97720050811768, 2) + 1.32745213676187e-5*std::pow(-6.20391988754272*x_50 - 5.59935998916626, 2) + 2.46147638759748e-5*std::pow(-7.59695959091187*x_56 - 6.57599973678589, 2) - 0.00011240877503454*std::pow(-5.23920011520386*x_59 - 6.44536018371582, 2) - 0.000255791349157908*std::pow(-5.33192014694214*x_7 - 7.97664022445679, 2) - 0.000135965868057573*std::pow(-7.07024002075195*x_70 - 9.68871974945068, 2) - 0.000243664160686771*std::pow(-3.4670398235321*x_70 - 4.69191980361938, 2) - 4.69082390601599e-5*std::pow(-5.50519990921021*x_77 - 7.96400022506714, 2) - 4.21693996227451e-5*std::pow(-7.53200006484985*x_81 - 9.99948024749756, 2) - 3.74348739611807e-5*std::pow(-8.54800033569336*x_88 - 8.59800052642822, 2) - 0.00440378220251121*std::exp(0.617359817028046*x_1) + 0.000172221587337435*std::exp(1.14975988864899*x_1) + 1.76685045353151e-5*std::exp(1.20047986507416*x_1) - 7.67751436726191e-6*std::exp(1.31991982460022*x_1) + 0.00434878987520421*std::exp(1.33495986461639*x_100) + 0.0010039671787403*std::exp(1.60943984985352*x_100) + 0.000806602710990507*std::exp(0.885279893875122*x_104) + 0.000623468072703093*std::exp(1.19487988948822*x_106) + 0.014909084310451*std::exp(0.567839860916138*x_109) + 0.00296548281031557*std::exp(0.605279862880707*x_109) - 0.00384987916088699*std::exp(0.867999851703644*x_109) + 0.00290168683891374*std::exp(0.886719882488251*x_109) - 0.0005671645397964*std::exp(1.18495988845825*x_110) - 0.00823010975646157*std::exp(0.60511988401413*x_26) + 0.00469660803504693*std::exp(0.78143984079361*x_26) - 0.000398215672791508*std::exp(1.22703981399536*x_26) + 0.0019684452987372*std::exp(0.628879845142365*x_31) + 0.0180634566435739*std::exp(0.654159843921661*x_31) + 0.0018679294151002*std::exp(0.657919824123383*x_31) + 0.00115869206233896*std::exp(0.81335985660553*x_49) - 0.0127496827379956*std::exp(0.863999843597412*x_50) + 0.00103468244974884*std::exp(1.11055994033813*x_66) + 0.000213107835206936*std::exp(1.48999989032745*x_66) + 0.00554544569303873*std::exp(1.17007982730865*x_68) + 0.012995264519215*std::exp(0.887999892234802*x_72) - 0.0199893911330712*std::exp(0.634559869766235*x_74) - 0.00175169029744583*std::exp(1.17399990558624*x_74) - 0.00323858223697917*std::exp(0.905119836330414*x_77) + 0.0125029956919954*std::exp(0.957039833068848*x_81) + 0.00645153058285262*std::sin(0.528159856796265*x_10 - 4.05343961715698) - 0.00538558369212073*std::sin(0.329999834299088*x_100 - 7.44367980957031) + 0.0322729877446835*std::sin(0.360319852828979*x_102 - 4.23464012145996) + 0.0956492931701732*std::sin(0.372879832983017*x_102 + 1.99031984806061) + 0.00385802566490449*std::sin(0.394319832324982*x_102 - 7.41599988937378) + 0.00807275511590149*std::sin(0.302079916000366*x_105 + 1.87591981887817) - 0.0688471387893606*std::sin(0.202159985899925*x_108 + 4.98984003067017) - 0.00844804069848087*std::sin(0.260319977998734*x_111 + 5.06303977966309) + 0.0536268376094519*std::sin(0.310319930315018*x_111 - 7.49119997024536) + 0.0722042939773741*std::sin(0.407119870185852*x_111 + 1.97735977172852) - 0.0327587974670714*std::sin(0.495199859142303*x_112 - 7.34656000137329) - 0.13654670314296*std::sin(0.157280027866364*x_114 - 7.63944053649902) - 0.583227064910011*std::sin(0.154240027070045*x_115 - 7.65759992599487) + 0.0182201057851123*std::sin(0.433519870042801*x_115 - 4.18584012985229) + 0.0351309996154051*std::sin(0.438559859991074*x_115 - 7.3557596206665) + 0.0201920893539867*std::sin(0.416879862546921*x_117 + 5.20480012893677) - 0.0176098858636805*std::sin(0.526559829711914*x_118 - 4.02767992019653) + 0.0327007000167033*std::sin(0.598879814147949*x_120 - 4.00255966186523) + 0.0294154090097527*std::sin(0.452239871025085*x_2 - 4.13647985458374) + 0.029673630932651*std::sin(0.315839856863022*x_24 + 5.1191201210022) + 0.0280202639466396*std::sin(0.384239852428436*x_24 + 5.1701602935791) - 0.0443993074024358*std::sin(0.343279838562012*x_28 - 4.25920009613037) - 0.0428661038839697*std::sin(0.348079830408096*x_28 + 8.34904003143311) - 0.0059381387638556*std::sin(0.367599844932556*x_28 + 5.1799201965332) + 0.0417118489897147*std::sin(0.281519949436188*x_3 + 1.88359987735748) + 0.0621780791967678*std::sin(0.309279918670654*x_35 - 1.13063991069794) - 0.0330156798054659*std::sin(0.321199834346771*x_35 + 1.9799998998642) + 0.0163366938708607*std::sin(0.32287985086441*x_35 + 1.98631989955902) + 0.00937718483683899*std::sin(0.403199851512909*x_36 + 5.21271991729736) - 0.0233028212746494*std::sin(0.410559862852097*x_36 + 5.20024013519287) - 0.014090532360795*std::sin(0.614959836006165*x_38 + 2.18871974945068) - 0.0158289215370156*std::sin(0.417519867420197*x_41 + 1.98311984539032) + 0.0356361050975604*std::sin(0.397759854793549*x_43 + 8.20655918121338) - 0.0235980705998199*std::sin(0.434879869222641*x_43 - 4.36527967453003) - 0.045514311647056*std::sin(0.438959866762161*x_45 + 5.22911977767944) + 0.0258463708874261*std::sin(0.594159841537476*x_46 + 2.18767976760864) + 0.0475723951882461*std::sin(0.153040036559105*x_49 + 1.74503993988037) + 0.0200180950211891*std::sin(0.412159860134125*x_51 + 1.99223983287811) + 0.0293361994893263*std::sin(0.232959985733032*x_53 + 5.03399991989136) - 0.0353194095932753*std::sin(0.250639975070953*x_53 + 5.05167961120605) - 0.0516804566262407*std::sin(0.423519849777222*x_53 + 5.22088003158569) + 0.0133703257298355*std::sin(0.30703991651535*x_55 + 5.13463973999023) - 0.0545235692569245*std::sin(0.153440043330193*x_56 + 1.72919988632202) - 0.0186216161852185*std::sin(0.490319848060608*x_58 + 5.28128004074097) + 0.00882578235738278*std::sin(0.537279844284058*x_58 + 8.55719947814941) + 0.23949951174906*std::sin(0.202960014343262*x_59 - 7.60008001327515) + 0.21114670643977*std::sin(0.264799952507019*x_63 + 1.86583995819092) - 0.012321863192174*std::sin(0.281759947538376*x_64 - 7.50191974639893) + 0.0555015581407355*std::sin(0.426319867372513*x_64 - 7.37799978256226) - 0.00693472905530078*std::sin(0.530159831047058*x_64 + 8.52952003479004) + 0.0197899209954773*std::sin(0.235039979219437*x_66 + 5.03575992584229) - 0.0552880710749905*std::sin(0.233679994940758*x_70 + 5.0449595451355) - 0.00215699184628207*std::sin(0.683279812335968*x_70 + 5.45639991760254) + 0.0134717122318521*std::sin(0.282959938049316*x_71 - 4.2960000038147) + 0.177802575314345*std::sin(0.23463998734951*x_73 + 5.05839967727661) + 0.0577884866565752*std::sin(0.25095996260643*x_73 - 7.52400016784668) + 0.0418796917122694*std::sin(0.186240002512932*x_75 - 4.40799999237061) - 0.00573336898597789*std::sin(0.317759931087494*x_76 + 5.14647960662842) - 0.038212118551625*std::sin(0.282799959182739*x_78 + 5.10743999481201) - 0.00792961557670189*std::sin(0.376399844884872*x_81 - 7.40743970870972) - 0.0434669187210287*std::sin(0.266319960355759*x_84 - 7.53360033035278) + 0.0109255552093935*std::sin(0.277999937534332*x_84 - 7.50880002975464) + 0.13805987533018*std::sin(0.282879948616028*x_84 - 7.50984001159668) - 0.208979181384627*std::sin(0.172720015048981*x_85 + 4.94823980331421) + 0.230645777302176*std::sin(0.125600054860115*x_86 + 4.900559425354) - 0.0879515939844191*std::sin(0.254159986972809*x_86 - 4.33599996566772) - 0.0139804926879153*std::sin(0.30895984172821*x_87 - 4.30751991271973) - 0.0595304166829957*std::sin(0.346319854259491*x_87 + 5.14383983612061) + 0.0055041527568718*std::sin(1.01335978507996*x_87 - 6.99656009674072) - 0.00982980199776876*std::sin(0.336639851331711*x_92 + 8.38432025909424) + 0.0272663129296672*std::sin(0.348559856414795*x_92 + 1.99535977840424) + 0.0799026690450907*std::sin(0.364159852266312*x_95 - 7.40639972686768) - 0.00469331460252709*std::sin(0.377039849758148*x_95 - 1.2163999080658) - 0.0115596992963929*std::sin(0.396079838275909*x_95 + 8.39648056030273) + 0.00982986362033453*std::sin(0.428159862756729*x_95 - 1.16703987121582) + 0.030722864926111*std::sin(0.407679855823517*x_96 + 5.20000028610229) - 0.0453641607773077*std::sin(0.400159865617752*x_97 + 5.19280004501343) + 0.0198199896453935*std::sin(0.439679861068726*x_98 + 2.02647995948792) - 0.112903749270065*std::sin(0.164400026202202*x_99 - 1.41487991809845) + 0.619492769241333*std::sin(-0.0239159377992296*x_1 + 0.00665125215856868*x_10 + 0.00506447868044416*x_101 + 0.00528857894196245*x_103 + 0.00104659686411283*x_104 - 0.00610684835133188*x_105 + 0.00134953482362981*x_106 + 0.00160626390865321*x_107 + 0.00336803210753995*x_108 + 0.00454241076655754*x_11 - 0.00588889525563339*x_111 + 0.00350638480490371*x_113 + 0.00456759072513846*x_116 - 0.00725548546775253*x_117 - 0.00445029537314079*x_118 + 0.00832035396661363*x_119 + 0.00189897106162404*x_12 - 0.000705968661375249*x_13 + 0.00240160798585685*x_14 - 0.000345797880329553*x_15 + 0.00968595653385549*x_16 + 0.00263535268471934*x_17 + 0.00508953907192437*x_18 + 0.000719994337384305*x_19 - 0.00420260515858901*x_2 + 0.000435042583936813*x_20 - 0.00634223660919568*x_21 + 0.0118297311671745*x_22 - 0.000642010698106483*x_23 + 0.00130576830886048*x_24 - 0.00248147090534112*x_25 - 0.0050970112722814*x_26 - 0.00325280288003786*x_27 - 0.00803742137807294*x_29 + 0.00169380976185066*x_3 - 0.00233829581222168*x_30 + 0.0117241620893366*x_32 + 0.00698035113474788*x_33 - 0.00102491650308488*x_34 + 0.0021583957381881*x_35 + 0.000387567935913786*x_37 + 0.00527654019291017*x_38 + 0.00456869951337275*x_39 - 0.00505456265277809*x_4 - 0.000446398598872114*x_40 + 0.00937602827579776*x_41 - 0.00699234150196231*x_42 - 0.000590543832290276*x_44 + 0.00203021890262221*x_45 - 0.00521219109205931*x_46 - 0.00400410510190216*x_47 + 0.00324380532175818*x_48 + 0.00088002382909844*x_49 + 0.00677168551768176*x_5 - 0.00154192015770445*x_50 + 0.00138957830818935*x_51 + 0.00232895900178127*x_52 + 0.00658350877537764*x_53 + 0.00904296438985406*x_54 + 0.000209001632636841*x_55 - 0.000410682172095549*x_56 - 0.00558916907256763*x_6 + 0.00730142779004137*x_60 - 0.00377574992341133*x_61 + 0.00478952986873397*x_62 + 1.75536261665443e-5*x_63 - 0.00173621953541255*x_64 - 0.00179296792369133*x_65 - 0.00102559467387568*x_69 + 0.00301723011358494*x_7 - 6.84877984360833e-5*x_70 - 0.00446142275405156*x_71 + 0.00190054283408723*x_72 - 0.00448558302709989*x_73 + 0.000244131664778573*x_76 + 0.000906806803906879*x_77 + 0.000532754390374147*x_78 - 0.00722845128534943*x_8 + 0.00224668657769367*x_80 + 0.000205516862469177*x_81 + 0.0060695838358917*x_82 + 0.00209960723307992*x_83 - 0.000369985157118045*x_85 - 0.000167471699874801*x_86 + 0.0026135291968132*x_88 - 0.00529273542590835*x_89 + 0.00377608357134663*x_9 + 0.020299338144244*x_91 - 0.00350496603276455*x_93 - 0.000634418761075482*x_94 - 5.2091657898634e-5*x_95 + 0.000794030053435923*x_96 + 0.00355755013958287*x_97 + 0.00217394310307112*x_99 - 7.87416608739313e-5*std::pow(-5.34607982635498*x_59 - 6.13520002365112, 2) - 1.94768998130193e-5*std::pow(-5.6637601852417*x_67 - 8.90248012542725, 2) + 5.26145793051823e-5*std::pow(-7.6625599861145*x_84 - 7.4585599899292, 2) + 9.8156562341121e-5*std::pow(-5.06239986419678*x_90 - 7.8996000289917, 2) + 0.000754152738749888*std::exp(1.53511989116669*x_100) + 0.00257398344874229*std::exp(0.871279835700989*x_109) - 9.81909229001238e-5*std::exp(1.75111997127533*x_110) - 0.00313642217207758*std::exp(0.616399824619293*x_112) + 0.00579689535269105*std::exp(0.721439838409424*x_114) - 0.00290666292734578*std::exp(0.598719835281372*x_31) + 0.00408016508708729*std::exp(1.00015985965729*x_66) + 0.00591767564271873*std::exp(1.06511986255646*x_68) + 0.00399036732161262*std::exp(1.08279979228973*x_74) + 0.0190629929579618*std::sin(0.344559848308563*x_102 - 7.43680000305176) + 0.0115766441042753*std::sin(0.424319863319397*x_115 - 4.16856002807617) + 0.0779584105227347*std::sin(0.26623997092247*x_120 + 5.06559944152832) + 0.0359428390850827*std::sin(0.278319954872131*x_28 - 4.29287958145142) + 0.0778515358470147*std::sin(0.287839949131012*x_36 - 7.49151992797852) - 0.0678436632662072*std::sin(0.271999955177307*x_43 - 1.33087992668152) + 0.017269014841709*std::sin(0.72655987739563*x_57 + 2.35935997962952) - 0.0355429665706528*std::sin(0.447759836912155*x_58 + 5.23080015182495) + 0.0215647176598968*std::sin(0.468879848718643*x_75 + 5.25735998153687) - 0.0453730454460701*std::sin(0.336639851331711*x_79 + 8.31711959838867) - 0.00910559864669758*std::sin(0.510159850120544*x_87 + 5.31903982162476) - 0.026242555531196*std::sin(0.375519841909409*x_92 - 1.20735991001129) + 0.0352889381440056*std::sin(0.441519856452942*x_98 + 1.99927973747253) - 1.89001921855212) - 0.0269972964221846);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0101788743917577*x_1 - 0.00115901127459224*x_10 - 0.0017764825052259*x_100 + 0.0252535495509525*x_101 - 0.00062860423707471*x_102 - 0.0177151026784683*x_103 + 0.00812663244113434*x_104 - 0.0158852094710822*x_105 + 0.00756291231478151*x_106 - 0.00527238839165718*x_107 - 0.016031519328727*x_108 - 0.0115930849621201*x_11 + 0.00769740838014281*x_110 - 0.00106877154536533*x_111 + 7.83975796798049e-5*x_112 + 0.0187001440104074*x_113 + 0.00133499826415019*x_114 + 0.000768938519448497*x_115 + 0.0368956359006875*x_116 - 0.00392503212241632*x_117 - 0.0108978265099677*x_118 + 0.00723169806033189*x_119 - 0.0364134264720142*x_12 - 0.00348823410249466*x_120 + 0.000714852206732738*x_13 - 0.0111379648055518*x_14 - 0.00168108552426222*x_15 - 0.0131126013697475*x_16 + 0.00765432647950378*x_17 + 0.0167308617605737*x_18 - 0.0132314180369782*x_19 - 0.0187038676186867*x_2 - 0.0093558206924494*x_20 - 0.015999478959791*x_21 + 0.01451593477585*x_22 - 0.00595723979803511*x_23 - 0.00160988285741282*x_24 + 0.0121310649036564*x_25 - 0.00148458871769953*x_26 + 0.00519046186998968*x_27 + 0.000358077166964351*x_28 - 0.00607047636530314*x_29 - 0.00937875822229683*x_3 + 0.0131465102728155*x_30 + 0.024712772618116*x_31 - 0.0142638722630829*x_32 - 0.0184680601825063*x_33 - 0.00469803998764018*x_34 + 0.00128607358516952*x_35 - 0.00236411366155701*x_36 - 0.00909430193486018*x_37 - 0.000732094217453147*x_38 + 0.00794590867633172*x_39 + 0.00376161277757003*x_4 - 0.0106248829000673*x_40 + 0.0119417993714621*x_41 + 0.00206258707568843*x_42 - 0.00199561724749469*x_43 - 0.0133686809107573*x_44 - 0.00258711870016684*x_45 - 0.00591654209242701*x_46 + 0.000648037884243481*x_47 - 0.0050632954877671*x_48 - 0.00183173416262494*x_49 + 0.0176227741343459*x_5 + 0.000650318983356408*x_50 - 0.00452184529321215*x_51 + 0.00169619191740291*x_52 + 0.0022479207308799*x_53 + 0.0190480401612772*x_54 - 0.0170888168189401*x_55 - 0.00681904254685585*x_56 + 0.00728515425223563*x_57 + 0.0195718467428158*x_58 - 0.00195375479166751*x_59 - 0.000506456145497163*x_6 + 0.00102726251298513*x_60 + 0.00570288884011856*x_61 - 0.00879702540179821*x_62 + 0.010885951429852*x_63 - 0.00141853860717256*x_64 - 0.0106124920518413*x_65 - 0.00185691716681148*x_66 - 0.00020868900662276*x_67 - 0.00222771353158608*x_68 + 0.0163252205512349*x_69 + 0.00225525308987908*x_7 - 2.91491265574111e-5*x_70 + 0.000119706887570695*x_71 - 0.00201338079278005*x_72 - 0.004342216600361*x_73 - 0.00140307652317449*x_74 + 0.00370470339680673*x_75 - 0.00404256306713775*x_76 + 4.68814774409516e-5*x_77 + 0.0118558892405506*x_78 + 0.00470167250759074*x_79 + 0.00245757578920354*x_8 - 0.00600812655372107*x_80 - 0.000244654728365458*x_81 + 0.0103827023406569*x_82 + 0.0108570813813433*x_83 + 0.00825743750047492*x_84 - 0.00616185105812852*x_85 - 0.00311305104408915*x_86 + 0.000829447116127451*x_87 - 0.000959662641962569*x_88 - 0.00459429768842634*x_89 + 0.00467680252443294*x_9 - 0.0141593009331906*x_90 + 0.0153726528947428*x_91 - 0.00289669411341393*x_92 + 0.0223074042147923*x_93 - 0.00743956569731365*x_94 - 2.21707568843774e-5*x_95 - 0.000824490532362316*x_96 - 0.00482182373657609*x_97 + 0.00227420801083594*x_98 + 0.00563355693676222*x_99 + 2.69546612673698e-5*std::pow(-5.44952011108398*x_114 - 6.8145604133606, 2) + 7.38703873494934e-6*std::pow(-7.48392009735107*x_15 - 9.32503986358643, 2) + 0.000322849392874324*std::pow(-4.71783971786499*x_15 - 6.56799983978271, 2) + 7.08763894457022e-6*std::pow(-7.35176038742065*x_23 - 9.59408092498779, 2) - 1.90902938975845e-5*std::pow(-4.51768016815186*x_24 - 6.28480005264282, 2) - 4.8714450592236e-6*std::pow(-9.80399990081787*x_40 - 9.97720050811768, 2) + 1.44957206873001e-5*std::pow(-6.20391988754272*x_50 - 5.59935998916626, 2) + 1.62099228489423e-5*std::pow(-7.59695959091187*x_56 - 6.57599973678589, 2) - 3.35132781395656e-5*std::pow(-5.34607982635498*x_59 - 6.13520002365112, 2) + 0.000147195821374119*std::pow(-5.23920011520386*x_59 - 6.44536018371582, 2) - 8.28957318763221e-6*std::pow(-5.6637601852417*x_67 - 8.90248012542725, 2) + 0.000242357797552391*std::pow(-5.33192014694214*x_7 - 7.97664022445679, 2) + 0.00012882526494041*std::pow(-7.07024002075195*x_70 - 9.68871974945068, 2) + 0.000319070697645303*std::pow(-3.4670398235321*x_70 - 4.69191980361938, 2) - 3.08911732802401e-5*std::pow(-5.50519990921021*x_77 - 7.96400022506714, 2) - 2.77704355774099e-5*std::pow(-7.53200006484985*x_81 - 9.99948024749756, 2) + 2.23933177288945e-5*std::pow(-7.6625599861145*x_84 - 7.4585599899292, 2) - 2.46525386889004e-5*std::pow(-8.54800033569336*x_88 - 8.59800052642822, 2) + 4.17764641798489e-5*std::pow(-5.06239986419678*x_90 - 7.8996000289917, 2) + 0.0041725060640818*std::exp(0.617359817028046*x_1) + 0.000113415617461479*std::exp(1.14975988864899*x_1) - 2.31363613448232e-5*std::exp(1.20047986507416*x_1) - 8.38381292692343e-6*std::exp(1.31991982460022*x_1) - 0.00412040180265043*std::exp(1.33495986461639*x_100) + 0.000320975328852983*std::exp(1.53511989116669*x_100) - 0.00131466403278504*std::exp(1.60943984985352*x_100) + 0.000531183958569905*std::exp(0.885279893875122*x_104) - 0.000590725016471434*std::exp(1.19487988948822*x_106) - 0.0141260947600429*std::exp(0.567839860916138*x_109) + 0.00323829457431021*std::exp(0.605279862880707*x_109) + 0.00504129793340189*std::exp(0.867999851703644*x_109) + 0.00109551439843832*std::exp(0.871279835700989*x_109) + 0.0019108905544486*std::exp(0.886719882488251*x_109) - 0.000619341257206067*std::exp(1.18495988845825*x_110) - 4.17910883947577e-5*std::exp(1.75111997127533*x_110) - 0.00133489422815484*std::exp(0.616399824619293*x_112) + 0.00246721956515154*std::exp(0.721439838409424*x_114) + 0.0107770747010567*std::exp(0.60511988401413*x_26) + 0.00309292643567226*std::exp(0.78143984079361*x_26) + 0.000377302335385136*std::exp(1.22703981399536*x_26) - 0.00123710627971213*std::exp(0.598719835281372*x_31) - 0.00257761836198833*std::exp(0.628879845142365*x_31) - 0.0171148069812834*std::exp(0.654159843921661*x_31) + 0.00203977095030597*std::exp(0.657919824123383*x_31) + 0.000763050542789438*std::exp(0.81335985660553*x_49) + 0.0120800998080854*std::exp(0.863999843597412*x_50) + 0.00173656112788664*std::exp(1.00015985965729*x_66) + 0.0011298688198429*std::exp(1.11055994033813*x_66) - 0.00027905813256044*std::exp(1.48999989032745*x_66) + 0.00251862492552304*std::exp(1.06511986255646*x_68) - 0.0052542121109091*std::exp(1.17007982730865*x_68) - 0.012312784219858*std::exp(0.887999892234802*x_72) + 0.01893959598467*std::exp(0.634559869766235*x_74) + 0.00169834225547192*std::exp(1.08279979228973*x_74) - 0.00115356640103919*std::exp(1.17399990558624*x_74) + 0.00306849962178364*std::exp(0.905119836330414*x_77) - 0.0118463681774023*std::exp(0.957039833068848*x_81) - 0.00844808016964373*std::sin(0.528159856796265*x_10 - 4.05343961715698) - 0.00588103440998608*std::sin(0.329999834299088*x_100 - 7.44367980957031) + 0.00811341008155264*std::sin(0.344559848308563*x_102 - 7.43680000305176) - 0.0422604813353396*std::sin(0.360319852828979*x_102 - 4.23464012145996) - 0.0906260204126589*std::sin(0.372879832983017*x_102 + 1.99031984806061) + 0.00254068244133682*std::sin(0.394319832324982*x_102 - 7.41599988937378) + 0.00881541413783372*std::sin(0.302079916000366*x_105 + 1.87591981887817) - 0.0453389199168891*std::sin(0.202159985899925*x_108 + 4.98984003067017) - 0.0092252243925606*std::sin(0.260319977998734*x_111 + 5.06303977966309) - 0.0702226886396928*std::sin(0.310319930315018*x_111 - 7.49119997024536) - 0.0684122966620694*std::sin(0.407119870185852*x_111 + 1.97735977172852) + 0.0310383835525378*std::sin(0.495199859142303*x_112 - 7.34656000137329) - 0.0899221107452993*std::sin(0.157280027866364*x_114 - 7.63944053649902) + 0.552597370434432*std::sin(0.154240027070045*x_115 - 7.65759992599487) + 0.00492714135672727*std::sin(0.424319863319397*x_115 - 4.16856002807617) + 0.0119987545102762*std::sin(0.433519870042801*x_115 - 4.18584012985229) - 0.0460029596665782*std::sin(0.438559859991074*x_115 - 7.3557596206665) - 0.0264409177736027*std::sin(0.416879862546921*x_117 + 5.20480012893677) + 0.0166850566570016*std::sin(0.526559829711914*x_118 - 4.02767992019653) + 0.0331799185611515*std::sin(0.26623997092247*x_120 + 5.06559944152832) - 0.0309833372417029*std::sin(0.598879814147949*x_120 - 4.00255966186523) + 0.01937136236694*std::sin(0.452239871025085*x_2 - 4.13647985458374) - 0.0388567038199813*std::sin(0.315839856863022*x_24 + 5.1191201210022) + 0.0184525969483442*std::sin(0.384239852428436*x_24 + 5.1701602935791) + 0.0152976499354336*std::sin(0.278319954872131*x_28 - 4.29287958145142) + 0.0581395226443434*std::sin(0.343279838562012*x_28 - 4.25920009613037) + 0.0406148783419468*std::sin(0.348079830408096*x_28 + 8.34904003143311) - 0.00648442219041168*std::sin(0.367599844932556*x_28 + 5.1799201965332) + 0.0274691180226984*std::sin(0.281519949436188*x_3 + 1.88359987735748) - 0.0589126347696145*std::sin(0.309279918670654*x_35 - 1.13063991069794) - 0.0217423016994425*std::sin(0.321199834346771*x_35 + 1.9799998998642) - 0.021392396386492*std::sin(0.32287985086441*x_35 + 1.98631989955902) + 0.0331344315763238*std::sin(0.287839949131012*x_36 - 7.49151992797852) + 0.0102398458267267*std::sin(0.403199851512909*x_36 + 5.21271991729736) - 0.0153459499724654*std::sin(0.410559862852097*x_36 + 5.20024013519287) - 0.00927924572504013*std::sin(0.614959836006165*x_38 + 2.18871974945068) - 0.0104240527428916*std::sin(0.417519867420197*x_41 + 1.98311984539032) - 0.0288749758617317*std::sin(0.271999955177307*x_43 - 1.33087992668152) + 0.0234679689465588*std::sin(0.397759854793549*x_43 + 8.20655918121338) + 0.030900945088296*std::sin(0.434879869222641*x_43 - 4.36527967453003) + 0.0431240085491867*std::sin(0.438959866762161*x_45 + 5.22911977767944) - 0.0244889811309913*std::sin(0.594159841537476*x_46 + 2.18767976760864) + 0.0519488525406912*std::sin(0.153040036559105*x_49 + 1.74503993988037) + 0.0131828108330135*std::sin(0.412159860134125*x_51 + 1.99223983287811) + 0.0320350046564788*std::sin(0.232959985733032*x_53 + 5.03399991989136) - 0.0232594107935358*std::sin(0.250639975070953*x_53 + 5.05167961120605) + 0.0489663223000767*std::sin(0.423519849777222*x_53 + 5.22088003158569) + 0.0146003386420166*std::sin(0.30703991651535*x_55 + 5.13463973999023) - 0.0595395049610611*std::sin(0.153440043330193*x_56 + 1.72919988632202) + 0.00734987414747408*std::sin(0.72655987739563*x_57 + 2.35935997962952) - 0.015127459992172*std::sin(0.447759836912155*x_58 + 5.23080015182495) - 0.0122631670653413*std::sin(0.490319848060608*x_58 + 5.28128004074097) - 0.0115570895863333*std::sin(0.537279844284058*x_58 + 8.55719947814941) - 0.226921568588868*std::sin(0.202960014343262*x_59 - 7.60008001327515) - 0.200057784994102*std::sin(0.264799952507019*x_63 + 1.86583995819092) - 0.0134554220249766*std::sin(0.281759947538376*x_64 - 7.50191974639893) - 0.0525867486762062*std::sin(0.426319867372513*x_64 - 7.37799978256226) - 0.00456682922213457*std::sin(0.530159831047058*x_64 + 8.52952003479004) + 0.0130325480325431*std::sin(0.235039979219437*x_66 + 5.03575992584229) - 0.0364096674300087*std::sin(0.233679994940758*x_70 + 5.0449595451355) - 0.00235542589164537*std::sin(0.683279812335968*x_70 + 5.45639991760254) + 0.0147110522695738*std::sin(0.282959938049316*x_71 - 4.2960000038147) - 0.168464808110949*std::sin(0.23463998734951*x_73 + 5.05839967727661) + 0.038056302915606*std::sin(0.25095996260643*x_73 - 7.52400016784668) + 0.0275796499618662*std::sin(0.186240002512932*x_75 - 4.40799999237061) + 0.00917817039818862*std::sin(0.468879848718643*x_75 + 5.25735998153687) - 0.00626081446677981*std::sin(0.317759931087494*x_76 + 5.14647960662842) - 0.0251643890121187*std::sin(0.282799959182739*x_78 + 5.10743999481201) - 0.0193112448378228*std::sin(0.336639851331711*x_79 + 8.31711959838867) - 0.00865910637184467*std::sin(0.376399844884872*x_81 - 7.40743970870972) - 0.0286249099320769*std::sin(0.266319960355759*x_84 - 7.53360033035278) + 0.0119306596662216*std::sin(0.277999937534332*x_84 - 7.50880002975464) - 0.130809299945184*std::sin(0.282879948616028*x_84 - 7.50984001159668) + 0.198004093185393*std::sin(0.172720015048981*x_85 + 4.94823980331421) + 0.151890559435827*std::sin(0.125600054860115*x_86 + 4.900559425354) + 0.0833325860294323*std::sin(0.254159986972809*x_86 - 4.33599996566772) - 0.0152666383564847*std::sin(0.30895984172821*x_87 - 4.30751991271973) + 0.0564040211764953*std::sin(0.346319854259491*x_87 + 5.14383983612061) - 0.00387543844881047*std::sin(0.510159850120544*x_87 + 5.31903982162476) - 0.00720751814764833*std::sin(1.01335978507996*x_87 - 6.99656009674072) - 0.0107341018350165*std::sin(0.336639851331711*x_92 + 8.38432025909424) + 0.0179560864850067*std::sin(0.348559856414795*x_92 + 1.99535977840424) - 0.0111691073422752*std::sin(0.375519841909409*x_92 - 1.20735991001129) - 0.0757063714315497*std::sin(0.364159852266312*x_95 - 7.40639972686768) - 0.00512507951825794*std::sin(0.377039849758148*x_95 - 1.2163999080658) - 0.0076125789666581*std::sin(0.396079838275909*x_95 + 8.39648056030273) - 0.012871903008872*std::sin(0.428159862756729*x_95 - 1.16703987121582) - 0.0291093733330101*std::sin(0.407679855823517*x_96 + 5.20000028610229) + 0.0429817432450137*std::sin(0.400159865617752*x_97 + 5.19280004501343) + 0.0130523495832616*std::sin(0.439679861068726*x_98 + 2.02647995948792) + 0.0150193428249304*std::sin(0.441519856452942*x_98 + 1.99927973747253) - 0.0743521682452699*std::sin(0.164400026202202*x_99 - 1.41487991809845) + 0.166103386368977);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
