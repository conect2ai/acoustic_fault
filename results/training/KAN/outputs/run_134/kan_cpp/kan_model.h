
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (8.47207423407565e-5*x_1 - 2.50985762317902e-5*x_10 + 0.000111548842559349*x_100 - 0.000222656268156639*x_101 - 4.86463945658983e-5*x_102 - 0.000210941118339282*x_103 - 0.000322325463274834*x_104 - 6.05566869276175e-5*x_105 + 1.40182440789463e-5*x_106 + 6.6205767103518e-5*x_107 + 1.50508452579344e-5*x_108 + 0.000116452631227248*x_109 - 0.000309626143335322*x_11 + 1.45781309440293e-5*x_110 - 2.66125487442931e-5*x_111 + 3.47915356232921e-5*x_112 - 0.000153302338676141*x_113 - 4.20825164685805e-5*x_114 + 0.000632350458966684*x_115 - 3.24807040785763e-5*x_116 + 0.000502886538614756*x_117 - 0.000375650790862889*x_118 + 0.000214318411445608*x_119 - 0.00040271449988137*x_12 + 9.49956622151821e-5*x_120 + 3.19198529047525e-6*x_13 + 0.000555045821935694*x_14 - 7.90553486571184e-5*x_15 - 5.47347677191892e-5*x_16 - 2.51388067781405e-5*x_17 - 2.26736304582607e-5*x_18 - 0.000427354291882527*x_19 - 6.44281165100629e-5*x_2 + 0.000123005348619428*x_20 - 0.000157654746772015*x_21 - 0.000143441361838844*x_22 + 0.000228892203987805*x_23 - 0.00016354109062087*x_24 - 0.000207055223770001*x_25 - 0.000132194065966029*x_26 - 0.000281034372849563*x_27 + 3.08404537614285e-5*x_28 + 6.45803784672707e-6*x_29 + 7.82589470127829e-5*x_3 - 0.000458323474821507*x_30 - 9.43058665767302e-6*x_31 + 2.50396172347623e-5*x_32 - 0.000121499486707121*x_33 - 0.00054094289988641*x_34 - 0.00044272599249254*x_35 - 0.000490604313540134*x_36 - 0.000259415604740461*x_37 - 0.000369288406981742*x_38 - 0.000494267028735635*x_39 + 1.79730562160767e-5*x_4 + 0.000163522861994454*x_40 + 0.000385263430197412*x_41 + 0.000487621884149463*x_42 - 0.00040159092899809*x_43 - 0.000691579028118811*x_44 - 0.000261626032356026*x_45 - 0.00016606788087595*x_46 - 0.000152975483561436*x_47 - 0.000152070303308507*x_48 - 0.00018765920905902*x_49 + 4.04425961093044e-5*x_5 + 0.00146657972819804*x_50 + 8.15607478784002e-5*x_51 + 0.000350749935710909*x_52 + 0.000373725784867928*x_53 + 0.000251591026865874*x_54 - 0.000101007116739984*x_55 - 0.000608864479024254*x_56 + 0.000401340709816742*x_57 - 9.63810374184365e-5*x_58 + 0.000725668958651135*x_59 + 5.27655116856215e-5*x_6 - 0.000245803047086436*x_60 - 1.05957529193839e-5*x_61 - 9.92316523793961e-7*x_62 - 2.44169492965124e-5*x_63 - 1.65233428259957e-5*x_64 + 8.89278472184341e-6*x_65 - 6.13447840860165e-5*x_66 - 6.39286443311168e-6*x_67 - 1.0938316142171e-5*x_68 + 1.49700991286445e-6*x_69 - 0.000242717897382129*x_7 - 5.43783198143676e-6*x_70 - 2.51148398845831e-6*x_71 + 3.33840009322786e-5*x_72 - 9.88686262561632e-6*x_73 - 2.63938270571329e-6*x_74 - 6.9145115545972e-6*x_75 + 2.28428320215437e-5*x_76 + 1.2684130641755e-6*x_77 + 4.43848984792168e-6*x_78 + 2.77174366516137e-5*x_79 - 0.000122862045495631*x_8 + 7.76769986427156e-5*x_80 - 2.29338440341699e-5*x_81 - 7.83247461467765e-6*x_82 - 1.84739867209529e-5*x_83 + 9.49067009229214e-6*x_84 + 1.46753382073455e-5*x_85 + 8.74210083456528e-5*x_86 + 3.1602570175879e-5*x_87 + 3.99224529711312e-5*x_88 - 8.4685496414814e-6*x_89 + 0.000230720458309868*x_9 - 1.79820861070303e-5*x_90 - 3.25345732274556e-6*x_91 - 0.000135237386244593*x_92 - 8.02228077958909e-6*x_93 + 4.21017734581509e-6*x_94 - 0.000130756443523218*x_95 + 0.000119704671814531*x_96 - 5.81845543888272e-5*x_97 - 0.000148322628742939*x_98 - 0.000217866460087325*x_99 - 1.44735214242642e-7*std::pow(7.56008005142212 - 7.57863998413086*x_29, 2) - 4.51571754514843e-7*std::pow(-9.79199981689453*x_13 - 9.96739959716797, 2) - 4.02868072195981e-7*std::pow(-9.3638391494751*x_18 - 5.88736009597778, 2) - 1.04670178527707e-8*std::pow(-9.32719993591309*x_28 - 3.25887989997864, 2) - 1.36057178710263e-7*std::pow(-9.69608020782471*x_29 - 5.72824001312256, 2) - 9.45678035710392e-8*std::pow(-6.40000009536743*x_3 - 0.823999881744385, 2) - 0.0011452784225117*std::sin(0.383359849452972*x_10 - 1.38967990875244) + 0.00136447344130358*std::sin(0.285519927740097*x_100 + 1.75823998451233) - 0.000831651173277477*std::sin(0.253679990768433*x_107 - 1.22095990180969) - 0.00152615248108372*std::sin(0.245599970221519*x_109 - 7.6048002243042) - 0.00137841360191102*std::sin(0.25655996799469*x_109 + 4.97463941574097) - 0.000377379473313121*std::sin(0.408079862594604*x_11 - 1.58663988113403) + 0.000881496817445415*std::sin(0.23471999168396*x_110 - 4.410560131073) + 0.00222341821818866*std::sin(0.280719965696335*x_110 + 7.9597601890564) + 0.000657432078676137*std::sin(0.283919930458069*x_110 + 4.74656009674072) - 0.00160340854594238*std::sin(0.239999979734421*x_111 + 4.98303985595703) - 0.00129133353581915*std::sin(0.267759948968887*x_112 + 4.9826397895813) - 0.000249286814449314*std::sin(0.344319850206375*x_112 + 1.63351988792419) + 0.000908150241892573*std::sin(0.324319839477539*x_113 + 1.80663990974426) + 0.000121477465645766*std::sin(0.258559972047806*x_114 - 1.42975986003876) - 0.000695341217115927*std::sin(0.269039958715439*x_116 + 8.17503929138184) + 0.000360641166578774*std::sin(0.31703993678093*x_116 + 7.74711990356445) + 0.00019870056569086*std::sin(0.262799948453903*x_118 + 8.14888000488281) - 0.000653122496327614*std::sin(0.270159959793091*x_119 - 7.64079999923706) - 0.00369404229805717*std::sin(0.297039926052094*x_119 + 1.72535991668701) + 0.000167000812140523*std::sin(0.360639840364456*x_12 + 1.83463990688324) + 0.00105648911343225*std::sin(0.308079928159714*x_120 + 4.95815992355347) + 0.00134857075534816*std::sin(0.285999953746796*x_14 + 1.7739999294281) - 0.000816759260259832*std::sin(0.329199850559235*x_14 - 1.32287991046906) + 0.000159049830661746*std::sin(0.283679932355881*x_15 - 4.61175966262817) - 8.42883708460303e-5*std::sin(0.315439850091934*x_15 - 8.15695953369141) + 0.000325533216295784*std::sin(0.341599822044373*x_15 + 5.05247974395752) + 0.000503880404303906*std::sin(0.327279835939407*x_16 + 1.80663990974426) - 0.000848035500894026*std::sin(0.383679836988449*x_16 - 7.60168027877808) - 0.000471297544698417*std::sin(0.395519822835922*x_16 + 4.79496002197266) - 0.00252096355548197*std::sin(0.151760026812553*x_18 + 1.7475198507309) + 0.000882343484076508*std::sin(0.186320006847382*x_19 + 4.78311967849731) + 0.000730495107542342*std::sin(0.245839968323708*x_19 + 1.5927197933197) + 0.000715991844082856*std::sin(0.356159836053848*x_2 + 8.18231964111328) + 0.000697755185486384*std::sin(0.287679940462112*x_20 - 4.59008026123047) - 0.000433163849975543*std::sin(0.302239924669266*x_20 - 4.4015998840332) + 0.00026443091188002*std::sin(0.344079852104187*x_20 + 1.80431985855103) + 0.000683357543641709*std::sin(0.346959829330444*x_20 - 1.35039985179901) + 9.88590424306829e-5*std::sin(0.42087984085083*x_20 + 7.9967999458313) + 0.00111551177275177*std::sin(0.381999850273132*x_22 - 4.39847993850708) + 0.000158560966080241*std::sin(0.479119867086411*x_23 + 1.40255987644196) - 0.000612625759105239*std::sin(0.276079952716827*x_24 + 4.81767988204956) - 0.000163276173301209*std::sin(0.348319828510284*x_24 - 7.5699200630188) + 0.000374635083685385*std::sin(0.370879858732224*x_24 + 8.21424007415771) - 0.000381588886968586*std::sin(0.392479836940765*x_25 + 1.80199980735779) - 0.000659359479701212*std::sin(0.443039864301682*x_25 - 1.40151989459991) + 0.000332544496472939*std::sin(0.30175992846489*x_26 - 1.37311983108521) - 0.00692821786190532*std::sin(0.105680070817471*x_27 - 1.46623992919922) + 0.000397657578742224*std::sin(0.395599842071533*x_27 + 8.00263977050781) - 0.00104127911454576*std::sin(0.33519983291626*x_28 - 4.36367988586426) + 0.00127678796544673*std::sin(0.22087998688221*x_29 + 1.8096798658371) + 0.00117240812813039*std::sin(0.316319912672043*x_3 + 1.85055994987488) + 1.06329329000113e-5*std::sin(0.394639849662781*x_3 + 8.19960021972656) + 0.00098948603023378*std::sin(0.320719838142395*x_32 + 8.20911979675293) + 0.000445256230683758*std::sin(0.271839946508408*x_33 + 8.16720008850098) - 0.00145872919464579*std::sin(0.2743199467659*x_33 + 4.98183965682983) - 0.00199866360712503*std::sin(0.282239943742752*x_33 + 4.96551990509033) + 0.000998615426111716*std::sin(0.267839968204498*x_36 - 7.61712026596069) - 0.00163348870849632*std::sin(0.291279941797256*x_36 - 7.6300802230835) - 0.00150183340231026*std::sin(0.222559988498688*x_37 - 1.37927985191345) + 0.000266951399192652*std::sin(0.249999970197678*x_38 - 7.82919979095459) + 0.000932593757077395*std::sin(0.371439844369888*x_4 + 8.19215965270996) - 8.91196576498477e-5*std::sin(0.243199974298477*x_40 + 1.5868798494339) - 0.00143074431060671*std::sin(0.246719971299171*x_41 - 1.21727979183197) - 0.000274056839628385*std::sin(0.197679996490479*x_43 - 1.37815976142883) + 0.000574335580880841*std::sin(0.242079973220825*x_43 + 1.76151990890503) + 0.000650013311405408*std::sin(0.245839968323708*x_44 + 1.78511989116669) + 0.00362103943451796*std::sin(0.168080016970634*x_45 + 7.99632024765015) - 0.00144323605071328*std::sin(0.207440003752708*x_47 - 7.60143995285034) + 0.00184178693668116*std::sin(0.283519923686981*x_48 - 4.45199966430664) - 0.00049981543863972*std::sin(0.431199848651886*x_5 - 7.61520004272461) - 0.000665866764349467*std::sin(0.274159938097*x_51 - 7.84543991088867) + 0.00180534173355212*std::sin(0.241199970245361*x_53 - 4.41567993164063) + 0.00068422935363367*std::sin(0.270639955997467*x_53 - 4.42847967147827) + 0.00186306377662571*std::sin(0.229999989271164*x_55 - 4.41167974472046) + 0.00119118354180943*std::sin(0.244719967246056*x_57 + 1.76287984848022) + 0.000209908243149171*std::sin(0.319679915904999*x_59 - 4.87175989151001) - 8.33241098080624e-5*std::sin(0.583919823169708*x_6 - 7.98712015151978) + 0.000896402197013893*std::sin(0.356159836053848*x_60 + 1.85079991817474) + 0.000937440991346321*std::sin(0.417679876089096*x_60 + 7.98752021789551) - 0.00170882204608517*std::sin(0.436959862709045*x_60 - 4.45959997177124) + 0.00122680816339595*std::sin(0.212479993700981*x_7 + 4.81024026870728) - 0.00143818186156938*std::sin(0.352559864521027*x_7 - 7.59416007995605) + 0.00103827197824958*std::sin(0.369039833545685*x_7 + 5.00751972198486) - 0.000861782132970598*std::sin(0.369439840316772*x_8 - 1.3796797990799) - 5.89328190114439e-5*std::sin(0.288959950208664*x_9 - 1.6341598033905) + 0.000914874175932907*std::sin(0.380959838628769*x_9 + 1.82615983486176) - 2.83936135447196e-5*std::sin(0.466959863901138*x_91 - 4.82599973678589) - 0.000979407522722846*std::sin(0.317919850349426*x_92 - 4.58975982666016) - 0.000749018934261781*std::sin(0.319039851427078*x_92 - 7.57272005081177) - 0.000476711568895055*std::sin(0.321999847888947*x_92 + 8.00944042205811) + 0.000806866790626678*std::sin(0.294959932565689*x_95 + 7.98992013931274) - 0.00161005402220822*std::sin(0.314799934625626*x_95 + 1.76271986961365) + 0.000570698962322004*std::sin(0.283279925584793*x_97 - 4.41336011886597) + 0.0015219275381085*std::sin(0.25927996635437*x_98 + 1.9579998254776) + 0.00067326586740372*std::sin(0.263199955224991*x_99 - 4.42944002151489) + 0.0210630292499244);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000118243911058046*x_1 + 7.1712875764983e-5*x_10 - 0.000237839684767411*x_100 + 2.75784277752597e-5*x_101 + 0.000172427222179436*x_102 - 0.000269927626377142*x_103 + 0.000162087755867193*x_104 - 0.000373368178301954*x_105 - 2.19315598252784e-5*x_106 - 5.42675570550326e-5*x_107 - 8.28889199194374e-5*x_108 - 3.83874032221893e-5*x_109 + 0.000144905931955439*x_11 - 4.16309121075856e-6*x_110 - 0.00018597257316135*x_111 - 0.000104786609515856*x_112 - 6.68331235444941e-6*x_113 + 2.11614769422262e-5*x_114 - 0.000289538442933383*x_115 - 0.000169923112827643*x_116 - 0.00030458449245435*x_117 + 0.000313484450859839*x_118 - 5.27967964085462e-6*x_119 + 0.000175032161418476*x_12 - 9.67950381390676e-5*x_120 - 0.00014759660935104*x_13 - 0.000320528162540923*x_14 + 4.20939985249472e-5*x_15 - 0.000140955216844942*x_16 - 5.97101441030137e-5*x_17 + 8.73892472920104e-6*x_18 - 9.20225689028318e-5*x_19 - 9.03749613965407e-5*x_2 - 8.993858590655e-5*x_20 - 8.06688924739364e-5*x_21 - 0.000119620077858722*x_22 - 1.48227858654969e-5*x_23 + 7.49795986825065e-5*x_24 + 7.01326163291067e-5*x_25 + 3.43041970167832e-5*x_26 + 1.74047544787564e-5*x_27 - 5.31844540477352e-5*x_28 - 3.12955401231925e-5*x_29 - 0.000278585615100276*x_3 + 1.52544781007637e-5*x_30 - 6.56463007872809e-6*x_31 - 2.0291108315101e-5*x_32 + 0.000107820106787166*x_33 - 0.000399802177544366*x_34 + 0.000474370291096777*x_35 - 0.000162784906452924*x_36 + 9.67521115643172e-5*x_37 + 0.000101772722745891*x_38 + 0.000245550044731381*x_39 - 4.73851899528285e-5*x_4 - 0.000414628252704395*x_40 + 0.000194910250170728*x_41 - 0.000502550494575436*x_42 - 0.000266809795438967*x_43 + 1.45078426447123e-5*x_44 + 4.55046417187809e-5*x_45 - 8.53550468428311e-5*x_46 + 6.51495554203763e-5*x_47 - 0.000289158370051802*x_48 - 0.000911478790818656*x_49 - 7.54084535574567e-5*x_5 - 0.000223959063649995*x_50 + 0.00019472959159001*x_51 - 0.000197973438954852*x_52 - 2.72364017182555e-5*x_53 - 0.000209742897441821*x_54 - 1.51635888867948e-6*x_55 + 0.000387824144423487*x_56 + 0.000249918903883737*x_57 + 0.000181080917867668*x_58 - 2.85200245642581e-5*x_59 + 4.83711811226439e-5*x_6 + 4.83133679834627e-5*x_60 + 4.74473055985047e-7*x_61 - 1.50620815430264e-5*x_62 - 4.33823699170667e-6*x_63 + 1.25604163751072e-5*x_64 + 9.56603389452496e-6*x_65 - 8.67379707635854e-6*x_66 + 1.0463335786322e-5*x_67 + 1.18000408890976e-5*x_68 + 1.44131248894672e-5*x_69 + 3.44591197687405e-5*x_7 + 1.31360960379462e-5*x_70 + 1.99005267419774e-5*x_71 + 3.4400366737974e-5*x_72 + 1.81490629083219e-5*x_73 + 2.50515480146205e-5*x_74 - 1.48015559871258e-6*x_75 + 8.30814690005515e-8*x_76 + 9.97177794942012e-6*x_77 + 3.21777123699705e-5*x_78 + 5.06165664295492e-6*x_79 + 2.84853950300826e-5*x_8 + 1.31685745595081e-5*x_80 + 3.94864662483055e-7*x_81 - 1.03836335222548e-5*x_82 + 9.01408118822502e-6*x_83 + 1.18738613077177e-5*x_84 + 7.56167311680471e-6*x_85 - 7.26462477596743e-5*x_86 + 2.05536231743727e-5*x_87 - 5.35452389815104e-5*x_88 + 7.81086458946868e-6*x_89 - 3.88692257397418e-5*x_9 + 3.47553456496378e-5*x_90 - 3.8897122186198e-6*x_91 - 0.000274317316769113*x_92 - 0.000147510941917584*x_93 - 1.45627426096781e-5*x_94 + 9.18473070829718e-5*x_95 - 6.43703362833139e-5*x_96 - 3.63305040665068e-6*x_97 + 9.32908921998257e-5*x_98 + 6.83419737278991e-5*x_99 + 1.35870242800466e-7*std::pow(7.56008005142212 - 7.57863998413086*x_29, 2) + 2.37633780168914e-7*std::pow(-9.79199981689453*x_13 - 9.96739959716797, 2) + 3.13500515820719e-7*std::pow(-9.3638391494751*x_18 - 5.88736009597778, 2) + 5.51871917374325e-9*std::pow(-9.32719993591309*x_28 - 3.25887989997864, 2) + 5.95271775072866e-9*std::pow(-9.69608020782471*x_29 - 5.72824001312256, 2) - 8.33415583548806e-8*std::pow(-6.40000009536743*x_3 - 0.823999881744385, 2) + 0.000891223209272075*std::sin(0.383359849452972*x_10 - 1.38967990875244) - 0.000718036455015698*std::sin(0.285519927740097*x_100 + 1.75823998451233) + 0.000780712886147178*std::sin(0.253679990768433*x_107 - 1.22095990180969) + 0.000803117953167221*std::sin(0.245599970221519*x_109 - 7.6048002243042) + 0.00107264239843554*std::sin(0.25655996799469*x_109 + 4.97463941574097) + 0.000354265138137054*std::sin(0.408079862594604*x_11 - 1.58663988113403) - 0.000576609769222302*std::sin(0.23471999168396*x_110 - 4.410560131073) - 9.7278079849724e-5*std::sin(0.280719965696335*x_110 + 7.9597601890564) - 0.000511595010889305*std::sin(0.283919930458069*x_110 + 4.74656009674072) + 0.000843772955500266*std::sin(0.239999979734421*x_111 + 4.98303985595703) + 0.00121223989591083*std::sin(0.267759948968887*x_112 + 4.9826397895813) + 0.000163064925142152*std::sin(0.344319850206375*x_112 + 1.63351988792419) - 0.00085252641874967*std::sin(0.324319839477539*x_113 + 1.80663990974426) - 0.000136866557946522*std::sin(0.258559972047806*x_114 - 1.42975986003876) + 0.000541094828014083*std::sin(0.269039958715439*x_116 + 8.17503929138184) - 0.000189782737387363*std::sin(0.31703993678093*x_116 + 7.74711990356445) + 0.00325875725160675*std::sin(0.262799948453903*x_118 + 8.14888000488281) + 0.000735861812020904*std::sin(0.270159959793091*x_119 - 7.64079999923706) + 0.000161620220028337*std::sin(0.297039926052094*x_119 + 1.72535991668701) - 7.30655087984718e-6*std::sin(0.360639840364456*x_12 + 1.83463990688324) - 0.000555963696183655*std::sin(0.308079928159714*x_120 + 4.95815992355347) - 0.00104941954103704*std::sin(0.285999953746796*x_14 + 1.7739999294281) + 0.000766733096584157*std::sin(0.329199850559235*x_14 - 1.32287991046906) + 0.00260847163284967*std::sin(0.283679932355881*x_15 - 4.61175966262817) + 6.55908213174658e-5*std::sin(0.315439850091934*x_15 - 8.15695953369141) - 0.000212939660141347*std::sin(0.341599822044373*x_15 + 5.05247974395752) - 0.000392105449806857*std::sin(0.327279835939407*x_16 + 1.80663990974426) + 0.000955466920607966*std::sin(0.383679836988449*x_16 - 7.60168027877808) + 0.000442430766862894*std::sin(0.395519822835922*x_16 + 4.79496002197266) - 0.00222169727260187*std::sin(0.151760026812553*x_18 + 1.7475198507309) - 0.00082830031407494*std::sin(0.186320006847382*x_19 + 4.78311967849731) - 0.000493647058166782*std::sin(0.245839968323708*x_19 + 1.5927197933197) - 0.000672137642575374*std::sin(0.356159836053848*x_2 + 8.18231964111328) - 0.00047152238403733*std::sin(0.287679940462112*x_20 - 4.59008026123047) + 0.000406632745020126*std::sin(0.302239924669266*x_20 - 4.4015998840332) - 0.000139420794351315*std::sin(0.344079852104187*x_20 + 1.80431985855103) + 0.000602235437961515*std::sin(0.346959829330444*x_20 - 1.35039985179901) + 0.00162132211495111*std::sin(0.42087984085083*x_20 + 7.9967999458313) - 0.000868059646066071*std::sin(0.381999850273132*x_22 - 4.39847993850708) - 0.000148849173110572*std::sin(0.479119867086411*x_23 + 1.40255987644196) + 0.000400734285803798*std::sin(0.276079952716827*x_24 + 4.81767988204956) + 7.1435920125238e-6*std::sin(0.348319828510284*x_24 - 7.5699200630188) - 0.000197525775590816*std::sin(0.370879858732224*x_24 + 8.21424007415771) + 0.000358216726963646*std::sin(0.392479836940765*x_25 + 1.80199980735779) + 0.000742888913234912*std::sin(0.443039864301682*x_25 - 1.40151989459991) - 0.000312176284908728*std::sin(0.30175992846489*x_26 - 1.37311983108521) + 0.00364588480988405*std::sin(0.105680070817471*x_27 - 1.46623992919922) - 0.000373301218075186*std::sin(0.395599842071533*x_27 + 8.00263977050781) - 0.000917667755955053*std::sin(0.33519983291626*x_28 - 4.36367988586426) - 0.000835179888947971*std::sin(0.22087998688221*x_29 + 1.8096798658371) - 0.000616964574517533*std::sin(0.316319912672043*x_3 + 1.85055994987488) - 5.6061976289536e-6*std::sin(0.394639849662781*x_3 + 8.19960021972656) + 0.000872023084136874*std::sin(0.320719838142395*x_32 + 8.20911979675293) - 0.000234760667466776*std::sin(0.271839946508408*x_33 + 8.16720008850098) + 0.000767637322973973*std::sin(0.2743199467659*x_33 + 4.98183965682983) + 0.00155530337355943*std::sin(0.282239943742752*x_33 + 4.96551990509033) - 0.000525508418693885*std::sin(0.267839968204498*x_36 - 7.61712026596069) + 0.00127113461712051*std::sin(0.291279941797256*x_36 - 7.6300802230835) + 0.00101489473817468*std::sin(0.222559988498688*x_37 - 1.37927985191345) - 0.000250600737450276*std::sin(0.249999970197678*x_38 - 7.82919979095459) - 0.000875472778835135*std::sin(0.371439844369888*x_4 + 8.19215965270996) + 0.000100409575743666*std::sin(0.243199974298477*x_40 + 1.5868798494339) + 0.00134311181894976*std::sin(0.246719971299171*x_41 - 1.21727979183197) - 0.00449462592311335*std::sin(0.197679996490479*x_43 - 1.37815976142883) - 0.000375687694151392*std::sin(0.242079973220825*x_43 + 1.76151990890503) - 0.000610200267476907*std::sin(0.245839968323708*x_44 + 1.78511989116669) + 0.00319118196618053*std::sin(0.168080016970634*x_45 + 7.99632024765015) + 0.000944057868009966*std::sin(0.207440003752708*x_47 - 7.60143995285034) - 0.000969216492514001*std::sin(0.283519923686981*x_48 - 4.45199966430664) + 0.000326942150015917*std::sin(0.431199848651886*x_5 - 7.61520004272461) - 0.000586821007806524*std::sin(0.274159938097*x_51 - 7.84543991088867) - 0.00095003767696146*std::sin(0.241199970245361*x_53 - 4.41567993164063) - 0.000447572040971397*std::sin(0.270639955997467*x_53 - 4.42847967147827) - 0.00144978342859328*std::sin(0.229999989271164*x_55 - 4.41167974472046) - 0.000804966720624925*std::sin(0.244719967246056*x_57 + 1.76287984848022) - 0.000163344645664235*std::sin(0.319679915904999*x_59 - 4.87175989151001) + 4.39325096126706e-5*std::sin(0.583919823169708*x_6 - 7.98712015151978) - 0.00058635976185195*std::sin(0.356159836053848*x_60 + 1.85079991817474) - 0.000729490010803316*std::sin(0.417679876089096*x_60 + 7.98752021789551) + 0.00192530022212364*std::sin(0.436959862709045*x_60 - 4.45959997177124) + 0.00108117245276932*std::sin(0.212479993700981*x_7 + 4.81024026870728) + 0.000756824555384948*std::sin(0.352559864521027*x_7 - 7.59416007995605) - 0.00116980306693037*std::sin(0.369039833545685*x_7 + 5.00751972198486) + 0.0004535016725301*std::sin(0.369439840316772*x_8 - 1.3796797990799) - 0.000966518392353048*std::sin(0.288959950208664*x_9 - 1.6341598033905) - 0.00103077289889495*std::sin(0.380959838628769*x_9 + 1.82615983486176) - 0.000465664975418995*std::sin(0.466959863901138*x_91 - 4.82599973678589) + 0.0011034815037457*std::sin(0.317919850349426*x_92 - 4.58975982666016) + 0.000506164914168319*std::sin(0.319039851427078*x_92 - 7.57272005081177) + 0.000447513184337964*std::sin(0.321999847888947*x_92 + 8.00944042205811) - 0.000627880868496867*std::sin(0.294959932565689*x_95 + 7.98992013931274) + 0.00181401999915095*std::sin(0.314799934625626*x_95 + 1.76271986961365) - 0.000535743889159349*std::sin(0.283279925584793*x_97 - 4.41336011886597) - 0.00142871011183811*std::sin(0.25927996635437*x_98 + 1.9579998254776) - 0.000440400542288913*std::sin(0.263199955224991*x_99 - 4.42944002151489) + 0.0813371201966856);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-9.11825352687061e-5*x_1 - 4.33665041556401e-5*x_10 - 0.000115598829850748*x_100 - 4.56565871807061e-5*x_101 + 9.70523333453731e-5*x_102 - 2.76613397398634e-5*x_103 - 0.000504761190368122*x_104 - 0.000433907362381272*x_105 - 0.000284525615221977*x_106 - 1.39522982980016e-5*x_107 - 0.000168316917850112*x_108 + 2.62918300975984e-6*x_109 + 0.00023248120436392*x_11 - 2.84542695217179e-5*x_110 - 0.000411622539450778*x_111 - 1.95785138223912e-5*x_112 - 1.67346626470374e-5*x_113 - 3.53991726785586e-5*x_114 - 0.000137416030730274*x_115 + 5.84107296369788e-5*x_116 - 0.000173551479534047*x_117 - 0.000132723726492778*x_118 + 8.64149660478633e-5*x_119 - 0.000164267430137845*x_12 - 4.59360489914825e-5*x_120 + 1.39276774477053e-6*x_13 - 8.52924753925265e-5*x_14 + 3.23201574635533e-5*x_15 - 3.90234469840177e-5*x_16 - 0.000107896962745535*x_17 + 3.14800813180491e-5*x_18 - 6.28037552440451e-5*x_19 - 2.82656188975126e-5*x_2 + 4.09327955153964e-5*x_20 - 3.22581001662662e-5*x_21 + 7.72363960306229e-5*x_22 - 2.15070362394551e-5*x_23 - 3.90893969300962e-6*x_24 - 2.008411608028e-6*x_25 + 2.28323765298796e-5*x_26 + 1.72100880273678e-5*x_27 + 3.39364581900781e-5*x_28 + 1.50692841985628e-5*x_29 - 6.14095127640716e-5*x_3 - 1.32785247007504e-5*x_30 - 1.02251958683845e-7*x_31 + 2.89995566495859e-5*x_32 + 0.000135204396619275*x_33 - 0.000339140747651094*x_34 - 0.000227474828450442*x_35 - 0.000147573981685404*x_36 - 4.32523265830398e-5*x_37 + 5.03953245739132e-5*x_38 - 0.000289312742883264*x_39 - 4.2965870551593e-5*x_4 - 0.000282485427982936*x_40 - 0.000155656283241716*x_41 - 0.000211470942152449*x_42 - 0.000522169024710579*x_43 + 0.000254572615673756*x_44 - 0.000231613910321583*x_45 - 5.46871359018597e-5*x_46 - 0.000295177693760408*x_47 - 0.000101377434496366*x_48 - 0.000340475416641365*x_49 - 5.51400322545269e-5*x_5 - 0.000323714334331575*x_50 + 5.24715620891984e-5*x_51 - 5.62541669971366e-5*x_52 - 5.52917545644471e-5*x_53 - 0.000455314031398771*x_54 - 0.000233999692359162*x_55 - 0.000431920998031436*x_56 - 0.000300887415490844*x_57 - 0.000563914338969111*x_58 - 0.000100997233782877*x_59 - 1.98350421843077e-6*x_6 - 1.63949450883509e-7*x_60 - 1.29632670014432e-5*x_61 - 4.53012811928972e-6*x_62 + 1.41615978565067e-6*x_63 + 9.46514591659211e-6*x_64 - 6.91674328638712e-6*x_65 + 7.45068928251285e-6*x_66 - 2.69871668424616e-6*x_67 + 3.07857305538563e-6*x_68 + 6.39205124165627e-6*x_69 - 2.25591347501654e-5*x_7 - 2.25201346220994e-6*x_70 + 1.05019316684542e-5*x_71 - 4.89181718731998e-6*x_72 - 6.90131336582608e-6*x_73 - 6.43721318307922e-6*x_74 + 3.6323714760031e-6*x_75 + 1.77013199979189e-5*x_76 + 1.20766122006261e-6*x_77 + 1.30381578577396e-6*x_78 + 4.77819022873824e-6*x_79 - 7.78138861604308e-5*x_8 + 3.11211830739252e-6*x_80 - 1.06459248935611e-5*x_81 + 2.60695688634541e-6*x_82 + 1.06945464938644e-5*x_83 - 2.50243035081254e-6*x_84 + 1.2619772151253e-5*x_85 - 5.8252656817077e-5*x_86 + 6.4439930155485e-6*x_87 - 1.0110150460774e-5*x_88 + 1.68085573873219e-6*x_89 - 1.65794534287137e-5*x_9 + 1.31187267953321e-5*x_90 + 1.92012486071573e-6*x_91 - 4.83999878044607e-5*x_92 - 0.000118832555446386*x_93 - 1.43163303517904e-5*x_94 - 0.000153208972404971*x_95 - 2.35223843401709e-5*x_96 - 9.78966968397251e-5*x_97 - 0.000149161094442484*x_98 + 1.97994094428351e-5*x_99 + 1.13233822936399e-7*std::pow(7.56008005142212 - 7.57863998413086*x_29, 2) + 9.09415128431902e-8*std::pow(-9.79199981689453*x_13 - 9.96739959716797, 2) - 3.81589569366308e-7*std::pow(-9.3638391494751*x_18 - 5.88736009597778, 2) - 1.96529818905315e-8*std::pow(-9.32719993591309*x_28 - 3.25887989997864, 2) + 2.67210253282405e-9*std::pow(-6.40000009536743*x_3 - 0.823999881744385, 2) - 0.00108478762704771*std::sin(0.383359849452972*x_10 - 1.38967990875244) - 0.000274789726651122*std::sin(0.285519927740097*x_100 + 1.75823998451233) + 0.000650643605929077*std::sin(0.253679990768433*x_107 - 1.22095990180969) + 0.000307350081291631*std::sin(0.245599970221519*x_109 - 7.6048002243042) - 0.00130560917844592*std::sin(0.25655996799469*x_109 + 4.97463941574097) + 0.000295243425620878*std::sin(0.408079862594604*x_11 - 1.58663988113403) + 0.000212802397485606*std::sin(0.23471999168396*x_110 - 4.410560131073) + 0.000622708129790897*std::sin(0.283919930458069*x_110 + 4.74656009674072) + 0.000322908590751787*std::sin(0.239999979734421*x_111 + 4.98303985595703) + 0.00101027682663076*std::sin(0.267759948968887*x_112 + 4.9826397895813) - 6.01804007983823e-5*std::sin(0.344319850206375*x_112 + 1.63351988792419) - 0.000710492772807286*std::sin(0.324319839477539*x_113 + 1.80663990974426) - 0.000126170322158443*std::sin(0.258559972047806*x_114 - 1.42975986003876) - 0.000658615000577248*std::sin(0.269039958715439*x_116 + 8.17503929138184) - 7.26291070118927e-5*std::sin(0.31703993678093*x_116 + 7.74711990356445) + 0.000142402963035018*std::sin(0.262799948453903*x_118 + 8.14888000488281) + 0.000678353596961572*std::sin(0.270159959793091*x_119 - 7.64079999923706) - 0.000212765119424075*std::sin(0.308079928159714*x_120 + 4.95815992355347) + 0.00127734255779635*std::sin(0.285999953746796*x_14 + 1.7739999294281) + 0.000638992894313055*std::sin(0.329199850559235*x_14 - 1.32287991046906) + 0.00011398642514027*std::sin(0.283679932355881*x_15 - 4.61175966262817) - 7.98364659636713e-5*std::sin(0.315439850091934*x_15 - 8.15695953369141) + 7.85870663602627e-5*std::sin(0.341599822044373*x_15 + 5.05247974395752) + 0.000477266678002999*std::sin(0.327279835939407*x_16 + 1.80663990974426) + 0.000880796382940712*std::sin(0.383679836988449*x_16 - 7.60168027877808) + 0.000368720376765208*std::sin(0.395519822835922*x_16 + 4.79496002197266) + 7.12322042744729e-5*std::sin(0.151760026812553*x_18 + 1.7475198507309) - 0.000690302815163613*std::sin(0.186320006847382*x_19 + 4.78311967849731) + 0.00125032840436582*std::sin(0.245839968323708*x_19 + 1.5927197933197) - 0.000560157347477761*std::sin(0.356159836053848*x_2 + 8.18231964111328) + 0.00119429017210303*std::sin(0.287679940462112*x_20 - 4.59008026123047) + 0.000338886420607713*std::sin(0.302239924669266*x_20 - 4.4015998840332) + 0.000496498238139445*std::sin(0.344079852104187*x_20 + 1.80431985855103) - 1.93089122749662e-5*std::sin(0.346959829330444*x_20 - 1.35039985179901) + 7.08494236842597e-5*std::sin(0.42087984085083*x_20 + 7.9967999458313) + 0.00105659317867295*std::sin(0.381999850273132*x_22 - 4.39847993850708) - 0.000124050421673156*std::sin(0.479119867086411*x_23 + 1.40255987644196) - 0.000147894158797808*std::sin(0.276079952716827*x_24 + 4.81767988204956) + 0.000703418740542004*std::sin(0.370879858732224*x_24 + 8.21424007415771) + 0.000298536667027423*std::sin(0.392479836940765*x_25 + 1.80199980735779) + 0.000684831524348026*std::sin(0.443039864301682*x_25 - 1.40151989459991) - 0.000260166710839031*std::sin(0.30175992846489*x_26 - 1.37311983108521) + 0.00139526577419751*std::sin(0.105680070817471*x_27 - 1.46623992919922) - 0.000311108033357564*std::sin(0.395599842071533*x_27 + 8.00263977050781) + 2.94223240287522e-5*std::sin(0.33519983291626*x_28 - 4.36367988586426) + 0.000308229745985054*std::sin(0.22087998688221*x_29 + 1.8096798658371) - 0.000236109915591114*std::sin(0.316319912672043*x_3 + 1.85055994987488) + 1.99645057137114e-5*std::sin(0.394639849662781*x_3 + 8.19960021972656) - 2.79588615547735e-5*std::sin(0.320719838142395*x_32 + 8.20911979675293) + 0.000836017742719134*std::sin(0.271839946508408*x_33 + 8.16720008850098) + 0.000293771783693915*std::sin(0.2743199467659*x_33 + 4.98183965682983) - 0.00189309910064042*std::sin(0.282239943742752*x_33 + 4.96551990509033) - 0.000201110004536746*std::sin(0.267839968204498*x_36 - 7.61712026596069) - 0.00154721184392248*std::sin(0.291279941797256*x_36 - 7.6300802230835) - 0.00257056473362491*std::sin(0.222559988498688*x_37 - 1.37927985191345) - 0.000208849847820234*std::sin(0.249999970197678*x_38 - 7.82919979095459) - 0.000729616195430209*std::sin(0.371439844369888*x_4 + 8.19215965270996) + 9.25624835565813e-5*std::sin(0.243199974298477*x_40 + 1.5868798494339) + 0.00111934506596922*std::sin(0.246719971299171*x_41 - 1.21727979183197) - 0.000196408630581417*std::sin(0.197679996490479*x_43 - 1.37815976142883) + 0.000138650515979089*std::sin(0.242079973220825*x_43 + 1.76151990890503) - 0.000508538938468625*std::sin(0.245839968323708*x_44 + 1.78511989116669) - 0.000102315886369961*std::sin(0.168080016970634*x_45 + 7.99632024765015) - 0.00034841202560378*std::sin(0.207440003752708*x_47 - 7.60143995285034) - 0.000370915338884652*std::sin(0.283519923686981*x_48 - 4.45199966430664) - 0.000120660587239657*std::sin(0.431199848651886*x_5 - 7.61520004272461) + 1.88146938001472e-5*std::sin(0.274159938097*x_51 - 7.84543991088867) - 0.000363575681620231*std::sin(0.241199970245361*x_53 - 4.41567993164063) + 0.00016518000292416*std::sin(0.270639955997467*x_53 - 4.42847967147827) + 0.00176466132039059*std::sin(0.229999989271164*x_55 - 4.41167974472046) + 0.00203885091325006*std::sin(0.244719967246056*x_57 + 1.76287984848022) + 0.000198821404915814*std::sin(0.319679915904999*x_59 - 4.87175989151001) - 0.0001564502176395*std::sin(0.583919823169708*x_6 - 7.98712015151978) + 0.000216400709407817*std::sin(0.356159836053848*x_60 + 1.85079991817474) + 0.000887927658909019*std::sin(0.417679876089096*x_60 + 7.98752021789551) + 0.00177483640212517*std::sin(0.436959862709045*x_60 - 4.45959997177124) - 3.46646223863811e-5*std::sin(0.212479993700981*x_7 + 4.81024026870728) + 0.000289633780073938*std::sin(0.352559864521027*x_7 - 7.59416007995605) - 0.0010783819804558*std::sin(0.369039833545685*x_7 + 5.00751972198486) + 0.000173553306047182*std::sin(0.369439840316772*x_8 - 1.3796797990799) - 4.22354512079887e-5*std::sin(0.288959950208664*x_9 - 1.6341598033905) - 0.000950217136143534*std::sin(0.380959838628769*x_9 + 1.82615983486176) - 2.03488836882828e-5*std::sin(0.466959863901138*x_91 - 4.82599973678589) + 0.00101724350281299*std::sin(0.317919850349426*x_92 - 4.58975982666016) - 0.00128203411528123*std::sin(0.319039851427078*x_92 - 7.57272005081177) + 0.000372956047126864*std::sin(0.321999847888947*x_92 + 8.00944042205811) + 0.000764250067008115*std::sin(0.294959932565689*x_95 + 7.98992013931274) + 0.00167225282149757*std::sin(0.314799934625626*x_95 + 1.76271986961365) - 0.000446487232479718*std::sin(0.283279925584793*x_97 - 4.41336011886597) - 0.00119068240769173*std::sin(0.25927996635437*x_98 + 1.9579998254776) + 0.000162533304594273*std::sin(0.263199955224991*x_99 - 4.42944002151489) - 0.2242601364851*std::sin(0.00115902427196375*x_1 + 0.0014028656241632*x_10 + 0.000285096663300065*x_100 - 0.00142477196186782*x_101 + 0.00169581112947592*x_102 + 0.00207636252269699*x_103 + 0.00662067607888051*x_104 + 0.00559643472819028*x_105 - 0.00175957417529718*x_106 - 1.99077367719111e-5*x_107 + 0.000764217779362863*x_108 - 0.00192137052801923*x_109 + 0.00319333197946711*x_11 + 0.000339249775769966*x_111 + 0.000571789815955798*x_112 + 0.00581577542545092*x_113 + 0.00116664958437763*x_114 - 0.0243955373694655*x_115 + 5.73351999914692e-5*x_116 - 0.0216732038996824*x_117 + 0.000869942224975265*x_118 + 0.000800435189739843*x_120 + 0.00156138817747648*x_13 - 0.0095545730099076*x_14 + 0.000896525738705054*x_15 - 0.0019798409254336*x_16 + 0.00185359673732976*x_17 + 0.00137955089271051*x_18 + 0.0022987593287946*x_19 + 0.000819313991030188*x_2 + 0.00114158915597313*x_20 + 0.00182921047089043*x_21 + 0.00481020289914402*x_22 - 0.010095662844604*x_23 + 0.00297636483942577*x_25 + 0.00397557233905502*x_26 + 0.0119299462933937*x_27 + 0.00149986188667356*x_28 - 0.00102371815300339*x_3 + 0.0086381167120909*x_30 + 4.11723708140471e-5*x_31 + 0.000334374016658761*x_32 - 0.00110305316973944*x_33 + 0.00458182582184305*x_34 + 0.000193494345667695*x_35 + 0.000815973472942491*x_36 - 0.00400209426841405*x_37 - 0.000133732709829795*x_38 - 0.00387538154448131*x_39 + 0.00121438655647583*x_4 - 0.020882852119854*x_40 - 0.0274163379390191*x_41 - 9.13119520300035e-5*x_42 + 0.0111585418207581*x_43 + 0.00454684759051095*x_44 + 0.00123674947738694*x_45 + 0.00253409794900795*x_46 + 0.000595471142013273*x_47 - 0.00553157193924362*x_48 + 0.0157759560814141*x_49 + 0.00136457289721637*x_5 - 0.0405439819538118*x_50 - 0.02139940480928*x_51 - 0.00789739523271823*x_52 - 0.0159137646746351*x_53 - 0.0313849788851522*x_54 - 3.1997825775752e-5*x_55 + 0.000709638685121723*x_56 - 0.0221925602068801*x_57 - 0.0188063738641801*x_58 - 0.0340763003068009*x_59 + 0.00193943076813448*x_6 + 0.000568973296208903*x_60 - 5.91328182229097e-5*x_61 + 0.000136771773772999*x_62 + 0.000777902402262061*x_63 + 0.00044026832730868*x_64 - 0.0001701240543966*x_65 + 0.00154118431595265*x_66 + 0.000236901256790111*x_67 + 0.000528587150794653*x_68 - 8.14393156697132e-5*x_69 + 0.00848758853767203*x_7 + 0.000835271475881559*x_70 - 6.7104418059141e-5*x_71 + 0.000404526998163059*x_72 + 0.00043328338429765*x_73 + 0.000209326905659873*x_74 + 0.000623976103657715*x_75 - 5.10232610034219e-6*x_76 + 0.000270825017928693*x_77 + 4.14095129796175e-6*x_78 - 0.000570960390122749*x_79 + 0.00211558879626734*x_8 - 0.00298196853800019*x_80 + 0.000648866712459139*x_81 - 0.000124069538016024*x_82 + 0.000336232593292894*x_83 - 0.000524179154358596*x_84 - 0.000330480219315784*x_85 + 0.000270588118632115*x_86 - 0.000307109447168024*x_87 + 0.000583665326660612*x_88 + 0.000166172785997022*x_89 - 0.00848954531376854*x_9 - 9.62996439706669e-5*x_90 + 3.67641541036039e-5*x_91 + 0.00473813509141388*x_92 + 0.00953687208257791*x_93 + 7.2828457936775e-5*x_94 + 0.000260990493477723*x_95 - 2.91557228490338e-5*x_96 + 0.00388620724892417*x_97 + 9.33428932217169e-5*x_98 + 0.0108225244106656*x_99 + 5.56363495986061e-6*std::pow(-9.69608020782471*x_29 - 5.72824001312256, 2) - 0.0909197695143176*std::sin(0.280719965696335*x_110 + 7.9597601890564) + 0.151056365180417*std::sin(0.297039926052094*x_119 + 1.72535991668701) - 0.00682897856296683*std::sin(0.360639840364456*x_12 + 1.83463990688324) + 0.00667667104743769*std::sin(0.348319828510284*x_24 - 7.5699200630188) - 4.73726211451605) + 0.27502992915555);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000219610879870186*x_1 + 8.56203385724626e-5*x_10 - 0.000326465846336235*x_100 - 0.000109779821697895*x_101 + 0.000403001446164989*x_102 - 0.000468391916215181*x_103 - 0.00028422977383369*x_104 - 0.000312729061738254*x_105 - 0.000686201966377602*x_106 - 9.88052384111962e-5*x_107 - 0.000378535340087748*x_108 + 2.78392695353016e-5*x_109 + 0.000598434881246847*x_11 - 4.90707350524705e-5*x_110 - 0.000261507992271066*x_111 - 0.000125408022979062*x_112 - 2.8434031144143e-5*x_113 - 3.42254282691347e-5*x_114 - 0.000361112692114976*x_115 + 0.000119867078318916*x_116 - 0.000551766116694465*x_117 - 3.99921669891539e-5*x_118 + 0.000277999254216804*x_119 - 8.44509220055382e-5*x_12 + 1.90065194700519e-5*x_120 + 0.000292199308740425*x_13 - 0.000434805871869351*x_14 + 9.38084514936172e-5*x_15 - 7.22028349979539e-5*x_16 - 0.000223022304145107*x_17 + 0.000167365273804656*x_18 - 0.000401426264337957*x_19 - 3.86162204453038e-5*x_2 + 8.60661137195615e-5*x_20 - 0.000169373703206853*x_21 - 0.000141268890686342*x_22 - 6.43729705028228e-6*x_23 + 8.70652901418927e-5*x_24 - 2.23888331159636e-5*x_25 + 4.29478108758564e-5*x_26 + 3.03164926352856e-5*x_27 - 2.20652688134119e-5*x_28 + 4.26420667058821e-6*x_29 - 5.94895914304298e-5*x_3 - 0.000207823175041791*x_30 - 4.29518737183528e-6*x_31 - 1.27724408833777e-5*x_32 - 0.00010191975769148*x_33 - 0.000642436919198203*x_34 + 0.000170844553125808*x_35 - 0.000305519878114743*x_36 - 0.000313579436755399*x_37 - 5.75283241349891e-5*x_38 + 1.3373244903813e-5*x_39 - 6.46561498126665e-5*x_4 - 0.000197161015182408*x_40 + 0.000223553890045149*x_41 - 8.47132225695126e-5*x_42 - 0.000917796553679512*x_43 - 6.26949135746776e-5*x_44 + 9.25548674648649e-6*x_45 - 0.000157895392604988*x_46 + 1.42098459322057e-5*x_47 - 0.000575346948939*x_48 - 0.000903278629058577*x_49 - 0.000114550577952533*x_5 - 0.000561176702664501*x_50 + 0.000464472531716153*x_51 - 6.47229132859278e-6*x_52 - 2.1799965869907e-5*x_53 - 7.57172155697798e-5*x_54 - 0.000888125054282595*x_55 - 0.000691723047255472*x_56 - 0.000216798751863658*x_57 - 0.000877550473913066*x_58 - 2.58835145249397e-6*x_59 + 0.000129680133593135*x_6 - 7.36193786068239e-5*x_60 - 7.90142754242526e-6*x_61 - 9.8677740192098e-6*x_62 - 1.1063598670148e-6*x_63 - 1.61254533844217e-6*x_64 - 4.70826409174304e-6*x_65 - 3.70206586379111e-5*x_66 + 1.35968213935862e-6*x_67 + 5.85416671420319e-6*x_68 + 1.78769152424004e-5*x_69 - 7.16935142922253e-6*x_7 + 1.64151779592512e-5*x_70 + 4.52169933527312e-5*x_71 + 4.19212750723837e-5*x_72 + 3.61456238682073e-6*x_73 + 2.01584624320789e-5*x_74 - 2.03240043673139e-6*x_75 + 8.76077136104218e-6*x_76 + 2.39191938319022e-6*x_77 + 1.19426282055667e-5*x_78 + 4.95405838986709e-6*x_79 - 4.36280701430614e-5*x_8 + 1.23625204905293e-5*x_80 - 1.2262352652058e-5*x_81 - 1.76331741204955e-5*x_82 + 1.85590011299151e-5*x_83 + 4.55237999609023e-6*x_84 + 5.82409254479254e-6*x_85 - 7.89078022138789e-5*x_86 + 1.17004166992036e-5*x_87 - 3.63499439416064e-5*x_88 + 1.88965571804868e-6*x_89 + 1.02551395355292e-5*x_9 - 8.95725827333274e-6*x_90 + 9.77804542336031e-7*x_91 - 6.91005191690541e-6*x_92 + 9.16836704269307e-6*x_93 - 2.4914058101715e-5*x_94 - 2.6908283855063e-5*x_95 + 1.33246435104061e-5*x_96 - 0.00017989919466686*x_97 - 0.00017977362759511*x_98 + 0.000188261346823882*x_99 - 7.33262688490383e-8*std::pow(7.56008005142212 - 7.57863998413086*x_29, 2) - 7.91591295471466e-10*std::pow(-9.79199981689453*x_13 - 9.96739959716797, 2) - 4.88750036140037e-7*std::pow(-9.3638391494751*x_18 - 5.88736009597778, 2) - 5.82422814834493e-10*std::pow(-9.32719993591309*x_28 - 3.25887989997864, 2) - 1.66249815051705e-7*std::pow(-6.40000009536743*x_3 - 0.823999881744385, 2) - 0.00138942474974958*std::sin(0.383359849452972*x_10 - 1.38967990875244) + 2.39187966970686e-6*std::sin(0.285519927740097*x_100 + 1.75823998451233) - 0.000421334074360985*std::sin(0.253679990768433*x_107 - 1.22095990180969) - 2.67529801744574e-6*std::sin(0.245599970221519*x_109 - 7.6048002243042) - 0.00167225884661865*std::sin(0.25655996799469*x_109 + 4.97463941574097) - 0.000191189330551415*std::sin(0.408079862594604*x_11 - 1.58663988113403) + 0.000130284128255456*std::sin(0.23471999168396*x_110 - 4.410560131073) + 0.000797581080230828*std::sin(0.283919930458069*x_110 + 4.74656009674072) - 2.81072550566452e-6*std::sin(0.239999979734421*x_111 + 4.98303985595703) - 0.000654219987283212*std::sin(0.267759948968887*x_112 + 4.9826397895813) - 3.68442797107655e-5*std::sin(0.344319850206375*x_112 + 1.63351988792419) + 0.000460090304496988*std::sin(0.324319839477539*x_113 + 1.80663990974426) - 0.000309634561766001*std::sin(0.258559972047806*x_114 - 1.42975986003876) - 0.000843571552202188*std::sin(0.269039958715439*x_116 + 8.17503929138184) + 6.32192791949854e-7*std::sin(0.31703993678093*x_116 + 7.74711990356445) - 0.000379937617881123*std::sin(0.262799948453903*x_118 + 8.14888000488281) + 0.00166474742335856*std::sin(0.270159959793091*x_119 - 7.64079999923706) + 1.85199268464397e-6*std::sin(0.308079928159714*x_120 + 4.95815992355347) + 0.00163605420956062*std::sin(0.285999953746796*x_14 + 1.7739999294281) - 0.000413789480439441*std::sin(0.329199850559235*x_14 - 1.32287991046906) - 0.000304120995206606*std::sin(0.283679932355881*x_15 - 4.61175966262817) - 0.000102256662019972*std::sin(0.315439850091934*x_15 - 8.15695953369141) + 4.81134026396156e-5*std::sin(0.341599822044373*x_15 + 5.05247974395752) + 0.000611295813220929*std::sin(0.327279835939407*x_16 + 1.80663990974426) + 0.00216156222296431*std::sin(0.383679836988449*x_16 - 7.60168027877808) - 0.000238770437804528*std::sin(0.395519822835922*x_16 + 4.79496002197266) - 0.00443184370393177*std::sin(0.151760026812553*x_18 + 1.7475198507309) + 0.000447015993095683*std::sin(0.186320006847382*x_19 + 4.78311967849731) - 4.43096334068588e-5*std::sin(0.245839968323708*x_19 + 1.5927197933197) + 0.000362738333774962*std::sin(0.356159836053848*x_2 + 8.18231964111328) - 4.23237283281112e-5*std::sin(0.287679940462112*x_20 - 4.59008026123047) - 0.000219451009798784*std::sin(0.302239924669266*x_20 - 4.4015998840332) + 1.47138944628479e-5*std::sin(0.344079852104187*x_20 + 1.80431985855103) + 0.00120133978959636*std::sin(0.346959829330444*x_20 - 1.35039985179901) - 0.000189029502540819*std::sin(0.42087984085083*x_20 + 7.9967999458313) + 0.00135331255285438*std::sin(0.381999850273132*x_22 - 4.39847993850708) + 8.03307204027857e-5*std::sin(0.479119867086411*x_23 + 1.40255987644196) - 9.05453217666385e-5*std::sin(0.276079952716827*x_24 + 4.81767988204956) + 2.08460540571296e-5*std::sin(0.370879858732224*x_24 + 8.21424007415771) - 0.000193321918664215*std::sin(0.392479836940765*x_25 + 1.80199980735779) + 0.0016806449036308*std::sin(0.443039864301682*x_25 - 1.40151989459991) + 0.000168474875172836*std::sin(0.30175992846489*x_26 - 1.37311983108521) - 1.21449512680579e-5*std::sin(0.105680070817471*x_27 - 1.46623992919922) + 0.000201462696423184*std::sin(0.395599842071533*x_27 + 8.00263977050781) - 0.00183056445929184*std::sin(0.33519983291626*x_28 - 4.36367988586426) + 0.000188707666043939*std::sin(0.22087998688221*x_29 + 1.8096798658371) + 2.05519512611037e-6*std::sin(0.316319912672043*x_3 + 1.85055994987488) + 5.91654929482288e-7*std::sin(0.394639849662781*x_3 + 8.19960021972656) + 0.00173951242717653*std::sin(0.320719838142395*x_32 + 8.20911979675293) + 2.47756706681059e-5*std::sin(0.271839946508408*x_33 + 8.16720008850098) - 2.55710708516812e-6*std::sin(0.2743199467659*x_33 + 4.98183965682983) - 0.00242473151294782*std::sin(0.282239943742752*x_33 + 4.96551990509033) + 1.75054190376201e-6*std::sin(0.267839968204498*x_36 - 7.61712026596069) - 0.00198170994529331*std::sin(0.291279941797256*x_36 - 7.6300802230835) + 9.10966915554409e-5*std::sin(0.222559988498688*x_37 - 1.37927985191345) + 0.000135243867010909*std::sin(0.249999970197678*x_38 - 7.82919979095459) + 0.000472473965069411*std::sin(0.371439844369888*x_4 + 8.19215965270996) + 0.000227157571936951*std::sin(0.243199974298477*x_40 + 1.5868798494339) - 0.000724848769684346*std::sin(0.246719971299171*x_41 - 1.21727979183197) + 0.000524027208731934*std::sin(0.197679996490479*x_43 - 1.37815976142883) + 8.4886081265727e-5*std::sin(0.242079973220825*x_43 + 1.76151990890503) + 0.000329312054961701*std::sin(0.245839968323708*x_44 + 1.78511989116669) + 0.00636577263668098*std::sin(0.168080016970634*x_45 + 7.99632024765015) - 0.000213308485082159*std::sin(0.207440003752708*x_47 - 7.60143995285034) + 3.22859543940307e-6*std::sin(0.283519923686981*x_48 - 4.45199966430664) - 7.38720973497178e-5*std::sin(0.431199848651886*x_5 - 7.61520004272461) - 0.00117059107055414*std::sin(0.274159938097*x_51 - 7.84543991088867) + 3.16470812743062e-6*std::sin(0.241199970245361*x_53 - 4.41567993164063) + 0.000101128243574716*std::sin(0.270639955997467*x_53 - 4.42847967147827) + 0.00226022499920035*std::sin(0.229999989271164*x_55 - 4.41167974472046) - 7.22536065100203e-5*std::sin(0.244719967246056*x_57 + 1.76287984848022) + 0.000254655726044583*std::sin(0.319679915904999*x_59 - 4.87175989151001) - 4.63645550820801e-6*std::sin(0.583919823169708*x_6 - 7.98712015151978) + 0.000132487124732543*std::sin(0.356159836053848*x_60 + 1.85079991817474) + 0.00113728128392557*std::sin(0.417679876089096*x_60 + 7.98752021789551) + 0.00435562565092173*std::sin(0.436959862709045*x_60 - 4.45959997177124) + 0.00215672377454856*std::sin(0.212479993700981*x_7 + 4.81024026870728) - 2.52108824686431e-6*std::sin(0.352559864521027*x_7 - 7.59416007995605) - 0.0026464569973553*std::sin(0.369039833545685*x_7 + 5.00751972198486) - 1.51067738013259e-6*std::sin(0.369439840316772*x_8 - 1.3796797990799) + 0.000112686115373538*std::sin(0.288959950208664*x_9 - 1.6341598033905) - 0.00233192767918014*std::sin(0.380959838628769*x_9 + 1.82615983486176) + 5.42917522942624e-5*std::sin(0.466959863901138*x_91 - 4.82599973678589) + 0.00249641707189486*std::sin(0.317919850349426*x_92 - 4.58975982666016) + 4.54332329529145e-5*std::sin(0.319039851427078*x_92 - 7.57272005081177) - 0.000241513309992718*std::sin(0.321999847888947*x_92 + 8.00944042205811) + 0.000978871745604959*std::sin(0.294959932565689*x_95 + 7.98992013931274) + 0.0041038753067154*std::sin(0.314799934625626*x_95 + 1.76271986961365) + 0.000289129537425048*std::sin(0.283279925584793*x_97 - 4.41336011886597) + 0.000771044340605399*std::sin(0.25927996635437*x_98 + 1.9579998254776) + 9.95078540079682e-5*std::sin(0.263199955224991*x_99 - 4.42944002151489) + 0.0537805780768394*std::sin(0.0011434790934061*x_1 + 0.00138404997280239*x_10 + 0.000281272861983395*x_100 - 0.00140566249618457*x_101 + 0.0016730664057929*x_102 + 0.00204851373044432*x_103 + 0.00653187760044647*x_104 + 0.00552137367965115*x_105 - 0.00173597424266241*x_106 - 1.96407282801272e-5*x_107 + 0.000753967863011248*x_108 - 0.0018956005345377*x_109 + 0.00315050206035719*x_11 + 0.000334699656788378*x_111 + 0.000564120800731972*x_112 + 0.00573777251418609*x_113 + 0.00115100213285997*x_114 - 0.0240683371601244*x_115 + 5.65662032214574e-5*x_116 - 0.021382516437231*x_117 + 0.000858274300886705*x_118 + 0.000789699514698937*x_120 + 0.00154044637444113*x_13 - 0.00942642423246277*x_14 + 0.000884501268616885*x_15 - 0.00195328670957629*x_16 + 0.00182873574610407*x_17 + 0.00136104794546834*x_18 + 0.00226792768437476*x_19 + 0.000808325107886475*x_2 + 0.0011262778223813*x_20 + 0.00180467655552961*x_21 + 0.00474568702594407*x_22 - 0.00996025680922289*x_23 + 0.00293644494818556*x_25 + 0.00392225077938249*x_26 + 0.011769938302362*x_27 + 0.0014797452925658*x_28 - 0.00100998774039161*x_3 + 0.00852225971932604*x_30 + 4.06201547203657e-5*x_31 + 0.000329889292809804*x_32 - 0.00108825869226649*x_33 + 0.00452037300998789*x_34 + 0.000190899141903583*x_35 + 0.000805029393821785*x_36 - 0.00394841698872982*x_37 - 0.000131939046915576*x_38 - 0.00382340377357072*x_39 + 0.00119809884247789*x_4 - 0.0206027650907481*x_40 - 0.0270486218531976*x_41 - 9.00872489473423e-5*x_42 + 0.0110088801361475*x_43 + 0.00448586391710684*x_44 + 0.00122016182523667*x_45 + 0.00250010987295745*x_46 + 0.000587484505794831*x_47 - 0.0054573808497384*x_48 + 0.015564364262213*x_49 + 0.00134627083930847*x_5 - 0.0400001939985846*x_50 - 0.0211123896217345*x_51 - 0.00779147301693507*x_52 - 0.0157003245255584*x_53 - 0.0309640342055634*x_54 - 3.15686614112321e-5*x_55 + 0.00070012079982935*x_56 - 0.0218949069830329*x_57 - 0.018554137179572*x_58 - 0.0336192588231438*x_59 + 0.00191341854533629*x_6 + 0.000561342056986353*x_60 - 5.8339711262057e-5*x_61 + 0.000134937350028495*x_62 + 0.00076746894367444*x_63 + 0.000434363317442328*x_64 - 0.000167842299935959*x_65 + 0.0015205134931224*x_66 + 0.000233723866612515*x_67 + 0.000521497582576677*x_68 - 8.03470273248342e-5*x_69 + 0.00837375047359219*x_7 + 0.000824068566200744*x_70 - 6.62043936282734e-5*x_71 + 0.000399101361642801*x_72 + 0.000427472058566262*x_73 + 0.000206519350888058*x_74 + 0.000615607150408249*x_75 - 5.0338921838076e-6*x_76 + 0.000267192632168173*x_77 + 4.08541162646182e-6*x_78 - 0.000563302499405102*x_79 + 0.00208721388955654*x_8 - 0.00294197348828657*x_80 + 0.000640163918954912*x_81 - 0.000122405480438735*x_82 + 0.000331722941660852*x_83 - 0.000517148707501007*x_84 - 0.000326047720235909*x_85 + 0.000266958910235482*x_86 - 0.000302990403841281*x_87 + 0.000575837033552073*x_88 + 0.000163944027124382*x_89 - 0.0083756810048252*x_9 - 9.50080444789454e-5*x_90 + 3.62710623246951e-5*x_91 + 0.00467458581310458*x_92 + 0.0094089607152397*x_93 + 7.1851660979118e-5*x_94 + 0.000257490011286713*x_95 - 2.87646776150135e-5*x_96 + 0.00383408428044296*x_97 + 9.20909505512153e-5*x_98 + 0.010677369491586*x_99 + 5.48901383157826e-6*std::pow(-9.69608020782471*x_29 - 5.72824001312256, 2) - 0.0897003265003029*std::sin(0.280719965696335*x_110 + 7.9597601890564) + 0.149030352243674*std::sin(0.297039926052094*x_119 + 1.72535991668701) - 0.00673738626960807*std::sin(0.360639840364456*x_12 + 1.83463990688324) + 0.0065871215478166*std::sin(0.348319828510284*x_24 - 7.5699200630188) + 1.56106579902102) - 0.00290642797856358);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000296471146314477*x_1 + 9.40740908348263e-5*x_10 - 0.000510975750467945*x_100 + 9.69345427881984e-5*x_101 + 0.000436774006513971*x_102 - 0.000277289646233101*x_103 + 0.000186576766957853*x_104 - 0.000473757219432049*x_105 - 0.000659740968158197*x_106 - 1.18015912109889e-6*x_107 - 0.000573343421920078*x_108 - 1.78031845761117e-5*x_109 + 0.000923032592444138*x_11 - 7.65692182796263e-5*x_110 - 0.000209952096025562*x_111 - 0.000153108942721209*x_112 - 2.80841751030731e-5*x_113 + 9.60937827388862e-6*x_114 - 0.000441546449938618*x_115 + 0.000207681935056508*x_116 - 0.000955615081428913*x_117 + 0.000515794404198135*x_118 + 4.57119440700401e-5*x_119 - 0.000384844025751446*x_12 - 5.81132824854775e-5*x_120 + 0.000284144235306128*x_13 - 0.000585839607350245*x_14 + 0.00015501151325468*x_15 - 3.60675622570189e-5*x_16 - 0.000289667925422505*x_17 + 0.000246631229000906*x_18 - 0.000252640638373606*x_19 + 4.63744145700666e-6*x_2 + 8.78852458519297e-5*x_20 - 6.36191904886252e-5*x_21 - 9.28578737005245e-5*x_22 + 1.70561258843415e-5*x_23 + 0.000325701578334782*x_24 - 7.60145226981967e-5*x_25 + 9.68297411460746e-5*x_26 + 5.79539708179139e-5*x_27 + 6.97808551211699e-5*x_28 + 1.04198371209575e-5*x_29 - 0.000100971312215305*x_3 - 1.44459765441636e-5*x_30 + 9.0909770277683e-7*x_31 - 1.81429517517861e-5*x_32 + 1.92562820044683e-5*x_33 - 8.37333292272556e-6*x_34 + 0.000732932498000989*x_35 - 3.39770458052949e-5*x_36 - 0.00080725092303886*x_37 - 0.000399693889851279*x_38 + 0.000305080168045177*x_39 - 0.000109646012934883*x_4 - 4.85819059838753e-5*x_40 + 0.000361551049045361*x_41 - 0.00059192779814826*x_42 - 0.00125699194978747*x_43 + 2.82735168509202e-5*x_44 + 0.000272900573023604*x_45 - 9.18501094862232e-5*x_46 - 1.90056370856716e-5*x_47 - 0.000335652018807288*x_48 - 0.00139230273949991*x_49 - 0.000148027054092789*x_5 - 0.00125044056825274*x_50 + 0.000636211616602157*x_51 - 0.000268175823413686*x_52 - 3.19684628420537e-5*x_53 + 0.000978006184443065*x_54 - 0.00106821840285146*x_55 - 0.000338421546282341*x_56 + 1.11191590164891e-5*x_57 - 0.00120879698457562*x_58 - 0.000117616582653529*x_59 + 4.42277103795036e-5*x_6 - 0.000223309027949571*x_60 - 1.73624024212311e-6*x_61 - 1.81768127328701e-5*x_62 - 5.1242059745438e-7*x_63 + 4.51691936792476e-7*x_64 - 1.00750526972034e-5*x_65 - 7.95113638117635e-6*x_66 - 7.32161412015522e-7*x_67 + 5.7061461745825e-6*x_68 + 2.18870079146285e-5*x_69 + 1.40017079941808e-5*x_7 + 1.21612100955213e-5*x_70 + 5.64387405704515e-5*x_71 + 3.65601541419157e-5*x_72 + 1.54763954581609e-5*x_73 + 2.1847926919614e-5*x_74 - 8.72785733826164e-6*x_75 - 5.9530087235092e-6*x_76 - 2.04543455209379e-6*x_77 + 1.35563773092243e-5*x_78 + 4.863399771117e-6*x_79 + 3.69802124799871e-5*x_8 + 4.89326105559957e-6*x_80 - 1.82449275910373e-5*x_81 - 1.17781887226668e-5*x_82 + 2.35837836325853e-5*x_83 + 1.14346883256641e-5*x_84 - 5.29866964021618e-6*x_85 - 0.000173366823970735*x_86 + 2.89636152681666e-5*x_87 - 5.36023896594161e-5*x_88 + 2.46086678632834e-6*x_89 - 1.55403051490801e-5*x_9 + 3.61817828075193e-6*x_90 + 5.55029020400617e-6*x_91 + 0.000113171843163709*x_92 - 0.000234487727795118*x_93 - 3.58028128470987e-5*x_94 + 8.68475451243503e-6*x_95 + 1.70790422359843e-5*x_96 + 9.981212522984e-5*x_97 - 3.53535486921964e-6*x_98 + 0.000515589540379112*x_99 + 2.89317182223805e-8*std::pow(7.56008005142212 - 7.57863998413086*x_29, 2) - 4.28593902149936e-7*std::pow(-9.79199981689453*x_13 - 9.96739959716797, 2) + 1.60794945801085e-7*std::pow(-9.3638391494751*x_18 - 5.88736009597778, 2) + 6.27381335569565e-10*std::pow(-9.32719993591309*x_28 - 3.25887989997864, 2) - 1.04852508875245e-7*std::pow(-6.40000009536743*x_3 - 0.823999881744385, 2) + 0.000457109894241846*std::sin(0.383359849452972*x_10 - 1.38967990875244) + 0.00129504334746656*std::sin(0.285519927740097*x_100 + 1.75823998451233) + 0.000166242179074947*std::sin(0.253679990768433*x_107 - 1.22095990180969) - 0.00144849548405928*std::sin(0.245599970221519*x_109 - 7.6048002243042) + 0.000550160103784397*std::sin(0.25655996799469*x_109 + 4.97463941574097) + 7.54359375632085e-5*std::sin(0.408079862594604*x_11 - 1.58663988113403) + 0.000236865954458284*std::sin(0.23471999168396*x_110 - 4.410560131073) - 0.000262397947999213*std::sin(0.283919930458069*x_110 + 4.74656009674072) - 0.00152182043844686*std::sin(0.239999979734421*x_111 + 4.98303985595703) + 0.00025812998021889*std::sin(0.267759948968887*x_112 + 4.9826397895813) - 6.69855614561631e-5*std::sin(0.344319850206375*x_112 + 1.63351988792419) - 0.000181533893043989*std::sin(0.324319839477539*x_113 + 1.80663990974426) - 0.000471615653933862*std::sin(0.258559972047806*x_114 - 1.42975986003876) + 0.000277528454190894*std::sin(0.269039958715439*x_116 + 8.17503929138184) + 0.000342290241394673*std::sin(0.31703993678093*x_116 + 7.74711990356445) - 0.000831499314711687*std::sin(0.262799948453903*x_118 + 8.14888000488281) + 0.00253563730167595*std::sin(0.270159959793091*x_119 - 7.64079999923706) + 0.00100273054542868*std::sin(0.308079928159714*x_120 + 4.95815992355347) - 0.000538249060872833*std::sin(0.285999953746796*x_14 + 1.7739999294281) + 0.000163265373233513*std::sin(0.329199850559235*x_14 - 1.32287991046906) - 0.000665573471018734*std::sin(0.283679932355881*x_15 - 4.61175966262817) + 3.36416433994702e-5*std::sin(0.315439850091934*x_15 - 8.15695953369141) + 8.74736408115855e-5*std::sin(0.341599822044373*x_15 + 5.05247974395752) - 0.000201111549641148*std::sin(0.327279835939407*x_16 + 1.80663990974426) + 0.00329235397846979*std::sin(0.383679836988449*x_16 - 7.60168027877808) + 9.4209607754856e-5*std::sin(0.395519822835922*x_16 + 4.79496002197266) - 0.00279513051581852*std::sin(0.151760026812553*x_18 + 1.7475198507309) - 0.000176375273911288*std::sin(0.186320006847382*x_19 + 4.78311967849731) - 0.000108612139585265*std::sin(0.245839968323708*x_19 + 1.5927197933197) - 0.000143122559295074*std::sin(0.356159836053848*x_2 + 8.18231964111328) - 0.000103744272644559*std::sin(0.287679940462112*x_20 - 4.59008026123047) + 8.65869064221252e-5*std::sin(0.302239924669266*x_20 - 4.4015998840332) - 1.5849692911076e-5*std::sin(0.344079852104187*x_20 + 1.80431985855103) + 0.000757675976431381*std::sin(0.346959829330444*x_20 - 1.35039985179901) - 0.000413693970866977*std::sin(0.42087984085083*x_20 + 7.9967999458313) - 0.000445229263422089*std::sin(0.381999850273132*x_22 - 4.39847993850708) - 3.16954047134052e-5*std::sin(0.479119867086411*x_23 + 1.40255987644196) - 0.00016461793427312*std::sin(0.276079952716827*x_24 + 4.81767988204956) - 2.24552076302742e-5*std::sin(0.370879858732224*x_24 + 8.21424007415771) + 7.62773745997902e-5*std::sin(0.392479836940765*x_25 + 1.80199980735779) + 0.0025598513316335*std::sin(0.443039864301682*x_25 - 1.40151989459991) - 6.64736893416217e-5*std::sin(0.30175992846489*x_26 - 1.37311983108521) - 0.00657568127034234*std::sin(0.105680070817471*x_27 - 1.46623992919922) - 7.94894115945868e-5*std::sin(0.395599842071533*x_27 + 8.00263977050781) - 0.00115452324656669*std::sin(0.33519983291626*x_28 - 4.36367988586426) + 0.000343084165581934*std::sin(0.22087998688221*x_29 + 1.8096798658371) + 0.00111275111767689*std::sin(0.316319912672043*x_3 + 1.85055994987488) - 6.37326097811599e-7*std::sin(0.394639849662781*x_3 + 8.19960021972656) + 0.00109709741422811*std::sin(0.320719838142395*x_32 + 8.20911979675293) - 2.66881601432544e-5*std::sin(0.271839946508408*x_33 + 8.16720008850098) - 0.00138450297535764*std::sin(0.2743199467659*x_33 + 4.98183965682983) + 0.000797717735809883*std::sin(0.282239943742752*x_33 + 4.96551990509033) + 0.000947801712452484*std::sin(0.267839968204498*x_36 - 7.61712026596069) + 0.000651967099099325*std::sin(0.291279941797256*x_36 - 7.6300802230835) + 0.000223296963171078*std::sin(0.222559988498688*x_37 - 1.37927985191345) - 5.33620149106502e-5*std::sin(0.249999970197678*x_38 - 7.82919979095459) - 0.000186420007991151*std::sin(0.371439844369888*x_4 + 8.19215965270996) + 0.000345991953301502*std::sin(0.243199974298477*x_40 + 1.5868798494339) + 0.000285997374304171*std::sin(0.246719971299171*x_41 - 1.21727979183197) + 0.00114684159831526*std::sin(0.197679996490479*x_43 - 1.37815976142883) + 0.000154329026324724*std::sin(0.242079973220825*x_43 + 1.76151990890503) - 0.000129933838594734*std::sin(0.245839968323708*x_44 + 1.78511989116669) + 0.00401484495894205*std::sin(0.168080016970634*x_45 + 7.99632024765015) - 0.000387810231296692*std::sin(0.207440003752708*x_47 - 7.60143995285034) + 0.00174806914344996*std::sin(0.283519923686981*x_48 - 4.45199966430664) - 0.000134304808121119*std::sin(0.431199848651886*x_5 - 7.61520004272461) - 0.000738282990428517*std::sin(0.274159938097*x_51 - 7.84543991088867) + 0.0017134784241068*std::sin(0.241199970245361*x_53 - 4.41567993164063) + 0.000183858450432636*std::sin(0.270639955997467*x_53 - 4.42847967147827) - 0.000743596377229828*std::sin(0.229999989271164*x_55 - 4.41167974472046) - 0.000177108637386974*std::sin(0.244719967246056*x_57 + 1.76287984848022) - 8.37797455539063e-5*std::sin(0.319679915904999*x_59 - 4.87175989151001) + 4.99435388683221e-6*std::sin(0.583919823169708*x_6 - 7.98712015151978) + 0.000240871161156911*std::sin(0.356159836053848*x_60 + 1.85079991817474) - 0.000374156662685148*std::sin(0.417679876089096*x_60 + 7.98752021789551) + 0.00663421172344111*std::sin(0.436959862709045*x_60 - 4.45959997177124) + 0.00136022947539506*std::sin(0.212479993700981*x_7 + 4.81024026870728) - 0.0013650011761996*std::sin(0.352559864521027*x_7 - 7.59416007995605) - 0.00403091483165498*std::sin(0.369039833545685*x_7 + 5.00751972198486) - 0.00081793106738881*std::sin(0.369439840316772*x_8 - 1.3796797990799) + 0.000246615294987545*std::sin(0.288959950208664*x_9 - 1.6341598033905) - 0.00355184379634642*std::sin(0.380959838628769*x_9 + 1.82615983486176) + 0.000118818334122684*std::sin(0.466959863901138*x_91 - 4.82599973678589) + 0.00380238356835342*std::sin(0.317919850349426*x_92 - 4.58975982666016) + 0.000111366316078073*std::sin(0.319039851427078*x_92 - 7.57272005081177) + 9.52918393549951e-5*std::sin(0.321999847888947*x_92 + 8.00944042205811) - 0.000322041161416233*std::sin(0.294959932565689*x_95 + 7.98992013931274) + 0.00625076162493218*std::sin(0.314799934625626*x_95 + 1.76271986961365) - 0.000114079366615126*std::sin(0.283279925584793*x_97 - 4.41336011886597) - 0.000304224365285554*std::sin(0.25927996635437*x_98 + 1.9579998254776) + 0.000180912465173638*std::sin(0.263199955224991*x_99 - 4.42944002151489) + 0.184612065553665*std::sin(0.00117793771249234*x_1 + 0.00142575816937908*x_10 + 0.000289748989326932*x_100 - 0.00144802198382116*x_101 + 0.00172348408138981*x_102 + 0.00211024547065485*x_103 + 0.00672871502707688*x_104 + 0.00568775967967251*x_105 - 0.00178828763913497*x_106 - 2.02325995074055e-5*x_107 + 0.000776688603201943*x_108 - 0.00195272425209054*x_109 + 0.00324544209997338*x_11 + 0.000344785794828044*x_111 + 0.000581120520187398*x_112 + 0.00591067966973442*x_113 + 0.00118568745792834*x_114 - 0.0247936339032152*x_115 + 5.82708196514412e-5*x_116 - 0.022026876262666*x_117 + 0.000884138304327003*x_118 + 0.000813497024357415*x_120 + 0.00158686755970437*x_13 - 0.00971048850949664*x_14 + 0.000911155618899563*x_15 - 0.00201214879378896*x_16 + 0.00188384450047288*x_17 + 0.00140206297843349*x_18 + 0.00233627144040988*x_19 + 0.00083268389778576*x_2 + 0.00116021808302141*x_20 + 0.00185906028878671*x_21 + 0.0048886977923608*x_22 - 0.0102604080733512*x_23 + 0.0030249343998255*x_25 + 0.00404044738336662*x_26 + 0.0121246241230022*x_27 + 0.00152433725727702*x_28 - 0.00104042361195989*x_3 + 0.0087790770963255*x_30 + 4.18442386995173e-5*x_31 + 0.000339830471050065*x_32 - 0.00112105325052325*x_33 + 0.00465659396284756*x_34 + 0.0001966518669448*x_35 + 0.000829288867733374*x_36 - 0.00406740210860902*x_37 - 0.00013591501585675*x_38 - 0.00393862163370135*x_39 + 0.00123420342180836*x_4 - 0.0212236271935004*x_40 - 0.0278637291539098*x_41 - 9.28020184729985e-5*x_42 + 0.0113406315510751*x_43 + 0.00462104494217644*x_44 + 0.00125693127017174*x_45 + 0.00257545041419058*x_46 + 0.000605188287981134*x_47 - 0.00562183843273585*x_48 + 0.0160333946996944*x_49 + 0.00138684056577409*x_5 - 0.0412055955282858*x_50 - 0.0217486092047341*x_51 - 0.00802626821551762*x_52 - 0.0161734521109042*x_53 - 0.0318971320349995*x_54 - 3.25199796162654e-5*x_55 + 0.000721218864581729*x_56 - 0.0225547076422733*x_57 - 0.0191132641012897*x_58 - 0.0346323715599037*x_59 + 0.00197107920672179*x_6 + 0.00057825803929886*x_60 - 6.00977721654639e-5*x_61 + 0.000139003672510429*x_62 + 0.00079059653747401*x_63 + 0.000447452809141032*x_64 - 0.00017290020953256*x_65 + 0.00156633400315807*x_66 + 0.000240767110111593*x_67 + 0.000537212855952491*x_68 - 8.27682763229696e-5*x_69 + 0.00862609254049717*x_7 + 0.000848901783517443*x_70 - 6.81994558861034e-5*x_71 + 0.000411128238108627*x_72 + 0.000440353882922376*x_73 + 0.000212742789241436*x_74 + 0.000634158405455245*x_75 - 5.18558798155615e-6*x_76 + 0.000275244453305635*x_77 + 4.2085250649659e-6*x_78 - 0.000580277559438346*x_79 + 0.00215011185488576*x_8 - 0.00303062954188587*x_80 + 0.000659455189572125*x_81 - 0.000126094156382904*x_82 + 0.00034171937671137*x_83 - 0.000532732927995705*x_84 - 0.000335873133101202*x_85 + 0.000275003688187723*x_86 - 0.000312120986965152*x_87 + 0.000593189820419227*x_88 + 0.000168884462690472*x_89 - 0.00862808124808056*x_9 - 9.78711016469402e-5*x_90 + 3.73640868738164e-5*x_91 + 0.00481545395214498*x_92 + 0.00969249873106655*x_93 + 7.40169030291655e-5*x_94 + 0.000265249444990928*x_95 - 2.96314980709274e-5*x_96 + 0.00394962399649565*x_97 + 9.48661014084835e-5*x_98 + 0.0109991308690132*x_99 + 5.65442467106991e-6*std::pow(-9.69608020782471*x_29 - 5.72824001312256, 2) - 0.0924034361597705*std::sin(0.280719965696335*x_110 + 7.9597601890564) + 0.153521365826577*std::sin(0.297039926052094*x_119 + 1.72535991668701) - 0.00694041667780709*std::sin(0.360639840364456*x_12 + 1.83463990688324) + 0.0067856237448396*std::sin(0.348319828510284*x_24 - 7.5699200630188) - 7.94185153862605) + 0.238069301771104);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000131116645369974*x_1 + 5.63182148876456e-5*x_10 + 0.000121732089927341*x_100 + 7.43297629034493e-5*x_101 - 7.75822491810119e-5*x_102 - 0.000372031459164975*x_103 + 0.00019044541788131*x_104 + 0.000108467446154549*x_105 + 0.000461668789557068*x_106 - 1.00935045954127e-5*x_107 + 0.000141221181933143*x_108 + 7.31700495868182e-5*x_109 - 0.000273198878125825*x_11 + 4.93493887457404e-6*x_110 + 1.24442122331464e-5*x_111 + 7.8719344544176e-6*x_112 - 1.89791787945418e-6*x_113 + 1.42451397328935e-5*x_114 - 0.000116388770533234*x_115 - 1.48449162450262e-5*x_116 + 0.000198330812543353*x_117 + 0.000102240510690194*x_118 + 1.62708590650251e-5*x_119 - 0.000295228939922102*x_12 + 7.45257594832768e-6*x_120 + 0.000307953324444068*x_13 + 0.000347683498521054*x_14 - 8.16612872136796e-5*x_15 - 7.48819745531694e-5*x_16 + 7.57438778910887e-6*x_17 - 6.29440865378174e-5*x_18 - 0.00031307233525668*x_19 + 3.33298330552472e-5*x_2 + 3.53579690739466e-6*x_20 - 9.16977843447765e-5*x_21 - 0.000107835561665346*x_22 - 2.00626464135025e-5*x_23 - 1.57792156363392e-5*x_24 - 6.36643116396539e-5*x_25 - 3.43052627606304e-5*x_26 + 5.18507085866892e-5*x_27 + 9.23813930893769e-5*x_28 - 1.17100766026445e-5*x_29 + 9.87542637532074e-5*x_3 - 0.000126790340657847*x_30 - 1.30469189525911e-5*x_31 + 2.34978002560761e-5*x_32 + 7.80992681199648e-5*x_33 + 2.43782003499707e-5*x_34 - 0.000241062234468857*x_35 - 0.000264178291458909*x_36 - 0.000174756486392363*x_37 - 0.000238466076041962*x_38 - 0.000721603462280417*x_39 + 8.34941229061384e-5*x_4 - 0.00025843605362697*x_40 - 0.000286678241928005*x_41 + 0.000254038386690709*x_42 - 0.000241267765339962*x_43 - 0.000643469218456771*x_44 + 4.45303600023637e-5*x_45 - 0.000104676302496838*x_46 - 9.87908325221162e-5*x_47 - 0.000298407423432703*x_48 + 0.000486241141957692*x_49 + 6.47775586590713e-5*x_5 + 0.000675268622399595*x_50 - 0.000331382369652976*x_51 - 0.00024222123656765*x_52 - 3.09655985155091e-5*x_53 + 0.000327145396934415*x_54 + 0.000455036452453486*x_55 + 0.000170873834825034*x_56 + 6.47324937039384e-5*x_57 - 0.000248888666798602*x_58 - 0.000263691864309754*x_59 + 0.000109211876519921*x_6 - 0.000214229853925027*x_60 - 6.60721922574705e-6*x_61 + 6.14384611757647e-6*x_62 - 6.10444846774424e-6*x_63 - 7.8151138164871e-6*x_64 + 9.25207899003093e-7*x_65 - 3.34170625956789e-5*x_66 - 2.31381879013022e-6*x_67 + 5.80385504339625e-6*x_68 + 1.03771986144834e-5*x_69 - 1.10987689070096e-5*x_7 + 2.59920554633664e-5*x_70 - 2.80359818474641e-6*x_71 + 5.05583966333494e-5*x_72 + 1.58151321723415e-5*x_73 - 1.93795236469199e-6*x_74 + 5.82391580442427e-6*x_75 + 1.92005907302629e-5*x_76 + 1.14406045301682e-5*x_77 + 1.08649467033736e-5*x_78 + 1.19133475485857e-5*x_79 + 5.00035096232692e-6*x_8 + 5.20515010136629e-6*x_80 - 6.40376846380691e-6*x_81 - 2.17022600621225e-5*x_82 - 1.02500504944127e-5*x_83 + 1.65138411687157e-5*x_84 - 1.45028452066243e-5*x_85 + 7.0089239401767e-5*x_86 + 1.71183364037027e-5*x_87 + 6.70918734363135e-5*x_88 - 9.80843606760103e-6*x_89 - 1.91187892184543e-5*x_9 + 2.39456542141453e-5*x_90 - 1.01072348515952e-5*x_91 + 0.000119393603093065*x_92 - 4.76811177847527e-5*x_93 + 9.03705376548324e-6*x_94 - 9.77563517465446e-5*x_95 + 4.03858206725795e-5*x_96 + 0.000219005942049141*x_97 + 0.000145461104880551*x_98 + 9.55429802441095e-5*x_99 + 3.815457495781e-8*std::pow(7.56008005142212 - 7.57863998413086*x_29, 2) - 3.06444129383905e-7*std::pow(-9.79199981689453*x_13 - 9.96739959716797, 2) + 3.75145619046154e-7*std::pow(-9.3638391494751*x_18 - 5.88736009597778, 2) - 2.42462462925473e-8*std::pow(-9.32719993591309*x_28 - 3.25887989997864, 2) - 1.36783884146718e-7*std::pow(-6.40000009536743*x_3 - 0.823999881744385, 2) + 0.00106646868403199*std::sin(0.383359849452972*x_10 - 1.38967990875244) + 0.000925954450443804*std::sin(0.285519927740097*x_100 + 1.75823998451233) + 0.000219236881608991*std::sin(0.253679990768433*x_107 - 1.22095990180969) - 0.00103567254527522*std::sin(0.245599970221519*x_109 - 7.6048002243042) + 0.00128356119454161*std::sin(0.25655996799469*x_109 + 4.97463941574097) + 9.94834151274717e-5*std::sin(0.408079862594604*x_11 - 1.58663988113403) + 0.000184580461947771*std::sin(0.23471999168396*x_110 - 4.410560131073) - 0.000612192380476806*std::sin(0.283919930458069*x_110 + 4.74656009674072) - 0.00108809980029846*std::sin(0.239999979734421*x_111 + 4.98303985595703) + 0.000340416687436868*std::sin(0.267759948968887*x_112 + 4.9826397895813) - 5.21992529727903e-5*std::sin(0.344319850206375*x_112 + 1.63351988792419) - 0.00023940329006011*std::sin(0.324319839477539*x_113 + 1.80663990974426) + 0.000161347689048833*std::sin(0.258559972047806*x_114 - 1.42975986003876) + 0.000647492887488896*std::sin(0.269039958715439*x_116 + 8.17503929138184) + 0.000244737114771415*std::sin(0.31703993678093*x_116 + 7.74711990356445) - 0.000832745821783376*std::sin(0.262799948453903*x_118 + 8.14888000488281) - 0.000867484392171611*std::sin(0.270159959793091*x_119 - 7.64079999923706) + 0.000716951145266277*std::sin(0.308079928159714*x_120 + 4.95815992355347) - 0.00125577191581595*std::sin(0.285999953746796*x_14 + 1.7739999294281) + 0.000215311129230967*std::sin(0.329199850559235*x_14 - 1.32287991046906) - 0.000666571237371243*std::sin(0.283679932355881*x_15 - 4.61175966262817) + 7.84882576746951e-5*std::sin(0.315439850091934*x_15 - 8.15695953369141) + 6.81648194911835e-5*std::sin(0.341599822044373*x_15 + 5.05247974395752) - 0.000469207016499087*std::sin(0.327279835939407*x_16 + 1.80663990974426) - 0.00112636996148421*std::sin(0.383679836988449*x_16 - 7.60168027877808) + 0.000124241758239161*std::sin(0.395519822835922*x_16 + 4.79496002197266) - 0.00364634869257705*std::sin(0.151760026812553*x_18 + 1.7475198507309) - 0.000232600205678307*std::sin(0.186320006847382*x_19 + 4.78311967849731) + 0.000640650044595695*std::sin(0.245839968323708*x_19 + 1.5927197933197) - 0.000188747186558497*std::sin(0.356159836053848*x_2 + 8.18231964111328) + 0.000611936871422261*std::sin(0.287679940462112*x_20 - 4.59008026123047) + 0.000114189091226951*std::sin(0.302239924669266*x_20 - 4.4015998840332) + 0.000612539035185527*std::sin(0.344079852104187*x_20 + 1.80431985855103) + 0.000988415671619746*std::sin(0.346959829330444*x_20 - 1.35039985179901) - 0.000414314142707262*std::sin(0.42087984085083*x_20 + 7.9967999458313) - 0.001038750358799*std::sin(0.381999850273132*x_22 - 4.39847993850708) - 4.17992697723793e-5*std::sin(0.479119867086411*x_23 + 1.40255987644196) - 0.000128280378758998*std::sin(0.276079952716827*x_24 + 4.81767988204956) + 0.000867820676016185*std::sin(0.370879858732224*x_24 + 8.21424007415771) + 0.00010059308556729*std::sin(0.392479836940765*x_25 + 1.80199980735779) - 0.000875768421218616*std::sin(0.443039864301682*x_25 - 1.40151989459991) - 8.76641803024722e-5*std::sin(0.30175992846489*x_26 - 1.37311983108521) - 0.00470160427362116*std::sin(0.105680070817471*x_27 - 1.46623992919922) - 0.00010482905611502*std::sin(0.395599842071533*x_27 + 8.00263977050781) - 0.00150611726602522*std::sin(0.33519983291626*x_28 - 4.36367988586426) + 0.000267352198904684*std::sin(0.22087998688221*x_29 + 1.8096798658371) + 0.000795615723338431*std::sin(0.316319912672043*x_3 + 1.85055994987488) + 2.46305789798152e-5*std::sin(0.394639849662781*x_3 + 8.19960021972656) + 0.00143120319404078*std::sin(0.320719838142395*x_32 + 8.20911979675293) + 0.0010314105110265*std::sin(0.271839946508408*x_33 + 8.16720008850098) - 0.000989917977798186*std::sin(0.2743199467659*x_33 + 4.98183965682983) + 0.00186113010165569*std::sin(0.282239943742752*x_33 + 4.96551990509033) + 0.00067767709513391*std::sin(0.267839968204498*x_36 - 7.61712026596069) + 0.00152108388588226*std::sin(0.291279941797256*x_36 - 7.6300802230835) - 0.00131711989064842*std::sin(0.222559988498688*x_37 - 1.37927985191345) - 7.03727646646719e-5*std::sin(0.249999970197678*x_38 - 7.82919979095459) - 0.000245847001338197*std::sin(0.371439844369888*x_4 + 8.19215965270996) - 0.000118369697080746*std::sin(0.243199974298477*x_40 + 1.5868798494339) + 0.000377167652876701*std::sin(0.246719971299171*x_41 - 1.21727979183197) + 0.00114856083745006*std::sin(0.197679996490479*x_43 - 1.37815976142883) + 0.000120262631394686*std::sin(0.242079973220825*x_43 + 1.76151990890503) - 0.000171354163831991*std::sin(0.245839968323708*x_44 + 1.78511989116669) + 0.00523751022862376*std::sin(0.168080016970634*x_45 + 7.99632024765015) - 0.00030220548919546*std::sin(0.207440003752708*x_47 - 7.60143995285034) + 0.00124986735480896*std::sin(0.283519923686981*x_48 - 4.45199966430664) - 0.000104658533901582*std::sin(0.431199848651886*x_5 - 7.61520004272461) - 0.00096311682108074*std::sin(0.274159938097*x_51 - 7.84543991088867) + 0.00122513503169212*std::sin(0.241199970245361*x_53 - 4.41567993164063) + 0.000143273767610339*std::sin(0.270639955997467*x_53 - 4.42847967147827) - 0.00173486126610877*std::sin(0.229999989271164*x_55 - 4.41167974472046) + 0.00104467748148147*std::sin(0.244719967246056*x_57 + 1.76287984848022) - 0.000195463883225721*std::sin(0.319679915904999*x_59 - 4.87175989151001) - 0.000193015519504321*std::sin(0.583919823169708*x_6 - 7.98712015151978) + 0.000187701564363353*std::sin(0.356159836053848*x_60 + 1.85079991817474) - 0.000872933114557605*std::sin(0.417679876089096*x_60 + 7.98752021789551) - 0.00226967599847314*std::sin(0.436959862709045*x_60 - 4.45959997177124) + 0.00177446846976986*std::sin(0.212479993700981*x_7 + 4.81024026870728) - 0.000975974214635836*std::sin(0.352559864521027*x_7 - 7.59416007995605) + 0.00137904411657083*std::sin(0.369039833545685*x_7 + 5.00751972198486) - 0.000584819738649307*std::sin(0.369439840316772*x_8 - 1.3796797990799) + 0.000246984997888979*std::sin(0.288959950208664*x_9 - 1.6341598033905) + 0.00121514581550191*std::sin(0.380959838628769*x_9 + 1.82615983486176) + 0.000118996455608907*std::sin(0.466959863901138*x_91 - 4.82599973678589) - 0.00130085970750478*std::sin(0.317919850349426*x_92 - 4.58975982666016) - 0.000656895588599155*std::sin(0.319039851427078*x_92 - 7.57272005081177) + 0.000125668983763475*std::sin(0.321999847888947*x_92 + 8.00944042205811) - 0.000751344081469379*std::sin(0.294959932565689*x_95 + 7.98992013931274) - 0.00213849123659363*std::sin(0.314799934625626*x_95 + 1.76271986961365) - 0.000150445601301663*std::sin(0.283279925584793*x_97 - 4.41336011886597) - 0.000401205046311446*std::sin(0.25927996635437*x_98 + 1.9579998254776) + 0.000140978075427641*std::sin(0.263199955224991*x_99 - 4.42944002151489) + 0.106514804065228*std::sin(0.00131123780441999*x_1 + 0.00158710260468262*x_10 + 0.000322538131319423*x_100 - 0.00161188588045131*x_101 + 0.00191852035881656*x_102 + 0.00234904919707006*x_103 + 0.00749016304096758*x_104 + 0.00633140906802471*x_105 - 0.00199065734354436*x_106 - 2.25222005157354e-5*x_107 + 0.000864581758423971*x_108 - 0.0021737022541975*x_109 + 0.00361270916824385*x_11 + 0.000383803119478155*x_111 + 0.000646882417391722*x_112 + 0.00657955556612063*x_113 + 0.00131986454171054*x_114 - 0.0275993796090098*x_115 + 6.4864976145337e-5*x_116 - 0.0245195247274814*x_117 + 0.000984190892841359*x_118 + 0.000905555566145898*x_120 + 0.00176644377102883*x_13 - 0.0108093658077193*x_14 + 0.00101426559362201*x_15 - 0.00223985151214123*x_16 + 0.00209702779737157*x_17 + 0.00156072597218218*x_18 + 0.00260065315980965*x_19 + 0.000926913702082164*x_2 + 0.00129151295157234*x_20 + 0.00206943890623496*x_21 + 0.00544192217614365*x_22 - 0.0114215164451164*x_23 + 0.00336724794433258*x_25 + 0.00449768039485751*x_26 + 0.0134966945585133*x_27 + 0.00169683729218449*x_28 - 0.00115816206421175*x_3 + 0.00977255219400613*x_30 + 4.65794983029185e-5*x_31 + 0.000378287031656262*x_32 - 0.00124791607167731*x_33 + 0.00518355255898922*x_34 + 0.000218905770239924*x_35 + 0.000923134476996985*x_36 - 0.00452768542345177*x_37 - 0.000151295696784028*x_38 - 0.00438433164049766*x_39 + 0.00137387076401134*x_4 - 0.0236253768156817*x_40 - 0.0310168989847698*x_41 - 0.000103303862044461*x_42 + 0.0126239822853659*x_43 + 0.00514398067049313*x_44 + 0.00139917058561578*x_45 + 0.00286689857254889*x_46 + 0.000673673789010494*x_47 - 0.00625802791197447*x_48 + 0.0178477970782881*x_49 + 0.00154378093108043*x_5 - 0.0458685837437084*x_50 - 0.0242097678683406*x_51 - 0.00893455248183986*x_52 - 0.0180037039402723*x_53 - 0.0355067376936019*x_54 - 3.62000691713923e-5*x_55 + 0.000802834844721527*x_56 - 0.0251070875943123*x_57 - 0.0212761966865352*x_58 - 0.0385515077448209*x_59 + 0.0021941343281142*x_6 + 0.000643696006840745*x_60 - 6.68986738339847e-5*x_61 + 0.000154733878044569*x_62 + 0.000880063569563489*x_63 + 0.000498088339321639*x_64 - 0.000192466281304075*x_65 + 0.00174358655598498*x_66 + 0.000268013268860617*x_67 + 0.000598005988156111*x_68 - 9.21346619353293e-5*x_69 + 0.00960225530057358*x_7 + 0.00094496686792754*x_70 - 7.59171761378792e-5*x_71 + 0.000457653136117005*x_72 + 0.000490186070525953*x_73 + 0.000236817604965625*x_74 + 0.000705922279595084*x_75 - 5.77240963376197e-6*x_76 + 0.000306392204616342*x_77 + 4.68477841188757e-6*x_78 - 0.000645944063869225*x_79 + 0.00239342701906753*x_8 - 0.00337358757120071*x_80 + 0.000734081747886596*x_81 - 0.000140363469996962*x_82 + 0.000380389693355449*x_83 - 0.00059301909382739*x_84 - 0.00037388186568833*x_85 + 0.000306124193565126*x_86 - 0.000347441832722751*x_87 + 0.000660317527388654*x_88 + 0.000187996096661471*x_89 - 0.00960446905817521*x_9 - 0.000108946582725641*x_90 + 4.15923547713896e-5*x_91 + 0.00536038977318774*x_92 + 0.0107893402347875*x_93 + 8.2392948615745e-5*x_94 + 0.000295266121616583*x_95 - 3.29847156264219e-5*x_96 + 0.00439657907419541*x_97 + 0.000105601524771245*x_98 + 0.0122438360350117*x_99 + 6.29430173796231e-6*std::pow(-9.69608020782471*x_29 - 5.72824001312256, 2) - 0.102860174579721*std::sin(0.280719965696335*x_110 + 7.9597601890564) + 0.170894450974043*std::sin(0.297039926052094*x_119 + 1.72535991668701) - 0.0077258216880689*std::sin(0.360639840364456*x_12 + 1.83463990688324) + 0.00755351177438546*std::sin(0.348319828510284*x_24 - 7.5699200630188) + 7.71667036056257) - 0.051660603075145);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000135664012367354*x_1 + 0.000123949211248672*x_10 + 0.00017172922439014*x_100 + 0.000317674747694356*x_101 - 3.15857408967808e-6*x_102 - 0.000451142357544216*x_103 + 8.10262124192557e-5*x_104 + 0.000374267093335076*x_105 + 0.000118263232390543*x_106 + 2.99218800310882e-6*x_107 + 0.000102754791007041*x_108 + 9.57406821891968e-5*x_109 - 8.42349005738804e-5*x_11 - 2.26706691748125e-5*x_110 - 5.14145864248766e-5*x_111 + 3.31158065853102e-5*x_112 + 7.31378524962279e-6*x_113 - 2.63669568636724e-5*x_114 - 0.000221035818465719*x_115 + 0.000198293612532766*x_116 + 0.000204215587131528*x_117 - 0.000147669513130886*x_118 + 0.000132294619832442*x_119 - 0.000542694702517646*x_12 - 3.67454173751312e-5*x_120 + 0.000782578081609351*x_13 + 0.000378812637232393*x_14 - 7.45853294621852e-5*x_15 + 4.22308106706315e-5*x_16 - 8.31827793343751e-6*x_17 - 3.17769811570444e-5*x_18 - 0.000475377405059018*x_19 + 0.000113251737966073*x_2 + 0.00015903137947445*x_20 - 0.000128888085409601*x_21 - 0.000165752829341266*x_22 - 1.84994505827681e-5*x_23 - 3.04554701307268e-5*x_24 - 8.79280705562417e-5*x_25 - 4.28986234277929e-5*x_26 + 5.77459238075968e-5*x_27 + 0.000146804468890247*x_28 + 1.18992380798865e-5*x_29 + 0.000314665782645663*x_3 - 0.000156123621785286*x_30 - 1.04045007207883e-5*x_31 + 1.15602897978604e-5*x_32 + 0.000183664641439741*x_33 + 2.27313685012451e-5*x_34 - 0.000615170348958854*x_35 + 0.000144815086121871*x_36 - 0.000484816270935801*x_37 - 0.000487987189928221*x_38 - 0.00107295333255636*x_39 + 0.00010422450812108*x_4 + 0.000161637842396011*x_40 - 0.000230301097677034*x_41 + 0.000433996351604513*x_42 - 0.00011169130030198*x_43 - 0.000862141937373479*x_44 - 4.91625503471171e-5*x_45 - 0.000161948480316508*x_46 + 2.4197711036401e-5*x_47 - 0.000401049504777097*x_48 + 0.00090501043454439*x_49 + 7.42930063851187e-5*x_5 + 0.000814936106579351*x_50 - 5.10933148823916e-5*x_51 - 0.000332346515644491*x_52 - 1.98519413153885e-5*x_53 + 0.000811074647874946*x_54 + 0.000607609674042644*x_55 - 0.000289167710982433*x_56 - 0.00023770537071306*x_57 - 0.000496396335987124*x_58 - 0.000349064758933786*x_59 + 0.000130620964569067*x_6 - 0.00038115194945014*x_60 - 7.97232560091533e-6*x_61 + 1.63854946399679e-5*x_62 - 9.30016539543788e-7*x_63 - 2.31446432454844e-5*x_64 - 1.05790704035506e-5*x_65 - 4.56317133430991e-5*x_66 - 6.94482858648478e-6*x_67 - 1.37867066182879e-6*x_68 + 1.3449795194913e-5*x_69 + 1.40015434503656e-5*x_7 + 2.26857518746695e-5*x_70 + 3.40325152260909e-6*x_71 + 5.55702075564835e-5*x_72 + 6.34519168690165e-6*x_73 - 1.70661319792159e-5*x_74 + 6.44545173567612e-7*x_75 + 1.12985279460021e-5*x_76 + 4.2155215762666e-6*x_77 - 8.46822485918983e-6*x_78 + 1.63460585211989e-5*x_79 - 1.56587336872121e-5*x_8 - 1.99401840537898e-7*x_80 - 9.80873627785408e-6*x_81 - 2.81081874808602e-5*x_82 - 2.72338076032245e-6*x_83 + 1.77959955680964e-5*x_84 - 2.63220299826058e-5*x_85 + 5.0592810874945e-5*x_86 + 1.11476895854364e-5*x_87 + 9.34326403956035e-5*x_88 - 1.71691704009078e-5*x_89 - 3.39988548121204e-5*x_9 + 3.01026662603673e-5*x_90 - 9.92371459979802e-6*x_91 + 0.000434182120843705*x_92 - 0.000100152981815053*x_93 + 1.40059612344445e-5*x_94 - 6.4435268324745e-5*x_95 + 6.71345576401518e-5*x_96 + 0.000201897775973384*x_97 + 3.67478860272429e-5*x_98 + 0.00033174226349326*x_99 + 9.18408711028818e-8*std::pow(7.56008005142212 - 7.57863998413086*x_29, 2) - 6.9179995004738e-7*std::pow(-9.79199981689453*x_13 - 9.96739959716797, 2) - 5.32992440672824e-8*std::pow(-9.3638391494751*x_18 - 5.88736009597778, 2) - 2.3292663999522e-8*std::pow(-9.32719993591309*x_28 - 3.25887989997864, 2) - 1.73680474137929e-7*std::pow(-6.40000009536743*x_3 - 0.823999881744385, 2) - 0.000151519761379224*std::sin(0.383359849452972*x_10 - 1.38967990875244) + 0.00209034920607233*std::sin(0.285519927740097*x_100 + 1.75823998451233) + 0.000527719315628954*std::sin(0.253679990768433*x_107 - 1.22095990180969) - 0.00233803863864939*std::sin(0.245599970221519*x_109 - 7.6048002243042) - 0.000182363428785633*std::sin(0.25655996799469*x_109 + 4.97463941574097) + 0.000239463904805638*std::sin(0.408079862594604*x_11 - 1.58663988113403) + 9.32324071082726e-5*std::sin(0.23471999168396*x_110 - 4.410560131073) + 8.69779345581255e-5*std::sin(0.283919930458069*x_110 + 4.74656009674072) - 0.00245639356513831*std::sin(0.239999979734421*x_111 + 4.98303985595703) + 0.000819408030275012*std::sin(0.267759948968887*x_112 + 4.9826397895813) - 2.63660733782537e-5*std::sin(0.344319850206375*x_112 + 1.63351988792419) - 0.00057626134554844*std::sin(0.324319839477539*x_113 + 1.80663990974426) + 0.000129473799693164*std::sin(0.258559972047806*x_114 - 1.42975986003876) - 9.19932945767767e-5*std::sin(0.269039958715439*x_116 + 8.17503929138184) + 0.000552495895790187*std::sin(0.31703993678093*x_116 + 7.74711990356445) - 0.0044714321302738*std::sin(0.262799948453903*x_118 + 8.14888000488281) - 0.000696114714075512*std::sin(0.270159959793091*x_119 - 7.64079999923706) + 0.00161852265689927*std::sin(0.308079928159714*x_120 + 4.95815992355347) + 0.00017841523514014*std::sin(0.285999953746796*x_14 + 1.7739999294281) + 0.000518269740616504*std::sin(0.329199850559235*x_14 - 1.32287991046906) - 0.00357915701277871*std::sin(0.283679932355881*x_15 - 4.61175966262817) - 1.11513092245511e-5*std::sin(0.315439850091934*x_15 - 8.15695953369141) + 3.44303515886865e-5*std::sin(0.341599822044373*x_15 + 5.05247974395752) + 6.66631249861123e-5*std::sin(0.327279835939407*x_16 + 1.80663990974426) - 0.000903857995322537*std::sin(0.383679836988449*x_16 - 7.60168027877808) + 0.000299059059540187*std::sin(0.395519822835922*x_16 + 4.79496002197266) - 0.00462992825324151*std::sin(0.151760026812553*x_18 + 1.7475198507309) - 0.000559885820555641*std::sin(0.186320006847382*x_19 + 4.78311967849731) + 0.000321084819740331*std::sin(0.245839968323708*x_19 + 1.5927197933197) - 0.000454328374799577*std::sin(0.356159836053848*x_2 + 8.18231964111328) + 0.000306694179935751*std::sin(0.287679940462112*x_20 - 4.59008026123047) + 0.000274861549901317*std::sin(0.302239924669266*x_20 - 4.4015998840332) + 0.00058844844521576*std::sin(0.344079852104187*x_20 + 1.80431985855103) + 0.00125503456465779*std::sin(0.346959829330444*x_20 - 1.35039985179901) - 0.00222466150086552*std::sin(0.42087984085083*x_20 + 7.9967999458313) + 0.000147581648532575*std::sin(0.381999850273132*x_22 - 4.39847993850708) - 0.000100613919866872*std::sin(0.479119867086411*x_23 + 1.40255987644196) - 6.4794986263749e-5*std::sin(0.276079952716827*x_24 + 4.81767988204956) + 0.000833690096784023*std::sin(0.370879858732224*x_24 + 8.21424007415771) + 0.000242134963255189*std::sin(0.392479836940765*x_25 + 1.80199980735779) - 0.000702762250980485*std::sin(0.443039864301682*x_25 - 1.40151989459991) - 0.000211014136375568*std::sin(0.30175992846489*x_26 - 1.37311983108521) - 0.0106139073643631*std::sin(0.105680070817471*x_27 - 1.46623992919922) - 0.00025233125624233*std::sin(0.395599842071533*x_27 + 8.00263977050781) - 0.00191238289877777*std::sin(0.33519983291626*x_28 - 4.36367988586426) + 0.000135040777266157*std::sin(0.22087998688221*x_29 + 1.8096798658371) + 0.00179610853948813*std::sin(0.316319912672043*x_3 + 1.85055994987488) + 2.36618812400198e-5*std::sin(0.394639849662781*x_3 + 8.19960021972656) + 0.00181726122839221*std::sin(0.320719838142395*x_32 + 8.20911979675293) + 0.00099084609588825*std::sin(0.271839946508408*x_33 + 8.16720008850098) - 0.00223474735498639*std::sin(0.2743199467659*x_33 + 4.98183965682983) - 0.000264422193657307*std::sin(0.282239943742752*x_33 + 4.96551990509033) + 0.00152986119037239*std::sin(0.267839968204498*x_36 - 7.61712026596069) - 0.000216109737564266*std::sin(0.291279941797256*x_36 - 7.6300802230835) - 0.000660122021738317*std::sin(0.222559988498688*x_37 - 1.37927985191345) - 0.000169392425832766*std::sin(0.249999970197678*x_38 - 7.82919979095459) - 0.000591771833021289*std::sin(0.371439844369888*x_4 + 8.19215965270996) - 9.49860177106999e-5*std::sin(0.243199974298477*x_40 + 1.5868798494339) + 0.000907870309925576*std::sin(0.246719971299171*x_41 - 1.21727979183197) + 0.00616720216157906*std::sin(0.197679996490479*x_43 - 1.37815976142883) + 6.07451866345105e-5*std::sin(0.242079973220825*x_43 + 1.76151990890503) - 0.000412462088513309*std::sin(0.245839968323708*x_44 + 1.78511989116669) + 0.00665029557746668*std::sin(0.168080016970634*x_45 + 7.99632024765015) - 0.000152645328230885*std::sin(0.207440003752708*x_47 - 7.60143995285034) + 0.00282158504834488*std::sin(0.283519923686981*x_48 - 4.45199966430664) - 5.28634880263124e-5*std::sin(0.431199848651886*x_5 - 7.61520004272461) - 0.00122291150875709*std::sin(0.274159938097*x_51 - 7.84543991088867) + 0.00276575164102465*std::sin(0.241199970245361*x_53 - 4.41567993164063) + 7.23682132378824e-5*std::sin(0.270639955997467*x_53 - 4.42847967147827) + 0.000246482404033697*std::sin(0.229999989271164*x_55 - 4.41167974472046) + 0.000523577706202994*std::sin(0.244719967246056*x_57 + 1.76287984848022) + 2.77707553799389e-5*std::sin(0.319679915904999*x_59 - 4.87175989151001) - 0.000185424398822891*std::sin(0.583919823169708*x_6 - 7.98712015151978) + 9.48088897325194e-5*std::sin(0.356159836053848*x_60 + 1.85079991817474) + 0.000124022973387021*std::sin(0.417679876089096*x_60 + 7.98752021789551) - 0.00182130638081685*std::sin(0.436959862709045*x_60 - 4.45959997177124) + 0.00225312014712101*std::sin(0.212479993700981*x_7 + 4.81024026870728) - 0.00220326920372084*std::sin(0.352559864521027*x_7 - 7.59416007995605) + 0.00110661691388024*std::sin(0.369039833545685*x_7 + 5.00751972198486) - 0.00132023500269919*std::sin(0.369439840316772*x_8 - 1.3796797990799) + 0.00132618696649993*std::sin(0.288959950208664*x_9 - 1.6341598033905) + 0.000975096370092188*std::sin(0.380959838628769*x_9 + 1.82615983486176) + 0.000638951959985672*std::sin(0.466959863901138*x_91 - 4.82599973678589) - 0.00104387766686516*std::sin(0.317919850349426*x_92 - 4.58975982666016) - 0.000329226858614654*std::sin(0.319039851427078*x_92 - 7.57272005081177) + 0.000302494496458515*std::sin(0.321999847888947*x_92 + 8.00944042205811) + 0.000106748072064831*std::sin(0.294959932565689*x_95 + 7.98992013931274) - 0.00171603688682835*std::sin(0.314799934625626*x_95 + 1.76271986961365) - 0.000362133639083123*std::sin(0.283279925584793*x_97 - 4.41336011886597) - 0.000965730085706873*std::sin(0.25927996635437*x_98 + 1.9579998254776) + 7.12086489702781e-5*std::sin(0.263199955224991*x_99 - 4.42944002151489) + 0.154060766100883*std::sin(0.00118804201581854*x_1 + 0.00143798826682857*x_10 + 0.000292234444750907*x_100 - 0.00146044305939448*x_101 + 0.00173826805999203*x_102 + 0.00212834707322865*x_103 + 0.00678643367969161*x_104 + 0.00573654905829622*x_105 - 0.00180362750010442*x_106 - 2.04061539494886e-5*x_107 + 0.000783351007464516*x_108 - 0.00196947464385259*x_109 + 0.0032732813745445*x_11 + 0.000347743353802988*x_111 + 0.000586105349132748*x_112 + 0.00596138124725725*x_113 + 0.0011958582382658*x_114 - 0.0250063127187926*x_115 + 5.87706644484794e-5*x_116 - 0.022215821940121*x_117 + 0.000891722407895882*x_118 + 0.000820475169807632*x_120 + 0.00160047964716172*x_13 - 0.00979378469766088*x_14 + 0.000918971475929262*x_15 - 0.00202940892693036*x_16 + 0.00190000404443713*x_17 + 0.00141408981946785*x_18 + 0.00235631188485434*x_19 + 0.00083982662748092*x_2 + 0.00117017038806357*x_20 + 0.00187500723475879*x_21 + 0.00493063284957161*x_22 - 0.0103484214498857*x_23 + 0.00305088216802541*x_25 + 0.00407510618196192*x_26 + 0.0122286286714225*x_27 + 0.00153741296226176*x_28 - 0.00104934832474521*x_3 + 0.00885438367405418*x_30 + 4.22031769318108e-5*x_31 + 0.000342745523452717*x_32 - 0.00113066960117404*x_33 + 0.00469653804254597*x_34 + 0.000198338738917911*x_35 + 0.000836402474994396*x_36 - 0.00410229212377633*x_37 - 0.000137080889512239*x_38 - 0.00397240697502457*x_39 + 0.00124479037017407*x_4 - 0.0214056826320613*x_40 - 0.028102743125688*x_41 - 9.35980705341474e-5*x_42 + 0.0114379110420766*x_43 + 0.00466068408377498*x_44 + 0.001267713177126*x_45 + 0.00259754252645644*x_46 + 0.00061037956929115*x_47 - 0.00567006234149844*x_48 + 0.0161709285282459*x_49 + 0.00139873682955192*x_5 - 0.0415590555045977*x_50 - 0.0219351679183206*x_51 - 0.00809511722830236*x_52 - 0.0163121873464155*x_53 - 0.0321707443779098*x_54 - 3.27989347212083e-5*x_55 + 0.00072740545161008*x_56 - 0.0227481810365235*x_57 - 0.0192772169283238*x_58 - 0.0349294466797812*x_59 + 0.0019879870465621*x_6 + 0.000583218313995836*x_60 - 6.06132884892462e-5*x_61 + 0.000140196040541103*x_62 + 0.000797378243449258*x_63 + 0.000451291041723088*x_64 - 0.000174383340723414*x_65 + 0.00157976995457571*x_66 + 0.000242832400903916*x_67 + 0.000541821046682535*x_68 - 8.34782593389513e-5*x_69 + 0.00870008682272847*x_7 + 0.000856183629597964*x_70 - 6.87844681339045e-5*x_71 + 0.000414654879950347*x_72 + 0.00044413122119479*x_73 + 0.00021456768851256*x_74 + 0.000639598191292495*x_75 - 5.23006975112227e-6*x_76 + 0.000277605489390615*x_77 + 4.24462562729729e-6*x_78 - 0.000585255157499575*x_79 + 0.00216855542973409*x_8 - 0.00305662616279017*x_80 + 0.000665111970227678*x_81 - 0.000127175787092441*x_82 + 0.000344650632072424*x_83 - 0.000537302690080097*x_84 - 0.000338754239614716*x_85 + 0.000277362658999*x_86 - 0.000314798348504155*x_87 + 0.000598278179346837*x_88 + 0.000170333146963001*x_89 - 0.00870209258936722*x_9 - 9.87106361040021e-5*x_90 + 3.7684594540118e-5*x_91 + 0.00485676072657778*x_92 + 0.00977564060361961*x_93 + 7.46518171095459e-5*x_94 + 0.000267524744288055*x_95 - 2.98856758948845e-5*x_96 + 0.00398350371565379*x_97 + 9.56798590917968e-5*x_98 + 0.0110934809806078*x_99 + 5.70292810330212e-6*std::pow(-9.69608020782471*x_29 - 5.72824001312256, 2) - 0.0931960691975275*std::sin(0.280719965696335*x_110 + 7.9597601890564) + 0.154838266059003*std::sin(0.297039926052094*x_119 + 1.72535991668701) - 0.00699995129884778*std::sin(0.360639840364456*x_12 + 1.83463990688324) + 0.00684383055819499*std::sin(0.348319828510284*x_24 - 7.5699200630188) + 7.85152319547949) - 0.0979329841978998);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.24416863118403e-5*x_1 + 4.05417667803206e-5*x_10 - 2.93826160757598e-5*x_100 - 0.00040629313297457*x_101 + 0.00010609094397654*x_102 - 0.000583653203832788*x_103 - 9.93616279058258e-5*x_104 - 0.000176989845865312*x_105 + 0.000297393426101415*x_106 - 0.000131201484313686*x_107 - 3.13571534074038e-6*x_108 + 0.000138250594650027*x_109 - 0.0001111256358615*x_11 + 5.14308221562196e-6*x_110 + 0.000194492100308901*x_111 - 6.9996269312729e-5*x_112 - 2.33390828017669e-5*x_113 + 1.04675738627795e-5*x_114 - 0.000127142390047276*x_115 - 3.1850340860876e-5*x_116 + 1.44300835363596e-5*x_117 + 0.000114071395671216*x_118 + 0.000178408224201406*x_119 + 8.68578032061993e-5*x_12 + 0.000203124825569474*x_120 + 0.000208521565473695*x_13 + 0.000184787748654384*x_14 - 4.7310968601225e-5*x_15 - 0.000178392944336254*x_16 - 9.2265200738794e-5*x_17 + 4.41311585248323e-5*x_18 - 0.000446965052516744*x_19 - 2.15210710237944e-5*x_2 - 6.69894848802689e-5*x_20 - 0.000168843586266948*x_21 - 7.9611635437105e-5*x_22 - 1.29100818716878e-5*x_23 + 1.40887225996777e-5*x_24 - 3.25423148324256e-5*x_25 - 1.69975294137393e-5*x_26 + 6.65630170231351e-5*x_27 + 3.0106118137416e-5*x_28 - 5.98216318517774e-6*x_29 + 2.37270761510694e-5*x_3 - 0.000384020626763636*x_30 - 1.82215393188274e-5*x_31 + 5.12170037665014e-5*x_32 - 0.000320905838967862*x_33 - 0.000320421238010657*x_34 + 0.000131768666135892*x_35 - 0.00101300783235384*x_36 + 2.4432762198318e-5*x_37 + 5.44157412557731e-5*x_38 - 0.000467794950402719*x_39 + 5.90002643442976e-5*x_4 - 0.000694468829465184*x_40 - 0.000281319847458448*x_41 + 0.000485289853940587*x_42 - 0.00103822801071848*x_43 - 0.000557360615547223*x_44 + 0.000262114453440525*x_45 - 0.000125891524547639*x_46 - 0.000357655364496216*x_47 - 0.000609230774237717*x_48 + 4.03932902967511e-5*x_49 + 1.31871256832585e-5*x_5 + 0.000268208388231045*x_50 - 0.000335955747721644*x_51 + 6.9093385889373e-5*x_52 - 4.63665470504747e-5*x_53 - 0.000273633240136639*x_54 - 0.000608366809948854*x_55 - 4.64907030134577e-5*x_56 + 0.000156944425063444*x_57 - 0.000757100349427024*x_58 + 4.02615369603793e-5*x_59 + 0.000215622205237841*x_6 - 6.73178318093426e-5*x_60 - 1.04140960592935e-5*x_61 - 2.32571552687846e-6*x_62 - 9.60145376163101e-6*x_63 - 2.11934100272346e-6*x_64 + 4.01240023732296e-6*x_65 - 6.51343252898436e-5*x_66 + 9.92087674076005e-7*x_67 + 1.29215739080649e-5*x_68 + 1.02940154264029e-5*x_69 - 9.47811343570368e-5*x_7 + 4.17472891359919e-5*x_70 + 1.5390589693787e-5*x_71 + 6.47017667326207e-5*x_72 + 2.03362811446024e-5*x_73 + 2.1323260240175e-5*x_74 + 1.17982226578798e-5*x_75 + 4.07769037178508e-5*x_76 + 1.96493065966048e-5*x_77 + 2.12737960687488e-5*x_78 + 5.06023657893349e-6*x_79 - 2.75949253691364e-5*x_8 + 1.13415772595662e-5*x_80 - 7.33910525829589e-6*x_81 - 2.75518040722602e-5*x_82 - 9.46124777435662e-6*x_83 + 9.58483370807847e-6*x_84 - 7.26988554441226e-7*x_85 + 0.000114306738319323*x_86 + 1.47710652356877e-5*x_87 + 5.13560943607059e-5*x_88 - 2.58860581900172e-6*x_89 + 4.92176848786646e-5*x_9 - 2.48561086888884e-5*x_90 - 1.00774097427054e-5*x_91 - 5.24798220581252e-5*x_92 + 0.000211752494988226*x_93 - 3.30687009623561e-6*x_94 - 0.000269114599731802*x_95 + 5.54857462228055e-5*x_96 + 6.51054933949366e-5*x_97 + 7.69012691024182e-5*x_98 - 0.000151815857089854*x_99 - 2.67052289000322e-7*std::pow(7.56008005142212 - 7.57863998413086*x_29, 2) + 1.2329550259926e-7*std::pow(-9.79199981689453*x_13 - 9.96739959716797, 2) + 2.20252383528349e-7*std::pow(-9.3638391494751*x_18 - 5.88736009597778, 2) - 1.4481905968113e-8*std::pow(-9.32719993591309*x_28 - 3.25887989997864, 2) - 2.2837580493283e-7*std::pow(-6.40000009536743*x_3 - 0.823999881744385, 2) + 0.000626136246009284*std::sin(0.383359849452972*x_10 - 1.38967990875244) - 0.000372550845013794*std::sin(0.285519927740097*x_100 + 1.75823998451233) - 0.00153448730936497*std::sin(0.253679990768433*x_107 - 1.22095990180969) + 0.0004166950995429*std::sin(0.245599970221519*x_109 - 7.6048002243042) + 0.000753593799711951*std::sin(0.25655996799469*x_109 + 4.97463941574097) - 0.00069630637365867*std::sin(0.408079862594604*x_11 - 1.58663988113403) + 0.000309532820788644*std::sin(0.23471999168396*x_110 - 4.410560131073) - 0.000359425311485035*std::sin(0.283919930458069*x_110 + 4.74656009674072) + 0.000437788813333354*std::sin(0.239999979734421*x_111 + 4.98303985595703) - 0.00238265150888057*std::sin(0.267759948968887*x_112 + 4.9826397895813) - 8.7535711229825e-5*std::sin(0.344319850206375*x_112 + 1.63351988792419) + 0.00167563645186601*std::sin(0.324319839477539*x_113 + 1.80663990974426) + 5.19779141759609e-5*std::sin(0.258559972047806*x_114 - 1.42975986003876) + 0.000380150652297866*std::sin(0.269039958715439*x_116 + 8.17503929138184) - 9.84681469705427e-5*std::sin(0.31703993678093*x_116 + 7.74711990356445) + 0.000612687087006965*std::sin(0.262799948453903*x_118 + 8.14888000488281) - 0.000279458785874738*std::sin(0.270159959793091*x_119 - 7.64079999923706) - 0.000288459928967931*std::sin(0.308079928159714*x_120 + 4.95815992355347) - 0.000737278388935135*std::sin(0.285999953746796*x_14 + 1.7739999294281) - 0.00150701010224736*std::sin(0.329199850559235*x_14 - 1.32287991046906) + 0.000490425264257709*std::sin(0.283679932355881*x_15 - 4.61175966262817) + 4.60813746826987e-5*std::sin(0.315439850091934*x_15 - 8.15695953369141) + 0.000114309221209041*std::sin(0.341599822044373*x_15 + 5.05247974395752) - 0.000275476930837981*std::sin(0.327279835939407*x_16 + 1.80663990974426) - 0.000362858380764827*std::sin(0.383679836988449*x_16 - 7.60168027877808) - 0.000869595480067093*std::sin(0.395519822835922*x_16 + 4.79496002197266) - 0.0060879819499777*std::sin(0.151760026812553*x_18 + 1.7475198507309) + 0.00162802016316585*std::sin(0.186320006847382*x_19 + 4.78311967849731) + 0.0014967283316854*std::sin(0.245839968323708*x_19 + 1.5927197933197) + 0.00132108320610448*std::sin(0.356159836053848*x_2 + 8.18231964111328) + 0.00142964674768522*std::sin(0.287679940462112*x_20 - 4.59008026123047) - 0.000799234645510891*std::sin(0.302239924669266*x_20 - 4.4015998840332) + 0.000365860042924752*std::sin(0.344079852104187*x_20 + 1.80431985855103) + 0.00165026915285035*std::sin(0.346959829330444*x_20 - 1.35039985179901) + 0.000304828818783475*std::sin(0.42087984085083*x_20 + 7.9967999458313) - 0.000609862492858429*std::sin(0.381999850273132*x_22 - 4.39847993850708) + 0.000292562312215483*std::sin(0.479119867086411*x_23 + 1.40255987644196) - 0.000215120208661867*std::sin(0.276079952716827*x_24 + 4.81767988204956) + 0.000518335798276273*std::sin(0.370879858732224*x_24 + 8.21424007415771) - 0.000704073201917594*std::sin(0.392479836940765*x_25 + 1.80199980735779) - 0.000282127473312251*std::sin(0.443039864301682*x_25 - 1.40151989459991) + 0.000613580941184619*std::sin(0.30175992846489*x_26 - 1.37311983108521) + 0.00189165530142277*std::sin(0.105680070817471*x_27 - 1.46623992919922) + 0.000733721694455123*std::sin(0.395599842071533*x_27 + 8.00263977050781) - 0.00251462915457791*std::sin(0.33519983291626*x_28 - 4.36367988586426) + 0.000448337160920258*std::sin(0.22087998688221*x_29 + 1.8096798658371) - 0.000320110033375754*std::sin(0.316319912672043*x_3 + 1.85055994987488) + 1.47114619072192e-5*std::sin(0.394639849662781*x_3 + 8.19960021972656) + 0.00238955183573317*std::sin(0.320719838142395*x_32 + 8.20911979675293) + 0.000616045463490994*std::sin(0.271839946508408*x_33 + 8.16720008850098) + 0.000398286091660664*std::sin(0.2743199467659*x_33 + 4.98183965682983) + 0.00109269126476349*std::sin(0.282239943742752*x_33 + 4.96551990509033) - 0.000272658308751175*std::sin(0.267839968204498*x_36 - 7.61712026596069) + 0.00089304615168893*std::sin(0.291279941797256*x_36 - 7.6300802230835) - 0.00307714121491082*std::sin(0.222559988498688*x_37 - 1.37927985191345) + 0.00049255450775595*std::sin(0.249999970197678*x_38 - 7.82919979095459) + 0.00172073740891698*std::sin(0.371439844369888*x_4 + 8.19215965270996) - 3.81326190177745e-5*std::sin(0.243199974298477*x_40 + 1.5868798494339) - 0.00263987962515579*std::sin(0.246719971299171*x_41 - 1.21727979183197) - 0.000845045841527636*std::sin(0.197679996490479*x_43 - 1.37815976142883) + 0.000201674820499666*std::sin(0.242079973220825*x_43 + 1.76151990890503) + 0.00119934560224219*std::sin(0.245839968323708*x_44 + 1.78511989116669) + 0.00874460190809392*std::sin(0.168080016970634*x_45 + 7.99632024765015) - 0.000506784502224032*std::sin(0.207440003752708*x_47 - 7.60143995285034) - 0.000502874778522914*std::sin(0.283519923686981*x_48 - 4.45199966430664) - 0.000175507477207025*std::sin(0.431199848651886*x_5 - 7.61520004272461) - 0.00160802992714212*std::sin(0.274159938097*x_51 - 7.84543991088867) - 0.000492923913367597*std::sin(0.241199970245361*x_53 - 4.41567993164063) + 0.00024026342206248*std::sin(0.270639955997467*x_53 - 4.42847967147827) - 0.00101855735360314*std::sin(0.229999989271164*x_55 - 4.41167974472046) + 0.00244064352636364*std::sin(0.244719967246056*x_57 + 1.76287984848022) - 0.000114759133489641*std::sin(0.319679915904999*x_59 - 4.87175989151001) - 0.000115285169098824*std::sin(0.583919823169708*x_6 - 7.98712015151978) + 0.000314766763885713*std::sin(0.356159836053848*x_60 + 1.85079991817474) - 0.000512509248091427*std::sin(0.417679876089096*x_60 + 7.98752021789551) - 0.000731172692657344*std::sin(0.436959862709045*x_60 - 4.45959997177124) + 0.0029626711336618*std::sin(0.212479993700981*x_7 + 4.81024026870728) + 0.000392675922881503*std::sin(0.352559864521027*x_7 - 7.59416007995605) + 0.000444256977949576*std::sin(0.369039833545685*x_7 + 5.00751972198486) + 0.000235297846141481*std::sin(0.369439840316772*x_8 - 1.3796797990799) - 0.000181717536050735*std::sin(0.288959950208664*x_9 - 1.6341598033905) + 0.000391457387966184*std::sin(0.380959838628769*x_9 + 1.82615983486176) - 8.75508346532905e-5*std::sin(0.466959863901138*x_91 - 4.82599973678589) - 0.000419069988732126*std::sin(0.317919850349426*x_92 - 4.58975982666016) - 0.00153468222894762*std::sin(0.319039851427078*x_92 - 7.57272005081177) - 0.000879584946431453*std::sin(0.321999847888947*x_92 + 8.00944042205811) - 0.000441122903725523*std::sin(0.294959932565689*x_95 + 7.98992013931274) - 0.000688911719882559*std::sin(0.314799934625626*x_95 + 1.76271986961365) + 0.00105300195958322*std::sin(0.283279925584793*x_97 - 4.41336011886597) + 0.00280812264569652*std::sin(0.25927996635437*x_98 + 1.9579998254776) + 0.000236413653406175*std::sin(0.263199955224991*x_99 - 4.42944002151489) + 0.199726715683937*std::sin(0.00119050340090604*x_1 + 0.00144096749048298*x_10 + 0.000292839895984773*x_100 - 0.00146346880488131*x_101 + 0.00174186940323071*x_102 + 0.00213275658204846*x_103 + 0.00680049381092775*x_104 + 0.00574843403889267*x_105 - 0.00180736425501127*x_106 - 2.04484314130426e-5*x_107 + 0.000784973953843831*x_108 - 0.00197355500082148*x_109 + 0.00328006295790199*x_11 + 0.000348463808377767*x_111 + 0.000587319642017047*x_112 + 0.00597373203511449*x_113 + 0.00119833581700059*x_114 - 0.0250581207898875*x_115 + 5.88924254932317e-5*x_116 - 0.0222618486732683*x_117 + 0.000893569878109692*x_118 + 0.000822175030015213*x_120 + 0.00160379552040855*x_13 - 0.00981407545782254*x_14 + 0.000920875400753947*x_15 - 0.00203361345572872*x_16 + 0.00190394047223926*x_17 + 0.00141701953032628*x_18 + 0.00236119369110163*x_19 + 0.00084156658003263*x_2 + 0.00117259474671811*x_20 + 0.00187889187417821*x_21 + 0.00494084813321163*x_22 - 0.0103698613063021*x_23 + 0.00305720298477439*x_25 + 0.00408354898571186*x_26 + 0.0122539639405893*x_27 + 0.00154059817396997*x_28 - 0.00105152236428567*x_3 + 0.00887272818346049*x_30 + 4.22906134609585e-5*x_31 + 0.000343455623524094*x_32 - 0.0011330121221103*x_33 + 0.0047062683286359*x_34 + 0.000198749657056954*x_35 + 0.000838135333388025*x_36 - 0.00411079125135226*x_37 - 0.000137364893657491*x_38 - 0.00398063700658877*x_39 + 0.00124736932648489*x_4 - 0.0214500309188363*x_40 - 0.0281609663803594*x_41 - 9.37919869882488e-5*x_42 + 0.0114616081026992*x_43 + 0.00467034008764402*x_44 + 0.00127033962490129*x_45 + 0.00260292411427372*x_46 + 0.000611644153497399*x_47 - 0.00568180957493522*x_48 + 0.0162044314530587*x_49 + 0.0014016347320905*x_5 - 0.0416451575431682*x_50 - 0.0219806131925508*x_51 - 0.008111888689717*x_52 - 0.0163459829312048*x_53 - 0.0322373957163398*x_54 - 3.28668875442008e-5*x_55 + 0.00072891249000377*x_56 - 0.022795310711085*x_57 - 0.0193171554605003*x_58 - 0.0350018134968022*x_59 + 0.0019921057575213*x_6 + 0.000584426625521614*x_60 - 6.07388670819264e-5*x_61 + 0.00014048649865531*x_62 + 0.000799030251451826*x_63 + 0.000452226026366246*x_64 - 0.000174744628075754*x_65 + 0.00158304292148773*x_66 + 0.000243335500998346*x_67 + 0.000542943591362469*x_68 - 8.36512095712924e-5*x_69 + 0.00871811165996507*x_7 + 0.000857957470581692*x_70 - 6.89269757740904e-5*x_71 + 0.000415513961804673*x_72 + 0.000445051372123952*x_73 + 0.000215012229784443*x_74 + 0.000640923310630931*x_75 - 5.24090540804397e-6*x_76 + 0.00027818063235921*x_77 + 4.25341964138258e-6*x_78 - 0.000586467688957107*x_79 + 0.00217304824221469*x_8 - 0.00306295887994577*x_80 + 0.000666489949005562*x_81 - 0.000127439269849508*x_82 + 0.000345364679147261*x_83 - 0.000538415873630194*x_84 - 0.00033945607054545*x_85 + 0.000277937298871663*x_86 - 0.000315450547626963*x_87 + 0.000599517691897075*x_88 + 0.000170686043125138*x_89 - 0.00872012158215053*x_9 - 9.89151447698981e-5*x_90 + 3.77626694716392e-5*x_91 + 0.00486682296197582*x_92 + 0.00979589377285276*x_93 + 7.48064807215573e-5*x_94 + 0.000268079001972008*x_95 - 2.99475930291255e-5*x_96 + 0.00399175673744186*x_97 + 9.58780885947996e-5*x_98 + 0.0111164644511337*x_99 + 5.71474342801422e-6*std::pow(-9.69608020782471*x_29 - 5.72824001312256, 2) - 0.0933891527853818*std::sin(0.280719965696335*x_110 + 7.9597601890564) + 0.155159059931591*std::sin(0.297039926052094*x_119 + 1.72535991668701) - 0.00701445379582244*std::sin(0.360639840364456*x_12 + 1.83463990688324) + 0.00685800960426658*std::sin(0.348319828510284*x_24 - 7.5699200630188) - 4.72746779108257) - 0.171619452256867);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000312036382451476*x_1 + 4.37439168407842e-5*x_10 - 0.000595794729927093*x_100 - 0.000296098425584121*x_101 + 0.00042027731473094*x_102 - 0.000395894867202729*x_103 + 0.000100743613492006*x_104 - 0.000915650140327551*x_105 - 0.000429145962554867*x_106 - 2.39382044093352e-6*x_107 - 0.000511270024180654*x_108 - 5.35896416928301e-5*x_109 + 0.000622752032824098*x_11 - 3.90925829930167e-5*x_110 - 0.000490569912516706*x_111 - 0.000191715856397419*x_112 - 4.90517115593521e-5*x_113 + 3.4030926648418e-5*x_114 - 0.000408479279580808*x_115 - 0.000182551688246472*x_116 - 0.0010764483477643*x_117 + 0.000527315805937095*x_118 + 8.60801025265831e-5*x_119 - 0.00021462735463244*x_12 - 3.29933366903358e-5*x_120 - 0.000388101105348628*x_13 - 0.000651035515941694*x_14 + 0.00013666549849127*x_15 - 0.000285066909428057*x_16 - 0.000329057645489948*x_17 + 0.000194901699464771*x_18 - 0.000291419614194358*x_19 - 0.000184738900453056*x_2 - 2.22918278108876e-5*x_20 - 0.000134039525723488*x_21 - 0.000118202053818822*x_22 - 2.1002940396693e-5*x_23 + 0.000204206809265178*x_24 - 4.89080861385661e-5*x_25 + 9.43398017033223e-5*x_26 + 3.75617699147841e-5*x_27 - 2.26788503836796e-5*x_28 - 3.67497641735875e-5*x_29 - 0.000487836752564933*x_3 - 7.33454498766497e-5*x_30 - 8.10221673792597e-6*x_31 - 9.60802076640524e-6*x_32 - 7.45231816983401e-5*x_33 - 0.00069090384929289*x_34 + 0.000829901302675342*x_35 - 0.000784708464954293*x_36 - 0.000438905404405812*x_37 - 0.000177009977160135*x_38 + 0.000477930054789806*x_39 - 0.000148793601888553*x_4 - 0.00087414143828462*x_40 + 0.000248343646950907*x_41 - 0.000816414421706881*x_42 - 0.00140208288739317*x_43 + 0.000145680838964912*x_44 + 8.936501458482e-5*x_45 - 0.000137924025390466*x_46 - 8.48309843356534e-5*x_47 - 0.000491372878092856*x_48 - 0.00228792334216725*x_49 - 0.000166231760929185*x_5 - 0.00116003181695481*x_50 + 0.00027845779264223*x_51 - 0.000100819275288774*x_52 - 5.90714698552071e-5*x_53 - 0.000348127312532596*x_54 - 0.00114945350175345*x_55 - 0.000237246316220841*x_56 + 0.000277312482193492*x_57 - 0.000898853747516694*x_58 - 0.000218516063136167*x_59 + 7.33846228974085e-5*x_6 - 7.85997542125035e-5*x_60 - 9.3152711152803e-6*x_61 - 3.51350473630709e-5*x_62 - 1.01088470826159e-5*x_63 + 2.33892070560798e-5*x_64 + 1.1972000336588e-5*x_65 - 4.0265691663446e-6*x_66 + 9.05212950771143e-6*x_67 + 1.88114109930341e-5*x_68 + 2.46011591335691e-5*x_69 - 5.65494726101907e-6*x_7 + 2.0815853095902e-5*x_70 + 5.27862594160169e-5*x_71 + 5.99082965649451e-5*x_72 + 2.41591464561139e-5*x_73 + 4.69924128591301e-5*x_74 + 1.2934418916922e-6*x_75 + 1.41353295611154e-5*x_76 + 1.20897238214117e-5*x_77 + 5.27149517330384e-5*x_78 + 1.08023770229475e-5*x_79 - 2.47935400395204e-6*x_8 + 2.48932950183594e-5*x_80 - 1.81283746216197e-5*x_81 - 1.06599709068668e-5*x_82 + 1.53045716073936e-5*x_83 + 1.02215783680286e-5*x_84 + 2.21601998095632e-5*x_85 - 0.000148445031714812*x_86 + 5.27753147769409e-5*x_87 - 9.66848695309825e-5*x_88 + 1.12846149206055e-5*x_89 - 1.01479201415135e-5*x_9 + 8.313145614103e-6*x_90 + 3.17015345410052e-6*x_91 - 0.000463256908979952*x_92 - 0.000117376513920805*x_93 - 4.58723297814916e-5*x_94 - 2.55324969296074e-6*x_95 + 1.11561778687904e-5*x_96 + 4.26679478366954e-6*x_97 - 1.9146440400115e-5*x_98 + 0.000244351555540629*x_99 + 8.61192819846245e-9*std::pow(7.56008005142212 - 7.57863998413086*x_29, 2) + 2.60071014520447e-9*std::pow(-9.79199981689453*x_13 - 9.96739959716797, 2) + 2.29741215954598e-7*std::pow(-9.3638391494751*x_18 - 5.88736009597778, 2) - 1.48703150934217e-8*std::pow(-9.32719993591309*x_28 - 3.25887989997864, 2) - 1.21950634248556e-7*std::pow(-6.40000009536743*x_3 - 0.823999881744385, 2) + 0.0006531112181717*std::sin(0.383359849452972*x_10 - 1.38967990875244) - 7.85833012401937e-6*std::sin(0.285519927740097*x_100 + 1.75823998451233) + 4.94842960499282e-5*std::sin(0.253679990768433*x_107 - 1.22095990180969) + 8.78947852916016e-6*std::sin(0.245599970221519*x_109 - 7.6048002243042) + 0.000786059851467558*std::sin(0.25655996799469*x_109 + 4.97463941574097) + 2.24545556846847e-5*std::sin(0.408079862594604*x_11 - 1.58663988113403) + 0.000278487685781662*std::sin(0.23471999168396*x_110 - 4.410560131073) - 0.000374909940962359*std::sin(0.283919930458069*x_110 + 4.74656009674072) + 9.23441475390777e-6*std::sin(0.239999979734421*x_111 + 4.98303985595703) + 7.68359776778133e-5*std::sin(0.267759948968887*x_112 + 4.9826397895813) - 7.87561641493631e-5*std::sin(0.344319850206375*x_112 + 1.63351988792419) - 5.40360873303695e-5*std::sin(0.324319839477539*x_113 + 1.80663990974426) - 0.000433273700325928*std::sin(0.258559972047806*x_114 - 1.42975986003876) + 0.000396528163308636*std::sin(0.269039958715439*x_116 + 8.17503929138184) - 2.07701905914703e-6*std::sin(0.31703993678093*x_116 + 7.74711990356445) + 0.00543724218665099*std::sin(0.262799948453903*x_118 + 8.14888000488281) + 0.00232949213457545*std::sin(0.270159959793091*x_119 - 7.64079999923706) - 6.08457444056326e-6*std::sin(0.308079928159714*x_120 + 4.95815992355347) - 0.0007690415461461*std::sin(0.285999953746796*x_14 + 1.7739999294281) + 4.85982084014123e-5*std::sin(0.329199850559235*x_14 - 1.32287991046906) + 0.00435223949185526*std::sin(0.283679932355881*x_15 - 4.61175966262817) + 4.80666355699166e-5*std::sin(0.315439850091934*x_15 - 8.15695953369141) + 0.000102844378172571*std::sin(0.341599822044373*x_15 + 5.05247974395752) - 0.000287344926961995*std::sin(0.327279835939407*x_16 + 1.80663990974426) + 0.00302468838584065*std::sin(0.383679836988449*x_16 - 7.60168027877808) + 2.80427996482601e-5*std::sin(0.395519822835922*x_16 + 4.79496002197266) - 0.00325092783060756*std::sin(0.151760026812553*x_18 + 1.7475198507309) - 5.25005526195528e-5*std::sin(0.186320006847382*x_19 + 4.78311967849731) + 0.000134357747426068*std::sin(0.245839968323708*x_19 + 1.5927197933197) - 4.26024197648897e-5*std::sin(0.356159836053848*x_2 + 8.18231964111328) + 0.00012833599295718*std::sin(0.287679940462112*x_20 - 4.59008026123047) + 2.57737966097534e-5*std::sin(0.302239924669266*x_20 - 4.4015998840332) + 0.000375672520617309*std::sin(0.344079852104187*x_20 + 1.80431985855103) + 0.000881228945991538*std::sin(0.346959829330444*x_20 - 1.35039985179901) + 0.00270517879084606*std::sin(0.42087984085083*x_20 + 7.9967999458313) - 0.00063613636515477*std::sin(0.381999850273132*x_22 - 4.39847993850708) - 9.43457790909576e-6*std::sin(0.479119867086411*x_23 + 1.40255987644196) - 0.000193544351524578*std::sin(0.276079952716827*x_24 + 4.81767988204956) + 0.000532237722129941*std::sin(0.370879858732224*x_24 + 8.21424007415771) + 2.27050211180499e-5*std::sin(0.392479836940765*x_25 + 1.80199980735779) + 0.00235173758438612*std::sin(0.443039864301682*x_25 - 1.40151989459991) - 1.97868178895129e-5*std::sin(0.30175992846489*x_26 - 1.37311983108521) + 3.99012699565373e-5*std::sin(0.105680070817471*x_27 - 1.46623992919922) - 2.36611285900422e-5*std::sin(0.395599842071533*x_27 + 8.00263977050781) - 0.00134278944475262*std::sin(0.33519983291626*x_28 - 4.36367988586426) + 0.000403370402132116*std::sin(0.22087998688221*x_29 + 1.8096798658371) - 6.75217987543255e-6*std::sin(0.316319912672043*x_3 + 1.85055994987488) + 1.51060277926749e-5*std::sin(0.394639849662781*x_3 + 8.19960021972656) + 0.00127599927681993*std::sin(0.320719838142395*x_32 + 8.20911979675293) + 0.00063256799030147*std::sin(0.271839946508408*x_33 + 8.16720008850098) + 8.40117163593885e-6*std::sin(0.2743199467659*x_33 + 4.98183965682983) + 0.00113976618917007*std::sin(0.282239943742752*x_33 + 4.96551990509033) - 5.7512659812762e-6*std::sin(0.267839968204498*x_36 - 7.61712026596069) + 0.000931520038538797*std::sin(0.291279941797256*x_36 - 7.6300802230835) - 0.000276227658283034*std::sin(0.222559988498688*x_37 - 1.37927985191345) - 1.58839456890712e-5*std::sin(0.249999970197678*x_38 - 7.82919979095459) - 5.54905073814346e-5*std::sin(0.371439844369888*x_4 + 8.19215965270996) + 0.00031786310025867*std::sin(0.243199974298477*x_40 + 1.5868798494339) + 8.51310949983964e-5*std::sin(0.246719971299171*x_41 - 1.21727979183197) - 0.00749929123144033*std::sin(0.197679996490479*x_43 - 1.37815976142883) + 0.000181447492056858*std::sin(0.242079973220825*x_43 + 1.76151990890503) - 3.86766136711112e-5*std::sin(0.245839968323708*x_44 + 1.78511989116669) + 0.0046695390926234*std::sin(0.168080016970634*x_45 + 7.99632024765015) - 0.000455955665233805*std::sin(0.207440003752708*x_47 - 7.60143995285034) - 1.06072931347931e-5*std::sin(0.283519923686981*x_48 - 4.45199966430664) - 0.000157904648173436*std::sin(0.431199848651886*x_5 - 7.61520004272461) - 0.000858673577804435*std::sin(0.274159938097*x_51 - 7.84543991088867) - 1.03973964604017e-5*std::sin(0.241199970245361*x_53 - 4.41567993164063) + 0.000216165782412621*std::sin(0.270639955997467*x_53 - 4.42847967147827) - 0.00106243846803213*std::sin(0.229999989271164*x_55 - 4.41167974472046) + 0.000219090772540517*std::sin(0.244719967246056*x_57 + 1.76287984848022) - 0.000119703144399401*std::sin(0.319679915904999*x_59 - 4.87175989151001) - 0.000118377152418516*std::sin(0.583919823169708*x_6 - 7.98712015151978) + 0.000283196681412245*std::sin(0.356159836053848*x_60 + 1.85079991817474) - 0.000534588983593662*std::sin(0.417679876089096*x_60 + 7.98752021789551) + 0.0060948559238538*std::sin(0.436959862709045*x_60 - 4.45959997177124) + 0.00158203984842532*std::sin(0.212479993700981*x_7 + 4.81024026870728) + 8.28283461185697e-6*std::sin(0.352559864521027*x_7 - 7.59416007995605) - 0.00370320486659406*std::sin(0.369039833545685*x_7 + 5.00751972198486) + 4.9632101958647e-6*std::sin(0.369439840316772*x_8 - 1.3796797990799) - 0.00161263763187178*std::sin(0.288959950208664*x_9 - 1.6341598033905) - 0.00326308190109084*std::sin(0.380959838628769*x_9 + 1.82615983486176) - 0.000776962827760666*std::sin(0.466959863901138*x_91 - 4.82599973678589) + 0.00349325300162752*std::sin(0.317919850349426*x_92 - 4.58975982666016) - 0.000137764778638238*std::sin(0.319039851427078*x_92 - 7.57272005081177) + 2.83649409315004e-5*std::sin(0.321999847888947*x_92 + 8.00944042205811) - 0.000460127198915333*std::sin(0.294959932565689*x_95 + 7.98992013931274) + 0.00574257999389791*std::sin(0.314799934625626*x_95 + 1.76271986961365) - 3.395730964418e-5*std::sin(0.283279925584793*x_97 - 4.41336011886597) - 9.0556612293953e-5*std::sin(0.25927996635437*x_98 + 1.9579998254776) + 0.000212702133029148*std::sin(0.263199955224991*x_99 - 4.42944002151489) + 0.257403939962387*std::sin(0.0011731445650988*x_1 + 0.00141995661554401*x_10 + 0.000288569971456764*x_100 - 0.00144212983627895*x_101 + 0.00171647105078139*x_102 + 0.00210165866893339*x_103 + 0.0067013352067758*x_104 + 0.00566461561170136*x_105 - 0.00178101091631209*x_106 - 2.01502710187554e-5*x_107 + 0.00077352817891588*x_108 - 0.00194477842009963*x_109 + 0.00323223606863794*x_11 + 0.000343382826643663*x_111 + 0.000578755882161864*x_112 + 0.00588662851783345*x_113 + 0.00118086277603875*x_114 - 0.0246927461054486*x_115 + 5.80337098073725e-5*x_116 - 0.0219372466808753*x_117 + 0.000880540656366528*x_118 + 0.000810186822892092*x_120 + 0.00158041043550584*x_13 - 0.0096709755520663*x_14 + 0.000907448034760332*x_15 - 0.00200396115734258*x_16 + 0.00187617894714055*x_17 + 0.00139635784272097*x_18 + 0.00232676491621387*x_19 + 0.000829295622996705*x_2 + 0.00115549703858791*x_20 + 0.00185149558491219*x_21 + 0.00486880518782598*x_22 - 0.0102186574377345*x_23 + 0.00301262563656884*x_25 + 0.00402400639532546*x_26 + 0.0120752878041998*x_27 + 0.00151813457518771*x_28 - 0.00103619002331513*x_3 + 0.00874335414590488*x_30 + 4.16739702706096e-5*x_31 + 0.000338447666578076*x_32 - 0.0011164915717445*x_33 + 0.00463764581221184*x_34 + 0.000195851670658116*x_35 + 0.000825914407664124*x_36 - 0.0040508514390714*x_37 - 0.000135361963944847*x_38 - 0.00392259498490871*x_39 + 0.001229181323567*x_4 - 0.0211372661132114*x_40 - 0.0277503488288281*x_41 - 9.24243976970934e-5*x_42 + 0.0112944853771445*x_43 + 0.00460224144409235*x_44 + 0.0012518166900224*x_45 + 0.00256497064661964*x_46 + 0.000602725715780266*x_47 - 0.00559896260496924*x_48 + 0.015968153199062*x_49 + 0.00138119737159447*x_5 - 0.041037925802874*x_50 - 0.0216601119196763*x_51 - 0.00799360852038343*x_52 - 0.0161076407025353*x_53 - 0.0317673393866671*x_54 - 3.23876525382861e-5*x_55 + 0.00071828415225842*x_56 - 0.0224629302613463*x_57 - 0.0190354903013362*x_58 - 0.0344914489459878*x_59 + 0.00196305868656868*x_6 + 0.000575905048996857*x_60 - 5.98532282672955e-5*x_61 + 0.000138438052542989*x_62 + 0.000787379520400231*x_63 + 0.000445632078517399*x_64 - 0.000172196661136177*x_65 + 0.00155996043207275*x_66 + 0.000239787404449704*x_67 + 0.000535026882642546*x_68 - 8.24314838561711e-5*x_69 + 0.00859099209966874*x_7 + 0.000845447516515133*x_70 - 6.79219454195018e-5*x_71 + 0.000409455315829288*x_72 + 0.000438562038545733*x_73 + 0.000211877117368524*x_74 + 0.000631577950923597*x_75 - 5.16448730088842e-6*x_76 + 0.000274124455855891*x_77 + 4.19140015188105e-6*x_78 - 0.000577916351505146*x_79 + 0.00214136283282477*x_8 - 0.00301829760452159*x_80 + 0.000656771799873729*x_81 - 0.00012558106653902*x_82 + 0.000340328886091674*x_83 - 0.000530565183964594*x_84 - 0.00033450643143658*x_85 + 0.000273884670435535*x_86 - 0.000310850935179497*x_87 + 0.000590776071193386*x_88 + 0.000168197254773135*x_89 - 0.00859297271500033*x_9 - 9.74728542601838e-5*x_90 + 3.72120486346872e-5*x_91 + 0.00479585938418552*x_92 + 0.00965305897585962*x_93 + 7.37157207832201e-5*x_94 + 0.000264170118238407*x_95 - 2.95109245157732e-5*x_96 + 0.00393355257797878*x_97 + 9.44800816708699e-5*x_98 + 0.0109543742958117*x_99 + 5.63141624661191e-6*std::pow(-9.69608020782471*x_29 - 5.72824001312256, 2) - 0.0920274372555108*std::sin(0.280719965696335*x_110 + 7.9597601890564) + 0.152896671900353*std::sin(0.297039926052094*x_119 + 1.72535991668701) - 0.00691217542213074*std::sin(0.360639840364456*x_12 + 1.83463990688324) + 0.00675801235722445*std::sin(0.348319828510284*x_24 - 7.5699200630188) - 7.94715917122928) + 0.293392035416255);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-5.1987360817446e-5*x_1 + 0.000217254310195294*x_10 - 0.00022361704600574*x_100 - 7.0075938404583e-5*x_101 + 0.000490047933267766*x_102 - 0.000352384650477867*x_103 + 0.000218976957224008*x_104 + 0.000112011817813536*x_105 - 0.000723625169641447*x_106 - 7.45780314808904e-5*x_107 - 0.000237386576312228*x_108 - 0.000135279242104783*x_109 + 0.000658708213582288*x_11 - 3.9061393658636e-5*x_110 - 0.00040727572412856*x_111 - 5.35927505897147e-5*x_112 + 0.000454125443461195*x_113 + 5.80042479738205e-5*x_114 - 0.0024964755060891*x_115 + 5.63959768738812e-5*x_116 - 0.00221094772191143*x_117 - 8.41953786490884e-5*x_118 + 0.000299752607977094*x_119 - 0.000303913721768367*x_12 - 2.05924324139377e-5*x_120 + 0.000444369749567868*x_13 - 0.00106691068188326*x_14 + 0.000125013765180209*x_15 - 0.000291791203215774*x_16 + 4.63864985367846e-5*x_17 + 0.000189419529056697*x_18 - 0.000325310795616495*x_19 + 2.54284681788218e-6*x_2 + 0.00020843684447469*x_20 - 6.99545115565363e-5*x_21 + 0.000219058160342781*x_22 - 0.00085325048955055*x_23 - 9.480932228457e-6*x_24 + 0.000179919461305127*x_25 + 0.000352432983343397*x_26 + 0.00102231347829122*x_27 + 0.000133331101310617*x_28 - 1.19104969312804e-6*x_29 - 0.000190016286546527*x_3 + 0.000518375030140115*x_30 - 5.32413385554294e-6*x_31 + 2.03194968996166e-5*x_32 + 6.79331540478527e-5*x_33 - 0.000541402275059285*x_34 - 7.67951259909306e-5*x_35 - 8.42959607256868e-5*x_36 - 0.000705157335170728*x_37 - 0.000176929313747738*x_38 - 0.000728628097413795*x_39 + 6.54042130782894e-5*x_4 - 0.00210005136562398*x_40 - 0.00217044877915407*x_41 - 0.000159988506668988*x_42 + 0.00033408898591146*x_43 + 5.47252507079976e-5*x_44 - 0.0002040032262489*x_45 - 2.85217012035112e-5*x_46 + 3.2604796842185e-5*x_47 - 0.00113427768529872*x_48 + 0.000580847586768098*x_49 + 2.92025346782105e-5*x_5 - 0.00342416525762915*x_50 - 0.00155137543241641*x_51 - 0.000873821584449218*x_52 - 0.00135613013043183*x_53 - 0.00292742293881938*x_54 - 0.000216917916569506*x_55 - 0.00049423340783343*x_56 - 0.00219064419866339*x_57 - 0.00231856800416275*x_58 - 0.00288063208326557*x_59 + 0.000308082140666114*x_6 - 0.000114257643207317*x_60 - 1.82511284720374e-5*x_61 + 3.25042049078035e-6*x_62 + 6.14022681036646e-5*x_63 + 3.67360277169958e-5*x_64 - 1.62543973644925e-5*x_65 + 9.07122437844166e-5*x_66 + 2.34924204394422e-5*x_67 + 5.24392169281263e-5*x_68 + 1.65298929311372e-5*x_69 + 0.000733940019958038*x_7 + 9.06689604891567e-5*x_70 + 3.30795394287414e-5*x_71 + 9.58292912184135e-5*x_72 + 4.45338730935782e-5*x_73 + 3.31065178562764e-5*x_74 + 5.11950900651279e-5*x_75 + 1.28255225617466e-5*x_76 + 3.02436097969116e-5*x_77 + 1.98972862293207e-5*x_78 - 3.11019236357158e-5*x_79 + 0.00010886418139526*x_8 - 0.000230497687286806*x_80 + 4.04316017417324e-5*x_81 - 3.43575282709915e-5*x_82 + 4.72513587908606e-5*x_83 - 3.20837197001141e-5*x_84 - 1.92125184247395e-5*x_85 - 6.04464039522589e-5*x_86 + 1.28056822215156e-6*x_87 + 2.94705078425539e-5*x_88 + 1.54219678996893e-5*x_89 - 0.000739630275750575*x_9 + 2.29710410241812e-5*x_90 + 4.78762118214504e-8*x_91 + 0.00033253036340235*x_92 + 0.000671075149225457*x_93 - 1.36789337089148e-5*x_94 + 1.32478652315675e-5*x_95 - 1.11213991498895e-5*x_96 + 0.000174335985305539*x_97 - 0.000186914263089378*x_98 + 0.00116047347675788*x_99 + 1.30647972906742e-7*std::pow(7.56008005142212 - 7.57863998413086*x_29, 2) - 1.25126647790614e-7*std::pow(-9.79199981689453*x_13 - 9.96739959716797, 2) - 5.26533437178241e-7*std::pow(-9.3638391494751*x_18 - 5.88736009597778, 2) - 2.30952120555089e-9*std::pow(-9.32719993591309*x_28 - 3.25887989997864, 2) + 4.63389454206138e-7*std::pow(-9.69608020782471*x_29 - 5.72824001312256, 2) - 1.99920797441773e-7*std::pow(-6.40000009536743*x_3 - 0.823999881744385, 2) - 0.00149683587742294*std::sin(0.383359849452972*x_10 - 1.38967990875244) + 0.000378083850468173*std::sin(0.285519927740097*x_100 + 1.75823998451233) + 0.000750705628362585*std::sin(0.253679990768433*x_107 - 1.22095990180969) - 0.000422883721282567*std::sin(0.245599970221519*x_109 - 7.6048002243042) - 0.00180153479949729*std::sin(0.25655996799469*x_109 + 4.97463941574097) + 0.000340648704345837*std::sin(0.408079862594604*x_11 - 1.58663988113403) + 0.000428689052361102*std::sin(0.23471999168396*x_110 - 4.410560131073) - 0.00757261442847124*std::sin(0.280719965696335*x_110 + 7.9597601890564) + 0.000859239031303001*std::sin(0.283919930458069*x_110 + 4.74656009674072) - 0.0004442907121331*std::sin(0.239999979734421*x_111 + 4.98303985595703) + 0.00116564658907702*std::sin(0.267759948968887*x_112 + 4.9826397895813) - 0.000121233027887831*std::sin(0.344319850206375*x_112 + 1.63351988792419) - 0.000819758956511606*std::sin(0.324319839477539*x_113 + 1.80663990974426) - 0.000212620415577652*std::sin(0.258559972047806*x_114 - 1.42975986003876) - 0.000908784851239455*std::sin(0.269039958715439*x_116 + 8.17503929138184) + 9.99305642528075e-5*std::sin(0.31703993678093*x_116 + 7.74711990356445) + 0.000301996466667276*std::sin(0.262799948453903*x_118 + 8.14888000488281) + 0.00114315174303383*std::sin(0.270159959793091*x_119 - 7.64079999923706) + 0.012581329853652*std::sin(0.297039926052094*x_119 + 1.72535991668701) - 0.000568778626187562*std::sin(0.360639840364456*x_12 + 1.83463990688324) + 0.000292744043154519*std::sin(0.308079928159714*x_120 + 4.95815992355347) + 0.00176253132004489*std::sin(0.285999953746796*x_14 + 1.7739999294281) + 0.000737263162003312*std::sin(0.329199850559235*x_14 - 1.32287991046906) + 0.000241733015287965*std::sin(0.283679932355881*x_15 - 4.61175966262817) - 0.000110161734519694*std::sin(0.315439850091934*x_15 - 8.15695953369141) + 0.00015831313652422*std::sin(0.341599822044373*x_15 + 5.05247974395752) + 0.000658552760854758*std::sin(0.327279835939407*x_16 + 1.80663990974426) + 0.00148430541966096*std::sin(0.383679836988449*x_16 - 7.60168027877808) + 0.000425425624116234*std::sin(0.395519822835922*x_16 + 4.79496002197266) - 0.00532943586825513*std::sin(0.151760026812553*x_18 + 1.7475198507309) - 0.000796463999485379*std::sin(0.186320006847382*x_19 + 4.78311967849731) + 5.70830754502247e-5*std::sin(0.245839968323708*x_19 + 1.5927197933197) - 0.000646303551880365*std::sin(0.356159836053848*x_2 + 8.18231964111328) + 5.45246798885591e-5*std::sin(0.287679940462112*x_20 - 4.59008026123047) + 0.000391003524829216*std::sin(0.302239924669266*x_20 - 4.4015998840332) + 5.83460166955202e-5*std::sin(0.344079852104187*x_20 + 1.80431985855103) + 0.00144465008072303*std::sin(0.346959829330444*x_20 - 1.35039985179901) + 0.000150251618098689*std::sin(0.42087984085083*x_20 + 7.9967999458313) + 0.00145793198432974*std::sin(0.381999850273132*x_22 - 4.39847993850708) - 0.000143128048753838*std::sin(0.479119867086411*x_23 + 1.40255987644196) - 0.000297931825646198*std::sin(0.276079952716827*x_24 + 4.81767988204956) + 0.000556093089303541*std::sin(0.348319828510284*x_24 - 7.5699200630188) + 8.26622904713686e-5*std::sin(0.370879858732224*x_24 + 8.21424007415771) + 0.000344448411031526*std::sin(0.392479836940765*x_25 + 1.80199980735779) + 0.0011540682532672*std::sin(0.443039864301682*x_25 - 1.40151989459991) - 0.000300177566273864*std::sin(0.30175992846489*x_26 - 1.37311983108521) - 0.00191974955819513*std::sin(0.105680070817471*x_27 - 1.46623992919922) - 0.000358953118945729*std::sin(0.395599842071533*x_27 + 8.00263977050781) - 0.00220131316450711*std::sin(0.33519983291626*x_28 - 4.36367988586426) + 0.000620926828255181*std::sin(0.22087998688221*x_29 + 1.8096798658371) + 0.000324864204744238*std::sin(0.316319912672043*x_3 + 1.85055994987488) + 2.34612994409631e-6*std::sin(0.394639849662781*x_3 + 8.19960021972656) + 0.00209182014123052*std::sin(0.320719838142395*x_32 + 8.20911979675293) + 9.82446692202399e-5*std::sin(0.271839946508408*x_33 + 8.16720008850098) - 0.00040420130872984*std::sin(0.2743199467659*x_33 + 4.98183965682983) - 0.00261217825747845*std::sin(0.282239943742752*x_33 + 4.96551990509033) + 0.000276707742351161*std::sin(0.267839968204498*x_36 - 7.61712026596069) - 0.00213490838226071*std::sin(0.291279941797256*x_36 - 7.6300802230835) - 0.000117357759870795*std::sin(0.222559988498688*x_37 - 1.37927985191345) - 0.000240968718992389*std::sin(0.249999970197678*x_38 - 7.82919979095459) - 0.00084182335684654*std::sin(0.371439844369888*x_4 + 8.19215965270996) + 0.000155984968445948*std::sin(0.243199974298477*x_40 + 1.5868798494339) + 0.00129148835621476*std::sin(0.246719971299171*x_41 - 1.21727979183197) - 0.000416527235068559*std::sin(0.197679996490479*x_43 - 1.37815976142883) + 0.000279310567017806*std::sin(0.242079973220825*x_43 + 1.76151990890503) - 0.000586746784062833*std::sin(0.245839968323708*x_44 + 1.78511989116669) + 0.00765504816629403*std::sin(0.168080016970634*x_45 + 7.99632024765015) - 0.000701873770465387*std::sin(0.207440003752708*x_47 - 7.60143995285034) + 0.000510343313166376*std::sin(0.283519923686981*x_48 - 4.45199966430664) - 0.000243069972012891*std::sin(0.431199848651886*x_5 - 7.61520004272461) - 0.00140767374827225*std::sin(0.274159938097*x_51 - 7.84543991088867) + 0.000500244660958857*std::sin(0.241199970245361*x_53 - 4.41567993164063) + 0.000332754046755286*std::sin(0.270639955997467*x_53 - 4.42847967147827) + 0.00243495437263592*std::sin(0.229999989271164*x_55 - 4.41167974472046) + 9.30826494114911e-5*std::sin(0.244719967246056*x_57 + 1.76287984848022) + 0.000274342188883147*std::sin(0.319679915904999*x_59 - 4.87175989151001) - 1.83852555944989e-5*std::sin(0.583919823169708*x_6 - 7.98712015151978) + 0.000435937828438151*std::sin(0.356159836053848*x_60 + 1.85079991817474) + 0.00122520016201542*std::sin(0.417679876089096*x_60 + 7.98752021789551) + 0.00299092882499187*std::sin(0.436959862709045*x_60 - 4.45959997177124) + 0.00259353032504295*std::sin(0.212479993700981*x_7 + 4.81024026870728) - 0.000398507819526445*std::sin(0.352559864521027*x_7 - 7.59416007995605) - 0.00181727383201914*std::sin(0.369039833545685*x_7 + 5.00751972198486) - 0.00023879241415422*std::sin(0.369439840316772*x_8 - 1.3796797990799) - 8.95694637321147e-5*std::sin(0.288959950208664*x_9 - 1.6341598033905) - 0.00160129227634159*std::sin(0.380959838628769*x_9 + 1.82615983486176) - 4.31542353017864e-5*std::sin(0.466959863901138*x_91 - 4.82599973678589) + 0.00171424414721042*std::sin(0.317919850349426*x_92 - 4.58975982666016) - 5.85305827467623e-5*std::sin(0.319039851427078*x_92 - 7.57272005081177) + 0.00043031269524305*std::sin(0.321999847888947*x_92 + 8.00944042205811) + 0.00105454458651409*std::sin(0.294959932565689*x_95 + 7.98992013931274) + 0.00281805644762652*std::sin(0.314799934625626*x_95 + 1.76271986961365) - 0.000515152189862747*std::sin(0.283279925584793*x_97 - 4.41336011886597) - 0.00137379661753555*std::sin(0.25927996635437*x_98 + 1.9579998254776) + 0.000327422290100608*std::sin(0.263199955224991*x_99 - 4.42944002151489) + 0.0363357085229738);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000129631765396691*x_1 + 8.23556128778226e-5*x_10 + 9.91366730025509e-5*x_100 - 0.0001134589196756*x_101 + 3.00962113654866e-5*x_102 + 4.78726113809321e-5*x_103 + 0.00050235702367391*x_104 + 0.000513787789008492*x_105 + 4.89883105933931e-5*x_106 + 6.45137585001688e-5*x_107 + 1.24970709508665e-5*x_108 + 3.29263157120943e-5*x_109 + 0.000141462904915319*x_11 - 9.9295026213696e-6*x_110 + 0.000475047176517873*x_111 + 5.79610634981207e-5*x_112 + 0.000183951663469971*x_113 + 5.10696984907655e-5*x_114 - 0.0006396160046251*x_115 + 0.000220544301757441*x_116 - 0.000722361175293145*x_117 + 0.000148414786613827*x_118 - 1.38800619176245e-6*x_119 - 0.000306562547748047*x_12 + 0.000192058068707182*x_120 + 0.000436271660924547*x_13 - 1.58335053932585e-6*x_14 + 5.26146492926219e-6*x_15 + 1.52330640545061e-5*x_16 + 2.99398237212616e-5*x_17 + 0.000140269942220701*x_18 - 9.33905357087939e-5*x_19 + 0.000137576517292069*x_2 + 0.000148223389464526*x_20 + 7.77583322407541e-5*x_21 + 0.000175741084043815*x_22 - 0.000283265977566232*x_23 + 9.50008580006033e-5*x_24 - 1.41666408326107e-5*x_25 + 0.000113093606606137*x_26 + 0.000403522807979454*x_27 + 0.000180908328448142*x_28 + 3.10449759970664e-5*x_29 + 0.000259688086574978*x_3 + 0.000117733343005461*x_30 - 2.47984891169099e-7*x_31 + 3.90078726838003e-5*x_32 - 0.000298470746696057*x_33 + 0.00074759610275413*x_34 + 8.46440910682786e-5*x_35 - 0.00011451054790493*x_36 - 0.000686503991416166*x_37 - 0.000487224119775431*x_38 - 0.00037676999948573*x_39 + 9.80399809694714e-5*x_4 - 0.000402464639147546*x_40 - 0.000957475772167047*x_41 + 0.000496634247074878*x_42 - 5.06661114415143e-5*x_43 - 0.000388989821451356*x_44 + 0.000411719281118353*x_45 + 0.000105853461282371*x_46 - 0.000109581804231017*x_47 - 0.000182482478929155*x_48 + 0.00106554500630607*x_49 + 0.000114668932011153*x_5 - 0.00125741851864881*x_50 - 0.000756759540857856*x_51 - 0.000171373273917676*x_52 - 0.000476522716782617*x_53 + 3.16273148069141e-5*x_54 - 0.000454247232421986*x_55 - 0.000173618951762296*x_56 - 0.000558628867111415*x_57 - 0.00128600343166078*x_58 - 0.00106052881024572*x_59 + 0.000109698414656297*x_6 - 0.000263145908755589*x_60 + 3.69614527609175e-7*x_61 + 1.25150897165094e-5*x_62 + 2.33164428864894e-5*x_63 - 5.73056027888076e-6*x_64 - 1.37515453924583e-5*x_65 + 2.56216022393351e-5*x_66 + 1.25433867696922e-7*x_67 + 1.10952487960026e-5*x_68 - 7.6979455353338e-6*x_69 + 0.000203739076714539*x_7 + 3.69276817294396e-5*x_70 - 1.82401826426007e-6*x_71 + 3.06861238280685e-5*x_72 + 1.84488814909847e-5*x_73 + 1.47647888517681e-6*x_74 + 1.91915476138138e-5*x_75 + 4.35076225855744e-6*x_76 + 7.12802267104771e-6*x_77 - 1.73280780521891e-5*x_78 - 1.69746454403528e-5*x_79 + 9.86568549134054e-5*x_8 - 0.000103682932809344*x_80 + 1.51998352333857e-5*x_81 - 1.15485828310642e-5*x_82 - 4.00329776948729e-7*x_83 - 1.60810920484051e-5*x_84 - 3.05103401737362e-5*x_85 + 9.06061978234404e-5*x_86 - 3.66760953333767e-6*x_87 + 9.04171653870142e-5*x_88 - 4.23857387307383e-6*x_89 - 0.000212401295235577*x_9 - 4.61224840217889e-5*x_90 + 8.83054990381356e-7*x_91 + 0.000525601630573149*x_92 + 0.000446129270738078*x_93 + 1.1960127783972e-5*x_94 - 0.000124531202462896*x_95 + 0.000126452845707174*x_96 + 0.00039576555332214*x_97 + 9.05438481052921e-5*x_98 + 0.000529837942805724*x_99 - 2.59052784133505e-7*std::pow(7.56008005142212 - 7.57863998413086*x_29, 2) - 6.87132641859287e-7*std::pow(-9.79199981689453*x_13 - 9.96739959716797, 2) + 2.33543026737442e-7*std::pow(-9.3638391494751*x_18 - 5.88736009597778, 2) + 1.58086602337407e-9*std::pow(-9.32719993591309*x_28 - 3.25887989997864, 2) + 1.68099275065143e-7*std::pow(-9.69608020782471*x_29 - 5.72824001312256, 2) - 5.08312442607574e-8*std::pow(-6.40000009536743*x_3 - 0.823999881744385, 2) + 0.000663919053680554*std::sin(0.383359849452972*x_10 - 1.38967990875244) + 0.0020762464239533*std::sin(0.285519927740097*x_100 + 1.75823998451233) - 0.00148852200891656*std::sin(0.253679990768433*x_107 - 1.22095990180969) - 0.0023222647911932*std::sin(0.245599970221519*x_109 - 7.6048002243042) + 0.000799067751712417*std::sin(0.25655996799469*x_109 + 4.97463941574097) - 0.00067544863734894*std::sin(0.408079862594604*x_11 - 1.58663988113403) + 0.000397624374070872*std::sin(0.23471999168396*x_110 - 4.410560131073) - 0.00274704351646204*std::sin(0.280719965696335*x_110 + 7.9597601890564) - 0.000381114037385474*std::sin(0.283919930458069*x_110 + 4.74656009674072) - 0.00243982122251388*std::sin(0.239999979734421*x_111 + 4.98303985595703) - 0.00231127959736253*std::sin(0.267759948968887*x_112 + 4.9826397895813) - 0.000112447953977631*std::sin(0.344319850206375*x_112 + 1.63351988792419) + 0.001625443053405*std::sin(0.324319839477539*x_113 + 1.80663990974426) + 4.93398042140273e-5*std::sin(0.258559972047806*x_114 - 1.42975986003876) + 0.000403090003075628*std::sin(0.269039958715439*x_116 + 8.17503929138184) + 0.000548768418478093*std::sin(0.31703993678093*x_116 + 7.74711990356445) - 0.00362003319250658*std::sin(0.262799948453903*x_118 + 8.14888000488281) - 0.000265275011503373*std::sin(0.270159959793091*x_119 - 7.64079999923706) + 0.00456400638503424*std::sin(0.297039926052094*x_119 + 1.72535991668701) - 0.000206330277624627*std::sin(0.360639840364456*x_12 + 1.83463990688324) + 0.00160760310703714*std::sin(0.308079928159714*x_120 + 4.95815992355347) - 0.000781767823538011*std::sin(0.285999953746796*x_14 + 1.7739999294281) - 0.00146186787675887*std::sin(0.329199850559235*x_14 - 1.32287991046906) - 0.00289765489220526*std::sin(0.283679932355881*x_15 - 4.61175966262817) + 4.88620533735764e-5*std::sin(0.315439850091934*x_15 - 8.15695953369141) + 0.000146841076232137*std::sin(0.341599822044373*x_15 + 5.05247974395752) - 0.00029209997727885*std::sin(0.327279835939407*x_16 + 1.80663990974426) - 0.000344441706601524*std::sin(0.383679836988449*x_16 - 7.60168027877808) - 0.000843546898716229*std::sin(0.395519822835922*x_16 + 4.79496002197266) - 0.00135504589746456*std::sin(0.151760026812553*x_18 + 1.7475198507309) + 0.00157925310235063*std::sin(0.186320006847382*x_19 + 4.78311967849731) + 0.000579301947371802*std::sin(0.245839968323708*x_19 + 1.5927197933197) + 0.00128151038845044*std::sin(0.356159836053848*x_2 + 8.18231964111328) + 0.000553338322964204*std::sin(0.287679940462112*x_20 - 4.59008026123047) - 0.000775293710720828*std::sin(0.302239924669266*x_20 - 4.4015998840332) - 3.99378170555323e-5*std::sin(0.344079852104187*x_20 + 1.80431985855103) + 0.000367312265978445*std::sin(0.346959829330444*x_20 - 1.35039985179901) - 0.00180106691560844*std::sin(0.42087984085083*x_20 + 7.9967999458313) - 0.000646663296869462*std::sin(0.381999850273132*x_22 - 4.39847993850708) + 0.000283798659040384*std::sin(0.479119867086411*x_23 + 1.40255987644196) - 0.000276342386249168*std::sin(0.276079952716827*x_24 + 4.81767988204956) + 0.000201728469071023*std::sin(0.348319828510284*x_24 - 7.5699200630188) - 5.65822933802826e-5*std::sin(0.370879858732224*x_24 + 8.21424007415771) - 0.000682982811618304*std::sin(0.392479836940765*x_25 + 1.80199980735779) - 0.000267808251202634*std::sin(0.443039864301682*x_25 - 1.40151989459991) + 0.000595201230815662*std::sin(0.30175992846489*x_26 - 1.37311983108521) - 0.0105422994136167*std::sin(0.105680070817471*x_27 - 1.46623992919922) + 0.000711743188718832*std::sin(0.395599842071533*x_27 + 8.00263977050781) - 0.000559699083793778*std::sin(0.33519983291626*x_28 - 4.36367988586426) + 0.000575931762355359*std::sin(0.22087998688221*x_29 + 1.8096798658371) + 0.00178399088597792*std::sin(0.316319912672043*x_3 + 1.85055994987488) - 1.60592468522395e-6*std::sin(0.394639849662781*x_3 + 8.19960021972656) + 0.000531859725996888*std::sin(0.320719838142395*x_32 + 8.20911979675293) - 6.72484232552671e-5*std::sin(0.271839946508408*x_33 + 8.16720008850098) - 0.00221967037409396*std::sin(0.2743199467659*x_33 + 4.98183965682983) + 0.00115862730370672*std::sin(0.282239943742752*x_33 + 4.96551990509033) + 0.00151953980532462*std::sin(0.267839968204498*x_36 - 7.61712026596069) + 0.000946935047605572*std::sin(0.291279941797256*x_36 - 7.6300802230835) - 0.00119099362282303*std::sin(0.222559988498688*x_37 - 1.37927985191345) + 0.000477800123149413*std::sin(0.249999970197678*x_38 - 7.82919979095459) + 0.00166919301913222*std::sin(0.371439844369888*x_4 + 8.19215965270996) - 3.61972192677027e-5*std::sin(0.243199974298477*x_40 + 1.5868798494339) - 0.00256080249015613*std::sin(0.246719971299171*x_41 - 1.21727979183197) + 0.00499291409986078*std::sin(0.197679996490479*x_43 - 1.37815976142883) + 0.000259070505230175*std::sin(0.242079973220825*x_43 + 1.76151990890503) + 0.00116341941333721*std::sin(0.245839968323708*x_44 + 1.78511989116669) + 0.00194634889490217*std::sin(0.168080016970634*x_45 + 7.99632024765015) - 0.000651012936115244*std::sin(0.207440003752708*x_47 - 7.60143995285034) + 0.00280254889924045*std::sin(0.283519923686981*x_48 - 4.45199966430664) - 0.000225456061788202*std::sin(0.431199848651886*x_5 - 7.61520004272461) - 0.00035791077793556*std::sin(0.274159938097*x_51 - 7.84543991088867) + 0.00274709217844519*std::sin(0.241199970245361*x_53 - 4.41567993164063) + 0.000308641237353477*std::sin(0.270639955997467*x_53 - 4.42847967147827) - 0.00108001994555278*std::sin(0.229999989271164*x_55 - 4.41167974472046) + 0.000944640064420204*std::sin(0.244719967246056*x_57 + 1.76287984848022) - 0.000121684019721346*std::sin(0.319679915904999*x_59 - 4.87175989151001) + 1.25846975687146e-5*std::sin(0.583919823169708*x_6 - 7.98712015151978) + 0.000404347872220735*std::sin(0.356159836053848*x_60 + 1.85079991817474) - 0.000543435485749451*std::sin(0.417679876089096*x_60 + 7.98752021789551) - 0.000694062431597941*std::sin(0.436959862709045*x_60 - 4.45959997177124) + 0.000659423007195316*std::sin(0.212479993700981*x_7 + 4.81024026870728) - 0.00218840459380811*std::sin(0.352559864521027*x_7 - 7.59416007995605) + 0.000421708963513681*std::sin(0.369039833545685*x_7 + 5.00751972198486) - 0.00131132788491481*std::sin(0.369439840316772*x_8 - 1.3796797990799) + 0.00107366962045455*std::sin(0.288959950208664*x_9 - 1.6341598033905) + 0.000371589187188252*std::sin(0.380959838628769*x_9 + 1.82615983486176) + 0.000517290039561361*std::sin(0.466959863901138*x_91 - 4.82599973678589) - 0.000397800325846482*std::sin(0.317919850349426*x_92 - 4.58975982666016) - 0.000593991832054879*std::sin(0.319039851427078*x_92 - 7.57272005081177) - 0.000853237132353179*std::sin(0.321999847888947*x_92 + 8.00944042205811) - 0.000467741490234579*std::sin(0.294959932565689*x_95 + 7.98992013931274) - 0.000653946390859112*std::sin(0.314799934625626*x_95 + 1.76271986961365) + 0.00102145946903957*std::sin(0.283279925584793*x_97 - 4.41336011886597) + 0.0027240058202802*std::sin(0.25927996635437*x_98 + 1.9579998254776) + 0.000303695843038326*std::sin(0.263199955224991*x_99 - 4.42944002151489) + 0.0287712028217339);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000187821123842912*x_1 + 3.16992044845612e-5*x_10 - 0.000317433354459913*x_100 + 0.000115618043366195*x_101 + 0.000227686947221332*x_102 - 0.000541241140049865*x_103 - 0.000169343399215922*x_104 - 0.000596129504960103*x_105 - 0.000302807529930816*x_106 + 3.23824724728674e-5*x_107 - 0.000420754547245702*x_108 + 0.000113954290202032*x_109 + 0.000259271594071464*x_11 - 3.90776516342271e-5*x_110 - 0.000264030701345583*x_111 - 0.000128255201163935*x_112 - 0.000333237786920755*x_113 - 4.98081057712153e-5*x_114 + 0.000843916811654116*x_115 + 4.56122819320611e-5*x_116 + 0.0004524729578727*x_117 + 0.000162385739463287*x_118 + 0.000163855482692046*x_119 - 0.00062550475797799*x_12 - 9.73554905326273e-5*x_120 + 0.000151122943113554*x_13 + 0.000266909991258699*x_14 + 1.33152422018216e-5*x_15 - 4.61213184797734e-5*x_16 - 0.000223998538904929*x_17 + 5.85730480531124e-5*x_18 - 0.000632105057750083*x_19 - 9.59786954516338e-5*x_2 + 7.59001799005599e-5*x_20 - 0.000263462151906426*x_21 - 0.000426929687088442*x_22 + 0.000525132866796025*x_23 + 0.00010953252492437*x_24 - 0.000329143972327039*x_25 - 0.000165754894859004*x_26 - 0.00056891054092077*x_27 + 3.3742696372101e-6*x_28 - 5.8518572032658e-6*x_29 - 6.59776342370419e-5*x_3 - 0.000599515887880038*x_30 - 1.06995570379118e-5*x_31 - 2.51987809883574e-5*x_32 + 0.00014218524688128*x_33 - 0.000707099470791224*x_34 + 0.000264868535737239*x_35 - 0.000252279650294355*x_36 - 0.000632812663097788*x_37 - 0.000549284292627136*x_38 - 4.67896267387726e-5*x_39 - 0.000101440118913999*x_4 + 0.000729204400306147*x_40 + 0.00154989168132728*x_41 - 0.000240755512221413*x_42 - 0.00136060639741779*x_43 - 0.000774029904746453*x_44 - 0.000151890914267204*x_45 - 0.00032742063060304*x_46 - 2.08416705274623e-5*x_47 - 0.000261966776834049*x_48 - 0.00179176572981769*x_49 - 0.000130167347890999*x_5 + 0.00179844785832666*x_50 + 0.00119092226042122*x_51 + 0.000125205937725221*x_52 + 0.000797337537928588*x_53 + 0.00199154111571712*x_54 - 0.000403094411931782*x_55 - 0.000393575531526202*x_56 + 0.00106761286322103*x_57 - 6.60345719007986e-5*x_58 + 0.00160057287085446*x_59 + 2.09028829623825e-5*x_6 - 0.000370818766437772*x_60 - 5.81254473532253e-6*x_61 - 2.03469192478801e-5*x_62 - 4.71599987221253e-5*x_63 - 2.49976725738112e-5*x_64 + 9.24369494578427e-6*x_65 - 0.00010581229078166*x_66 - 9.99607860977072e-6*x_67 - 1.85170390768362e-5*x_68 + 2.72428242491431e-5*x_69 - 0.000409225671050733*x_7 - 1.73950777394532e-5*x_70 + 4.44056705738556e-5*x_71 + 5.51345904693677e-5*x_72 - 1.41549537133488e-6*x_73 + 1.20970452450893e-5*x_74 - 3.44034639894227e-5*x_75 + 7.16806778341624e-6*x_76 - 6.46227540453138e-6*x_77 + 2.47416801384837e-5*x_78 + 4.81591071460001e-5*x_79 - 0.000113062785304564*x_8 + 0.00016829445890105*x_80 - 5.13127078396693e-5*x_81 - 1.72688258877635e-5*x_82 - 5.30375489403546e-6*x_83 + 4.27146360073088e-5*x_84 + 1.63705014037108e-5*x_85 - 9.9023506388452e-5*x_86 + 6.29225023318563e-5*x_87 - 3.97385429363899e-5*x_88 - 8.90934877231424e-6*x_89 + 0.000411443065723356*x_9 + 2.5121132500723e-5*x_90 - 2.57096211168088e-6*x_91 - 0.000256060335011229*x_92 - 0.000626206237238641*x_93 - 2.5632182635153e-5*x_94 + 1.57910951394129e-6*x_95 + 6.02927030631809e-5*x_96 - 9.05055673799886e-5*x_97 - 5.91023291811492e-5*x_98 - 9.42599401861251e-5*x_99 + 6.41467199705846e-8*std::pow(7.56008005142212 - 7.57863998413086*x_29, 2) - 6.04846591551154e-7*std::pow(-9.79199981689453*x_13 - 9.96739959716797, 2) + 8.50428057671087e-9*std::pow(-9.3638391494751*x_18 - 5.88736009597778, 2) - 3.15361849544722e-9*std::pow(-9.32719993591309*x_28 - 3.25887989997864, 2) - 2.88340819916369e-7*std::pow(-9.69608020782471*x_29 - 5.72824001312256, 2) - 1.85725731139522e-7*std::pow(-6.40000009536743*x_3 - 0.823999881744385, 2) + 2.41760757818362e-5*std::sin(0.383359849452972*x_10 - 1.38967990875244) + 0.00182761012393528*std::sin(0.285519927740097*x_100 + 1.75823998451233) + 0.000368588219560745*std::sin(0.253679990768433*x_107 - 1.22095990180969) - 0.00204416710554133*std::sin(0.245599970221519*x_109 - 7.6048002243042) + 2.90974063978527e-5*std::sin(0.25655996799469*x_109 + 4.97463941574097) + 0.000167254772958572*std::sin(0.408079862594604*x_11 - 1.58663988113403) + 0.000944728205030214*std::sin(0.23471999168396*x_110 - 4.410560131073) + 0.00471200592373559*std::sin(0.280719965696335*x_110 + 7.9597601890564) - 1.38779596673332e-5*std::sin(0.283919930458069*x_110 + 4.74656009674072) - 0.0021476458263409*std::sin(0.239999979734421*x_111 + 4.98303985595703) + 0.000572319674546839*std::sin(0.267759948968887*x_112 + 4.9826397895813) - 0.000267168616030748*std::sin(0.344319850206375*x_112 + 1.63351988792419) - 0.000402492645364381*std::sin(0.324319839477539*x_113 + 1.80663990974426) - 0.000232639987689981*std::sin(0.258559972047806*x_114 - 1.42975986003876) + 1.46781966976743e-5*std::sin(0.269039958715439*x_116 + 8.17503929138184) + 0.000483051869824231*std::sin(0.31703993678093*x_116 + 7.74711990356445) + 0.000550768826481133*std::sin(0.262799948453903*x_118 + 8.14888000488281) + 0.00125078679159126*std::sin(0.270159959793091*x_119 - 7.64079999923706) - 0.00782864377406945*std::sin(0.297039926052094*x_119 + 1.72535991668701) + 0.000353918488945309*std::sin(0.360639840364456*x_12 + 1.83463990688324) + 0.00141508815128824*std::sin(0.308079928159714*x_120 + 4.95815992355347) - 2.84674434946251e-5*std::sin(0.285999953746796*x_14 + 1.7739999294281) + 0.000361988116198423*std::sin(0.329199850559235*x_14 - 1.32287991046906) + 0.000440862804194937*std::sin(0.283679932355881*x_15 - 4.61175966262817) + 1.77927218486501e-6*std::sin(0.315439850091934*x_15 - 8.15695953369141) + 0.000348884312481221*std::sin(0.341599822044373*x_15 + 5.05247974395752) - 1.06365846068396e-5*std::sin(0.327279835939407*x_16 + 1.80663990974426) + 0.00162406226899687*std::sin(0.383679836988449*x_16 - 7.60168027877808) + 0.000208879309577768*std::sin(0.395519822835922*x_16 + 4.79496002197266) - 0.00495102753619799*std::sin(0.151760026812553*x_18 + 1.7475198507309) - 0.000391055077280911*std::sin(0.186320006847382*x_19 + 4.78311967849731) - 0.000114735088914917*std::sin(0.245839968323708*x_19 + 1.5927197933197) - 0.000317327946512093*std::sin(0.356159836053848*x_2 + 8.18231964111328) - 0.000109592798666327*std::sin(0.287679940462112*x_20 - 4.59008026123047) + 0.000191978436838318*std::sin(0.302239924669266*x_20 - 4.4015998840332) + 7.96706594182472e-5*std::sin(0.344079852104187*x_20 + 1.80431985855103) + 0.00134207494125868*std::sin(0.346959829330444*x_20 - 1.35039985179901) + 0.000274022766856674*std::sin(0.42087984085083*x_20 + 7.9967999458313) - 2.35477213431058e-5*std::sin(0.381999850273132*x_22 - 4.39847993850708) - 7.0274300160036e-5*std::sin(0.479119867086411*x_23 + 1.40255987644196) - 0.000656570531283402*std::sin(0.276079952716827*x_24 + 4.81767988204956) - 0.000346025003081492*std::sin(0.348319828510284*x_24 - 7.5699200630188) + 0.000112874186857426*std::sin(0.370879858732224*x_24 + 8.21424007415771) + 0.000169120387214304*std::sin(0.392479836940765*x_25 + 1.80199980735779) + 0.00126273116108846*std::sin(0.443039864301682*x_25 - 1.40151989459991) - 0.000147383888603965*std::sin(0.30175992846489*x_26 - 1.37311983108521) - 0.00927982965586373*std::sin(0.105680070817471*x_27 - 1.46623992919922) - 0.000176242039514961*std::sin(0.395599842071533*x_27 + 8.00263977050781) - 0.00204501233576869*std::sin(0.33519983291626*x_28 - 4.36367988586426) + 0.00136837431392696*std::sin(0.22087998688221*x_29 + 1.8096798658371) + 0.00157035300174699*std::sin(0.316319912672043*x_3 + 1.85055994987488) + 3.20360720942583e-6*std::sin(0.394639849662781*x_3 + 8.19960021972656) + 0.00194329369487219*std::sin(0.320719838142395*x_32 + 8.20911979675293) + 0.000134151704339142*std::sin(0.271839946508408*x_33 + 8.16720008850098) - 0.00195385865603041*std::sin(0.2743199467659*x_33 + 4.98183965682983) + 4.21904768993054e-5*std::sin(0.282239943742752*x_33 + 4.96551990509033) + 0.00133757067556851*std::sin(0.267839968204498*x_36 - 7.61712026596069) + 3.44818744762281e-5*std::sin(0.291279941797256*x_36 - 7.6300802230835) + 0.000235885206034009*std::sin(0.222559988498688*x_37 - 1.37927985191345) - 0.000118312994797929*std::sin(0.249999970197678*x_38 - 7.82919979095459) - 0.000413326023625934*std::sin(0.371439844369888*x_4 + 8.19215965270996) + 0.000170671950953057*std::sin(0.243199974298477*x_40 + 1.5868798494339) + 0.000634106600264774*std::sin(0.246719971299171*x_41 - 1.21727979183197) - 0.000759645366013151*std::sin(0.197679996490479*x_43 - 1.37815976142883) + 0.000615533728168157*std::sin(0.242079973220825*x_43 + 1.76151990890503) - 0.000288086227543583*std::sin(0.245839968323708*x_44 + 1.78511989116669) + 0.00711151333821236*std::sin(0.168080016970634*x_45 + 7.99632024765015) - 0.00154676202640933*std::sin(0.207440003752708*x_47 - 7.60143995285034) + 0.00246693585211479*std::sin(0.283519923686981*x_48 - 4.45199966430664) - 0.000535668119098718*std::sin(0.431199848651886*x_5 - 7.61520004272461) - 0.00130772405597232*std::sin(0.274159938097*x_51 - 7.84543991088867) + 0.00241812022830618*std::sin(0.241199970245361*x_53 - 4.41567993164063) + 0.000733310383309861*std::sin(0.270639955997467*x_53 - 4.42847967147827) - 3.93280534800585e-5*std::sin(0.229999989271164*x_55 - 4.41167974472046) - 0.000187093038916169*std::sin(0.244719967246056*x_57 + 1.76287984848022) - 4.43102523705726e-6*std::sin(0.319679915904999*x_59 - 4.87175989151001) - 2.51048061160824e-5*std::sin(0.583919823169708*x_6 - 7.98712015151978) + 0.000960702774882695*std::sin(0.356159836053848*x_60 + 1.85079991817474) - 1.97887640265543e-5*std::sin(0.417679876089096*x_60 + 7.98752021789551) + 0.00327254390476723*std::sin(0.436959862709045*x_60 - 4.45959997177124) + 0.00240938072484138*std::sin(0.212479993700981*x_7 + 4.81024026870728) - 0.00192633704013553*std::sin(0.352559864521027*x_7 - 7.59416007995605) - 0.00198838178714714*std::sin(0.369039833545685*x_7 + 5.00751972198486) - 0.00115429271334068*std::sin(0.369439840316772*x_8 - 1.3796797990799) - 0.000163353131156441*std::sin(0.288959950208664*x_9 - 1.6341598033905) - 0.00175206418651796*std::sin(0.380959838628769*x_9 + 1.82615983486176) - 7.87029325115977e-5*std::sin(0.466959863901138*x_91 - 4.82599973678589) + 0.00187565119850406*std::sin(0.317919850349426*x_92 - 4.58975982666016) + 0.000117644530585033*std::sin(0.319039851427078*x_92 - 7.57272005081177) + 0.000211278807833068*std::sin(0.321999847888947*x_92 + 8.00944042205811) - 1.70324283533232e-5*std::sin(0.294959932565689*x_95 + 7.98992013931274) + 0.00308339448732793*std::sin(0.314799934625626*x_95 + 1.76271986961365) - 0.000252934068016097*std::sin(0.283279925584793*x_97 - 4.41336011886597) - 0.000674519052695087*std::sin(0.25927996635437*x_98 + 1.9579998254776) + 0.000721560466053313*std::sin(0.263199955224991*x_99 - 4.42944002151489) + 0.0379622594753781);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
