
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (515.688571460547*x_1 - 1352.55952607978*x_10 - 597.095785059763*x_100 - 24625.6663677371*x_101 + 263.200742409386*x_102 - 5247.64195630592*x_103 + 20204.5924513985*x_104 + 9025.4861472699*x_105 - 4015.22969421228*x_106 - 4052.92623008378*x_107 - 3210.12450652433*x_108 + 1654.34806869281*x_109 - 10009.785858003*x_11 + 1087.34152717178*x_110 + 1172.88970806492*x_111 + 703.046597229924*x_112 - 122595.221491525*x_113 + 1841.12825975711*x_114 + 5388.30327492256*x_115 + 5760.92320866449*x_116 - 3073.65092679592*x_117 - 108.343502289263*x_118 - 11341.5538505263*x_119 + 506.566594837387*x_12 - 332.483473585224*x_120 - 42.9113920978105*x_13 + 7168.49286548071*x_14 + 9076.95616625577*x_15 - 2316.40725770207*x_16 - 564.900879131947*x_17 - 1304.59670058634*x_18 + 3282.79699889852*x_19 + 285.241336421065*x_2 - 3682.26260122377*x_20 + 1631.16348811855*x_21 + 2123.44664463843*x_22 + 8978.42244560253*x_23 - 3281.54672931109*x_24 + 2014.55115617441*x_25 - 626.854194717808*x_26 - 3325.24895165105*x_27 + 2216.51708625728*x_28 - 198.654830097728*x_29 + 7600.71264036417*x_3 + 3679.9670545128*x_30 + 53382.0415616505*x_31 - 38.1165719844943*x_32 - 15147.7650629796*x_33 - 1856.30836834744*x_34 + 704.938680137938*x_35 + 2012.28585322462*x_36 + 14735.5333523265*x_37 - 1507.73562419517*x_38 + 30665.1459900212*x_39 + 21216.1064561123*x_4 - 1196.22833125318*x_40 - 1333.10006789307*x_41 + 14277.5233785453*x_42 + 889.01640973289*x_43 + 13812.9357433427*x_44 + 3214.16652854441*x_45 + 4314.92559904932*x_46 - 6119.6625121947*x_47 + 52214.3312588536*x_48 - 37657.8773304792*x_49 + 1631.57615063538*x_5 - 3694.46127148853*x_51 - 126.97082302468*x_52 - 6803.82617867146*x_53 - 2293.12730067686*x_54 + 4689.32383539736*x_55 - 6336.09867710616*x_56 + 2757.90552946011*x_57 + 2089.58631819951*x_58 - 3309.82137235251*x_59 + 1449.73752918858*x_6 + 3042.86338596436*x_60 + 2294.86009960897*x_61 - 52201.6316785311*x_62 + 8112.14514004553*x_63 - 3086.70186617306*x_64 - 3852.37678066532*x_65 - 434.871927589532*x_66 - 135.80105512847*x_67 + 2983.79829802474*x_68 - 9191.77193926586*x_69 - 14308.9344133401*x_7 - 5024.07470495648*x_70 - 62.8537285944641*x_71 - 5944.88249472645*x_72 - 89.7920122369003*x_73 - 4700.98992575507*x_74 + 6699.6814591919*x_75 - 7954.91137123686*x_76 - 3839.59452608896*x_77 + 40.32575464358*x_78 - 33.9701362655073*x_79 + 13004.7072364282*x_8 + 3967.9654039624*x_80 + 6631.25709597878*x_81 + 16346.2826468902*x_82 - 810.695885396238*x_83 - 11160.5405404059*x_84 - 2199.52150585906*x_85 - 6793.74807896683*x_86 + 1783.82705615386*x_87 + 4738.64973215196*x_88 - 2771.59595376307*x_89 + 3246652.94233636*x_9 - 31271.5949107452*x_90 - 15595.3165832915*x_91 - 7202.30544368748*x_92 + 215421.976116062*x_93 - 1925.17711529311*x_94 - 6376.69487905186*x_95 - 10736.595184667*x_96 + 17019.8103321842*x_97 + 682.05920878356*x_98 - 4169.14851604734*x_99 - 0.718091086165124*std::pow(-9.98124027252197*x_110 - 9.80000019073486, 2) - 19.3841659892534*std::pow(-4.5798397064209*x_22 - 7.37175989151001, 2) - 25.8372922666796*std::pow(-7.55879974365234*x_24 - 8.38191986083984, 2) + 0.110720528427148*std::pow(-6.16311979293823*x_27 - 8.35552024841309, 2) - 30.1888521275491*std::pow(-7.410719871521*x_67 - 9.21880054473877, 2) - 0.000572867452540205*std::pow(-2.03479981422424*x_7 - 3.25959992408752, 2) - 0.000396708234622787*std::pow(-7.58656024932861*x_71 - 9.77288055419922, 2) + 95.2355391901173*std::pow(-5.86728000640869*x_73 - 7.48176002502441, 2) - 2.35536164285163*std::pow(-5.56799983978271*x_88 - 7.39811992645264, 2) - 799.51436386718*std::exp(0.941519796848297*x_1) - 0.014560227894335*std::exp(1.05287981033325*x_1) - 0.379208476566334*std::exp(1.08055984973907*x_1) - 16.3960445848251*std::exp(1.14351987838745*x_1) - 1.03292137452245*std::exp(1.17575979232788*x_1) - 0.0014519179438294*std::exp(1.91935980319977*x_10) - 16.5255457966364*std::exp(0.718959867954254*x_108) - 174.916979477418*std::exp(2.84631991386414*x_17) - 0.00244620691013459*std::exp(2.97367978096008*x_17) + 0.0140191187675469*std::exp(3.23551988601685*x_17) - 0.000131671558404626*std::exp(3.33439970016479*x_17) + 0.299085506112986*std::exp(3.69400000572205*x_17) + 26.4168768920689*std::exp(0.924879848957062*x_29) - 4838.93715960187*std::exp(1.05567979812622*x_29) - 0.329749250715742*std::exp(1.32319986820221*x_29) + 0.432181147089187*std::exp(1.51199984550476*x_29) - 0.568749118094088*std::exp(1.89591979980469*x_29) + 33.7874394215023*std::exp(2.74616003036499*x_29) + 4.14669920511741e-5*std::exp(2.97727990150452*x_29) + 15.0852256666242*std::exp(0.801359891891479*x_38) + 4328.74024159333*std::exp(0.83847987651825*x_38) + 0.350321870402543*std::exp(0.859919905662537*x_38) - 184.297498014909*std::exp(0.908879816532135*x_38) + 0.0208262422618763*std::exp(2.08367991447449*x_38) + 0.126339048852539*std::exp(2.11967992782593*x_38) - 180.520981568846*std::exp(1.6879198551178*x_50) + 0.000468868809038322*std::exp(1.74383985996246*x_50) + 0.0827304966480756*std::exp(1.81527996063232*x_50) - 10.6655492937952*std::exp(1.86807990074158*x_50) - 5289.91114775756*std::exp(1.90071976184845*x_50) + 3.38702191002228*std::exp(1.93159985542297*x_50) - 2700.16493483865*std::exp(1.93415975570679*x_50) + 13.6631960046684*std::exp(1.94911980628967*x_50) + 0.0357614906043173*std::exp(1.96527981758118*x_50) + 0.453944959336871*std::exp(1.98295974731445*x_50) - 86.3035987524036*std::exp(0.994239807128906*x_6) + 202.277145719415*std::exp(1.77975988388062*x_71) + 2.25416673894688*std::exp(1.78367984294891*x_71) + 0.000786776519430745*std::exp(1.81471991539001*x_71) - 641.266655804047*std::exp(1.83799982070923*x_71) - 4257.05377745461*std::exp(0.713119864463806*x_73) + 13.9409519313029*std::exp(0.727599859237671*x_78) - 0.437640850820634*std::exp(1.04399979114532*x_78) + 16.4680991787974*std::exp(1.13199985027313*x_78) - 29.618306484358*std::exp(1.46615982055664*x_78) - 2269.13643253102*std::exp(1.48823988437653*x_78) - 1.63090238969017*std::exp(1.54943978786469*x_78) - 26.8169692805672*std::exp(0.753439843654633*x_88) + 105.256061844825*std::sin(0.459999859333038*x_1 - 4.27928018569946) + 2378.36121029426*std::sin(0.380079835653305*x_100 - 4.21152019500732) + 187.963132955411*std::sin(0.457999855279922*x_100 + 5.24911975860596) + 25087.5567697594*std::sin(0.479119867086411*x_100 + 8.45336055755615) - 21.0041703033694*std::sin(0.761759877204895*x_100 + 5.39792013168335) - 75206.6681922292*std::sin(0.372159838676453*x_102 - 4.21256017684937) + 3508.36766227964*std::sin(0.382799834012985*x_102 + 1.98967981338501) - 428.166348277961*std::sin(0.396079838275909*x_105 + 5.19479990005493) + 42.2662594228714*std::sin(0.527279853820801*x_105 - 4.23031997680664) + 5.0975173243848*std::sin(0.530399858951569*x_108 - 7.23000001907349) - 16756.0379048927*std::sin(0.502559840679169*x_110 - 7.3328800201416) + 0.0415996098765748*std::sin(0.498479843139648*x_111 + 2.05335974693298) + 2.93334708818847*std::sin(0.27567994594574*x_112 + 1.84967994689941) + 471.799317407972*std::sin(0.350959837436676*x_114 - 1.23111987113953) - 1737.11493762769*std::sin(0.430639863014221*x_118 - 7.37128019332886) - 0.135081987460825*std::sin(0.330879837274551*x_120 - 1.24343991279602) - 11071.7740365887*std::sin(0.34911984205246*x_120 + 5.16007995605469) - 141.149741074713*std::sin(0.393999844789505*x_120 - 7.39271974563599) + 117952.881928684*std::sin(0.397199839353561*x_120 + 5.19304037094116) + 3975.03766154564*std::sin(0.287039935588837*x_14 + 1.89999985694885) + 2.02155363196888*std::sin(0.421199858188629*x_16 + 2.00095963478088) - 626.722660170657*std::sin(0.754159867763519*x_2 - 0.799599885940552) + 0.0906219951159281*std::sin(0.439279854297638*x_21 + 8.22023963928223) + 30158.5413096363*std::sin(0.442079842090607*x_21 + 8.21959972381592) - 69.272815424936*std::sin(0.390879839658737*x_24 + 8.39072036743164) - 832.112740107966*std::sin(0.320799857378006*x_28 + 5.11976003646851) + 124.761927633604*std::sin(0.331279844045639*x_28 + 5.14024019241333) + 31480.7811070335*std::sin(0.336159855127335*x_28 - 4.27024030685425) + 0.0775436245590341*std::sin(0.337359845638275*x_28 + 5.132080078125) + 3.97252637576932*std::sin(0.347679853439331*x_28 + 5.14071989059448) + 4168.43675281716*std::sin(0.322559833526611*x_3 - 4.25808000564575) + 0.439370092348159*std::sin(0.341759830713272*x_3 + 8.33720016479492) + 21822.0342004542*std::sin(0.346719831228256*x_3 - 4.24839973449707) - 0.0349610483767662*std::sin(0.277759939432144*x_33 - 1.18871986865997) + 65036.1287943914*std::sin(0.345999836921692*x_34 + 2.00871968269348) + 5141.91223641282*std::sin(0.348639845848083*x_34 + 2.0033597946167) + 0.0721125164976185*std::sin(0.35591983795166*x_34 - 7.40551996231079) + 63512.5583060166*std::sin(0.311519920825958*x_35 - 4.32943964004517) + 0.062751814574717*std::sin(0.261519968509674*x_36 + 1.84575986862183) - 4357.13731579341*std::sin(0.351119846105576*x_36 - 7.42143964767456) + 8.94712744884251*std::sin(0.366719841957092*x_36 + 1.95679974555969) - 19820.9044465471*std::sin(0.370879858732224*x_36 - 7.42600011825562) - 119.92567891556*std::sin(0.37271985411644*x_36 - 7.41264009475708) - 1.05709664691228*std::sin(0.384159833192825*x_36 - 1.19167983531952) - 286.42160737964*std::sin(0.36847984790802*x_41 - 7.41703987121582) - 1953.97118505023*std::sin(0.39727982878685*x_46 - 7.39071989059448) + 0.26954361369156*std::sin(0.357199847698212*x_47 + 5.14815998077393) + 6851.33528505612*std::sin(0.331759840250015*x_51 - 4.25544023513794) + 82122.7061071703*std::sin(0.246239975094795*x_52 - 7.53248023986816) + 3180.36838032337*std::sin(0.404719859361649*x_52 + 5.20879983901978) + 0.649943518409025*std::sin(0.434639871120453*x_52 - 4.17999982833862) + 10.9069019322573*std::sin(0.31063985824585*x_55 + 5.11191987991333) + 1.22897516843082*std::sin(0.332079827785492*x_55 + 5.14311981201172) + 36.1420748613901*std::sin(0.445359855890274*x_58 - 7.3699197769165) - 5.92325061062232*std::sin(0.438239872455597*x_59 - 4.15751981735229) - 6.08913504239221*std::sin(0.269919961690903*x_64 - 4.29559993743896) + 379.894883361813*std::sin(0.324319839477539*x_65 + 5.12215995788574) - 0.36813698966922*std::sin(0.4651198387146*x_67 + 8.45736026763916) - 821.204591853271*std::sin(0.249279975891113*x_68 - 4.33143997192383) + 4.94453742431207*std::sin(0.304399847984314*x_70 - 1.28231990337372) - 4603.64822012972*std::sin(0.292719930410385*x_75 - 7.47431993484497) + 521.388480241038*std::sin(0.27839994430542*x_8 - 4.29239988327026) + 0.781631248554085*std::sin(0.349999845027924*x_92 + 2.00279974937439) + 184.814589769092*std::sin(0.359759837388992*x_92 + 2.00303983688354) - 622.934524077041*std::sin(0.365439832210541*x_92 + 2.000079870224) - 74303.159153328*std::sin(0.383919835090637*x_94 - 7.39567947387695) - 3363.34908270651*std::sin(0.392479836940765*x_94 - 7.40143966674805) + 143.486233668828*std::sin(0.306479930877686*x_95 - 4.30711984634399) - 2797.89019801442*std::sin(0.404239863157272*x_96 + 5.18688011169434) + 29.6904468494287*std::sin(0.488079845905304*x_96 + 5.24823999404907) - 6.41034117856697*std::sin(0.502879858016968*x_96 - 7.33160018920898) - 1269.90497376205*std::sin(0.44447985291481*x_98 - 7.3746395111084) + 5.51776857872985*std::sin(0.484719842672348*x_98 + 2.04863977432251) + 11.5395857048244*std::sin(0.62095981836319*x_98 - 7.40104007720947) + 32.4202175013385*std::sin(0.482239842414856*x_99 + 2.05831980705261) + 45805.5483844198*std::sin(0.53303986787796*x_99 + 8.38224029541016) - 3828029.81772064 - 0.00576260904912708*std::exp(-2.41559982299805*x_86) - 0.0179771359492749*std::exp(-2.41311979293823*x_86) - 3.31196906126572*std::exp(-4.34423971176147*x_111) - 0.00055286372636858*std::exp(-4.29680013656616*x_111));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-482.336630000181*x_1 + 768.954762298688*x_10 - 164.128001477673*x_100 + 88169.5863846946*x_101 - 172.41701152262*x_102 - 1125.22401936841*x_103 + 6062.63523802807*x_104 + 1496.64146345805*x_105 + 1351.38073128037*x_106 - 1492.17037332973*x_107 + 257.346293854196*x_108 + 6510.72101809367*x_109 - 3826.85313958743*x_11 + 366.209711969253*x_110 - 63.9807663584933*x_111 + 180.369438146653*x_112 - 23164.6070273787*x_113 + 164.633605713071*x_114 - 104.479683390546*x_115 + 3585.104592637*x_116 + 398.930869965703*x_117 + 723.428627675877*x_118 - 1013.40437671084*x_119 + 3518.71402772992*x_12 + 338.353248715113*x_120 - 378.194832608666*x_13 + 2107.53157808121*x_14 + 1498.54810036073*x_15 - 1.7353834254512*x_16 + 300.672049039547*x_17 - 632.322350553982*x_18 + 1062.03255446904*x_19 - 360.262973281787*x_2 + 351.0282469995*x_20 - 438.044589127027*x_21 + 817.637292304959*x_22 + 281.110916394807*x_23 - 823.949424856725*x_24 + 1085.02430362553*x_25 + 1199.27415816498*x_26 - 909.448493086375*x_27 + 651.706569347985*x_28 + 199.523839497315*x_29 + 2241.16061934351*x_3 - 361.788031256666*x_30 + 60604.3676437816*x_31 - 2348.01120058504*x_32 - 206.366817658424*x_33 - 771.7335247276*x_34 - 109.838057244896*x_35 + 634.885320896445*x_36 - 2883.65647703664*x_37 + 513.849746310917*x_38 - 21974.3287809026*x_39 + 5955.95384619082*x_4 + 3262.27425004928*x_40 + 3021.34569889275*x_41 - 12883.4292532141*x_42 + 2916.1839263697*x_43 + 6319.17379703295*x_44 + 3605.02744156325*x_45 + 2248.42728390002*x_46 - 311.320714330011*x_47 - 23422.9843541279*x_48 + 18988.99459096*x_49 + 638.248966901501*x_5 - 1105.95702970182*x_51 + 171.862071806525*x_52 + 900.417262804784*x_53 - 358.956260794912*x_54 + 1528.91309764839*x_55 + 3416.27036585919*x_56 + 2162.5358550924*x_57 - 1257.329723731*x_58 + 2109.76688033463*x_59 + 593.411839888827*x_6 + 5043.06627460866*x_60 + 1818.87969216313*x_61 - 16236.4704160192*x_62 + 2331.68459241966*x_63 + 3009.35882904588*x_64 - 946.559171850854*x_65 - 159.122463452641*x_66 - 57.3440296232161*x_67 + 505.619791249906*x_68 - 2934.39934450585*x_69 - 5076.6603162886*x_7 - 2162.51549479914*x_70 + 51.5329991261074*x_71 + 7282.69058155576*x_72 + 118.133619898917*x_73 + 616.017978934391*x_74 + 974.508058420636*x_75 - 2879.9965540898*x_76 + 109.78413436374*x_77 - 40.6531563113382*x_78 - 967.24356356236*x_79 + 62022.3481240465*x_8 + 3022.61640987261*x_80 + 1244.58184338339*x_81 + 3200.02913445144*x_82 + 2664.37511961453*x_83 - 3278.25356305688*x_84 - 932.663786697869*x_85 + 2750.22943044731*x_86 + 60.8485291383255*x_87 + 2202.34139026673*x_88 + 1025.62577467891*x_89 + 988596.236515825*x_9 - 10408.6029008518*x_90 - 4318.63060060251*x_91 + 269.013996043428*x_92 - 39482.1444472763*x_93 - 1312.20997117834*x_94 - 3571.45187840608*x_95 - 893.082051121646*x_96 + 4393.31636022758*x_97 + 789.008872606469*x_98 + 1838.51813413165*x_99 + 0.722840608068871*std::pow(-9.98124027252197*x_110 - 9.80000019073486, 2) + 7.05915544770517*std::pow(-4.5798397064209*x_22 - 7.37175989151001, 2) + 9.40919834051145*std::pow(-7.55879974365234*x_24 - 8.38191986083984, 2) + 0.314263140754777*std::pow(-6.16311979293823*x_27 - 8.35552024841309, 2) + 10.9939112198225*std::pow(-7.410719871521*x_67 - 9.21880054473877, 2) + 0.00148646874229807*std::pow(-2.03479981422424*x_7 - 3.25959992408752, 2) - 0.000228278874780463*std::pow(-7.58656024932861*x_71 - 9.77288055419922, 2) + 29.147111235741*std::pow(-5.86728000640869*x_73 - 7.48176002502441, 2) + 2.37094022602791*std::pow(-5.56799983978271*x_88 - 7.39811992645264, 2) - 244.693675243323*std::exp(0.941519796848297*x_1) - 0.00837843067065739*std::exp(1.05287981033325*x_1) - 0.232060770801647*std::exp(1.08055984973907*x_1) + 5.97096761944531*std::exp(1.14351987838745*x_1) + 0.84774789300049*std::exp(1.17575979232788*x_1) - 0.000835481004839974*std::exp(1.91935980319977*x_10) - 14.1634455534438*std::exp(0.718959867954254*x_108) - 53.5338456757242*std::exp(2.84631991386414*x_17) - 0.0014076273497491*std::exp(2.97367978096008*x_17) + 0.00857915291507911*std::exp(3.23551988601685*x_17) + 0.000341659584516917*std::exp(3.33439970016479*x_17) - 0.245467964830811*std::exp(3.69400000572205*x_17) - 21.6810807456266*std::exp(0.924879848957062*x_29) + 1762.20166656869*std::exp(1.05567979812622*x_29) - 0.201793657107174*std::exp(1.32319986820221*x_29) + 1.57109792786045*std::exp(1.51199984550476*x_29) - 1.61430663936329*std::exp(1.89591979980469*x_29) + 10.3407432095641*std::exp(2.74616003036499*x_29) - 0.000107597991905234*std::exp(2.97727990150452*x_29) - 12.3808729200033*std::exp(0.801359891891479*x_38) + 1324.82342626818*std::exp(0.83847987651825*x_38) + 1.27351683057116*std::exp(0.859919905662537*x_38) + 185.516458980296*std::exp(0.908879816532135*x_38) + 0.01274484651808*std::exp(2.08367991447449*x_38) + 0.108280613646118*std::exp(2.11967992782593*x_38) + 181.71496429968*std::exp(1.6879198551178*x_50) - 0.0012166144642771*std::exp(1.74383985996246*x_50) + 0.300748222660982*std::exp(1.81527996063232*x_50) - 30.2725164570396*std::exp(1.86807990074158*x_50) + 1926.43341566884*std::exp(1.90071976184845*x_50) + 2.90289355651332*std::exp(1.93159985542297*x_50) - 826.393260119814*std::exp(1.93415975570679*x_50) - 11.2137728101188*std::exp(1.94911980628967*x_50) + 0.0205783296719012*std::exp(1.96527981758118*x_50) + 0.277796578069924*std::exp(1.98295974731445*x_50) + 86.8744188621975*std::exp(0.994239807128906*x_6) - 73.6635156726934*std::exp(1.77975988388062*x_71) + 6.39810457220239*std::exp(1.78367984294891*x_71) - 0.002041517105086*std::exp(1.81471991539001*x_71) - 196.261508124393*std::exp(1.83799982070923*x_71) + 1550.2964832716*std::exp(0.713119864463806*x_73) + 39.5692415966505*std::exp(0.727599859237671*x_78) - 1.59094546002834*std::exp(1.04399979114532*x_78) - 13.5158364662588*std::exp(1.13199985027313*x_78) + 10.7861349147945*std::exp(1.46615982055664*x_78) - 694.47574477446*std::exp(1.48823988437653*x_78) - 1.3977872491243*std::exp(1.54943978786469*x_78) - 76.1158306535774*std::exp(0.753439843654633*x_88) + 298.753095281679*std::sin(0.459999859333038*x_1 - 4.27928018569946) - 2394.09191477027*std::sin(0.380079835653305*x_100 - 4.21152019500732) - 154.266678815115*std::sin(0.457999855279922*x_100 + 5.24911975860596) - 9136.16624718559*std::sin(0.479119867086411*x_100 + 8.45336055755615) - 18.001912078909*std::sin(0.761759877204895*x_100 + 5.39792013168335) - 23017.2175440976*std::sin(0.372159838676453*x_102 - 4.21256017684937) - 3531.57233558561*std::sin(0.382799834012985*x_102 + 1.98967981338501) + 351.40827613735*std::sin(0.396079838275909*x_105 + 5.19479990005493) + 36.2248770146771*std::sin(0.527279853820801*x_105 - 4.23031997680664) + 18.5308844671121*std::sin(0.530399858951569*x_108 - 7.23000001907349) + 6102.06682731946*std::sin(0.502559840679169*x_110 - 7.3328800201416) - 0.107942106850594*std::sin(0.498479843139648*x_111 + 2.05335974693298) + 10.663527465249*std::sin(0.27567994594574*x_112 + 1.84967994689941) - 387.219092485713*std::sin(0.350959837436676*x_114 - 1.23111987113953) + 1748.60437901548*std::sin(0.430639863014221*x_118 - 7.37128019332886) + 0.350508919851619*std::sin(0.330879837274551*x_120 - 1.24343991279602) + 4032.02149886028*std::sin(0.34911984205246*x_120 + 5.16007995605469) - 400.631766999283*std::sin(0.393999844789505*x_120 - 7.39271974563599) + 36099.819451732*std::sin(0.397199839353561*x_120 + 5.19304037094116) - 4001.32893406729*std::sin(0.287039935588837*x_14 + 1.89999985694885) + 7.34890622517054*std::sin(0.421199858188629*x_16 + 2.00095963478088) + 630.867862721425*std::sin(0.754159867763519*x_2 - 0.799599885940552) - 0.23514473113667*std::sin(0.439279854297638*x_21 + 8.22023963928223) + 9230.10848402774*std::sin(0.442079842090607*x_21 + 8.21959972381592) - 196.620200911437*std::sin(0.390879839658737*x_24 + 8.39072036743164) + 837.616411942463*std::sin(0.320799857378006*x_28 + 5.11976003646851) + 106.928920286609*std::sin(0.331279844045639*x_28 + 5.14024019241333) - 11464.3945771478*std::sin(0.336159855127335*x_28 - 4.27024030685425) - 0.201209151541755*std::sin(0.337359845638275*x_28 + 5.132080078125) + 14.4412314127487*std::sin(0.347679853439331*x_28 + 5.14071989059448) - 4196.00718509702*std::sin(0.322559833526611*x_3 - 4.25808000564575) + 0.252827901061332*std::sin(0.341759830713272*x_3 + 8.33720016479492) - 7946.95689727108*std::sin(0.346719831228256*x_3 - 4.24839973449707) + 0.0907164569737646*std::sin(0.277759939432144*x_33 - 1.18871986865997) - 23684.2866043919*std::sin(0.345999836921692*x_34 + 2.00871968269348) - 5175.92132699269*std::sin(0.348639845848083*x_34 + 2.0033597946167) - 0.187116585567655*std::sin(0.35591983795166*x_34 - 7.40551996231079) + 19438.20151127*std::sin(0.311519920825958*x_35 - 4.32943964004517) - 0.162827562421614*std::sin(0.261519968509674*x_36 + 1.84575986862183) + 4385.95583132395*std::sin(0.351119846105576*x_36 - 7.42143964767456) + 5.47529240653924*std::sin(0.366719841957092*x_36 + 1.95679974555969) + 7218.20302611201*std::sin(0.370879858732224*x_36 - 7.42600011825562) - 340.39054047643*std::sin(0.37271985411644*x_36 - 7.41264009475708) - 0.608287935643153*std::sin(0.384159833192825*x_36 - 1.19167983531952) - 812.963550606454*std::sin(0.36847984790802*x_41 - 7.41703987121582) + 1966.89493403067*std::sin(0.39727982878685*x_46 - 7.39071989059448) + 0.155104198672045*std::sin(0.357199847698212*x_47 + 5.14815998077393) - 6896.65066026858*std::sin(0.331759840250015*x_51 - 4.25544023513794) + 25133.8908798255*std::sin(0.246239975094795*x_52 - 7.53248023986816) - 1158.19864471423*std::sin(0.404719859361649*x_52 + 5.20879983901978) + 0.397740037947566*std::sin(0.434639871120453*x_52 - 4.17999982833862) + 39.6496032752911*std::sin(0.31063985824585*x_55 + 5.11191987991333) + 0.707192450515379*std::sin(0.332079827785492*x_55 + 5.14311981201172) + 30.9760606873256*std::sin(0.445359855890274*x_58 - 7.3699197769165) - 21.5326532016132*std::sin(0.438239872455597*x_59 - 4.15751981735229) - 22.1356889628289*std::sin(0.269919961690903*x_64 - 4.29559993743896) - 311.79051462706*std::sin(0.324319839477539*x_65 + 5.12215995788574) - 0.211838047291013*std::sin(0.4651198387146*x_67 + 8.45736026763916) + 673.985919584443*std::sin(0.249279975891113*x_68 - 4.33143997192383) + 3.0258637051926*std::sin(0.304399847984314*x_70 - 1.28231990337372) + 4634.0971819396*std::sin(0.292719930410385*x_75 - 7.47431993484497) - 427.918326081132*std::sin(0.27839994430542*x_8 - 4.29239988327026) + 0.449776148667134*std::sin(0.349999845027924*x_92 + 2.00279974937439) + 524.567704500762*std::sin(0.359759837388992*x_92 + 2.00303983688354) + 511.260046785002*std::sin(0.365439832210541*x_92 + 2.000079870224) + 27059.0723897903*std::sin(0.383919835090637*x_94 - 7.39567947387695) + 3385.59458950367*std::sin(0.392479836940765*x_94 - 7.40143966674805) - 117.763225031105*std::sin(0.306479930877686*x_95 - 4.30711984634399) + 2816.39570662715*std::sin(0.404239863157272*x_96 + 5.18688011169434) + 25.4466044622194*std::sin(0.488079845905304*x_96 + 5.24823999404907) - 3.92287832927587*std::sin(0.502879858016968*x_96 - 7.33160018920898) + 1278.30424455758*std::sin(0.44447985291481*x_98 - 7.3746395111084) + 3.37665877376865*std::sin(0.484719842672348*x_98 + 2.04863977432251) + 32.7533339853339*std::sin(0.62095981836319*x_98 - 7.40104007720947) + 27.7861918185161*std::sin(0.482239842414856*x_99 + 2.05831980705261) + 14018.9200935751*std::sin(0.53303986787796*x_99 + 8.38224029541016) - 1439818.99389741 - 0.00331599345495129*std::exp(-2.41559982299805*x_86) - 0.0110013047782305*std::exp(-2.41311979293823*x_86) - 1.01363767621806*std::exp(-4.34423971176147*x_111) - 0.00033833099842883*std::exp(-4.29680013656616*x_111));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (315.515081582149*x_1 + 1855.82087385586*x_10 + 433.225333107299*x_100 + 48827.1850198544*x_101 - 72.4270156809605*x_102 + 4299.5390805715*x_103 - 15945.7164056611*x_104 - 8224.14529968375*x_105 + 4301.78742170439*x_106 + 2583.98262577886*x_107 + 2006.79446663228*x_108 + 2475.29187551896*x_109 + 6617.03373542386*x_11 - 912.718793419845*x_110 - 2613.67896264379*x_111 - 867.33421736618*x_112 + 105455.472974602*x_113 - 1783.80462479709*x_114 - 5773.53518491109*x_115 - 2542.94034203115*x_116 + 2457.21213411917*x_117 + 728.15665513498*x_118 + 10077.3567243246*x_119 - 794.304449925134*x_12 - 186.545184502997*x_120 - 526.253841452059*x_13 - 5621.23694951725*x_14 - 8000.2244612897*x_15 + 2077.26440640157*x_16 + 513.733846027586*x_17 + 628.42317709271*x_18 - 2454.75428021675*x_19 - 567.75326030565*x_2 + 3796.07836873542*x_20 - 2557.70186125864*x_21 - 1815.62513695919*x_22 - 8592.74166144157*x_23 + 2399.54438141223*x_24 - 1034.2100270803*x_25 + 1790.6742730248*x_26 + 2448.72796762163*x_27 - 1671.5290885821*x_28 - 128.912232819653*x_29 - 5790.10531731858*x_3 - 4623.71148133442*x_30 - 6590.86771476026*x_31 - 1414.15592827232*x_32 + 12881.036502467*x_33 + 1802.81652577537*x_34 - 1274.67874589675*x_35 - 1599.50380110471*x_36 - 17164.9132952433*x_37 + 1977.02720288291*x_38 - 48982.2521107187*x_39 - 17814.7564969916*x_4 + 2553.30100850331*x_40 + 3519.69685990658*x_41 + 12043.0611188711*x_42 + 909.965234190163*x_43 - 9400.49176214038*x_44 - 1452.56605426154*x_45 - 2641.67692413715*x_46 + 6287.10992135352*x_47 - 68687.1296641677*x_48 + 50920.8359386006*x_49 - 1323.45897152859*x_5 + 2995.00706939242*x_51 - 138.439697340855*x_52 + 6861.16689432804*x_53 + 1871.65826948212*x_54 - 3401.76507839818*x_55 + 9019.58486309155*x_56 - 1121.83606377371*x_57 - 2911.26162772779*x_58 + 3937.36498006142*x_59 - 964.787872889307*x_6 - 201.845044334988*x_60 - 763.17559876966*x_61 + 40353.3931043441*x_62 - 6874.25770879161*x_63 + 5667.41069871062*x_64 + 3004.10526045588*x_65 + 284.696953752614*x_66 + 131.007997129875*x_67 - 3925.81854785299*x_68 + 7201.01023670405*x_69 + 11019.7863434535*x_7 + 3265.46664068032*x_70 - 53.4256637747323*x_71 + 8479.98815483126*x_72 - 76.8245362946364*x_73 + 5150.67647829207*x_74 - 6105.85596761913*x_75 + 5619.72382805764*x_76 + 3883.8675304703*x_77 + 26.2657219032744*x_78 - 496.61257034734*x_79 + 35773.2576111896*x_8 - 1944.05001532045*x_80 - 5730.35190086089*x_81 - 14094.4566835515*x_82 + 1590.27354053438*x_83 + 8530.89621483786*x_84 + 1450.67917008641*x_85 + 8862.57761593289*x_86 - 1186.166214949*x_87 - 3192.52995615079*x_88 + 3325.56572700416*x_89 - 2535958.13785245*x_9 + 23721.7660171214*x_90 + 14315.0598112904*x_91 + 7755.27977390204*x_92 - 256456.297890407*x_93 + 2659.05315198287*x_94 + 3675.26882606398*x_95 + 10206.5185409471*x_96 - 13771.616142495*x_97 - 39.5777744698025*x_98 + 4384.59829293806*x_99 - 0.466878754558713*std::pow(-9.98124027252197*x_110 - 9.80000019073486, 2) + 24.9948330296224*std::pow(-4.5798397064209*x_22 - 7.37175989151001, 2) + 33.3157901403259*std::pow(-7.55879974365234*x_24 - 8.38191986083984, 2) - 0.473910670622595*std::pow(-6.16311979293823*x_27 - 8.35552024841309, 2) + 38.9268910874154*std::pow(-7.410719871521*x_67 - 9.21880054473877, 2) + 0.000889666099999455*std::pow(-2.03479981422424*x_7 - 3.25959992408752, 2) + 4.63304161525134e-5*std::pow(-7.58656024932861*x_71 - 9.77288055419922, 2) - 74.0124779263879*std::pow(-5.86728000640869*x_73 - 7.48176002502441, 2) - 1.53137719091122*std::pow(-5.56799983978271*x_88 - 7.39811992645264, 2) + 621.34408762491*std::exp(0.941519796848297*x_1) + 0.00170044722732162*std::exp(1.05287981033325*x_1) + 0.191126613269879*std::exp(1.08055984973907*x_1) + 21.141812186872*std::exp(1.14351987838745*x_1) - 1.38338052201915*std::exp(1.17575979232788*x_1) + 0.000169565329595136*std::exp(1.91935980319977*x_10) + 6.84266329940575*std::exp(0.718959867954254*x_108) + 135.937058713752*std::exp(2.84631991386414*x_17) + 0.000285685484319361*std::exp(2.97367978096008*x_17) - 0.00706584070939336*std::exp(3.23551988601685*x_17) + 0.000204486607377075*std::exp(3.33439970016479*x_17) + 0.4005620115725*std::exp(3.69400000572205*x_17) + 35.3798399824591*std::exp(0.924879848957062*x_29) + 6239.5475983923*std::exp(1.05567979812622*x_29) + 0.166198440731731*std::exp(1.32319986820221*x_29) - 0.0280370092983867*std::exp(1.51199984550476*x_29) + 2.43438393765731*std::exp(1.89591979980469*x_29) - 26.2579719255961*std::exp(2.74616003036499*x_29) - 6.43984519163921e-5*std::exp(2.97727990150452*x_29) + 20.2034809930422*std::exp(0.801359891891479*x_38) - 3364.08859869447*std::exp(0.83847987651825*x_38) - 0.0227265293825448*std::exp(0.859919905662537*x_38) - 119.824055748969*std::exp(0.908879816532135*x_38) - 0.010496730417771*std::exp(2.08367991447449*x_38) - 0.0523126790185083*std::exp(2.11967992782593*x_38) - 117.36869134064*std::exp(1.6879198551178*x_50) - 0.000728155671785591*std::exp(1.74383985996246*x_50) - 0.00536699881381817*std::exp(1.81527996063232*x_50) + 45.651133445471*std::exp(1.86807990074158*x_50) + 6821.05415074558*std::exp(1.90071976184845*x_50) - 1.40244992832308*std::exp(1.93159985542297*x_50) + 2098.43824413492*std::exp(1.93415975570679*x_50) + 18.2989719136433*std::exp(1.94911980628967*x_50) - 0.00417648185071742*std::exp(1.96527981758118*x_50) - 0.228794892652702*std::exp(1.98295974731445*x_50) - 56.1117071020037*std::exp(0.994239807128906*x_6) - 260.825432766535*std::exp(1.77975988388062*x_71) - 9.64837944801147*std::exp(1.78367984294891*x_71) - 0.00122186798099508*std::exp(1.81471991539001*x_71) + 498.361584459332*std::exp(1.83799982070923*x_71) + 5489.24046691469*std::exp(0.713119864463806*x_73) - 59.6706498129501*std::exp(0.727599859237671*x_78) + 0.0283911981965281*std::exp(1.04399979114532*x_78) + 22.0555486608655*std::exp(1.13199985027313*x_78) + 38.1912033567571*std::exp(1.46615982055664*x_78) + 1763.46363503439*std::exp(1.48823988437653*x_78) + 0.67530089863159*std::exp(1.54943978786469*x_78) + 114.783121760309*std::exp(0.753439843654633*x_88) - 450.521430529439*std::sin(0.459999859333038*x_1 - 4.27928018569946) + 1546.33073874085*std::sin(0.380079835653305*x_100 - 4.21152019500732) + 251.737008645435*std::sin(0.457999855279922*x_100 + 5.24911975860596) - 32349.0467905068*std::sin(0.479119867086411*x_100 + 8.45336055755615) + 8.69710852748885*std::sin(0.761759877204895*x_100 + 5.39792013168335) + 58447.00325981*std::sin(0.372159838676453*x_102 - 4.21256017684937) + 2281.02305718154*std::sin(0.382799834012985*x_102 + 1.98967981338501) - 573.438599492285*std::sin(0.396079838275909*x_105 + 5.19479990005493) - 17.5010124152698*std::sin(0.527279853820801*x_105 - 4.23031997680664) - 0.330692677329977*std::sin(0.530399858951569*x_108 - 7.23000001907349) + 21606.0040913293*std::sin(0.502559840679169*x_110 - 7.3328800201416) - 0.0646044080812807*std::sin(0.498479843139648*x_111 + 2.05335974693298) - 0.190295851961269*std::sin(0.27567994594574*x_112 + 1.84967994689941) + 631.875767219816*std::sin(0.350959837436676*x_114 - 1.23111987113953) - 1129.41390616073*std::sin(0.430639863014221*x_118 - 7.37128019332886) + 0.209783021240874*std::sin(0.330879837274551*x_120 - 1.24343991279602) + 14276.4534486377*std::sin(0.34911984205246*x_120 + 5.16007995605469) + 604.155068632431*std::sin(0.393999844789505*x_120 - 7.39271974563599) - 91667.3034493253*std::sin(0.397199839353561*x_120 + 5.19304037094116) + 2584.43624841161*std::sin(0.287039935588837*x_14 + 1.89999985694885) - 0.131144818228275*std::sin(0.421199858188629*x_16 + 2.00095963478088) - 407.474066551658*std::sin(0.754159867763519*x_2 - 0.799599885940552) - 0.140736424475606*std::sin(0.439279854297638*x_21 + 8.22023963928223) - 23437.7669507976*std::sin(0.442079842090607*x_21 + 8.21959972381592) + 296.504423166184*std::sin(0.390879839658737*x_24 + 8.39072036743164) - 541.011812065178*std::sin(0.320799857378006*x_28 + 5.11976003646851) - 51.6596470632357*std::sin(0.331279844045639*x_28 + 5.14024019241333) - 40592.7635910994*std::sin(0.336159855127335*x_28 - 4.27024030685425) - 0.120425647739895*std::sin(0.337359845638275*x_28 + 5.132080078125) - 0.257710822616115*std::sin(0.347679853439331*x_28 + 5.14071989059448) + 2710.17785502009*std::sin(0.322559833526611*x_3 - 4.25808000564575) - 0.051312772074959*std::sin(0.341759830713272*x_3 + 8.33720016479492) - 28138.3321577752*std::sin(0.346719831228256*x_3 - 4.24839973449707) + 0.0542946879305679*std::sin(0.277759939432144*x_33 - 1.18871986865997) - 83860.5685181423*std::sin(0.345999836921692*x_34 + 2.00871968269348) + 3343.09898456893*std::sin(0.348639845848083*x_34 + 2.0033597946167) - 0.111991108988828*std::sin(0.35591983795166*x_34 - 7.40551996231079) - 49358.9038256873*std::sin(0.311519920825958*x_35 - 4.32943964004517) - 0.097453890761335*std::sin(0.261519968509674*x_36 + 1.84575986862183) - 2832.86463602077*std::sin(0.351119846105576*x_36 - 7.42143964767456) - 4.50948297167642*std::sin(0.366719841957092*x_36 + 1.95679974555969) + 25557.9836353137*std::sin(0.370879858732224*x_36 - 7.42600011825562) + 513.31094357212*std::sin(0.37271985411644*x_36 - 7.41264009475708) + 0.123455283481678*std::sin(0.384159833192825*x_36 - 1.19167983531952) + 1225.95383134754*std::sin(0.36847984790802*x_41 - 7.41703987121582) - 1270.40656943914*std::sin(0.39727982878685*x_46 - 7.39071989059448) - 0.03147922504169*std::sin(0.357199847698212*x_47 + 5.14815998077393) + 4454.50855271531*std::sin(0.331759840250015*x_51 - 4.25544023513794) - 63821.8150986529*std::sin(0.246239975094795*x_52 - 7.53248023986816) - 4100.91291433142*std::sin(0.404719859361649*x_52 + 5.20879983901978) - 0.327581030400559*std::sin(0.434639871120453*x_52 - 4.17999982833862) - 0.707566521471106*std::sin(0.31063985824585*x_55 + 5.11191987991333) - 0.143528482711346*std::sin(0.332079827785492*x_55 + 5.14311981201172) - 14.9651970507834*std::sin(0.445359855890274*x_58 - 7.3699197769165) + 0.384260705413004*std::sin(0.438239872455597*x_59 - 4.15751981735229) + 0.395022172884028*std::sin(0.269919961690903*x_64 - 4.29559993743896) + 508.789144091865*std::sin(0.324319839477539*x_65 + 5.12215995788574) + 0.0429936624550439*std::sin(0.4651198387146*x_67 + 8.45736026763916) - 1099.8305049963*std::sin(0.249279975891113*x_68 - 4.33143997192383) - 2.49211911255793*std::sin(0.304399847984314*x_70 - 1.28231990337372) - 2993.13776323128*std::sin(0.292719930410385*x_75 - 7.47431993484497) + 698.29000131214*std::sin(0.27839994430542*x_8 - 4.29239988327026) - 0.0912844702045398*std::sin(0.349999845027924*x_92 + 2.00279974937439) - 791.051193690244*std::sin(0.359759837388992*x_92 + 2.00303983688354) - 834.289529055262*std::sin(0.365439832210541*x_92 + 2.000079870224) + 95809.9026618179*std::sin(0.383919835090637*x_94 - 7.39567947387695) - 2186.73683761495*std::sin(0.392479836940765*x_94 - 7.40143966674805) + 192.169574307741*std::sin(0.306479930877686*x_95 - 4.30711984634399) - 1819.09442438146*std::sin(0.404239863157272*x_96 + 5.18688011169434) - 12.2937985528378*std::sin(0.488079845905304*x_96 + 5.24823999404907) + 3.23090562336*std::sin(0.502879858016968*x_96 - 7.33160018920898) - 825.649648047023*std::sin(0.44447985291481*x_98 - 7.3746395111084) - 2.7810359905684*std::sin(0.484719842672348*x_98 + 2.04863977432251) - 49.3922209166348*std::sin(0.62095981836319*x_98 - 7.40104007720947) - 13.4241032148127*std::sin(0.482239842414856*x_99 + 2.05831980705261) - 35597.867849944*std::sin(0.53303986787796*x_99 + 8.38224029541016) + 2341445.3412325 + 0.000672998571920648*std::exp(-2.41559982299805*x_86) + 0.00906073920443091*std::exp(-2.41311979293823*x_86) + 2.57390296862251*std::exp(-4.34423971176147*x_111) + 0.000278651396660189*std::exp(-4.29680013656616*x_111));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-164.604983559433*x_1 - 1800.35059645004*x_10 - 589.235838582341*x_100 - 46129.0259137309*x_101 + 262.375500313783*x_102 - 5394.52905640971*x_103 + 20708.9327051909*x_104 + 9866.63817550728*x_105 - 4586.15482647707*x_106 - 3720.02533543411*x_107 - 2626.93072815895*x_108 - 373.158350311264*x_109 - 9349.58805456637*x_11 + 1120.71951688563*x_110 + 2414.96170401317*x_111 + 997.345128241576*x_112 - 129242.143445856*x_113 + 2058.13548665377*x_114 + 6442.30218995159*x_115 + 4481.44097262292*x_116 - 2958.82259951918*x_117 - 466.480593432221*x_118 - 12062.894346936*x_119 + 1385.77689701739*x_12 + 164.004047810229*x_120 + 340.973237829913*x_13 + 7262.02918334651*x_14 + 9682.56028821*x_15 - 2458.26037637823*x_16 - 538.192427424958*x_17 - 1057.78939400157*x_18 + 3251.71739634497*x_19 + 483.927128536519*x_2 - 4179.30629083559*x_20 + 2510.1479683852*x_21 + 2341.192428896*x_22 + 9845.59452454624*x_23 - 3094.30843846675*x_24 + 1726.73237321977*x_25 - 1442.1708633779*x_26 - 3227.57228463797*x_27 + 2224.6050331791*x_28 + 78.9573676200491*x_29 + 7628.71801352021*x_3 + 4893.23281659521*x_30 + 34230.7167354008*x_31 + 1121.351575889*x_32 - 15572.461722638*x_33 - 1975.83735965754*x_34 + 1275.41059918799*x_35 + 2041.00660166963*x_36 + 18292.607844799*x_37 - 1980.12847291497*x_38 + 45924.4351028123*x_39 + 22699.4837216383*x_4 - 1748.82270341732*x_40 - 2767.84295477783*x_41 - 7545.99065415622*x_42 - 0.326232325042854*x_43 + 13190.3724478688*x_44 + 2803.59670879208*x_45 + 3946.35064500282*x_46 - 7145.72219998575*x_47 + 68787.0739327216*x_48 - 50064.9638881408*x_49 + 1702.19122048394*x_5 - 3765.73163608043*x_51 + 75.7371419110015*x_52 - 7650.17177886264*x_53 - 2360.9729903221*x_54 + 4583.61406895142*x_55 - 8667.49938732942*x_56 + 2334.88354484387*x_57 + 2851.67250826492*x_58 - 3875.29161416901*x_59 + 1383.59833508653*x_6 + 2007.63695016302*x_60 + 1774.51389664746*x_61 - 52421.3735225457*x_62 + 8727.23626188802*x_63 - 4975.24520377259*x_64 - 3858.02803001747*x_65 - 268.572046189205*x_66 - 159.678344352183*x_67 + 4260.15113270247*x_68 - 9338.09878473814*x_69 - 14477.320511958*x_7 - 4612.95430836304*x_70 - 0.979486331425834*x_71 - 6917.76618520212*x_72 + 65.7940717053777*x_73 - 5572.68435397893*x_74 + 7272.66113024105*x_75 - 7652.27694061425*x_76 - 4403.98189071333*x_77 - 16.1382719543818*x_78 + 144.034233369376*x_79 - 13214.0807137851*x_8 + 3434.46901441211*x_80 + 6943.54177025485*x_81 + 17410.5038928627*x_82 - 798.80305135146*x_83 - 11065.4423442877*x_84 - 2037.51559257246*x_85 - 8881.02021021625*x_86 + 1453.59008498544*x_87 + 4486.0646283916*x_88 - 3413.90942396331*x_89 + 3290206.63595147*x_9 - 31269.3437032187*x_90 - 16880.7033893274*x_91 - 8590.63017306093*x_92 + 268832.078251482*x_93 - 2314.63003088185*x_94 - 5698.20984902316*x_95 - 11913.8825666653*x_96 + 17452.1305693095*x_97 + 425.826948529334*x_98 - 4555.99389066173*x_99 + 0.287025873156495*std::pow(-9.98124027252197*x_110 - 9.80000019073486, 2) - 25.3122713153972*std::pow(-4.5798397064209*x_22 - 7.37175989151001, 2) - 33.7389058818411*std::pow(-7.55879974365234*x_24 - 8.38191986083984, 2) + 0.258286973445663*std::pow(-6.16311979293823*x_27 - 8.35552024841309, 2) - 39.4212686878853*std::pow(-7.410719871521*x_67 - 9.21880054473877, 2) - 0.000332982477173288*std::pow(-2.03479981422424*x_7 - 3.25959992408752, 2) + 7.69289040135004e-5*std::pow(-7.58656024932861*x_71 - 9.77288055419922, 2) + 96.1826467074646*std::pow(-5.86728000640869*x_73 - 7.48176002502441, 2) + 0.941454009336289*std::pow(-5.56799983978271*x_88 - 7.39811992645264, 2) - 807.465450937041*std::exp(0.941519796848297*x_1) + 0.00282349161509855*std::exp(1.05287981033325*x_1) - 0.0186935009798938*std::exp(1.08055984973907*x_1) - 21.4103165057774*std::exp(1.14351987838745*x_1) - 0.434223077991512*std::exp(1.17575979232788*x_1) + 0.000281553157681579*std::exp(1.91935980319977*x_10) - 30.9119982308021*std::exp(0.718959867954254*x_108) - 176.656510618666*std::exp(2.84631991386414*x_17) + 0.000474363777111512*std::exp(2.97367978096008*x_17) + 0.000691087954550359*std::exp(3.23551988601685*x_17) - 7.65348450089551e-5*std::exp(3.33439970016479*x_17) + 0.125730604720105*std::exp(3.69400000572205*x_17) + 11.1052185364064*std::exp(0.924879848957062*x_29) - 6318.79082803487*std::exp(1.05567979812622*x_29) - 0.0162553537758159*std::exp(1.32319986820221*x_29) - 0.119516885495422*std::exp(1.51199984550476*x_29) - 1.32676830980869*std::exp(1.89591979980469*x_29) + 34.123451987191*std::exp(2.74616003036499*x_29) + 2.41029258564064e-5*std::exp(2.97727990150452*x_29) + 6.34157960395249*std::exp(0.801359891891479*x_38) + 4371.78911240691*std::exp(0.83847987651825*x_38) - 0.0968792349074925*std::exp(0.859919905662537*x_38) + 73.6649588157159*std::exp(0.908879816532135*x_38) + 0.00102665263090918*std::exp(2.08367991447449*x_38) + 0.236324566986817*std::exp(2.11967992782593*x_38) + 72.155459601334*std::exp(1.6879198551178*x_50) + 0.00027253267193062*std::exp(1.74383985996246*x_50) - 0.0228785808022001*std::exp(1.81527996063232*x_50) - 24.880412750581*std::exp(1.86807990074158*x_50) - 6907.68260448335*std::exp(1.90071976184845*x_50) + 6.33562222868349*std::exp(1.93159985542297*x_50) - 2727.01779386177*std::exp(1.93415975570679*x_50) + 5.74378183149846*std::exp(1.94911980628967*x_50) - 0.00693480003180453*std::exp(1.96527981758118*x_50) + 0.0223777185020209*std::exp(1.98295974731445*x_50) + 34.496133242295*std::exp(0.994239807128906*x_6) + 264.137956525575*std::exp(1.77975988388062*x_71) + 5.25848198988285*std::exp(1.78367984294891*x_71) + 0.000457318343466965*std::exp(1.81471991539001*x_71) - 647.643985900575*std::exp(1.83799982070923*x_71) - 5558.9546787263*std::exp(0.713119864463806*x_73) + 32.5212165479949*std::exp(0.727599859237671*x_78) + 0.12102673105464*std::exp(1.04399979114532*x_78) + 6.92291677804901*std::exp(1.13199985027313*x_78) - 38.6762376080712*std::exp(1.46615982055664*x_78) - 2291.70275799536*std::exp(1.48823988437653*x_78) - 3.05069813760553*std::exp(1.54943978786469*x_78) - 62.5581717397646*std::exp(0.753439843654633*x_88) + 245.539558353872*std::sin(0.459999859333038*x_1 - 4.27928018569946) - 950.647092295579*std::sin(0.380079835653305*x_100 - 4.21152019500732) + 79.0165952162246*std::sin(0.457999855279922*x_100 + 5.24911975860596) + 32759.8847403926*std::sin(0.479119867086411*x_100 + 8.45336055755615) - 39.2895268481466*std::sin(0.761759877204895*x_100 + 5.39792013168335) - 75954.5906737444*std::sin(0.372159838676453*x_102 - 4.21256017684937) - 1402.31832844151*std::sin(0.382799834012985*x_102 + 1.98967981338501) - 179.994057851304*std::sin(0.396079838275909*x_105 + 5.19479990005493) + 79.0615059000565*std::sin(0.527279853820801*x_105 - 4.23031997680664) - 1.40968526385929*std::sin(0.530399858951569*x_108 - 7.23000001907349) - 21880.4037199672*std::sin(0.502559840679169*x_110 - 7.3328800201416) + 0.0241800107245089*std::sin(0.498479843139648*x_111 + 2.05335974693298) - 0.81119805993065*std::sin(0.27567994594574*x_112 + 1.84967994689941) + 198.336637088084*std::sin(0.350959837436676*x_114 - 1.23111987113953) + 694.336611819642*std::sin(0.430639863014221*x_118 - 7.37128019332886) - 0.0785171763673198*std::sin(0.330879837274551*x_120 - 1.24343991279602) - 14457.7666386202*std::sin(0.34911984205246*x_120 + 5.16007995605469) - 329.271725331537*std::sin(0.393999844789505*x_120 - 7.39271974563599) + 119125.911053289*std::sin(0.397199839353561*x_120 + 5.19304037094116) - 1588.84948945423*std::sin(0.287039935588837*x_14 + 1.89999985694885) - 0.559047509550481*std::sin(0.421199858188629*x_16 + 2.00095963478088) + 250.505294144648*std::sin(0.754159867763519*x_2 - 0.799599885940552) + 0.0526745520037543*std::sin(0.439279854297638*x_21 + 8.22023963928223) + 30458.4648615948*std::sin(0.442079842090607*x_21 + 8.21959972381592) - 161.59845055237*std::sin(0.390879839658737*x_24 + 8.39072036743164) + 332.601100884871*std::sin(0.320799857378006*x_28 + 5.11976003646851) + 233.374469669038*std::sin(0.331279844045639*x_28 + 5.14024019241333) + 41108.2980327157*std::sin(0.336159855127335*x_28 - 4.27024030685425) + 0.0450726744557903*std::sin(0.337359845638275*x_28 + 5.132080078125) - 1.09857633350764*std::sin(0.347679853439331*x_28 + 5.14071989059448) - 1666.15241676994*std::sin(0.322559833526611*x_3 - 4.25808000564575) - 0.0852018100728198*std::sin(0.341759830713272*x_3 + 8.33720016479492) + 28495.6933737569*std::sin(0.346719831228256*x_3 - 4.24839973449707) - 0.0203213089545417*std::sin(0.277759939432144*x_33 - 1.18871986865997) + 84925.6108444083*std::sin(0.345999836921692*x_34 + 2.00871968269348) - 2055.25716414628*std::sin(0.348639845848083*x_34 + 2.0033597946167) + 0.0419158118899962*std::sin(0.35591983795166*x_34 - 7.40551996231079) + 64144.184082792*std::sin(0.311519920825958*x_35 - 4.32943964004517) + 0.0364748504589578*std::sin(0.261519968509674*x_36 + 1.84575986862183) + 1741.57731048729*std::sin(0.351119846105576*x_36 - 7.42143964767456) + 0.441058536577609*std::sin(0.366719841957092*x_36 + 1.95679974555969) - 25882.5740217924*std::sin(0.370879858732224*x_36 - 7.42600011825562) - 279.760592597763*std::sin(0.37271985411644*x_36 - 7.41264009475708) + 0.20499016502804*std::sin(0.384159833192825*x_36 - 1.19167983531952) - 668.159474583847*std::sin(0.36847984790802*x_41 - 7.41703987121582) + 781.015523402151*std::sin(0.39727982878685*x_46 - 7.39071989059448) - 0.0522693833286489*std::sin(0.357199847698212*x_47 + 5.14815998077393) - 2738.52514028971*std::sin(0.331759840250015*x_51 - 4.25544023513794) + 82939.407865363*std::sin(0.246239975094795*x_52 - 7.53248023986816) + 4152.9951492515*std::sin(0.404719859361649*x_52 + 5.20879983901978) + 0.0320396841027086*std::sin(0.434639871120453*x_52 - 4.17999982833862) - 3.01623279526902*std::sin(0.31063985824585*x_55 + 5.11191987991333) - 0.238320520009089*std::sin(0.332079827785492*x_55 + 5.14311981201172) + 67.6058611268505*std::sin(0.445359855890274*x_58 - 7.3699197769165) + 1.63803643393159*std::sin(0.438239872455597*x_59 - 4.15751981735229) + 1.68391069469203*std::sin(0.269919961690903*x_64 - 4.29559993743896) + 159.70153163193*std::sin(0.324319839477539*x_65 + 5.12215995788574) + 0.0713884227006556*std::sin(0.4651198387146*x_67 + 8.45736026763916) - 345.220840937822*std::sin(0.249279975891113*x_68 - 4.33143997192383) + 0.24374643737778*std::sin(0.304399847984314*x_70 - 1.28231990337372) + 1840.10938938773*std::sin(0.292719930410385*x_75 - 7.47431993484497) + 219.183101738263*std::sin(0.27839994430542*x_8 - 4.29239988327026) - 0.151572440514487*std::sin(0.349999845027924*x_92 + 2.00279974937439) + 431.132344815978*std::sin(0.359759837388992*x_92 + 2.00303983688354) - 261.871380633369*std::sin(0.365439832210541*x_92 + 2.000079870224) - 97026.7033992013*std::sin(0.383919835090637*x_94 - 7.39567947387695) + 1344.35341949357*std::sin(0.392479836940765*x_94 - 7.40143966674805) + 60.319241686613*std::sin(0.306479930877686*x_95 - 4.30711984634399) + 1118.33567155076*std::sin(0.404239863157272*x_96 + 5.18688011169434) + 55.5377142622467*std::sin(0.488079845905304*x_96 + 5.24823999404907) - 0.316004853551931*std::sin(0.502879858016968*x_96 - 7.33160018920898) + 507.589623297471*std::sin(0.44447985291481*x_98 - 7.3746395111084) + 0.272004500709705*std::sin(0.484719842672348*x_98 + 2.04863977432251) + 26.9193500867101*std::sin(0.62095981836319*x_98 - 7.40104007720947) + 60.6439096400421*std::sin(0.482239842414856*x_99 + 2.05831980705261) + 46261.0797919177*std::sin(0.53303986787796*x_99 + 8.38224029541016) - 3469914.29272995 + 0.00111747415283464*std::exp(-2.41559982299805*x_86) - 0.00088620278619924*std::exp(-2.41311979293823*x_86) - 3.34490624859958*std::exp(-4.34423971176147*x_111) - 2.72540284547434e-5*std::exp(-4.29680013656616*x_111));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-568.290660175106*x_1 - 5447.14189543343*x_10 - 728.513620850745*x_100 - 277506.116280221*x_101 + 662.76725844144*x_102 - 7559.25030848844*x_103 + 25121.9005175827*x_104 + 15880.2464781201*x_105 - 11816.9675940442*x_106 - 3254.73303323722*x_107 - 4109.73588795549*x_108 - 17071.9856271089*x_109 - 7768.12637522902*x_11 + 1334.99743787453*x_110 + 6607.56911789838*x_111 + 1853.58752371703*x_112 - 193458.833870393*x_113 + 3632.16838292913*x_114 + 13420.2993478989*x_115 - 1472.88165303356*x_116 - 5833.04932790778*x_117 - 2890.89601939762*x_118 - 20499.1571003169*x_119 - 2935.01628745798*x_12 + 415.923048024927*x_120 + 1927.27599096273*x_13 + 8830.94245275179*x_14 + 15187.3848702102*x_15 - 4576.48972927735*x_16 - 1527.05701136427*x_17 - 193.157140106398*x_18 + 3526.10993831934*x_19 + 1906.41550199313*x_2 - 8914.96072658545*x_20 + 6853.96797601728*x_21 + 2866.30955526308*x_22 + 18445.5328196847*x_23 - 3567.9721909867*x_24 + 332.095154411302*x_25 - 6311.57162005532*x_26 - 3739.45770462464*x_27 + 2603.87323125423*x_28 + 228.030063841397*x_29 + 9074.81268389969*x_3 + 11434.0446288097*x_30 - 94119.275404728*x_31 + 8158.3954238548*x_32 - 27255.2487221394*x_33 - 2372.55711124626*x_34 + 3402.24316299627*x_35 + 2421.09319109521*x_36 + 44107.0168691373*x_37 - 5316.01820217611*x_38 + 151145.372923079*x_39 + 30446.2260926838*x_4 - 10535.3978233586*x_40 - 13313.257290899*x_41 - 25932.2691182065*x_42 - 7207.80379163715*x_43 + 9597.83764973218*x_44 - 2894.03342678521*x_45 + 1850.70406656624*x_46 - 13732.3441524404*x_47 + 196100.851750257*x_48 - 147454.09254285*x_49 + 1832.48577036495*x_5 - 4648.82429885056*x_51 + 151.068420349153*x_52 - 16624.3563690621*x_53 - 3597.24141563002*x_54 + 4855.41108108419*x_55 - 26137.7371990831*x_56 - 1101.7025176*x_57 + 8872.89608748727*x_58 - 12019.0067647052*x_59 + 1123.44249642211*x_6 - 8217.47696565044*x_60 - 1420.74349016823*x_61 - 60800.3060227911*x_62 + 11750.1641739137*x_63 - 18138.4129022346*x_64 - 4932.99551017191*x_65 - 63.3972510015114*x_66 - 260.28834755544*x_67 + 8768.73357586688*x_68 - 10979.918365911*x_69 - 15754.1050005206*x_7 - 3209.59100385688*x_70 + 41.173532167667*x_71 - 28165.6774730282*x_72 + 120.686246538607*x_73 - 12579.611143886*x_74 + 11874.051396769*x_75 - 7385.1635962776*x_76 - 8934.71664568235*x_77 - 46.5291769533013*x_78 + 2528.58888580578*x_79 - 191853.765432492*x_8 - 932.294714734349*x_80 + 10458.5269827761*x_81 + 26143.7303749624*x_82 - 6853.92928087393*x_83 - 12967.0351074937*x_84 - 1466.13751560422*x_85 - 24807.3075685877*x_86 + 1895.38477539054*x_87 + 3132.76522862214*x_88 - 8960.66750108699*x_89 + 3914542.20718097*x_9 - 34379.3967395825*x_90 - 24062.9090722601*x_91 - 18069.8709270341*x_92 + 642491.751796021*x_93 - 2350.38509680552*x_94 - 1822.27202140449*x_95 - 21280.1593875161*x_96 + 22831.0428892413*x_97 - 1310.03166123603*x_98 - 12350.1909502353*x_99 + 0.825449599964239*std::pow(-9.98124027252197*x_110 - 9.80000019073486, 2) - 68.9225676405898*std::pow(-4.5798397064209*x_22 - 7.37175989151001, 2) - 91.8673790188948*std::pow(-7.55879974365234*x_24 - 8.38191986083984, 2) - 0.0587095800919924*std::pow(-6.16311979293823*x_27 - 8.35552024841309, 2) - 107.339836230576*std::pow(-7.410719871521*x_67 - 9.21880054473877, 2) + 0.00128451700279812*std::pow(-2.03479981422424*x_7 - 3.25959992408752, 2) - 0.00013916821918813*std::pow(-7.58656024932861*x_71 - 9.77288055419922, 2) + 113.435429302514*std::pow(-5.86728000640869*x_73 - 7.48176002502441, 2) + 2.70750098883127*std::pow(-5.56799983978271*x_88 - 7.39811992645264, 2) - 952.304736971672*std::exp(0.941519796848297*x_1) - 0.0051078369697939*std::exp(1.05287981033325*x_1) - 0.992324381890607*std::exp(1.08055984973907*x_1) - 58.2979681747588*std::exp(1.14351987838745*x_1) + 0.195279507206901*std::exp(1.17575979232788*x_1) - 0.000509343686405098*std::exp(1.91935980319977*x_10) - 1.82666346198554*std::exp(0.718959867954254*x_108) - 208.344309572397*std::exp(2.84631991386414*x_17) - 0.000858147700848292*std::exp(2.97367978096008*x_17) + 0.0366856603302313*std::exp(3.23551988601685*x_17) + 0.000295241691259808*std::exp(3.33439970016479*x_17) - 0.0565437715658396*std::exp(3.69400000572205*x_17) - 4.99425689957631*std::exp(0.924879848957062*x_29) - 17205.3816437665*std::exp(1.05567979812622*x_29) - 0.862897961454588*std::exp(1.32319986820221*x_29) + 0.586198224451308*std::exp(1.51199984550476*x_29) + 0.301579322058289*std::exp(1.89591979980469*x_29) + 40.2443534042439*std::exp(2.74616003036499*x_29) - 9.29797217636298e-5*std::exp(2.97727990150452*x_29) - 2.85194546936859*std::exp(0.801359891891479*x_38) + 5155.97970904504*std::exp(0.83847987651825*x_38) + 0.475166628159403*std::exp(0.859919905662537*x_38) + 211.850973980528*std::exp(0.908879816532135*x_38) + 0.0544987500457558*std::exp(2.08367991447449*x_38) + 0.0139649804733174*std::exp(2.11967992782593*x_38) + 207.50984783411*std::exp(1.6879198551178*x_50) - 0.00105132514444807*std::exp(1.74383985996246*x_50) + 0.112213294285761*std::exp(1.81527996063232*x_50) + 5.65540942934685*std::exp(1.86807990074158*x_50) - 18808.8700383686*std::exp(1.90071976184845*x_50) + 0.374386979051635*std::exp(1.93159985542297*x_50) - 3216.17718737924*std::exp(1.93415975570679*x_50) - 2.58310288515088*std::exp(1.94911980628967*x_50) + 0.0125453986798338*std::exp(1.96527981758118*x_50) + 1.18789710416064*std::exp(1.98295974731445*x_50) + 99.2064550558486*std::exp(0.994239807128906*x_6) + 719.218988617873*std::exp(1.77975988388062*x_71) - 1.19527231833964*std::exp(1.78367984294891*x_71) - 0.00176415645910725*std::exp(1.81471991539001*x_71) - 763.815262843266*std::exp(1.83799982070923*x_71) - 15136.4302745297*std::exp(0.713119864463806*x_73) - 7.392192266387*std::exp(0.727599859237671*x_78) - 0.593603611416843*std::exp(1.04399979114532*x_78) - 3.11338536658391*std::exp(1.13199985027313*x_78) - 105.311197458773*std::exp(1.46615982055664*x_78) - 2702.77742488848*std::exp(1.48823988437653*x_78) - 0.180273005319939*std::exp(1.54943978786469*x_78) + 14.2197027793079*std::exp(0.753439843654633*x_88) - 55.8120457048979*std::sin(0.459999859333038*x_1 - 4.27928018569946) - 2733.93911640399*std::sin(0.380079835653305*x_100 - 4.21152019500732) - 35.5354714133667*std::sin(0.457999855279922*x_100 + 5.24911975860596) + 89201.6107042983*std::sin(0.479119867086411*x_100 + 8.45336055755615) - 2.32171154372982*std::sin(0.761759877204895*x_100 + 5.39792013168335) - 89578.9614396653*std::sin(0.372159838676453*x_102 - 4.21256017684937) - 4032.88766446305*std::sin(0.382799834012985*x_102 + 1.98967981338501) + 80.9472197561552*std::sin(0.396079838275909*x_105 + 5.19479990005493) + 4.67193233510481*std::sin(0.527279853820801*x_105 - 4.23031997680664) + 6.91412761706493*std::sin(0.530399858951569*x_108 - 7.23000001907349) - 59577.9646402385*std::sin(0.502559840679169*x_110 - 7.3328800201416) - 0.0932770852302502*std::sin(0.498479843139648*x_111 + 2.05335974693298) + 3.97870861877426*std::sin(0.27567994594574*x_112 + 1.84967994689941) - 89.1962742532817*std::sin(0.350959837436676*x_114 - 1.23111987113953) + 1996.82304652221*std::sin(0.430639863014221*x_118 - 7.37128019332886) + 0.302888755323405*std::sin(0.330879837274551*x_120 - 1.24343991279602) - 39366.9294495917*std::sin(0.34911984205246*x_120 + 5.16007995605469) + 74.8446755656735*std::sin(0.393999844789505*x_120 - 7.39271974563599) + 140494.146542697*std::sin(0.397199839353561*x_120 + 5.19304037094116) - 4569.32736080661*std::sin(0.287039935588837*x_14 + 1.89999985694885) + 2.7419778897683*std::sin(0.421199858188629*x_16 + 2.00095963478088) + 720.421098511497*std::sin(0.754159867763519*x_2 - 0.799599885940552) - 0.203197952751083*std::sin(0.439279854297638*x_21 + 8.22023963928223) + 35921.958437877*std::sin(0.442079842090607*x_21 + 8.21959972381592) + 36.7319228255316*std::sin(0.390879839658737*x_24 + 8.39072036743164) + 956.518109861796*std::sin(0.320799857378006*x_28 + 5.11976003646851) + 13.7906522095974*std::sin(0.331279844045639*x_28 + 5.14024019241333) + 111933.434042559*std::sin(0.336159855127335*x_28 - 4.27024030685425) - 0.173872863195492*std::sin(0.337359845638275*x_28 + 5.132080078125) + 5.38822186887621*std::sin(0.347679853439331*x_28 + 5.14071989059448) - 4791.64066562155*std::sin(0.322559833526611*x_3 - 4.25808000564575) + 0.154134318322782*std::sin(0.341759830713272*x_3 + 8.33720016479492) + 77590.6804073957*std::sin(0.346719831228256*x_3 - 4.24839973449707) + 0.0783917132601492*std::sin(0.277759939432144*x_33 - 1.18871986865997) + 231243.221317782*std::sin(0.345999836921692*x_34 + 2.00871968269348) - 5910.65601616756*std::sin(0.348639845848083*x_34 + 2.0033597946167) - 0.161694914146392*std::sin(0.35591983795166*x_34 - 7.40551996231079) + 75650.0606686498*std::sin(0.311519920825958*x_35 - 4.32943964004517) - 0.14070579925642*std::sin(0.261519968509674*x_36 + 1.84575986862183) + 5008.55298666651*std::sin(0.351119846105576*x_36 - 7.42143964767456) + 23.4131177545448*std::sin(0.366719841957092*x_36 + 1.95679974555969) - 70475.4400149163*std::sin(0.370879858732224*x_36 - 7.42600011825562) + 63.5906127923905*std::sin(0.37271985411644*x_36 - 7.41264009475708) - 0.370837419093178*std::sin(0.384159833192825*x_36 - 1.19167983531952) + 151.875108775303*std::sin(0.36847984790802*x_41 - 7.41703987121582) + 2246.10047961308*std::sin(0.39727982878685*x_46 - 7.39071989059448) + 0.0945579179788294*std::sin(0.357199847698212*x_47 + 5.14815998077393) - 7875.6470860439*std::sin(0.331759840250015*x_51 - 4.25544023513794) + 97816.6816922663*std::sin(0.246239975094795*x_52 - 7.53248023986816) + 11308.1550651369*std::sin(0.404719859361649*x_52 + 5.20879983901978) + 1.70079215003049*std::sin(0.434639871120453*x_52 - 4.17999982833862) + 14.7938117847476*std::sin(0.31063985824585*x_55 + 5.11191987991333) + 0.431133691438443*std::sin(0.332079827785492*x_55 + 5.14311981201172) + 3.99499105216149*std::sin(0.445359855890274*x_58 - 7.3699197769165) - 8.03412877751095*std::sin(0.438239872455597*x_59 - 4.15751981735229) - 8.25912970599327*std::sin(0.269919961690903*x_64 - 4.29559993743896) - 71.8212319380227*std::sin(0.324319839477539*x_65 + 5.12215995788574) - 0.129145212521892*std::sin(0.4651198387146*x_67 + 8.45736026763916) + 155.253276743636*std::sin(0.249279975891113*x_68 - 4.33143997192383) + 12.9390173124391*std::sin(0.304399847984314*x_70 - 1.28231990337372) + 5291.91860878822*std::sin(0.292719930410385*x_75 - 7.47431993484497) - 98.5713801613387*std::sin(0.27839994430542*x_8 - 4.29239988327026) + 0.274202094711998*std::sin(0.349999845027924*x_92 + 2.00279974937439) - 97.9979694312654*std::sin(0.359759837388992*x_92 + 2.00303983688354) + 117.769222212263*std::sin(0.365439832210541*x_92 + 2.000079870224) - 264193.183007922*std::sin(0.383919835090637*x_94 - 7.39567947387695) + 3866.18802036179*std::sin(0.392479836940765*x_94 - 7.40143966674805) - 27.1268672456096*std::sin(0.306479930877686*x_95 - 4.30711984634399) + 3216.18996418485*std::sin(0.404239863157272*x_96 + 5.18688011169434) + 3.28185556454746*std::sin(0.488079845905304*x_96 + 5.24823999404907) - 16.7747775717683*std::sin(0.502879858016968*x_96 - 7.33160018920898) + 1459.76265794147*std::sin(0.44447985291481*x_98 - 7.3746395111084) + 14.4390661935684*std::sin(0.484719842672348*x_98 + 2.04863977432251) - 6.11886739333591*std::sin(0.62095981836319*x_98 - 7.40104007720947) + 3.58359278828617*std::sin(0.482239842414856*x_99 + 2.05831980705261) + 54559.1707634593*std::sin(0.53303986787796*x_99 + 8.38224029541016) - 2594595.66160605 - 0.00202156640385088*std::exp(-2.41559982299805*x_86) - 0.0470431211890568*std::exp(-2.41311979293823*x_86) - 3.94489951436436*std::exp(-4.34423971176147*x_111) - 0.00144675077019928*std::exp(-4.29680013656616*x_111));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-424.887065687052*x_1 + 1646.86667271496*x_10 + 45.3464908810266*x_100 + 87393.1558097907*x_101 - 25.1035989132164*x_102 + 1061.68750579616*x_103 - 1855.69650978398*x_104 - 2550.60846364944*x_105 + 3346.77456619014*x_106 - 148.152707201669*x_107 + 1337.13910989469*x_108 + 7230.43561893973*x_109 - 422.884002394152*x_11 - 155.265216703331*x_110 - 1259.6403464081*x_111 - 186.85107666869*x_112 + 29579.1955560626*x_113 - 725.758403970603*x_114 - 2828.23520726627*x_115 + 1951.87846158621*x_116 + 1615.97934285739*x_117 + 1050.05929950694*x_118 + 3932.73506262608*x_119 + 3111.16738247008*x_12 + 393.062590571091*x_120 - 567.212643143432*x_13 - 755.291878556233*x_14 - 2508.3117402548*x_15 + 1001.19048612794*x_16 + 551.834100471122*x_17 - 271.325543625623*x_18 - 154.728232665361*x_19 - 601.776361584135*x_2 + 2198.80099828106*x_20 - 1633.49607195432*x_21 - 39.3723429679491*x_22 - 4057.60963543496*x_23 + 513.147536978043*x_24 + 543.096863003975*x_25 + 1950.86312571093*x_26 + 330.520508643213*x_27 - 153.237250111091*x_28 + 173.908902273575*x_29 - 633.755893357992*x_3 - 2488.65966106701*x_30 + 54033.4777724063*x_31 - 2266.29115295054*x_32 + 5880.42714595193*x_33 + 429.158502545262*x_34 - 609.244710575429*x_35 - 210.272444335234*x_36 - 10854.074880059*x_37 + 1449.29204158503*x_38 - 43767.4481683759*x_39 - 2530.8327118505*x_4 + 4581.80974971722*x_40 + 4511.60798610358*x_41 - 9776.80726797185*x_42 + 3117.93543839984*x_43 + 1268.55312043462*x_44 + 2675.69896201799*x_45 + 833.798559531677*x_46 + 2729.66041114753*x_47 - 54745.3989058158*x_48 + 42450.4356999137*x_49 - 58.3266046797638*x_5 + 466.16535707983*x_51 + 105.941890985582*x_52 + 4140.59773632011*x_53 + 566.466839979641*x_54 - 196.669066228739*x_55 + 7676.44599391036*x_56 + 1677.3853109453*x_57 - 2558.58849297284*x_58 + 4000.83932186031*x_59 + 111.503841901777*x_6 + 4610.08943636274*x_60 + 1424.07169298864*x_61 + 4577.2422958674*x_62 - 958.002527221375*x_63 + 5630.82931391193*x_64 + 582.640678106187*x_65 + 157.706365377105*x_66 + 30.2876517354008*x_67 - 1278.9991420127*x_68 + 779.229048468486*x_69 + 585.244732629961*x_7 - 306.632699495753*x_70 - 12.4000649213157*x_71 + 11675.0139355602*x_72 + 106.077382691592*x_73 + 3102.39098024038*x_74 - 2057.47994360398*x_75 + 66.4072933725448*x_76 + 1944.29096022525*x_77 - 35.4098079628058*x_78 - 1224.65386106337*x_79 + 75358.0112160376*x_8 + 1967.04786422773*x_80 - 1727.91451880112*x_81 - 3684.2967868328*x_82 + 3778.82319256762*x_83 + 1215.62789258066*x_84 - 137.681474972559*x_85 + 6870.24341516288*x_86 - 688.669262270053*x_87 + 463.854591990669*x_88 + 2541.38760261332*x_89 - 297513.651987442*x_9 + 1752.91689486217*x_90 + 3524.33182170506*x_91 + 3964.07101432951*x_92 - 163172.434466288*x_93 + 771.427909115725*x_94 - 1568.07144987882*x_95 + 4103.14631841424*x_96 - 2556.85499171393*x_97 + 745.577753353525*x_98 + 3980.45555959004*x_99 + 0.629816588532225*std::pow(-9.98124027252197*x_110 - 9.80000019073486, 2) + 18.6466572315247*std::pow(-4.5798397064209*x_22 - 7.37175989151001, 2) + 24.8542616151037*std::pow(-7.55879974365234*x_24 - 8.38191986083984, 2) - 0.0956881093576466*std::pow(-6.16311979293823*x_27 - 8.35552024841309, 2) + 29.0402578139125*std::pow(-7.410719871521*x_67 - 9.21880054473877, 2) + 0.00101419426390973*std::pow(-2.03479981422424*x_7 - 3.25959992408752, 2) - 1.68193058117953e-5*std::pow(-7.58656024932861*x_71 - 9.77288055419922, 2) - 8.51416964217654*std::pow(-5.86728000640869*x_73 - 7.48176002502441, 2) + 2.06581847796305*std::pow(-5.56799983978271*x_88 - 7.39811992645264, 2) + 71.4775280657877*std::exp(0.941519796848297*x_1) - 0.00061731243334818*std::exp(1.05287981033325*x_1) - 0.0676068956218442*std::exp(1.08055984973907*x_1) + 15.7722247888059*std::exp(1.14351987838745*x_1) - 1.75837158554185*std::exp(1.17575979232788*x_1) - 6.15572095046625e-5*std::exp(1.91935980319977*x_10) - 9.1713141982142*std::exp(0.718959867954254*x_108) + 15.6377844787001*std::exp(2.84631991386414*x_17) - 0.000103712246204322*std::exp(2.97367978096008*x_17) + 0.00249938795622357*std::exp(3.23551988601685*x_17) + 0.000233108965541473*std::exp(3.33439970016479*x_17) + 0.509141807467794*std::exp(3.69400000572205*x_17) + 44.9702047527545*std::exp(0.924879848957062*x_29) + 4654.83026868463*std::exp(1.05567979812622*x_29) - 0.0587890950550015*std::exp(1.32319986820221*x_29) + 0.534335578570175*std::exp(1.51199984550476*x_29) + 0.491530600353493*std::exp(1.89591979980469*x_29) - 3.02063697497589*std::exp(2.74616003036499*x_29) - 7.34124190393579e-5*std::exp(2.97727990150452*x_29) + 25.6800109165542*std::exp(0.801359891891479*x_38) - 386.994488268371*std::exp(0.83847987651825*x_38) + 0.433127267508269*std::exp(0.859919905662537*x_38) + 161.641919404196*std::exp(0.908879816532135*x_38) + 0.00371299080532979*std::exp(2.08367991447449*x_38) + 0.0701153914544844*std::exp(2.11967992782593*x_38) + 158.329647813001*std::exp(1.6879198551178*x_50) - 0.000830076930613331*std::exp(1.74383985996246*x_50) + 0.102285460829519*std::exp(1.81527996063232*x_50) + 9.21749798056242*std::exp(1.86807990074158*x_50) + 5088.64606360379*std::exp(1.90071976184845*x_50) + 1.87972261342028*std::exp(1.93159985542297*x_50) + 241.397933088601*std::exp(1.93415975570679*x_50) + 23.2592491692849*std::exp(1.94911980628967*x_50) + 0.00151618593783813*std::exp(1.96527981758118*x_50) + 0.0809312327663162*std::exp(1.98295974731445*x_50) + 75.694350189711*std::exp(0.994239807128906*x_6) - 194.581113476442*std::exp(1.77975988388062*x_71) - 1.94812070074831*std::exp(1.78367984294891*x_71) - 0.00139289503958949*std::exp(1.81471991539001*x_71) + 57.3299961318796*std::exp(1.83799982070923*x_71) + 4095.0857853968*std::exp(0.713119864463806*x_73) - 12.0482023695357*std::exp(0.727599859237671*x_78) - 0.541085789614348*std::exp(1.04399979114532*x_78) + 28.0341160306322*std::exp(1.13199985027313*x_78) + 28.4914197029811*std::exp(1.46615982055664*x_78) + 202.863476094197*std::exp(1.48823988437653*x_78) - 0.905114930939914*std::exp(1.54943978786469*x_78) + 23.1760552953645*std::exp(0.753439843654633*x_88) - 90.9655481186563*std::sin(0.459999859333038*x_1 - 4.27928018569946) - 2085.99072265946*std::sin(0.380079835653305*x_100 - 4.21152019500732) + 319.975014817585*std::sin(0.457999855279922*x_100 + 5.24911975860596) - 24133.0512812091*std::sin(0.479119867086411*x_100 + 8.45336055755615) - 11.656852227187*std::sin(0.761759877204895*x_100 + 5.39792013168335) + 6723.56492814364*std::sin(0.372159838676453*x_102 - 4.21256017684937) - 3077.08617325134*std::sin(0.382799834012985*x_102 + 1.98967981338501) - 728.879815315334*std::sin(0.396079838275909*x_105 + 5.19479990005493) + 23.4568437206645*std::sin(0.527279853820801*x_105 - 4.23031997680664) + 6.30241482568547*std::sin(0.530399858951569*x_108 - 7.23000001907349) + 16118.521454273*std::sin(0.502559840679169*x_110 - 7.3328800201416) - 0.0736472032590185*std::sin(0.498479843139648*x_111 + 2.05335974693298) + 3.62670080375086*std::sin(0.27567994594574*x_112 + 1.84967994689941) + 803.157466067316*std::sin(0.350959837436676*x_114 - 1.23111987113953) + 1523.57246174403*std::sin(0.430639863014221*x_118 - 7.37128019332886) + 0.23914672797837*std::sin(0.330879837274551*x_120 - 1.24343991279602) + 10650.5265957598*std::sin(0.34911984205246*x_120 + 5.16007995605469) + 121.985977231381*std::sin(0.393999844789505*x_120 - 7.39271974563599) - 10545.1269039348*std::sin(0.397199839353561*x_120 + 5.19304037094116) - 3486.38871518606*std::sin(0.287039935588837*x_14 + 1.89999985694885) + 2.49938720562889*std::sin(0.421199858188629*x_16 + 2.00095963478088) + 549.680027212813*std::sin(0.754159867763519*x_2 - 0.799599885940552) - 0.160435554896845*std::sin(0.439279854297638*x_21 + 8.22023963928223) - 2696.2091993645*std::sin(0.442079842090607*x_21 + 8.21959972381592) + 59.8677122666988*std::sin(0.390879839658737*x_24 + 8.39072036743164) + 729.821630355805*std::sin(0.320799857378006*x_28 + 5.11976003646851) + 69.2401238896169*std::sin(0.331279844045639*x_28 + 5.14024019241333) - 30283.0328118813*std::sin(0.336159855127335*x_28 - 4.27024030685425) - 0.137281842216411*std::sin(0.337359845638275*x_28 + 5.132080078125) + 4.91151035550364*std::sin(0.347679853439331*x_28 + 5.14071989059448) - 3656.01337455949*std::sin(0.322559833526611*x_3 - 4.25808000564575) + 0.0186280477761879*std::sin(0.341759830713272*x_3 + 8.33720016479492) - 20991.771947066*std::sin(0.346719831228256*x_3 - 4.24839973449707) + 0.0618944130387619*std::sin(0.277759939432144*x_33 - 1.18871986865997) - 62561.7012342258*std::sin(0.345999836921692*x_34 + 2.00871968269348) - 4509.82011288321*std::sin(0.348639845848083*x_34 + 2.0033597946167) - 0.127666705908462*std::sin(0.35591983795166*x_34 - 7.40551996231079) - 5678.09769782002*std::sin(0.311519920825958*x_35 - 4.32943964004517) - 0.111094687103276*std::sin(0.261519968509674*x_36 + 1.84575986862183) + 3821.51709284473*std::sin(0.351119846105576*x_36 - 7.42143964767456) + 1.59513183098221*std::sin(0.366719841957092*x_36 + 1.95679974555969) + 19066.7791143798*std::sin(0.370879858732224*x_36 - 7.42600011825562) + 103.643485466318*std::sin(0.37271985411644*x_36 - 7.41264009475708) - 0.0448179045084529*std::sin(0.384159833192825*x_36 - 1.19167983531952) + 247.534422736875*std::sin(0.36847984790802*x_41 - 7.41703987121582) + 1713.77070342246*std::sin(0.39727982878685*x_46 - 7.39071989059448) + 0.0114278859691569*std::sin(0.357199847698212*x_47 + 5.14815998077393) - 6009.10483260373*std::sin(0.331759840250015*x_51 - 4.25544023513794) - 7341.86688306808*std::sin(0.246239975094795*x_52 - 7.53248023986816) - 3059.36500392883*std::sin(0.404719859361649*x_52 + 5.20879983901978) + 0.115874687209126*std::sin(0.434639871120453*x_52 - 4.17999982833862) + 13.4849606319782*std::sin(0.31063985824585*x_55 + 5.11191987991333) + 0.0521050671221771*std::sin(0.332079827785492*x_55 + 5.14311981201172) + 20.0580560792525*std::sin(0.445359855890274*x_58 - 7.3699197769165) - 7.32332625650113*std::sin(0.438239872455597*x_59 - 4.15751981735229) - 7.52842070456427*std::sin(0.269919961690903*x_64 - 4.29559993743896) + 646.705920578886*std::sin(0.324319839477539*x_65 + 5.12215995788574) - 0.0156079659293381*std::sin(0.4651198387146*x_67 + 8.45736026763916) - 1397.96005373486*std::sin(0.249279975891113*x_68 - 4.33143997192383) + 0.881533104351092*std::sin(0.304399847984314*x_70 - 1.28231990337372) + 4037.72456261604*std::sin(0.292719930410385*x_75 - 7.47431993484497) + 887.574515638765*std::sin(0.27839994430542*x_8 - 4.29239988327026) + 0.0331389516378126*std::sin(0.349999845027924*x_92 + 2.00279974937439) - 159.722491645707*std::sin(0.359759837388992*x_92 + 2.00303983688354) - 1060.43924911179*std::sin(0.365439832210541*x_92 + 2.000079870224) + 71476.1491786473*std::sin(0.383919835090637*x_94 - 7.39567947387695) + 2949.89463889001*std::sin(0.392479836940765*x_94 - 7.40143966674805) + 244.260717633357*std::sin(0.306479930877686*x_95 - 4.30711984634399) + 2453.94726873965*std::sin(0.404239863157272*x_96 + 5.18688011169434) + 16.4775445296889*std::sin(0.488079845905304*x_96 + 5.24823999404907) - 1.14286281489274*std::sin(0.502879858016968*x_96 - 7.33160018920898) + 1113.79633272735*std::sin(0.44447985291481*x_98 - 7.3746395111084) + 0.983731185930982*std::sin(0.484719842672348*x_98 + 2.04863977432251) - 9.97286731332496*std::sin(0.62095981836319*x_98 - 7.40104007720947) + 17.9925071606251*std::sin(0.482239842414856*x_99 + 2.05831980705261) - 4095.07010528214*std::sin(0.53303986787796*x_99 + 8.38224029541016) - 270216.027430194 - 0.000244318306029739*std::exp(-2.41559982299805*x_86) - 0.00320504004738336*std::exp(-2.41311979293823*x_86) + 0.296093944309634*std::exp(-4.34423971176147*x_111) - 9.85668901184652e-5*std::exp(-4.29680013656616*x_111));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-109.403387231045*x_1 - 4500.89611265717*x_10 - 518.98108106956*x_100 - 232088.921472211*x_101 + 487.545737625514*x_102 - 5636.56953741254*x_103 + 17878.1435880704*x_104 + 11958.1716272511*x_105 - 9626.10279098718*x_106 - 2119.03755320473*x_107 - 3481.67521085224*x_108 - 15087.4770730961*x_109 - 5028.98920799147*x_11 + 971.723271716528*x_110 + 4999.4263222521*x_111 + 1340.60310812422*x_112 - 144990.9634735*x_113 + 2809.06429739741*x_114 + 10430.1215325168*x_115 - 1936.72226787035*x_116 - 4769.93659986923*x_117 - 2457.93640472604*x_118 - 15778.7288389025*x_119 - 3622.53236292253*x_12 + 57.8710666052169*x_120 + 1568.42980153099*x_13 + 6325.58483943472*x_14 + 11477.8392141053*x_15 - 3590.74375320893*x_16 - 1299.68307009224*x_17 - 7.98710283647173*x_18 + 2443.40326781591*x_19 + 1571.96977117979*x_2 - 7089.25033792385*x_20 + 5413.13857375519*x_21 + 1941.72341907047*x_22 + 14444.6138591963*x_23 - 2663.88375604621*x_24 - 25.6679833993368*x_25 - 5202.93806213072*x_26 - 2673.23774928013*x_27 + 1834.71987925855*x_28 + 50.5368403690476*x_29 + 6435.22870907158*x_3 + 8912.45084942786*x_30 - 89739.3098013543*x_31 + 6648.79903125792*x_32 - 21356.9116291248*x_33 - 1779.74739621571*x_34 + 2573.68480403005*x_35 + 1732.83793771196*x_36 + 35091.0817875335*x_37 - 4292.9223159131*x_38 + 123370.830287071*x_39 + 21781.5830776164*x_4 - 9406.62087464762*x_40 - 11209.9705598436*x_41 - 11349.4629597498*x_42 - 6430.39763667129*x_43 + 5872.93972688397*x_44 - 3305.57041500406*x_45 + 834.992197651879*x_46 - 10604.5778230188*x_47 + 159241.689160319*x_48 - 120312.329217143*x_49 + 1267.23328510949*x_5 - 3340.60641629712*x_51 + 28.9226216964854*x_52 - 13272.1616236359*x_53 - 2720.30118444623*x_54 + 3379.46472837299*x_55 - 21404.6733976066*x_56 - 1552.1338924515*x_57 + 7250.97910710199*x_58 - 10116.5360325262*x_59 + 711.55051091405*x_6 - 7832.99011397502*x_60 - 1642.29073428217*x_61 - 43260.2504293903*x_62 + 8384.99479177888*x_63 - 14972.8943573838*x_64 - 3622.93324281556*x_65 - 83.2878532130459*x_66 - 193.895962562518*x_67 + 6498.73355442488*x_68 - 7796.11512570293*x_69 - 10914.7016363681*x_7 - 2037.34059087924*x_70 + 23.1266103779009*x_71 - 24692.4095621705*x_72 + 27.4034836904985*x_73 - 10011.1824429073*x_74 + 9011.75709841868*x_75 - 5013.19410940536*x_76 - 6985.16826499892*x_77 - 10.4866659510492*x_78 + 2289.67356575847*x_79 - 166184.740033946*x_8 - 1610.82652511141*x_80 + 7896.0691487071*x_81 + 19452.9183209494*x_82 - 6525.07044318303*x_83 - 9369.1055212282*x_84 - 923.747474675197*x_85 - 20094.0150688848*x_86 + 1623.74092810368*x_87 + 1882.71024008447*x_88 - 7304.67354909706*x_89 + 2786467.80616939*x_9 - 24082.6278966306*x_90 - 17842.6660795632*x_91 - 14131.463088355*x_92 + 513842.586328112*x_93 - 1839.3765366835*x_94 - 451.789090581751*x_95 - 16367.0724532779*x_96 + 16634.7265700633*x_97 - 1236.61702197369*x_98 - 10331.5159693417*x_99 + 0.183759842955994*std::pow(-9.98124027252197*x_110 - 9.80000019073486, 2) - 55.6478251838455*std::pow(-4.5798397064209*x_22 - 7.37175989151001, 2) - 74.1733806900549*std::pow(-7.55879974365234*x_24 - 8.38191986083984, 2) - 0.0394841975486703*std::pow(-6.16311979293823*x_27 - 8.35552024841309, 2) - 86.6657851891165*std::pow(-7.410719871521*x_67 - 9.21880054473877, 2) + 0.00133418269453716*std::pow(-2.03479981422424*x_7 - 3.25959992408752, 2) - 0.000317128207602568*std::pow(-7.58656024932861*x_71 - 9.77288055419922, 2) + 80.7020415857592*std::pow(-5.86728000640869*x_73 - 7.48176002502441, 2) + 0.602738139957167*std::pow(-5.56799983978271*x_88 - 7.39811992645264, 2) - 677.503818321602*std::exp(0.941519796848297*x_1) - 0.0116394331436198*std::exp(1.05287981033325*x_1) - 1.22430483572507*std::exp(1.08055984973907*x_1) - 47.069563027304*std::exp(1.14351987838745*x_1) + 0.864849567639944*std::exp(1.17575979232788*x_1) - 0.00116066190446095*std::exp(1.91935980319977*x_10) - 16.508746879391*std::exp(0.718959867954254*x_108) - 148.223630294801*std::exp(2.84631991386414*x_17) - 0.00195549561398351*std::exp(2.97367978096008*x_17) + 0.045261843973336*std::exp(3.23551988601685*x_17) + 0.000306657174896599*std::exp(3.33439970016479*x_17) - 0.250419806414383*std::exp(3.69400000572205*x_17) - 22.1184546297787*std::exp(0.924879848957062*x_29) - 13891.561250684*std::exp(1.05567979812622*x_29) - 1.06462177713842*std::exp(1.32319986820221*x_29) - 0.454186245067958*std::exp(1.51199984550476*x_29) + 0.20282239304191*std::exp(1.89591979980469*x_29) + 28.631279504042*std::exp(2.74616003036499*x_29) - 9.65747712561895e-5*std::exp(2.97727990150452*x_29) - 12.63063309302*std::exp(0.801359891891479*x_38) + 3668.14928504406*std::exp(0.83847987651825*x_38) - 0.368158990633805*std::exp(0.859919905662537*x_38) + 47.1618154644726*std::exp(0.908879816532135*x_38) + 0.0672391855321221*std::exp(2.08367991447449*x_38) + 0.126210619858262*std::exp(2.11967992782593*x_38) + 46.1954031493508*std::exp(1.6879198551178*x_50) - 0.00109197450169902*std::exp(1.74383985996246*x_50) - 0.0869428337591103*std::exp(1.81527996063232*x_50) + 3.80345597391524*std::exp(1.86807990074158*x_50) - 15186.2118262755*std::exp(1.90071976184845*x_50) + 3.38357885879267*std::exp(1.93159985542297*x_50) - 2288.1040493166*std::exp(1.93415975570679*x_50) - 11.4399889949809*std::exp(1.94911980628967*x_50) + 0.0285877035734509*std::exp(1.96527981758118*x_50) + 1.46559753595575*std::exp(1.98295974731445*x_50) + 22.0851310632089*std::exp(0.994239807128906*x_6) + 580.694740744674*std::exp(1.77975988388062*x_71) - 0.803861452727653*std::exp(1.78367984294891*x_71) - 0.00183236735136215*std::exp(1.81471991539001*x_71) - 543.40563159881*std::exp(1.83799982070923*x_71) - 12221.0975977692*std::exp(0.713119864463806*x_73) - 4.97150174309605*std::exp(0.727599859237671*x_78) + 0.459923937129888*std::exp(1.04399979114532*x_78) - 13.7884923343942*std::exp(1.13199985027313*x_78) - 85.027869777677*std::exp(1.46615982055664*x_78) - 1922.85300528736*std::exp(1.48823988437653*x_78) - 1.62924450833382*std::exp(1.54943978786469*x_78) + 9.56323572305959*std::exp(0.753439843654633*x_88) - 37.5355067223207*std::sin(0.459999859333038*x_1 - 4.27928018569946) - 608.623739963545*std::sin(0.380079835653305*x_100 - 4.21152019500732) - 157.378710788993*std::sin(0.457999855279922*x_100 + 5.24911975860596) + 72021.0492516084*std::sin(0.479119867086411*x_100 + 8.45336055755615) - 20.9828186746198*std::sin(0.761759877204895*x_100 + 5.39792013168335) - 63729.6928813472*std::sin(0.372159838676453*x_102 - 4.21256017684937) - 897.792916627498*std::sin(0.382799834012985*x_102 + 1.98967981338501) + 358.497258668279*std::sin(0.396079838275909*x_105 + 5.19479990005493) + 42.2232939799712*std::sin(0.527279853820801*x_105 - 4.23031997680664) - 5.35706443542161*std::sin(0.530399858951569*x_108 - 7.23000001907349) - 48103.02742054*std::sin(0.502559840679169*x_110 - 7.3328800201416) - 0.0968836322446298*std::sin(0.498479843139648*x_111 + 2.05335974693298) - 3.0827024927823*std::sin(0.27567994594574*x_112 + 1.84967994689941) - 395.030488997048*std::sin(0.350959837436676*x_114 - 1.23111987113953) + 444.528520524726*std::sin(0.430639863014221*x_118 - 7.37128019332886) + 0.314599911750562*std::sin(0.330879837274551*x_120 - 1.24343991279602) - 31784.7126569545*std::sin(0.34911984205246*x_120 + 5.16007995605469) + 50.3356002695079*std::sin(0.393999844789505*x_120 - 7.39271974563599) + 99952.5855948179*std::sin(0.397199839353561*x_120 + 5.19304037094116) - 1017.2139865023*std::sin(0.287039935588837*x_14 + 1.89999985694885) - 2.12448381770333*std::sin(0.421199858188629*x_16 + 2.00095963478088) + 160.378620245734*std::sin(0.754159867763519*x_2 - 0.799599885940552) - 0.211054576572609*std::sin(0.439279854297638*x_21 + 8.22023963928223) + 25556.1723662575*std::sin(0.442079842090607*x_21 + 8.21959972381592) + 24.7034724982409*std::sin(0.390879839658737*x_24 + 8.39072036743164) + 212.93803723496*std::sin(0.320799857378006*x_28 + 5.11976003646851) + 124.635101849845*std::sin(0.331279844045639*x_28 + 5.14024019241333) + 90374.6390051718*std::sin(0.336159855127335*x_28 - 4.27024030685425) - 0.180595636040414*std::sin(0.337359845638275*x_28 + 5.132080078125) - 4.17479302416622*std::sin(0.347679853439331*x_28 + 5.14071989059448) - 1066.70490391457*std::sin(0.322559833526611*x_3 - 4.25808000564575) + 0.351232058475005*std::sin(0.341759830713272*x_3 + 8.33720016479492) + 62646.4272445876*std::sin(0.346719831228256*x_3 - 4.24839973449707) + 0.0814227192002748*std::sin(0.277759939432144*x_33 - 1.18871986865997) + 186704.918219891*std::sin(0.345999836921692*x_34 + 2.00871968269348) - 1315.8177329602*std::sin(0.348639845848083*x_34 + 2.0033597946167) - 0.167946828090911*std::sin(0.35591983795166*x_34 - 7.40551996231079) + 53820.1722300113*std::sin(0.311519920825958*x_35 - 4.32943964004517) - 0.146146171658297*std::sin(0.261519968509674*x_36 + 1.84575986862183) + 1114.99346575065*std::sin(0.351119846105576*x_36 - 7.42143964767456) + 28.8865151450544*std::sin(0.366719841957092*x_36 + 1.95679974555969) - 56901.6085726183*std::sin(0.370879858732224*x_36 - 7.42600011825562) + 42.766858727341*std::sin(0.37271985411644*x_36 - 7.41264009475708) - 0.845042113170997*std::sin(0.384159833192825*x_36 - 1.19167983531952) + 102.141197198373*std::sin(0.36847984790802*x_41 - 7.41703987121582) + 500.022135106691*std::sin(0.39727982878685*x_46 - 7.39071989059448) + 0.215472923474862*std::sin(0.357199847698212*x_47 + 5.14815998077393) - 1753.25988621347*std::sin(0.331759840250015*x_51 - 4.25544023513794) + 69590.3031552708*std::sin(0.246239975094795*x_52 - 7.53248023986816) + 9130.16240918401*std::sin(0.404719859361649*x_52 + 5.20879983901978) + 2.09839452889219*std::sin(0.434639871120453*x_52 - 4.17999982833862) - 11.4622418569177*std::sin(0.31063985824585*x_55 + 5.11191987991333) + 0.98244164939788*std::sin(0.332079827785492*x_55 + 5.14311981201172) + 36.1053349114879*std::sin(0.445359855890274*x_58 - 7.3699197769165) + 6.22484106850655*std::sin(0.438239872455597*x_59 - 4.15751981735229) + 6.39917173445125*std::sin(0.269919961690903*x_64 - 4.29559993743896) - 318.080285419586*std::sin(0.324319839477539*x_65 + 5.12215995788574) - 0.294288379965226*std::sin(0.4651198387146*x_67 + 8.45736026763916) + 687.582282375166*std::sin(0.249279975891113*x_68 - 4.33143997192383) + 15.9638337566273*std::sin(0.304399847984314*x_70 - 1.28231990337372) + 1178.07572083014*std::sin(0.292719930410385*x_75 - 7.47431993484497) - 436.550750939184*std::sin(0.27839994430542*x_8 - 4.29239988327026) + 0.624835320335134*std::sin(0.349999845027924*x_92 + 2.00279974937439) - 65.9069810809359*std::sin(0.359759837388992*x_92 + 2.00303983688354) + 521.573729718878*std::sin(0.365439832210541*x_92 + 2.000079870224) - 213308.594935897*std::sin(0.383919835090637*x_94 - 7.39567947387695) + 860.682594662116*std::sin(0.392479836940765*x_94 - 7.40143966674805) - 120.138870403512*std::sin(0.306479930877686*x_95 - 4.30711984634399) + 715.981403057021*std::sin(0.404239863157272*x_96 + 5.18688011169434) + 29.6602652526608*std::sin(0.488079845905304*x_96 + 5.24823999404907) - 20.6962981804397*std::sin(0.502879858016968*x_96 - 7.33160018920898) + 324.969273457726*std::sin(0.44447985291481*x_98 - 7.3746395111084) + 17.8145562950493*std::sin(0.484719842672348*x_98 + 2.04863977432251) - 4.11514728182402*std::sin(0.62095981836319*x_98 - 7.40104007720947) + 32.3872609770829*std::sin(0.482239842414856*x_99 + 2.05831980705261) + 38815.3550871222*std::sin(0.53303986787796*x_99 + 8.38224029541016) - 1639097.00848605 - 0.00460662451486971*std::exp(-2.41559982299805*x_86) - 0.0580406183808876*std::exp(-2.41311979293823*x_86) - 2.80654330500971*std::exp(-4.34423971176147*x_111) - 0.00178496467119883*std::exp(-4.29680013656616*x_111));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-594.859488762173*x_1 + 1782.66285468378*x_10 - 612.017191037541*x_100 + 183861.053329221*x_101 + 22.439967226871*x_102 - 4094.41409867188*x_103 + 20029.1933788982*x_104 + 5584.31892471432*x_105 + 2225.55357182815*x_106 - 5243.06327329748*x_107 - 691.393077130278*x_108 + 17025.7678431865*x_109 - 12578.9248214407*x_11 + 1081.27597184293*x_110 - 775.386093911228*x_111 + 487.545949572938*x_112 - 85003.4126935151*x_113 + 694.571590573242*x_114 + 728.092155305002*x_115 + 10656.0598178237*x_116 - 158.797249461467*x_117 + 1997.33417209515*x_118 - 5283.33409770356*x_119 + 7791.75965139399*x_12 + 529.153393715424*x_120 - 1240.03924039703*x_13 + 7043.17817618658*x_14 + 5737.06807466638*x_15 - 640.967890802945*x_16 + 508.70922436474*x_17 - 2078.81291071216*x_18 + 3479.73734783634*x_19 - 910.222780393273*x_2 + 191.592158849139*x_20 - 1209.93290388547*x_21 + 2496.68322219535*x_22 + 2470.27265037661*x_23 - 2885.39346975768*x_24 + 3400.14793339812*x_25 + 3208.73245887343*x_26 - 3219.76911136866*x_27 + 2247.06846383422*x_28 + 245.058118524528*x_29 + 7714.1058188782*x_3 - 568.7626202845*x_30 + 172502.288045846*x_31 - 5424.95132323964*x_32 - 4721.02448897838*x_33 - 1725.52738418351*x_34 - 366.462026563327*x_35 + 2012.87681477748*x_36 - 4643.73475214757*x_37 + 1172.24363236182*x_38 - 52570.1945955181*x_39 + 19923.2212421587*x_4 + 8062.35787145036*x_40 + 7678.38817579499*x_41 - 12576.6983171712*x_42 + 7634.94542617274*x_43 + 19114.4580565627*x_44 + 9554.17967075488*x_45 + 6800.47527614972*x_46 - 1811.89667764703*x_47 - 50739.2657871116*x_48 + 42473.2379518386*x_49 + 1865.36941991281*x_5 - 3531.49244550993*x_51 + 147.03076929309*x_52 + 715.90775929974*x_53 - 1597.09068387286*x_54 + 5124.29324691393*x_55 + 8115.31701745245*x_56 + 6497.1413584032*x_57 - 2744.00286040728*x_58 + 4462.33204496427*x_59 + 1918.00710326644*x_6 + 13279.0961666955*x_60 + 5527.11069560126*x_61 - 52954.4859340189*x_62 + 7688.98420669226*x_63 + 7636.4637573482*x_64 - 3344.96362872781*x_65 - 270.743501644241*x_66 - 192.08155750709*x_67 + 1272.49687319755*x_68 - 9502.36818148018*x_69 - 15972.94870777*x_7 - 6700.09474774164*x_70 + 1.49923901153694*x_71 + 18030.3127404991*x_72 + 146.874854955255*x_73 + 739.211454029255*x_74 + 3765.14819512779*x_75 - 9433.01782429951*x_76 - 528.360912338276*x_77 - 49.7915018131776*x_78 - 2599.21521617001*x_79 + 169141.059001579*x_8 + 8719.46152002018*x_80 + 4527.21362625114*x_81 + 11838.5374717685*x_82 + 6802.06689264776*x_83 - 10907.4378099277*x_84 - 2889.70378971397*x_85 + 5933.38814389732*x_86 + 588.936925192137*x_87 + 6675.3144075231*x_88 + 2235.2685947702*x_89 + 3252489.63536054*x_9 - 33563.5600569876*x_90 - 12670.1466402581*x_91 - 540.433292159287*x_92 - 76606.8432441935*x_93 - 1375.55385066994*x_94 - 10792.9727955934*x_95 - 4392.77799345614*x_96 + 14964.6153347312*x_97 + 2272.87607768158*x_98 + 3490.22710544724*x_99 + 0.887593213049343*std::pow(-9.98124027252197*x_110 - 9.80000019073486, 2) + 15.0184830285565*std::pow(-4.5798397064209*x_22 - 7.37175989151001, 2) + 20.0182424988575*std::pow(-7.55879974365234*x_24 - 8.38191986083984, 2) - 0.126854832846448*std::pow(-6.16311979293823*x_27 - 8.35552024841309, 2) + 23.3897482914951*std::pow(-7.410719871521*x_67 - 9.21880054473877, 2) + 0.000417847883998921*std::pow(-2.03479981422424*x_7 - 3.25959992408752, 2) + 0.00022177440975791*std::pow(-7.58656024932861*x_71 - 9.77288055419922, 2) + 95.8568343805663*std::pow(-5.86728000640869*x_73 - 7.48176002502441, 2) + 2.91133401980585*std::pow(-5.56799983978271*x_88 - 7.39811992645264, 2) - 804.730215356969*std::exp(0.941519796848297*x_1) + 0.00813969982316401*std::exp(1.05287981033325*x_1) + 0.771596655093157*std::exp(1.08055984973907*x_1) + 12.7033434128231*std::exp(1.14351987838745*x_1) - 1.76641946995944*std::exp(1.17575979232788*x_1) + 0.00081167522352002*std::exp(1.91935980319977*x_10) - 18.4522010662436*std::exp(0.718959867954254*x_108) - 176.058098423154*std::exp(2.84631991386414*x_17) + 0.00136751911428475*std::exp(2.97367978096008*x_17) - 0.0285254835185645*std::exp(3.23551988601685*x_17) + 9.60408586982028e-5*std::exp(3.33439970016479*x_17) + 0.511472096726536*std::exp(3.69400000572205*x_17) + 45.176028716848*std::exp(0.924879848957062*x_29) + 3749.11645143888*std::exp(1.05567979812622*x_29) + 0.670959207387955*std::exp(1.32319986820221*x_29) - 0.851567870580064*std::exp(1.51199984550476*x_29) + 0.651627799580659*std::exp(1.89591979980469*x_29) + 34.007861060196*std::exp(2.74616003036499*x_29) - 3.02459055887227e-5*std::exp(2.97727990150452*x_29) + 25.7975456637022*std::exp(0.801359891891479*x_38) + 4356.97996717977*std::exp(0.83847987651825*x_38) - 0.690272704410115*std::exp(0.859919905662537*x_38) + 227.80008215057*std::exp(0.908879816532135*x_38) - 0.0423763176734066*std::exp(2.08367991447449*x_38) + 0.141068474266037*std::exp(2.11967992782593*x_38) + 223.132136215751*std::exp(1.6879198551178*x_50) - 0.000341991570407828*std::exp(1.74383985996246*x_50) - 0.163011814229125*std::exp(1.81527996063232*x_50) + 12.2197436383278*std::exp(1.86807990074158*x_50) + 4098.52251777114*std::exp(1.90071976184845*x_50) + 3.78190288348746*std::exp(1.93159985542297*x_50) - 2717.78020222413*std::exp(1.93415975570679*x_50) + 23.3657043409298*std::exp(1.94911980628967*x_50) - 0.0199919809539037*std::exp(1.96527981758118*x_50) - 0.923667148456946*std::exp(1.98295974731445*x_50) + 106.675169752424*std::exp(0.994239807128906*x_6) - 156.720484220785*std::exp(1.77975988388062*x_71) - 2.5826461356286*std::exp(1.78367984294891*x_71) - 0.000573872546548802*std::exp(1.81471991539001*x_71) - 645.450134917354*std::exp(1.83799982070923*x_71) + 3298.28427716723*std::exp(0.713119864463806*x_73) - 15.972441173178*std::exp(0.727599859237671*x_78) + 0.862325647294527*std::exp(1.04399979114532*x_78) + 28.1624252727851*std::exp(1.13199985027313*x_78) + 22.9477003816685*std::exp(1.46615982055664*x_78) - 2283.93976712641*std::exp(1.48823988437653*x_78) - 1.8210435639654*std::exp(1.54943978786469*x_78) + 30.7247644484739*std::exp(0.753439843654633*x_88) - 120.594078813362*std::sin(0.459999859333038*x_1 - 4.27928018569946) - 2939.76253028099*std::sin(0.380079835653305*x_100 - 4.21152019500732) + 321.439507281489*std::sin(0.457999855279922*x_100 + 5.24911975860596) - 19437.361699413*std::sin(0.479119867086411*x_100 + 8.45336055755615) - 23.4529726543907*std::sin(0.761759877204895*x_100 + 5.39792013168335) - 75697.2995430346*std::sin(0.372159838676453*x_102 - 4.21256017684937) - 4336.50185319963*std::sin(0.382799834012985*x_102 + 1.98967981338501) - 732.215822650875*std::sin(0.396079838275909*x_105 + 5.19479990005493) + 47.1939339726725*std::sin(0.527279853820801*x_105 - 4.23031997680664) - 10.0441261781267*std::sin(0.530399858951569*x_108 - 7.23000001907349) + 12982.2593884098*std::sin(0.502559840679169*x_110 - 7.3328800201416) - 0.0303426366518657*std::sin(0.498479843139648*x_111 + 2.05335974693298) - 5.77985446700986*std::sin(0.27567994594574*x_112 + 1.84967994689941) + 806.833434508335*std::sin(0.350959837436676*x_114 - 1.23111987113953) + 2147.15299859665*std::sin(0.430639863014221*x_118 - 7.37128019332886) + 0.0985284159129517*std::sin(0.330879837274551*x_120 - 1.24343991279602) + 8578.19988524172*std::sin(0.34911984205246*x_120 + 5.16007995605469) + 161.718220322021*std::sin(0.393999844789505*x_120 - 7.39271974563599) + 118722.3799424*std::sin(0.397199839353561*x_120 + 5.19304037094116) - 4913.32717809581*std::sin(0.287039935588837*x_14 + 1.89999985694885) - 3.98326056847612*std::sin(0.421199858188629*x_16 + 2.00095963478088) + 774.65768667652*std::sin(0.754159867763519*x_2 - 0.799599885940552) - 0.066099424456818*std::sin(0.439279854297638*x_21 + 8.22023963928223) + 30355.2888350452*std::sin(0.442079842090607*x_21 + 8.21959972381592) + 79.3673182955876*std::sin(0.390879839658737*x_24 + 8.39072036743164) + 1028.5291585445*std::sin(0.320799857378006*x_28 + 5.11976003646851) + 139.307482030394*std::sin(0.331279844045639*x_28 + 5.14024019241333) - 24390.7102861068*std::sin(0.336159855127335*x_28 - 4.27024030685425) - 0.0565600983192968*std::sin(0.337359845638275*x_28 + 5.132080078125) - 7.82744885893626*std::sin(0.347679853439331*x_28 + 5.14071989059448) - 5152.37724309416*std::sin(0.322559833526611*x_3 - 4.25808000564575) - 0.24562394826123*std::sin(0.341759830713272*x_3 + 8.33720016479492) - 16907.2969386352*std::sin(0.346719831228256*x_3 - 4.24839973449707) + 0.0255004888510234*std::sin(0.277759939432144*x_33 - 1.18871986865997) - 50388.7552904307*std::sin(0.345999836921692*x_34 + 2.00871968269348) - 6355.63717620903*std::sin(0.348639845848083*x_34 + 2.0033597946167) - 0.0525986636084067*std::sin(0.35591983795166*x_34 - 7.40551996231079) + 63926.8999199163*std::sin(0.311519920825958*x_35 - 4.32943964004517) - 0.0457709943563217*std::sin(0.261519968509674*x_36 + 1.84575986862183) + 5385.61971361523*std::sin(0.351119846105576*x_36 - 7.42143964767456) - 18.2052196584045*std::sin(0.366719841957092*x_36 + 1.95679974555969) + 15356.859676405*std::sin(0.370879858732224*x_36 - 7.42600011825562) + 137.401366927545*std::sin(0.37271985411644*x_36 - 7.41264009475708) + 0.590955680940055*std::sin(0.384159833192825*x_36 - 1.19167983531952) + 328.159246021502*std::sin(0.36847984790802*x_41 - 7.41703987121582) + 2415.19717450685*std::sin(0.39727982878685*x_46 - 7.39071989059448) - 0.150684736572963*std::sin(0.357199847698212*x_47 + 5.14815998077393) - 8468.56174168264*std::sin(0.331759840250015*x_51 - 4.25544023513794) + 82658.4561303752*std::sin(0.246239975094795*x_52 - 7.53248023986816) - 2464.08891519629*std::sin(0.404719859361649*x_52 + 5.20879983901978) - 1.32247635745072*std::sin(0.434639871120453*x_52 - 4.17999982833862) - 21.4909125852294*std::sin(0.31063985824585*x_55 + 5.11191987991333) - 0.687042059626102*std::sin(0.332079827785492*x_55 + 5.14311981201172) + 40.3557522698789*std::sin(0.445359855890274*x_58 - 7.3699197769165) + 11.6711474884368*std::sin(0.438239872455597*x_59 - 4.15751981735229) + 11.9980054582397*std::sin(0.269919961690903*x_64 - 4.29559993743896) + 649.66582651901*std::sin(0.324319839477539*x_65 + 5.12215995788574) + 0.205802039051638*std::sin(0.4651198387146*x_67 + 8.45736026763916) - 1404.35837194324*std::sin(0.249279975891113*x_68 - 4.33143997192383) - 10.0609263066269*std::sin(0.304399847984314*x_70 - 1.28231990337372) + 5690.31839299871*std::sin(0.292719930410385*x_75 - 7.47431993484497) + 891.636852162283*std::sin(0.27839994430542*x_8 - 4.29239988327026) - 0.436960450193951*std::sin(0.349999845027924*x_92 + 2.00279974937439) - 211.745953761132*std::sin(0.359759837388992*x_92 + 2.00303983688354) - 1065.29276959569*std::sin(0.365439832210541*x_92 + 2.000079870224) + 57568.6741091185*std::sin(0.383919835090637*x_94 - 7.39567947387695) + 4157.25229910398*std::sin(0.392479836940765*x_94 - 7.40143966674805) + 245.378673610031*std::sin(0.306479930877686*x_95 - 4.30711984634399) + 3458.31942278675*std::sin(0.404239863157272*x_96 + 5.18688011169434) + 33.1519516362229*std::sin(0.488079845905304*x_96 + 5.24823999404907) + 13.0434790281461*std::sin(0.502879858016968*x_96 - 7.33160018920898) + 1569.66025291896*std::sin(0.44447985291481*x_98 - 7.3746395111084) - 11.2273117348982*std::sin(0.484719842672348*x_98 + 2.04863977432251) - 13.22114549576*std::sin(0.62095981836319*x_98 - 7.40104007720947) + 36.1999766487476*std::sin(0.482239842414856*x_99 + 2.05831980705261) + 46104.3734569623*std::sin(0.53303986787796*x_99 + 8.38224029541016) - 4939878.19475694 + 0.00322150918231114*std::exp(-2.41559982299805*x_86) + 0.0365790820189882*std::exp(-2.41311979293823*x_86) - 3.33357560086406*std::exp(-4.34423971176147*x_111) + 0.00112494268548797*std::exp(-4.29680013656616*x_111));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-348.909160051542*x_1 - 1437.89452300376*x_10 + 619.432556961584*x_100 - 167888.534233475*x_101 + 39.3382119339474*x_102 + 4259.2486575841*x_103 - 19343.4353545246*x_104 - 5602.08391219804*x_105 - 1189.1889165804*x_106 + 5388.08672940681*x_107 + 1907.35170931498*x_108 - 15186.5594650676*x_109 + 12549.5068733726*x_11 - 1092.04352075324*x_110 + 1483.05269860159*x_111 - 204.047877897236*x_112 + 87669.2268321996*x_113 - 750.75187327625*x_114 - 854.02812215951*x_115 - 10680.4697203041*x_116 + 1030.878110869*x_117 - 1808.17922249324*x_118 + 6077.31997571563*x_119 - 5089.54410857842*x_12 + 252.770932966549*x_120 + 1377.23572985971*x_13 - 7007.05222168549*x_14 - 6005.61169316747*x_15 + 916.80322091885*x_16 - 188.467361986625*x_17 + 2136.61918207486*x_18 - 3413.10053865276*x_19 + 815.096436346523*x_2 + 287.193663211919*x_20 + 1358.30130507767*x_21 - 2155.0441608018*x_22 - 3345.3186140327*x_23 + 3242.75086573868*x_24 - 3285.95579169019*x_25 - 3072.29330068721*x_26 + 3342.8632858614*x_27 - 2189.19596783185*x_28 + 149.025986333782*x_29 - 7640.66524006467*x_3 + 730.87984160737*x_30 - 160463.991152246*x_31 + 5655.94163377581*x_32 + 6539.74302824657*x_33 + 1831.82814965615*x_34 + 719.788265497155*x_35 - 2005.30600900339*x_36 + 3352.18971916343*x_37 - 973.121725086756*x_38 + 46751.4781604933*x_39 - 18448.803920915*x_4 - 6133.1633868589*x_40 - 6842.75954710153*x_41 - 16274.937252597*x_42 - 6889.16896530759*x_43 - 18374.0260435111*x_44 - 8371.14067208772*x_45 - 6514.03661959355*x_46 + 1867.70953310038*x_47 + 41635.6612306576*x_48 - 34623.2618977128*x_49 - 1732.31723687295*x_5 + 3552.17049931886*x_51 + 133.155931874996*x_52 + 242.146279880416*x_53 + 1726.73672090037*x_54 - 5099.19469907977*x_55 - 6750.26316040021*x_56 - 5809.58366181789*x_57 + 2271.81141068059*x_58 - 3027.42225623801*x_59 - 1844.75046977286*x_6 - 11691.8265765617*x_60 - 5166.55903433382*x_61 + 52620.4637853553*x_62 - 7068.39583654033*x_63 - 6712.87453373887*x_64 + 3462.45180966681*x_65 + 549.77225364239*x_66 + 193.602331906503*x_67 - 419.288331954496*x_68 + 9323.21259688011*x_69 + 15375.3076520657*x_7 + 6758.69451354396*x_70 + 39.2682577982951*x_71 - 12949.9676955172*x_72 + 94.2818356431092*x_73 - 221.324871666189*x_74 - 3923.82694345594*x_75 + 9442.16527842696*x_76 + 765.96279639042*x_77 - 30.2984468349827*x_78 + 2094.76554155929*x_79 - 155605.111736496*x_8 - 7988.19776292992*x_80 - 4859.32064571075*x_81 - 11820.9637520081*x_82 - 4622.10565971225*x_83 + 11162.655457248*x_84 + 2883.80691811427*x_85 - 4765.04597371132*x_86 - 1260.2359986767*x_87 - 6472.49144004372*x_88 - 1754.86939259951*x_89 - 3199113.84082324*x_9 + 32873.188958299*x_90 + 12689.2311970708*x_91 + 823.066465040986*x_92 + 57094.4082185204*x_93 + 1417.71327705243*x_94 + 10344.8982598077*x_95 + 4805.96405324615*x_96 - 15023.4547338308*x_97 - 2085.31853552915*x_98 - 1918.62176524406*x_99 + 0.540159113892203*std::pow(-9.98124027252197*x_110 - 9.80000019073486, 2) - 12.2454381518025*std::pow(-4.5798397064209*x_22 - 7.37175989151001, 2) - 16.3220313237659*std::pow(-7.55879974365234*x_24 - 8.38191986083984, 2) + 0.277828425594399*std::pow(-6.16311979293823*x_27 - 8.35552024841309, 2) - 19.0710150649124*std::pow(-7.410719871521*x_67 - 9.21880054473877, 2) + 0.000314372519631113*std::pow(-2.03479981422424*x_7 - 3.25959992408752, 2) + 0.000110158578505344*std::pow(-7.58656024932861*x_71 - 9.77288055419922, 2) - 94.5667901420331*std::pow(-5.86728000640869*x_73 - 7.48176002502441, 2) + 1.7717391044259*std::pow(-5.56799983978271*x_88 - 7.39811992645264, 2) + 793.900131257036*std::exp(0.941519796848297*x_1) + 0.00404310742145023*std::exp(1.05287981033325*x_1) + 0.484248962556523*std::exp(1.08055984973907*x_1) - 10.357770873866*std::exp(1.14351987838745*x_1) + 0.65458716322417*std::exp(1.17575979232788*x_1) + 0.000403170902037691*std::exp(1.91935980319977*x_10) - 20.2529041802118*std::exp(0.718959867954254*x_108) + 173.688703095365*std::exp(2.84631991386414*x_17) + 0.000679266656026452*std::exp(2.97367978096008*x_17) - 0.0179024049794777*std::exp(3.23551988601685*x_17) + 7.22574120695266e-5*std::exp(3.33439970016479*x_17) - 0.189537691674237*std::exp(3.69400000572205*x_17) - 16.7410113998427*std::exp(0.924879848957062*x_29) - 3056.8715590454*std::exp(1.05567979812622*x_29) + 0.421089565319767*std::exp(1.32319986820221*x_29) + 1.85013948852796*std::exp(1.51199984550476*x_29) - 1.42714882491059*std::exp(1.89591979980469*x_29) - 33.5501822153953*std::exp(2.74616003036499*x_29) - 2.2755844680731e-5*std::exp(2.97727990150452*x_29) - 9.5598709827041*std::exp(0.801359891891479*x_38) - 4298.34359617517*std::exp(0.83847987651825*x_38) + 1.49970522891172*std::exp(0.859919905662537*x_38) + 138.631400860185*std::exp(0.908879816532135*x_38) - 0.026595096978272*std::exp(2.08367991447449*x_38) + 0.154834985913165*std::exp(2.11967992782593*x_38) + 135.790647345198*std::exp(1.6879198551178*x_50) - 0.00025730117537699*std::exp(1.74383985996246*x_50) + 0.354163895822479*std::exp(1.81527996063232*x_50) - 26.7628127366127*std::exp(1.86807990074158*x_50) - 3341.76254084435*std::exp(1.90071976184845*x_50) + 4.15096911437086*std::exp(1.93159985542297*x_50) + 2681.2042322984*std::exp(1.93415975570679*x_50) - 8.65869652218853*std::exp(1.94911980628967*x_50) - 0.00993030803595411*std::exp(1.96527981758118*x_50) - 0.579687399414421*std::exp(1.98295974731445*x_50) + 64.9188888790731*std::exp(0.994239807128906*x_6) + 127.783278310941*std::exp(1.77975988388062*x_71) + 5.65632773800342*std::exp(1.78367984294891*x_71) - 0.000431759416080078*std::exp(1.81471991539001*x_71) + 636.76364706084*std::exp(1.83799982070923*x_71) - 2689.28200313692*std::exp(0.713119864463806*x_73) + 34.981703766972*std::exp(0.727599859237671*x_78) - 1.87351212645362*std::exp(1.04399979114532*x_78) - 10.436231247637*std::exp(1.13199985027313*x_78) - 18.7105878280455*std::exp(1.46615982055664*x_78) + 2253.20243517947*std::exp(1.48823988437653*x_78) - 1.99875454839116*std::exp(1.54943978786469*x_78) - 67.2911921598681*std::exp(0.753439843654633*x_88) + 264.116567740695*std::sin(0.459999859333038*x_1 - 4.27928018569946) - 1789.0397313367*std::sin(0.380079835653305*x_100 - 4.21152019500732) - 119.116766316211*std::sin(0.457999855279922*x_100 + 5.24911975860596) + 15848.4055994073*std::sin(0.479119867086411*x_100 + 8.45336055755615) - 25.7416882790991*std::sin(0.761759877204895*x_100 + 5.39792013168335) + 74678.5629471617*std::sin(0.372159838676453*x_102 - 4.21256017684937) - 2639.04789263636*std::sin(0.382799834012985*x_102 + 1.98967981338501) + 271.339331550672*std::sin(0.396079838275909*x_105 + 5.19479990005493) + 51.7994692993207*std::sin(0.527279853820801*x_105 - 4.23031997680664) + 21.8221413840466*std::sin(0.530399858951569*x_108 - 7.23000001907349) - 10585.1872062681*std::sin(0.502559840679169*x_110 - 7.3328800201416) - 0.0228286213758188*std::sin(0.498479843139648*x_111 + 2.05335974693298) + 12.55746882521*std::sin(0.27567994594574*x_112 + 1.84967994689941) - 298.990595422588*std::sin(0.350959837436676*x_114 - 1.23111987113953) + 1306.68446317703*std::sin(0.430639863014221*x_118 - 7.37128019332886) + 0.0741289535066712*std::sin(0.330879837274551*x_120 - 1.24343991279602) - 6994.30268348638*std::sin(0.34911984205246*x_120 + 5.16007995605469) - 354.183735328246*std::sin(0.393999844789505*x_120 - 7.39271974563599) - 117124.610485278*std::sin(0.397199839353561*x_120 + 5.19304037094116) - 2990.0842139891*std::sin(0.287039935588837*x_14 + 1.89999985694885) + 8.65414011664629*std::sin(0.421199858188629*x_16 + 2.00095963478088) + 471.430384384554*std::sin(0.754159867763519*x_2 - 0.799599885940552) - 0.0497306398055375*std::sin(0.439279854297638*x_21 + 8.22023963928223) - 29946.7664200946*std::sin(0.442079842090607*x_21 + 8.21959972381592) - 173.824651303619*std::sin(0.390879839658737*x_24 + 8.39072036743164) + 625.927948438252*std::sin(0.320799857378006*x_28 + 5.11976003646851) + 152.902142948658*std::sin(0.331279844045639*x_28 + 5.14024019241333) + 19887.1572927271*std::sin(0.336159855127335*x_28 - 4.27024030685425) - 0.0425536213060416*std::sin(0.337359845638275*x_28 + 5.132080078125) + 17.0061280241661*std::sin(0.347679853439331*x_28 + 5.14071989059448) - 3135.56197270446*std::sin(0.322559833526611*x_3 - 4.25808000564575) - 0.122004991544622*std::sin(0.341759830713272*x_3 + 8.33720016479492) + 13785.497415588*std::sin(0.346719831228256*x_3 - 4.24839973449707) + 0.0191855774287995*std::sin(0.277759939432144*x_33 - 1.18871986865997) + 41084.8675783063*std::sin(0.345999836921692*x_34 + 2.00871968269348) - 3867.82514202321*std::sin(0.348639845848083*x_34 + 2.0033597946167) - 0.0395731916829496*std::sin(0.35591983795166*x_34 - 7.40551996231079) - 63066.5697258107*std::sin(0.311519920825958*x_35 - 4.32943964004517) - 0.0344363185092867*std::sin(0.261519968509674*x_36 + 1.84575986862183) + 3277.50542646957*std::sin(0.351119846105576*x_36 - 7.42143964767456) - 11.4254755700459*std::sin(0.366719841957092*x_36 + 1.95679974555969) - 12521.3362105722*std::sin(0.370879858732224*x_36 - 7.42600011825562) - 300.926693854904*std::sin(0.37271985411644*x_36 - 7.41264009475708) + 0.293536291419179*std::sin(0.384159833192825*x_36 - 1.19167983531952) - 718.711022833151*std::sin(0.36847984790802*x_41 - 7.41703987121582) + 1469.80705403845*std::sin(0.39727982878685*x_46 - 7.39071989059448) - 0.0748473027228419*std::sin(0.357199847698212*x_47 + 5.14815998077393) - 5153.67934215424*std::sin(0.331759840250015*x_51 - 4.25544023513794) - 81546.0360740891*std::sin(0.246239975094795*x_52 - 7.53248023986816) + 2009.11425968955*std::sin(0.404719859361649*x_52 + 5.20879983901978) - 0.829977423921985*std::sin(0.434639871120453*x_52 - 4.17999982833862) + 46.6917404849378*std::sin(0.31063985824585*x_55 + 5.11191987991333) - 0.341263794792249*std::sin(0.332079827785492*x_55 + 5.14311981201172) + 44.2939669315346*std::sin(0.445359855890274*x_58 - 7.3699197769165) - 25.3570520809834*std::sin(0.438239872455597*x_59 - 4.15751981735229) - 26.0671925852988*std::sin(0.269919961690903*x_64 - 4.29559993743896) - 240.748541134756*std::sin(0.324319839477539*x_65 + 5.12215995788574) + 0.102224869407509*std::sin(0.4651198387146*x_67 + 8.45736026763916) + 520.417136741334*std::sin(0.249279975891113*x_68 - 4.33143997192383) - 6.31417087435855*std::sin(0.304399847984314*x_70 - 1.28231990337372) + 3462.93470447685*std::sin(0.292719930410385*x_75 - 7.47431993484497) - 330.416442758321*std::sin(0.27839994430542*x_8 - 4.29239988327026) - 0.217044618037606*std::sin(0.349999845027924*x_92 + 2.00279974937439) + 463.750916219721*std::sin(0.359759837388992*x_92 + 2.00303983688354) + 394.768617484086*std::sin(0.365439832210541*x_92 + 2.000079870224) - 46939.070806557*std::sin(0.383919835090637*x_94 - 7.39567947387695) + 2529.96269585659*std::sin(0.392479836940765*x_94 - 7.40143966674805) - 90.9306835696212*std::sin(0.306479930877686*x_95 - 4.30711984634399) + 2104.61586175382*std::sin(0.404239863157272*x_96 + 5.18688011169434) + 36.3871658164259*std::sin(0.488079845905304*x_96 + 5.24823999404907) + 8.18600125572721*std::sin(0.502879858016968*x_96 - 7.33160018920898) + 955.241972181889*std::sin(0.44447985291481*x_98 - 7.3746395111084) - 7.04618666246905*std::sin(0.484719842672348*x_98 + 2.04863977432251) + 28.956011806722*std::sin(0.62095981836319*x_98 - 7.40104007720947) + 39.7326397951635*std::sin(0.482239842414856*x_99 + 2.05831980705261) - 45483.8993746115*std::sin(0.53303986787796*x_99 + 8.38224029541016) + 4963160.46395904 + 0.00160017051810754*std::exp(-2.41559982299805*x_86) + 0.0229567901857045*std::exp(-2.41311979293823*x_86) + 3.2887122374388*std::exp(-4.34423971176147*x_111) + 0.000706006596564795*std::exp(-4.29680013656616*x_111));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (442.128414008992*x_1 + 1802.6822578305*x_10 + 553.763715933184*x_100 + 62405.9714480529*x_101 - 305.699646756644*x_102 + 5030.75769608312*x_103 - 19381.6193302999*x_104 - 9470.53108160645*x_105 + 4595.23900934481*x_106 + 3426.86899987491*x_107 + 2260.38126113195*x_108 + 1269.95966916561*x_109 + 8543.45116582645*x_11 - 1013.3822115584*x_110 - 2712.8761026659*x_111 - 1014.81540629054*x_112 + 122529.732651824*x_113 - 1960.86868964873*x_114 - 6404.97388117563*x_115 - 3606.72159032742*x_116 + 2737.50353927549*x_117 + 573.440720390823*x_118 + 11526.5764680071*x_119 - 1510.67049756944*x_12 - 360.563114096411*x_120 - 452.061755875413*x_13 - 6781.36482488396*x_14 - 9198.14555997143*x_15 + 2353.84841821872*x_16 + 534.431626094807*x_17 + 884.463116618106*x_18 - 3057.65425533323*x_19 - 550.388637196701*x_2 + 4094.96625469273*x_20 - 2611.55267846178*x_21 - 2267.19220153982*x_22 - 9424.90012587757*x_23 + 2774.75206396823*x_24 - 1483.39941103837*x_25 + 1659.26659557833*x_26 + 3021.11037480093*x_27 - 2090.79139356114*x_28 - 168.012491767876*x_29 - 7150.66259772532*x_3 - 5003.14987342136*x_30 - 23885.8858997793*x_31 - 1761.19856780273*x_32 + 14833.0041574907*x_33 + 1742.83611122903*x_34 - 1426.4639588535*x_35 - 1891.07583430445*x_36 - 18391.9006241816*x_37 + 2013.24018000739*x_38 - 48827.2333556226*x_39 - 21713.6690292169*x_4 + 1761.64941865386*x_40 + 3120.9418649568*x_41 + 14405.6972707158*x_42 + 341.965412698292*x_43 - 11828.1862601684*x_44 - 2376.35678075279*x_45 - 3528.82292735455*x_46 + 6970.56376539862*x_47 - 70567.1189545891*x_48 + 51535.0185499968*x_49 - 1560.2596494682*x_5 + 3542.69235253146*x_51 - 136.860313536879*x_52 + 7484.80646426457*x_53 + 2210.51114328053*x_54 - 4226.42547253866*x_55 + 8886.43854956107*x_56 - 2041.4738571406*x_57 - 2965.11735585541*x_58 + 3825.92596457822*x_59 - 1255.95021216069*x_6 - 1340.46689197912*x_60 - 1481.0166908066*x_61 + 48600.4503164086*x_62 - 8368.94132791641*x_63 + 5351.38272082155*x_64 + 3581.18674213822*x_65 + 196.380624479236*x_66 + 135.693462026866*x_67 - 4426.8091194993*x_68 + 8661.83111407227*x_69 + 13417.3519639218*x_7 + 4025.63738986256*x_70 - 3.83226320394567*x_71 + 6991.99728601203*x_72 - 94.357409385709*x_73 + 5498.21876917099*x_74 - 6965.77065133891*x_75 + 7011.6005884236*x_76 + 4326.56914335864*x_77 + 34.1508471987089*x_78 - 247.598138281999*x_79 + 22811.8170812922*x_8 - 3003.49524497624*x_80 - 6539.75160566473*x_81 - 16609.5131329991*x_82 + 598.753745107221*x_83 + 10145.2105715481*x_84 + 1814.90507724164*x_85 + 9106.36189128854*x_86 - 1207.47713276617*x_87 - 4026.96424186989*x_88 + 3423.84020673053*x_89 - 3069045.79953182*x_9 + 28884.0631402818*x_90 + 15853.6040597459*x_91 + 8490.14421569877*x_92 - 266437.734725552*x_93 + 1941.94784909406*x_94 + 5045.45719784443*x_95 + 11507.49095905*x_96 - 16418.4330103553*x_97 - 278.29487446221*x_98 + 4409.44966909948*x_99 - 0.607261434606607*std::pow(-9.98124027252197*x_110 - 9.80000019073486, 2) + 25.8187519918028*std::pow(-4.5798397064209*x_22 - 7.37175989151001, 2) + 34.413997566001*std::pow(-7.55879974365234*x_24 - 8.38191986083984, 2) - 0.197911074244971*std::pow(-6.16311979293823*x_27 - 8.35552024841309, 2) + 40.2100604395629*std::pow(-7.410719871521*x_67 - 9.21880054473877, 2) + 0.000392220871332323*std::pow(-2.03479981422424*x_7 - 3.25959992408752, 2) + 7.75175943060701e-5*std::pow(-7.58656024932861*x_71 - 9.77288055419922, 2) - 89.5639804223542*std::pow(-5.86728000640869*x_73 - 7.48176002502441, 2) - 1.99183685442178*std::pow(-5.56799983978271*x_88 - 7.39811992645264, 2) + 751.900912639784*std::exp(0.941519796848297*x_1) + 0.00284509808572589*std::exp(1.05287981033325*x_1) + 0.157982970406137*std::exp(1.08055984973907*x_1) + 21.8387218215545*std::exp(1.14351987838745*x_1) + 1.19985809806864*std::exp(1.17575979232788*x_1) + 0.000283707713409299*std::exp(1.91935980319977*x_10) - 20.5105955719176*std::exp(0.718959867954254*x_108) + 164.500154655275*std::exp(2.84631991386414*x_17) + 0.000477993795689227*std::exp(2.97367978096008*x_17) - 0.00584053933980577*std::exp(3.23551988601685*x_17) + 9.01505804495373e-5*std::exp(3.33439970016479*x_17) - 0.347422539000644*std::exp(3.69400000572205*x_17) - 30.686269493925*std::exp(0.924879848957062*x_29) + 6445.22537090034*std::exp(1.05567979812622*x_29) + 0.137377641420308*std::exp(1.32319986820221*x_29) - 0.58870404287095*std::exp(1.51199984550476*x_29) + 1.01662944114238*std::exp(1.89591979980469*x_29) - 31.7752972115575*std::exp(2.74616003036499*x_29) - 2.83908951044841e-5*std::exp(2.97727990150452*x_29) - 17.5232409975641*std::exp(0.801359891891479*x_38) - 4070.95092387269*std::exp(0.83847987651825*x_38) - 0.477197820407308*std::exp(0.859919905662537*x_38) - 155.853157343338*std::exp(0.908879816532135*x_38) - 0.00867647169894819*std::exp(2.08367991447449*x_38) + 0.156805056113947*std::exp(2.11967992782593*x_38) - 152.659505675695*std::exp(1.6879198551178*x_50) - 0.000321016898422332*std::exp(1.74383985996246*x_50) - 0.112692971855602*std::exp(1.81527996063232*x_50) + 19.0644891975618*std::exp(1.86807990074158*x_50) + 7045.9004559879*std::exp(1.90071976184845*x_50) + 4.20378470064393*std::exp(1.93159985542297*x_50) + 2539.36210597012*std::exp(1.93415975570679*x_50) - 15.8713884483995*std::exp(1.94911980628967*x_50) - 0.00698786785477675*std::exp(1.96527981758118*x_50) - 0.18911911918822*std::exp(1.98295974731445*x_50) - 72.9835646198877*std::exp(0.994239807128906*x_6) - 269.4231705318*std::exp(1.77975988388062*x_71) - 4.02928496792537*std::exp(1.78367984294891*x_71) - 0.000538676391243019*std::exp(1.81471991539001*x_71) + 603.077324855449*std::exp(1.83799982070923*x_71) + 5670.18543675303*std::exp(0.713119864463806*x_73) - 24.9192160831953*std::exp(0.727599859237671*x_78) + 0.596141085604601*std::exp(1.04399979114532*x_78) - 19.1296091327503*std::exp(1.13199985027313*x_78) + 39.450121813897*std::exp(1.46615982055664*x_78) + 2134.00262913562*std::exp(1.48823988437653*x_78) - 2.02418605375307*std::exp(1.54943978786469*x_78) + 47.9348795901348*std::exp(0.753439843654633*x_88) - 188.143432536189*std::sin(0.459999859333038*x_1 - 4.27928018569946) + 2011.28668549423*std::sin(0.380079835653305*x_100 - 4.21152019500732) - 218.341001336304*std::sin(0.457999855279922*x_100 + 5.24911975860596) - 33415.3869027842*std::sin(0.479119867086411*x_100 + 8.45336055755615) - 26.0692171815456*std::sin(0.761759877204895*x_100 + 5.39792013168335) + 70727.8880854837*std::sin(0.372159838676453*x_102 - 4.21256017684937) + 2966.88877047759*std::sin(0.382799834012985*x_102 + 1.98967981338501) + 497.364923384713*std::sin(0.396079838275909*x_105 + 5.19479990005493) + 52.4585489658511*std::sin(0.527279853820801*x_105 - 4.23031997680664) - 6.94368340146673*std::sin(0.530399858951569*x_108 - 7.23000001907349) + 22318.2151489786*std::sin(0.502559840679169*x_110 - 7.3328800201416) - 0.0284816935584759*std::sin(0.498479843139648*x_111 + 2.05335974693298) - 3.9957163832598*std::sin(0.27567994594574*x_112 + 1.84967994689941) - 548.049682791137*std::sin(0.350959837436676*x_114 - 1.23111987113953) - 1469.00989223224*std::sin(0.430639863014221*x_118 - 7.37128019332886) + 0.0924855733874465*std::sin(0.330879837274551*x_120 - 1.24343991279602) + 14747.0563406466*std::sin(0.34911984205246*x_120 + 5.16007995605469) + 252.302777834705*std::sin(0.393999844789505*x_120 - 7.39271974563599) - 110928.438035422*std::sin(0.397199839353561*x_120 + 5.19304037094116) + 3361.53326433359*std::sin(0.287039935588837*x_14 + 1.89999985694885) - 2.75369900801096*std::sin(0.421199858188629*x_16 + 2.00095963478088) - 529.994744466425*std::sin(0.754159867763519*x_2 - 0.799599885940552) - 0.0620454831717783*std::sin(0.439279854297638*x_21 + 8.22023963928223) - 28362.5107432933*std::sin(0.442079842090607*x_21 + 8.21959972381592) + 123.823987398538*std::sin(0.390879839658737*x_24 + 8.39072036743164) - 703.685070108506*std::sin(0.320799857378006*x_28 + 5.11976003646851) + 154.847620281718*std::sin(0.331279844045639*x_28 + 5.14024019241333) - 41930.8460503972*std::sin(0.336159855127335*x_28 - 4.27024030685425) - 0.0530912130824474*std::sin(0.337359845638275*x_28 + 5.132080078125) - 5.41125487212488*std::sin(0.347679853439331*x_28 + 5.14071989059448) + 3525.08328170582*std::sin(0.322559833526611*x_3 - 4.25808000564575) - 0.0858538079030558*std::sin(0.341759830713272*x_3 + 8.33720016479492) - 29065.8720777838*std::sin(0.346719831228256*x_3 - 4.24839973449707) + 0.0239365193400726*std::sin(0.277759939432144*x_33 - 1.18871986865997) - 86624.9123527039*std::sin(0.345999836921692*x_34 + 2.00871968269348) + 4348.31327315391*std::sin(0.348639845848083*x_34 + 2.0033597946167) - 0.049372736973004*std::sin(0.35591983795166*x_34 - 7.40551996231079) - 59730.1971204043*std::sin(0.311519920825958*x_35 - 4.32943964004517) - 0.042963815243898*std::sin(0.261519968509674*x_36 + 1.84575986862183) - 3684.65993819378*std::sin(0.351119846105576*x_36 - 7.42143964767456) - 3.72748463792097*std::sin(0.366719841957092*x_36 + 1.95679974555969) + 26400.4660526709*std::sin(0.370879858732224*x_36 - 7.42600011825562) + 214.365125247329*std::sin(0.37271985411644*x_36 - 7.41264009475708) + 0.206558830561129*std::sin(0.384159833192825*x_36 - 1.19167983531952) + 511.97378488646*std::sin(0.36847984790802*x_41 - 7.41703987121582) - 1652.39670547968*std::sin(0.39727982878685*x_46 - 7.39071989059448) - 0.0526693692501795*std::sin(0.357199847698212*x_47 + 5.14815998077393) + 5793.90522223714*std::sin(0.331759840250015*x_51 - 4.25544023513794) - 77232.055433951*std::sin(0.246239975094795*x_52 - 7.53248023986816) - 4236.09364982039*std::sin(0.404719859361649*x_52 + 5.20879983901978) - 0.270774558006253*std::sin(0.434639871120453*x_52 - 4.17999982833862) - 14.8570508129818*std::sin(0.31063985824585*x_55 + 5.11191987991333) - 0.240144242554583*std::sin(0.332079827785492*x_55 + 5.14311981201172) + 44.8575490174022*std::sin(0.445359855890274*x_58 - 7.3699197769165) + 8.06847222489226*std::sin(0.438239872455597*x_59 - 4.15751981735229) + 8.29443496364202*std::sin(0.269919961690903*x_64 - 4.29559993743896) - 441.292012596073*std::sin(0.324319839477539*x_65 + 5.12215995788574) + 0.0719347150466166*std::sin(0.4651198387146*x_67 + 8.45736026763916) + 953.924474805112*std::sin(0.249279975891113*x_68 - 4.33143997192383) - 2.05995582337803*std::sin(0.304399847984314*x_70 - 1.28231990337372) - 3893.12453035698*std::sin(0.292719930410385*x_75 - 7.47431993484497) - 605.653252694225*std::sin(0.27839994430542*x_8 - 4.29239988327026) - 0.152732332566717*std::sin(0.349999845027924*x_92 + 2.00279974937439) - 330.352957278482*std::sin(0.359759837388992*x_92 + 2.00303983688354) + 723.610772045389*std::sin(0.365439832210541*x_92 + 2.000079870224) + 98968.1392251182*std::sin(0.383919835090637*x_94 - 7.39567947387695) - 2844.25225211265*std::sin(0.392479836940765*x_94 - 7.40143966674805) - 166.67591907323*std::sin(0.306479930877686*x_95 - 4.30711984634399) - 2366.06587695103*std::sin(0.404239863157272*x_96 + 5.18688011169434) + 36.8501443263736*std::sin(0.488079845905304*x_96 + 5.24823999404907) + 2.67062790862913*std::sin(0.502879858016968*x_96 - 7.33160018920898) - 1073.90877151687*std::sin(0.44447985291481*x_98 - 7.3746395111084) - 2.29877105589676*std::sin(0.484719842672348*x_98 + 2.04863977432251) - 20.6268145178372*std::sin(0.62095981836319*x_98 - 7.40104007720947) + 40.2381850322247*std::sin(0.482239842414856*x_99 + 2.05831980705261) - 43077.6921475454*std::sin(0.53303986787796*x_99 + 8.38224029541016) + 3128928.25268681 + 0.00112602550546871*std::exp(-2.41559982299805*x_86) + 0.00748949855334945*std::exp(-2.41311979293823*x_86) + 3.11473148244041*std::exp(-4.34423971176147*x_111) + 0.0002303299085305*std::exp(-4.29680013656616*x_111));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-504.726819397148*x_1 - 381.741823557363*x_10 + 2052.89115797332*x_100 - 306338.801583594*x_101 - 39.4888034481385*x_102 + 15937.2850656962*x_103 - 66509.1352531594*x_104 - 24606.7815188456*x_105 + 3858.83248139338*x_106 + 16002.6715790878*x_107 + 7367.51928194066*x_108 - 29898.4523461453*x_109 + 37632.4060658926*x_11 - 3809.72412174553*x_110 - 358.726158359277*x_111 - 1720.40677183337*x_112 + 350878.957048004*x_113 - 4289.80584923156*x_114 - 10502.304420206*x_115 - 27419.2085481631*x_116 + 6142.70511818851*x_117 - 2963.07928210866*x_118 + 28511.0034459168*x_119 - 12103.22870652*x_12 + 422.412649079314*x_120 + 2399.97687133466*x_13 - 23919.4019551126*x_14 - 25264.7072799661*x_15 + 5172.49518437624*x_16 + 349.80190325862*x_17 + 5733.71869983713*x_18 - 11085.6333402067*x_19 + 1003.04893347872*x_2 + 6228.05398647635*x_20 - 816.537960177521*x_21 - 7437.80600911836*x_22 - 20354.9522554082*x_23 + 10827.9201351332*x_24 - 8841.94854501945*x_25 - 4198.29235600533*x_26 + 11015.9633923865*x_27 - 7312.42690116058*x_28 + 194.075438853835*x_29 - 25589.3311913182*x_3 - 5177.0114140141*x_30 - 365474.857974518*x_31 + 10753.1924405304*x_32 + 33345.0041118261*x_33 + 6767.80801226437*x_34 - 172.762211092036*x_35 - 6835.74017619312*x_36 - 18222.9699385256*x_37 + 749.213560649484*x_38 + 30680.5643225008*x_39 - 67114.0648797469*x_4 - 9599.36095066076*x_40 - 9882.51987396156*x_41 - 22278.7180440878*x_42 - 13832.0133311974*x_43 - 54749.67202543*x_44 - 20546.0397001117*x_45 - 18322.1258130634*x_46 + 13510.6959539774*x_47 - 10238.1935713044*x_48 - 880.913850215229*x_49 - 5796.35416030622*x_5 + 12273.1582048337*x_51 + 168.297186212264*x_52 + 10716.3823371954*x_53 + 6738.71402999508*x_54 - 16392.4790020404*x_55 - 1499.19236988365*x_56 - 14459.0642104325*x_57 + 602.66146314178*x_58 - 668.32124302292*x_59 - 5534.88147475856*x_6 - 26165.7315406856*x_60 - 12613.9019715771*x_61 + 176720.111203885*x_62 - 25813.9958685704*x_63 - 6430.14839246005*x_64 + 12162.8479319699*x_65 + 1684.80397266335*x_66 + 711.815752649421*x_67 - 6644.48138528428*x_68 + 31498.9649990088*x_69 + 50462.4628789574*x_7 + 20003.800935187*x_70 + 2.78420659046714*x_71 - 16793.3923582636*x_72 + 115.65393808271*x_73 + 7214.03744825495*x_74 - 17719.8392030188*x_75 + 29406.0448568361*x_76 + 7475.17283984707*x_77 - 39.3877901109471*x_78 + 3984.89740054288*x_79 - 292343.995959174*x_8 - 20458.6945342835*x_80 - 19373.9808876553*x_81 - 47172.9406080727*x_82 - 7631.93303116321*x_83 + 37619.713839148*x_84 + 8545.02005740927*x_85 + 2661.30069642478*x_86 - 4569.16489523121*x_87 - 19102.9974699311*x_88 + 866.54771352038*x_89 - 10858360.4853265*x_9 + 108169.08133516*x_90 + 49470.9835421702*x_91 + 13360.7852455379*x_92 - 254377.750358096*x_93 + 6541.48475876963*x_94 + 28398.2428564089*x_95 + 25835.6681483948*x_96 - 53672.1469672905*x_97 - 4693.15527375557*x_98 + 2416.78468184743*x_99 + 0.70189597819541*std::pow(-9.98124027252197*x_110 - 9.80000019073486, 2) + 10.1521722681238*std::pow(-4.5798397064209*x_22 - 7.37175989151001, 2) + 13.5319023876816*std::pow(-7.55879974365234*x_24 - 8.38191986083984, 2) + 0.349271269538887*std::pow(-6.16311979293823*x_27 - 8.35552024841309, 2) + 15.8109679594009*std::pow(-7.410719871521*x_67 - 9.21880054473877, 2) - 0.000413583783697444*std::pow(-2.03479981422424*x_7 - 3.25959992408752, 2) - 0.000416009965417352*std::pow(-7.58656024932861*x_71 - 9.77288055419922, 2) - 319.637066393651*std::pow(-5.86728000640869*x_73 - 7.48176002502441, 2) + 2.30224117269315*std::pow(-5.56799983978271*x_88 - 7.39811992645264, 2) + 2683.39348923024*std::exp(0.941519796848297*x_1) - 0.015268651805402*std::exp(1.05287981033325*x_1) + 0.337540020627834*std::exp(1.08055984973907*x_1) + 8.5871875650088*std::exp(1.14351987838745*x_1) - 1.49063724514929*std::exp(1.17575979232788*x_1) - 0.00152256061479447*std::exp(1.91935980319977*x_10) + 17.3145532955688*std::exp(0.718959867954254*x_108) + 587.070233003965*std::exp(2.84631991386414*x_17) - 0.00256522643916483*std::exp(2.97367978096008*x_17) - 0.0124786599730824*std::exp(3.23551988601685*x_17) - 9.50607703210409e-5*std::exp(3.33439970016479*x_17) + 0.431618519950235*std::exp(3.69400000572205*x_17) + 38.1229216154493*std::exp(0.924879848957062*x_29) + 2534.32227448626*std::exp(1.05567979812622*x_29) + 0.293515508662778*std::exp(1.32319986820221*x_29) + 0.0962185254888899*std::exp(1.51199984550476*x_29) - 1.79413636610803*std::exp(1.89591979980469*x_29) - 113.400082673789*std::exp(2.74616003036499*x_29) + 2.99372488261109e-5*std::exp(2.97727990150452*x_29) + 21.7699040651069*std::exp(0.801359891891479*x_38) - 14528.4611581914*std::exp(0.83847987651825*x_38) + 0.0779938089471696*std::exp(0.859919905662537*x_38) + 180.141036618292*std::exp(0.908879816532135*x_38) - 0.0185377982747818*std::exp(2.08367991447449*x_38) - 0.132371070921845*std::exp(2.11967992782593*x_38) + 176.449691946078*std::exp(1.6879198551178*x_50) + 0.000338501577005152*std::exp(1.74383985996246*x_50) + 0.0184186803474763*std::exp(1.81527996063232*x_50) - 33.6447991631878*std::exp(1.86807990074158*x_50) + 2770.51327794432*std::exp(1.90071976184845*x_50) - 3.54873431086775*std::exp(1.93159985542297*x_50) + 9062.50760892833*std::exp(1.93415975570679*x_50) + 19.7177339482881*std::exp(1.94911980628967*x_50) + 0.0375014561614055*std::exp(1.96527981758118*x_50) - 0.404064255962552*std::exp(1.98295974731445*x_50) + 84.3571937253837*std::exp(0.994239807128906*x_6) - 105.939684502618*std::exp(1.77975988388062*x_71) + 7.11083743772366*std::exp(1.78367984294891*x_71) + 0.000568016228514285*std::exp(1.81471991539001*x_71) + 2152.26998639751*std::exp(1.83799982070923*x_71) + 2229.56939841243*std::exp(0.713119864463806*x_73) + 43.9771562581604*std::exp(0.727599859237671*x_78) - 0.0974340450602182*std::exp(1.04399979114532*x_78) + 23.7655668652196*std::exp(1.13199985027313*x_78) + 15.5121530576035*std::exp(1.46615982055664*x_78) + 7615.85557985096*std::exp(1.48823988437653*x_78) + 1.7087693619117*std::exp(1.54943978786469*x_78) - 84.594944034899*std::exp(0.753439843654633*x_88) + 332.033443747469*std::sin(0.459999859333038*x_1 - 4.27928018569946) - 2324.72203090075*std::sin(0.380079835653305*x_100 - 4.21152019500732) + 271.254766925335*std::sin(0.457999855279922*x_100 + 5.24911975860596) - 13139.23943151*std::sin(0.479119867086411*x_100 + 8.45336055755615) + 22.007008459649*std::sin(0.761759877204895*x_100 + 5.39792013168335) + 252414.581768855*std::sin(0.372159838676453*x_102 - 4.21256017684937) - 3429.24344784119*std::sin(0.382799834012985*x_102 + 1.98967981338501) - 617.898633531297*std::sin(0.396079838275909*x_105 + 5.19479990005493) - 44.2842499961846*std::sin(0.527279853820801*x_105 - 4.23031997680664) + 1.13488430467135*std::sin(0.530399858951569*x_108 - 7.23000001907349) + 8775.72877966439*std::sin(0.502559840679169*x_110 - 7.3328800201416) + 0.0300329927574021*std::sin(0.498479843139648*x_111 + 2.05335974693298) + 0.653064886040432*std::sin(0.27567994594574*x_112 + 1.84967994689941) + 680.866571368496*std::sin(0.350959837436676*x_114 - 1.23111987113953) + 1697.9377851568*std::sin(0.430639863014221*x_118 - 7.37128019332886) - 0.0975229422367957*std::sin(0.330879837274551*x_120 - 1.24343991279602) + 5798.67905565323*std::sin(0.34911984205246*x_120 + 5.16007995605469) - 445.261144979887*std::sin(0.393999844789505*x_120 - 7.39271974563599) - 395882.813002163*std::sin(0.397199839353561*x_120 + 5.19304037094116) - 3885.38863880648*std::sin(0.287039935588837*x_14 + 1.89999985694885) + 0.450068011931617*std::sin(0.421199858188629*x_16 + 2.00095963478088) + 612.588184274662*std::sin(0.754159867763519*x_2 - 0.799599885940552) + 0.0654248857393874*std::sin(0.439279854297638*x_21 + 8.22023963928223) - 101220.487151127*std::sin(0.442079842090607*x_21 + 8.21959972381592) - 218.523200094012*std::sin(0.390879839658737*x_24 + 8.39072036743164) + 813.346101823971*std::sin(0.320799857378006*x_28 + 5.11976003646851) - 130.718650497439*std::sin(0.331279844045639*x_28 + 5.14024019241333) - 16487.596789611*std::sin(0.336159855127335*x_28 - 4.27024030685425) + 0.0559829075723037*std::sin(0.337359845638275*x_28 + 5.132080078125) + 0.884422268108259*std::sin(0.347679853439331*x_28 + 5.14071989059448) - 4074.42600045242*std::sin(0.322559833526611*x_3 - 4.25808000564575) + 0.460747524177249*std::sin(0.341759830713272*x_3 + 8.33720016479492) - 11428.9699421024*std::sin(0.346719831228256*x_3 - 4.24839973449707) - 0.0252402586419894*std::sin(0.277759939432144*x_33 - 1.18871986865997) - 34061.7173593435*std::sin(0.345999836921692*x_34 + 2.00871968269348) - 5025.94669186859*std::sin(0.348639845848083*x_34 + 2.0033597946167) + 0.0520618989484941*std::sin(0.35591983795166*x_34 - 7.40551996231079) - 213165.883122312*std::sin(0.311519920825958*x_35 - 4.32943964004517) + 0.0453039054507473*std::sin(0.261519968509674*x_36 + 1.84575986862183) + 4258.8707997098*std::sin(0.351119846105576*x_36 - 7.42143964767456) - 7.96399281732269*std::sin(0.366719841957092*x_36 + 1.95679974555969) + 10380.9076213507*std::sin(0.370879858732224*x_36 - 7.42600011825562) - 378.309196317747*std::sin(0.37271985411644*x_36 - 7.41264009475708) - 1.10852939552144*std::sin(0.384159833192825*x_36 - 1.19167983531952) - 903.525659188658*std::sin(0.36847984790802*x_41 - 7.41703987121582) + 1909.90327372077*std::sin(0.39727982878685*x_46 - 7.39071989059448) + 0.282658184589781*std::sin(0.357199847698212*x_47 + 5.14815998077393) - 6696.81712320182*std::sin(0.331759840250015*x_51 - 4.25544023513794) - 275626.736485447*std::sin(0.246239975094795*x_52 - 7.53248023986816) - 1665.67123347154*std::sin(0.404719859361649*x_52 + 5.20879983901978) - 0.578525961753741*std::sin(0.434639871120453*x_52 - 4.17999982833862) + 2.42825497743692*std::sin(0.31063985824585*x_55 + 5.11191987991333) + 1.28877061955579*std::sin(0.332079827785492*x_55 + 5.14311981201172) - 37.867667979072*std::sin(0.445359855890274*x_58 - 7.3699197769165) - 1.3187211975668*std::sin(0.438239872455597*x_59 - 4.15751981735229) - 1.35565283036467*std::sin(0.269919961690903*x_64 - 4.29559993743896) + 548.236754847458*std::sin(0.324319839477539*x_65 + 5.12215995788574) - 0.386048594344815*std::sin(0.4651198387146*x_67 + 8.45736026763916) - 1185.10293299919*std::sin(0.249279975891113*x_68 - 4.33143997192383) - 4.40121824097844*std::sin(0.304399847984314*x_70 - 1.28231990337372) + 4499.82214372242*std::sin(0.292719930410385*x_75 - 7.47431993484497) + 752.430056158339*std::sin(0.27839994430542*x_8 - 4.29239988327026) + 0.819661303449608*std::sin(0.349999845027924*x_92 + 2.00279974937439) + 583.003236300775*std::sin(0.359759837388992*x_92 + 2.00303983688354) - 898.973944950931*std::sin(0.365439832210541*x_92 + 2.000079870224) + 38915.1884176297*std::sin(0.383919835090637*x_94 - 7.39567947387695) + 3287.49547223328*std::sin(0.392479836940765*x_94 - 7.40143966674805) + 207.068930267645*std::sin(0.306479930877686*x_95 - 4.30711984634399) + 2734.78938153412*std::sin(0.404239863157272*x_96 + 5.18688011169434) - 31.1080088167691*std::sin(0.488079845905304*x_96 + 5.24823999404907) + 5.70595550299217*std::sin(0.502879858016968*x_96 - 7.33160018920898) + 1241.26480741326*std::sin(0.44447985291481*x_98 - 7.3746395111084) - 4.91146120136451*std::sin(0.484719842672348*x_98 + 2.04863977432251) + 36.4019735665258*std::sin(0.62095981836319*x_98 - 7.40104007720947) - 33.9681115945419*std::sin(0.482239842414856*x_99 + 2.05831980705261) - 153736.212706482*std::sin(0.53303986787796*x_99 + 8.38224029541016) + 14528667.1859966 - 0.00604298721835348*std::exp(-2.41559982299805*x_86) + 0.016001759491487*std::exp(-2.41311979293823*x_86) + 11.1158931185992*std::exp(-4.34423971176147*x_111) + 0.000492113560573818*std::exp(-4.29680013656616*x_111));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (405.736929680935*x_1 + 746.650079678891*x_10 - 709.212286631156*x_100 + 134901.0532005*x_101 + 34.125228698674*x_102 - 5429.08599374309*x_103 + 23736.8049870187*x_104 + 7964.07147637683*x_105 - 210.469011043812*x_106 - 5752.46470661622*x_107 - 2628.17010978882*x_108 + 13702.237834409*x_109 - 14131.7902949073*x_11 + 1308.77128328705*x_110 - 735.167599237733*x_111 + 469.989201792344*x_112 - 117914.756078878*x_113 + 1334.72083477624*x_114 + 2576.30616092258*x_115 + 11224.0203755369*x_116 - 1797.2009793119*x_117 + 1491.6793475462*x_118 - 9071.66304292373*x_119 + 4806.47324008366*x_12 - 247.636104669955*x_120 - 1083.1614950451*x_13 + 8445.30638392395*x_14 + 8268.5712179334*x_15 - 1548.7890773311*x_16 + 17.4649295959618*x_17 - 2242.19704663954*x_18 + 4106.23338374955*x_19 - 588.768878780368*x_2 - 1542.51188897322*x_20 - 549.121636497277*x_21 + 2603.54692883258*x_22 + 5917.00881114335*x_23 - 3867.94287252283*x_24 + 3526.64597447449*x_25 + 2371.50903772517*x_26 - 3980.20054345421*x_27 + 2653.71869368055*x_28 - 154.953037841266*x_29 + 9097.81506727835*x_3 + 717.258769822991*x_30 + 156504.732569632*x_31 - 4752.96955867737*x_32 - 11012.3053040842*x_33 - 2251.569326591*x_34 - 298.591978852*x_35 + 2413.4479518188*x_36 + 2192.41964718675*x_37 + 273.244438568764*x_38 - 29572.3878429464*x_39 + 23333.3830816395*x_4 + 4934.27081440374*x_40 + 5405.72828928654*x_41 + 15723.3978389979*x_42 + 6209.0620574958*x_43 + 20649.8802677972*x_44 + 8417.51793604185*x_45 + 7099.11825766771*x_46 - 3766.90793157364*x_47 - 17623.322606983*x_48 + 16693.7582318145*x_49 + 2094.72841910604*x_5 - 4315.65103838801*x_51 - 91.9391946546335*x_52 - 2592.88889279377*x_53 - 2194.02109248898*x_54 + 5968.41346100227*x_55 + 3527.47658446393*x_56 + 5995.35215641797*x_57 - 1295.47863434995*x_58 + 1552.52298149976*x_59 + 2082.81796922117*x_6 + 11226.944282516*x_60 + 5190.07225970455*x_61 - 63199.1270449666*x_62 + 8926.90456675881*x_63 + 4706.33647484945*x_64 - 4292.11312913844*x_65 - 614.083431900116*x_66 - 164.579046225204*x_67 + 1487.54705485241*x_68 - 11132.2689619045*x_69 - 18195.0266651013*x_7 - 7489.60568864191*x_70 - 56.8257653099614*x_71 + 8664.05273983198*x_72 - 64.4412574915171*x_73 - 1436.0897697641*x_74 + 5731.88941112025*x_75 - 10704.4086192946*x_76 - 1991.97963014303*x_77 + 31.4169491522575*x_78 - 1799.171614641*x_79 + 137459.071816829*x_8 + 8281.93656866813*x_80 + 6390.63981566881*x_81 + 15790.3857061703*x_82 + 3767.18716770179*x_83 - 13355.3468353545*x_84 - 3241.46637371592*x_85 + 1779.58861679728*x_86 + 1703.34685376936*x_87 + 7189.0503964767*x_88 + 359.760362039954*x_89 + 3871385.38891366*x_9 - 39135.3913768981*x_90 - 16289.56400277*x_91 - 3233.99914176996*x_92 + 30759.1218636366*x_93 - 2436.82147409337*x_94 - 11048.4662457786*x_95 - 7861.98399501798*x_96 + 18797.8070555513*x_97 + 2045.26522664658*x_98 + 296.732158388311*x_99 - 0.560041211172424*std::pow(-9.98124027252197*x_110 - 9.80000019073486, 2) + 3.78290692303064*std::pow(-4.5798397064209*x_22 - 7.37175989151001, 2) + 5.04226345575948*std::pow(-7.55879974365234*x_24 - 8.38191986083984, 2) + 0.189731327874085*std::pow(-6.16311979293823*x_27 - 8.35552024841309, 2) + 5.89148987761285*std::pow(-7.410719871521*x_67 - 9.21880054473877, 2) + 0.00123790907747415*std::pow(-2.03479981422424*x_7 - 3.25959992408752, 2) - 9.86484534260936e-5*std::pow(-7.58656024932861*x_71 - 9.77288055419922, 2) + 114.141925990897*std::pow(-5.86728000640869*x_73 - 7.48176002502441, 2) - 1.83695301699982*std::pow(-5.56799983978271*x_88 - 7.39811992645264, 2) - 958.235865783356*std::exp(0.941519796848297*x_1) - 0.00362065578163099*std::exp(1.05287981033325*x_1) - 0.463567784558343*std::exp(1.08055984973907*x_1) + 3.19976163042767*std::exp(1.14351987838745*x_1) - 1.10463655281737*std::exp(1.17575979232788*x_1) - 0.000361044836380961*std::exp(1.91935980319977*x_10) - 17.2977920729487*std::exp(0.718959867954254*x_108) - 209.641916199016*std::exp(2.84631991386414*x_17) - 0.000608292209196152*std::exp(2.97367978096008*x_17) + 0.0171378337514436*std::exp(3.23551988601685*x_17) + 0.000284529024421779*std::exp(3.33439970016479*x_17) + 0.319850852755401*std::exp(3.69400000572205*x_17) + 28.2509865184532*std::exp(0.924879848957062*x_29) + 944.340287393153*std::exp(1.05567979812622*x_29) - 0.4031057823343*std::exp(1.32319986820221*x_29) - 0.757868696886047*std::exp(1.51199984550476*x_29) - 0.974611726805554*std::exp(1.89591979980469*x_29) + 40.4950026289264*std::exp(2.74616003036499*x_29) - 8.96060085942729e-5*std::exp(2.97727990150452*x_29) + 16.1325848122332*std::exp(0.801359891891479*x_38) + 5188.09209767183*std::exp(0.83847987651825*x_38) - 0.614321057734312*std::exp(0.859919905662537*x_38) - 143.734125089227*std::exp(0.908879816532135*x_38) + 0.0254592805346337*std::exp(2.08367991447449*x_38) + 0.132242930105833*std::exp(2.11967992782593*x_38) - 140.788809536349*std::exp(1.6879198551178*x_50) - 0.00101317844516974*std::exp(1.74383985996246*x_50) - 0.145075402084751*std::exp(1.81527996063232*x_50) - 18.2765459916473*std::exp(1.86807990074158*x_50) + 1032.34988361961*std::exp(1.90071976184845*x_50) + 3.54529898540548*std::exp(1.93159985542297*x_50) - 3236.20812961755*std::exp(1.93415975570679*x_50) + 14.6118243918061*std::exp(1.94911980628967*x_50) + 0.00889272123045828*std::exp(1.96527981758118*x_50) + 0.554930261624597*std::exp(1.98295974731445*x_50) - 67.308413800197*std::exp(0.994239807128906*x_6) - 39.4752921192006*std::exp(1.77975988388062*x_71) + 3.86275295742828*std::exp(1.78367984294891*x_71) - 0.00170014510516895*std::exp(1.81471991539001*x_71) - 768.572444590213*std::exp(1.83799982070923*x_71) + 830.783135852988*std::exp(0.713119864463806*x_73) + 23.8892945990163*std::exp(0.727599859237671*x_78) + 0.767442780763152*std::exp(1.04399979114532*x_78) + 17.6114704923516*std::exp(1.13199985027313*x_78) + 5.78014533667521*std::exp(1.46615982055664*x_78) - 2719.61081910985*std::exp(1.48823988437653*x_78) - 1.70711520062943*std::exp(1.54943978786469*x_78) - 45.9537112352962*std::exp(0.753439843654633*x_88) + 180.367386827959*std::sin(0.459999859333038*x_1 - 4.27928018569946) + 1854.89044284338*std::sin(0.380079835653305*x_100 - 4.21152019500732) + 201.01331269344*std::sin(0.457999855279922*x_100 + 5.24911975860596) - 4895.94921127181*std::sin(0.479119867086411*x_100 + 8.45336055755615) - 21.9857047412279*std::sin(0.761759877204895*x_100 + 5.39792013168335) - 90136.8756644806*std::sin(0.372159838676453*x_102 - 4.21256017684937) + 2736.18557962359*std::sin(0.382799834012985*x_102 + 1.98967981338501) - 457.89370871799*std::sin(0.396079838275909*x_105 + 5.19479990005493) + 44.2413809622523*std::sin(0.527279853820801*x_105 - 4.23031997680664) - 8.93895728216094*std::sin(0.530399858951569*x_108 - 7.23000001907349) + 3270.01594126484*std::sin(0.502559840679169*x_110 - 7.3328800201416) - 0.089892582406715*std::sin(0.498479843139648*x_111 + 2.05335974693298) - 5.14388920065758*std::sin(0.27567994594574*x_112 + 1.84967994689941) + 504.556091545769*std::sin(0.350959837436676*x_114 - 1.23111987113953) - 1354.78071286212*std::sin(0.430639863014221*x_118 - 7.37128019332886) + 0.291898619374381*std::sin(0.330879837274551*x_120 - 1.24343991279602) + 2160.70635571645*std::sin(0.34911984205246*x_120 + 5.16007995605469) - 241.874999908527*std::sin(0.393999844789505*x_120 - 7.39271974563599) + 141369.169891926*std::sin(0.397199839353561*x_120 + 5.19304037094116) + 3100.142794303*std::sin(0.287039935588837*x_14 + 1.89999985694885) - 3.54497697797388*std::sin(0.421199858188629*x_16 + 2.00095963478088) - 488.782724689704*std::sin(0.754159867763519*x_2 - 0.799599885940552) - 0.195825037494083*std::sin(0.439279854297638*x_21 + 8.22023963928223) + 36145.6869928147*std::sin(0.442079842090607*x_21 + 8.21959972381592) - 118.706290900675*std::sin(0.390879839658737*x_24 + 8.39072036743164) - 648.967012375517*std::sin(0.320799857378006*x_28 + 5.11976003646851) + 130.592109294545*std::sin(0.331279844045639*x_28 + 5.14024019241333) - 6143.61561174374*std::sin(0.336159855127335*x_28 - 4.27024030685425) - 0.16756399114006*std::sin(0.337359845638275*x_28 + 5.132080078125) - 6.96618399027122*std::sin(0.347679853439331*x_28 + 5.14071989059448) + 3250.97527698116*std::sin(0.322559833526611*x_3 - 4.25808000564575) + 0.109257071845355*std::sin(0.341759830713272*x_3 + 8.33720016479492) - 4258.66783730988*std::sin(0.346719831228256*x_3 - 4.24839973449707) + 0.0755473171877825*std::sin(0.277759939432144*x_33 - 1.18871986865997) - 12692.0921952388*std::sin(0.345999836921692*x_34 + 2.00871968269348) + 4010.1914814199*std::sin(0.348639845848083*x_34 + 2.0033597946167) - 0.155827911633086*std::sin(0.35591983795166*x_34 - 7.40551996231079) + 76121.2231411418*std::sin(0.311519920825958*x_35 - 4.32943964004517) - 0.13560037412767*std::sin(0.261519968509674*x_36 + 1.84575986862183) - 3398.14336453188*std::sin(0.351119846105576*x_36 - 7.42143964767456) + 10.9375193486624*std::sin(0.366719841957092*x_36 + 1.95679974555969) + 3868.13839156872*std::sin(0.370879858732224*x_36 - 7.42600011825562) - 205.505326158391*std::sin(0.37271985411644*x_36 - 7.41264009475708) - 0.262865603077188*std::sin(0.384159833192825*x_36 - 1.19167983531952) - 490.813697079902*std::sin(0.36847984790802*x_41 - 7.41703987121582) - 1523.90749607483*std::sin(0.39727982878685*x_46 - 7.39071989059448) + 0.0670267423282408*std::sin(0.357199847698212*x_47 + 5.14815998077393) + 5343.37521397512*std::sin(0.331759840250015*x_51 - 4.25544023513794) + 98425.9019518369*std::sin(0.246239975094795*x_52 - 7.53248023986816) - 620.663152099659*std::sin(0.404719859361649*x_52 + 5.20879983901978) + 0.794530965249196*std::sin(0.434639871120453*x_52 - 4.17999982833862) - 19.1262381761366*std::sin(0.31063985824585*x_55 + 5.11191987991333) + 0.305606209006608*std::sin(0.332079827785492*x_55 + 5.14311981201172) + 37.8310104689263*std::sin(0.445359855890274*x_58 - 7.3699197769165) + 10.3869552196719*std::sin(0.438239872455597*x_59 - 4.15751981735229) + 10.6778485614705*std::sin(0.269919961690903*x_64 - 4.29559993743896) + 406.2707818238*std::sin(0.324319839477539*x_65 + 5.12215995788574) - 0.0915437127599275*std::sin(0.4651198387146*x_67 + 8.45736026763916) - 878.220387221619*std::sin(0.249279975891113*x_68 - 4.33143997192383) + 6.04450691664117*std::sin(0.304399847984314*x_70 - 1.28231990337372) - 3590.39789615264*std::sin(0.292719930410385*x_75 - 7.47431993484497) + 557.588203418119*std::sin(0.27839994430542*x_8 - 4.29239988327026) + 0.19436630523358*std::sin(0.349999845027924*x_92 + 2.00279974937439) + 316.699333226776*std::sin(0.359759837388992*x_92 + 2.00303983688354) - 666.184534738211*std::sin(0.365439832210541*x_92 + 2.000079870224) + 14500.5947287082*std::sin(0.383919835090637*x_94 - 7.39567947387695) - 2623.08519095234*std::sin(0.392479836940765*x_94 - 7.40143966674805) + 153.448406089923*std::sin(0.306479930877686*x_95 - 4.30711984634399) - 2182.08225309057*std::sin(0.404239863157272*x_96 + 5.18688011169434) + 31.0778949436506*std::sin(0.488079845905304*x_96 + 5.24823999404907) - 7.83639565581175*std::sin(0.502879858016968*x_96 - 7.33160018920898) - 990.402378307816*std::sin(0.44447985291481*x_98 - 7.3746395111084) + 6.74525996599129*std::sin(0.484719842672348*x_98 + 2.04863977432251) + 19.7742997617081*std::sin(0.62095981836319*x_98 - 7.40104007720947) + 33.9352290205187*std::sin(0.482239842414856*x_99 + 2.05831980705261) + 54898.9752998578*std::sin(0.53303986787796*x_99 + 8.38224029541016) - 5528090.6273374 - 0.00143297370909413*std::exp(-2.41559982299805*x_86) - 0.0219763575966682*std::exp(-2.41311979293823*x_86) - 3.96946907309957*std::exp(-4.34423971176147*x_111) - 0.000675854651552128*std::exp(-4.29680013656616*x_111));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
