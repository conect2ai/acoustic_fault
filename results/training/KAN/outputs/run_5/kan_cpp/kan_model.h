
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00367054564369545*x_10 + 0.00401621691574128*x_100 - 0.0133653704070326*x_101 - 0.000542729473788159*x_102 - 0.00955703665506763*x_103 - 0.00148271182049068*x_104 + 0.000824649697947023*x_105 + 0.002614636805178*x_106 + 0.0112233547938465*x_107 + 0.000752075682092981*x_108 + 0.00238307915058248*x_109 + 0.00505955327908759*x_11 - 0.00612523228272521*x_110 - 0.00226082161307998*x_111 + 0.00183232107644955*x_112 + 0.0139773878957676*x_113 - 0.0162223986613765*x_114 + 0.000975085989251134*x_115 + 0.00308011037974517*x_116 + 0.0030397211619199*x_117 - 0.00411427032790964*x_118 + 0.00439214199219887*x_119 + 0.0206611459254804*x_12 - 0.0213262699332648*x_120 + 0.0162444653653804*x_13 + 0.00482472548357635*x_14 + 0.00135156786659456*x_15 + 0.00807109922217598*x_16 - 0.00282395961337393*x_17 + 0.00774989529433647*x_18 - 0.0144705901091221*x_19 + 0.00261485407545359*x_2 + 0.00923821239916073*x_20 - 0.00227284706251762*x_21 + 0.00529810794859381*x_22 + 0.0025781689328935*x_23 + 0.000290858858781084*x_24 - 0.00779907354996691*x_25 - 0.00623749084051372*x_26 - 0.0134916103422448*x_27 + 0.00122844032259866*x_28 + 0.00450737981504699*x_29 + 0.00396057197831242*x_3 - 0.0245014452706215*x_30 + 0.0589318508044619*x_32 + 0.00238224073333173*x_33 - 0.0127518468217254*x_34 - 0.00157389867987247*x_35 + 0.000477123245456553*x_36 + 0.00613873555538852*x_37 + 0.00185180657881118*x_38 + 0.010155295499388*x_39 + 0.000768336215375453*x_4 + 0.0113455531447964*x_40 + 0.0142228187319418*x_41 - 0.0220387087860941*x_42 - 0.0126205374889119*x_43 + 5.36851916093936e-5*x_44 + 0.00219590808752451*x_45 + 0.00223417155943942*x_46 + 0.0171976660017266*x_47 - 0.00183201256362179*x_48 - 0.000368244896219739*x_49 + 0.00870596541916648*x_5 + 0.00727246489678155*x_50 + 0.00617196678044969*x_51 + 0.00433254895899692*x_52 + 0.00880653803850286*x_53 + 0.00638163767529398*x_54 - 0.0104630211011238*x_55 + 0.00482229198122651*x_56 - 0.0145024662726837*x_57 - 0.0190928780358069*x_58 - 0.013806236951269*x_59 - 0.00375813526464415*x_6 + 0.00447029880082349*x_60 - 0.0171174280124767*x_61 + 0.00809064292472329*x_62 + 0.0151673251309146*x_63 - 0.00314514128529474*x_64 - 0.00228088779135677*x_65 - 0.000141455267173334*x_66 + 0.00803773799338273*x_67 + 0.00383656468730846*x_68 + 0.0055953591148246*x_69 + 0.0155329988616921*x_7 - 0.00719422721023142*x_71 + 0.00663348155719092*x_72 - 0.0014994067003449*x_73 + 0.000270308720566736*x_74 + 0.0011261989085096*x_75 - 0.00675827601093178*x_76 - 0.00955006765123625*x_77 - 0.00513975669038753*x_78 - 0.00642707167220852*x_79 + 0.0169718860701768*x_8 - 0.00195355245793964*x_80 + 5.98825611366877e-5*x_81 + 0.0197183893806103*x_82 + 0.000382798132855873*x_83 - 0.00413414154542217*x_84 + 0.00629920103113277*x_85 + 0.000195658792868302*x_86 + 0.00782851310630602*x_87 - 0.00752420280591885*x_88 + 0.00216944529259629*x_89 - 0.0216744340952586*x_9 + 0.00156549728021703*x_90 + 0.0399772654272425*x_91 + 0.000310547648456234*x_92 - 0.0571999966113371*x_93 + 0.0101681104799406*x_94 - 0.000900524224818267*x_95 + 0.00695628166259713*x_96 + 0.000433979850911221*x_97 - 0.00540397565012147*x_98 + 0.000311359616763883*x_99 + 1.74430902064055e-5*std::pow(-7.63032007217407*x_114 - 9.03103923797607, 2) - 1.32149365710386e-6*std::pow(-8.24623966217041*x_115 - 9.84912014007568, 2) - 2.69813415018012e-6*std::pow(-5.6736798286438*x_15 - 7.62943983078003, 2) - 1.88071441414282e-5*std::pow(-5.82647943496704*x_40 - 6.01991987228394, 2) + 2.31453528167677e-5*std::pow(-5.20471954345703*x_56 - 4.8187198638916, 2) - 1.01937595879761e-5*std::pow(-9.47784042358398*x_59 - 9.54600048065186, 2) + 1.73164299371841e-6*std::pow(-6.42759990692139*x_59 - 7.42335987091064, 2) - 2.29048259327699e-6*std::pow(-6.70647954940796*x_7 - 9.27136039733887, 2) - 1.73972021368524e-5*std::pow(-6.94496011734009*x_70 - 9.19479942321777, 2) - 2.98661783455575e-5*std::pow(-5.8473596572876*x_70 - 8.2651195526123, 2) + 3.17263523464931e-5*std::pow(-7.79071998596191*x_71 - 9.37960052490234, 2) + 4.00817634847106e-7*std::pow(-8.39999961853027*x_84 - 6.35200023651123, 2) + 0.000169465052472394*std::pow(-5.13184022903442*x_86 - 7.89423990249634, 2) - 5.19968651618711e-5*std::pow(-9.01288032531738*x_89 - 8.98544025421143, 2) - 1.87827499439509e-5*std::exp(0.783919870853424*x_1) + 8.52048191776138e-6*std::exp(1.17175984382629*x_1) + 0.000701844413998849*std::exp(1.17815983295441*x_1) - 2.88463815714004e-5*std::exp(1.26551985740662*x_1) - 0.000111956954417553*std::exp(1.30431985855103*x_1) + 5.68764580493507e-5*std::exp(1.37551987171173*x_100) + 0.000230018084252917*std::exp(1.68319988250732*x_100) + 0.00139632504143466*std::exp(1.04447984695435*x_104) - 0.00423063725418486*std::exp(0.591199815273285*x_108) + 0.000315390855370881*std::exp(0.572079837322235*x_109) + 0.00274687275547928*std::exp(0.707839846611023*x_109) + 0.0110326032405882*std::exp(0.873599886894226*x_109) - 0.000761210104143029*std::exp(1.00887978076935*x_109) - 0.000731846138840765*std::exp(1.26239991188049*x_110) + 0.000329446989941463*std::exp(0.642959833145142*x_112) - 0.00344481286595352*std::exp(0.843519866466522*x_112) + 0.00593605205596635*std::exp(0.757279872894287*x_114) - 0.00292952634472889*std::exp(0.615599870681763*x_26) + 0.0187497555728883*std::exp(0.734559834003448*x_26) - 1.07976417716599e-6*std::exp(1.43647980690002*x_26) - 0.0114536237365617*std::exp(0.60207986831665*x_31) + 0.0012661317277264*std::exp(0.623999834060669*x_31) + 0.0209087710118355*std::exp(0.63895982503891*x_31) + 0.000424812560781598*std::exp(0.642719864845276*x_31) + 0.00405097506076063*std::exp(0.659439861774445*x_31) - 9.64754433344421e-5*std::exp(1.0668797492981*x_50) + 5.6947748293621e-6*std::exp(2.77047991752625*x_6) + 0.00121022880818169*std::exp(1.22575986385345*x_66) + 0.000634956160905318*std::exp(1.55999982357025*x_66) + 0.000118281998116809*std::exp(1.14623987674713*x_68) + 0.00400471362538997*std::exp(1.21247982978821*x_68) - 0.00027058552521109*std::exp(0.705119848251343*x_70) + 0.000133034555764472*std::exp(0.99919980764389*x_72) - 0.000406114912367314*std::exp(0.636719882488251*x_74) + 0.00440733015902747*std::exp(1.1736798286438*x_74) - 0.0048013661898952*std::exp(1.25471985340118*x_74) + 5.5531422553922e-5*std::exp(1.5201598405838*x_74) - 3.86881505405361e-6*std::exp(1.60031986236572*x_77) - 0.0125157515772364*std::exp(0.726239860057831*x_81) + 0.000114822713697918*std::exp(1.06903982162476*x_81) - 5.13577731268943e-5*std::exp(1.76583993434906*x_81) + 0.00535045912843173*std::exp(0.691679835319519*x_90) - 0.010382891722446*std::sin(0.340159833431244*x_100 - 7.4347996711731) - 0.00561538022120796*std::sin(0.351999849081039*x_102 + 5.17088031768799) + 0.00144176541503587*std::sin(0.376479834318161*x_102 + 1.99015986919403) + 0.0336875325541281*std::sin(0.384479850530624*x_102 + 5.17479991912842) - 0.0192789464330448*std::sin(0.193599998950958*x_111 + 4.98087978363037) - 0.0261753722738986*std::sin(0.207520008087158*x_111 + 1.80207979679108) - 0.00101689408925545*std::sin(0.414799869060516*x_111 - 1.19263982772827) + 0.000215742118391862*std::sin(0.628399848937988*x_112 - 4.1780800819397) + 0.0125647527994777*std::sin(0.409599870443344*x_115 + 5.1956000328064) - 0.0600240105734196*std::sin(0.428799867630005*x_115 + 5.23239994049072) + 0.00441756506761734*std::sin(0.420559853315353*x_117 - 7.37207984924316) + 0.10136496723045*std::sin(0.296399921178818*x_120 + 5.10007953643799) + 0.000561203301532408*std::sin(0.621119856834412*x_120 - 3.98495984077454) + 0.100355644081271*std::sin(0.462159872055054*x_2 - 4.12944030761719) + 0.0765744364708791*std::sin(0.419599860906601*x_24 - 7.37135982513428) - 0.0333525992464203*std::sin(0.386959850788116*x_28 - 7.39767980575562) + 0.163134649805803*std::sin(0.283039927482605*x_3 + 1.88183987140656) - 0.00104968392200305*std::sin(0.310239940881729*x_35 + 8.27095985412598) - 0.126850888609541*std::sin(0.319999843835831*x_35 + 1.98159980773926) - 0.142944781104057*std::sin(0.199840009212494*x_36 + 1.8115998506546) + 0.0134965019474602*std::sin(0.417759865522385*x_36 + 5.21744012832642) - 0.0410527285360531*std::sin(0.447279840707779*x_36 + 5.21871995925903) - 0.069030364174116*std::sin(0.55215984582901*x_38 + 2.15399980545044) + 0.0560630172256089*std::sin(0.547839879989624*x_4 - 4.04007959365845) - 0.13737767748699*std::sin(0.261919975280762*x_43 - 1.34247982501984) + 0.00047422853779443*std::sin(0.307839840650558*x_43 - 1.27559983730316) - 0.00062332069757171*std::sin(0.465679854154587*x_45 + 5.24111986160278) + 0.0840372455543733*std::sin(0.397999823093414*x_51 + 1.99647974967957) + 0.0496108553815056*std::sin(0.222879990935326*x_53 + 5.02343988418579) - 0.13673205588179*std::sin(0.250239968299866*x_53 + 5.05375957489014) + 0.0198692178711656*std::sin(0.297119915485382*x_55 + 5.12536001205444) + 0.00380173367961122*std::sin(0.26599994301796*x_63 + 1.87447988986969) - 0.0216749801613448*std::sin(0.280479967594147*x_64 - 7.5111198425293) - 0.00106833167926931*std::sin(0.430239856243134*x_64 + 2.03743982315063) - 0.0118950874976062*std::sin(0.607439875602722*x_64 + 8.60208034515381) + 0.0929720790647948*std::sin(0.203359991312027*x_66 + 4.99975967407227) + 0.037893740821452*std::sin(0.303439915180206*x_70 - 4.24783992767334) - 0.0042404150506835*std::sin(0.647679805755615*x_70 + 5.42951965332031) - 0.00240360800049487*std::sin(0.208719998598099*x_73 - 4.37784004211426) + 0.134307684794273*std::sin(0.255119979381561*x_73 - 7.54936027526855) - 0.0116814738746228*std::sin(0.537359833717346*x_75 + 2.13783979415894) + 0.00242122006740904*std::sin(0.465439856052399*x_76 + 8.45416069030762) + 0.0608582297549969*std::sin(0.470639854669571*x_80 + 5.25368022918701) - 0.0127607033913524*std::sin(0.394079834222794*x_81 - 7.40359973907471) - 0.0106177861688134*std::sin(0.251359969377518*x_84 + 1.85143995285034) - 0.00104748117578482*std::sin(0.22647999227047*x_86 - 4.36448001861572) + 0.00855477146157368*std::sin(0.388559848070145*x_87 + 5.18847990036011) - 0.00407416810766102*std::sin(0.750559866428375*x_87 - 0.815679848194122) - 0.0160551140136756*std::sin(0.330479830503464*x_92 + 8.39352035522461) + 0.0722280682757458*std::sin(0.341359823942184*x_92 + 1.98951983451843) - 0.0399030760427742*std::sin(0.366719841957092*x_92 - 1.19439995288849) + 0.00136517556706869*std::sin(0.353439837694168*x_95 - 7.42496013641357) - 0.00662975126080025*std::sin(0.360319852828979*x_95 + 4.98791980743408) + 0.0305099549608544*std::sin(0.394079834222794*x_95 - 1.00503981113434) - 0.0251227230965193*std::sin(0.370639860630035*x_96 - 7.42136001586914) + 0.000592563513895861*std::sin(0.416559875011444*x_96 - 7.38855981826782) - 0.000800006861022963*std::sin(0.400159865617752*x_97 - 7.40319967269897) - 0.0691048032314662*std::sin(0.4511998295784*x_98 - 1.14263987541199) + 0.216512773361603 - 3.02011922677894e-6*std::exp(-2.09607982635498*x_30));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00611295786386827*x_10 - 0.00171494629779502*x_100 - 0.001214910730207*x_101 - 0.00013574343272686*x_102 + 0.00482355113089403*x_103 - 0.00157171653697849*x_104 - 0.00259195151313269*x_105 - 0.00296447439050417*x_106 + 0.00327631400950737*x_107 + 0.00286157735217572*x_108 + 0.000277413147975589*x_109 + 0.00756717585749962*x_11 - 0.003149892230147*x_110 - 0.000570442679235322*x_111 + 0.000626610846283159*x_112 - 0.0101291952058677*x_113 + 0.0116200583927773*x_114 + 0.000122028756331754*x_115 - 0.00109696538295367*x_116 - 0.00260453048061922*x_117 + 0.00776409089430272*x_118 + 0.00533024662253443*x_119 + 0.0254682389089308*x_12 + 0.0121015205241892*x_120 - 0.00795746750774273*x_13 + 0.00448568693885959*x_14 + 0.000518008130146115*x_15 + 0.00423398844495329*x_16 - 0.000429480690715653*x_17 - 0.00410580092646245*x_18 + 0.0110633163006185*x_19 + 0.00749382405523806*x_2 - 0.00777065483548394*x_20 + 0.0147170092138108*x_21 - 0.0016699872122764*x_22 - 0.004233438230225*x_23 + 0.000170056419369794*x_24 + 0.00965950759795096*x_25 - 0.000803879812905261*x_26 + 0.00260878602343725*x_27 + 0.00365854916470228*x_28 - 0.0047822036149602*x_29 + 0.00382375436456964*x_3 + 0.0145036647723168*x_30 - 0.00464732107728334*x_32 - 0.00959541897186889*x_33 - 0.000973039990334865*x_34 - 0.000332561916183694*x_35 + 0.00190556697295614*x_36 + 0.00248418157469991*x_37 + 0.000194065089930107*x_38 - 0.00753923826644862*x_39 + 0.00282657978286889*x_4 - 0.00801235601071486*x_40 + 0.000269471404195976*x_41 + 0.0100451530236152*x_42 + 0.0081319219018431*x_43 + 0.0160733144061367*x_44 + 0.00643222388397876*x_45 - 0.00447454800819823*x_46 - 0.00981432802718195*x_47 - 0.000500884340229559*x_48 + 0.00510719017077679*x_49 - 0.000162172489193476*x_5 - 0.00424285976016826*x_50 + 0.00362319420648892*x_51 + 0.00289165703904776*x_52 + 0.00259149558287746*x_53 + 0.00177193811801884*x_54 + 0.0166941261631311*x_55 + 0.0044581601538455*x_56 + 0.0124163786939447*x_57 + 0.00691343965101323*x_58 + 0.0060988677811457*x_59 + 0.0016038065834572*x_6 + 0.00609572285723736*x_60 + 0.00986593967746296*x_61 + 0.00200422129842103*x_62 - 0.0153668137869783*x_63 + 0.000532070952996203*x_64 - 0.00424547375839022*x_65 - 0.000333637790041561*x_66 - 0.00307158955261358*x_67 - 0.00245985089186475*x_68 - 0.00342530031943606*x_69 + 0.00178001502694904*x_7 - 0.00394618056597218*x_71 + 0.00208718450222542*x_72 + 0.00329986157173852*x_73 + 0.000978715157679842*x_74 + 0.00415599166340881*x_75 + 0.0132104544771382*x_76 + 0.00551260416082323*x_77 + 0.00070295240016199*x_78 + 0.00627554968920982*x_79 - 0.0266307728661721*x_8 - 0.00152299883738266*x_80 + 6.97090140279597e-6*x_81 - 0.00524634938832955*x_82 + 0.00232922031726563*x_83 - 0.00140158367947678*x_84 + 0.0022783784608755*x_85 + 0.00101370646435766*x_86 - 0.00639683587179194*x_87 + 0.00688911099777791*x_88 - 0.00382018890879497*x_89 + 0.00965994442136781*x_9 + 0.000537499517338906*x_90 - 0.000662914339080584*x_91 + 0.00129586722991062*x_92 + 0.014701311505873*x_93 - 0.00290221389452279*x_94 + 0.0024619413271385*x_95 - 0.00365083788798788*x_96 + 0.00854153516756452*x_97 + 0.00948659878351451*x_98 + 0.00223346836720056*x_99 + 9.74006482844734e-6*std::pow(-7.63032007217407*x_114 - 9.03103923797607, 2) - 9.43155284383659e-6*std::pow(-8.24623966217041*x_115 - 9.84912014007568, 2) - 1.92566908515883e-5*std::pow(-5.6736798286438*x_15 - 7.62943983078003, 2) - 1.05017402884379e-5*std::pow(-5.82647943496704*x_40 - 6.01991987228394, 2) + 1.2924157029803e-5*std::pow(-5.20471954345703*x_56 - 4.8187198638916, 2) - 3.69088611036256e-5*std::pow(-9.47784042358398*x_59 - 9.54600048065186, 2) + 1.23588049886727e-5*std::pow(-6.42759990692139*x_59 - 7.42335987091064, 2) - 1.63472654599975e-5*std::pow(-6.70647954940796*x_7 - 9.27136039733887, 2) - 6.29905886752696e-5*std::pow(-6.94496011734009*x_70 - 9.19479942321777, 2) - 3.47670808618186e-6*std::pow(-5.8473596572876*x_70 - 8.2651195526123, 2) - 1.954215188314e-5*std::pow(-7.79071998596191*x_71 - 9.37960052490234, 2) + 2.86065141779562e-6*std::pow(-8.39999961853027*x_84 - 6.35200023651123, 2) - 0.000104383629045395*std::pow(-5.13184022903442*x_86 - 7.89423990249634, 2) - 6.05293116088537e-6*std::pow(-9.01288032531738*x_89 - 8.98544025421143, 2) - 0.00013405323415413*std::exp(0.783919870853424*x_1) + 3.08503728113768e-5*std::exp(1.17175984382629*x_1) - 0.000432307817391274*std::exp(1.17815983295441*x_1) - 1.61075602572067e-5*std::exp(1.26551985740662*x_1) - 1.30328575763593e-5*std::exp(1.30431985855103*x_1) + 0.00040592954554041*std::exp(1.37551987171173*x_100) + 0.000832833602729548*std::exp(1.68319988250732*x_100) - 0.000860079839621529*std::exp(1.04447984695435*x_104) + 0.00260590170848588*std::exp(0.591199815273285*x_108) + 0.00225095709154773*std::exp(0.572079837322235*x_109) + 0.00153382906338689*std::exp(0.707839846611023*x_109) - 0.00679563808153415*std::exp(0.873599886894226*x_109) - 0.00275613700343012*std::exp(1.00887978076935*x_109) - 0.000408656307592807*std::exp(1.26239991188049*x_110) + 0.0011928389214809*std::exp(0.642959833145142*x_112) + 0.0021218656182169*std::exp(0.843519866466522*x_112) + 0.000691013089930351*std::exp(0.757279872894287*x_114) - 0.0106070267818116*std::exp(0.615599870681763*x_26) - 0.0115490922869246*std::exp(0.734559834003448*x_26) - 7.70631992146019e-6*std::exp(1.43647980690002*x_26) - 0.00133331107181685*std::exp(0.60207986831665*x_31) + 0.0045843223664671*std::exp(0.623999834060669*x_31) - 0.0128789586127209*std::exp(0.63895982503891*x_31) + 0.00303190415950841*std::exp(0.642719864845276*x_31) + 0.00226202807205242*std::exp(0.659439861774445*x_31) - 0.000688549080088274*std::exp(1.0668797492981*x_50) + 2.06192476268788e-5*std::exp(2.77047991752625*x_6) + 0.00067578089142803*std::exp(1.22575986385345*x_66) + 7.39149546838112e-5*std::exp(1.55999982357025*x_66) + 0.000844183329761969*std::exp(1.14623987674713*x_68) + 0.000466186871421633*std::exp(1.21247982978821*x_68) - 0.00193117966634712*std::exp(0.705119848251343*x_70) + 0.000949472921042049*std::exp(0.99919980764389*x_72) - 0.00289845829835969*std::exp(0.636719882488251*x_74) + 0.000513055276944839*std::exp(1.1736798286438*x_74) + 0.00295744768591014*std::exp(1.25471985340118*x_74) + 3.1008247351291e-5*std::exp(1.5201598405838*x_74) - 2.76118870712591e-5*std::exp(1.60031986236572*x_77) + 0.00770919756493971*std::exp(0.726239860057831*x_81) + 0.000819494279138656*std::exp(1.06903982162476*x_81) - 0.000185952680026704*std::exp(1.76583993434906*x_81) + 0.000622844486541784*std::exp(0.691679835319519*x_90) - 0.00579771343762449*std::sin(0.340159833431244*x_100 - 7.4347996711731) - 0.0203317811097957*std::sin(0.351999849081039*x_102 + 5.17088031768799) + 0.0102899371686187*std::sin(0.376479834318161*x_102 + 1.99015986919403) - 0.0207501596953602*std::sin(0.384479850530624*x_102 + 5.17479991912842) - 0.0107651904484828*std::sin(0.193599998950958*x_111 + 4.98087978363037) - 0.0947739812043999*std::sin(0.207520008087158*x_111 + 1.80207979679108) - 0.00725761360097401*std::sin(0.414799869060516*x_111 - 1.19263982772827) + 0.00153976008837867*std::sin(0.628399848937988*x_112 - 4.1780800819397) + 0.0454935896687542*std::sin(0.409599870443344*x_115 + 5.1956000328064) + 0.0369723666449361*std::sin(0.428799867630005*x_115 + 5.23239994049072) + 0.0159948146794866*std::sin(0.420559853315353*x_117 - 7.37207984924316) + 0.0117998492190108*std::sin(0.296399921178818*x_120 + 5.10007953643799) + 0.00400533030641892*std::sin(0.621119856834412*x_120 - 3.98495984077454) - 0.0618150242280634*std::sin(0.462159872055054*x_2 - 4.12944030761719) - 0.0471667606643468*std::sin(0.419599860906601*x_24 - 7.37135982513428) + 0.0205438543029701*std::sin(0.386959850788116*x_28 - 7.39767980575562) - 0.100484356634848*std::sin(0.283039927482605*x_3 + 1.88183987140656) - 0.00749163594276664*std::sin(0.310239940881729*x_35 + 8.27095985412598) + 0.0781350249359173*std::sin(0.319999843835831*x_35 + 1.98159980773926) - 0.016640136230081*std::sin(0.199840009212494*x_36 + 1.8115998506546) + 0.00753632540851357*std::sin(0.417759865522385*x_36 + 5.21744012832642) + 0.025286823001496*std::sin(0.447279840707779*x_36 + 5.21871995925903) + 0.0425199167715906*std::sin(0.55215984582901*x_38 + 2.15399980545044) - 0.0345325546941121*std::sin(0.547839879989624*x_4 - 4.04007959365845) - 0.0159920722582488*std::sin(0.261919975280762*x_43 - 1.34247982501984) + 0.00338458795486446*std::sin(0.307839840650558*x_43 - 1.27559983730316) - 0.00444866463505289*std::sin(0.465679854154587*x_45 + 5.24111986160278) - 0.0517635496992717*std::sin(0.397999823093414*x_51 + 1.99647974967957) + 0.027702255844159*std::sin(0.222879990935326*x_53 + 5.02343988418579) + 0.0842214249578331*std::sin(0.250239968299866*x_53 + 5.05375957489014) + 0.0110947927153773*std::sin(0.297119915485382*x_55 + 5.12536001205444) + 0.0271331246311297*std::sin(0.26599994301796*x_63 + 1.87447988986969) - 0.0121031141517162*std::sin(0.280479967594147*x_64 - 7.5111198425293) - 0.00762472572880558*std::sin(0.430239856243134*x_64 + 2.03743982315063) + 0.00732689355532408*std::sin(0.607439875602722*x_64 + 8.60208034515381) - 0.0572670463384158*std::sin(0.203359991312027*x_66 + 4.99975967407227) - 0.0233410141344224*std::sin(0.303439915180206*x_70 - 4.24783992767334) - 0.00236780966012628*std::sin(0.647679805755615*x_70 + 5.42951965332031) - 0.0171546459952127*std::sin(0.208719998598099*x_73 - 4.37784004211426) - 0.0827281102680155*std::sin(0.255119979381561*x_73 - 7.54936027526855) - 0.00135983500160356*std::sin(0.537359833717346*x_75 + 2.13783979415894) + 0.0013519875286686*std::sin(0.465439856052399*x_76 + 8.45416069030762) - 0.0374862119736448*std::sin(0.470639854669571*x_80 + 5.25368022918701) - 0.00712546210663512*std::sin(0.394079834222794*x_81 - 7.40359973907471) - 0.0059288763857253*std::sin(0.251359969377518*x_84 + 1.85143995285034) - 0.0074759148553084*std::sin(0.22647999227047*x_86 - 4.36448001861572) + 0.0047769075113583*std::sin(0.388559848070145*x_87 + 5.18847990036011) - 0.000474272035761691*std::sin(0.750559866428375*x_87 - 0.815679848194122) - 0.00896503139471747*std::sin(0.330479830503464*x_92 + 8.39352035522461) - 0.0444895733696425*std::sin(0.341359823942184*x_92 + 1.98951983451843) - 0.00464509873129042*std::sin(0.366719841957092*x_92 - 1.19439995288849) + 0.00974331237437861*std::sin(0.353439837694168*x_95 - 7.42496013641357) - 0.00370199352938975*std::sin(0.360319852828979*x_95 + 4.98791980743408) - 0.0187929002137141*std::sin(0.394079834222794*x_95 - 1.00503981113434) - 0.00292452464208794*std::sin(0.370639860630035*x_96 - 7.42136001586914) + 0.00422914939061191*std::sin(0.416559875011444*x_96 - 7.38855981826782) - 0.00570968081807212*std::sin(0.400159865617752*x_97 - 7.40319967269897) - 0.00804445836387306*std::sin(0.4511998295784*x_98 - 1.14263987541199) + 0.110192617500905 - 1.68640743758035e-6*std::exp(-2.09607982635498*x_30));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0105753042849978*x_10 - 0.00298500295071029*x_100 + 0.0195384443838699*x_101 - 9.75945287828736e-5*x_102 + 0.00429644377476363*x_103 + 0.00097096783943953*x_104 - 0.00928599729099326*x_105 - 0.00893934565772622*x_106 - 0.00665545889212817*x_107 - 0.00497247252562016*x_108 + 0.000279618475516017*x_109 + 0.00774566516049206*x_11 + 0.00545848523823436*x_110 - 0.00075186427881681*x_111 + 0.000408158298903639*x_112 - 0.0155768095815846*x_113 + 0.0183832107529514*x_114 + 0.000118393270753319*x_115 - 0.00248521873330085*x_116 - 0.00487068572554528*x_117 + 0.00115104554860935*x_118 + 0.00622274242080236*x_119 - 0.0205846154631058*x_12 + 0.0204706044962813*x_120 - 0.0181452142450216*x_13 - 0.00501424463846339*x_14 - 0.000397077671349353*x_15 - 0.00540126204517027*x_16 + 0.00334012149742711*x_17 - 0.00258829408822809*x_18 + 0.0145831426924153*x_19 - 0.00313457206903307*x_2 - 0.0173986892744087*x_20 + 0.0027606465928925*x_21 + 0.00709094729356635*x_22 - 0.00899145386588098*x_23 - 0.000606258910774412*x_24 + 0.0145907891867618*x_25 - 0.000768224848417994*x_26 + 0.0144607559534125*x_27 + 0.000190868149241645*x_28 - 0.00917074499705921*x_29 + 0.000118037741295362*x_3 + 0.0326723195273365*x_30 - 0.0523773808199592*x_32 - 0.023096493409844*x_33 - 0.00441275146904428*x_34 - 0.000129613116014065*x_35 - 0.00144645313559923*x_36 - 0.00877614480999461*x_37 - 0.00286279621812055*x_38 - 0.0160340797014436*x_39 + 0.0046084945345176*x_4 - 0.0186663975279113*x_40 + 0.00334123019656904*x_41 + 0.0203103379538767*x_42 + 0.0115819392091241*x_43 + 0.00533822982817747*x_44 + 0.00206286855244151*x_45 - 0.0102099344015261*x_46 - 0.0187960172765946*x_47 + 0.00010495873537393*x_48 + 0.00612536532857573*x_49 + 0.00649982075777576*x_5 - 0.00473875795053646*x_50 + 0.000766784682098438*x_51 + 0.00649564028619078*x_52 + 0.0011648360791378*x_53 + 0.0112571223085947*x_54 + 0.0127067380190245*x_55 - 0.0004350374469188*x_56 + 0.0193099984666057*x_57 + 0.0213414265696604*x_58 + 0.0108588919921269*x_59 + 0.00426014705765982*x_6 + 0.00443201746912073*x_60 + 0.0188659793236807*x_61 - 0.0030433018181539*x_62 - 0.0196674908308851*x_63 - 0.000524786760784998*x_64 - 0.0137064133861396*x_65 - 0.00114656022207887*x_66 - 0.00873959551878602*x_67 - 0.00599367755139873*x_68 - 0.00149824877094175*x_69 - 0.00358657185278885*x_7 - 0.000526862622019559*x_71 - 0.00302209171011856*x_72 - 0.000318779925641575*x_73 - 0.000132541188872912*x_74 + 0.00231046246901708*x_75 + 0.00949236119925636*x_76 + 0.00730592577869115*x_77 + 0.00653661410270662*x_78 + 0.0140958708856925*x_79 - 0.0258789032984669*x_8 - 0.00593566270047021*x_80 + 7.02631738057993e-6*x_81 - 0.0107740414685644*x_82 + 0.00620649964997604*x_83 + 0.00419821055222656*x_84 - 0.00665223378394774*x_85 - 0.000209304875272492*x_86 - 0.00750598908924784*x_87 + 0.00753064948302494*x_88 - 0.00435275399882101*x_89 + 0.0294817040193723*x_9 - 0.00933338730864368*x_90 - 0.00562041765543171*x_91 - 0.00132000066619068*x_92 + 0.0447209879032488*x_93 - 0.0178859404061871*x_94 - 0.0005507544176648*x_95 - 0.00757583051541519*x_96 + 0.00677698887193975*x_97 + 0.00792416866592799*x_98 - 0.00387176648349378*x_99 + 5.64976705793131e-6*std::pow(-7.63032007217407*x_114 - 9.03103923797607, 2) + 3.22953013240688e-5*std::pow(-8.24623966217041*x_115 - 9.84912014007568, 2) + 6.59383077053836e-5*std::pow(-5.6736798286438*x_15 - 7.62943983078003, 2) - 6.09158022842692e-6*std::pow(-5.82647943496704*x_40 - 6.01991987228394, 2) + 7.49671361788586e-6*std::pow(-5.20471954345703*x_56 - 4.8187198638916, 2) + 4.99833306170168e-6*std::pow(-9.47784042358398*x_59 - 9.54600048065186, 2) - 4.23187292403729e-5*std::pow(-6.42759990692139*x_59 - 7.42335987091064, 2) + 5.59759217380799e-5*std::pow(-6.70647954940796*x_7 - 9.27136039733887, 2) + 8.53041607183928e-6*std::pow(-6.94496011734009*x_70 - 9.19479942321777, 2) - 3.50434657465451e-6*std::pow(-5.8473596572876*x_70 - 8.2651195526123, 2) - 3.30738507981724e-5*std::pow(-7.79071998596191*x_71 - 9.37960052490234, 2) - 9.7953752738826e-6*std::pow(-8.39999961853027*x_84 - 6.35200023651123, 2) - 0.000176662661996691*std::pow(-5.13184022903442*x_86 - 7.89423990249634, 2) - 6.10104962926665e-6*std::pow(-9.01288032531738*x_89 - 8.98544025421143, 2) + 0.000459021930127096*std::exp(0.783919870853424*x_1) - 4.17787040234032e-6*std::exp(1.17175984382629*x_1) - 0.000731653521924481*std::exp(1.17815983295441*x_1) - 9.34326053549655e-6*std::exp(1.26551985740662*x_1) - 1.31364637678948e-5*std::exp(1.30431985855103*x_1) - 0.0013899743983449*std::exp(1.37551987171173*x_100) - 0.000112785374756804*std::exp(1.68319988250732*x_100) - 0.00145563049864024*std::exp(1.04447984695435*x_104) + 0.00441032312186266*std::exp(0.591199815273285*x_108) - 0.00770767430801058*std::exp(0.572079837322235*x_109) + 0.000889704233745051*std::exp(0.707839846611023*x_109) - 0.0115011858126509*std::exp(0.873599886894226*x_109) + 0.000373246160810715*std::exp(1.00887978076935*x_109) - 0.000237042872436582*std::exp(1.26239991188049*x_110) - 0.000161538612686613*std::exp(0.642959833145142*x_112) + 0.00359112278373109*std::exp(0.843519866466522*x_112) + 0.00069650637750212*std::exp(0.757279872894287*x_114) + 0.00143644238983782*std::exp(0.615599870681763*x_26) - 0.0195461051288632*std::exp(0.734559834003448*x_26) + 2.63877993458808e-5*std::exp(1.43647980690002*x_26) - 0.00134391038063871*std::exp(0.60207986831665*x_31) - 0.000620825714060305*std::exp(0.623999834060669*x_31) - 0.0217968194158015*std::exp(0.63895982503891*x_31) - 0.0103817748824902*std::exp(0.642719864845276*x_31) + 0.00131209924273521*std::exp(0.659439861774445*x_31) + 0.00235771355852528*std::exp(1.0668797492981*x_50) - 2.79233398265758e-6*std::exp(2.77047991752625*x_6) + 0.000391989651610785*std::exp(1.22575986385345*x_66) + 7.45025500678196e-5*std::exp(1.55999982357025*x_66) - 0.00289063269419464*std::exp(1.14623987674713*x_68) + 0.000469892877261783*std::exp(1.21247982978821*x_68) + 0.0066126999729797*std::exp(0.705119848251343*x_70) - 0.00325116283519898*std::exp(0.99919980764389*x_72) + 0.00992483270471676*std::exp(0.636719882488251*x_74) + 0.000517133868533829*std::exp(1.1736798286438*x_74) + 0.00500529235941417*std::exp(1.25471985340118*x_74) + 1.79864690323048e-5*std::exp(1.5201598405838*x_74) + 9.45479740035821e-5*std::exp(1.60031986236572*x_77) + 0.0130473272115149*std::exp(0.726239860057831*x_81) - 0.00280609302798198*std::exp(1.06903982162476*x_81) + 2.51823925392866e-5*std::exp(1.76583993434906*x_81) + 0.000627795860006229*std::exp(0.691679835319519*x_90) - 0.00336298895008876*std::sin(0.340159833431244*x_100 - 7.4347996711731) + 0.00275340421475078*std::sin(0.351999849081039*x_102 + 5.17088031768799) - 0.0352345607312628*std::sin(0.376479834318161*x_102 + 1.99015986919403) - 0.0351183272910025*std::sin(0.384479850530624*x_102 + 5.17479991912842) - 0.00624439564206577*std::sin(0.193599998950958*x_111 + 4.98087978363037) + 0.0128346394193267*std::sin(0.207520008087158*x_111 + 1.80207979679108) + 0.0248513497213012*std::sin(0.414799869060516*x_111 - 1.19263982772827) - 0.00527241026417617*std::sin(0.628399848937988*x_112 - 4.1780800819397) - 0.00616090842517184*std::sin(0.409599870443344*x_115 + 5.1956000328064) + 0.0625733821629402*std::sin(0.428799867630005*x_115 + 5.23239994049072) - 0.00216607634691865*std::sin(0.420559853315353*x_117 - 7.37207984924316) + 0.0118936534696222*std::sin(0.296399921178818*x_120 + 5.10007953643799) - 0.0137149577900902*std::sin(0.621119856834412*x_120 - 3.98495984077454) - 0.104618002184715*std::sin(0.462159872055054*x_2 - 4.12944030761719) - 0.0798267465207652*std::sin(0.419599860906601*x_24 - 7.37135982513428) + 0.0347691685183366*std::sin(0.386959850788116*x_28 - 7.39767980575562) - 0.17006339111296*std::sin(0.283039927482605*x_3 + 1.88183987140656) + 0.0256526835175377*std::sin(0.310239940881729*x_35 + 8.27095985412598) + 0.132238566780946*std::sin(0.319999843835831*x_35 + 1.98159980773926) - 0.0167724188957458*std::sin(0.199840009212494*x_36 + 1.8115998506546) + 0.00437147840192128*std::sin(0.417759865522385*x_36 + 5.21744012832642) + 0.0427963417801914*std::sin(0.447279840707779*x_36 + 5.21871995925903) + 0.0719622583870908*std::sin(0.55215984582901*x_38 + 2.15399980545044) - 0.0584441554063531*std::sin(0.547839879989624*x_4 - 4.04007959365845) - 0.0161192030652672*std::sin(0.261919975280762*x_43 - 1.34247982501984) - 0.0115894264359227*std::sin(0.307839840650558*x_43 - 1.27559983730316) + 0.015233012766572*std::sin(0.465679854154587*x_45 + 5.24111986160278) - 0.0876065199869077*std::sin(0.397999823093414*x_51 + 1.99647974967957) + 0.0160688142487101*std::sin(0.222879990935326*x_53 + 5.02343988418579) + 0.142539412226555*std::sin(0.250239968299866*x_53 + 5.05375957489014) + 0.00643558287362111*std::sin(0.297119915485382*x_55 + 5.12536001205444) - 0.0929086069213386*std::sin(0.26599994301796*x_63 + 1.87447988986969) - 0.00702046411775769*std::sin(0.280479967594147*x_64 - 7.5111198425293) + 0.0261084064312986*std::sin(0.430239856243134*x_64 + 2.03743982315063) + 0.0124003019581456*std::sin(0.607439875602722*x_64 + 8.60208034515381) - 0.096920838481604*std::sin(0.203359991312027*x_66 + 4.99975967407227) - 0.039503183865127*std::sin(0.303439915180206*x_70 - 4.24783992767334) - 0.00137345831396951*std::sin(0.647679805755615*x_70 + 5.42951965332031) + 0.0587405351691547*std::sin(0.208719998598099*x_73 - 4.37784004211426) - 0.140012071965304*std::sin(0.255119979381561*x_73 - 7.54936027526855) - 0.00137064516543811*std::sin(0.537359833717346*x_75 + 2.13783979415894) + 0.000784226258935842*std::sin(0.465439856052399*x_76 + 8.45416069030762) - 0.0634430327437297*std::sin(0.470639854669571*x_80 + 5.25368022918701) - 0.00413315535282965*std::sin(0.394079834222794*x_81 - 7.40359973907471) - 0.00343907058983686*std::sin(0.251359969377518*x_84 + 1.85143995285034) + 0.0255988517397793*std::sin(0.22647999227047*x_86 - 4.36448001861572) + 0.00277086602315346*std::sin(0.388559848070145*x_87 + 5.18847990036011) - 0.000478042315540255*std::sin(0.750559866428375*x_87 - 0.815679848194122) - 0.00520020553654455*std::sin(0.330479830503464*x_92 + 8.39352035522461) - 0.0752957770720933*std::sin(0.341359823942184*x_92 + 1.98951983451843) - 0.0046820254747951*std::sin(0.366719841957092*x_92 - 1.19439995288849) - 0.0333628209728702*std::sin(0.353439837694168*x_95 - 7.42496013641357) - 0.00214735748266628*std::sin(0.360319852828979*x_95 + 4.98791980743408) - 0.031805789938086*std::sin(0.394079834222794*x_95 - 1.00503981113434) - 0.00294777348513277*std::sin(0.370639860630035*x_96 - 7.42136001586914) - 0.014481353831736*std::sin(0.416559875011444*x_96 - 7.38855981826782) + 0.0195509547088415*std::sin(0.400159865617752*x_97 - 7.40319967269897) - 0.00810840870547416*std::sin(0.4511998295784*x_98 - 1.14263987541199) + 0.165420691357214 - 9.78207984741988e-7*std::exp(-2.09607982635498*x_30));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00230173941171005*x_10 - 0.00146764405078922*x_100 + 0.000949051182666806*x_101 + 0.000145038742345631*x_102 + 0.0049507374800931*x_103 - 0.000882444038799033*x_104 - 0.000449420974389809*x_105 - 0.00149321001594664*x_106 - 0.00333999964111663*x_107 + 0.0048806637776221*x_108 - 0.000550648802361832*x_109 + 5.69598034566496e-5*x_11 + 0.00247395704233291*x_110 + 0.000446426548365525*x_111 - 0.000535208755224483*x_112 - 0.00848516238034686*x_113 + 0.00551585782257356*x_114 - 0.000227614253934596*x_115 - 0.000445792975828784*x_116 - 0.000732500099760026*x_117 + 0.00272030756717981*x_118 - 0.000504471315821702*x_119 + 0.000316819784990192*x_12 + 0.00875237193829815*x_120 - 0.00533688038235573*x_13 + 0.00110917410077939*x_14 - 0.000413537043181915*x_15 + 0.00300088133798986*x_16 - 0.000939607144195248*x_17 - 0.00291393996119107*x_18 + 0.0083754364558772*x_19 + 0.00226609146686528*x_2 - 0.000515381564357345*x_20 + 0.00280129456622187*x_21 - 0.0036685129861969*x_22 + 0.00385460892619923*x_23 + 0.000486816785194542*x_24 - 0.00245546330999296*x_25 + 0.00146231509653368*x_26 + 0.00334812166939183*x_27 - 0.000902466944329539*x_28 - 0.00105097979818054*x_29 - 0.00139102415882542*x_3 + 0.00707229104545967*x_30 - 0.0167097006413023*x_32 + 0.0103258897971496*x_33 + 0.00651506681133774*x_34 + 0.000341698338136356*x_35 + 0.00126924899440816*x_36 - 0.00161354908755887*x_37 + 0.00277637115655794*x_38 - 0.00335030374502119*x_39 - 0.0058286061571379*x_4 - 0.000914420667970065*x_40 - 0.00795917973775843*x_41 + 0.00610725244352384*x_42 + 0.00528080138925261*x_43 + 0.000874461343756316*x_44 - 0.000167947736106724*x_45 - 0.00367526923804582*x_46 - 0.00848361150269493*x_47 + 0.00485385046744354*x_48 + 0.000397157137033916*x_49 - 0.0047569844949168*x_5 - 0.00277039801493585*x_50 - 0.00186234903763845*x_51 - 0.00135623973648043*x_52 - 0.00239655759945405*x_53 - 0.00650915736973774*x_54 + 0.0081607695509912*x_55 - 0.00246374961708306*x_56 + 0.0016402956997431*x_57 + 0.00162331973789829*x_58 + 0.00522321512429899*x_59 + 0.000527902863096185*x_6 - 0.000801713948026524*x_60 + 0.00325781065914468*x_61 + 9.07742222398023e-5*x_62 - 0.00710962293830955*x_63 + 0.000771275568140424*x_64 + 0.00469476143708902*x_65 + 0.00130834214756303*x_66 - 0.00209316438969154*x_67 - 0.00152914534226948*x_68 - 0.00592718245115277*x_69 - 0.00454556155951639*x_7 + 0.00137228293863641*x_71 - 0.00187099729926533*x_72 + 0.000289108777438936*x_73 - 1.54866702560039e-5*x_74 + 0.000278609325509792*x_75 + 0.00224126968012515*x_76 + 0.00372061557712819*x_77 - 0.00237408264928091*x_78 + 0.00339168761492436*x_79 - 0.00699068667436306*x_8 + 0.00671682533150681*x_80 - 1.38368297856228e-5*x_81 - 0.00677363830349517*x_82 - 0.00226733635299317*x_83 + 0.00141854295760269*x_84 - 0.00200879461798128*x_85 + 3.41207581010763e-5*x_86 - 0.00425067462736656*x_87 + 0.00524589707200324*x_88 - 0.000919627700810694*x_89 + 0.0114156031320398*x_9 + 0.00735213885236469*x_90 - 0.0152767956000995*x_91 + 0.00123091261087239*x_92 + 0.00469361305639303*x_93 - 0.00111982902074912*x_94 + 0.000335362592990679*x_95 - 0.00280157723918137*x_96 + 0.000829268122926365*x_97 + 0.0044991303473638*x_98 + 0.00159859342350055*x_99 - 6.11632058789235e-6*std::pow(-7.63032007217407*x_114 - 9.03103923797607, 2) - 3.37661882614446e-5*std::pow(-8.24623966217041*x_115 - 9.84912014007568, 2) - 6.89414627000773e-5*std::pow(-5.6736798286438*x_15 - 7.62943983078003, 2) + 6.59461835893244e-6*std::pow(-5.82647943496704*x_40 - 6.01991987228394, 2) - 8.11578661074875e-6*std::pow(-5.20471954345703*x_56 - 4.8187198638916, 2) + 5.8402626847175e-7*std::pow(-9.47784042358398*x_59 - 9.54600048065186, 2) + 4.42461324072112e-5*std::pow(-6.42759990692139*x_59 - 7.42335987091064, 2) - 5.8525340654037e-5*std::pow(-6.70647954940796*x_7 - 9.27136039733887, 2) + 9.96729710775139e-7*std::pow(-6.94496011734009*x_70 - 9.19479942321777, 2) + 6.90106131518394e-6*std::pow(-5.8473596572876*x_70 - 8.2651195526123, 2) - 1.3076010174073e-5*std::pow(-7.79071998596191*x_71 - 9.37960052490234, 2) + 1.02415048638335e-5*std::pow(-8.39999961853027*x_84 - 6.35200023651123, 2) - 6.98449896186625e-5*std::pow(-5.13184022903442*x_86 - 7.89423990249634, 2) + 1.2014712780713e-5*std::pow(-9.01288032531738*x_89 - 8.98544025421143, 2) - 0.000479928047528446*std::exp(0.783919870853424*x_1) - 4.88159958753668e-7*std::exp(1.17175984382629*x_1) - 0.000289265043703635*std::exp(1.17815983295441*x_1) + 1.0114819989096e-5*std::exp(1.26551985740662*x_1) + 2.58694566863359e-5*std::exp(1.30431985855103*x_1) + 0.00145328067207483*std::exp(1.37551987171173*x_100) - 1.31783178000104e-5*std::exp(1.68319988250732*x_100) - 0.00057549510415529*std::exp(1.04447984695435*x_104) + 0.00174365635148878*std::exp(0.591199815273285*x_108) + 0.00805871972305214*std::exp(0.572079837322235*x_109) - 0.000963175342663129*std::exp(0.707839846611023*x_109) - 0.00454708535809314*std::exp(0.873599886894226*x_109) + 4.36116520905622e-5*std::exp(1.00887978076935*x_109) + 0.000256617695213061*std::exp(1.26239991188049*x_110) - 1.88748512787875e-5*std::exp(0.642959833145142*x_112) + 0.00141977897714311*std::exp(0.843519866466522*x_112) - 0.00137162039060953*std::exp(0.757279872894287*x_114) + 0.000167839973538301*std::exp(0.615599870681763*x_26) - 0.00772770824565244*std::exp(0.734559834003448*x_26) - 2.75896295742002e-5*std::exp(1.43647980690002*x_26) + 0.00264654415347439*std::exp(0.60207986831665*x_31) - 7.2539888934594e-5*std::exp(0.623999834060669*x_31) - 0.00861754605421398*std::exp(0.63895982503891*x_31) + 0.0108546119961062*std::exp(0.642719864845276*x_31) - 0.00142045141497176*std::exp(0.659439861774445*x_31) - 0.00246509543555159*std::exp(1.0668797492981*x_50) - 3.26268052986282e-7*std::exp(2.77047991752625*x_6) - 0.000424359863301279*std::exp(1.22575986385345*x_66) - 0.000146716842984137*std::exp(1.55999982357025*x_66) + 0.00302228633098773*std::exp(1.14623987674713*x_68) - 0.000925353554070624*std::exp(1.21247982978821*x_68) - 0.0069138748687777*std::exp(0.705119848251343*x_70) + 0.00339923678866948*std::exp(0.99919980764389*x_72) - 0.0103768584230874*std::exp(0.636719882488251*x_74) - 0.00101838458579459*std::exp(1.1736798286438*x_74) + 0.00197888217538691*std::exp(1.25471985340118*x_74) - 1.94717781667365e-5*std::exp(1.5201598405838*x_74) - 9.88541539807163e-5*std::exp(1.60031986236572*x_77) + 0.00515836466709995*std::exp(0.726239860057831*x_81) + 0.00293389631238248*std::exp(1.06903982162476*x_81) + 2.94241671460432e-6*std::exp(1.76583993434906*x_81) - 0.00123630971738255*std::exp(0.691679835319519*x_90) + 0.00364070205751347*std::sin(0.340159833431244*x_100 - 7.4347996711731) + 0.000321719335083249*std::sin(0.351999849081039*x_102 + 5.17088031768799) + 0.0368393160052185*std::sin(0.376479834318161*x_102 + 1.99015986919403) - 0.0138843102291236*std::sin(0.384479850530624*x_102 + 5.17479991912842) + 0.00676005315491655*std::sin(0.193599998950958*x_111 + 4.98087978363037) + 0.00149965327934706*std::sin(0.207520008087158*x_111 + 1.80207979679108) - 0.0259832024733292*std::sin(0.414799869060516*x_111 - 1.19263982772827) + 0.00551254177148876*std::sin(0.628399848937988*x_112 - 4.1780800819397) - 0.000719866466186287*std::sin(0.409599870443344*x_115 + 5.1956000328064) + 0.0247388847093056*std::sin(0.428799867630005*x_115 + 5.23239994049072) - 0.000253093475464625*std::sin(0.420559853315353*x_117 - 7.37207984924316) - 0.0234220075288943*std::sin(0.296399921178818*x_120 + 5.10007953643799) + 0.0143396044548689*std::sin(0.621119856834412*x_120 - 3.98495984077454) - 0.0413615599013985*std::sin(0.462159872055054*x_2 - 4.12944030761719) - 0.0315601396413855*std::sin(0.419599860906601*x_24 - 7.37135982513428) + 0.0137462675291185*std::sin(0.386959850788116*x_28 - 7.39767980575562) - 0.0672359153459474*std::sin(0.283039927482605*x_3 + 1.88183987140656) - 0.0268210329537593*std::sin(0.310239940881729*x_35 + 8.27095985412598) + 0.0522815699685031*std::sin(0.319999843835831*x_35 + 1.98159980773926) + 0.0330296929078434*std::sin(0.199840009212494*x_36 + 1.8115998506546) - 0.00473247181256141*std::sin(0.417759865522385*x_36 + 5.21744012832642) + 0.0169198743728326*std::sin(0.447279840707779*x_36 + 5.21871995925903) + 0.0284508516580375*std::sin(0.55215984582901*x_38 + 2.15399980545044) - 0.0231063620432975*std::sin(0.547839879989624*x_4 - 4.04007959365845) + 0.031743323993654*std::sin(0.261919975280762*x_43 - 1.34247982501984) + 0.0121172659437576*std::sin(0.307839840650558*x_43 - 1.27559983730316) - 0.0159267991248536*std::sin(0.465679854154587*x_45 + 5.24111986160278) - 0.0346359350066136*std::sin(0.397999823093414*x_51 + 1.99647974967957) - 0.0173957648881173*std::sin(0.222879990935326*x_53 + 5.02343988418579) + 0.0563540912080249*std::sin(0.250239968299866*x_53 + 5.05375957489014) - 0.00696702848478657*std::sin(0.297119915485382*x_55 + 5.12536001205444) + 0.0971401220547347*std::sin(0.26599994301796*x_63 + 1.87447988986969) + 0.00760020878378008*std::sin(0.280479967594147*x_64 - 7.5111198425293) - 0.0272975117314829*std::sin(0.430239856243134*x_64 + 2.03743982315063) + 0.00490255808299312*std::sin(0.607439875602722*x_64 + 8.60208034515381) - 0.0383184249635416*std::sin(0.203359991312027*x_66 + 4.99975967407227) - 0.0156178981782556*std::sin(0.303439915180206*x_70 - 4.24783992767334) + 0.00148687747232883*std::sin(0.647679805755615*x_70 + 5.42951965332031) - 0.0614158681845609*std::sin(0.208719998598099*x_73 - 4.37784004211426) - 0.0553548871186332*std::sin(0.255119979381561*x_73 - 7.54936027526855) + 0.00269919259597814*std::sin(0.537359833717346*x_75 + 2.13783979415894) - 0.000848987075734656*std::sin(0.465439856052399*x_76 + 8.45416069030762) - 0.0250827079886596*std::sin(0.470639854669571*x_80 + 5.25368022918701) + 0.00447446822466443*std::sin(0.394079834222794*x_81 - 7.40359973907471) + 0.00372306646205979*std::sin(0.251359969377518*x_84 + 1.85143995285034) - 0.0267647494119525*std::sin(0.22647999227047*x_86 - 4.36448001861572) - 0.00299968206298231*std::sin(0.388559848070145*x_87 + 5.18847990036011) + 0.000941402130330402*std::sin(0.750559866428375*x_87 - 0.815679848194122) + 0.00562963461295079*std::sin(0.330479830503464*x_92 + 8.39352035522461) - 0.0297687848042729*std::sin(0.341359823942184*x_92 + 1.98951983451843) + 0.00922024810973489*std::sin(0.366719841957092*x_92 - 1.19439995288849) + 0.0348823280079828*std::sin(0.353439837694168*x_95 - 7.42496013641357) + 0.00232468465445114*std::sin(0.360319852828979*x_95 + 4.98791980743408) - 0.0125746722195355*std::sin(0.394079834222794*x_95 - 1.00503981113434) + 0.00580500961614513*std::sin(0.370639860630035*x_96 - 7.42136001586914) + 0.0151409059434465*std::sin(0.416559875011444*x_96 - 7.38855981826782) - 0.0204414013904159*std::sin(0.400159865617752*x_97 - 7.40319967269897) + 0.0159677772882852*std::sin(0.4511998295784*x_98 - 1.14263987541199) - 0.01244121548576 + 1.05898766709664e-6*std::exp(-2.09607982635498*x_30));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00636375022581956*x_10 - 0.00108216845902827*x_100 - 0.00660318534809494*x_101 + 0.000317220175791747*x_102 + 0.00342683587703528*x_103 - 0.000974633144649299*x_104 + 0.0049467746872865*x_105 + 0.00507206905310332*x_106 - 0.00316235688255528*x_107 + 0.00306526648334851*x_108 - 0.00225747702451717*x_109 - 0.00957508272711385*x_11 + 0.00236776755502275*x_110 + 0.00252493473885853*x_111 - 0.000614224855558737*x_112 - 0.000177964662239268*x_113 - 0.00118966002912909*x_114 - 0.000900575727337239*x_115 - 0.00143624678336992*x_116 + 0.000516523800739837*x_117 + 0.00183175678479201*x_118 - 0.00969849332698442*x_119 - 0.0138465203670006*x_12 + 0.000182012065805774*x_120 - 0.00102494296074037*x_13 - 0.00096575693188545*x_14 - 0.000462290700719671*x_15 - 0.00480936714905138*x_16 - 0.000868734416118544*x_17 - 0.0029233235518043*x_18 - 3.91017246820141e-5*x_19 + 0.000269980081706871*x_2 + 0.00560966357530764*x_20 - 0.00244840249831008*x_21 - 0.0145645505347055*x_22 + 0.00669761686011059*x_23 - 0.000796509307717626*x_24 - 0.00336043335886237*x_25 + 0.00569769218433895*x_26 - 8.10211795489462e-6*x_27 - 0.00284739606510029*x_28 + 0.00517209386786927*x_29 - 0.00780032951557945*x_3 - 0.00491446240202741*x_30 - 0.0136414953906588*x_32 + 0.016085537608291*x_33 + 0.0103337162149658*x_34 + 0.00163115601077028*x_35 + 0.000600198498805137*x_36 - 0.00406350822418619*x_37 - 1.28264399942609e-5*x_38 + 0.0014960032855363*x_39 - 0.00923531652981432*x_4 + 0.00573527445470589*x_40 - 0.0166918296213576*x_41 + 0.00479389248835777*x_42 - 0.000508218006825398*x_43 - 0.00617623373919539*x_44 - 0.00212508721693101*x_45 + 0.00451847964514787*x_46 - 0.00262243205985339*x_47 + 0.00242684479510796*x_48 - 0.00642092897639057*x_49 - 0.012467722189366*x_5 - 0.00127489397322032*x_50 - 0.00651760419703385*x_51 - 0.00812502812127197*x_52 - 0.00888980179747334*x_53 - 0.0154541962141249*x_54 - 0.00200198293415667*x_55 - 0.00514282752717421*x_56 - 0.00336572426518998*x_57 - 0.00136774681434136*x_58 + 0.00248950318700998*x_59 - 0.000643044423501124*x_6 - 0.00753579935330507*x_60 + 0.00257809697587368*x_61 - 0.00186975580736672*x_62 + 0.00331323391398838*x_63 + 0.00290234579007473*x_64 + 0.00895533758409792*x_65 + 0.00137544234254073*x_66 + 0.0024002607243823*x_67 - 0.00111810821615672*x_68 - 0.00319222786311507*x_69 - 0.00829007050245373*x_7 + 0.00385810940082878*x_71 - 0.0040222337173959*x_72 + 0.00313039993311133*x_73 - 0.000337296896320476*x_74 + 0.000674897707080099*x_75 - 0.00363970263985957*x_76 + 0.00125909008232176*x_77 - 0.00419907465099282*x_78 - 0.00472653618111479*x_79 + 0.00392146430547943*x_8 + 0.00681378470859159*x_80 - 5.67264020174383e-5*x_81 - 0.00745996673787546*x_82 - 0.00233002942260433*x_83 + 0.001004456059774*x_84 - 0.00104443189787865*x_85 - 0.000534326145677783*x_86 - 0.000680779438433731*x_87 + 0.00288650294112156*x_88 - 7.31771039359728e-5*x_89 - 0.00198755672490237*x_9 + 0.00700082121488986*x_90 - 0.0282535836342405*x_91 + 0.000763905606341435*x_92 + 0.00739842362062859*x_93 + 0.00809169373871422*x_94 + 0.000632937869459051*x_95 - 0.000625054912536406*x_96 - 0.00315894235572875*x_97 + 0.00190346833703573*x_98 + 0.00377723153498876*x_99 + 4.39609535749883e-6*std::pow(-7.63032007217407*x_114 - 9.03103923797607, 2) - 2.95561651219068e-5*std::pow(-8.24623966217041*x_115 - 9.84912014007568, 2) - 6.03457292701265e-5*std::pow(-5.6736798286438*x_15 - 7.62943983078003, 2) - 4.73987109334461e-6*std::pow(-5.82647943496704*x_40 - 6.01991987228394, 2) + 5.83320827109523e-6*std::pow(-5.20471954345703*x_56 - 4.8187198638916, 2) + 1.27199872192527e-5*std::pow(-9.47784042358398*x_59 - 9.54600048065186, 2) + 3.87294528274166e-5*std::pow(-6.42759990692139*x_59 - 7.42335987091064, 2) - 5.12283062213951e-5*std::pow(-6.70647954940796*x_7 - 9.27136039733887, 2) + 2.17085940591086e-5*std::pow(-6.94496011734009*x_70 - 9.19479942321777, 2) + 2.82920571097056e-5*std::pow(-5.8473596572876*x_70 - 8.2651195526123, 2) - 1.07083230944e-6*std::pow(-7.79071998596191*x_71 - 9.37960052490234, 2) + 8.96457742012614e-6*std::pow(-8.39999961853027*x_84 - 6.35200023651123, 2) - 5.71980830088848e-6*std::pow(-5.13184022903442*x_86 - 7.89423990249634, 2) + 4.92563280666319e-5*std::pow(-9.01288032531738*x_89 - 8.98544025421143, 2) - 0.000420089839858585*std::exp(0.783919870853424*x_1) - 1.06320362139634e-5*std::exp(1.17175984382629*x_1) - 2.3688751436092e-5*std::exp(1.17815983295441*x_1) - 7.27001022216265e-6*std::exp(1.26551985740662*x_1) + 0.000106056172020457*std::exp(1.30431985855103*x_1) + 0.00127208327986979*std::exp(1.37551987171173*x_100) - 0.000287021394476011*std::exp(1.68319988250732*x_100) - 4.71289593117581e-5*std::exp(1.04447984695435*x_104) + 0.000142793064006377*std::exp(0.591199815273285*x_108) + 0.00705394547236069*std::exp(0.572079837322235*x_109) + 0.000692280692532797*std::exp(0.707839846611023*x_109) - 0.000372373977261215*std::exp(0.873599886894226*x_109) + 0.000949853948614436*std::exp(1.00887978076935*x_109) - 0.000184443546142981*std::exp(1.26239991188049*x_110) - 0.000411090870381091*std::exp(0.642959833145142*x_112) + 0.000116269808660981*std::exp(0.843519866466522*x_112) - 0.00562318760138812*std::exp(0.757279872894287*x_114) + 0.00365552447473544*std::exp(0.615599870681763*x_26) - 0.000632844388862458*std::exp(0.734559834003448*x_26) - 2.41497097935216e-5*std::exp(1.43647980690002*x_26) + 0.0108499511761633*std::exp(0.60207986831665*x_31) - 0.00157990575072682*std::exp(0.623999834060669*x_31) - 0.000705715781809086*std::exp(0.63895982503891*x_31) + 0.00950124136035421*std::exp(0.642719864845276*x_31) + 0.00102094711700875*std::exp(0.659439861774445*x_31) - 0.00215774333692305*std::exp(1.0668797492981*x_50) - 7.10605958683297e-6*std::exp(2.77047991752625*x_6) + 0.000305007953419008*std::exp(1.22575986385345*x_66) - 0.000601490279695085*std::exp(1.55999982357025*x_66) + 0.00264546276744989*std::exp(1.14623987674713*x_68) - 0.0037936419345866*std::exp(1.21247982978821*x_68) - 0.00605184173207748*std::exp(0.705119848251343*x_70) + 0.00297541443044945*std::exp(0.99919980764389*x_72) - 0.00908305487799525*std::exp(0.636719882488251*x_74) - 0.0041750382361552*std::exp(1.1736798286438*x_74) + 0.000162056387366602*std::exp(1.25471985340118*x_74) + 1.3995308514483e-5*std::exp(1.5201598405838*x_74) - 8.652885766726e-5*std::exp(1.60031986236572*x_77) + 0.000422433408652186*std::exp(0.726239860057831*x_81) + 0.00256809335978097*std::exp(1.06903982162476*x_81) + 6.40853075006725e-5*std::exp(1.76583993434906*x_81) - 0.00506845882567539*std::exp(0.691679835319519*x_90) - 0.00261674861267967*std::sin(0.340159833431244*x_100 - 7.4347996711731) + 0.00700698932798662*std::sin(0.351999849081039*x_102 + 5.17088031768799) + 0.0322461303123043*std::sin(0.376479834318161*x_102 + 1.99015986919403) - 0.00113702633981683*std::sin(0.384479850530624*x_102 + 5.17479991912842) - 0.00485877708071783*std::sin(0.193599998950958*x_111 + 4.98087978363037) + 0.032662179042941*std::sin(0.207520008087158*x_111 + 1.80207979679108) - 0.0227435746300846*std::sin(0.414799869060516*x_111 - 1.19263982772827) + 0.00482522911908209*std::sin(0.628399848937988*x_112 - 4.1780800819397) - 0.0156785623246347*std::sin(0.409599870443344*x_115 + 5.1956000328064) + 0.00202593885241555*std::sin(0.428799867630005*x_115 + 5.23239994049072) - 0.0055123304326884*std::sin(0.420559853315353*x_117 - 7.37207984924316) - 0.0960224441381841*std::sin(0.296399921178818*x_120 + 5.10007953643799) + 0.0125517193048074*std::sin(0.621119856834412*x_120 - 3.98495984077454) - 0.00338721782268691*std::sin(0.462159872055054*x_2 - 4.12944030761719) - 0.00258455115654799*std::sin(0.419599860906601*x_24 - 7.37135982513428) + 0.00112572162367789*std::sin(0.386959850788116*x_28 - 7.39767980575562) - 0.00550614365916989*std::sin(0.283039927482605*x_3 + 1.88183987140656) - 0.0234769430467986*std::sin(0.310239940881729*x_35 + 8.27095985412598) + 0.00428148904484084*std::sin(0.319999843835831*x_35 + 1.98159980773926) + 0.135410760082464*std::sin(0.199840009212494*x_36 + 1.8115998506546) + 0.00340145632749841*std::sin(0.417759865522385*x_36 + 5.21744012832642) + 0.00138561747114727*std::sin(0.447279840707779*x_36 + 5.21871995925903) + 0.00232992256666479*std::sin(0.55215984582901*x_38 + 2.15399980545044) - 0.00189224684748573*std::sin(0.547839879989624*x_4 - 4.04007959365845) + 0.130137075192239*std::sin(0.261919975280762*x_43 - 1.34247982501984) + 0.0106064655651018*std::sin(0.307839840650558*x_43 - 1.27559983730316) - 0.0139410199680464*std::sin(0.465679854154587*x_45 + 5.24111986160278) - 0.00283643693902028*std::sin(0.397999823093414*x_51 + 1.99647974967957) + 0.0125031773867737*std::sin(0.222879990935326*x_53 + 5.02343988418579) + 0.00461499959325014*std::sin(0.250239968299866*x_53 + 5.05375957489014) + 0.00500754025846223*std::sin(0.297119915485382*x_55 + 5.12536001205444) + 0.0850285340229008*std::sin(0.26599994301796*x_63 + 1.87447988986969) - 0.00546263755639904*std::sin(0.280479967594147*x_64 - 7.5111198425293) - 0.0238940136774081*std::sin(0.430239856243134*x_64 + 2.03743982315063) + 0.000401484667286704*std::sin(0.607439875602722*x_64 + 8.60208034515381) - 0.0031380066971171*std::sin(0.203359991312027*x_66 + 4.99975967407227) - 0.00127899487322063*std::sin(0.303439915180206*x_70 - 4.24783992767334) - 0.00106869073642309*std::sin(0.647679805755615*x_70 + 5.42951965332031) - 0.0537584380894074*std::sin(0.208719998598099*x_73 - 4.37784004211426) - 0.00453317187910789*std::sin(0.255119979381561*x_73 - 7.54936027526855) + 0.0110657922872654*std::sin(0.537359833717346*x_75 + 2.13783979415894) + 0.00061020806358676*std::sin(0.465439856052399*x_76 + 8.45416069030762) - 0.00205409553563685*std::sin(0.470639854669571*x_80 + 5.25368022918701) - 0.0032160166732695*std::sin(0.394079834222794*x_81 - 7.40359973907471) - 0.00267594789290804*std::sin(0.251359969377518*x_84 + 1.85143995285034) - 0.0234276770283067*std::sin(0.22647999227047*x_86 - 4.36448001861572) + 0.00215601654647622*std::sin(0.388559848070145*x_87 + 5.18847990036011) + 0.00385943576184504*std::sin(0.750559866428375*x_87 - 0.815679848194122) - 0.00404629061390254*std::sin(0.330479830503464*x_92 + 8.39352035522461) - 0.00243785192553521*std::sin(0.341359823942184*x_92 + 1.98951983451843) + 0.0377999519454092*std::sin(0.366719841957092*x_92 - 1.19439995288849) + 0.0305331427538616*std::sin(0.353439837694168*x_95 - 7.42496013641357) - 0.00167086326987366*std::sin(0.360319852828979*x_95 + 4.98791980743408) - 0.00102977629368897*std::sin(0.394079834222794*x_95 - 1.00503981113434) + 0.0237986095299591*std::sin(0.370639860630035*x_96 - 7.42136001586914) + 0.0132531132236429*std::sin(0.416559875011444*x_96 - 7.38855981826782) - 0.017892734298001*std::sin(0.400159865617752*x_97 - 7.40319967269897) + 0.0654625783372256*std::sin(0.4511998295784*x_98 - 1.14263987541199) + 0.117467166367656 - 7.61145643050125e-7*std::exp(-2.09607982635498*x_30));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00545366107554297*x_10 + 0.000940899074785976*x_100 - 0.0126309560577531*x_101 + 0.000272663316723324*x_102 - 0.000533956002895256*x_103 + 0.00165533990374205*x_104 + 0.00945802756426545*x_105 + 0.00786227122204334*x_106 + 0.00982626645535561*x_107 - 0.00369916291534179*x_108 - 0.000926868791035805*x_109 - 0.00436359506522372*x_11 - 0.013330146587385*x_110 + 0.00123169939075275*x_111 - 0.00106337833654908*x_112 + 0.013311643562607*x_113 - 0.00287993590190196*x_114 - 0.000386476757543102*x_115 + 2.4141638328066e-5*x_116 + 0.0015188377188959*x_117 + 0.00793149089981702*x_118 - 0.00202606909786106*x_119 + 0.0525212617986542*x_12 - 0.00728890256199938*x_120 + 0.00937812431562672*x_13 + 0.00560236861457869*x_14 + 0.000699179046550966*x_15 - 0.00196196876247228*x_16 + 0.00134637872994887*x_17 - 0.00456175426910792*x_18 - 0.00859761243528549*x_19 + 0.00630019807276655*x_2 + 0.00162927601674015*x_20 + 0.0156331553074675*x_21 - 0.00314786610852382*x_22 - 0.0103458577154236*x_23 + 0.000196895035702618*x_24 + 0.0105909615297614*x_25 + 0.0024919919891362*x_26 - 0.00902711687912544*x_27 + 0.00800327275310242*x_28 + 0.000795421040786969*x_29 + 0.00902488431749318*x_3 - 0.0123097555130565*x_30 + 0.0464473315522383*x_32 - 0.0173032528222106*x_33 + 0.0027378039903715*x_34 + 0.000221338967285979*x_35 + 0.000786236217279953*x_36 + 0.017620337222629*x_37 - 0.00532899408689155*x_38 + 0.00914653213909556*x_39 + 0.0182715101822061*x_4 + 0.000944902042275747*x_40 + 0.00496528510008128*x_41 - 0.00527597169331101*x_42 - 0.00156875031274526*x_43 + 0.0171718172372264*x_44 + 0.00430461692773603*x_45 + 0.0152490850805545*x_46 + 0.0162502442753834*x_47 - 0.0133971997787028*x_48 + 0.00103755983004682*x_49 - 0.00444611203457474*x_5 - 0.00158048456753715*x_50 + 0.00378872585438265*x_51 - 0.00511778086689697*x_52 + 0.00021503150259928*x_53 + 0.000995356925455333*x_54 - 0.0012207802468225*x_55 + 0.0103350898932276*x_56 + 0.00623352068084685*x_57 + 0.00041976233388422*x_58 - 0.00354142583707944*x_59 + 6.8320104139246e-5*x_6 + 0.00148187190764958*x_60 - 0.00169354028584525*x_61 - 0.00420586907167006*x_62 + 0.00415782698777036*x_63 + 0.00284666992015751*x_64 + 0.00308417593123688*x_65 - 0.00289686905215071*x_66 + 0.00155718535027391*x_67 + 0.00607607745354227*x_68 + 0.00695349120648932*x_69 + 0.0016184343106408*x_7 + 0.000670631689664721*x_71 + 0.00579709830213023*x_72 + 0.00495765633940697*x_73 + 0.00160693268989854*x_74 - 0.00136419344818354*x_75 + 0.0109847104684382*x_76 + 2.32829498539701e-5*x_77 + 0.00791562867240119*x_78 - 0.0114612399644567*x_79 - 0.00539407208104756*x_8 - 0.0120895759230886*x_80 - 2.32905722125609e-5*x_81 + 0.00265602116103324*x_82 - 0.000647238685645281*x_83 - 0.00766154050442022*x_84 + 0.0115488574486073*x_85 + 0.00196540136910328*x_86 + 0.00307636943677192*x_87 - 0.00754558672282891*x_88 + 0.00122048637364389*x_89 - 0.0333868200697419*x_9 - 0.0106230790072274*x_90 + 0.00499221089940745*x_91 - 0.000128315196976673*x_92 + 0.0196832763789194*x_93 + 0.00805479751596323*x_94 + 0.00498945294042613*x_95 + 0.00487690223530022*x_96 - 0.000272374058139838*x_97 - 0.00514926973719403*x_98 + 0.00265982766476059*x_99 - 1.33262763134601e-5*std::pow(-7.63032007217407*x_114 - 9.03103923797607, 2) + 4.56550242689074e-5*std::pow(-8.24623966217041*x_115 - 9.84912014007568, 2) + 9.321526398939e-5*std::pow(-5.6736798286438*x_15 - 7.62943983078003, 2) + 1.43683943917063e-5*std::pow(-5.82647943496704*x_40 - 6.01991987228394, 2) - 1.76827249850202e-5*std::pow(-5.20471954345703*x_56 - 4.8187198638916, 2) - 6.05999150916821e-5*std::pow(-9.47784042358398*x_59 - 9.54600048065186, 2) - 5.98248826078806e-5*std::pow(-6.42759990692139*x_59 - 7.42335987091064, 2) + 7.91316990599464e-5*std::pow(-6.70647954940796*x_7 - 9.27136039733887, 2) - 0.000103422977874585*std::pow(-6.94496011734009*x_70 - 9.19479942321777, 2) + 1.16160760372733e-5*std::pow(-5.8473596572876*x_70 - 8.2651195526123, 2) + 1.43078259275497e-5*std::pow(-7.79071998596191*x_71 - 9.37960052490234, 2) - 1.38474662727136e-5*std::pow(-8.39999961853027*x_84 - 6.35200023651123, 2) + 7.64246845996498e-5*std::pow(-5.13184022903442*x_86 - 7.89423990249634, 2) + 2.02235295199723e-5*std::pow(-9.01288032531738*x_89 - 8.98544025421143, 2) + 0.000648907317805233*std::exp(0.783919870853424*x_1) + 5.06526052827061e-5*std::exp(1.17175984382629*x_1) + 0.000316515040684425*std::exp(1.17815983295441*x_1) + 2.20382310081053e-5*std::exp(1.26551985740662*x_1) + 4.35442553234895e-5*std::exp(1.30431985855103*x_1) - 0.00196497051545705*std::exp(1.37551987171173*x_100) + 0.00136741270529078*std::exp(1.68319988250732*x_100) + 0.000629709189790741*std::exp(1.04447984695435*x_104) - 0.00190791619327694*std::exp(0.591199815273285*x_108) - 0.0108961379260085*std::exp(0.572079837322235*x_109) - 0.0020985722658242*std::exp(0.707839846611023*x_109) + 0.00497544013160108*std::exp(0.873599886894226*x_109) - 0.00452524579178905*std::exp(1.00887978076935*x_109) + 0.000559120187405179*std::exp(1.26239991188049*x_110) + 0.00195849818169263*std::exp(0.642959833145142*x_112) - 0.00155352819324327*std::exp(0.843519866466522*x_112) - 0.00230875310679225*std::exp(0.757279872894287*x_114) - 0.0174154634722619*std::exp(0.615599870681763*x_26) + 0.00845569121817575*std::exp(0.734559834003448*x_26) + 3.73037429640388e-5*std::exp(1.43647980690002*x_26) + 0.00445474351243902*std::exp(0.60207986831665*x_31) + 0.00752690648949651*std::exp(0.623999834060669*x_31) + 0.00942935553161403*std::exp(0.63895982503891*x_31) - 0.0146764440888241*std::exp(0.642719864845276*x_31) - 0.00309488813964898*std::exp(0.659439861774445*x_31) + 0.00333303809905565*std::exp(1.0668797492981*x_50) + 3.38543270662037e-5*std::exp(2.77047991752625*x_6) - 0.000924597838427515*std::exp(1.22575986385345*x_66) - 0.000246958246886261*std::exp(1.55999982357025*x_66) - 0.00408641196691974*std::exp(1.14623987674713*x_68) - 0.00155758321141057*std::exp(1.21247982978821*x_68) + 0.00934820129776561*std::exp(0.705119848251343*x_70) - 0.0045960840140097*std::exp(0.99919980764389*x_72) + 0.01403047686262*std::exp(0.636719882488251*x_74) - 0.00171417586998525*std::exp(1.1736798286438*x_74) - 0.00216530128989243*std::exp(1.25471985340118*x_74) - 4.2425228114759e-5*std::exp(1.5201598405838*x_74) + 0.000133660002252171*std::exp(1.60031986236572*x_77) - 0.00564430455048352*std::exp(0.726239860057831*x_81) - 0.00396690044808006*std::exp(1.06903982162476*x_81) - 0.000305311957176106*std::exp(1.76583993434906*x_81) - 0.00208099407132318*std::exp(0.691679835319519*x_90) + 0.00793238367678921*std::sin(0.340159833431244*x_100 - 7.4347996711731) - 0.0333823415861308*std::sin(0.351999849081039*x_102 + 5.17088031768799) - 0.049810178550377*std::sin(0.376479834318161*x_102 + 1.99015986919403) + 0.0151922712844235*std::sin(0.384479850530624*x_102 + 5.17479991912842) + 0.0147288447264238*std::sin(0.193599998950958*x_111 + 4.98087978363037) - 0.155607489425436*std::sin(0.207520008087158*x_111 + 1.80207979679108) + 0.0351317042456431*std::sin(0.414799869060516*x_111 - 1.19263982772827) - 0.0074534687306727*std::sin(0.628399848937988*x_112 - 4.1780800819397) + 0.0746950078844756*std::sin(0.409599870443344*x_115 + 5.1956000328064) - 0.0270693928308724*std::sin(0.428799867630005*x_115 + 5.23239994049072) + 0.0262615638223761*std::sin(0.420559853315353*x_117 - 7.37207984924316) - 0.0394246345562243*std::sin(0.296399921178818*x_120 + 5.10007953643799) - 0.0193884777376872*std::sin(0.621119856834412*x_120 - 3.98495984077454) + 0.0452579947004427*std::sin(0.462159872055054*x_2 - 4.12944030761719) + 0.034533238979383*std::sin(0.419599860906601*x_24 - 7.37135982513428) - 0.0150412243751638*std::sin(0.386959850788116*x_28 - 7.39767980575562) + 0.0735698244374825*std::sin(0.283039927482605*x_3 + 1.88183987140656) + 0.0362645289109887*std::sin(0.310239940881729*x_35 + 8.27095985412598) - 0.0572067161443138*std::sin(0.319999843835831*x_35 + 1.98159980773926) + 0.0555965824359681*std::sin(0.199840009212494*x_36 + 1.8115998506546) - 0.0103111382265832*std::sin(0.417759865522385*x_36 + 5.21744012832642) - 0.0185137984767331*std::sin(0.447279840707779*x_36 + 5.21871995925903) - 0.0311310428482898*std::sin(0.55215984582901*x_38 + 2.15399980545044) + 0.0252830795887539*std::sin(0.547839879989624*x_4 - 4.04007959365845) + 0.0534313272039458*std::sin(0.261919975280762*x_43 - 1.34247982501984) - 0.0163836695587798*std::sin(0.307839840650558*x_43 - 1.27559983730316) + 0.0215345124223415*std::sin(0.465679854154587*x_45 + 5.24111986160278) + 0.0378987873453291*std::sin(0.397999823093414*x_51 + 1.99647974967957) - 0.0379019978190716*std::sin(0.222879990935326*x_53 + 5.02343988418579) - 0.0616628861996769*std::sin(0.250239968299866*x_53 + 5.05375957489014) - 0.0151798038277792*std::sin(0.297119915485382*x_55 + 5.12536001205444) - 0.131342471810995*std::sin(0.26599994301796*x_63 + 1.87447988986969) + 0.0165593808952943*std::sin(0.280479967594147*x_64 - 7.5111198425293) + 0.0369087724954926*std::sin(0.430239856243134*x_64 + 2.03743982315063) - 0.00536439989854476*std::sin(0.607439875602722*x_64 + 8.60208034515381) + 0.0419281835129878*std::sin(0.203359991312027*x_66 + 4.99975967407227) + 0.017089170589034*std::sin(0.303439915180206*x_70 - 4.24783992767334) + 0.00323961763543547*std::sin(0.647679805755615*x_70 + 5.42951965332031) + 0.0830399608848886*std::sin(0.208719998598099*x_73 - 4.37784004211426) + 0.0605695528367633*std::sin(0.255119979381561*x_73 - 7.54936027526855) + 0.00454336297014793*std::sin(0.537359833717346*x_75 + 2.13783979415894) - 0.00184977817876207*std::sin(0.465439856052399*x_76 + 8.45416069030762) + 0.0274456057249699*std::sin(0.470639854669571*x_80 + 5.25368022918701) + 0.00974899844781071*std::sin(0.394079834222794*x_81 - 7.40359973907471) + 0.00811183973989203*std::sin(0.251359969377518*x_84 + 1.85143995285034) + 0.0361884283322904*std::sin(0.22647999227047*x_86 - 4.36448001861572) - 0.00653572543319009*std::sin(0.388559848070145*x_87 + 5.18847990036011) + 0.00158459666247401*std::sin(0.750559866428375*x_87 - 0.815679848194122) + 0.0122658819657871*std::sin(0.330479830503464*x_92 + 8.39352035522461) + 0.0325731309003375*std::sin(0.341359823942184*x_92 + 1.98951983451843) + 0.015519801699132*std::sin(0.366719841957092*x_92 - 1.19439995288849) - 0.0471641489240548*std::sin(0.353439837694168*x_95 - 7.42496013641357) + 0.00506503699433316*std::sin(0.360319852828979*x_95 + 4.98791980743408) + 0.0137592598061636*std::sin(0.394079834222794*x_95 - 1.00503981113434) + 0.00977116852300379*std::sin(0.370639860630035*x_96 - 7.42136001586914) - 0.0204719118115739*std::sin(0.416559875011444*x_96 - 7.38855981826782) + 0.0276386742069887*std::sin(0.400159865617752*x_97 - 7.40319967269897) + 0.026877447780222*std::sin(0.4511998295784*x_98 - 1.14263987541199) + 0.244723753561826 + 2.30732873816532e-6*std::exp(-2.09607982635498*x_30));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00153409580527056*x_10 + 0.0030263515664498*x_100 - 0.00565680214570118*x_101 - 0.000386500063550488*x_102 - 0.00759591462004422*x_103 - 0.000304485322597775*x_104 - 0.000495795019969896*x_105 + 0.000610544895916762*x_106 + 0.00675634675316895*x_107 - 0.000918457719838736*x_108 + 0.00201108027733717*x_109 + 0.00423672471274469*x_11 - 0.00349873203989477*x_110 - 0.0019590031005972*x_111 + 0.00113899488692507*x_112 + 0.0102126731692383*x_113 - 0.0116156139772261*x_114 + 0.000814479424664566*x_115 + 0.00246765973960278*x_116 + 0.00217579520236833*x_117 - 0.00462973289395536*x_118 + 0.00430890633793969*x_119 + 0.0104567844158128*x_12 - 0.0150534584552929*x_120 + 0.0114415102891419*x_13 + 0.00217589580237819*x_14 + 0.000816049143167486*x_15 + 0.00537199540211687*x_16 - 0.00136873581115743*x_17 + 0.00630875446768101*x_18 - 0.010687045351035*x_19 - 0.000110419727795932*x_2 + 0.0054753911392041*x_20 - 0.00382522768033208*x_21 + 0.00766938703528458*x_22 + 0.000650214398507345*x_23 + 0.000372631631056481*x_24 - 0.00582864520388106*x_25 - 0.00518717262386089*x_26 - 0.00842644366253144*x_27 + 0.000694945533657753*x_28 + 0.00216411132909055*x_29 + 0.00369483987664245*x_3 - 0.015951097341501*x_30 + 0.0392379914697618*x_32 - 0.000883264798900969*x_33 - 0.0102872921737643*x_34 - 0.00133392055676661*x_35 - 0.000273980385647525*x_36 + 0.0041042068115734*x_37 + 0.00116157458617588*x_38 + 0.00703836277501187*x_39 + 0.00225491238015051*x_4 + 0.00674411648252815*x_40 + 0.0130406955436174*x_41 - 0.0164385327178843*x_42 - 0.00895900547308744*x_43 - 0.00169506899652682*x_44 + 0.000533345693243747*x_45 + 0.000750286560143133*x_46 + 0.0127378474465517*x_47 - 0.00147526467447114*x_48 + 0.000562242475127151*x_49 + 0.00877531663269527*x_5 + 0.00555086790828967*x_50 + 0.00472809263534491*x_51 + 0.00434587703560202*x_52 + 0.00722123850610512*x_53 + 0.00776792968317349*x_54 - 0.00898700376475102*x_55 + 0.00328033404154838*x_56 - 0.0102827348734107*x_57 - 0.0123855567551885*x_58 - 0.0100856001879408*x_59 - 0.00237747327501672*x_6 + 0.00353341835848942*x_60 - 0.0129148936782691*x_61 + 0.0049786736186698*x_62 + 0.011119019263135*x_63 - 0.00283461639580563*x_64 - 0.0030100879932688*x_65 - 0.000361505725757846*x_66 + 0.0046829651206698*x_67 + 0.00303259865766567*x_68 + 0.00480046233634745*x_69 + 0.0111724891051966*x_7 - 0.00455539660618248*x_71 + 0.00458370407083746*x_72 - 0.00252609266624972*x_73 + 3.7827602690177e-5*x_74 - 0.000371824121275807*x_75 - 0.00579947239235054*x_76 - 0.00713564155855381*x_77 - 0.00211140668000595*x_78 - 0.00360261942524866*x_79 + 0.0144609116100289*x_8 - 0.00258230515133213*x_80 + 5.05348878693327e-5*x_81 + 0.0148421742473824*x_82 + 0.000384997937125688*x_83 - 0.00235858472458889*x_84 + 0.00342768153162214*x_85 + 4.00489863770782e-5*x_86 + 0.00608963433041891*x_87 - 0.00658615475241853*x_88 + 0.00208105441583374*x_89 - 0.0138247819045034*x_9 - 0.000976204662419159*x_90 + 0.0317751739532828*x_91 - 0.000284708219276372*x_92 - 0.0393517407146791*x_93 + 0.00422627183852838*x_94 - 0.00127557228687884*x_95 + 0.00498717876899337*x_96 - 0.000595296482765221*x_97 - 0.00561800261429044*x_98 - 0.00136951889528923*x_99 + 7.12281361184618e-6*std::pow(-7.63032007217407*x_114 - 9.03103923797607, 2) + 8.708918006228e-6*std::pow(-8.24623966217041*x_115 - 9.84912014007568, 2) + 1.77812651293532e-5*std::pow(-5.6736798286438*x_15 - 7.62943983078003, 2) - 7.6798193843729e-6*std::pow(-5.82647943496704*x_40 - 6.01991987228394, 2) + 9.45130892195437e-6*std::pow(-5.20471954345703*x_56 - 4.8187198638916, 2) - 1.42653735626683e-6*std::pow(-9.47784042358398*x_59 - 9.54600048065186, 2) - 1.14118874254782e-5*std::pow(-6.42759990692139*x_59 - 7.42335987091064, 2) + 1.50947565978169e-5*std::pow(-6.70647954940796*x_7 - 9.27136039733887, 2) - 2.43460310482687e-6*std::pow(-6.94496011734009*x_70 - 9.19479942321777, 2) - 2.52040651757222e-5*std::pow(-5.8473596572876*x_70 - 8.2651195526123, 2) + 2.29099421609383e-5*std::pow(-7.79071998596191*x_71 - 9.37960052490234, 2) - 2.64147156406618e-6*std::pow(-8.39999961853027*x_84 - 6.35200023651123, 2) + 0.000122372547213802*std::pow(-5.13184022903442*x_86 - 7.89423990249634, 2) - 4.38801497570235e-5*std::pow(-9.01288032531738*x_89 - 8.98544025421143, 2) + 0.000123782228022072*std::exp(0.783919870853424*x_1) + 1.192375162881e-6*std::exp(1.17175984382629*x_1) + 0.000506809442040022*std::exp(1.17815983295441*x_1) - 1.17793003921878e-5*std::exp(1.26551985740662*x_1) - 9.44804635988881e-5*std::exp(1.30431985855103*x_1) - 0.000374827686060948*std::exp(1.37551987171173*x_100) + 3.21892415621376e-5*std::exp(1.68319988250732*x_100) + 0.00100830141416096*std::exp(1.04447984695435*x_104) - 0.00305498891706029*std::exp(0.591199815273285*x_108) - 0.00207849132273454*std::exp(0.572079837322235*x_109) + 0.00112167410826966*std::exp(0.707839846611023*x_109) + 0.00796676212147018*std::exp(0.873599886894226*x_109) - 0.000106525432560588*std::exp(1.00887978076935*x_109) - 0.000298846338454284*std::exp(1.26239991188049*x_110) + 4.61035434478469e-5*std::exp(0.642959833145142*x_112) - 0.00248753662735436*std::exp(0.843519866466522*x_112) + 0.00500943378741022*std::exp(0.757279872894287*x_114) - 0.000409964422925275*std::exp(0.615599870681763*x_26) + 0.0135394012843107*std::exp(0.734559834003448*x_26) + 7.11587046555289e-6*std::exp(1.43647980690002*x_26) - 0.00966571202429853*std::exp(0.60207986831665*x_31) + 0.000177185285955423*std::exp(0.623999834060669*x_31) + 0.0150984496832774*std::exp(0.63895982503891*x_31) - 0.00279960311574307*std::exp(0.642719864845276*x_31) + 0.0016541988811959*std::exp(0.659439861774445*x_31) + 0.000635793233737872*std::exp(1.0668797492981*x_50) + 7.96939437260758e-7*std::exp(2.77047991752625*x_6) + 0.00049419191934233*std::exp(1.22575986385345*x_66) + 0.000535839446146092*std::exp(1.55999982357025*x_66) - 0.000779502964448311*std::exp(1.14623987674713*x_68) + 0.00337957746239217*std::exp(1.21247982978821*x_68) + 0.00178321487966878*std::exp(0.705119848251343*x_70) - 0.000876725387155372*std::exp(0.99919980764389*x_72) + 0.00267638172449845*std::exp(0.636719882488251*x_74) + 0.00371934551832532*std::exp(1.1736798286438*x_74) - 0.00346711845416868*std::exp(1.25471985340118*x_74) + 2.26760263102352e-5*std::exp(1.5201598405838*x_74) + 2.54962957301317e-5*std::exp(1.60031986236572*x_77) - 0.00903775957612894*std::exp(0.726239860057831*x_81) - 0.000756705560766206*std::exp(1.06903982162476*x_81) - 7.1871208328877e-6*std::exp(1.76583993434906*x_81) + 0.00451525196939332*std::exp(0.691679835319519*x_90) - 0.00423981081424468*std::sin(0.340159833431244*x_100 - 7.4347996711731) - 0.000785828779466588*std::sin(0.351999849081039*x_102 + 5.17088031768799) - 0.00950153390163101*std::sin(0.376479834318161*x_102 + 1.99015986919403) + 0.0243261315997177*std::sin(0.384479850530624*x_102 + 5.17479991912842) - 0.00787247789528242*std::sin(0.193599998950958*x_111 + 4.98087978363037) - 0.00366303972941951*std::sin(0.207520008087158*x_111 + 1.80207979679108) + 0.00670154351232545*std::sin(0.414799869060516*x_111 - 1.19263982772827) - 0.00142178542398936*std::sin(0.628399848937988*x_112 - 4.1780800819397) + 0.00175833941207082*std::sin(0.409599870443344*x_115 + 5.1956000328064) - 0.0433439872156182*std::sin(0.428799867630005*x_115 + 5.23239994049072) + 0.000618203866621378*std::sin(0.420559853315353*x_117 - 7.37207984924316) + 0.0855418865799155*std::sin(0.296399921178818*x_120 + 5.10007953643799) - 0.0036984464598804*std::sin(0.621119856834412*x_120 - 3.98495984077454) + 0.0724678959722823*std::sin(0.462159872055054*x_2 - 4.12944030761719) + 0.0552952287547863*std::sin(0.419599860906601*x_24 - 7.37135982513428) - 0.0240842726358016*std::sin(0.386959850788116*x_28 - 7.39767980575562) + 0.117801294982749*std::sin(0.283039927482605*x_3 + 1.88183987140656) + 0.0069176353288103*std::sin(0.310239940881729*x_35 + 8.27095985412598) - 0.0916003986014313*std::sin(0.319999843835831*x_35 + 1.98159980773926) - 0.120631087707005*std::sin(0.199840009212494*x_36 + 1.8115998506546) + 0.00551124064865385*std::sin(0.417759865522385*x_36 + 5.21744012832642) - 0.029644619275422*std::sin(0.447279840707779*x_36 + 5.21871995925903) - 0.0498475725575278*std::sin(0.55215984582901*x_38 + 2.15399980545044) + 0.0404837110796433*std::sin(0.547839879989624*x_4 - 4.04007959365845) - 0.115933009473456*std::sin(0.261919975280762*x_43 - 1.34247982501984) - 0.00312526468035895*std::sin(0.307839840650558*x_43 - 1.27559983730316) + 0.00410781301715337*std::sin(0.465679854154587*x_45 + 5.24111986160278) + 0.0606842039068535*std::sin(0.397999823093414*x_51 + 1.99647974967957) + 0.0202583872367383*std::sin(0.222879990935326*x_53 + 5.02343988418579) - 0.0987356963569832*std::sin(0.250239968299866*x_53 + 5.05375957489014) + 0.00811351279130028*std::sin(0.297119915485382*x_55 + 5.12536001205444) - 0.0250542155229182*std::sin(0.26599994301796*x_63 + 1.87447988986969) - 0.00885088834047468*std::sin(0.280479967594147*x_64 - 7.5111198425293) + 0.00704052792701453*std::sin(0.430239856243134*x_64 + 2.03743982315063) - 0.00858957133153009*std::sin(0.607439875602722*x_64 + 8.60208034515381) + 0.0671361438180609*std::sin(0.203359991312027*x_66 + 4.99975967407227) + 0.0273634800811576*std::sin(0.303439915180206*x_70 - 4.24783992767334) - 0.00173155591615265*std::sin(0.647679805755615*x_70 + 5.42951965332031) + 0.0158402765559231*std::sin(0.208719998598099*x_73 - 4.37784004211426) + 0.0969850317742707*std::sin(0.255119979381561*x_73 - 7.54936027526855) - 0.00985799473498032*std::sin(0.537359833717346*x_75 + 2.13783979415894) + 0.000988695182410004*std::sin(0.465439856052399*x_76 + 8.45416069030762) + 0.0439463859090058*std::sin(0.470639854669571*x_80 + 5.25368022918701) - 0.00521078035698509*std::sin(0.394079834222794*x_81 - 7.40359973907471) - 0.00433572898815392*std::sin(0.251359969377518*x_84 + 1.85143995285034) + 0.00690311877316888*std::sin(0.22647999227047*x_86 - 4.36448001861572) + 0.00349330548037605*std::sin(0.388559848070145*x_87 + 5.18847990036011) - 0.00343819009363181*std::sin(0.750559866428375*x_87 - 0.815679848194122) - 0.00655603928450456*std::sin(0.330479830503464*x_92 + 8.39352035522461) + 0.0521566692735968*std::sin(0.341359823942184*x_92 + 1.98951983451843) - 0.0336742022249216*std::sin(0.366719841957092*x_92 - 1.19439995288849) - 0.00899679087659259*std::sin(0.353439837694168*x_95 - 7.42496013641357) - 0.00270723145754536*std::sin(0.360319852828979*x_95 + 4.98791980743408) + 0.0220315684530079*std::sin(0.394079834222794*x_95 - 1.00503981113434) - 0.0212010637246622*std::sin(0.370639860630035*x_96 - 7.42136001586914) - 0.00390511678074275*std::sin(0.416559875011444*x_96 - 7.38855981826782) + 0.00527221157635964*std::sin(0.400159865617752*x_97 - 7.40319967269897) - 0.058317537130103*std::sin(0.4511998295784*x_98 - 1.14263987541199) + 0.0587597320671207 - 1.2332531726517e-6*std::exp(-2.09607982635498*x_30));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0167248388976603*x_10 + 0.00756212908767935*x_100 - 0.0301975438169195*x_101 - 0.000370617645021822*x_102 - 0.0163695654955559*x_103 - 0.000966569698016645*x_104 + 0.0111550443387443*x_105 + 0.0129348500542485*x_106 + 0.0168485959149757*x_107 + 0.0011912753843475*x_108 + 0.00183030777204736*x_109 - 0.00608471705236321*x_11 - 0.0113362594609337*x_110 - 0.00110603938624055*x_111 + 0.00114403148232192*x_112 + 0.0352621992060564*x_113 - 0.0377956362990551*x_114 + 0.000743481475942495*x_115 + 0.00545338584834935*x_116 + 0.00844607230901363*x_117 - 0.00813023273538871*x_118 - 0.00396930830676514*x_119 + 0.0305421269353847*x_12 - 0.0462617260836666*x_120 + 0.0366449973442626*x_13 + 0.00679915375352725*x_14 + 0.00158410919155488*x_15 + 0.00823739671734311*x_16 - 0.00464346930142531*x_17 + 0.0115250387512748*x_18 - 0.0346838523151919*x_19 + 0.00159899168379515*x_2 + 0.0268821070241194*x_20 - 0.0100750551069166*x_21 + 6.94745049117583e-5*x_22 + 0.00904788487585849*x_23 + 0.000460796214999797*x_24 - 0.0211427906257003*x_25 - 0.0047411206509593*x_26 - 0.0279629912079797*x_27 + 0.000610894348738219*x_28 + 0.0145894040777184*x_29 + 0.00315130403379509*x_3 - 0.0604439747701571*x_30 + 0.111327182032161*x_32 + 0.019686186459537*x_33 - 0.00952447478835472*x_34 - 0.00122051599311906*x_35 + 0.000401848856615507*x_36 + 0.0144178194253515*x_37 + 0.00212598067225455*x_38 + 0.0283996884938969*x_39 - 9.45065410228369e-5*x_4 + 0.0300606973524396*x_40 + 0.0132452467521376*x_41 - 0.0442465588193744*x_42 - 0.0270967165508945*x_43 - 0.00984139789705401*x_44 - 0.0019507392415643*x_45 + 0.0160872746264822*x_46 + 0.0409508013072709*x_47 - 0.00514374224296243*x_48 - 0.00798583677061353*x_49 + 0.00347911816518081*x_5 + 0.0133168347651252*x_50 + 0.00437264110330105*x_51 - 0.00312681575524986*x_52 + 0.00655665927623449*x_53 - 0.00215446889992242*x_54 - 0.0309789316964351*x_55 + 0.00490880728170947*x_56 - 0.034661564212263*x_57 - 0.0387908141461646*x_58 - 0.0267621217450001*x_59 - 0.00790171136687973*x_6 - 0.00206305070636888*x_60 - 0.0369248284224792*x_61 + 0.00841892400683955*x_62 + 0.0404510577917022*x_63 - 0.00249533501223347*x_64 + 0.00988791743647365*x_65 + 0.000119692937752579*x_66 + 0.0171258636324033*x_67 + 0.0108451559379718*x_68 + 0.0110504936815076*x_69 + 0.0181283645012863*x_7 - 0.00477273510006822*x_71 + 0.00896948803461823*x_72 - 0.00185326891693719*x_73 + 0.000123523855394977*x_74 - 0.00288672379849929*x_75 - 0.0194951474740544*x_76 - 0.0186656221877293*x_77 - 0.00866153248230369*x_78 - 0.0233333241778771*x_79 + 0.0508414876317842*x_8 - 0.000227404651263031*x_80 + 4.59923947686718e-5*x_81 + 0.0320242726732915*x_82 - 0.00499265667510883*x_83 - 0.00814696147115299*x_84 + 0.0125108066521761*x_85 + 0.000114013769090454*x_86 + 0.0182681368744395*x_87 - 0.0190635979198467*x_88 + 0.00774741217716272*x_89 - 0.0574326819305282*x_9 + 0.00484163715826945*x_90 + 0.0471516281215569*x_91 + 0.00031894034634766*x_92 - 0.0948145042745715*x_93 + 0.0272568267415957*x_94 - 0.000919487439471126*x_95 + 0.0159527437077659*x_96 - 0.00940213939631592*x_97 - 0.0179905094642964*x_98 + 0.00238332832620666*x_99 + 8.48624789717219e-6*std::pow(-7.63032007217407*x_114 - 9.03103923797607, 2) - 5.40164029655953e-6*std::pow(-8.24623966217041*x_115 - 9.84912014007568, 2) - 1.10286947446096e-5*std::pow(-5.6736798286438*x_15 - 7.62943983078003, 2) - 9.14987456542533e-6*std::pow(-5.82647943496704*x_40 - 6.01991987228394, 2) + 1.12604589752379e-5*std::pow(-5.20471954345703*x_56 - 4.8187198638916, 2) - 4.65827548085131e-6*std::pow(-9.47784042358398*x_59 - 9.54600048065186, 2) + 7.07813656451715e-6*std::pow(-6.42759990692139*x_59 - 7.42335987091064, 2) - 9.36240821732582e-6*std::pow(-6.70647954940796*x_7 - 9.27136039733887, 2) - 7.9500560563646e-6*std::pow(-6.94496011734009*x_70 - 9.19479942321777, 2) - 2.2938515631705e-5*std::pow(-5.8473596572876*x_70 - 8.2651195526123, 2) + 7.2036330530602e-5*std::pow(-7.79071998596191*x_71 - 9.37960052490234, 2) + 1.63835269002101e-6*std::pow(-8.39999961853027*x_84 - 6.35200023651123, 2) + 0.000384779201843435*std::pow(-5.13184022903442*x_86 - 7.89423990249634, 2) - 3.99358394808705e-5*std::pow(-9.01288032531738*x_89 - 8.98544025421143, 2) - 7.67749874787875e-5*std::exp(0.783919870853424*x_1) + 3.89363234045284e-6*std::exp(1.17175984382629*x_1) + 0.00159357418828724*std::exp(1.17815983295441*x_1) - 1.40340697694396e-5*std::exp(1.26551985740662*x_1) - 8.59877791952954e-5*std::exp(1.30431985855103*x_1) + 0.000232484027504344*std::exp(1.37551987171173*x_100) + 0.000105112112246753*std::exp(1.68319988250732*x_100) + 0.00317042851678668*std::exp(1.04447984695435*x_104) - 0.00960588157974065*std::exp(0.591199815273285*x_108) + 0.00128916846810399*std::exp(0.572079837322235*x_109) + 0.00133638265176347*std::exp(0.707839846611023*x_109) + 0.0250500985733349*std::exp(0.873599886894226*x_109) - 0.000347852657628722*std::exp(1.00887978076935*x_109) - 0.000356050887961947*std::exp(1.26239991188049*x_110) + 0.000150548462737415*std::exp(0.642959833145142*x_112) - 0.00782162649893562*std::exp(0.843519866466522*x_112) + 0.00455914450456138*std::exp(0.757279872894287*x_114) - 0.00133871518396953*std::exp(0.615599870681763*x_26) + 0.0425722936902917*std::exp(0.734559834003448*x_26) - 4.41356464997611e-6*std::exp(1.43647980690002*x_26) - 0.00879687799627261*std::exp(0.60207986831665*x_31) + 0.000578588334548589*std::exp(0.623999834060669*x_31) + 0.0474744503606241*std::exp(0.63895982503891*x_31) + 0.00173643258480065*std::exp(0.642719864845276*x_31) + 0.0019708422179834*std::exp(0.659439861774445*x_31) - 0.000394345927838842*std::exp(1.0668797492981*x_50) + 2.60235977978893e-6*std::exp(2.77047991752625*x_6) + 0.00058878911689384*std::exp(1.22575986385345*x_66) + 0.000487673771108398*std::exp(1.55999982357025*x_66) + 0.000483480797619232*std::exp(1.14623987674713*x_68) + 0.00307579312738464*std::exp(1.21247982978821*x_68) - 0.00110602549530896*std::exp(0.705119848251343*x_70) + 0.000543782267428461*std::exp(0.99919980764389*x_72) - 0.00166000545207657*std::exp(0.636719882488251*x_74) + 0.00338502002422999*std::exp(1.1736798286438*x_74) - 0.0109017512658363*std::exp(1.25471985340118*x_74) + 2.7016624479884e-5*std::exp(1.5201598405838*x_74) - 1.58138839211013e-5*std::exp(1.60031986236572*x_77) - 0.0284176638905785*std::exp(0.726239860057831*x_81) + 0.000469340881007533*std::exp(1.06903982162476*x_81) - 2.3469128660865e-5*std::exp(1.76583993434906*x_81) + 0.00410938382990624*std::exp(0.691679835319519*x_90) - 0.0050513866524532*std::sin(0.340159833431244*x_100 - 7.4347996711731) - 0.00256607856741735*std::sin(0.351999849081039*x_102 + 5.17088031768799) + 0.00589325429008212*std::sin(0.376479834318161*x_102 + 1.99015986919403) + 0.0764892920347911*std::sin(0.384479850530624*x_102 + 5.17479991912842) - 0.00937941137098755*std::sin(0.193599998950958*x_111 + 4.98087978363037) - 0.0119614450206851*std::sin(0.207520008087158*x_111 + 1.80207979679108) - 0.00415658150179357*std::sin(0.414799869060516*x_111 - 1.19263982772827) + 0.000881851618512163*std::sin(0.628399848937988*x_112 - 4.1780800819397) + 0.00574175596193216*std::sin(0.409599870443344*x_115 + 5.1956000328064) - 0.136287633012976*std::sin(0.428799867630005*x_115 + 5.23239994049072) + 0.00201870907999635*std::sin(0.420559853315353*x_117 - 7.37207984924316) + 0.077852675304499*std::sin(0.296399921178818*x_120 + 5.10007953643799) + 0.00229393334718174*std::sin(0.621119856834412*x_120 - 3.98495984077454) + 0.227862701286837*std::sin(0.462159872055054*x_2 - 4.12944030761719) + 0.173866234465513*std::sin(0.419599860906601*x_24 - 7.37135982513428) - 0.0757288085667818*std::sin(0.386959850788116*x_28 - 7.39767980575562) + 0.370405693855436*std::sin(0.283039927482605*x_3 + 1.88183987140656) - 0.00429061081092779*std::sin(0.310239940881729*x_35 + 8.27095985412598) - 0.288021529868294*std::sin(0.319999843835831*x_35 + 1.98159980773926) - 0.109787769224709*std::sin(0.199840009212494*x_36 + 1.8115998506546) + 0.00656619096246802*std::sin(0.417759865522385*x_36 + 5.21744012832642) - 0.0932123519813675*std::sin(0.447279840707779*x_36 + 5.21871995925903) - 0.156737026557171*std::sin(0.55215984582901*x_38 + 2.15399980545044) + 0.127293991925082*std::sin(0.547839879989624*x_4 - 4.04007959365845) - 0.105511993065272*std::sin(0.261919975280762*x_43 - 1.34247982501984) + 0.00193842169862762*std::sin(0.307839840650558*x_43 - 1.27559983730316) - 0.00254783984742071*std::sin(0.465679854154587*x_45 + 5.24111986160278) + 0.190810930028184*std::sin(0.397999823093414*x_51 + 1.99647974967957) + 0.024136205923169*std::sin(0.222879990935326*x_53 + 5.02343988418579) - 0.310457233282229*std::sin(0.250239968299866*x_53 + 5.05375957489014) + 0.00966658466948223*std::sin(0.297119915485382*x_55 + 5.12536001205444) + 0.0155396870277687*std::sin(0.26599994301796*x_63 + 1.87447988986969) - 0.0105451071248783*std::sin(0.280479967594147*x_64 - 7.5111198425293) - 0.00436683401226396*std::sin(0.430239856243134*x_64 + 2.03743982315063) - 0.0270084138671148*std::sin(0.607439875602722*x_64 + 8.60208034515381) + 0.211097933493421*std::sin(0.203359991312027*x_66 + 4.99975967407227) + 0.0860397063312832*std::sin(0.303439915180206*x_70 - 4.24783992767334) - 0.00206300677696349*std::sin(0.647679805755615*x_70 + 5.42951965332031) - 0.00982481131317721*std::sin(0.208719998598099*x_73 - 4.37784004211426) + 0.304952572832081*std::sin(0.255119979381561*x_73 - 7.54936027526855) - 0.00897187674881231*std::sin(0.537359833717346*x_75 + 2.13783979415894) + 0.00117794917428654*std::sin(0.465439856052399*x_76 + 8.45416069030762) + 0.138181770985181*std::sin(0.470639854669571*x_80 + 5.25368022918701) - 0.0062082171816973*std::sin(0.394079834222794*x_81 - 7.40359973907471) - 0.00516566528530752*std::sin(0.251359969377518*x_84 + 1.85143995285034) - 0.00428160702746538*std::sin(0.22647999227047*x_86 - 4.36448001861572) + 0.00416198680781394*std::sin(0.388559848070145*x_87 + 5.18847990036011) - 0.0031291371712336*std::sin(0.750559866428375*x_87 - 0.815679848194122) - 0.00781098279749658*std::sin(0.330479830503464*x_92 + 8.39352035522461) + 0.16399757977452*std::sin(0.341359823942184*x_92 + 1.98951983451843) - 0.0306472868061621*std::sin(0.366719841957092*x_92 - 1.19439995288849) + 0.00558019125957648*std::sin(0.353439837694168*x_95 - 7.42496013641357) - 0.00322544411741218*std::sin(0.360319852828979*x_95 + 4.98791980743408) + 0.069274437099821*std::sin(0.394079834222794*x_95 - 1.00503981113434) - 0.0192953370127525*std::sin(0.370639860630035*x_96 - 7.42136001586914) + 0.00242211904516105*std::sin(0.416559875011444*x_96 - 7.38855981826782) - 0.00327004921650267*std::sin(0.400159865617752*x_97 - 7.40319967269897) - 0.0530754752352395*std::sin(0.4511998295784*x_98 - 1.14263987541199) - 0.00379009818318026 - 1.46931995043231e-6*std::exp(-2.09607982635498*x_30));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00303356262347408*x_10 - 0.00380451653615209*x_100 + 0.0085226343453593*x_101 + 0.000285104379638226*x_102 + 0.00777870085974875*x_103 + 0.000385651160022326*x_104 - 0.00150714060998768*x_105 - 0.00161199630111327*x_106 - 0.00608884955735007*x_107 - 0.0027454574956066*x_108 - 0.00216157881464554*x_109 - 0.00233003762085743*x_11 + 0.00304761741545277*x_110 + 0.00202793439717513*x_111 - 0.000481962066851461*x_112 - 0.0120725147184241*x_113 + 0.0169107583522569*x_114 - 0.000860130582810475*x_115 - 0.00387819786836894*x_116 - 0.00399248081743392*x_117 + 0.00614148780292408*x_118 - 0.00338817599234194*x_119 - 0.0140818216200029*x_12 + 0.018929856736834*x_120 - 0.0163818505588048*x_13 - 0.00357152681899746*x_14 - 0.000562513713727048*x_15 - 0.0100216666122932*x_16 + 0.00278763202883007*x_17 - 0.00717294193806028*x_18 + 0.0124908860260092*x_19 - 5.74318389225553e-5*x_2 - 0.0117132581490336*x_20 + 0.00671051464881488*x_21 - 0.00822629342361145*x_22 - 0.00595996061763675*x_23 - 0.00126135222675976*x_24 + 0.0151624766361335*x_25 + 0.00543567373929876*x_26 + 0.0114215590114222*x_27 + 0.000342976070648791*x_28 - 0.00415636862711026*x_29 - 0.00411692536090243*x_3 + 0.0244888181593737*x_30 - 0.0496515614108115*x_32 - 0.0132903740676328*x_33 + 0.00646677412564334*x_34 + 0.00147598581505441*x_35 - 0.000387103428142435*x_36 - 0.00655702187438072*x_37 - 0.00442964081361665*x_38 - 0.0119346079625631*x_39 + 0.00166377949780918*x_4 - 0.0130700185287448*x_40 - 0.011193284702108*x_41 + 0.0235872700120435*x_42 + 0.01106519921596*x_43 + 0.00623858565743309*x_44 + 0.00192682619171721*x_45 - 0.00118250568599894*x_46 - 0.0165580156450191*x_47 - 0.00183268107318914*x_48 + 0.000616411083422252*x_49 - 0.00709709497566145*x_5 - 0.0067439398839674*x_50 - 0.00396396231355922*x_51 - 0.00284478374975855*x_52 - 0.00708369578539731*x_53 - 0.00344568604986618*x_54 + 0.0116607614565381*x_55 - 0.00166084593141246*x_56 + 0.0186564981228961*x_57 + 0.0201778120117248*x_58 + 0.0124077840893476*x_59 + 0.00369355868164853*x_6 - 0.00187743962617002*x_60 + 0.0211562631765263*x_61 - 0.00589693620262891*x_62 - 0.016086284883913*x_63 + 0.00322879851440684*x_64 - 0.0040749255058672*x_65 - 0.000735272444673556*x_66 - 0.00600060500033693*x_67 - 0.00518357885649462*x_68 - 0.00267907232622385*x_69 - 0.0107795730674977*x_7 + 0.00304908980285687*x_71 - 0.00475588153875635*x_72 + 0.0045622126688009*x_73 + 0.000151338668089673*x_74 + 0.0028271554599887*x_75 + 0.010473079192757*x_76 + 0.00885077630997576*x_77 + 0.00489077885488831*x_78 + 0.00612136857289448*x_79 - 0.0255962218963296*x_8 - 0.00315222906793029*x_80 - 5.43166497378579e-5*x_81 - 0.0172963564457408*x_82 + 0.00376397338715603*x_83 + 0.00247751609485534*x_84 - 0.00358388296146331*x_85 + 7.54825239455734e-6*x_86 - 0.00759085150066028*x_87 + 0.00834994864811883*x_88 - 0.00426030487200494*x_89 + 0.0170824989792466*x_9 - 0.00560472320211807*x_90 - 0.0311036868470838*x_91 - 0.000456205375407785*x_92 + 0.0581206968442476*x_93 - 0.00733675574417597*x_94 + 0.00189128611820462*x_95 - 0.00675915476206068*x_96 + 0.00425637684175456*x_97 + 0.00878199673941002*x_98 + 0.000923719425000047*x_99 + 6.1897512245888e-6*std::pow(-7.63032007217407*x_114 - 9.03103923797607, 2) + 1.63361132148313e-5*std::pow(-8.24623966217041*x_115 - 9.84912014007568, 2) + 3.33539436297731e-5*std::pow(-5.6736798286438*x_15 - 7.62943983078003, 2) - 6.67379128943989e-6*std::pow(-5.82647943496704*x_40 - 6.01991987228394, 2) + 8.21322221268555e-6*std::pow(-5.20471954345703*x_56 - 4.8187198638916, 2) - 5.70721505261149e-6*std::pow(-9.47784042358398*x_59 - 9.54600048065186, 2) - 2.14063199176066e-5*std::pow(-6.42759990692139*x_59 - 7.42335987091064, 2) + 2.83146141180702e-5*std::pow(-6.70647954940796*x_7 - 9.27136039733887, 2) - 9.74023107489066e-6*std::pow(-6.94496011734009*x_70 - 9.19479942321777, 2) + 2.70902031812091e-5*std::pow(-5.8473596572876*x_70 - 8.2651195526123, 2) - 3.04978834323358e-5*std::pow(-7.79071998596191*x_71 - 9.37960052490234, 2) - 4.9548495569121e-6*std::pow(-8.39999961853027*x_84 - 6.35200023651123, 2) - 0.000162903234500862*std::pow(-5.13184022903442*x_86 - 7.89423990249634, 2) + 4.71639064671475e-5*std::pow(-9.01288032531738*x_89 - 8.98544025421143, 2) + 0.000232189634752164*std::exp(0.783919870853424*x_1) + 4.77039135923028e-6*std::exp(1.17175984382629*x_1) - 0.000674668455169538*std::exp(1.17815983295441*x_1) - 1.02362553620782e-5*std::exp(1.26551985740662*x_1) + 0.000101550878308875*std::exp(1.30431985855103*x_1) - 0.000703098537747857*std::exp(1.37551987171173*x_100) + 0.000128781011705393*std::exp(1.68319988250732*x_100) - 0.00134225825529019*std::exp(1.04447984695435*x_104) + 0.00406682370584241*std::exp(0.591199815273285*x_108) - 0.00389881608024717*std::exp(0.572079837322235*x_109) + 0.000974738925318047*std::exp(0.707839846611023*x_109) - 0.0106054123055802*std::exp(0.873599886894226*x_109) - 0.000426181305049555*std::exp(1.00887978076935*x_109) - 0.000259698567197497*std::exp(1.26239991188049*x_110) + 0.00018444861327211*std::exp(0.642959833145142*x_112) + 0.00331142704603021*std::exp(0.843519866466522*x_112) - 0.00538431313272734*std::exp(0.757279872894287*x_114) - 0.00164016393631452*std::exp(0.615599870681763*x_26) - 0.0180237505276885*std::exp(0.734559834003448*x_26) + 1.33478883902932e-5*std::exp(1.43647980690002*x_26) + 0.0103890424343739*std::exp(0.60207986831665*x_31) + 0.000708873501744394*std::exp(0.623999834060669*x_31) - 0.0200991672180949*std::exp(0.63895982503891*x_31) - 0.00525147135644945*std::exp(0.642719864845276*x_31) + 0.00143750491148144*std::exp(0.659439861774445*x_31) + 0.0011926154592497*std::exp(1.0668797492981*x_50) + 3.18835306511495e-6*std::exp(2.77047991752625*x_6) + 0.000429454595420506*std::exp(1.22575986385345*x_66) - 0.000575938816512296*std::exp(1.55999982357025*x_66) - 0.00146218493151706*std::exp(1.14623987674713*x_68) - 0.00363248704066311*std::exp(1.21247982978821*x_68) + 0.00334493907736973*std::exp(0.705119848251343*x_70) - 0.00164455391274147*std::exp(0.99919980764389*x_72) + 0.00502033373448291*std::exp(0.636719882488251*x_74) - 0.00399768152835947*std::exp(1.1736798286438*x_74) + 0.00461545357550593*std::exp(1.25471985340118*x_74) + 1.97055502602442e-5*std::exp(1.5201598405838*x_74) + 4.78257314293685e-5*std::exp(1.60031986236572*x_77) + 0.0120311319909054*std::exp(0.726239860057831*x_81) - 0.00141942175849273*std::exp(1.06903982162476*x_81) - 2.87538521316661e-5*std::exp(1.76583993434906*x_81) - 0.00485314937937248*std::exp(0.691679835319519*x_90) - 0.00368441119052303*std::sin(0.340159833431244*x_100 - 7.4347996711731) - 0.00314390213424466*std::sin(0.351999849081039*x_102 + 5.17088031768799) - 0.0178228952690335*std::sin(0.376479834318161*x_102 + 1.99015986919403) - 0.0323831252246803*std::sin(0.384479850530624*x_102 + 5.17479991912842) - 0.0068412122439692*std::sin(0.193599998950958*x_111 + 4.98087978363037) - 0.0146548952189841*std::sin(0.207520008087158*x_111 + 1.80207979679108) + 0.0125706974681787*std::sin(0.414799869060516*x_111 - 1.19263982772827) - 0.00266697282450898*std::sin(0.628399848937988*x_112 - 4.1780800819397) + 0.00703467113292585*std::sin(0.409599870443344*x_115 + 5.1956000328064) + 0.0576998344346949*std::sin(0.428799867630005*x_115 + 5.23239994049072) + 0.00247327726656757*std::sin(0.420559853315353*x_117 - 7.37207984924316) - 0.0919433857910367*std::sin(0.296399921178818*x_120 + 5.10007953643799) - 0.00693751394196057*std::sin(0.621119856834412*x_120 - 3.98495984077454) - 0.0964697958826616*std::sin(0.462159872055054*x_2 - 4.12944030761719) - 0.0736094150339289*std::sin(0.419599860906601*x_24 - 7.37135982513428) + 0.0320611607938337*std::sin(0.386959850788116*x_28 - 7.39767980575562) - 0.156817949924276*std::sin(0.283039927482605*x_3 + 1.88183987140656) + 0.0129760406320908*std::sin(0.310239940881729*x_35 + 8.27095985412598) + 0.121939124039566*std::sin(0.319999843835831*x_35 + 1.98159980773926) + 0.129658475851778*std::sin(0.199840009212494*x_36 + 1.8115998506546) + 0.00478928839261973*std::sin(0.417759865522385*x_36 + 5.21744012832642) + 0.03946313511866*std::sin(0.447279840707779*x_36 + 5.21871995925903) + 0.0663574550544443*std::sin(0.55215984582901*x_38 + 2.15399980545044) - 0.053892213814509*std::sin(0.547839879989624*x_4 - 4.04007959365845) + 0.12460881846434*std::sin(0.261919975280762*x_43 - 1.34247982501984) - 0.00586234450802575*std::sin(0.307839840650558*x_43 - 1.27559983730316) + 0.00770540019616511*std::sin(0.465679854154587*x_45 + 5.24111986160278) - 0.0807832583746476*std::sin(0.397999823093414*x_51 + 1.99647974967957) + 0.0176046130139146*std::sin(0.222879990935326*x_53 + 5.02343988418579) + 0.131437684868535*std::sin(0.250239968299866*x_53 + 5.05375957489014) + 0.00705067245507369*std::sin(0.297119915485382*x_55 + 5.12536001205444) - 0.0469964811930116*std::sin(0.26599994301796*x_63 + 1.87447988986969) - 0.00769145451918572*std::sin(0.280479967594147*x_64 - 7.5111198425293) + 0.0132065615069105*std::sin(0.430239856243134*x_64 + 2.03743982315063) + 0.0114345005047367*std::sin(0.607439875602722*x_64 + 8.60208034515381) - 0.0893721282173632*std::sin(0.203359991312027*x_66 + 4.99975967407227) - 0.0364264658529373*std::sin(0.303439915180206*x_70 - 4.24783992767334) - 0.00150472845935833*std::sin(0.647679805755615*x_70 + 5.42951965332031) + 0.0297130540196549*std::sin(0.208719998598099*x_73 - 4.37784004211426) - 0.129107187305616*std::sin(0.255119979381561*x_73 - 7.54936027526855) + 0.0105957145590604*std::sin(0.537359833717346*x_75 + 2.13783979415894) + 0.000859179749683379*std::sin(0.465439856052399*x_76 + 8.45416069030762) - 0.0585017520040046*std::sin(0.470639854669571*x_80 + 5.25368022918701) - 0.00452818729414315*std::sin(0.394079834222794*x_81 - 7.40359973907471) - 0.00376776443641277*std::sin(0.251359969377518*x_84 + 1.85143995285034) + 0.0129488106023353*std::sin(0.22647999227047*x_86 - 4.36448001861572) + 0.00303569530993469*std::sin(0.388559848070145*x_87 + 5.18847990036011) + 0.00369548592906451*std::sin(0.750559866428375*x_87 - 0.815679848194122) - 0.00569722224967729*std::sin(0.330479830503464*x_92 + 8.39352035522461) - 0.0694313415787295*std::sin(0.341359823942184*x_92 + 1.98951983451843) + 0.0361942001767622*std::sin(0.366719841957092*x_92 - 1.19439995288849) - 0.0168761026599485*std::sin(0.353439837694168*x_95 - 7.42496013641357) - 0.00235259409311476*std::sin(0.360319852828979*x_95 + 4.98791980743408) - 0.029328585894773*std::sin(0.394079834222794*x_95 - 1.00503981113434) + 0.022787638420809*std::sin(0.370639860630035*x_96 - 7.42136001586914) - 0.00732518434571662*std::sin(0.416559875011444*x_96 - 7.38855981826782) + 0.0098895689616509*std::sin(0.400159865617752*x_97 - 7.40319967269897) + 0.0626817110203306*std::sin(0.4511998295784*x_98 - 1.14263987541199) + 0.0886354321213866 - 1.07170154262542e-6*std::exp(-2.09607982635498*x_30));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0147285670801191*x_10 + 0.00510139444644824*x_100 - 0.0254352388528689*x_101 + 2.09722636437786e-5*x_102 - 0.0106508174369222*x_103 + 0.00128242424501964*x_104 + 0.0138011113295547*x_105 + 0.0139259011701272*x_106 + 0.0165381942897696*x_107 - 0.00442967753145307*x_108 + 0.000120856599815009*x_109 - 0.00828114818114659*x_11 - 0.016336234004593*x_110 + 0.000574873062168614*x_111 - 0.000183299885801766*x_112 + 0.0322460227252844*x_113 - 0.024352545036851*x_114 + 4.37572358826471e-5*x_115 + 0.00281320354624*x_116 + 0.00593556820761413*x_117 + 0.000395892863760994*x_118 - 0.00494920448768563*x_119 + 0.0511765698445968*x_12 - 0.0331957848276052*x_120 + 0.0281305335605862*x_13 + 0.00655399931709348*x_14 + 0.00138088208163981*x_15 + 0.000126713905693322*x_16 - 0.000827392236206281*x_17 + 0.00342051023396008*x_18 - 0.0283699135081708*x_19 + 0.00387665451081038*x_2 + 0.0159744243246178*x_20 + 0.00417078027335049*x_21 - 0.00223147601083534*x_22 - 0.00417029792623822*x_23 + 5.71832750002385e-5*x_24 - 0.00233951604033119*x_25 - 0.000264351368666903*x_26 - 0.0223020503111721*x_27 + 0.00620549933684325*x_28 + 0.00923423071604901*x_29 + 0.00788008655153807*x_3 - 0.0440614667094399*x_30 + 0.0963107045895333*x_32 - 0.00564479461564147*x_33 - 0.00405604780614086*x_34 - 0.000348513939072141*x_35 + 0.000102960803555925*x_36 + 0.0206873165789585*x_37 - 0.00436681753515957*x_38 + 0.0233324910548136*x_39 + 0.0154210108291464*x_4 + 0.0171898979213997*x_40 + 0.0118769623115318*x_41 - 0.0287586280058861*x_42 - 0.0175895087782421*x_43 + 0.00576082897073623*x_44 + 0.00152478178314909*x_45 + 0.0222758447554722*x_46 + 0.0369810232013902*x_47 - 0.0147322131675804*x_48 - 0.00450489301900254*x_49 - 0.00106644013369073*x_5 + 0.00674628590460958*x_50 + 0.00475166923632197*x_51 - 0.00613375439258207*x_52 + 0.00310689305347875*x_53 + 0.000676893213086636*x_54 - 0.0215875040965073*x_55 + 0.0104378055463445*x_56 - 0.014366618436276*x_57 - 0.0200436067032872*x_58 - 0.018381981988176*x_59 - 0.004244543262211*x_6 - 0.00101149852120838*x_60 - 0.021408693294177*x_61 + 0.000308006833009601*x_62 + 0.0279866720954659*x_63 + 0.000938829620290964*x_64 + 0.00660055216121595*x_65 - 0.00258465925373891*x_66 + 0.0110083701439854*x_67 + 0.0108021648026628*x_68 + 0.013385671142122*x_69 + 0.0108832132361074*x_7 - 0.00150539853349374*x_71 + 0.00899090145059792*x_72 + 0.00281597680977974*x_73 + 0.00117202578195772*x_74 - 0.00297966237713167*x_75 - 0.00371952841180741*x_76 - 0.0111044159873676*x_77 + 0.00249130062888376*x_78 - 0.0229217733583638*x_79 + 0.0268462991496435*x_8 - 0.0115526147289217*x_80 + 3.03691244389661e-6*x_81 + 0.0202644528460496*x_82 - 0.00244821448745681*x_83 - 0.0102610673563994*x_84 + 0.0155546544700841*x_85 + 0.00140000828982137*x_86 + 0.0137272102765015*x_87 - 0.0178475515442511*x_88 + 0.00552095828962716*x_89 - 0.0600787677220468*x_9 - 0.00845240202376926*x_90 + 0.0302931069642858*x_91 - 0.000546698685858302*x_92 - 0.0333167615162142*x_93 + 0.0211510816784096*x_94 + 0.00309303635852943*x_95 + 0.0130762301554159*x_96 - 0.00643325492567052*x_97 - 0.0155377105396536*x_98 + 0.00268937066393433*x_99 - 4.26782874500468e-6*std::pow(-7.63032007217407*x_114 - 9.03103923797607, 2) + 4.55788013975315e-5*std::pow(-8.24623966217041*x_115 - 9.84912014007568, 2) + 9.30596374139778e-5*std::pow(-5.6736798286438*x_15 - 7.62943983078003, 2) + 4.60157400027424e-6*std::pow(-5.82647943496704*x_40 - 6.01991987228394, 2) - 5.66301044687608e-6*std::pow(-5.20471954345703*x_56 - 4.8187198638916, 2) - 4.41989034876032e-5*std::pow(-9.47784042358398*x_59 - 9.54600048065186, 2) - 5.9725002596751e-5*std::pow(-6.42759990692139*x_59 - 7.42335987091064, 2) + 7.89995855540226e-5*std::pow(-6.70647954940796*x_7 - 9.27136039733887, 2) - 7.54321554834447e-5*std::pow(-6.94496011734009*x_70 - 9.19479942321777, 2) - 1.51464745240647e-6*std::pow(-5.8473596572876*x_70 - 8.2651195526123, 2) + 5.3751850180444e-5*std::pow(-7.79071998596191*x_71 - 9.37960052490234, 2) - 1.38243473792843e-5*std::pow(-8.39999961853027*x_84 - 6.35200023651123, 2) + 0.000287113375399555*std::pow(-5.13184022903442*x_86 - 7.89423990249634, 2) - 2.63699353962593e-6*std::pow(-9.01288032531738*x_89 - 8.98544025421143, 2) + 0.000647823941335458*std::exp(0.783919870853424*x_1) + 3.69437747379498e-5*std::exp(1.17175984382629*x_1) + 0.00118908834457982*std::exp(1.17815983295441*x_1) + 7.05789025929516e-6*std::exp(1.26551985740662*x_1) - 5.67783778110859e-6*std::exp(1.30431985855103*x_1) - 0.00196168991935058*std::exp(1.37551987171173*x_100) + 0.000997330476411266*std::exp(1.68319988250732*x_100) + 0.00236570071499866*std::exp(1.04447984695435*x_104) - 0.00716768752270023*std::exp(0.591199815273285*x_108) - 0.0108779463921537*std::exp(0.572079837322235*x_109) - 0.000672081745033896*std::exp(0.707839846611023*x_109) + 0.0186918064204734*std::exp(0.873599886894226*x_109) - 0.00330051455858261*std::exp(1.00887978076935*x_109) + 0.000179061963866834*std::exp(1.26239991188049*x_110) + 0.00142844213531184*std::exp(0.642959833145142*x_112) - 0.00583631748926432*std::exp(0.843519866466522*x_112) + 0.000301043743189829*std::exp(0.757279872894287*x_114) - 0.0127020704243204*std::exp(0.615599870681763*x_26) + 0.0317664647188866*std::exp(0.734559834003448*x_26) + 3.7241462887589e-5*std::exp(1.43647980690002*x_26) - 0.00058086447528316*std::exp(0.60207986831665*x_31) + 0.0054897933930461*std::exp(0.623999834060669*x_31) + 0.0354243410843801*std::exp(0.63895982503891*x_31) - 0.0146519411840956*std::exp(0.642719864845276*x_31) - 0.000991158539285798*std::exp(0.659439861774445*x_31) + 0.0033274734599303*std::exp(1.0668797492981*x_50) + 2.46918519996784e-5*std::exp(2.77047991752625*x_6) - 0.000296108615759716*std::exp(1.22575986385345*x_66) + 3.22014661660952e-5*std::exp(1.55999982357025*x_66) - 0.00407958954028146*std::exp(1.14623987674713*x_68) + 0.000203096935273497*std::exp(1.21247982978821*x_68) + 0.00933259410542423*std::exp(0.705119848251343*x_70) - 0.00458841066970111*std::exp(0.99919980764389*x_72) + 0.014007052425762*std::exp(0.636719882488251*x_74) + 0.00022351542001952*std::exp(1.1736798286438*x_74) - 0.00813463562662677*std::exp(1.25471985340118*x_74) - 1.35869618641081e-5*std::exp(1.5201598405838*x_74) + 0.000133436851584245*std::exp(1.60031986236572*x_77) - 0.0212046060740932*std::exp(0.726239860057831*x_81) - 0.00396027755065624*std::exp(1.06903982162476*x_81) - 0.000222681066605821*std::exp(1.76583993434906*x_81) + 0.000271345707318778*std::exp(0.691679835319519*x_90) + 0.00254039870372589*std::sin(0.340159833431244*x_100 - 7.4347996711731) - 0.0243476066216159*std::sin(0.351999849081039*x_102 + 5.17088031768799) - 0.0497270184843459*std::sin(0.376479834318161*x_102 + 1.99015986919403) + 0.0570745474620715*std::sin(0.384479850530624*x_102 + 5.17479991912842) + 0.00471701062063757*std::sin(0.193599998950958*x_111 + 4.98087978363037) - 0.11349323504262*std::sin(0.207520008087158*x_111 + 1.80207979679108) + 0.0350730504738663*std::sin(0.414799869060516*x_111 - 1.19263982772827) - 0.00744102486940092*std::sin(0.628399848937988*x_112 - 4.1780800819397) + 0.0544792420830447*std::sin(0.409599870443344*x_115 + 5.1956000328064) - 0.101694691792341*std::sin(0.428799867630005*x_115 + 5.23239994049072) + 0.0191540255966143*std::sin(0.420559853315353*x_117 - 7.37207984924316) + 0.00514067074811079*std::sin(0.296399921178818*x_120 + 5.10007953643799) - 0.019356107906142*std::sin(0.621119856834412*x_120 - 3.98495984077454) + 0.170025897919359*std::sin(0.462159872055054*x_2 - 4.12944030761719) + 0.129734978414233*std::sin(0.419599860906601*x_24 - 7.37135982513428) - 0.0565070922191955*std::sin(0.386959850788116*x_28 - 7.39767980575562) + 0.276388194893447*std::sin(0.283039927482605*x_3 + 1.88183987140656) + 0.0362039838435629*std::sin(0.310239940881729*x_35 + 8.27095985412598) - 0.214915029793834*std::sin(0.319999843835831*x_35 + 1.98159980773926) - 0.00724936903640592*std::sin(0.199840009212494*x_36 + 1.8115998506546) - 0.00330221069127017*std::sin(0.417759865522385*x_36 + 5.21744012832642) - 0.0695529095078048*std::sin(0.447279840707779*x_36 + 5.21871995925903) - 0.116953558116766*std::sin(0.55215984582901*x_38 + 2.15399980545044) + 0.0949838440191086*std::sin(0.547839879989624*x_4 - 4.04007959365845) - 0.00696703631832893*std::sin(0.261919975280762*x_43 - 1.34247982501984) - 0.0163563163735074*std::sin(0.307839840650558*x_43 - 1.27559983730316) + 0.0214985597008877*std::sin(0.465679854154587*x_45 + 5.24111986160278) + 0.142378719850382*std::sin(0.397999823093414*x_51 + 1.99647974967957) - 0.0121383672363116*std::sin(0.222879990935326*x_53 + 5.02343988418579) - 0.231656034780011*std::sin(0.250239968299866*x_53 + 5.05375957489014) - 0.00486143327632287*std::sin(0.297119915485382*x_55 + 5.12536001205444) - 0.131123190351936*std::sin(0.26599994301796*x_63 + 1.87447988986969) + 0.00530325202044896*std::sin(0.280479967594147*x_64 - 7.5111198425293) + 0.0368471518378845*std::sin(0.430239856243134*x_64 + 2.03743982315063) - 0.0201530561746181*std::sin(0.607439875602722*x_64 + 8.60208034515381) + 0.15751641443923*std::sin(0.203359991312027*x_66 + 4.99975967407227) + 0.0642008465759351*std::sin(0.303439915180206*x_70 - 4.24783992767334) + 0.0010375091242383*std::sin(0.647679805755615*x_70 + 5.42951965332031) + 0.082901322381045*std::sin(0.208719998598099*x_73 - 4.37784004211426) + 0.227548583975241*std::sin(0.255119979381561*x_73 - 7.54936027526855) - 0.000592419774630525*std::sin(0.537359833717346*x_75 + 2.13783979415894) - 0.000592403781634738*std::sin(0.465439856052399*x_76 + 8.45416069030762) + 0.103108053907723*std::sin(0.470639854669571*x_80 + 5.25368022918701) + 0.0031221816831569*std::sin(0.394079834222794*x_81 - 7.40359973907471) + 0.00259787070314721*std::sin(0.251359969377518*x_84 + 1.85143995285034) + 0.036128010317795*std::sin(0.22647999227047*x_86 - 4.36448001861572) - 0.0020931095991949*std::sin(0.388559848070145*x_87 + 5.18847990036011) - 0.000206619282639567*std::sin(0.750559866428375*x_87 - 0.815679848194122) + 0.00392823039272767*std::sin(0.330479830503464*x_92 + 8.39352035522461) + 0.122371215650006*std::sin(0.341359823942184*x_92 + 1.98951983451843) - 0.00202366341525446*std::sin(0.366719841957092*x_92 - 1.19439995288849) - 0.0470854065092919*std::sin(0.353439837694168*x_95 - 7.42496013641357) + 0.00162211183157695*std::sin(0.360319852828979*x_95 + 4.98791980743408) + 0.0516909889342894*std::sin(0.394079834222794*x_95 - 1.00503981113434) - 0.00127408562606793*std::sin(0.370639860630035*x_96 - 7.42136001586914) - 0.0204377331439285*std::sin(0.416559875011444*x_96 - 7.38855981826782) + 0.0275925303456544*std::sin(0.400159865617752*x_97 - 7.40319967269897) - 0.00350461357836096*std::sin(0.4511998295784*x_98 - 1.14263987541199) + 0.018423721787158 + 7.38937395660272e-7*std::exp(-2.09607982635498*x_30));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00744574389668652*x_10 + 0.00143867634777517*x_100 - 0.0100728607127467*x_101 - 1.52288170401194e-5*x_102 - 0.00256575424103153*x_103 - 0.00187502405854252*x_104 + 0.00330370397240526*x_105 + 0.00441208551921751*x_106 - 0.000556539621040475*x_107 + 0.00522791015121779*x_108 - 0.000462079486180858*x_109 - 0.00646965216059008*x_11 + 0.00335643769783174*x_110 + 0.000750555571179082*x_111 + 0.00033084916082339*x_112 + 0.00556521448922117*x_113 - 0.0125395668030177*x_114 - 0.000174926250604289*x_115 + 0.0010847155181974*x_116 + 0.00274350957049526*x_117 - 0.00456541395006039*x_118 - 0.00682395204286045*x_119 - 0.0186145408078535*x_12 - 0.0121844762143961*x_120 + 0.00808193870185975*x_13 - 3.43524161078171e-5*x_14 - 9.33958065005093e-5*x_15 + 0.00183706324373491*x_16 - 0.00312336339383787*x_17 + 0.00369933064917006*x_18 - 0.00745612392347102*x_19 - 0.00126202233744774*x_2 + 0.0129858418043672*x_20 - 0.011159363453234*x_21 - 0.00860171608246774*x_22 + 0.012976297226704*x_23 - 0.000248895837238585*x_24 - 0.0153400570347457*x_25 + 0.00108033432149053*x_26 - 0.00603817156065906*x_27 - 0.00510561577807786*x_28 + 0.00816102248801897*x_29 - 0.00771561034885803*x_3 - 0.019178034666737*x_30 + 0.0103203399833681*x_32 + 0.0275979906495121*x_33 + 0.00346646208562461*x_34 + 0.000542190675442531*x_35 + 0.000539347703169737*x_36 - 0.00470587749854216*x_37 + 0.00380286017860254*x_38 + 0.00714151171597319*x_39 - 0.0149092213004648*x_4 + 0.0144428071949422*x_40 - 0.00948675836034426*x_41 - 0.0101787566503931*x_42 - 0.00858938524112452*x_43 - 0.0145596096643032*x_44 - 0.0039570915604916*x_45 + 0.00163310152607538*x_46 + 0.00504034266714038*x_47 + 0.00644223237200696*x_48 - 0.00734894976691591*x_49 - 0.00583687327821413*x_5 + 0.00420947225132566*x_50 - 0.00445812646405628*x_51 - 0.00448857205066258*x_52 - 0.00374395359706044*x_53 - 0.0125836446054345*x_54 - 0.0104148460063624*x_55 - 0.00629047985034131*x_56 - 0.017557405372104*x_57 - 0.0154502981612048*x_58 - 0.00581231022965538*x_59 - 0.00330708759068217*x_6 - 0.00631757326007789*x_60 - 0.0110367053483759*x_61 + 0.00379422674975743*x_62 + 0.0139138789540979*x_63 - 0.000134381550267222*x_64 + 0.00941472038928791*x_65 + 0.00246108091744249*x_66 + 0.00679517636459914*x_67 + 0.000559751717329862*x_68 - 0.0022639416399525*x_69 - 0.000155722386408983*x_7 + 0.000719890141122227*x_71 - 0.00198471148932891*x_72 - 0.000802893798562433*x_73 - 0.000837282375106011*x_74 - 0.000118144596904407*x_75 - 0.0137164785592586*x_76 - 0.0053639281950396*x_77 - 0.00981809906559633*x_78 - 0.00619183528811335*x_79 + 0.0223852567666861*x_8 + 0.0110192060437721*x_80 - 1.16112396327546e-5*x_81 + 0.00468833950348607*x_82 - 0.00376532407604353*x_83 + 0.0010816028670258*x_84 - 0.00122116897830361*x_85 - 0.00109370799907415*x_86 + 0.00415204643829088*x_87 - 0.000996371396745765*x_88 + 0.00220483062675955*x_89 - 0.00624959148863177*x_9 + 0.0126209908106088*x_90 - 0.00572961305328496*x_91 + 0.000980824254330295*x_92 - 0.038623365753354*x_93 + 0.0117484971387936*x_94 - 0.00195215832750866*x_95 + 0.00294605433130608*x_96 - 0.00529623427286342*x_97 - 0.0024295652318622*x_98 + 0.00255342812283764*x_99 + 9.41633497763199e-6*std::pow(-7.63032007217407*x_114 - 9.03103923797607, 2) - 4.85582251404057e-5*std::pow(-8.24623966217041*x_115 - 9.84912014007568, 2) - 9.91428182944098e-5*std::pow(-5.6736798286438*x_15 - 7.62943983078003, 2) - 1.0152694683839e-5*std::pow(-5.82647943496704*x_40 - 6.01991987228394, 2) + 1.24945977300587e-5*std::pow(-5.20471954345703*x_56 - 4.8187198638916, 2) + 3.15752123023833e-5*std::pow(-9.47784042358398*x_59 - 9.54600048065186, 2) + 6.36291441126274e-5*std::pow(-6.42759990692139*x_59 - 7.42335987091064, 2) - 8.41636801256194e-5*std::pow(-6.70647954940796*x_7 - 9.27136039733887, 2) + 5.38879052618169e-5*std::pow(-6.94496011734009*x_70 - 9.19479942321777, 2) + 5.79105748154774e-6*std::pow(-5.8473596572876*x_70 - 8.2651195526123, 2) + 1.74557393463378e-5*std::pow(-7.79071998596191*x_71 - 9.37960052490234, 2) + 1.47280260094514e-5*std::pow(-8.39999961853027*x_84 - 6.35200023651123, 2) + 9.32391392481826e-5*std::pow(-5.13184022903442*x_86 - 7.89423990249634, 2) + 1.00822017309581e-5*std::pow(-9.01288032531738*x_89 - 8.98544025421143, 2) - 0.000690171303987293*std::exp(0.783919870853424*x_1) - 2.63922278282168e-5*std::exp(1.17175984382629*x_1) + 0.000386152590712223*std::exp(1.17815983295441*x_1) - 1.55721944079122e-5*std::exp(1.26551985740662*x_1) + 2.17084740802637e-5*std::exp(1.30431985855103*x_1) + 0.00208992289921536*std::exp(1.37551987171173*x_100) - 0.000712481963204251*std::exp(1.68319988250732*x_100) + 0.000768253649201559*std::exp(1.04447984695435*x_104) - 0.00232768332052267*std::exp(0.591199815273285*x_108) + 0.0115890228303386*std::exp(0.572079837322235*x_109) + 0.00148284929450319*std::exp(0.707839846611023*x_109) + 0.00607010362792487*std::exp(0.873599886894226*x_109) + 0.00235785143230041*std::exp(1.00887978076935*x_109) - 0.00039507382659069*std::exp(1.26239991188049*x_110) - 0.00102046340802983*std::exp(0.642959833145142*x_112) - 0.00189532521193356*std::exp(0.843519866466522*x_112) - 0.00115100158687273*std::exp(0.757279872894287*x_114) + 0.00907421991679571*std::exp(0.615599870681763*x_26) + 0.010316056586444*std::exp(0.734559834003448*x_26) - 3.96758862454762e-5*std::exp(1.43647980690002*x_26) + 0.00222085975189105*std::exp(0.60207986831665*x_31) - 0.00392184824065307*std::exp(0.623999834060669*x_31) + 0.0115039400952505*std::exp(0.63895982503891*x_31) + 0.0156097184863626*std::exp(0.642719864845276*x_31) + 0.00218684520384738*std::exp(0.659439861774445*x_31) - 0.00354498583687572*std::exp(1.0668797492981*x_50) - 1.76395884854371e-5*std::exp(2.77047991752625*x_6) + 0.000653320009388835*std::exp(1.22575986385345*x_66) - 0.00012311811653708*std::exp(1.55999982357025*x_66) + 0.00434626671398516*std::exp(1.14623987674713*x_68) - 0.000776514709496484*std::exp(1.21247982978821*x_68) - 0.00994265298384429*std::exp(0.705119848251343*x_70) + 0.00488834878286319*std::exp(0.99919980764389*x_72) - 0.0149226742342648*std::exp(0.636719882488251*x_74) - 0.0008545821295172*std::exp(1.1736798286438*x_74) - 0.00264169658717146*std::exp(1.25471985340118*x_74) + 2.99776284112855e-5*std::exp(1.5201598405838*x_74) - 0.000142159435583701*std::exp(1.60031986236572*x_77) - 0.00688612718127063*std::exp(0.726239860057831*x_81) + 0.00421915546321662*std::exp(1.06903982162476*x_81) + 0.00015908091375552*std::exp(1.76583993434906*x_81) - 0.00103745501037728*std::exp(0.691679835319519*x_90) - 0.00560501524317813*std::sin(0.340159833431244*x_100 - 7.4347996711731) + 0.017393663359727*std::sin(0.351999849081039*x_102 + 5.17088031768799) + 0.0529776054895283*std::sin(0.376479834318161*x_102 + 1.99015986919403) + 0.0185347745326648*std::sin(0.384479850530624*x_102 + 5.17479991912842) - 0.0104073885694123*std::sin(0.193599998950958*x_111 + 4.98087978363037) + 0.0810783234104465*std::sin(0.207520008087158*x_111 + 1.80207979679108) - 0.0373657276859205*std::sin(0.414799869060516*x_111 - 1.19263982772827) + 0.00792743446086533*std::sin(0.628399848937988*x_112 - 4.1780800819397) - 0.0389193735389282*std::sin(0.409599870443344*x_115 + 5.1956000328064) - 0.0330250219643436*std::sin(0.428799867630005*x_115 + 5.23239994049072) - 0.013683425988792*std::sin(0.420559853315353*x_117 - 7.37207984924316) - 0.0196546858139972*std::sin(0.296399921178818*x_120 + 5.10007953643799) + 0.0206213901359709*std::sin(0.621119856834412*x_120 - 3.98495984077454) + 0.0552153599595938*std::sin(0.462159872055054*x_2 - 4.12944030761719) + 0.0421310142757751*std::sin(0.419599860906601*x_24 - 7.37135982513428) - 0.0183504952794465*std::sin(0.386959850788116*x_28 - 7.39767980575562) + 0.0897561715972356*std::sin(0.283039927482605*x_3 + 1.88183987140656) - 0.0385705886190888*std::sin(0.310239940881729*x_35 + 8.27095985412598) - 0.0697929602255156*std::sin(0.319999843835831*x_35 + 1.98159980773926) + 0.0277170193816909*std::sin(0.199840009212494*x_36 + 1.8115998506546) + 0.00728584109006546*std::sin(0.417759865522385*x_36 + 5.21744012832642) - 0.0225870822133928*std::sin(0.447279840707779*x_36 + 5.21871995925903) - 0.0379802894088245*std::sin(0.55215984582901*x_38 + 2.15399980545044) + 0.0308456958736276*std::sin(0.547839879989624*x_4 - 4.04007959365845) + 0.0266375569650687*std::sin(0.261919975280762*x_43 - 1.34247982501984) + 0.0174255063446116*std::sin(0.307839840650558*x_43 - 1.27559983730316) - 0.0229038910664881*std::sin(0.465679854154587*x_45 + 5.24111986160278) + 0.0462370283781923*std::sin(0.397999823093414*x_51 + 1.99647974967957) + 0.0267815179117496*std::sin(0.222879990935326*x_53 + 5.02343988418579) - 0.0752295474025791*std::sin(0.250239968299866*x_53 + 5.05375957489014) + 0.0107260358689048*std::sin(0.297119915485382*x_55 + 5.12536001205444) + 0.139694533489475*std::sin(0.26599994301796*x_63 + 1.87447988986969) - 0.0117008437964622*std::sin(0.280479967594147*x_64 - 7.5111198425293) - 0.0392557996231909*std::sin(0.430239856243134*x_64 + 2.03743982315063) - 0.00654463975538139*std::sin(0.607439875602722*x_64 + 8.60208034515381) + 0.0511529456937888*std::sin(0.203359991312027*x_66 + 4.99975967407227) + 0.0208490171013959*std::sin(0.303439915180206*x_70 - 4.24783992767334) - 0.00228911093670577*std::sin(0.647679805755615*x_70 + 5.42951965332031) - 0.088320468138378*std::sin(0.208719998598099*x_73 - 4.37784004211426) + 0.0738956660499322*std::sin(0.255119979381561*x_73 - 7.54936027526855) + 0.00226503993562342*std::sin(0.537359833717346*x_75 + 2.13783979415894) + 0.00130705161410654*std::sin(0.465439856052399*x_76 + 8.45416069030762) + 0.0334840067361287*std::sin(0.470639854669571*x_80 + 5.25368022918701) - 0.00688863362290324*std::sin(0.394079834222794*x_81 - 7.40359973907471) - 0.00573181873758237*std::sin(0.251359969377518*x_84 + 1.85143995285034) - 0.0384896488081278*std::sin(0.22647999227047*x_86 - 4.36448001861572) + 0.0046181377718085*std::sin(0.388559848070145*x_87 + 5.18847990036011) + 0.000789981946400016*std::sin(0.750559866428375*x_87 - 0.815679848194122) - 0.00866706127572088*std::sin(0.330479830503464*x_92 + 8.39352035522461) + 0.0397396561552805*std::sin(0.341359823942184*x_92 + 1.98951983451843) + 0.00773721379349656*std::sin(0.366719841957092*x_92 - 1.19439995288849) + 0.0501633149622392*std::sin(0.353439837694168*x_95 - 7.42496013641357) - 0.00357895063038475*std::sin(0.360319852828979*x_95 + 4.98791980743408) + 0.0167864813278495*std::sin(0.394079834222794*x_95 - 1.00503981113434) + 0.00487130063517453*std::sin(0.370639860630035*x_96 - 7.42136001586914) + 0.0217737197322648*std::sin(0.416559875011444*x_96 - 7.38855981826782) - 0.0293962162153375*std::sin(0.400159865617752*x_97 - 7.40319967269897) + 0.0133994340733586*std::sin(0.4511998295784*x_98 - 1.14263987541199) - 0.12626403336335 - 1.6303564319867e-6*std::exp(-2.09607982635498*x_30));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00690031037580481*x_10 + 0.00432270544713427*x_100 - 0.00503007664371689*x_101 - 0.000256228859455015*x_102 - 0.0122224899968355*x_103 + 0.00212779629398407*x_104 + 0.00303575510911163*x_105 + 0.00456735736262852*x_106 + 0.00770628545352841*x_107 - 0.00850974466568057*x_108 + 0.00151190663556595*x_109 - 0.00177246937644588*x_11 - 0.00588818141419228*x_110 - 0.00118449216356902*x_111 + 0.000660705169693491*x_112 + 0.0225186719651306*x_113 - 0.0183157115329773*x_114 + 0.000608284726328165*x_115 + 0.00244432049019354*x_116 + 0.00349655398040743*x_117 - 0.00787872470177606*x_118 + 0.000575181581722067*x_119 + 0.00411862648096284*x_12 - 0.0249157521528338*x_120 + 0.0177517144654618*x_13 - 0.0012321980274497*x_14 + 0.000783538216854454*x_15 - 0.00278843811682624*x_16 + 0.000995321430359906*x_17 + 0.00782416243777556*x_18 - 0.0220908808586841*x_19 - 0.00520557809577529*x_2 + 0.00698331917307791*x_20 - 0.00909028069508596*x_21 + 0.00974344888771191*x_22 - 0.00472735121046102*x_23 - 0.000309531867698801*x_24 - 0.00253893804112589*x_25 - 0.00386285212801581*x_26 - 0.0110728970890376*x_27 + 0.00145127075886477*x_28 + 0.00427375080779235*x_29 + 0.00417283422664337*x_3 - 0.0252084570868322*x_30 + 0.0514387862701871*x_32 - 0.0124154213654003*x_33 - 0.0123385074077292*x_34 - 0.000998299275500405*x_35 - 0.00244701102462337*x_36 + 0.00669810227284224*x_37 - 0.00374282296253175*x_38 + 0.0128495285505253*x_39 + 0.0110503888399126*x_4 + 0.00800505653112096*x_40 + 0.0180467985689852*x_41 - 0.0217063123588781*x_42 - 0.0147349042827869*x_43 - 0.00586530823603138*x_44 - 0.00177613513192824*x_45 + 0.0094824761819246*x_46 + 0.0244931903128326*x_47 - 0.00896042423680398*x_48 - 0.00186234287578346*x_49 + 0.0101568537907549*x_5 + 0.00780521026531867*x_50 + 0.00403096824069387*x_51 + 0.00197336123368941*x_52 + 0.00589947871731129*x_53 + 0.0121063363170574*x_54 - 0.0221948548196853*x_55 + 0.00478076042714817*x_56 - 0.0116031686193929*x_57 - 0.0111771637058905*x_58 - 0.0149264722789326*x_59 - 0.00248720884176803*x_6 + 0.000608876384210564*x_60 - 0.0157257513755976*x_61 + 0.000582830331927607*x_62 + 0.0218288422773113*x_63 - 0.0022511697708908*x_64 - 0.00483884132826094*x_65 - 0.00222855483834546*x_66 + 0.00624034072527981*x_67 + 0.00588277365210095*x_68 + 0.0125494007196344*x_69 + 0.0108411301889347*x_7 - 0.00196466263272693*x_71 + 0.00490543850589031*x_72 - 0.0026072974003164*x_73 - 9.82610885441653e-5*x_74 - 0.00305182770569318*x_75 - 0.00947502643389644*x_76 - 0.0106215492324439*x_77 + 0.00342572032535447*x_78 - 0.0106677221916704*x_79 + 0.0271500770208187*x_8 - 0.0112709277941438*x_80 + 3.79915377611829e-5*x_81 + 0.0189063082088326*x_82 + 0.00161025985150718*x_83 - 0.00372111119669695*x_84 + 0.00525990206044124*x_85 - 7.04208635053081e-5*x_86 + 0.0117572253003465*x_87 - 0.0145752766029311*x_88 + 0.00430691697353867*x_89 - 0.0312651283834995*x_9 - 0.0119944835674945*x_90 + 0.0371000729831631*x_91 - 0.00230250064451128*x_92 - 0.0286896539046477*x_93 + 0.00554528817174901*x_94 - 0.00130227930582724*x_95 + 0.00854895598095304*x_96 - 0.00538532325612878*x_97 - 0.0140224584730328*x_98 - 0.00350075783234077*x_99 + 1.70672027869158e-6*std::pow(-7.63032007217407*x_114 - 9.03103923797607, 2) + 5.98223835310116e-5*std::pow(-8.24623966217041*x_115 - 9.84912014007568, 2) + 0.000122141196124946*std::pow(-5.6736798286438*x_15 - 7.62943983078003, 2) - 1.84018622334842e-6*std::pow(-5.82647943496704*x_40 - 6.01991987228394, 2) + 2.26465852910297e-6*std::pow(-5.20471954345703*x_56 - 4.8187198638916, 2) + 3.70557750179857e-6*std::pow(-9.47784042358398*x_59 - 9.54600048065186, 2) - 7.83893367570436e-5*std::pow(-6.42759990692139*x_59 - 7.42335987091064, 2) + 0.00010368731429738*std::pow(-6.70647954940796*x_7 - 9.27136039733887, 2) + 6.32413196291222e-6*std::pow(-6.94496011734009*x_70 - 9.19479942321777, 2) - 1.89481214707483e-5*std::pow(-5.8473596572876*x_70 - 8.2651195526123, 2) + 3.90221807706055e-5*std::pow(-7.79071998596191*x_71 - 9.37960052490234, 2) - 1.81445186277818e-5*std::pow(-8.39999961853027*x_84 - 6.35200023651123, 2) + 0.000208435430573817*std::pow(-5.13184022903442*x_86 - 7.89423990249634, 2) - 3.29885834667497e-5*std::pow(-9.01288032531738*x_89 - 8.98544025421143, 2) + 0.000850271860840119*std::exp(0.783919870853424*x_1) - 3.09731712097468e-6*std::exp(1.17175984382629*x_1) + 0.000863241361527969*std::exp(1.17815983295441*x_1) - 2.82247605282147e-6*std::exp(1.26551985740662*x_1) - 7.10293077090115e-5*std::exp(1.30431985855103*x_1) - 0.00257472691527745*std::exp(1.37551987171173*x_100) - 8.36148656105052e-5*std::exp(1.68319988250732*x_100) + 0.00171742555167737*std::exp(1.04447984695435*x_104) - 0.0052035194561504*std::exp(0.591199815273285*x_108) - 0.0142773539704457*std::exp(0.572079837322235*x_109) + 0.00026876794073107*std::exp(0.707839846611023*x_109) + 0.013569673353016*std::exp(0.873599886894226*x_109) + 0.000276710767181649*std::exp(1.00887978076935*x_109) - 7.16075323386785e-5*std::exp(1.26239991188049*x_110) - 0.000119758695839984*std::exp(0.642959833145142*x_112) - 0.00423698598906233*std::exp(0.843519866466522*x_112) + 0.00376603374264208*std::exp(0.757279872894287*x_114) + 0.00106492475325376*std::exp(0.615599870681763*x_26) + 0.0230614708989951*std::exp(0.734559834003448*x_26) + 4.88795889274513e-5*std::exp(1.43647980690002*x_26) - 0.007266569272091*std::exp(0.60207986831665*x_31) - 0.000460257003717292*std::exp(0.623999834060669*x_31) + 0.0257169760079661*std::exp(0.63895982503891*x_31) - 0.0192307392496781*std::exp(0.642719864845276*x_31) + 0.000396367914335218*std::exp(0.659439861774445*x_31) + 0.00436732400602342*std::exp(1.0668797492981*x_50) - 2.07013215324247e-6*std::exp(2.77047991752625*x_6) + 0.000118414915266673*std::exp(1.22575986385345*x_66) + 0.000402837829675774*std::exp(1.55999982357025*x_66) - 0.00535447977227937*std::exp(1.14623987674713*x_68) + 0.00254072681651743*std::exp(1.21247982978821*x_68) + 0.0122490720860462*std::exp(0.705119848251343*x_70) - 0.00602230981211173*std::exp(0.99919980764389*x_72) + 0.0183843198298387*std::exp(0.636719882488251*x_74) + 0.00279616046782788*std::exp(1.1736798286438*x_74) - 0.00590549387341322*std::exp(1.25471985340118*x_74) + 5.43347559726347e-6*std::exp(1.5201598405838*x_74) + 0.000175136472831331*std::exp(1.60031986236572*x_77) - 0.0153938881845929*std::exp(0.726239860057831*x_81) - 0.00519788224482454*std::exp(1.06903982162476*x_81) + 1.86692855564274e-5*std::exp(1.76583993434906*x_81) + 0.00339451363066272*std::exp(0.691679835319519*x_90) - 0.00101591470573546*std::sin(0.340159833431244*x_100 - 7.4347996711731) + 0.00204127107689463*std::sin(0.351999849081039*x_102 + 5.17088031768799) - 0.0652669372693367*std::sin(0.376479834318161*x_102 + 1.99015986919403) + 0.041434356231253*std::sin(0.384479850530624*x_102 + 5.17479991912842) - 0.00188634974879641*std::sin(0.193599998950958*x_111 + 4.98087978363037) + 0.00951512243959232*std::sin(0.207520008087158*x_111 + 1.80207979679108) + 0.0460335378008381*std::sin(0.414799869060516*x_111 - 1.19263982772827) - 0.0097663788856283*std::sin(0.628399848937988*x_112 - 4.1780800819397) - 0.00456746746748117*std::sin(0.409599870443344*x_115 + 5.1956000328064) - 0.0738272009839676*std::sin(0.428799867630005*x_115 + 5.23239994049072) - 0.00160584812561233*std::sin(0.420559853315353*x_117 - 7.37207984924316) + 0.0643093900310379*std::sin(0.296399921178818*x_120 + 5.10007953643799) - 0.0254049794054388*std::sin(0.621119856834412*x_120 - 3.98495984077454) + 0.123433543255179*std::sin(0.462159872055054*x_2 - 4.12944030761719) + 0.0941835818293868*std::sin(0.419599860906601*x_24 - 7.37135982513428) - 0.0410224012754254*std::sin(0.386959850788116*x_28 - 7.39767980575562) + 0.200649281239389*std::sin(0.283039927482605*x_3 + 1.88183987140656) + 0.0475178929772705*std::sin(0.310239940881729*x_35 + 8.27095985412598) - 0.156021664645624*std::sin(0.319999843835831*x_35 + 1.98159980773926) - 0.0906890411163735*std::sin(0.199840009212494*x_36 + 1.8115998506546) + 0.00132056609766725*std::sin(0.417759865522385*x_36 + 5.21744012832642) - 0.0504932611402941*std::sin(0.447279840707779*x_36 + 5.21871995925903) - 0.0849046660027035*std::sin(0.55215984582901*x_38 + 2.15399980545044) + 0.0689553330565939*std::sin(0.547839879989624*x_4 - 4.04007959365845) - 0.0871570808382311*std::sin(0.261919975280762*x_43 - 1.34247982501984) - 0.0214677394150062*std::sin(0.307839840650558*x_43 - 1.27559983730316) + 0.028216957101915*std::sin(0.465679854154587*x_45 + 5.24111986160278) + 0.103362547060945*std::sin(0.397999823093414*x_51 + 1.99647974967957) + 0.00485417732299277*std::sin(0.222879990935326*x_53 + 5.02343988418579) - 0.168175116492569*std::sin(0.250239968299866*x_53 + 5.05375957489014) + 0.00194410489547354*std::sin(0.297119915485382*x_55 + 5.12536001205444) - 0.17209978197163*std::sin(0.26599994301796*x_63 + 1.87447988986969) - 0.00212078982243755*std::sin(0.280479967594147*x_64 - 7.5111198425293) + 0.0483620538865405*std::sin(0.430239856243134*x_64 + 2.03743982315063) - 0.0146304954803626*std::sin(0.607439875602722*x_64 + 8.60208034515381) + 0.114352045147304*std::sin(0.203359991312027*x_66 + 4.99975967407227) + 0.0466078289826666*std::sin(0.303439915180206*x_70 - 4.24783992767334) - 0.000414903682285197*std::sin(0.647679805755615*x_70 + 5.42951965332031) + 0.108808361576957*std::sin(0.208719998598099*x_73 - 4.37784004211426) + 0.165193234245315*std::sin(0.255119979381561*x_73 - 7.54936027526855) - 0.00741112516548842*std::sin(0.537359833717346*x_75 + 2.13783979415894) + 0.000236904432604752*std::sin(0.465439856052399*x_76 + 8.45416069030762) + 0.0748532581666621*std::sin(0.470639854669571*x_80 + 5.25368022918701) - 0.00124857184080788*std::sin(0.394079834222794*x_81 - 7.40359973907471) - 0.00103889796788817*std::sin(0.251359969377518*x_84 + 1.85143995285034) + 0.0474181773801654*std::sin(0.22647999227047*x_86 - 4.36448001861572) + 0.000837042161696678*std::sin(0.388559848070145*x_87 + 5.18847990036011) - 0.00258479110728583*std::sin(0.750559866428375*x_87 - 0.815679848194122) - 0.00157091365919687*std::sin(0.330479830503464*x_92 + 8.39352035522461) + 0.0888377178121876*std::sin(0.341359823942184*x_92 + 1.98951983451843) - 0.0253158714572351*std::sin(0.366719841957092*x_92 - 1.19439995288849) - 0.0617998095725485*std::sin(0.353439837694168*x_95 - 7.42496013641357) - 0.00064868843683063*std::sin(0.360319852828979*x_95 + 4.98791980743408) + 0.0375260592451024*std::sin(0.394079834222794*x_95 - 1.00503981113434) - 0.0159387117896732*std::sin(0.370639860630035*x_96 - 7.42136001586914) - 0.0268246174351301*std::sin(0.416559875011444*x_96 - 7.38855981826782) + 0.0362153212089121*std::sin(0.400159865617752*x_97 - 7.40319967269897) - 0.0438424424675932*std::sin(0.4511998295784*x_98 - 1.14263987541199) - 0.0361202821253057 - 2.95503759220204e-7*std::exp(-2.09607982635498*x_30));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
