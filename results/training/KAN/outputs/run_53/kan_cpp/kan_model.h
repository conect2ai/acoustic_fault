
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-4615.30301174152*x_1 - 103.062616515095*x_10 - 207.367988270267*x_100 + 399.775834372962*x_101 - 268.456349269758*x_102 - 61.3334062916064*x_103 + 483.342480506088*x_104 + 237.72604892985*x_105 + 26.6550425281495*x_106 - 40.1438249438127*x_107 + 212.451980497056*x_108 - 411.9011503772*x_109 - 46.5107967002587*x_11 + 189.726993287832*x_110 + 56.7156955788398*x_111 - 223.039723512391*x_112 + 129.32940940079*x_113 + 21.2138550567038*x_114 + 242.451636927362*x_115 - 880.071379305526*x_116 + 253.974528756639*x_117 + 197.305963684905*x_118 + 172.78769394666*x_119 - 1340.77775491675*x_12 - 81.1386967302414*x_120 - 172.538616089783*x_13 + 140.621329337021*x_14 + 125.515608470319*x_15 + 113.04884805094*x_16 + 218.350076810997*x_17 - 87.6175635632597*x_18 - 46.009422115084*x_19 + 80.6367824350931*x_2 + 304.366073364742*x_20 - 745.330716134578*x_21 + 281.449275555984*x_22 - 248.769661041512*x_23 - 46.734713837344*x_24 - 32.7846603751956*x_25 + 97.1759589018486*x_26 + 54.7614629889593*x_27 - 134.10806304702*x_28 + 163.528945112132*x_29 + 447.044150911947*x_3 - 784.012911011209*x_30 + 14765.6149786721*x_31 - 36.8267579512879*x_32 + 198.797685228432*x_33 - 105.801375088023*x_34 - 69.5059248702211*x_35 + 81.7518162953046*x_36 - 1036.78377164718*x_37 + 422.072812506377*x_38 - 403.186918769145*x_39 + 2.86716079453722*x_4 - 69.9325627995246*x_40 - 231.353942050464*x_41 - 19223.1404339386*x_42 - 78.1671525593951*x_43 + 269.725524192878*x_44 - 19.9952122678108*x_45 + 103.960936926744*x_46 - 264.610716509167*x_47 + 585.92009170658*x_48 - 51.1173812692871*x_49 - 13.3659570846775*x_5 + 1282.14847914954*x_50 + 325.771430185384*x_51 - 162.88063599738*x_52 + 41.4816158004514*x_53 + 61.5070013840003*x_54 - 117.084988608067*x_55 + 75.0773136865501*x_56 - 293.393771661297*x_57 - 187.18745878373*x_58 + 113.590824149357*x_59 + 177.268490473204*x_6 + 145.461836774338*x_60 + 24.709152788362*x_61 - 104.428427646458*x_62 + 353.487604549066*x_63 - 32.1556349653046*x_64 - 7.13159865739002*x_65 + 7.56062809536907*x_66 + 61.8557090798624*x_67 - 450.343734135684*x_68 + 164.523621439515*x_69 + 30.8421155498818*x_7 + 19.1952580055841*x_70 + 54.7418617802988*x_72 - 147.006842995891*x_73 - 12.7669120306269*x_74 + 12.167538950255*x_75 + 78.7962714311391*x_76 - 84.0978911114415*x_77 - 16.7753435810852*x_78 + 58.8067400078429*x_79 - 96.4179753103531*x_8 - 81.2878419424638*x_80 - 107.500588133577*x_81 - 80.1759767150101*x_82 + 116.383556816489*x_83 + 1270.14657883315*x_84 + 93.6228360926622*x_85 - 157.274248516073*x_86 + 89.846150401667*x_87 - 193.034892610581*x_88 - 530.647174549239*x_89 - 829.067755589102*x_9 - 9.67052924184604*x_90 - 66.7305963388674*x_91 + 73.4172812556348*x_92 - 33.2265221992928*x_93 - 70.3826313334815*x_94 + 124.420209463219*x_95 + 108.418673297941*x_96 - 200.102575552871*x_97 - 1.78422332105629*x_98 + 194.332554783504*x_99 + 0.00019948155177184*std::pow(-6.1384801864624*x_15 - 8.91168022155762, 2) + 0.0188947407789536*std::pow(-6.67000007629395*x_6 - 8.49240016937256, 2) + 0.000161954851054852*std::pow(-5.50063991546631*x_64 - 8.64447975158691, 2) - 0.0100240948189749*std::pow(-6.22312021255493*x_80 - 8.63335990905762, 2) - 0.0125737063506003*std::pow(-5.10504007339478*x_81 - 6.32679986953735, 2) - 5.1009471855072*std::exp(0.346639841794968*x_1) - 8.4911227744375*std::exp(0.7290398478508*x_19) + 0.00119696359063684*std::exp(2.51127982139587*x_71) - 1.76178575631286*std::exp(2.52927994728088*x_71) - 0.283964288732969*std::exp(2.55039978027344*x_71) - 0.10039783971869*std::exp(2.5557599067688*x_71) + 0.143935667800209*std::exp(2.58471989631653*x_71) + 0.0892040034446376*std::exp(2.58607983589172*x_71) - 2.10347533753554*std::exp(2.60103988647461*x_71) + 0.0995824433788658*std::exp(2.60951995849609*x_71) - 0.0206668668171973*std::exp(2.61911988258362*x_71) + 0.984647067196119*std::exp(2.61959981918335*x_71) + 2.80199955948945*std::exp(2.62344002723694*x_71) + 1.62725812884801*std::exp(2.63927984237671*x_71) + 12.0894158485155*std::exp(2.65535998344421*x_71) - 4.22179233561302*std::exp(2.66295981407166*x_71) + 0.335112419640902*std::exp(2.69736003875732*x_71) - 0.266484939657725*std::exp(1.32943987846375*x_76) - 1.53444645397037*std::exp(2.37591981887817*x_81) + 1.56925657340076*std::sin(0.41567987203598*x_103 + 5.20480012893677) + 8.01976914008613*std::sin(0.364319831132889*x_105 + 5.16792011260986) - 2.18928926410379*std::sin(0.324479848146439*x_112 + 1.92879974842072) - 6.61844164861463*std::sin(0.342559844255447*x_112 + 1.97303986549377) + 76.9297423718439*std::sin(0.462799847126007*x_113 + 8.24320030212402) - 247.894439779315*std::sin(0.271039962768555*x_115 - 7.52120018005371) + 98.1724300180571*std::sin(0.402399837970734*x_115 + 5.18944025039673) - 29.7560623596454*std::sin(0.444559872150421*x_115 - 4.1701602935791) + 80.6021266179614*std::sin(0.364959836006165*x_119 + 5.17040014266968) - 6.09095586959913*std::sin(0.416319847106934*x_16 + 2.00135970115662) - 434.08387261323*std::sin(0.323679834604263*x_28 - 4.28424024581909) - 48.1955273652464*std::sin(0.325439840555191*x_28 - 4.28664016723633) + 3.09945738193692*std::sin(0.34079983830452*x_28 + 5.14592027664185) + 6.50800390668593*std::sin(0.370079845190048*x_28 + 5.16351985931396) + 35.4879892262204*std::sin(0.391679853200912*x_36 - 7.39351987838745) + 20.7356610351689*std::sin(0.42399987578392*x_36 - 7.37871980667114) + 2.02212555424773*std::sin(0.341519832611084*x_43 - 4.24616003036499) - 3.84121362663477*std::sin(0.445039868354797*x_45 + 5.23095989227295) + 35.531122663138*std::sin(0.461359858512878*x_45 - 4.14215993881226) - 731.788473837106*std::sin(0.258959949016571*x_48 + 5.06367969512939) + 22.8462796689963*std::sin(0.214479997754097*x_53 + 5.02799987792969) + 56.9758033391058*std::sin(0.241599977016449*x_53 + 5.06559991836548) - 6.14892486084417*std::sin(0.327359855175018*x_53 + 5.13840007781982) - 1.51121812258615*std::sin(0.457919865846634*x_53 - 7.34488010406494) + 145.381943348544*std::sin(0.594959855079651*x_53 - 1.00071978569031) + 293.136240453173*std::sin(0.529839813709259*x_55 + 5.14864015579224) - 20.9774678216627*std::sin(0.24695996940136*x_56 - 7.5360803604126) - 23.5866827275214*std::sin(0.386239856481552*x_59 + 2.000079870224) + 19.5101735390806*std::sin(0.19472000002861*x_64 - 4.39791965484619) - 3.67698381425281*std::sin(0.258799970149994*x_64 - 4.32423973083496) - 2.76268344149798*std::sin(0.36847984790802*x_67 + 1.96831977367401) - 1.20702829025885*std::sin(0.515679836273193*x_69 - 1.07575976848602) + 10.8379838278587*std::sin(0.191359996795654*x_72 - 7.60400009155273) - 41.8205461986977*std::sin(0.473599851131439*x_75 - 0.933439791202545) - 4.85699582071839*std::sin(0.237279981374741*x_78 - 7.56224012374878) - 54.2264223596112*std::sin(0.136480033397675*x_80 - 7.68383979797363) + 678.331856195518*std::sin(0.289759933948517*x_80 - 7.48191976547241) - 107.822617636378*std::sin(0.309119939804077*x_80 - 4.26359987258911) - 266.977094221625*std::sin(0.357839852571487*x_80 + 5.14359998703003) - 0.837068305383282*std::sin(0.388959854841232*x_80 + 1.99631977081299) + 23.3515929182857*std::sin(0.487999856472015*x_80 - 7.32735967636108) + 0.0867492708308002*std::sin(0.517279863357544*x_80 + 2.1354398727417) - 7.45161241131232*std::sin(0.559519827365875*x_80 - 1.01055979728699) - 20.2588906462589*std::sin(0.6211998462677*x_80 + 8.41695976257324) - 30.4627227802999*std::sin(0.522799849510193*x_81 - 7.26743984222412) - 7.37757502660159*std::sin(0.669119834899902*x_82 + 5.44583988189697) - 515.643642757885*std::sin(0.295759916305542*x_85 + 5.14039945602417) + 103.083318036615*std::sin(0.551439881324768*x_85 - 7.2323203086853) - 1.1528745213193*std::sin(0.622239828109741*x_87 - 7.19248008728027) + 1272.73184942118*std::sin(0.399919867515564*x_92 - 1.20775985717773) + 5.42701470708624*std::sin(0.386559844017029*x_93 + 8.1825590133667) + 4.6498000842628*std::sin(0.371919840574265*x_95 - 4.22896003723145) - 343.14822318544*std::sin(0.277999937534332*x_96 + 5.09999990463257) + 4.34730396641413*std::sin(0.373279839754105*x_96 - 7.40655994415283) - 2.13183349443547*std::sin(0.381279855966568*x_96 + 5.18871974945068) + 18.344667588178*std::sin(0.400719821453094*x_96 - 7.40183973312378) - 64.2656870858036*std::sin(0.438079863786697*x_96 - 7.36663961410522) + 330.672435459754*std::sin(0.441119849681854*x_96 - 7.36895990371704) + 2.2240371254653*std::sin(0.441359847784042*x_96 - 7.37751960754395) + 6.70654703523549*std::sin(0.446559876203537*x_96 - 4.17528009414673) + 2.92408219570449*std::sin(0.45415985584259*x_99 - 1.14119982719421) + 214572.390975214 + 0.0017104910012739*std::exp(-3.74424004554749*x_74) + 0.00531096212986855*std::exp(-3.28631997108459*x_74) - 0.314251082451452*std::exp(-3.16623997688293*x_74) + 0.0370743886219252*std::exp(-2.93903994560242*x_74) - 0.00901281233154666*std::exp(-2.78071999549866*x_74) + 0.00564520854468156*std::exp(-4.0*x_45) + 0.0698758111044405*std::exp(-3.97359991073608*x_45) - 0.000284624850689435*std::exp(-3.93063998222351*x_45) - 0.174536182946991*std::exp(-3.84967994689941*x_45) - 0.00655864019259103*std::exp(-4.89256000518799*x_111) - 0.000101086987619037*std::exp(-4.78735971450806*x_111) - 0.0163014666599152*std::exp(-4.68495988845825*x_111));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-3698.03180896241*x_1 - 59.8095221712677*x_10 - 336.51298112338*x_100 + 193.769197869465*x_101 - 134.983941782287*x_102 + 65.7975091385628*x_103 + 92.5083057827868*x_104 - 13.1173278740434*x_105 + 84.471762409916*x_106 - 151.803488314308*x_107 - 24.6105270905082*x_108 + 243.061864626126*x_109 - 35.1199579142163*x_11 - 2.85951141463081*x_110 + 39.6920270928666*x_111 - 17.9283455224705*x_112 + 10.1512125952069*x_113 + 43.7956528652532*x_114 + 27.6740130956531*x_115 + 749.119403772473*x_116 + 158.834850218228*x_117 + 18.1715555355418*x_118 + 20.7760047186444*x_119 - 259.393860597245*x_12 - 188.518707436562*x_120 - 51.5322063422584*x_13 - 8.69264882741557*x_14 - 134.231797911623*x_15 + 100.110820593595*x_16 - 12.9152912741596*x_17 - 25.3371564247588*x_18 + 23.7022858857817*x_19 + 27.5366508413911*x_2 + 228.27768017517*x_20 + 88.5298289051341*x_21 - 28.4026353132353*x_22 + 13.6597175233114*x_23 - 93.2317853018443*x_24 + 139.821180042755*x_25 + 0.607340750385972*x_26 - 50.064267302293*x_27 - 15.3834371008832*x_28 + 124.905058608351*x_29 + 229.206474367086*x_3 + 882.826150163912*x_30 + 4643.8417417119*x_31 + 116.403793900013*x_32 - 61.4627553264389*x_33 + 42.2735388303725*x_34 + 194.278996962608*x_35 + 46.4792027009612*x_36 + 1989.91491380524*x_37 + 177.872989540849*x_38 - 23.7724723222898*x_39 + 21.5951332674867*x_4 - 85.7915240072373*x_40 - 165.646305275779*x_41 + 87467.74397092*x_42 - 225.555526249711*x_43 + 171.970385030149*x_44 - 75.6227359698785*x_45 + 31.1089584421947*x_46 - 187.551860004701*x_47 + 52.7713856061179*x_48 + 481.586548817653*x_49 - 110.956169842385*x_5 - 236.912789187892*x_50 - 28.2024399595561*x_51 + 213.553000661978*x_52 - 52.4927473984479*x_53 - 148.219155344416*x_54 - 105.75288491537*x_55 + 4.86685073102477*x_56 - 957.168089982383*x_57 + 94.3563252555655*x_58 + 112.001781154253*x_59 + 117.235981095436*x_6 + 27.9888023787497*x_60 + 21.3479109617825*x_61 + 349.368470110211*x_62 + 57.3505051511053*x_63 + 33.9605181785384*x_64 + 38.1058802431329*x_65 + 88.6000208236816*x_66 + 51.3194277963454*x_67 + 34.9832993490982*x_68 + 120.171016491106*x_69 + 24.4013611746367*x_7 + 160.232470911721*x_70 + 17.3257277134535*x_72 + 44.9616528751676*x_73 - 51.8039319550161*x_74 - 2.10819669885122*x_75 - 138.303707185366*x_76 + 4.85561946509443*x_77 + 94.7683480655622*x_78 + 101.171514255284*x_79 - 492.382634554402*x_8 - 7.28510767770494*x_80 + 76.4395117844074*x_81 - 13.6741023325909*x_82 + 55.1067816474746*x_83 + 423.498782282828*x_84 + 123.247553530195*x_85 + 85.308948101875*x_86 - 94.1252694159457*x_87 - 220.861815848538*x_88 - 167.477781581028*x_89 + 225.185545625041*x_9 + 145.680110494611*x_90 + 126.702890834443*x_91 + 48.1524136053218*x_92 - 67.4526220602313*x_93 - 28.5061800532504*x_94 - 18.9398706785074*x_95 + 3.87021263626682*x_96 - 359.842796053649*x_97 - 85.7994689822232*x_98 + 105.805086641762*x_99 + 9.78899703373323e-5*std::pow(-6.1384801864624*x_15 - 8.91168022155762, 2) - 0.0416960151527359*std::pow(-6.67000007629395*x_6 - 8.49240016937256, 2) + 7.94747956637085e-5*std::pow(-5.50063991546631*x_64 - 8.64447975158691, 2) - 0.0122846307176196*std::pow(-6.22312021255493*x_80 - 8.63335990905762, 2) - 0.015409205724643*std::pow(-5.10504007339478*x_81 - 6.32679986953735, 2) + 11.2565276035501*std::exp(0.346639841794968*x_1) - 0.199757650302852*std::exp(0.7290398478508*x_19) + 0.000587376272851146*std::exp(2.51127982139587*x_71) + 0.995858864164378*std::exp(2.52927994728088*x_71) + 0.626638884563808*std::exp(2.55039978027344*x_71) + 0.0651839785940115*std::exp(2.5557599067688*x_71) + 0.176394632927101*std::exp(2.58471989631653*x_71) - 0.0321227745596383*std::exp(2.58607983589172*x_71) - 0.553903720513618*std::exp(2.60103988647461*x_71) - 0.0123002825475627*std::exp(2.60951995849609*x_71) + 0.0453854399414677*std::exp(2.61911988258362*x_71) + 0.0231642846000094*std::exp(2.61959981918335*x_71) + 2.11805049223482*std::exp(2.62344002723694*x_71) - 15.6083636157245*std::exp(2.63927984237671*x_71) + 1.19086340503584*std::exp(2.65535998344421*x_71) - 1.807379981136*std::exp(2.66295981407166*x_71) + 0.578840829310033*std::exp(2.69736003875732*x_71) - 0.326580018906592*std::exp(1.32943987846375*x_76) - 0.151150076390556*std::exp(2.37591981887817*x_81) - 1.01885047701903*std::sin(0.41567987203598*x_103 + 5.20480012893677) + 9.82830909979308*std::sin(0.364319831132889*x_105 + 5.16792011260986) + 4.80778519982534*std::sin(0.324479848146439*x_112 + 1.92879974842072) + 4.29706814367538*std::sin(0.342559844255447*x_112 + 1.97303986549377) + 20.2577466716785*std::sin(0.462799847126007*x_113 + 8.24320030212402) - 106.125411264929*std::sin(0.271039962768555*x_115 - 7.52120018005371) + 25.8515387694417*std::sin(0.402399837970734*x_115 + 5.18944025039673) + 285.414730980827*std::sin(0.444559872150421*x_115 - 4.1701602935791) + 21.2247878633586*std::sin(0.364959836006165*x_119 + 5.17040014266968) + 3.95459442288285*std::sin(0.416319847106934*x_16 + 2.00135970115662) - 328.126946682024*std::sin(0.323679834604263*x_28 - 4.28424024581909) - 83.2482993588479*std::sin(0.325439840555191*x_28 - 4.28664016723633) - 1.11612895041149*std::sin(0.34079983830452*x_28 + 5.14592027664185) - 0.80385943703273*std::sin(0.370079845190048*x_28 + 5.16351985931396) + 0.834871610047157*std::sin(0.391679853200912*x_36 - 7.39351987838745) - 198.892684271578*std::sin(0.42399987578392*x_36 - 7.37871980667114) - 4.44068560116958*std::sin(0.341519832611084*x_43 - 4.24616003036499) - 4.70744658374271*std::sin(0.445039868354797*x_45 + 5.23095989227295) + 61.3730297751611*std::sin(0.461359858512878*x_45 - 4.14215993881226) + 413.64736645912*std::sin(0.258959949016571*x_48 + 5.06367969512939) + 27.9983493845064*std::sin(0.214479997754097*x_53 + 5.02799987792969) + 1.34038252672552*std::sin(0.241599977016449*x_53 + 5.06559991836548) + 3.99223118374365*std::sin(0.327359855175018*x_53 + 5.13840007781982) + 3.31870814999488*std::sin(0.457919865846634*x_53 - 7.34488010406494) + 109.895198101867*std::sin(0.594959855079651*x_53 - 1.00071978569031) - 165.696834826307*std::sin(0.529839813709259*x_55 + 5.14864015579224) + 2.59110715286603*std::sin(0.24695996940136*x_56 - 7.5360803604126) + 52.0499694552556*std::sin(0.386239856481552*x_59 + 2.000079870224) + 23.9099172037549*std::sin(0.19472000002861*x_64 - 4.39791965484619) + 8.07483444605425*std::sin(0.258799970149994*x_64 - 4.32423973083496) + 0.99485509555592*std::sin(0.36847984790802*x_67 + 1.96831977367401) + 2.65069255343586*std::sin(0.515679836273193*x_69 - 1.07575976848602) - 3.90280814469701*std::sin(0.191359996795654*x_72 - 7.60400009155273) - 11.012516153629*std::sin(0.473599851131439*x_75 - 0.933439791202545) + 10.6661979325161*std::sin(0.237279981374741*x_78 - 7.56224012374878) + 6.69797098700478*std::sin(0.136480033397675*x_80 - 7.68383979797363) - 383.430726135024*std::sin(0.289759933948517*x_80 - 7.48191976547241) - 28.3927023048815*std::sin(0.309119939804077*x_80 - 4.26359987258911) - 114.29483431661*std::sin(0.357839852571487*x_80 + 5.14359998703003) + 0.301432171500393*std::sin(0.388959854841232*x_80 + 1.99631977081299) + 40.3352863645434*std::sin(0.487999856472015*x_80 - 7.32735967636108) + 0.0425697688482238*std::sin(0.517279863357544*x_80 + 2.1354398727417) + 16.4438638057675*std::sin(0.559519827365875*x_80 - 1.01055979728699) + 194.319589530558*std::sin(0.6211998462677*x_80 + 8.41695976257324) + 292.192889038777*std::sin(0.522799849510193*x_81 - 7.26743984222412) + 16.28048162705*std::sin(0.669119834899902*x_82 + 5.44583988189697) + 291.470339427162*std::sin(0.295759916305542*x_85 + 5.14039945602417) + 44.1307176188711*std::sin(0.551439881324768*x_85 - 7.2323203086853) + 0.14240143014128*std::sin(0.622239828109741*x_87 - 7.19248008728027) + 125.369976754119*std::sin(0.399919867515564*x_92 - 1.20775985717773) - 3.52352611856289*std::sin(0.386559844017029*x_93 + 8.1825590133667) - 3.01891425162403*std::sin(0.371919840574265*x_95 - 4.22896003723145) - 259.388071838189*std::sin(0.277999937534332*x_96 + 5.09999990463257) - 2.82251659480325*std::sin(0.373279839754105*x_96 - 7.40655994415283) + 4.68160954840041*std::sin(0.381279855966568*x_96 + 5.18871974945068) - 175.958710575673*std::sin(0.400719821453094*x_96 - 7.40183973312378) - 16.9229477251188*std::sin(0.438079863786697*x_96 - 7.36663961410522) - 186.914370721556*std::sin(0.441119849681854*x_96 - 7.36895990371704) - 0.800886063795634*std::sin(0.441359847784042*x_96 - 7.37751960754395) + 11.5842416459597*std::sin(0.446559876203537*x_96 - 4.17528009414673) - 1.05297553404947*std::sin(0.45415985584259*x_99 - 1.14119982719421) - 68935.7648583025 + 4.024010397156e-5*std::exp(-3.74424004554749*x_74) + 0.00650863840565403*std::exp(-3.28631997108459*x_74) - 0.237544526949498*std::exp(-3.16623997688293*x_74) + 0.0640387183473349*std::exp(-2.93903994560242*x_74) + 0.00324555544028115*std::exp(-2.78071999549866*x_74) + 0.000132806181739596*std::exp(-4.0*x_45) - 0.0394976776430899*std::exp(-3.97359991073608*x_45) + 3.51564589575123e-5*std::exp(-3.93063998222351*x_45) - 0.0171926216891392*std::exp(-3.84967994689941*x_45) - 0.00280780153196278*std::exp(-4.89256000518799*x_111) + 3.64018921663595e-5*std::exp(-4.78735971450806*x_111) + 0.00921449161113196*std::exp(-4.68495988845825*x_111));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-9800.08274407429*x_1 - 315.847046916687*x_10 - 547.126508721474*x_100 - 93.2363037152603*x_101 - 362.21125638898*x_102 - 76.8869094893623*x_103 + 390.26035381939*x_104 + 263.663641249424*x_105 + 229.727608426491*x_106 - 124.296003011629*x_107 + 54.2348258626067*x_108 - 182.211468266132*x_109 + 106.478394560596*x_11 + 250.609890042545*x_110 + 309.449885536141*x_111 - 271.637057533525*x_112 - 605.134484439775*x_113 - 195.32497389154*x_114 + 513.643502693396*x_115 + 579.039867648677*x_116 + 366.767987510233*x_117 + 207.984249452649*x_118 + 404.708735778209*x_119 - 1035.84534139081*x_12 - 494.076138969625*x_120 - 421.547450527625*x_13 + 61.2594904519898*x_14 - 117.038163206605*x_15 + 462.437784381069*x_16 + 151.490392879564*x_17 - 121.672038275778*x_18 - 131.399764224112*x_19 + 59.3914735718345*x_2 - 74.9190702487586*x_20 - 684.858824316648*x_21 - 361.206729450641*x_22 - 301.665406829708*x_23 + 8.21171138203349*x_24 - 305.32539740827*x_25 - 25.9774666762172*x_26 + 74.554986100355*x_27 - 63.1659548819994*x_28 + 28.0727903491045*x_29 + 848.946557723934*x_3 - 74.7570910452329*x_30 - 9826.35518306136*x_31 - 49.9932141469371*x_32 - 75.287511559929*x_33 - 325.221023925072*x_34 + 15.2618820074481*x_35 + 70.2509428095264*x_36 - 1952.93766684873*x_37 + 348.558596760847*x_38 - 503.351633638682*x_39 + 250.83123769861*x_4 - 271.021976734234*x_40 - 321.45147389732*x_41 + 63011.8996666193*x_42 - 764.408504106*x_43 - 531.27093941335*x_44 - 180.121315935832*x_45 - 55.2544735010675*x_46 - 523.892062682304*x_47 + 1460.56058571565*x_48 + 840.152684041292*x_49 - 143.285735620665*x_5 + 466.791156699164*x_50 - 197.20904789866*x_51 - 98.8696789155316*x_52 - 10.6156730245155*x_53 + 590.661629836886*x_54 - 175.427650303317*x_55 - 107.570204988979*x_56 + 1954.40367222615*x_57 + 257.892292346474*x_58 + 292.175097943144*x_59 + 296.653455985161*x_6 + 77.1046597696618*x_60 - 130.112550744713*x_61 + 159.999807296863*x_62 + 473.800630289423*x_63 + 78.6589699528923*x_64 + 35.2817701540932*x_65 + 200.813789501665*x_66 + 65.4053093220445*x_67 - 587.181417665729*x_68 + 219.645689783761*x_69 - 47.497473138261*x_7 + 113.781779470891*x_70 - 231.648810760737*x_72 + 170.72091875826*x_73 + 27.9975150685899*x_74 + 233.958818631812*x_75 - 480.195309880994*x_76 - 23.6788389729445*x_77 + 251.049466166555*x_78 + 108.006879059628*x_79 - 1363.3066315797*x_8 - 23.813006727068*x_80 + 206.772119311792*x_81 + 37.8302723709345*x_82 + 187.004430604913*x_83 + 2723.31263835201*x_84 + 222.658421215993*x_85 - 161.374271386464*x_86 - 238.082948906846*x_87 - 379.765318424044*x_88 - 781.728395850148*x_89 + 17.9213821373558*x_9 + 184.080134781095*x_90 - 902.276890890995*x_91 + 109.102996272705*x_92 + 28.2978167412926*x_93 - 236.183892223666*x_94 + 59.4936108795665*x_95 + 30.2079791906589*x_96 - 782.520006073092*x_97 - 412.902724534343*x_98 + 268.54033497314*x_99 - 0.000744849997900632*std::pow(-6.1384801864624*x_15 - 8.91168022155762, 2) + 0.00750354304973736*std::pow(-6.67000007629395*x_6 - 8.49240016937256, 2) - 0.000604727953019825*std::pow(-5.50063991546631*x_64 - 8.64447975158691, 2) - 0.0013909818460148*std::pow(-6.22312021255493*x_80 - 8.63335990905762, 2) - 0.00174477572156431*std::pow(-5.10504007339478*x_81 - 6.32679986953735, 2) - 2.02570531391062*std::exp(0.346639841794968*x_1) + 1.28509844598235*std::exp(0.7290398478508*x_19) - 0.00446937734368896*std::exp(2.51127982139587*x_71) - 0.0379923590786255*std::exp(2.52927994728088*x_71) - 0.112768854043727*std::exp(2.55039978027344*x_71) - 0.0133148979029304*std::exp(2.5557599067688*x_71) + 0.0199730653510101*std::exp(2.58471989631653*x_71) + 0.0863652845564055*std::exp(2.58607983589172*x_71) + 3.42903144874704*std::exp(2.60103988647461*x_71) + 0.052974820888684*std::exp(2.60951995849609*x_71) + 0.00774886933968223*std::exp(2.61911988258362*x_71) - 0.14902250850785*std::exp(2.61959981918335*x_71) + 13.9646514281038*std::exp(2.62344002723694*x_71) - 2.59332436449249*std::exp(2.63927984237671*x_71) + 3.99210782057412*std::exp(2.65535998344421*x_71) - 3.5518277040946*std::exp(2.66295981407166*x_71) + 0.185451733307694*std::exp(2.69736003875732*x_71) - 0.0369784723702516*std::exp(1.32943987846375*x_76) - 0.506697409196949*std::exp(2.37591981887817*x_81) + 0.208116938739707*std::sin(0.41567987203598*x_103 + 5.20480012893677) + 1.1128539269175*std::sin(0.364319831132889*x_105 + 5.16792011260986) + 0.820855749657845*std::sin(0.324479848146439*x_112 + 1.92879974842072) - 0.877746723183733*std::sin(0.342559844255447*x_112 + 1.97303986549377) - 125.408889388798*std::sin(0.462799847126007*x_113 + 8.24320030212402) - 208.555577561664*std::sin(0.271039962768555*x_115 - 7.52120018005371) - 160.038172981977*std::sin(0.402399837970734*x_115 + 5.18944025039673) + 47.4215615461422*std::sin(0.444559872150421*x_115 - 4.1701602935791) - 131.395515828913*std::sin(0.364959836006165*x_119 + 5.17040014266968) - 0.807790842534126*std::sin(0.416319847106934*x_16 + 2.00135970115662) - 2163.39433426238*std::sin(0.323679834604263*x_28 - 4.28424024581909) - 26.6714796698404*std::sin(0.325439840555191*x_28 - 4.28664016723633) + 3.00082404852565*std::sin(0.34079983830452*x_28 + 5.14592027664185) + 3.46205947154647*std::sin(0.370079845190048*x_28 + 5.16351985931396) - 5.37096930725694*std::sin(0.391679853200912*x_36 - 7.39351987838745) - 33.0459525892364*std::sin(0.42399987578392*x_36 - 7.37871980667114) - 0.758179110887749*std::sin(0.341519832611084*x_43 - 4.24616003036499) - 0.533021536388464*std::sin(0.445039868354797*x_45 + 5.23095989227295) + 19.662978445586*std::sin(0.461359858512878*x_45 - 4.14215993881226) - 15.7807896720681*std::sin(0.258959949016571*x_48 + 5.06367969512939) + 3.17023739723571*std::sin(0.214479997754097*x_53 + 5.02799987792969) - 8.62306649835614*std::sin(0.241599977016449*x_53 + 5.06559991836548) - 0.815478768909099*std::sin(0.327359855175018*x_53 + 5.13840007781982) + 0.566618630644857*std::sin(0.457919865846634*x_53 - 7.34488010406494) + 724.556917194041*std::sin(0.594959855079651*x_53 - 1.00071978569031) + 6.32139138731777*std::sin(0.529839813709259*x_55 + 5.14864015579224) - 11.1593727051144*std::sin(0.24695996940136*x_56 - 7.5360803604126) - 9.36682282741826*std::sin(0.386239856481552*x_59 + 2.000079870224) + 2.70730651450828*std::sin(0.19472000002861*x_64 - 4.39791965484619) + 1.37865441301738*std::sin(0.258799970149994*x_64 - 4.32423973083496) - 2.67476718925877*std::sin(0.36847984790802*x_67 + 1.96831977367401) + 0.452565190129981*std::sin(0.515679836273193*x_69 - 1.07575976848602) + 10.493089112213*std::sin(0.191359996795654*x_72 - 7.60400009155273) + 68.1747798798186*std::sin(0.473599851131439*x_75 - 0.933439791202545) + 1.82109007287025*std::sin(0.237279981374741*x_78 - 7.56224012374878) - 28.8468018504574*std::sin(0.136480033397675*x_80 - 7.68383979797363) + 14.6280144238345*std::sin(0.289759933948517*x_80 - 7.48191976547241) + 175.769660886323*std::sin(0.309119939804077*x_80 - 4.26359987258911) - 224.609967576094*std::sin(0.357839852571487*x_80 + 5.14359998703003) - 0.810430469440115*std::sin(0.388959854841232*x_80 + 1.99631977081299) + 12.9228077754692*std::sin(0.487999856472015*x_80 - 7.32735967636108) - 0.323915638425087*std::sin(0.517279863357544*x_80 + 2.1354398727417) - 2.95920939971402*std::sin(0.559519827365875*x_80 - 1.01055979728699) + 32.2861344362898*std::sin(0.6211998462677*x_80 + 8.41695976257324) + 48.5477502274692*std::sin(0.522799849510193*x_81 - 7.26743984222412) - 2.92980742431959*std::sin(0.669119834899902*x_82 + 5.44583988189697) - 11.1196939594221*std::sin(0.295759916305542*x_85 + 5.14039945602417) + 86.7248210538234*std::sin(0.551439881324768*x_85 - 7.2323203086853) - 0.613294062706027*std::sin(0.622239828109741*x_87 - 7.19248008728027) + 420.275291480851*std::sin(0.399919867515564*x_92 - 1.20775985717773) + 0.719738063538263*std::sin(0.386559844017029*x_93 + 8.1825590133667) + 0.616662804343894*std::sin(0.371919840574265*x_95 - 4.22896003723145) - 1710.18775100413*std::sin(0.277999937534332*x_96 + 5.09999990463257) + 0.576545358226793*std::sin(0.373279839754105*x_96 - 7.40655994415283) + 0.799313188034514*std::sin(0.381279855966568*x_96 + 5.18871974945068) - 29.2354805740726*std::sin(0.400719821453094*x_96 - 7.40183973312378) + 104.764271850577*std::sin(0.438079863786697*x_96 - 7.36663961410522) + 7.1308476983507*std::sin(0.441119849681854*x_96 - 7.36895990371704) + 2.15326209348923*std::sin(0.441359847784042*x_96 - 7.37751960754395) + 3.71141354154156*std::sin(0.446559876203537*x_96 - 4.17528009414673) + 2.83102978730176*std::sin(0.45415985584259*x_99 - 1.14119982719421) + 20823.8581830672 - 0.000258876168204916*std::exp(-3.74424004554749*x_74) + 0.000736969476140165*std::exp(-3.28631997108459*x_74) - 1.56616970637155*std::exp(-3.16623997688293*x_74) + 0.0205170242231747*std::exp(-2.93903994560242*x_74) - 0.00872599963689523*std::exp(-2.78071999549866*x_74) - 0.000854380382987354*std::exp(-4.0*x_45) + 0.0015068500224148*std::exp(-3.97359991073608*x_45) - 0.000151411734580327*std::exp(-3.93063998222351*x_45) - 0.0576344853751884*std::exp(-3.84967994689941*x_45) - 0.00551783652187872*std::exp(-4.89256000518799*x_111) - 9.78701192047536e-5*std::exp(-4.78735971450806*x_111) - 0.000351536032478718*std::exp(-4.68495988845825*x_111));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (4470.42942101524*x_1 + 165.44102735631*x_10 + 275.22096863112*x_100 - 15.7271965713164*x_101 + 159.353980063885*x_102 + 44.6014190884036*x_103 - 68.2253310606247*x_104 - 102.428850341718*x_105 - 143.14762851278*x_106 + 35.1368966387137*x_107 - 3.70213965404809*x_108 + 91.5907936377976*x_109 - 8.34379999943122*x_11 - 93.4456685965536*x_110 - 129.217377161871*x_111 + 91.3980244253428*x_112 + 276.824980940511*x_113 + 128.451613314604*x_114 - 180.560433589813*x_115 - 391.212358435346*x_116 - 145.175710985926*x_117 - 87.9722426612228*x_118 - 158.132646836026*x_119 + 977.120233450421*x_12 + 267.965072887542*x_120 + 128.023226780245*x_13 - 21.2300449311446*x_14 + 36.8611942145621*x_15 - 174.76922068045*x_16 - 87.3945935806432*x_17 + 75.5325723547038*x_18 + 34.9526845049087*x_19 - 50.3308568403168*x_2 - 245.346656000796*x_20 + 435.637696964293*x_21 + 78.2746598019403*x_22 + 181.971474951735*x_23 + 34.2069232847912*x_24 + 6.73885040272556*x_25 + 23.588526256867*x_26 - 57.121313815091*x_27 + 90.6982243711107*x_28 - 27.0942483863356*x_29 - 522.804987365275*x_3 - 172.093022099442*x_30 + 439.213757795631*x_31 + 34.1201818175972*x_32 + 74.5313517712794*x_33 + 103.219150291171*x_34 + 0.441107175982361*x_35 - 71.9480900467304*x_36 + 55.9105106716782*x_37 - 102.379195561934*x_38 + 227.622366918814*x_39 - 110.397344217176*x_4 + 98.7668161471701*x_40 + 162.548440409629*x_41 - 62455.4130766446*x_42 + 421.047491951196*x_43 + 252.7664351311*x_44 + 72.974967270557*x_45 + 10.1609111669433*x_46 + 202.800095118242*x_47 - 579.933475984689*x_48 - 538.15925248785*x_49 + 63.5413822958243*x_5 + 233.133008005974*x_50 + 26.7435112972008*x_51 - 188.497963575529*x_52 + 57.2250187478004*x_53 - 173.220480703682*x_54 + 80.8473779396841*x_55 + 88.0197364887633*x_56 - 1529.6029733693*x_57 - 110.300001531697*x_58 - 128.563500781359*x_59 - 159.674127037548*x_6 - 17.7031266185924*x_60 + 30.2415852098062*x_61 - 63.1886370484399*x_62 - 234.419860432513*x_63 - 6.97929871558753*x_64 - 5.87942479811706*x_65 - 16.2180152464689*x_66 + 4.81948778031681*x_67 + 228.579949219524*x_68 - 149.103659276777*x_69 + 39.750128641536*x_7 - 85.7374967732895*x_70 + 36.1935849458623*x_72 - 61.2798401144762*x_73 - 62.3441656434717*x_74 - 56.5318438404953*x_75 + 66.3664256477468*x_76 + 31.8520212602233*x_77 - 173.269713917221*x_78 - 41.4765457987891*x_79 + 713.8458892572*x_8 + 25.3035501748618*x_80 - 104.725082420063*x_81 + 4.5035286311685*x_82 - 125.200922104882*x_83 - 1199.32255774424*x_84 - 105.653034076928*x_85 + 78.4723205446088*x_86 + 96.9019873176765*x_87 + 115.303185565429*x_88 + 347.202290562519*x_89 - 13.7175447277206*x_9 + 194.632474947723*x_90 + 428.917188568033*x_91 - 45.5276096144408*x_92 - 38.1077379732696*x_93 + 94.5563717666511*x_94 - 42.4174015016183*x_95 - 34.1224497620749*x_96 + 296.944330152072*x_97 + 171.149916894541*x_98 - 140.608609887618*x_99 - 0.000226371951524749*std::pow(-6.1384801864624*x_15 - 8.91168022155762, 2) - 0.0105730915919199*std::pow(-6.67000007629395*x_6 - 8.49240016937256, 2) - 0.000183786597640465*std::pow(-5.50063991546631*x_64 - 8.64447975158691, 2) + 0.0161089199825724*std::pow(-6.22312021255493*x_80 - 8.63335990905762, 2) + 0.020206196483973*std::pow(-5.10504007339478*x_81 - 6.32679986953735, 2) + 2.85438061463052*std::exp(0.346639841794968*x_1) - 0.749066604655343*std::exp(0.7290398478508*x_19) - 0.00135831600220578*std::exp(2.51127982139587*x_71) - 0.900497388966415*std::exp(2.52927994728088*x_71) + 0.158900324102481*std::exp(2.55039978027344*x_71) - 0.025250804466316*std::exp(2.5557599067688*x_71) - 0.231307484326929*std::exp(2.58471989631653*x_71) - 0.169531563325742*std::exp(2.58607983589172*x_71) - 0.781106007974979*std::exp(2.60103988647461*x_71) + 0.0547065438399518*std::exp(2.60951995849609*x_71) + 0.046296631489174*std::exp(2.61911988258362*x_71) + 0.0868632164439878*std::exp(2.61959981918335*x_71) - 5.57126903643003*std::exp(2.62344002723694*x_71) + 0.726446672115526*std::exp(2.63927984237671*x_71) - 3.83466620724099*std::exp(2.65535998344421*x_71) + 1.16579292354588*std::exp(2.66295981407166*x_71) + 0.41393838511644*std::exp(2.69736003875732*x_71) + 0.428246604509467*std::exp(1.32943987846375*x_76) + 0.486714166969736*std::exp(2.37591981887817*x_81) + 0.394679716251377*std::sin(0.41567987203598*x_103 + 5.20480012893677) - 12.887928704725*std::sin(0.364319831132889*x_105 + 5.16792011260986) + 4.90430983950974*std::sin(0.324479848146439*x_112 + 1.92879974842072) - 1.66458736969994*std::sin(0.342559844255447*x_112 + 1.97303986549377) + 28.5671445185647*std::sin(0.462799847126007*x_113 + 8.24320030212402) + 68.4528183073536*std::sin(0.271039962768555*x_115 - 7.52120018005371) + 36.4554190563748*std::sin(0.402399837970734*x_115 + 5.18944025039673) - 13.2838128709974*std::sin(0.444559872150421*x_115 - 4.1701602935791) + 29.9308502616498*std::sin(0.364959836006165*x_119 + 5.17040014266968) - 1.53192076749014*std::sin(0.416319847106934*x_16 + 2.00135970115662) + 863.097223021825*std::sin(0.323679834604263*x_28 - 4.28424024581909) - 59.5321975496556*std::sin(0.325439840555191*x_28 - 4.28664016723633) - 5.89049633570976*std::sin(0.34079983830452*x_28 + 5.14592027664185) + 3.57523263088813*std::sin(0.370079845190048*x_28 + 5.16351985931396) + 3.13066579083722*std::sin(0.391679853200912*x_36 - 7.39351987838745) + 9.25689150729751*std::sin(0.42399987578392*x_36 - 7.37871980667114) - 4.52984007870742*std::sin(0.341519832611084*x_43 - 4.24616003036499) + 6.17290678758306*std::sin(0.445039868354797*x_45 + 5.23095989227295) + 43.8888405040729*std::sin(0.461359858512878*x_45 - 4.14215993881226) - 374.037312769039*std::sin(0.258959949016571*x_48 + 5.06367969512939) - 36.7144263630349*std::sin(0.214479997754097*x_53 + 5.02799987792969) + 5.02626951564268*std::sin(0.241599977016449*x_53 + 5.06559991836548) - 1.54650040054937*std::sin(0.327359855175018*x_53 + 5.13840007781982) + 3.38533698116803*std::sin(0.457919865846634*x_53 - 7.34488010406494) - 289.06568407218*std::sin(0.594959855079651*x_53 - 1.00071978569031) + 149.830033642659*std::sin(0.529839813709259*x_55 + 5.14864015579224) - 11.5241675550263*std::sin(0.24695996940136*x_56 - 7.5360803604126) + 13.1986016503292*std::sin(0.386239856481552*x_59 + 2.000079870224) - 31.3532373808183*std::sin(0.19472000002861*x_64 - 4.39791965484619) + 8.23695077467993*std::sin(0.258799970149994*x_64 - 4.32423973083496) + 5.25045989782257*std::sin(0.36847984790802*x_67 + 1.96831977367401) + 2.70390981107121*std::sin(0.515679836273193*x_69 - 1.07575976848602) - 20.597509872708*std::sin(0.191359996795654*x_72 - 7.60400009155273) - 15.5296709734045*std::sin(0.473599851131439*x_75 - 0.933439791202545) + 10.8803403846947*std::sin(0.237279981374741*x_78 - 7.56224012374878) - 29.7897907647584*std::sin(0.136480033397675*x_80 - 7.68383979797363) + 346.714158159156*std::sin(0.289759933948517*x_80 - 7.48191976547241) - 40.0389264986761*std::sin(0.309119939804077*x_80 - 4.26359987258911) + 73.7222445943021*std::sin(0.357839852571487*x_80 + 5.14359998703003) + 1.59084225978861*std::sin(0.388959854841232*x_80 + 1.99631977081299) + 28.8444118927303*std::sin(0.487999856472015*x_80 - 7.32735967636108) - 0.0984431971623018*std::sin(0.517279863357544*x_80 + 2.1354398727417) + 4.16976244628088*std::sin(0.559519827365875*x_80 - 1.01055979728699) - 9.0440498835583*std::sin(0.6211998462677*x_80 + 8.41695976257324) - 13.599282864233*std::sin(0.522799849510193*x_81 - 7.26743984222412) + 4.12833271411727*std::sin(0.669119834899902*x_82 + 5.44583988189697) - 263.5597162009*std::sin(0.295759916305542*x_85 + 5.14039945602417) - 28.465114612338*std::sin(0.551439881324768*x_85 - 7.2323203086853) - 0.633342368418961*std::sin(0.622239828109741*x_87 - 7.19248008728027) - 403.700383460135*std::sin(0.399919867515564*x_92 - 1.20775985717773) + 1.36493461999208*std::sin(0.386559844017029*x_93 + 8.1825590133667) + 1.16945935354944*std::sin(0.371919840574265*x_95 - 4.22896003723145) + 682.288141075711*std::sin(0.277999937534332*x_96 + 5.09999990463257) + 1.09337932687737*std::sin(0.373279839754105*x_96 - 7.40655994415283) + 4.77560099269764*std::sin(0.381279855966568*x_96 + 5.18871974945068) + 8.1894952523185*std::sin(0.400719821453094*x_96 - 7.40183973312378) - 23.864465341521*std::sin(0.438079863786697*x_96 - 7.36663961410522) + 169.015820265149*std::sin(0.441119849681854*x_96 - 7.36895990371704) - 4.22676647028098*std::sin(0.441359847784042*x_96 - 7.37751960754395) + 8.2840774819615*std::sin(0.446559876203537*x_96 - 4.17528009414673) - 5.55719706277994*std::sin(0.45415985584259*x_99 - 1.14119982719421) + 96867.0957177492 + 0.000150895437582768*std::exp(-3.74424004554749*x_74) - 0.00853482189918811*std::exp(-3.28631997108459*x_74) + 0.624831406342333*std::exp(-3.16623997688293*x_74) + 0.0457951172677633*std::exp(-2.93903994560242*x_74) + 0.0171287846456009*std::exp(-2.78071999549866*x_74) + 0.000498006837195459*std::exp(-4.0*x_45) + 0.0357154581514763*std::exp(-3.97359991073608*x_45) - 0.000156361315748614*std::exp(-3.93063998222351*x_45) + 0.055361484051344*std::exp(-3.84967994689941*x_45) + 0.00181108299906371*std::exp(-4.89256000518799*x_111) + 0.000192115088798466*std::exp(-4.78735971450806*x_111) - 0.00833213011910053*std::exp(-4.68495988845825*x_111));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (5612.5681380822*x_1 + 81.0927919576481*x_10 + 550.89010568634*x_100 + 476.916612522414*x_101 + 77.1364196522137*x_102 + 1.93965809933763*x_103 - 282.329882429253*x_104 - 119.780579540531*x_105 - 103.452170925631*x_106 + 120.737610419059*x_107 + 113.20391688018*x_108 - 343.009036659404*x_109 - 142.181327634827*x_11 - 21.4508668158184*x_110 - 219.435293616955*x_111 + 187.080927843842*x_112 + 677.131248446049*x_113 + 53.2553864467272*x_114 - 325.021469453015*x_115 - 640.022899425221*x_116 - 226.341271894761*x_117 + 29.7146144058681*x_118 - 198.104588997937*x_119 - 689.379749404613*x_12 + 168.323750973641*x_120 + 291.79487151201*x_13 + 54.5029111763721*x_14 + 276.107472177741*x_15 - 332.995453211661*x_16 + 168.650993850632*x_17 - 10.5853623899443*x_18 + 111.60546601062*x_19 + 4.1507848463117*x_2 + 755.15260556663*x_20 - 261.387833391363*x_21 + 751.300459707026*x_22 - 10.3527321884031*x_23 - 150.023567980376*x_24 + 509.499945638137*x_25 + 53.6229397428463*x_26 - 25.2074897378985*x_27 - 170.6890285376*x_28 + 96.9844408494754*x_29 - 273.622311494619*x_3 + 86.5196584400996*x_30 + 22641.3777250681*x_31 - 20.1271186419723*x_32 + 132.18622754318*x_33 + 171.116761708789*x_34 - 117.402821813881*x_35 + 87.7199657711301*x_36 + 737.51236820672*x_37 - 253.559377920808*x_38 + 230.561273956323*x_39 - 247.862240391858*x_4 + 265.566759430136*x_40 - 44.6064826204303*x_41 - 74443.1744618529*x_42 + 332.356309350873*x_43 + 482.915598306525*x_44 + 158.316294553555*x_45 + 143.266140926239*x_46 + 219.062515406569*x_47 - 1094.54047389547*x_48 - 341.296628183391*x_49 + 129.973992583625*x_5 - 1052.28107675883*x_50 + 486.861481372136*x_51 + 29.7945155953326*x_52 - 30.1127866690845*x_53 - 477.925298360907*x_54 + 138.294724232791*x_55 + 126.954213352833*x_56 - 250.295909068176*x_57 - 351.23026594023*x_58 - 263.789802537908*x_59 - 78.8912731626057*x_6 + 205.537598951185*x_60 + 99.6451142696098*x_61 - 348.643345894867*x_62 - 227.903210020979*x_63 - 215.301386638901*x_64 - 89.556624398626*x_65 - 315.320405824644*x_66 - 92.5582483513971*x_67 + 206.010116150487*x_68 - 15.0489982680049*x_69 + 11.5256940246252*x_7 + 103.341600432424*x_70 + 357.194098150138*x_72 - 210.211168502274*x_73 + 169.649703313572*x_74 - 248.1421196687*x_75 + 783.344174293561*x_76 - 113.054749222792*x_77 - 93.5654967953545*x_78 - 72.3166852364728*x_79 + 1121.22340710917*x_8 - 70.0732688180802*x_80 - 65.875737849989*x_81 - 137.854515747491*x_82 + 8.57670965548224*x_83 - 1589.51839367525*x_84 - 36.7045581338884*x_85 - 94.693162559048*x_86 + 282.030091330209*x_87 + 293.587004299863*x_88 + 261.7545369113*x_89 - 391.40494688594*x_9 - 638.723896487063*x_90 + 663.357334349259*x_91 - 139.329770823843*x_92 + 90.4675917750533*x_93 + 195.389548262783*x_94 + 48.2743086995582*x_95 + 118.854090126245*x_96 + 674.654994006527*x_97 + 378.947001970916*x_98 - 17.9544625357486*x_99 + 0.000119065481460198*std::pow(-6.1384801864624*x_15 - 8.91168022155762, 2) - 0.03673120141418*std::pow(-6.67000007629395*x_6 - 8.49240016937256, 2) + 9.66667450918769e-5*std::pow(-5.50063991546631*x_64 - 8.64447975158691, 2) - 0.00325404761883954*std::pow(-6.22312021255493*x_80 - 8.63335990905762, 2) - 0.00408170911678813*std::pow(-5.10504007339478*x_81 - 6.32679986953735, 2) + 9.91619417624719*std::exp(0.346639841794968*x_1) - 1.19216582329402*std::exp(0.7290398478508*x_19) + 0.00071443722461367*std::exp(2.51127982139587*x_71) + 0.356863024485329*std::exp(2.52927994728088*x_71) + 0.55202395237426*std::exp(2.55039978027344*x_71) + 0.0146585965134878*std::exp(2.5557599067688*x_71) + 0.0467247692215313*std::exp(2.58471989631653*x_71) + 0.0378324080429834*std::exp(2.58607983589172*x_71) - 1.32487576177966*std::exp(2.60103988647461*x_71) + 0.0058404474664277*std::exp(2.60951995849609*x_71) + 0.0173365531382031*std::exp(2.61911988258362*x_71) + 0.138245861319048*std::exp(2.61959981918335*x_71) - 10.5503859045088*std::exp(2.62344002723694*x_71) + 7.49014905404924*std::exp(2.63927984237671*x_71) + 9.96318019545747*std::exp(2.65535998344421*x_71) + 6.4723922571467*std::exp(2.66295981407166*x_71) + 0.112051027829533*std::exp(2.69736003875732*x_71) - 0.0865070312092778*std::exp(1.32943987846375*x_76) - 1.26457446023455*std::exp(2.37591981887817*x_81) - 0.229119461136553*std::sin(0.41567987203598*x_103 + 5.20480012893677) + 2.60339822649532*std::sin(0.364319831132889*x_105 + 5.16792011260986) + 1.83650139122443*std::sin(0.324479848146439*x_112 + 1.92879974842072) + 0.966326227207098*std::sin(0.342559844255447*x_112 + 1.97303986549377) + 48.4542648110259*std::sin(0.462799847126007*x_113 + 8.24320030212402) + 380.044759445607*std::sin(0.271039962768555*x_115 - 7.52120018005371) + 61.833990009277*std::sin(0.402399837970734*x_115 + 5.18944025039673) - 136.964958652939*std::sin(0.444559872150421*x_115 - 4.1701602935791) + 50.7673192066733*std::sin(0.364959836006165*x_119 + 5.17040014266968) + 0.889310613894539*std::sin(0.416319847106934*x_16 + 2.00135970115662) + 1634.45863347233*std::sin(0.323679834604263*x_28 - 4.28424024581909) - 16.1150648604702*std::sin(0.325439840555191*x_28 - 4.28664016723633) + 1.3145142802705*std::sin(0.34079983830452*x_28 + 5.14592027664185) + 0.381690322496868*std::sin(0.370079845190048*x_28 + 5.16351985931396) + 4.98256461681288*std::sin(0.391679853200912*x_36 - 7.39351987838745) + 95.4447171805537*std::sin(0.42399987578392*x_36 - 7.37871980667114) - 1.69627488450077*std::sin(0.341519832611084*x_43 - 4.24616003036499) - 1.246944714803*std::sin(0.445039868354797*x_45 + 5.23095989227295) + 11.8804872066756*std::sin(0.461359858512878*x_45 - 4.14215993881226) + 148.229287880925*std::sin(0.258959949016571*x_48 + 5.06367969512939) + 7.41641846957733*std::sin(0.214479997754097*x_53 + 5.02799987792969) + 7.99948455581043*std::sin(0.241599977016449*x_53 + 5.06559991836548) + 0.897774382192103*std::sin(0.327359855175018*x_53 + 5.13840007781982) + 1.26769643010567*std::sin(0.457919865846634*x_53 - 7.34488010406494) - 547.407511425179*std::sin(0.594959855079651*x_53 - 1.00071978569031) - 59.3769616876169*std::sin(0.529839813709259*x_55 + 5.14864015579224) - 1.23031525070111*std::sin(0.24695996940136*x_56 - 7.5360803604126) + 45.8522931905991*std::sin(0.386239856481552*x_59 + 2.000079870224) + 6.33344305840116*std::sin(0.19472000002861*x_64 - 4.39791965484619) + 3.08446489968485*std::sin(0.258799970149994*x_64 - 4.32423973083496) - 1.17168471387288*std::sin(0.36847984790802*x_67 + 1.96831977367401) + 1.01252455335776*std::sin(0.515679836273193*x_69 - 1.07575976848602) + 4.59650924516275*std::sin(0.191359996795654*x_72 - 7.60400009155273) - 26.340707216447*std::sin(0.473599851131439*x_75 - 0.933439791202545) + 4.07432664480362*std::sin(0.237279981374741*x_78 - 7.56224012374878) - 3.1803454538538*std::sin(0.136480033397675*x_80 - 7.68383979797363) - 137.401245832125*std::sin(0.289759933948517*x_80 - 7.48191976547241) - 67.9121690323401*std::sin(0.309119939804077*x_80 - 4.26359987258911) + 409.300207141682*std::sin(0.357839852571487*x_80 + 5.14359998703003) - 0.355009959937092*std::sin(0.388959854841232*x_80 + 1.99631977081299) + 7.80803645163198*std::sin(0.487999856472015*x_80 - 7.32735967636108) + 0.0517784406931226*std::sin(0.517279863357544*x_80 + 2.1354398727417) + 14.485865646021*std::sin(0.559519827365875*x_80 - 1.01055979728699) - 93.2501782723225*std::sin(0.6211998462677*x_80 + 8.41695976257324) - 140.217664408385*std::sin(0.522799849510193*x_81 - 7.26743984222412) + 14.3419376545337*std::sin(0.669119834899902*x_82 + 5.44583988189697) + 104.447518236453*std::sin(0.295759916305542*x_85 + 5.14039945602417) - 158.036117473859*std::sin(0.551439881324768*x_85 - 7.2323203086853) - 0.0676153631974186*std::sin(0.622239828109741*x_87 - 7.19248008728027) + 1048.88912046467*std::sin(0.399919867515564*x_92 - 1.20775985717773) - 0.792371818824423*std::sin(0.386559844017029*x_93 + 8.1825590133667) - 0.678894520983416*std::sin(0.371919840574265*x_95 - 4.22896003723145) + 1292.05808216207*std::sin(0.277999937534332*x_96 + 5.09999990463257) - 0.634728545392064*std::sin(0.373279839754105*x_96 - 7.40655994415283) + 1.78830419651844*std::sin(0.381279855966568*x_96 + 5.18871974945068) + 84.4391508307978*std::sin(0.400719821453094*x_96 - 7.40183973312378) - 40.4777986291262*std::sin(0.438079863786697*x_96 - 7.36663961410522) - 66.9802017692906*std::sin(0.441119849681854*x_96 - 7.36895990371704) + 0.943238832162585*std::sin(0.441359847784042*x_96 - 7.37751960754395) + 2.24245788708908*std::sin(0.446559876203537*x_96 - 4.17528009414673) + 1.24013571709001*std::sin(0.45415985584259*x_99 - 1.14119982719421) - 184861.955718603 + 0.000240155391335251*std::exp(-3.74424004554749*x_74) + 0.00172405828002863*std::exp(-3.28631997108459*x_74) + 1.18325150321456*std::exp(-3.16623997688293*x_74) + 0.012396506687785*std::exp(-2.93903994560242*x_74) - 0.00382243375381157*std::exp(-2.78071999549866*x_74) + 0.000792595381213593*std::exp(-4.0*x_45) - 0.01415387381794*std::exp(-3.97359991073608*x_45) - 1.66930678911647e-5*std::exp(-3.93063998222351*x_45) - 0.143839492587372*std::exp(-3.84967994689941*x_45) + 0.0100549929094922*std::exp(-4.89256000518799*x_111) - 4.28721135348248e-5*std::exp(-4.78735971450806*x_111) + 0.00330198531516055*std::exp(-4.68495988845825*x_111));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-2439.99346328199*x_1 + 2.47125058241715*x_10 - 266.915620613461*x_100 - 82.387480205581*x_101 - 84.2948653726428*x_102 + 19.769662995531*x_103 + 182.061216732267*x_104 + 98.7897258289166*x_105 + 47.1838270642363*x_106 - 102.256803836187*x_107 + 23.2818628946088*x_108 + 116.504014235205*x_109 + 41.2876970457297*x_11 + 62.6383594456344*x_110 + 75.9237280305765*x_111 - 100.63535800843*x_112 - 187.60741770027*x_113 + 81.1989423620649*x_114 + 156.436180727185*x_115 + 33.0653727380787*x_116 + 152.58022135212*x_117 + 22.0668945047338*x_118 + 73.8731090321102*x_119 + 160.677351312751*x_12 - 59.9922324405826*x_120 - 136.148384003687*x_13 + 3.23477693477852*x_14 - 120.275069694653*x_15 + 152.484394598358*x_16 - 47.7580260203756*x_17 + 9.96239527934692*x_18 - 32.0151170552395*x_19 + 4.4510013766316*x_2 - 275.349308296298*x_20 - 162.415761090792*x_21 - 235.881282983523*x_22 - 17.4022286163209*x_23 + 58.4018149053557*x_24 - 156.12375621807*x_25 + 3.88568897665321*x_26 - 14.3175561104789*x_27 + 60.8261230854291*x_28 + 11.1567760638932*x_29 + 148.196353319475*x_3 + 132.199262034492*x_30 - 1734.71922858944*x_31 + 112.683483763317*x_32 + 8.02768132954076*x_33 - 22.0600230155363*x_34 + 108.055100803137*x_35 - 41.3447060212481*x_36 + 49.3274673770876*x_37 + 221.903764023974*x_38 - 140.477835188073*x_39 + 38.664678447261*x_4 - 115.212785270959*x_40 - 33.8006738553685*x_41 - 14860.3552340397*x_42 - 56.8804245954506*x_43 + 113.826054322158*x_44 - 75.1434936063944*x_45 - 15.1048612626612*x_46 - 58.1523202254413*x_47 + 241.930455319729*x_48 + 142.746571251822*x_49 - 59.088335681475*x_5 + 626.023367336805*x_50 - 63.2316372838188*x_51 + 24.6401537908707*x_52 + 22.3667997754585*x_53 - 45.0755280131235*x_54 - 84.1816001990831*x_55 + 12.5919667849423*x_56 - 1252.24168214773*x_57 + 56.4517605619325*x_58 + 113.378076430411*x_59 + 59.8477771203488*x_6 - 20.3715289742324*x_60 - 3.83341639529644*x_61 + 291.234257953492*x_62 + 143.481745153977*x_63 + 75.1864121033809*x_64 + 15.1298343842256*x_65 + 160.694632226608*x_66 + 67.8541550450515*x_67 - 41.3687138606212*x_68 + 72.0055811418686*x_69 + 38.6828039103035*x_7 - 62.372043442501*x_70 - 137.371973334136*x_72 - 33.1864995141324*x_73 - 121.210221961891*x_74 + 48.9173148065669*x_75 - 287.459770887068*x_76 + 46.2504057454868*x_77 + 14.0273152786816*x_78 + 48.0764609242935*x_79 - 306.51687404426*x_8 + 8.67303110448183*x_80 - 31.3113288064557*x_81 + 22.6972084152446*x_82 - 28.394166800664*x_83 + 248.312782929564*x_84 + 37.0024763932551*x_85 + 45.0275564282333*x_86 - 64.6360127032212*x_87 - 266.951304757904*x_88 - 211.899635519294*x_89 - 17.0023914930373*x_9 + 354.287838244605*x_90 - 16.4366093073331*x_91 + 76.1303677921095*x_92 - 116.483928555522*x_93 - 70.1244946728044*x_94 - 4.82977716567939*x_95 - 18.1453286426007*x_96 - 212.968027404051*x_97 - 95.3677072650452*x_98 + 87.3153146325486*x_99 + 0.000559569419864401*std::pow(-6.1384801864624*x_15 - 8.91168022155762, 2) + 0.0095623549016821*std::pow(-6.67000007629395*x_6 - 8.49240016937256, 2) + 0.000454302572062615*std::pow(-5.50063991546631*x_64 - 8.64447975158691, 2) - 0.00172118075884003*std::pow(-6.22312021255493*x_80 - 8.63335990905762, 2) - 0.00215896016835274*std::pow(-5.10504007339478*x_81 - 6.32679986953735, 2) - 2.58151555997466*std::exp(0.346639841794968*x_1) - 0.251628517955247*std::exp(0.7290398478508*x_19) + 0.00335762488341548*std::exp(2.51127982139587*x_71) - 0.729551394242765*std::exp(2.52927994728088*x_71) - 0.143710217569799*std::exp(2.55039978027344*x_71) + 0.0220425053657296*std::exp(2.5557599067688*x_71) + 0.0247143813384084*std::exp(2.58471989631653*x_71) + 0.00613068108992909*std::exp(2.58607983589172*x_71) - 2.10705337688909*std::exp(2.60103988647461*x_71) - 0.00286106475307751*std::exp(2.60951995849609*x_71) - 0.0224115421580625*std::exp(2.61911988258362*x_71) + 0.0291793310271566*std::exp(2.61959981918335*x_71) + 3.49867636830755*std::exp(2.62344002723694*x_71) - 8.71140334878055*std::exp(2.63927984237671*x_71) - 1.19160378931369*std::exp(2.65535998344421*x_71) - 2.0198266307225*std::exp(2.66295981407166*x_71) - 0.649304314255197*std::exp(2.69736003875732*x_71) - 0.0457566253055883*std::exp(1.32943987846375*x_76) + 0.151244049502571*std::exp(2.37591981887817*x_81) - 0.344532776166433*std::sin(0.41567987203598*x_103 + 5.20480012893677) + 1.37702930623983*std::sin(0.364319831132889*x_105 + 5.16792011260986) - 2.37410678031889*std::sin(0.324479848146439*x_112 + 1.92879974842072) + 1.4530893887869*std::sin(0.342559844255447*x_112 + 1.97303986549377) + 77.0606008804998*std::sin(0.462799847126007*x_113 + 8.24320030212402) - 118.599815261068*std::sin(0.271039962768555*x_115 - 7.52120018005371) + 98.3394226191917*std::sin(0.402399837970734*x_115 + 5.18944025039673) + 159.296829858116*std::sin(0.444559872150421*x_115 - 4.1701602935791) + 80.7392319007627*std::sin(0.364959836006165*x_119 + 5.17040014266968) + 1.3372790471812*std::sin(0.416319847106934*x_16 + 2.00135970115662) - 542.012571640824*std::sin(0.323679834604263*x_28 - 4.28424024581909) + 93.382286098475*std::sin(0.325439840555191*x_28 - 4.28664016723633) + 0.213014932365393*std::sin(0.34079983830452*x_28 + 5.14592027664185) - 0.186978948884292*std::sin(0.370079845190048*x_28 + 5.16351985931396) + 1.05166187928512*std::sin(0.391679853200912*x_36 - 7.39351987838745) - 111.00679343899*std::sin(0.42399987578392*x_36 - 7.37871980667114) + 2.19283128443096*std::sin(0.341519832611084*x_43 - 4.24616003036499) - 0.659553117179512*std::sin(0.445039868354797*x_45 + 5.23095989227295) - 68.8440949464896*std::sin(0.461359858512878*x_45 - 4.14215993881226) - 303.031909223722*std::sin(0.258959949016571*x_48 + 5.06367969512939) + 3.9228057682495*std::sin(0.214479997754097*x_53 + 5.02799987792969) + 1.68843830602586*std::sin(0.241599977016449*x_53 + 5.06559991836548) + 1.35000623139299*std::sin(0.327359855175018*x_53 + 5.13840007781982) - 1.6387935802724*std::sin(0.457919865846634*x_53 - 7.34488010406494) + 181.529068357475*std::sin(0.594959855079651*x_53 - 1.00071978569031) + 121.387037078371*std::sin(0.529839813709259*x_55 + 5.14864015579224) + 0.602695533037245*std::sin(0.24695996940136*x_56 - 7.5360803604126) - 11.9368788295398*std::sin(0.386239856481552*x_59 + 2.000079870224) + 3.34998180918339*std::sin(0.19472000002861*x_64 - 4.39791965484619) - 3.98739095270446*std::sin(0.258799970149994*x_64 - 4.32423973083496) - 0.189869630041476*std::sin(0.36847984790802*x_67 + 1.96831977367401) - 1.30892435957445*std::sin(0.515679836273193*x_69 - 1.07575976848602) + 0.74485695642178*std::sin(0.191359996795654*x_72 - 7.60400009155273) - 41.8916835005787*std::sin(0.473599851131439*x_75 - 0.933439791202545) - 5.26701834198618*std::sin(0.237279981374741*x_78 - 7.56224012374878) + 1.55795841550423*std::sin(0.136480033397675*x_80 - 7.68383979797363) + 280.895647880832*std::sin(0.289759933948517*x_80 - 7.48191976547241) - 108.00602533421*std::sin(0.309119939804077*x_80 - 4.26359987258911) - 127.729504872354*std::sin(0.357839852571487*x_80 + 5.14359998703003) - 0.0575287950386353*std::sin(0.388959854841232*x_80 + 1.99631977081299) - 45.2453837515827*std::sin(0.487999856472015*x_80 - 7.32735967636108) + 0.243341996897896*std::sin(0.517279863357544*x_80 + 2.1354398727417) - 3.7711532166727*std::sin(0.559519827365875*x_80 - 1.01055979728699) + 108.454439212626*std::sin(0.6211998462677*x_80 + 8.41695976257324) + 163.079882986447*std::sin(0.522799849510193*x_81 - 7.26743984222412) - 3.73368396759017*std::sin(0.669119834899902*x_82 + 5.44583988189697) - 213.526836142515*std::sin(0.295759916305542*x_85 + 5.14039945602417) + 49.3180181311212*std::sin(0.551439881324768*x_85 - 7.2323203086853) + 0.0331227929919201*std::sin(0.622239828109741*x_87 - 7.19248008728027) - 125.447921847831*std::sin(0.399919867515564*x_92 - 1.20775985717773) - 1.19150970913344*std::sin(0.386559844017029*x_93 + 8.1825590133667) - 1.02087100274382*std::sin(0.371919840574265*x_95 - 4.22896003723145) - 428.467083522446*std::sin(0.277999937534332*x_96 + 5.09999990463257) - 0.954457499032245*std::sin(0.373279839754105*x_96 - 7.40655994415283) - 2.31180065450238*std::sin(0.381279855966568*x_96 + 5.18871974945068) - 98.2067908138538*std::sin(0.400719821453094*x_96 - 7.40183973312378) - 64.3750038690205*std::sin(0.438079863786697*x_96 - 7.36663961410522) + 136.93068834442*std::sin(0.441119849681854*x_96 - 7.36895990371704) + 0.152850341037132*std::sin(0.441359847784042*x_96 - 7.37751960754395) - 12.9944152126623*std::sin(0.446559876203537*x_96 - 4.17528009414673) + 0.20096200540741*std::sin(0.45415985584259*x_99 - 1.14119982719421) + 106686.53468621 + 5.06892111985567e-5*std::exp(-3.74424004554749*x_74) + 0.000911915339383495*std::exp(-3.28631997108459*x_74) - 0.392385085202617*std::exp(-3.16623997688293*x_74) - 0.0718342832724175*std::exp(-2.93903994560242*x_74) - 0.000619419263647571*std::exp(-2.78071999549866*x_74) + 0.00016729182905268*std::exp(-4.0*x_45) + 0.0289354112623645*std::exp(-3.97359991073608*x_45) + 8.17744675192731e-6*std::exp(-3.93063998222351*x_45) + 0.0172033106957372*std::exp(-3.84967994689941*x_45) - 0.00313784171963512*std::exp(-4.89256000518799*x_111) - 6.94735728782112e-6*std::exp(-4.78735971450806*x_111) - 0.00675039952351116*std::exp(-4.68495988845825*x_111));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-16572.0161260372*x_1 - 665.253426501471*x_10 - 860.460589203012*x_100 - 561.697133546872*x_101 - 719.312693765456*x_102 - 166.021537946753*x_103 + 491.297309947306*x_104 + 443.417567344525*x_105 + 574.398070888017*x_106 - 256.000481496486*x_107 + 0.616040633318621*x_108 - 479.38408683618*x_109 + 369.116130375811*x_11 + 586.10628959473*x_110 + 663.972302437446*x_111 - 458.763313293819*x_112 - 1550.63310444726*x_113 - 386.874378783666*x_114 + 1095.37394882645*x_115 + 1678.55976737405*x_116 + 669.669688623828*x_117 + 406.518223183461*x_118 + 935.825211348977*x_119 - 1720.9230815831*x_12 - 1182.89018885344*x_120 - 1043.43740695618*x_13 + 25.9872231101517*x_14 - 414.214042425107*x_15 + 966.470623346296*x_16 + 206.716303130917*x_17 - 207.817561022232*x_18 - 220.761037866547*x_19 + 41.7409633957847*x_2 - 697.013989596741*x_20 - 2030.9228229141*x_21 - 1034.96199703365*x_22 - 630.073806843868*x_23 + 213.827753729453*x_24 - 767.49329039102*x_25 - 161.876167864306*x_26 + 91.3809527426757*x_27 - 33.9074898344183*x_28 - 178.869174814144*x_29 + 1624.62076172473*x_3 + 949.827880026691*x_30 - 38830.2896661954*x_31 + 23.8962323323748*x_32 - 278.540357374263*x_33 - 741.907557524663*x_34 - 64.8915026712671*x_35 - 16.4236515805542*x_36 - 5817.43562745604*x_37 + 368.984128521365*x_38 - 938.293914250136*x_39 + 546.330853284658*x_4 - 536.422437391704*x_40 - 744.944601830744*x_41 - 19448.642313114*x_42 - 1667.32292603565*x_43 - 1367.40603249644*x_44 - 402.041672269139*x_45 - 291.330324794472*x_46 - 960.507016145287*x_47 + 2509.66450131249*x_48 + 2131.82844302554*x_49 - 281.69365340553*x_5 + 329.328919125722*x_50 - 600.787436646575*x_51 - 208.923286795503*x_52 - 3.6338801045002*x_53 + 1141.38578874978*x_54 - 201.497858966363*x_55 - 317.70111748319*x_56 + 3034.30749756438*x_57 + 650.345442714594*x_58 + 492.198019504494*x_59 + 601.654097877109*x_6 + 301.014239939708*x_60 - 375.074547868743*x_61 + 498.787846318962*x_62 + 938.62598793679*x_63 + 168.651715000063*x_64 - 9.2574759778937*x_65 + 451.667833835774*x_66 + 103.446775929197*x_67 - 1000.69245882028*x_68 + 462.122935042653*x_69 - 136.716933353639*x_7 + 189.363928082407*x_70 - 789.437486894724*x_72 + 255.710979847611*x_73 + 65.5405455694925*x_74 + 551.924444665806*x_75 - 1063.39206478434*x_76 - 40.0598830412143*x_77 + 624.203224118921*x_78 + 177.538303334806*x_79 - 2551.41813425807*x_8 - 11.4017919069939*x_80 + 640.513383750517*x_81 + 116.193821612056*x_82 + 179.726227668362*x_83 + 4295.98340013838*x_84 + 316.679802345199*x_85 - 399.931988113077*x_86 - 547.361022246698*x_87 - 978.67232521058*x_88 - 1584.48359107406*x_89 + 572.337253112352*x_9 + 134.98233936895*x_90 - 1956.61598840273*x_91 + 150.480769699237*x_92 + 17.7779140343383*x_93 - 472.713900295849*x_94 - 23.6926796201124*x_95 + 39.8537428545872*x_96 - 1111.16383080133*x_97 - 829.895603317667*x_98 + 579.185491392373*x_99 - 9.73031723751112e-5*std::pow(-6.1384801864624*x_15 - 8.91168022155762, 2) + 0.00867495201954596*std::pow(-6.67000007629395*x_6 - 8.49240016937256, 2) - 7.8998386814235e-5*std::pow(-5.50063991546631*x_64 - 8.64447975158691, 2) + 3.26793599951674e-5*std::pow(-6.22312021255493*x_80 - 8.63335990905762, 2) + 4.09912998355706e-5*std::pow(-5.10504007339478*x_81 - 6.32679986953735, 2) - 2.3419465027963*std::exp(0.346639841794968*x_1) - 1.66403067277004*std::exp(0.7290398478508*x_19) - 0.000583855266574627*std::exp(2.51127982139587*x_71) + 0.136258781191705*std::exp(2.52927994728088*x_71) - 0.130373663700478*std::exp(2.55039978027344*x_71) - 0.0495945917496129*std::exp(2.5557599067688*x_71) - 0.000469241920505784*std::exp(2.58471989631653*x_71) - 0.0694776880798266*std::exp(2.58607983589172*x_71) + 2.06973214070394*std::exp(2.60103988647461*x_71) - 0.0837850848743664*std::exp(2.60951995849609*x_71) - 0.010968826876677*std::exp(2.61911988258362*x_71) + 0.192964224542843*std::exp(2.61959981918335*x_71) + 31.0235904414441*std::exp(2.62344002723694*x_71) - 2.06994187798865*std::exp(2.63927984237671*x_71) + 2.75578340700725*std::exp(2.65535998344421*x_71) + 4.13980100788028*std::exp(2.66295981407166*x_71) - 0.0070062079592839*std::exp(2.69736003875732*x_71) + 0.000868762460215421*std::exp(1.32943987846375*x_76) - 0.34977720427343*std::exp(2.37591981887817*x_81) + 0.775182407572453*std::sin(0.41567987203598*x_103 + 5.20480012893677) - 0.0261450961448319*std::sin(0.364319831132889*x_105 + 5.16792011260986) - 1.16195333977474*std::sin(0.324479848146439*x_112 + 1.92879974842072) - 3.26938221481047*std::sin(0.342559844255447*x_112 + 1.97303986549377) - 75.6956630400181*std::sin(0.462799847126007*x_113 + 8.24320030212402) + 243.080087807614*std::sin(0.271039962768555*x_115 - 7.52120018005371) - 96.5975831109299*std::sin(0.402399837970734*x_115 + 5.18944025039673) + 37.8509828959193*std::sin(0.444559872150421*x_115 - 4.1701602935791) - 79.3091362153725*std::sin(0.364959836006165*x_119 + 5.17040014266968) - 3.00881443827961*std::sin(0.416319847106934*x_16 + 2.00135970115662) - 4806.15360397937*std::sin(0.323679834604263*x_28 - 4.28424024581909) + 1.00762570301068*std::sin(0.325439840555191*x_28 - 4.28664016723633) - 2.41405233939503*std::sin(0.34079983830452*x_28 + 5.14592027664185) - 5.47560032856264*std::sin(0.370079845190048*x_28 + 5.16351985931396) + 6.9546871663595*std::sin(0.391679853200912*x_36 - 7.39351987838745) - 26.3766469397569*std::sin(0.42399987578392*x_36 - 7.37871980667114) + 1.07323211223248*std::sin(0.341519832611084*x_43 - 4.24616003036499) + 0.0125226671525018*std::sin(0.445039868354797*x_45 + 5.23095989227295) - 0.742850517660689*std::sin(0.461359858512878*x_45 - 4.14215993881226) + 56.5974637823526*std::sin(0.258959949016571*x_48 + 5.06367969512939) - 0.0744807198391761*std::sin(0.214479997754097*x_53 + 5.02799987792969) + 11.1657182307397*std::sin(0.241599977016449*x_53 + 5.06559991836548) - 3.03744999919397*std::sin(0.327359855175018*x_53 + 5.13840007781982) - 0.802070778612214*std::sin(0.457919865846634*x_53 - 7.34488010406494) + 1609.6611624194*std::sin(0.594959855079651*x_53 - 1.00071978569031) - 22.6715346654073*std::sin(0.529839813709259*x_55 + 5.14864015579224) + 17.6496866541066*std::sin(0.24695996940136*x_56 - 7.5360803604126) - 10.829116067547*std::sin(0.386239856481552*x_59 + 2.000079870224) - 0.0636047439859519*std::sin(0.19472000002861*x_64 - 4.39791965484619) - 1.95153911057875*std::sin(0.258799970149994*x_64 - 4.32423973083496) + 2.15175161427396*std::sin(0.36847984790802*x_67 + 1.96831977367401) - 0.640623683706319*std::sin(0.515679836273193*x_69 - 1.07575976848602) - 8.44130342505878*std::sin(0.191359996795654*x_72 - 7.60400009155273) + 41.1496759979369*std::sin(0.473599851131439*x_75 - 0.933439791202545) - 2.57782404896868*std::sin(0.237279981374741*x_78 - 7.56224012374878) + 45.6241607021815*std::sin(0.136480033397675*x_80 - 7.68383979797363) - 52.4630600727223*std::sin(0.289759933948517*x_80 - 7.48191976547241) + 106.092965881075*std::sin(0.309119939804077*x_80 - 4.26359987258911) + 261.792138475506*std::sin(0.357839852571487*x_80 + 5.14359998703003) + 0.651961440934912*std::sin(0.388959854841232*x_80 + 1.99631977081299) - 0.488212631275699*std::sin(0.487999856472015*x_80 - 7.32735967636108) - 0.0423145858756856*std::sin(0.517279863357544*x_80 + 2.1354398727417) - 3.42118375121564*std::sin(0.559519827365875*x_80 - 1.01055979728699) + 25.7701746310961*std::sin(0.6211998462677*x_80 + 8.41695976257324) + 38.7498851489167*std::sin(0.522799849510193*x_81 - 7.26743984222412) - 3.38719171250328*std::sin(0.669119834899902*x_82 + 5.44583988189697) + 39.880543953588*std::sin(0.295759916305542*x_85 + 5.14039945602417) - 101.081339388441*std::sin(0.551439881324768*x_85 - 7.2323203086853) + 0.969987141716713*std::sin(0.622239828109741*x_87 - 7.19248008728027) + 290.119337125393*std::sin(0.399919867515564*x_92 - 1.20775985717773) + 2.68084034050169*std::sin(0.386559844017029*x_93 + 8.1825590133667) + 2.2969113433364*std::sin(0.371919840574265*x_95 - 4.22896003723145) - 3799.31891879171*std::sin(0.277999937534332*x_96 + 5.09999990463257) + 2.1474841095176*std::sin(0.373279839754105*x_96 - 7.40655994415283) - 1.13145900330214*std::sin(0.381279855966568*x_96 + 5.18871974945068) - 23.3352011001676*std::sin(0.400719821453094*x_96 - 7.40183973312378) + 63.2347599861803*std::sin(0.438079863786697*x_96 - 7.36663961410522) - 25.574632368317*std::sin(0.441119849681854*x_96 - 7.36895990371704) - 1.73221998693066*std::sin(0.441359847784042*x_96 - 7.37751960754395) - 0.14021403106435*std::sin(0.446559876203537*x_96 - 4.17528009414673) - 2.27745911470237*std::sin(0.45415985584259*x_99 - 1.14119982719421) - 159601.458736985 + 0.00033521002666287*std::exp(-3.74424004554749*x_74) - 1.73141661663197e-5*std::exp(-3.28631997108459*x_74) - 3.47937130994078*std::exp(-3.16623997688293*x_74) - 0.000775115637095334*std::exp(-2.93903994560242*x_74) + 0.00701974507547573*std::exp(-2.78071999549866*x_74) + 0.00110630836722955*std::exp(-4.0*x_45) - 0.00540428529505154*std::exp(-3.97359991073608*x_45) + 0.000239473108544244*std::exp(-3.93063998222351*x_45) - 0.0397855382687295*std::exp(-3.84967994689941*x_45) + 0.0064312649986537*std::exp(-4.89256000518799*x_111) + 7.87329034966863e-5*std::exp(-4.78735971450806*x_111) + 0.00126077644274178*std::exp(-4.68495988845825*x_111));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2186.31047976993*x_1 + 10.2090379366722*x_10 + 144.388261968832*x_100 + 68.6779425350197*x_101 + 29.9152216409635*x_102 + 70.36364068435*x_103 - 298.127433348775*x_104 - 121.418436406149*x_105 + 24.2813158845142*x_106 - 52.4179513465431*x_107 - 60.7188004570734*x_108 + 112.729907395694*x_109 + 0.965080047316065*x_11 - 11.6439359656755*x_110 - 60.9432641861961*x_111 + 158.824646406571*x_112 + 148.589657983513*x_113 + 69.92238945801*x_114 - 157.926496551264*x_115 + 599.480815662012*x_116 - 100.181998307519*x_117 - 24.2755487798047*x_118 - 79.209594800754*x_119 + 438.620374923031*x_12 - 61.5701379823079*x_120 + 75.1026240273993*x_13 - 42.0322971817836*x_14 - 43.1497261981628*x_15 - 44.9746422902557*x_16 - 28.990667156793*x_17 + 11.5594232288398*x_18 + 77.407793010867*x_19 - 44.3537249845436*x_2 + 156.778677939238*x_20 + 23.2205720899418*x_21 + 91.7275946187299*x_22 + 100.5967634031*x_23 - 81.1033038686464*x_24 + 244.453162182588*x_25 - 24.3473100601385*x_26 - 90.1223443065279*x_27 + 3.67249827765763*x_28 + 3.7026547501132*x_29 - 182.759331611265*x_3 + 1149.1429164261*x_30 + 5859.73665411715*x_31 + 151.433155495753*x_32 - 39.6697487542179*x_33 + 104.658713646739*x_34 + 144.429263674542*x_35 - 5.80158854150316*x_36 + 885.01239809817*x_37 - 155.449006662648*x_38 + 238.062629359712*x_39 - 116.915499805367*x_4 + 63.4842537454004*x_40 - 71.7010048529394*x_41 - 43372.5355743706*x_42 + 19.8026413581755*x_43 + 239.831182083017*x_44 - 18.7120449696042*x_45 + 10.8178237254594*x_46 + 47.2526737269366*x_47 - 782.51299265991*x_48 + 271.739250740445*x_49 + 1.4955416508467*x_5 - 1359.79989491234*x_50 + 62.3142863081214*x_51 + 93.3321204430984*x_52 - 35.748169938344*x_53 - 353.605331822604*x_54 + 52.2063891054708*x_55 + 72.906091283977*x_56 - 981.039969071731*x_57 - 31.9813131480444*x_58 - 106.119375557669*x_59 - 27.0524602784037*x_6 + 115.762859571135*x_60 + 14.2166321706596*x_61 + 221.478501067804*x_62 - 201.084733447725*x_63 - 57.0034579173273*x_64 - 36.5014801572206*x_65 - 26.2719117787065*x_66 - 16.3912847435871*x_67 + 320.596248284896*x_68 + 13.3152199520453*x_69 + 14.8602596007038*x_7 + 21.2967598089234*x_70 + 58.6033342218089*x_72 + 0.715731967196699*x_73 + 39.9430655731638*x_74 - 96.0568565137385*x_75 + 158.996151762793*x_76 - 7.64879345127269*x_77 + 37.40839684756*x_78 - 8.11647515101864*x_79 + 445.344580054537*x_8 + 0.800286517987024*x_80 + 93.4938020508384*x_81 - 25.9087993903313*x_82 - 42.0649941615551*x_83 - 1306.40283012371*x_84 + 39.7855943123519*x_85 + 38.3180996749623*x_86 + 17.3502449294644*x_87 - 60.4796858227092*x_88 + 137.656976331953*x_89 + 317.616862542609*x_9 - 12.5561246466612*x_90 + 506.355198207219*x_91 - 67.1922117985502*x_92 - 9.3459420657105*x_93 + 107.010178099567*x_94 - 62.5989586110705*x_95 + 17.4142668423358*x_96 + 189.265758990528*x_97 + 85.498920100598*x_98 + 44.0897610947582*x_99 - 6.14153481650156e-5*std::pow(-6.1384801864624*x_15 - 8.91168022155762, 2) + 0.00854337569284686*std::pow(-6.67000007629395*x_6 - 8.49240016937256, 2) - 4.98618216882702e-5*std::pow(-5.50063991546631*x_64 - 8.64447975158691, 2) - 0.00759640029550409*std::pow(-6.22312021255493*x_80 - 8.63335990905762, 2) - 0.00952853183875304*std::pow(-5.10504007339478*x_81 - 6.32679986953735, 2) - 2.30642530135686*std::exp(0.346639841794968*x_1) - 0.499645779081068*std::exp(0.7290398478508*x_19) - 0.000368514957933998*std::exp(2.51127982139587*x_71) + 1.01452844707268*std::exp(2.52927994728088*x_71) - 0.128396236306141*std::exp(2.55039978027344*x_71) - 0.0780079505485159*std::exp(2.5557599067688*x_71) + 0.109076477143988*std::exp(2.58471989631653*x_71) + 0.0577712392999175*std::exp(2.58607983589172*x_71) + 0.528648378195207*std::exp(2.60103988647461*x_71) - 0.108182827345915*std::exp(2.60951995849609*x_71) - 0.010454276083896*std::exp(2.61911988258362*x_71) + 0.0579398937076004*std::exp(2.61959981918335*x_71) - 3.12278603622142*std::exp(2.62344002723694*x_71) - 8.70843478758653*std::exp(2.63927984237671*x_71) - 0.214799222451687*std::exp(2.65535998344421*x_71) + 6.67675358080376*std::exp(2.66295981407166*x_71) - 0.121999669833301*std::exp(2.69736003875732*x_71) - 0.201946042103615*std::exp(1.32943987846375*x_76) + 0.0272633441794507*std::exp(2.37591981887817*x_81) + 1.21929405571654*std::sin(0.41567987203598*x_103 + 5.20480012893677) + 6.07749405465571*std::sin(0.364319831132889*x_105 + 5.16792011260986) - 1.10744577767373*std::sin(0.324479848146439*x_112 + 1.92879974842072) - 5.142451971875*std::sin(0.342559844255447*x_112 + 1.97303986549377) - 19.3340909751281*std::sin(0.462799847126007*x_113 + 8.24320030212402) + 392.044410734275*std::sin(0.271039962768555*x_115 - 7.52120018005371) - 24.6728330902769*std::sin(0.402399837970734*x_115 + 5.18944025039673) + 159.242546711243*std::sin(0.444559872150421*x_115 - 4.1701602935791) - 20.2570397452782*std::sin(0.364959836006165*x_119 + 5.17040014266968) - 4.73260167350423*std::sin(0.416319847106934*x_16 + 2.00135970115662) + 483.779896165474*std::sin(0.323679834604263*x_28 - 4.28424024581909) + 17.5458684351436*std::sin(0.325439840555191*x_28 - 4.28664016723633) + 2.00730334062756*std::sin(0.34079983830452*x_28 + 5.14592027664185) - 7.07006415101642*std::sin(0.370079845190048*x_28 + 5.16351985931396) + 2.08823079067186*std::sin(0.391679853200912*x_36 - 7.39351987838745) - 110.968965956312*std::sin(0.42399987578392*x_36 - 7.37871980667114) + 1.02288648818388*std::sin(0.341519832611084*x_43 - 4.24616003036499) - 2.91092580980262*std::sin(0.445039868354797*x_45 + 5.23095989227295) - 12.9353165673609*std::sin(0.461359858512878*x_45 - 4.14215993881226) + 421.402103682242*std::sin(0.258959949016571*x_48 + 5.06367969512939) + 17.3132326422348*std::sin(0.214479997754097*x_53 + 5.02799987792969) + 3.35264492156905*std::sin(0.241599977016449*x_53 + 5.06559991836548) - 4.77764290362492*std::sin(0.327359855175018*x_53 + 5.13840007781982) - 0.764445409952331*std::sin(0.457919865846634*x_53 - 7.34488010406494) - 162.025972156215*std::sin(0.594959855079651*x_53 - 1.00071978569031) - 168.803189458225*std::sin(0.529839813709259*x_55 + 5.14864015579224) + 22.7891755062825*std::sin(0.24695996940136*x_56 - 7.5360803604126) - 10.6648667079706*std::sin(0.386239856481552*x_59 + 2.000079870224) + 14.7850844105208*std::sin(0.19472000002861*x_64 - 4.39791965484619) - 1.85999185508996*std::sin(0.258799970149994*x_64 - 4.32423973083496) - 1.78919824274203*std::sin(0.36847984790802*x_67 + 1.96831977367401) - 0.610571844249696*std::sin(0.515679836273193*x_69 - 1.07575976848602) + 7.0190096079763*std::sin(0.191359996795654*x_72 - 7.60400009155273) + 10.5103984480663*std::sin(0.473599851131439*x_75 - 0.933439791202545) - 2.45689758864983*std::sin(0.237279981374741*x_78 - 7.56224012374878) + 58.9096580548602*std::sin(0.136480033397675*x_80 - 7.68383979797363) - 390.618985424333*std::sin(0.289759933948517*x_80 - 7.48191976547241) + 27.0981318055363*std::sin(0.309119939804077*x_80 - 4.26359987258911) + 422.223579023573*std::sin(0.357839852571487*x_80 + 5.14359998703003) - 0.542111020955316*std::sin(0.388959854841232*x_80 + 1.99631977081299) - 8.50128631211374*std::sin(0.487999856472015*x_80 - 7.32735967636108) - 0.0267079167161708*std::sin(0.517279863357544*x_80 + 2.1354398727417) - 3.36929334422165*std::sin(0.559519827365875*x_80 - 1.01055979728699) + 108.417481488747*std::sin(0.6211998462677*x_80 + 8.41695976257324) + 163.024310698863*std::sin(0.522799849510193*x_81 - 7.26743984222412) - 3.33581687580647*std::sin(0.669119834899902*x_82 + 5.44583988189697) + 296.934597328621*std::sin(0.295759916305542*x_85 + 5.14039945602417) - 163.025998937999*std::sin(0.551439881324768*x_85 - 7.2323203086853) + 1.25244190702253*std::sin(0.622239828109741*x_87 - 7.19248008728027) - 22.6133185482851*std::sin(0.399919867515564*x_92 - 1.20775985717773) + 4.21672713359829*std::sin(0.386559844017029*x_93 + 8.1825590133667) + 3.61284043610884*std::sin(0.371919840574265*x_95 - 4.22896003723145) + 382.433493284678*std::sin(0.277999937534332*x_96 + 5.09999990463257) + 3.377804480471*std::sin(0.373279839754105*x_96 - 7.40655994415283) - 1.07838193921006*std::sin(0.381279855966568*x_96 + 5.18871974945068) - 98.1733251532102*std::sin(0.400719821453094*x_96 - 7.40183973312378) + 16.151342801725*std::sin(0.438079863786697*x_96 - 7.36663961410522) - 190.418495117605*std::sin(0.441119849681854*x_96 - 7.36895990371704) + 1.44035442385608*std::sin(0.441359847784042*x_96 - 7.37751960754395) - 2.44155834300918*std::sin(0.446559876203537*x_96 - 4.17528009414673) + 1.89372500938832*std::sin(0.45415985584259*x_99 - 1.14119982719421) - 225178.134816691 + 0.00010065095413713*std::exp(-3.74424004554749*x_74) + 0.00402472193463054*std::exp(-3.28631997108459*x_74) + 0.350228067960748*std::exp(-3.16623997688293*x_74) - 0.0134971517199905*std::exp(-2.93903994560242*x_74) - 0.00583697275755318*std::exp(-2.78071999549866*x_74) + 0.000332182762669966*std::exp(-4.0*x_45) - 0.0402381492038486*std::exp(-3.97359991073608*x_45) + 0.000309206322276549*std::exp(-3.93063998222351*x_45) + 0.00310107922967201*std::exp(-3.84967994689941*x_45) + 0.0103724723790156*std::exp(-4.89256000518799*x_111) - 6.54670230744921e-5*std::exp(-4.78735971450806*x_111) + 0.00938723769120654*std::exp(-4.68495988845825*x_111));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (8246.0106953272*x_1 + 275.509011391937*x_10 + 673.440391585675*x_100 + 353.868740623801*x_101 + 219.297067586178*x_102 + 81.651137638478*x_103 - 79.2573240390739*x_104 - 160.49086955931*x_105 - 305.948487688061*x_106 + 82.0107607047405*x_107 + 120.822515398096*x_108 - 52.4001625738996*x_109 - 87.4016203137715*x_11 - 123.225031782345*x_110 - 297.787544068015*x_111 + 182.649561309981*x_112 + 860.412696485036*x_113 + 247.542434969103*x_114 - 389.568746579259*x_115 - 1077.55425396457*x_116 - 286.937260373056*x_117 - 66.2545483146145*x_118 - 325.860621648274*x_119 + 1252.67991791428*x_12 + 508.291206267133*x_120 + 328.865561023276*x_13 + 42.7476337624396*x_14 + 248.515439786567*x_15 - 381.954325407366*x_16 + 12.2833963255127*x_17 + 98.2958237856078*x_18 + 79.0223885864457*x_19 - 69.1623160004892*x_2 + 23.6758624489367*x_20 + 699.133141250527*x_21 + 579.820296119233*x_22 + 285.080871078284*x_23 - 83.8605828539818*x_24 + 242.68011591484*x_25 + 103.445943210824*x_26 - 112.35937480471*x_27 + 44.1750008529083*x_28 + 83.4961817131842*x_29 - 975.718897297354*x_3 - 509.002880176887*x_30 + 16790.1094340664*x_31 + 25.8542426818136*x_32 + 257.32841714905*x_33 + 208.478274302427*x_34 - 24.5912637521093*x_35 - 33.7192782652269*x_36 + 14.2056131253699*x_37 - 145.358122546382*x_38 + 441.314691883511*x_39 - 319.228285292477*x_4 + 260.202839386174*x_40 + 195.552868485951*x_41 - 133768.27483064*x_42 + 829.088937960739*x_43 + 733.20048822088*x_44 + 180.096964272806*x_45 + 134.238443663398*x_46 + 283.057214652262*x_47 - 1279.93508998325*x_48 - 1109.01820334595*x_49 + 155.044175806963*x_5 + 37.7491270080064*x_50 + 333.906129207994*x_51 - 495.020329351232*x_52 + 104.713445532664*x_53 - 435.763080189511*x_54 + 150.2350022019*x_55 + 279.404096698403*x_56 - 2589.45806647838*x_57 - 400.51909686696*x_58 - 300.826196519522*x_59 - 269.71631053627*x_6 + 117.935517005444*x_60 + 91.9590023298898*x_61 - 312.975089619998*x_62 - 474.257538882751*x_63 - 123.593776765288*x_64 - 36.9337133678821*x_65 - 145.3399233907*x_66 - 1.42945065829997*x_67 + 335.384789677409*x_68 - 248.448300680876*x_69 + 87.0084127617549*x_7 - 256.633343375658*x_70 + 280.291596083196*x_72 - 151.861960985165*x_73 - 14.91367023462*x_74 - 195.937657454103*x_75 + 451.29449338076*x_76 - 16.0248322131042*x_77 - 366.02236715245*x_78 - 72.8939161943641*x_79 + 1720.76193200396*x_8 - 10.4409596345836*x_80 - 219.858402857147*x_81 - 72.828430561167*x_82 - 142.418679032609*x_83 - 2253.54528204842*x_84 - 95.7345080834005*x_85 + 56.4684406577416*x_86 + 302.786620903153*x_87 + 294.594108276071*x_88 + 579.18283685625*x_89 - 407.175263235144*x_9 + 242.634155187547*x_90 + 1084.74930977284*x_91 - 129.24829032922*x_92 - 1.75739681378317*x_93 + 244.255538960616*x_94 - 11.6520358253497*x_95 + 18.3771675946254*x_96 + 606.589689131592*x_97 + 434.056059922474*x_98 - 202.818100910203*x_99 + 0.000125192428584019*std::pow(-6.1384801864624*x_15 - 8.91168022155762, 2) - 0.0429784518469359*std::pow(-6.67000007629395*x_6 - 8.49240016937256, 2) + 0.000101641083821678*std::pow(-5.50063991546631*x_64 - 8.64447975158691, 2) + 0.00416089730463903*std::pow(-6.22312021255493*x_80 - 8.63335990905762, 2) + 0.00521921448353634*std::pow(-5.10504007339478*x_81 - 6.32679986953735, 2) + 11.6027425594682*std::exp(0.346639841794968*x_1) - 0.23215136459944*std::exp(0.7290398478508*x_19) + 0.00075120118881904*std::exp(2.51127982139587*x_71) - 1.91093958427237*std::exp(2.52927994728088*x_71) + 0.645912301858804*std::exp(2.55039978027344*x_71) + 0.0468160173259353*std::exp(2.5557599067688*x_71) - 0.0597461958418061*std::exp(2.58471989631653*x_71) + 0.123611870931336*std::exp(2.58607983589172*x_71) + 0.95983776127151*std::exp(2.60103988647461*x_71) - 0.0209724026173075*std::exp(2.60951995849609*x_71) - 0.00737373507725306*std::exp(2.61911988258362*x_71) + 0.0269207225440877*std::exp(2.61959981918335*x_71) - 13.5401710279353*std::exp(2.62344002723694*x_71) + 2.83986847678685*std::exp(2.63927984237671*x_71) + 1.04349806733181*std::exp(2.65535998344421*x_71) + 3.08818057329751*std::exp(2.66295981407166*x_71) + 1.32839709560571*std::exp(2.69736003875732*x_71) + 0.110615121581833*std::exp(1.32943987846375*x_76) - 0.132445763236678*std::exp(2.37591981887817*x_81) - 0.731752228285163*std::sin(0.41567987203598*x_103 + 5.20480012893677) - 3.32892260113559*std::sin(0.364319831132889*x_105 + 5.16792011260986) - 0.781116904839323*std::sin(0.324479848146439*x_112 + 1.92879974842072) + 3.08621260935909*std::sin(0.342559844255447*x_112 + 1.97303986549377) - 35.1038447543182*std::sin(0.462799847126007*x_113 + 8.24320030212402) + 181.331229084197*std::sin(0.271039962768555*x_115 - 7.52120018005371) - 44.7971049461015*std::sin(0.402399837970734*x_115 + 5.18944025039673) - 51.92987024639*std::sin(0.444559872150421*x_115 - 4.1701602935791) - 36.7795920333198*std::sin(0.364959836006165*x_119 + 5.17040014266968) + 2.84024333911615*std::sin(0.416319847106934*x_16 + 2.00135970115662) + 2097.63411837315*std::sin(0.323679834604263*x_28 - 4.28424024581909) - 191.048719238111*std::sin(0.325439840555191*x_28 - 4.28664016723633) + 4.29498353278442*std::sin(0.34079983830452*x_28 + 5.14592027664185) - 1.37060784546882*std::sin(0.370079845190048*x_28 + 5.16351985931396) + 0.970258627111074*std::sin(0.391679853200912*x_36 - 7.39351987838745) + 36.1875900787794*std::sin(0.42399987578392*x_36 - 7.37871980667114) + 0.721474535151059*std::sin(0.341519832611084*x_43 - 4.24616003036499) + 1.59444774957165*std::sin(0.445039868354797*x_45 + 5.23095989227295) + 140.846585751434*std::sin(0.461359858512878*x_45 - 4.14215993881226) - 793.742120435931*std::sin(0.258959949016571*x_48 + 5.06367969512939) - 9.48325262404868*std::sin(0.214479997754097*x_53 + 5.02799987792969) + 1.55774575938798*std::sin(0.241599977016449*x_53 + 5.06559991836548) + 2.86727457112372*std::sin(0.327359855175018*x_53 + 5.13840007781982) - 0.539187781992259*std::sin(0.457919865846634*x_53 - 7.34488010406494) - 702.532721907906*std::sin(0.594959855079651*x_53 - 1.00071978569031) + 317.953328581274*std::sin(0.529839813709259*x_55 + 5.14864015579224) + 4.41792635448522*std::sin(0.24695996940136*x_56 - 7.5360803604126) + 53.6508608238167*std::sin(0.386239856481552*x_59 + 2.000079870224) - 8.0984697329611*std::sin(0.19472000002861*x_64 - 4.39791965484619) - 1.31191170724952*std::sin(0.258799970149994*x_64 - 4.32423973083496) - 3.82830877323272*std::sin(0.36847984790802*x_67 + 1.96831977367401) - 0.430655837764067*std::sin(0.515679836273193*x_69 - 1.07575976848602) + 15.0184230118846*std::sin(0.191359996795654*x_72 - 7.60400009155273) + 19.0831519258692*std::sin(0.473599851131439*x_75 - 0.933439791202545) - 1.73292840032729*std::sin(0.237279981374741*x_78 - 7.56224012374878) + 11.4202697145639*std::sin(0.136480033397675*x_80 - 7.68383979797363) + 735.759833811925*std::sin(0.289759933948517*x_80 - 7.48191976547241) + 49.200586324814*std::sin(0.309119939804077*x_80 - 4.26359987258911) + 195.289917255233*std::sin(0.357839852571487*x_80 + 5.14359998703003) - 1.15994322373623*std::sin(0.388959854841232*x_80 + 1.99631977081299) + 92.5665131828239*std::sin(0.487999856472015*x_80 - 7.32735967636108) + 0.0544428885615567*std::sin(0.517279863357544*x_80 + 2.1354398727417) + 16.9496247102975*std::sin(0.559519827365875*x_80 - 1.01055979728699) - 35.355536961866*std::sin(0.6211998462677*x_80 + 8.41695976257324) - 53.1631242807887*std::sin(0.522799849510193*x_81 - 7.26743984222412) + 16.7812174158609*std::sin(0.669119834899902*x_82 + 5.44583988189697) - 559.298339649795*std::sin(0.295759916305542*x_85 + 5.14039945602417) - 75.4039694246349*std::sin(0.551439881324768*x_85 - 7.2323203086853) + 0.242799310882098*std::sin(0.622239828109741*x_87 - 7.19248008728027) + 109.855864149609*std::sin(0.399919867515564*x_92 - 1.20775985717773) - 2.5306442376345*std::sin(0.386559844017029*x_93 + 8.1825590133667) - 2.16822515222365*std::sin(0.371919840574265*x_95 - 4.22896003723145) + 1658.20355471774*std::sin(0.277999937534332*x_96 + 5.09999990463257) - 2.02716969192778*std::sin(0.373279839754105*x_96 - 7.40655994415283) - 0.760617250588815*std::sin(0.381279855966568*x_96 + 5.18871974945068) + 32.0148612425006*std::sin(0.400719821453094*x_96 - 7.40183973312378) + 29.3251040876398*std::sin(0.438079863786697*x_96 - 7.36663961410522) + 358.667360139323*std::sin(0.441119849681854*x_96 - 7.36895990371704) + 3.08189520070293*std::sin(0.441359847784042*x_96 - 7.37751960754395) + 26.5849818777129*std::sin(0.446559876203537*x_96 - 4.17528009414673) + 4.05196243453767*std::sin(0.45415985584259*x_99 - 1.14119982719421) + 184435.647147109 + 4.6765643440729e-5*std::exp(-3.74424004554749*x_74) - 0.00220452503794951*std::exp(-3.28631997108459*x_74) + 1.51856319452161*std::exp(-3.16623997688293*x_74) + 0.146964144806979*std::exp(-2.93903994560242*x_74) - 0.0124892443347224*std::exp(-2.78071999549866*x_74) + 0.000154342706130882*std::exp(-4.0*x_45) + 0.0757915387521738*std::exp(-3.97359991073608*x_45) + 5.99429654566671e-5*std::exp(-3.93063998222351*x_45) - 0.0150650926286914*std::exp(-3.84967994689941*x_45) + 0.00479755128151439*std::exp(-4.89256000518799*x_111) - 0.000140078372986443*std::exp(-4.78735971450806*x_111) - 0.0176815585042092*std::exp(-4.68495988845825*x_111));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-2403.87385008143*x_1 - 86.9417550181851*x_10 - 83.5539412655614*x_100 + 393.454475873283*x_101 - 189.161043806366*x_102 + 37.8244522395319*x_103 + 98.2664626939149*x_104 + 53.9435028527253*x_105 + 52.3458330805763*x_106 - 103.721112000969*x_107 + 99.9197074869032*x_108 - 132.763391544312*x_109 - 45.9046912546831*x_11 + 125.39273459598*x_110 + 8.49676182993278*x_111 - 18.589513308347*x_112 + 251.518282231479*x_113 + 68.7915996501798*x_114 + 44.1480659612542*x_115 + 100.455304414702*x_116 + 124.484255004969*x_117 + 128.179409001823*x_118 + 54.6227360162866*x_119 - 574.041810281629*x_12 - 166.129437487448*x_120 - 50.4328264166523*x_13 + 64.3959647317574*x_14 + 37.6282638445121*x_15 + 71.581013571932*x_16 + 146.9735798873*x_17 - 62.7818337535058*x_18 + 34.4304668030428*x_19 + 24.1729271186813*x_2 + 428.307220238982*x_20 - 428.94494318074*x_21 + 283.396875202601*x_22 - 79.8471535518581*x_23 - 151.724714477096*x_24 + 240.390912094222*x_25 + 44.62456521139*x_26 - 49.9000174156461*x_27 - 103.900181050542*x_28 + 158.702427129849*x_29 + 216.098764645093*x_3 + 619.170674488502*x_30 + 16681.0021704566*x_31 + 118.167992667691*x_32 + 84.7602082315674*x_33 + 8.49588032197289*x_34 + 130.758893912298*x_35 + 79.0526726546145*x_36 + 450.567727077474*x_37 + 188.388803325369*x_38 - 60.6288521948872*x_39 - 96.4705328652444*x_4 - 11.6931709610848*x_40 - 268.487085838795*x_41 - 22283.1731438269*x_42 - 121.535073477329*x_43 + 428.939166439243*x_44 - 47.2075248549297*x_45 + 100.436239486678*x_46 - 195.944295415282*x_47 - 243.79224441558*x_48 + 315.902070538886*x_49 - 36.7556397716169*x_5 - 474.34933238233*x_50 + 261.044005607548*x_51 - 13.7735710419568*x_52 - 17.2630662372365*x_53 - 268.993555705488*x_54 - 56.6235385797902*x_55 + 120.80151244609*x_56 - 990.492579776297*x_57 - 121.829691889906*x_58 + 9.59377391790823*x_59 + 126.191308933614*x_6 + 215.66534241265*x_60 + 28.1864010187048*x_61 + 184.233612665874*x_62 + 58.9726242550467*x_63 - 71.4679480886139*x_64 - 27.8061811518625*x_65 + 0.798381041897402*x_66 + 38.8564072456646*x_67 - 43.2752592491688*x_68 + 144.835019104298*x_69 + 35.7192940183916*x_7 + 112.581390135329*x_70 + 115.503404714614*x_72 - 58.548940356342*x_73 + 33.0705136985806*x_74 - 76.3159062059393*x_75 + 158.366596214677*x_76 - 62.4559995227433*x_77 + 45.9319402735355*x_78 + 61.2940767485988*x_79 + 158.11598107476*x_8 - 59.0094172735216*x_80 + 49.8204535659402*x_81 - 83.2067569115119*x_82 + 73.2379871338521*x_83 - 59.8084503927262*x_84 + 152.686129232333*x_85 - 60.4745666895998*x_86 + 48.8146598690951*x_87 - 215.845791743924*x_88 - 288.338697317369*x_89 - 189.98166262879*x_9 + 23.0919436406572*x_90 + 399.780621783004*x_91 - 7.21266493354585*x_92 - 26.3332326108811*x_93 + 35.3338026494023*x_94 + 38.1989917040051*x_95 + 94.5302609164805*x_96 - 102.535099001144*x_97 + 48.3492785449308*x_98 + 195.623251267268*x_99 + 0.000635784093767851*std::pow(-6.1384801864624*x_15 - 8.91168022155762, 2) + 0.00382183766903644*std::pow(-6.67000007629395*x_6 - 8.49240016937256, 2) + 0.000516179653179095*std::pow(-5.50063991546631*x_64 - 8.64447975158691, 2) + 4.28830442821494e-5*std::pow(-6.22312021255493*x_80 - 8.63335990905762, 2) + 5.37902739310556e-5*std::pow(-5.10504007339478*x_81 - 6.32679986953735, 2) - 1.03176816921732*std::exp(0.346639841794968*x_1) - 1.10701655119403*std::exp(0.7290398478508*x_19) + 0.0038149413065353*std::exp(2.51127982139587*x_71) - 0.01313714592747*std::exp(2.52927994728088*x_71) - 0.0574374334126697*std::exp(2.55039978027344*x_71) - 0.0106311516683043*std::exp(2.5557599067688*x_71) - 0.000615756307928492*std::exp(2.58471989631653*x_71) + 0.070492668015744*std::exp(2.58607983589172*x_71) + 0.122613040745555*std::exp(2.60103988647461*x_71) - 0.0306265507039222*std::exp(2.60951995849609*x_71) + 0.0185141990490218*std::exp(2.61911988258362*x_71) + 0.128371786561874*std::exp(2.61959981918335*x_71) - 0.19807054754155*std::exp(2.62344002723694*x_71) - 10.079874762342*std::exp(2.63927984237671*x_71) + 8.70332986178194*std::exp(2.65535998344421*x_71) + 2.31911830734997*std::exp(2.66295981407166*x_71) + 0.388566550049422*std::exp(2.69736003875732*x_71) + 0.00114002168517365*std::exp(1.32943987846375*x_76) - 1.10466823306319*std::exp(2.37591981887817*x_81) + 0.166168960259025*std::sin(0.41567987203598*x_103 + 5.20480012893677) - 0.0343085456969071*std::sin(0.364319831132889*x_105 + 5.16792011260986) + 1.96125216125047*std::sin(0.324479848146439*x_112 + 1.92879974842072) - 0.7008283960232*std::sin(0.342559844255447*x_112 + 1.97303986549377) - 4.48428820041946*std::sin(0.462799847126007*x_113 + 8.24320030212402) + 136.173569868163*std::sin(0.271039962768555*x_115 - 7.52120018005371) - 5.72253924117654*std::sin(0.402399837970734*x_115 + 5.18944025039673) + 184.320715127106*std::sin(0.444559872150421*x_115 - 4.1701602935791) - 4.69835403288607*std::sin(0.364959836006165*x_119 + 5.17040014266968) - 0.64497279857907*std::sin(0.416319847106934*x_16 + 2.00135970115662) + 30.6849549766258*std::sin(0.323679834604263*x_28 - 4.28424024581909) - 55.8832460348497*std::sin(0.325439840555191*x_28 - 4.28664016723633) + 2.44931854868405*std::sin(0.34079983830452*x_28 + 5.14592027664185) - 2.00153465677808*std::sin(0.370079845190048*x_28 + 5.16351985931396) + 4.62668983662456*std::sin(0.391679853200912*x_36 - 7.39351987838745) - 128.444813175917*std::sin(0.42399987578392*x_36 - 7.37871980667114) - 1.81150027938937*std::sin(0.341519832611084*x_43 - 4.24616003036499) + 0.0164326991137759*std::sin(0.445039868354797*x_45 + 5.23095989227295) + 41.1987289739746*std::sin(0.461359858512878*x_45 - 4.14215993881226) - 5.45674292937773*std::sin(0.258959949016571*x_48 + 5.06367969512939) - 0.09773630840696*std::sin(0.214479997754097*x_53 + 5.02799987792969) + 7.42812923443382*std::sin(0.241599977016449*x_53 + 5.06559991836548) - 0.651111149162225*std::sin(0.327359855175018*x_53 + 5.13840007781982) + 1.35380913689186*std::sin(0.457919865846634*x_53 - 7.34488010406494) - 10.2769042286886*std::sin(0.594959855079651*x_53 - 1.00071978569031) + 2.18583533988987*std::sin(0.529839813709259*x_55 + 5.14864015579224) + 6.45161396006074*std::sin(0.24695996940136*x_56 - 7.5360803604126) - 4.7708763824938*std::sin(0.386239856481552*x_59 + 2.000079870224) - 0.0834644574834912*std::sin(0.19472000002861*x_64 - 4.39791965484619) + 3.29398794888736*std::sin(0.258799970149994*x_64 - 4.32423973083496) - 2.18318594630091*std::sin(0.36847984790802*x_67 + 1.96831977367401) + 1.08130381936063*std::sin(0.515679836273193*x_69 - 1.07575976848602) + 8.56462004433922*std::sin(0.191359996795654*x_72 - 7.60400009155273) + 2.43774873114035*std::sin(0.473599851131439*x_75 - 0.933439791202545) + 4.35108950962128*std::sin(0.237279981374741*x_78 - 7.56224012374878) + 16.6773199927468*std::sin(0.136480033397675*x_80 - 7.68383979797363) + 5.05813181322463*std::sin(0.289759933948517*x_80 - 7.48191976547241) + 6.28505539077575*std::sin(0.309119939804077*x_80 - 4.26359987258911) + 146.656068710344*std::sin(0.357839852571487*x_80 + 5.14359998703003) - 0.661485761617264*std::sin(0.388959854841232*x_80 + 1.99631977081299) + 27.0764297788184*std::sin(0.487999856472015*x_80 - 7.32735967636108) + 0.276485750438041*std::sin(0.517279863357544*x_80 + 2.1354398727417) - 1.50723703181654*std::sin(0.559519827365875*x_80 - 1.01055979728699) + 125.491510485085*std::sin(0.6211998462677*x_80 + 8.41695976257324) + 188.698046795281*std::sin(0.522799849510193*x_81 - 7.26743984222412) - 1.49226149607806*std::sin(0.669119834899902*x_82 + 5.44583988189697) - 3.8450110958211*std::sin(0.295759916305542*x_85 + 5.14039945602417) - 56.6258098543777*std::sin(0.551439881324768*x_85 - 7.2323203086853) + 0.35456621452953*std::sin(0.622239828109741*x_87 - 7.19248008728027) + 916.256438682148*std::sin(0.399919867515564*x_92 - 1.20775985717773) + 0.574667907385374*std::sin(0.386559844017029*x_93 + 8.1825590133667) + 0.492368461927069*std::sin(0.371919840574265*x_95 - 4.22896003723145) + 24.2568048321301*std::sin(0.277999937534332*x_96 + 5.09999990463257) + 0.460337074429756*std::sin(0.373279839754105*x_96 - 7.40655994415283) + 1.90978100379042*std::sin(0.381279855966568*x_96 + 5.18871974945068) - 113.634062456049*std::sin(0.400719821453094*x_96 - 7.40183973312378) + 3.74609160781739*std::sin(0.438079863786697*x_96 - 7.36663961410522) + 2.46573229648433*std::sin(0.441119849681854*x_96 - 7.36895990371704) + 1.7575254998215*std::sin(0.441359847784042*x_96 - 7.37751960754395) + 7.77631532432638*std::sin(0.446559876203537*x_96 - 4.17528009414673) + 2.31072987212364*std::sin(0.45415985584259*x_99 - 1.14119982719421) - 75579.9064943663 + 0.000223002528567735*std::exp(-3.74424004554749*x_74) - 2.27202783202786e-5*std::exp(-3.28631997108459*x_74) + 0.0222140948437641*std::exp(-3.16623997688293*x_74) + 0.0429881628900832*std::exp(-2.93903994560242*x_74) - 0.00712229455004484*std::exp(-2.78071999549866*x_74) + 0.000735985035184988*std::exp(-4.0*x_45) + 0.000521044470923936*std::exp(-3.97359991073608*x_45) + 8.75362877778742e-5*std::exp(-3.93063998222351*x_45) - 0.125650899269091*std::exp(-3.84967994689941*x_45) + 0.00360279742176153*std::exp(-4.89256000518799*x_111) - 7.98830902624555e-5*std::exp(-4.78735971450806*x_111) - 0.000121555498774882*std::exp(-4.68495988845825*x_111));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (6336.36154796114*x_1 + 179.240322632713*x_10 + 422.391149607151*x_100 + 617.774008732727*x_101 + 189.012559400836*x_102 + 57.8514208085873*x_103 - 251.946882837699*x_104 - 173.196674315874*x_105 - 194.528578117465*x_106 + 125.312228976355*x_107 + 66.9254589474158*x_108 - 94.5172245450127*x_109 - 240.971743583892*x_11 - 155.418572040952*x_110 - 304.159435849266*x_111 + 216.855162298034*x_112 + 932.998108447295*x_113 + 135.325667706315*x_114 - 494.476760176318*x_115 - 841.21136632969*x_116 - 255.057360340817*x_117 - 62.6697002074162*x_118 - 365.567783203453*x_119 - 398.193254885367*x_12 + 370.581548089073*x_120 + 477.595163784367*x_13 + 44.0226515088946*x_14 + 304.184086968674*x_15 - 452.653968726654*x_16 + 91.8085215299377*x_17 + 1.44175763690971*x_18 + 151.287117371873*x_19 + 26.9714432061993*x_2 + 939.314271273675*x_20 + 244.930296369793*x_21 + 849.174822807825*x_22 + 118.484386279181*x_23 - 243.405518050784*x_24 + 636.213428123396*x_25 + 96.8163400381077*x_26 - 28.4100531221711*x_27 - 163.195293202771*x_28 + 181.899422073043*x_29 - 404.808717238473*x_3 - 67.5022012249197*x_30 + 33014.1058921008*x_31 - 4.48859830875285*x_32 + 179.005284215032*x_33 + 324.753684619218*x_34 + 16.1196751200652*x_35 + 108.816896533605*x_36 + 2727.33865945392*x_37 - 140.868170738186*x_38 + 344.669231168165*x_39 - 317.058799056881*x_4 + 290.793534975014*x_40 + 88.5739509350122*x_41 + 2632.67163404582*x_42 + 581.730822569496*x_43 + 845.571966447535*x_44 + 177.360470573063*x_45 + 218.233192120089*x_46 + 317.656858801314*x_47 - 1378.30649415115*x_48 - 659.830719505893*x_49 + 138.089851712103*x_5 - 880.21836920724*x_50 + 578.849149575449*x_51 + 212.179496519645*x_52 - 48.8071068068147*x_53 - 713.651497347697*x_54 + 97.6771129493534*x_55 + 175.703213011141*x_56 - 762.615169853574*x_57 - 427.266690373738*x_58 - 262.367796517594*x_59 - 149.61343643174*x_6 + 50.1313887215515*x_60 + 197.602188905848*x_61 - 266.272074717305*x_62 - 344.881609596406*x_63 - 188.030811478849*x_64 - 50.8303925171764*x_65 - 337.596662133243*x_66 - 72.7538977955233*x_67 + 358.399764783524*x_68 - 65.6085056355614*x_69 + 41.977602194119*x_7 + 183.338326169135*x_70 + 520.818613428674*x_72 - 188.704332866572*x_73 + 101.438701354229*x_74 - 344.593696431883*x_75 + 855.442327067144*x_76 - 81.5879854486112*x_77 - 189.022255520773*x_78 - 70.6130012637872*x_79 + 1319.38946282865*x_8 - 66.8483252197479*x_80 - 214.786962381957*x_81 - 152.318040420993*x_82 + 16.862040978753*x_83 - 1920.58269405529*x_84 - 66.6098957241511*x_85 + 47.2778830472717*x_86 + 332.404867639864*x_87 + 409.163639715849*x_88 + 480.730175082758*x_89 - 495.827707107446*x_9 - 520.317676093978*x_90 + 1057.28075529455*x_91 - 105.60015771886*x_92 + 45.5900076325547*x_93 + 260.353961383209*x_94 + 73.8322704605074*x_95 + 100.527405061327*x_96 + 605.058342435087*x_97 + 463.333280822634*x_98 - 104.609022419651*x_99 - 6.22675549415336e-5*std::pow(-6.1384801864624*x_15 - 8.91168022155762, 2) + 0.0376168605541348*std::pow(-6.67000007629395*x_6 - 8.49240016937256, 2) - 5.05537103382882e-5*std::pow(-5.50063991546631*x_64 - 8.64447975158691, 2) - 0.00312359562468355*std::pow(-6.22312021255493*x_80 - 8.63335990905762, 2) - 0.00391807687896624*std::pow(-5.10504007339478*x_81 - 6.32679986953735, 2) - 10.1552924814382*std::exp(0.346639841794968*x_1) + 1.063414495925*std::exp(0.7290398478508*x_19) - 0.000373628515925329*std::exp(2.51127982139587*x_71) + 0.5926900947427*std::exp(2.52927994728088*x_71) - 0.565334299982588*std::exp(2.55039978027344*x_71) + 0.0889998174282414*std::exp(2.5557599067688*x_71) + 0.0448516130679035*std::exp(2.58471989631653*x_71) - 0.113639355475666*std::exp(2.58607983589172*x_71) - 1.50062198498359*std::exp(2.60103988647461*x_71) + 0.0547631170405172*std::exp(2.60951995849609*x_71) - 0.0125413310522567*std::exp(2.61911988258362*x_71) - 0.123315607657758*std::exp(2.61959981918335*x_71) - 15.0103936240109*std::exp(2.62344002723694*x_71) + 1.41254822288938*std::exp(2.63927984237671*x_71) + 9.25860609665242*std::exp(2.65535998344421*x_71) + 1.62068310545372*std::exp(2.66295981407166*x_71) + 0.139342550539762*std::exp(2.69736003875732*x_71) - 0.0830390380968141*std::exp(1.32943987846375*x_76) - 1.17514654733804*std::exp(2.37591981887817*x_81) - 1.39110113247522*std::sin(0.41567987203598*x_103 + 5.20480012893677) + 2.49903021163831*std::sin(0.364319831132889*x_105 + 5.16792011260986) - 1.32853236405578*std::sin(0.324479848146439*x_112 + 1.92879974842072) + 5.86705949088778*std::sin(0.342559844255447*x_112 + 1.97303986549377) + 54.881776193091*std::sin(0.462799847126007*x_113 + 8.24320030212402) + 95.1629778417115*std::sin(0.271039962768555*x_115 - 7.52120018005371) + 70.0363366166017*std::sin(0.402399837970734*x_115 + 5.18944025039673) - 25.8298743519311*std::sin(0.444559872150421*x_115 - 4.1701602935791) + 57.5016597917682*std::sin(0.364959836006165*x_119 + 5.17040014266968) + 5.39945841341526*std::sin(0.416319847106934*x_16 + 2.00135970115662) + 2325.40000646781*std::sin(0.323679834604263*x_28 - 4.28424024581909) - 20.0401038996964*std::sin(0.325439840555191*x_28 - 4.28664016723633) - 3.94848129687592*std::sin(0.34079983830452*x_28 + 5.14592027664185) + 3.57892985499513*std::sin(0.370079845190048*x_28 + 5.16351985931396) - 4.44445842757148*std::sin(0.391679853200912*x_36 - 7.39351987838745) + 17.9996772647249*std::sin(0.42399987578392*x_36 - 7.37871980667114) + 1.22709195493272*std::sin(0.341519832611084*x_43 - 4.24616003036499) - 1.19695576451642*std::sin(0.445039868354797*x_45 + 5.23095989227295) + 14.7741383644574*std::sin(0.461359858512878*x_45 - 4.14215993881226) + 246.184178942305*std::sin(0.258959949016571*x_48 + 5.06367969512939) + 7.11910057746956*std::sin(0.214479997754097*x_53 + 5.02799987792969) - 7.13555754607384*std::sin(0.241599977016449*x_53 + 5.06559991836548) + 5.45084626849026*std::sin(0.327359855175018*x_53 + 5.13840007781982) - 0.917056607330139*std::sin(0.457919865846634*x_53 - 7.34488010406494) - 778.815324254694*std::sin(0.594959855079651*x_53 - 1.00071978569031) - 98.6152518852905*std::sin(0.529839813709259*x_55 + 5.14864015579224) - 11.5360849418082*std::sin(0.24695996940136*x_56 - 7.5360803604126) - 46.9578792043597*std::sin(0.386239856481552*x_59 + 2.000079870224) + 6.0795407270221*std::sin(0.19472000002861*x_64 - 4.39791965484619) - 2.23131409788549*std::sin(0.258799970149994*x_64 - 4.32423973083496) + 3.51945600591762*std::sin(0.36847984790802*x_67 + 1.96831977367401) - 0.73246426328055*std::sin(0.515679836273193*x_69 - 1.07575976848602) - 13.8067962119877*std::sin(0.191359996795654*x_72 - 7.60400009155273) - 29.8348309247657*std::sin(0.473599851131439*x_75 - 0.933439791202545) - 2.94738399612512*std::sin(0.237279981374741*x_78 - 7.56224012374878) - 29.820597021002*std::sin(0.136480033397675*x_80 - 7.68383979797363) - 228.200603095419*std::sin(0.289759933948517*x_80 - 7.48191976547241) - 76.9207927549059*std::sin(0.309119939804077*x_80 - 4.26359987258911) + 102.488524245541*std::sin(0.357839852571487*x_80 + 5.14359998703003) + 1.06636360521533*std::sin(0.388959854841232*x_80 + 1.99631977081299) + 9.70978789710911*std::sin(0.487999856472015*x_80 - 7.32735967636108) - 0.0270785189889291*std::sin(0.517279863357544*x_80 + 2.1354398727417) - 14.8351474232461*std::sin(0.559519827365875*x_80 - 1.01055979728699) - 17.5858147350857*std::sin(0.6211998462677*x_80 + 8.41695976257324) - 26.4432938848779*std::sin(0.522799849510193*x_81 - 7.26743984222412) - 14.6877490540894*std::sin(0.669119834899902*x_82 + 5.44583988189697) + 173.469945698306*std::sin(0.295759916305542*x_85 + 5.14039945602417) - 39.5721482051047*std::sin(0.551439881324768*x_85 - 7.2323203086853) - 0.633997321233015*std::sin(0.622239828109741*x_87 - 7.19248008728027) + 974.713998435385*std::sin(0.399919867515564*x_92 - 1.20775985717773) - 4.81089353580126*std::sin(0.386559844017029*x_93 + 8.1825590133667) - 4.12191497084744*std::sin(0.371919840574265*x_95 - 4.22896003723145) + 1838.25507179305*std::sin(0.277999937534332*x_96 + 5.09999990463257) - 3.8537608020255*std::sin(0.373279839754105*x_96 - 7.40655994415283) - 1.29366632293565*std::sin(0.381279855966568*x_96 + 5.18871974945068) + 15.9241654054736*std::sin(0.400719821453094*x_96 - 7.40183973312378) - 45.8472230218877*std::sin(0.438079863786697*x_96 - 7.36663961410522) - 111.242968334362*std::sin(0.441119849681854*x_96 - 7.36895990371704) - 2.83326011986318*std::sin(0.441359847784042*x_96 - 7.37751960754395) + 2.7886384223121*std::sin(0.446559876203537*x_96 - 4.17528009414673) - 3.72506617692284*std::sin(0.45415985584259*x_99 - 1.14119982719421) - 92963.5668519111 - 0.000214219129109745*std::exp(-3.74424004554749*x_74) + 0.0016549422537699*std::exp(-3.28631997108459*x_74) + 1.68345224337839*std::exp(-3.16623997688293*x_74) + 0.0154158412744511*std::exp(-2.93903994560242*x_74) + 0.0114816616388271*std::exp(-2.78071999549866*x_74) - 0.00070699679634908*std::exp(-4.0*x_45) - 0.0235072289325282*std::exp(-3.97359991073608*x_45) - 0.000156523012310955*std::exp(-3.93063998222351*x_45) - 0.1336674813546*std::exp(-3.84967994689941*x_45) + 0.00251776414136167*std::exp(-4.89256000518799*x_111) + 0.000128777405457294*std::exp(-4.78735971450806*x_111) + 0.00548404809409434*std::exp(-4.68495988845825*x_111));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-8388.48630439693*x_1 - 263.178146148083*x_10 - 568.152702747592*x_100 + 65.114578374889*x_101 - 339.42598028478*x_102 - 36.6640576678022*x_103 + 289.938255841601*x_104 + 174.919537384666*x_105 + 241.736939901072*x_106 - 146.716664186491*x_107 + 17.1834268834702*x_108 - 103.824547695656*x_109 + 37.6694821479787*x_11 + 193.170244921897*x_110 + 234.323578042683*x_111 - 203.238478903701*x_112 - 417.853006501727*x_113 - 112.704690470566*x_114 + 376.730786487968*x_115 + 663.079389480293*x_116 + 361.17296187927*x_117 + 163.248090241628*x_118 + 315.477663196067*x_119 - 1407.73722572675*x_12 - 487.952767622643*x_120 - 338.366903590874*x_13 + 28.6332623990869*x_14 - 163.663657868809*x_15 + 334.685610837385*x_16 + 107.92337357778*x_17 - 114.797043405825*x_18 - 45.3040268130608*x_19 + 75.2650896094916*x_2 + 165.272439762934*x_20 - 848.156543086513*x_21 - 225.179801705925*x_22 - 281.085293428478*x_23 - 15.8422724746156*x_24 - 88.7197284560559*x_25 - 32.3330866132911*x_26 + 42.7089029532265*x_27 - 92.2887419472804*x_28 + 67.4428542917559*x_29 + 871.758646599966*x_3 + 602.72766718066*x_30 - 3285.34318656691*x_31 + 43.3036623224676*x_32 - 97.6563366960051*x_33 - 197.417095249172*x_34 + 60.4550455753573*x_35 + 62.9658255166987*x_36 - 141.299833055213*x_37 + 304.157672124402*x_38 - 422.814881279672*x_39 + 192.298483297657*x_4 - 219.479688619334*x_40 - 371.36758034682*x_41 + 79532.074693096*x_42 - 680.237580729011*x_43 - 233.460597708714*x_44 - 160.153135315003*x_45 - 36.7124096187754*x_46 - 399.136297936207*x_47 + 928.316696286492*x_48 + 945.126069953279*x_49 - 153.294574171323*x_5 + 260.485593584232*x_50 - 83.579169495976*x_51 + 235.695666972811*x_52 - 56.7995568509613*x_53 + 217.797396300233*x_54 - 153.227640548928*x_55 - 126.500183922485*x_56 + 727.051620547935*x_57 + 211.548329585082*x_58 + 252.75388271076*x_59 + 309.234058418896*x_6 + 89.2055855417306*x_60 - 65.8694869290736*x_61 + 323.304350231799*x_62 + 439.814653176385*x_63 + 61.2764095473144*x_64 + 16.3982021521952*x_65 + 140.673371625142*x_66 + 55.5145359058775*x_67 - 385.983874915893*x_68 + 281.288347864072*x_69 - 33.8900691992263*x_7 + 212.555782791709*x_70 - 171.970326292689*x_72 + 42.8250082254218*x_73 - 1.33202927357092*x_74 + 136.657863443747*x_75 - 297.235263322425*x_76 - 35.2283591774122*x_77 + 271.295119827378*x_78 + 123.452458677986*x_79 - 1211.17965163483*x_8 - 36.1002456132493*x_80 + 198.606226296216*x_81 - 5.25136219392012*x_82 + 132.049639660171*x_83 + 1929.06591735458*x_84 + 159.742746264028*x_85 - 99.5845621122725*x_86 - 190.441226543348*x_87 - 421.253877397155*x_88 - 694.732562602758*x_89 + 84.1769177037111*x_9 - 115.470813996016*x_90 - 598.604832895659*x_91 + 101.122199972265*x_92 - 39.5398902182774*x_93 - 179.704049329903*x_94 + 32.6948408635099*x_95 + 51.5659480386629*x_96 - 559.236398016334*x_97 - 278.841639051805*x_98 + 278.404796757305*x_99 + 0.000189242746521304*std::pow(-6.1384801864624*x_15 - 8.91168022155762, 2) + 0.00390588948660575*std::pow(-6.67000007629395*x_6 - 8.49240016937256, 2) + 0.000153642181714747*std::pow(-5.50063991546631*x_64 - 8.64447975158691, 2) + 0.0064297914858717*std::pow(-6.22312021255493*x_80 - 8.63335990905762, 2) + 0.00806519805518044*std::pow(-5.10504007339478*x_81 - 6.32679986953735, 2) - 1.05445934488799*std::exp(0.346639841794968*x_1) - 0.277972285362659*std::exp(0.7290398478508*x_19) + 0.00113552694655794*std::exp(2.51127982139587*x_71) + 0.744005582326551*std::exp(2.52927994728088*x_71) - 0.0587006269580063*std::exp(2.55039978027344*x_71) + 0.0939830138172698*std::exp(2.5557599067688*x_71) - 0.092325177290141*std::exp(2.58471989631653*x_71) - 0.025186485239865*std::exp(2.58607983589172*x_71) - 1.84876458468335*std::exp(2.60103988647461*x_71) + 0.0258061582898092*std::exp(2.60951995849609*x_71) - 0.00448487556941287*std::exp(2.61911988258362*x_71) + 0.0322342053948545*std::exp(2.61959981918335*x_71) + 10.7754549134532*std::exp(2.62344002723694*x_71) - 8.29818162830522*std::exp(2.63927984237671*x_71) + 5.64635135336668*std::exp(2.65535998344421*x_71) - 1.92613563428143*std::exp(2.66295981407166*x_71) + 0.0857716992016299*std::exp(2.69736003875732*x_71) + 0.170932401086316*std::exp(1.32943987846375*x_76) - 0.716661906630351*std::exp(2.37591981887817*x_81) - 1.46899039495279*std::sin(0.41567987203598*x_103 + 5.20480012893677) - 5.14414959822336*std::sin(0.364319831132889*x_105 + 5.16792011260986) - 0.475093298941021*std::sin(0.324479848146439*x_112 + 1.92879974842072) + 6.19556252060219*std::sin(0.342559844255447*x_112 + 1.97303986549377) + 67.6142860664634*std::sin(0.462799847126007*x_113 + 8.24320030212402) - 113.098484255464*std::sin(0.271039962768555*x_115 - 7.52120018005371) + 86.2846873319339*std::sin(0.402399837970734*x_115 + 5.18944025039673) + 151.740652344024*std::sin(0.444559872150421*x_115 - 4.1701602935791) + 70.8419796906376*std::sin(0.364959836006165*x_119 + 5.17040014266968) + 5.70177995121093*std::sin(0.416319847106934*x_16 + 2.00135970115662) - 1669.32617179044*std::sin(0.323679834604263*x_28 - 4.28424024581909) - 12.3355985447079*std::sin(0.325439840555191*x_28 - 4.28664016723633) - 0.87512257956218*std::sin(0.34079983830452*x_28 + 5.14592027664185) + 1.68650791513192*std::sin(0.370079845190048*x_28 + 5.16351985931396) + 1.16176361244422*std::sin(0.391679853200912*x_36 - 7.39351987838745) - 105.741233306737*std::sin(0.42399987578392*x_36 - 7.37871980667114) + 0.438817435499446*std::sin(0.341519832611084*x_43 - 4.24616003036499) + 2.46388358430117*std::sin(0.445039868354797*x_45 + 5.23095989227295) + 9.094156428534*std::sin(0.461359858512878*x_45 - 4.14215993881226) + 309.035708607664*std::sin(0.258959949016571*x_48 + 5.06367969512939) - 14.6543720058884*std::sin(0.214479997754097*x_53 + 5.02799987792969) + 1.86520613177612*std::sin(0.241599977016449*x_53 + 5.06559991836548) + 5.75604506807421*std::sin(0.327359855175018*x_53 + 5.13840007781982) - 0.327946432228461*std::sin(0.457919865846634*x_53 - 7.34488010406494) + 559.085232714268*std::sin(0.594959855079651*x_53 - 1.00071978569031) - 123.79200961178*std::sin(0.529839813709259*x_55 + 5.14864015579224) - 5.43617767105417*std::sin(0.24695996940136*x_56 - 7.5360803604126) - 4.87579994703866*std::sin(0.386239856481552*x_59 + 2.000079870224) - 12.5144813546655*std::sin(0.19472000002861*x_64 - 4.39791965484619) - 0.797934927608219*std::sin(0.258799970149994*x_64 - 4.32423973083496) + 0.780035458440977*std::sin(0.36847984790802*x_67 + 1.96831977367401) - 0.261934803105595*std::sin(0.515679836273193*x_69 - 1.07575976848602) - 3.06007252106877*std::sin(0.191359996795654*x_72 - 7.60400009155273) - 36.7564778842859*std::sin(0.473599851131439*x_75 - 0.933439791202545) - 1.05400698082374*std::sin(0.237279981374741*x_78 - 7.56224012374878) - 14.0524332545064*std::sin(0.136480033397675*x_80 - 7.68383979797363) - 286.4608740711*std::sin(0.289759933948517*x_80 - 7.48191976547241) - 94.7663294914295*std::sin(0.309119939804077*x_80 - 4.26359987258911) - 121.804687165531*std::sin(0.357839852571487*x_80 + 5.14359998703003) + 0.236343748085022*std::sin(0.388959854841232*x_80 + 1.99631977081299) + 5.97681758799741*std::sin(0.487999856472015*x_80 - 7.32735967636108) + 0.0822966842042509*std::sin(0.517279863357544*x_80 + 2.1354398727417) - 1.54038496299591*std::sin(0.559519827365875*x_80 - 1.01055979728699) + 103.309948919808*std::sin(0.6211998462677*x_80 + 8.41695976257324) + 155.344257952851*std::sin(0.522799849510193*x_81 - 7.26743984222412) - 1.52508007758147*std::sin(0.669119834899902*x_82 + 5.44583988189697) + 217.757322267133*std::sin(0.295759916305542*x_85 + 5.14039945602417) + 47.0303691859486*std::sin(0.551439881324768*x_85 - 7.2323203086853) - 0.298760116502303*std::sin(0.622239828109741*x_87 - 7.19248008728027) + 594.428323956993*std::sin(0.399919867515564*x_92 - 1.20775985717773) - 5.08026068719945*std::sin(0.386559844017029*x_93 + 8.1825590133667) - 4.35270546449278*std::sin(0.371919840574265*x_95 - 4.22896003723145) - 1319.62126655009*std::sin(0.277999937534332*x_96 + 5.09999990463257) - 4.06953705267137*std::sin(0.373279839754105*x_96 - 7.40655994415283) - 0.462624936901119*std::sin(0.381279855966568*x_96 + 5.18871974945068) - 93.5483933734297*std::sin(0.400719821453094*x_96 - 7.40183973312378) - 56.4837267993726*std::sin(0.438079863786697*x_96 - 7.36663961410522) - 139.643618426374*std::sin(0.441119849681854*x_96 - 7.36895990371704) - 0.627950272077289*std::sin(0.441359847784042*x_96 - 7.37751960754395) + 1.71653421739548*std::sin(0.446559876203537*x_96 - 4.17528009414673) - 0.825605916980741*std::sin(0.45415985584259*x_99 - 1.14119982719421) - 77379.1255896892 + 5.5996021415185e-5*std::exp(-3.74424004554749*x_74) - 0.00340662969585797*std::exp(-3.28631997108459*x_74) - 1.20849354133249*std::exp(-3.16623997688293*x_74) + 0.00948915385580646*std::exp(-2.93903994560242*x_74) + 0.00254474077387184*std::exp(-2.78071999549866*x_74) + 0.000184806127787723*std::exp(-4.0*x_45) - 0.0295086921579511*std::exp(-3.97359991073608*x_45) - 7.37587239365096e-5*std::exp(-3.93063998222351*x_45) - 0.0815169752734751*std::exp(-3.84967994689941*x_45) - 0.00299229085258777*std::exp(-4.89256000518799*x_111) + 2.85416105028225e-5*std::exp(-4.78735971450806*x_111) + 0.00688414136147283*std::exp(-4.68495988845825*x_111));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
