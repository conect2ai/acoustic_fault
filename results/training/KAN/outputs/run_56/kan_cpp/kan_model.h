
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (7.35871911097751e-6*x_1 - 1.1913101123275e-5*x_10 + 3.73172746004317e-5*x_100 + 8.71975233739974e-7*x_101 + 5.8311107688628e-6*x_102 - 7.59145688177211e-7*x_103 - 2.41900757986607e-7*x_104 - 1.87740843807304e-6*x_105 - 2.24505255054297e-5*x_106 + 1.90766708228514e-5*x_107 - 1.18817498737854e-5*x_108 - 1.1992949520482e-5*x_109 - 2.27559109064534e-5*x_11 - 8.92565526592836e-6*x_110 - 8.83193057532173e-6*x_111 - 7.41877194855595e-6*x_112 + 8.10894220807802e-6*x_113 - 5.59562128957414e-6*x_114 - 1.28884192092293e-5*x_115 - 6.38381302289111e-6*x_116 + 8.80447310267212e-6*x_117 + 1.89871214032318e-5*x_118 - 1.5555589884526e-5*x_119 + 1.7887727787314e-5*x_12 + 7.99859883038736e-7*x_120 - 6.63479099403149e-6*x_13 + 5.48329256450214e-7*x_14 - 3.58604997320588e-6*x_15 - 2.68999776643021e-5*x_16 + 1.03248835831891e-5*x_17 + 4.8141898489161e-6*x_18 + 6.86638885702255e-7*x_19 + 4.25971909133812e-5*x_2 - 1.00580700435506e-5*x_20 + 1.04423794731205e-7*x_21 - 9.21090722513585e-6*x_22 + 1.81980110673074e-5*x_23 + 2.07370655545401e-6*x_24 - 1.78341909128532e-5*x_25 + 1.60571625480863e-5*x_26 - 3.71339702532941e-7*x_27 + 7.00216644056614e-6*x_28 - 1.04561769701239e-5*x_29 - 2.40573849101295e-5*x_3 + 3.56653431794296e-6*x_30 + 2.38016913960909e-5*x_31 + 2.32649024471378e-5*x_32 + 1.14427135258759e-5*x_33 - 1.9516166440812e-5*x_34 - 7.93332085031815e-6*x_35 - 7.85977619980812e-6*x_36 - 3.23309693905396e-5*x_37 - 1.80241253917794e-5*x_38 + 2.19821401553655e-5*x_39 - 1.33511142872806e-5*x_4 + 3.33484949214032e-5*x_40 - 1.57206479240252e-5*x_41 - 3.31366985806241e-6*x_42 + 3.18738338133352e-5*x_43 - 7.01394498012786e-6*x_44 - 1.0578106041998e-5*x_45 + 1.08609563557492e-6*x_46 + 2.44387204357648e-5*x_47 - 1.24991743951986e-5*x_48 + 1.17004542647709e-5*x_49 + 1.25509674279352e-5*x_5 - 5.69112050541253e-6*x_50 - 5.87342091576115e-6*x_51 + 1.16876872382786e-5*x_52 + 2.5361814272629e-6*x_53 - 3.65560624316556e-5*x_54 - 9.25482864829681e-6*x_55 - 1.72253948695652e-6*x_56 - 2.70229160116966e-5*x_57 + 2.10976913791e-5*x_58 - 1.82427250046062e-5*x_59 + 2.79706708490653e-5*x_6 + 2.43754561298152e-7*x_60 - 2.43942220793222e-5*x_61 + 1.40522711579086e-5*x_62 - 7.46564429102741e-6*x_63 - 5.28761374210839e-5*x_64 + 9.12773321119486e-5*x_65 + 1.66450999830469e-5*x_66 - 6.01776061315044e-6*x_67 + 1.24495654559576e-5*x_68 + 3.07808787619099e-5*x_69 + 6.96831994467792e-6*x_7 + 2.42234541724854e-6*x_70 + 1.55307869532418e-5*x_71 + 6.20022836215932e-6*x_72 + 1.77343038138787e-5*x_73 - 1.08977242261436e-5*x_74 - 1.35441558266327e-6*x_75 + 5.26010147800381e-6*x_76 - 1.1095775446086e-5*x_77 - 8.77464544701525e-6*x_78 - 4.55339510943777e-6*x_79 - 2.99879163289841e-5*x_8 - 1.36684279981477e-5*x_80 - 3.70869981828398e-6*x_81 + 1.3966221329368e-5*x_82 - 3.57812296359379e-5*x_83 + 7.16081116553221e-6*x_84 + 1.87646157808894e-5*x_85 - 1.27130651066418e-6*x_86 + 4.6525797438235e-6*x_87 - 7.56573079740989e-6*x_88 + 4.78294227795525e-6*x_89 - 6.45496779998662e-5*x_9 + 1.24864643562835e-5*x_90 - 3.70675233128939e-5*x_91 - 3.33011584079228e-6*x_92 + 2.7726422818485e-5*x_93 - 2.98814665509096e-5*x_94 - 1.99342058958081e-6*x_95 + 4.97088053244893e-6*x_96 + 3.8535364648261e-6*x_97 - 4.31318911007737e-5*x_98 - 3.84024646901166e-6*x_99 - 9.58069685021083e-6*std::sin(0.670719861984253*x_1 - 3.32943987846375) + 0.0003370667430402*std::sin(0.701119899749756*x_1 + 1.60103988647461) + 3.96090579351086e-5*std::sin(1.61799991130829*x_105 + 1.007199883461) - 3.90330807067847e-6*std::sin(1.96023988723755*x_108 + 0.77023983001709) + 5.90115307460675e-6*std::sin(1.13239991664886*x_117 + 1.01463985443115) + 4.89253366190619e-5*std::sin(1.17567980289459*x_12 + 4.21504020690918) + 5.90301786947008e-6*std::sin(1.87639987468719*x_14 + 0.768719851970673) - 5.25944124383632e-5*std::sin(2.1833598613739*x_18 - 4.80199956893921) + 1.42855297162224e-5*std::sin(0.870799839496613*x_20 + 1.14535987377167) - 3.17932411979032e-5*std::sin(1.74535989761353*x_25 - 8.78991985321045) - 9.31207380258725e-5*std::sin(1.72271990776062*x_27 - 3.17679977416992) + 2.16480911742527e-5*std::sin(1.64095985889435*x_29 - 2.00951981544495) + 1.40778059478664e-6*std::sin(1.84607982635498*x_29 + 0.777919828891754) - 9.84078389120474e-7*std::sin(1.39055991172791*x_36 + 9.79512023925781) + 2.4894024286192e-6*std::sin(1.49111998081207*x_43 + 6.57128047943115) + 7.25418003641724e-6*std::sin(0.909519791603088*x_54 - 8.36359977722168) - 2.755000686088e-5*std::sin(1.82759988307953*x_55 + 7.39031982421875) + 7.23299332364158e-6*std::sin(1.14431989192963*x_57 + 4.40703964233398) + 6.08270041149142e-6*std::sin(1.82799994945526*x_66 - 7.59944009780884) + 4.717510138078e-5*std::sin(0.662799835205078*x_67 - 1.82927989959717) - 1.10608235080331e-5*std::sin(1.29015982151031*x_75 - 2.24439978599548) - 1.62914182912912e-6*std::sin(1.79999983310699*x_80 + 10.0) - 1.46920238985725e-5*std::sin(2.02975988388062*x_80 + 4.20175981521606) + 4.03958349285498e-6*std::sin(1.31343984603882*x_81 + 0.630799829959869) - 3.92195914103265e-6*std::sin(1.73103988170624*x_83 - 1.99575984477997) - 3.02899126605944e-5*std::sin(0.549839854240417*x_84 - 4.0252799987793) + 2.89536085159402e-5*std::sin(1.47151982784271*x_84 - 2.02431988716125) - 3.5348745688004e-5*std::sin(1.16479980945587*x_86 - 1.57279980182648) - 4.16972996300338e-6*std::sin(1.36223995685577*x_86 + 1.20127987861633) - 4.61702542706992e-6*std::sin(0.874159872531891*x_87 - 2.22207975387573) - 9.72010279104305e-6*std::sin(1.64415991306305*x_90 + 7.17944002151489) + 0.000144582710010775*std::sin(0.255839973688126*x_91 + 7.76056003570557) + 0.000233059291489266*std::sin(0.285119920969009*x_92 + 5.24528026580811) + 5.44848385488475e-5*std::sin(1.87415981292725*x_92 + 7.19328022003174) - 3.19105073718571e-6*std::sin(1.89463984966278*x_92 - 5.60960006713867) - 1.641123190241e-5*std::sin(0.972719848155975*x_95 + 7.59464025497437) - 3.13281501289282e-5*std::sin(1.46863985061646*x_98 - 8.19791984558105) + 0.0633535505626854);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.70835295384074e-6*x_1 - 7.16696134752248e-6*x_10 + 1.59988981505973e-5*x_100 + 3.87415728427727e-6*x_101 + 6.07427212307867e-7*x_102 + 5.87870279054849e-6*x_103 + 1.91277520127481e-6*x_104 - 1.54933768496403e-6*x_105 - 1.61802299334008e-5*x_106 - 5.11835341067495e-6*x_107 - 9.80619643527102e-6*x_108 - 5.31670784320501e-6*x_109 - 2.25824080445332e-5*x_11 - 1.43253418077586e-5*x_110 - 2.31813980494967e-6*x_111 - 4.49142986934471e-6*x_112 + 1.83327278717608e-5*x_113 - 2.24544601445545e-6*x_114 - 8.9462336330904e-6*x_115 - 3.18229642291929e-7*x_116 - 6.23909000438909e-6*x_117 + 1.5412309723213e-5*x_118 - 6.2172578824961e-6*x_119 + 1.58294458164687e-6*x_12 - 1.83372624514017e-6*x_120 - 1.51932174304273e-5*x_13 - 1.00283181197796e-5*x_14 - 3.12962202987895e-6*x_15 - 2.6099702705075e-5*x_16 + 9.33392337650907e-6*x_17 - 4.47905196421855e-6*x_18 + 2.93710103767419e-6*x_19 + 3.45393815871843e-5*x_2 - 1.49596609399389e-5*x_20 - 2.88750673102359e-6*x_21 + 1.7260807813042e-6*x_22 - 2.79523736627964e-6*x_23 - 9.62668253799315e-6*x_24 + 2.96338830455904e-6*x_25 + 8.5865511526865e-7*x_26 - 1.91173302894826e-6*x_27 + 1.08481241641286e-5*x_28 - 8.10043421055367e-6*x_29 - 1.75275038383852e-5*x_3 + 6.7356339434094e-6*x_30 + 2.0459696870896e-5*x_31 + 1.10185657229438e-5*x_32 + 1.18282753697333e-5*x_33 - 1.04820488150671e-5*x_34 - 8.50322386322167e-6*x_35 - 5.98892968884112e-6*x_36 - 1.08685959842704e-5*x_37 - 1.25387608787586e-5*x_38 + 6.48237881136374e-6*x_39 - 1.52478278943584e-5*x_4 + 1.51522160451397e-5*x_40 - 6.93674946745936e-6*x_41 + 7.89419513037798e-6*x_42 + 3.08886808392671e-5*x_43 - 7.78472504099793e-6*x_44 - 7.61148371919827e-6*x_45 + 3.68733441483264e-6*x_46 + 2.18982912460373e-5*x_47 - 8.4838892755204e-6*x_48 + 3.93263006238431e-6*x_49 + 4.52902670445212e-6*x_5 + 6.20505882175864e-6*x_50 - 8.05920309241726e-6*x_51 + 1.49622123576974e-5*x_52 - 2.93459826604641e-7*x_53 - 2.73997273171267e-5*x_54 - 8.22804316179558e-6*x_55 + 4.47833963930776e-6*x_56 - 1.88939000662795e-5*x_57 + 2.85814613481661e-6*x_58 - 4.46491208586379e-6*x_59 + 1.35081875405675e-5*x_6 + 3.06979055351779e-6*x_60 - 1.64900992018434e-5*x_61 + 4.91709359088609e-6*x_62 - 3.87482959479783e-6*x_63 - 3.4456507888269e-5*x_64 + 5.52883762727368e-5*x_65 + 1.98507950586571e-5*x_66 - 6.91931650015064e-6*x_67 + 9.43023277817716e-6*x_68 + 3.92057476301082e-5*x_69 + 7.85867995551953e-6*x_7 - 9.57372078781157e-6*x_70 + 8.00882484717046e-6*x_71 - 3.54561877826755e-6*x_72 + 1.07830352310128e-5*x_73 - 2.22093035459222e-7*x_74 - 1.98587895063713e-6*x_75 + 7.95065695512553e-6*x_76 - 2.57068930386846e-6*x_77 - 7.60636911401028e-6*x_78 - 9.71093769610545e-6*x_79 - 3.04738503069886e-5*x_8 - 1.09495801051482e-5*x_80 - 1.81000384145522e-6*x_81 + 1.29573456864389e-5*x_82 - 1.31338915784704e-5*x_83 + 4.91796702852577e-6*x_84 + 1.37706056222631e-5*x_85 + 2.81753040521521e-6*x_86 - 3.39768882809095e-6*x_87 - 2.8865912590019e-6*x_88 + 1.01939236187366e-5*x_89 - 3.3893787352191e-5*x_9 + 1.23514599226122e-5*x_90 - 2.61641220758571e-5*x_91 + 1.43859922892438e-7*x_92 + 3.87559896221127e-5*x_93 - 1.84794034012438e-5*x_94 - 2.56640381062339e-6*x_95 + 2.61689803708757e-6*x_96 + 7.15759864885598e-6*x_97 - 3.32799406381819e-5*x_98 - 2.2723611721606e-6*x_99 - 5.40481282630424e-6*std::sin(0.670719861984253*x_1 - 3.32943987846375) + 0.000272768043203602*std::sin(0.701119899749756*x_1 + 1.60103988647461) - 2.34725536063091e-5*std::sin(1.61799991130829*x_105 + 1.007199883461) - 2.20199530944929e-6*std::sin(1.96023988723755*x_108 + 0.77023983001709) + 1.857272303555e-6*std::sin(1.13239991664886*x_117 + 1.01463985443115) + 3.9592361477998e-5*std::sin(1.17567980289459*x_12 + 4.21504020690918) + 3.33010293443456e-6*std::sin(1.87639987468719*x_14 + 0.768719851970673) - 4.25615260492922e-5*std::sin(2.1833598613739*x_18 - 4.80199956893921) + 8.05897686232396e-6*std::sin(0.870799839496613*x_20 + 1.14535987377167) - 2.57283768503318e-5*std::sin(1.74535989761353*x_25 - 8.78991985321045) - 7.53570680509504e-5*std::sin(1.72271990776062*x_27 - 3.17679977416992) - 1.28287822799116e-5*std::sin(1.64095985889435*x_29 - 2.00951981544495) + 4.43071358279187e-7*std::sin(1.84607982635498*x_29 + 0.777919828891754) - 3.0971939102974e-7*std::sin(1.39055991172791*x_36 + 9.79512023925781) + 1.40436070427778e-6*std::sin(1.49111998081207*x_43 + 6.57128047943115) + 4.0923417073034e-6*std::sin(0.909519791603088*x_54 - 8.36359977722168) - 1.66160499325244e-5*std::sin(1.82759988307953*x_55 + 7.39031982421875) + 4.08038952691951e-6*std::sin(1.14431989192963*x_57 + 4.40703964233398) + 1.9144107706168e-6*std::sin(1.82799994945526*x_66 - 7.59944009780884) + 2.84524009040447e-5*std::sin(0.662799835205078*x_67 - 1.82927989959717) + 6.55470708613105e-6*std::sin(1.29015982151031*x_75 - 2.24439978599548) - 5.12740469455809e-7*std::sin(1.79999983310699*x_80 + 10.0) + 8.70657714478844e-6*std::sin(2.02975988388062*x_80 + 4.20175981521606) + 1.27137975313028e-6*std::sin(1.31343984603882*x_81 + 0.630799829959869) - 1.23435979311547e-6*std::sin(1.73103988170624*x_83 - 1.99575984477997) - 9.53315651202133e-6*std::sin(0.549839854240417*x_84 - 4.0252799987793) - 1.71580735169189e-5*std::sin(1.47151982784271*x_84 - 2.02431988716125) - 2.86056349079466e-5*std::sin(1.16479980945587*x_86 - 1.57279980182648) - 2.35229340189068e-6*std::sin(1.36223995685577*x_86 + 1.20127987861633) - 2.60462872771631e-6*std::sin(0.874159872531891*x_87 - 2.22207975387573) - 5.86242007636589e-6*std::sin(1.64415991306305*x_90 + 7.17944002151489) - 8.56805384473749e-5*std::sin(0.255839973688126*x_91 + 7.76056003570557) + 7.33508454528627e-5*std::sin(0.285119920969009*x_92 + 5.24528026580811) + 4.40913353277955e-5*std::sin(1.87415981292725*x_92 + 7.19328022003174) - 1.80018554217686e-6*std::sin(1.89463984966278*x_92 - 5.60960006713867) + 9.7253896117899e-6*std::sin(0.972719848155975*x_95 + 7.59464025497437) + 1.85652404177976e-5*std::sin(1.46863985061646*x_98 - 8.19791984558105) + 0.0996530860058617);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.99968617112937e-6*x_1 + 1.95380296644016e-6*x_10 + 2.0837557634617e-5*x_100 - 7.59170951043097e-6*x_101 + 2.41272994243714e-7*x_102 + 5.47205304797172e-6*x_103 + 1.93630233901182e-7*x_104 + 1.14456039752298e-5*x_105 - 3.85701930893865e-6*x_106 + 1.23070090292386e-5*x_107 + 1.34855519448708e-6*x_108 - 1.49502481362465e-5*x_109 - 5.18241017076515e-7*x_11 - 9.89085497200563e-6*x_110 - 5.44535886468454e-6*x_111 - 1.10142567989518e-5*x_112 + 5.44119141629981e-6*x_113 - 1.17228057544022e-5*x_114 - 9.11677769138823e-6*x_115 - 3.70000380770689e-6*x_116 + 8.18906152990538e-6*x_117 + 7.64101790969105e-6*x_118 - 1.17866473368979e-6*x_119 - 3.19581860438871e-6*x_12 + 1.13902446743211e-5*x_120 + 2.81859600226484e-6*x_13 + 1.80344828095188e-5*x_14 + 6.76924513021338e-6*x_15 - 1.90273502884993e-6*x_16 + 8.92420305554517e-6*x_17 + 1.4280018521199e-5*x_18 - 1.50517548733546e-5*x_19 - 2.74815541639221e-6*x_2 - 2.38067375084598e-6*x_20 + 5.94237623055978e-6*x_21 - 2.67085949631636e-5*x_22 + 2.87091245485108e-5*x_23 + 1.12652550393803e-6*x_24 - 1.28936359911234e-5*x_25 + 1.41037804982671e-5*x_26 + 8.55570794711513e-6*x_27 + 8.60601321338823e-7*x_28 - 5.54817783261728e-7*x_29 + 8.01697220513863e-7*x_3 + 6.50746347423673e-6*x_30 + 9.01106307568721e-6*x_31 + 1.90077295442618e-5*x_32 + 7.30650183324874e-6*x_33 - 2.10316838659689e-5*x_34 + 4.40386943277852e-7*x_35 - 3.68270341826628e-6*x_36 + 1.26490157620177e-5*x_37 + 1.3431387759329e-6*x_38 + 4.18372519765733e-6*x_39 - 3.06003001679273e-6*x_4 + 1.03998627954552e-5*x_40 - 1.55742696161421e-5*x_41 + 6.04332446093853e-6*x_42 - 7.31578087501342e-7*x_43 + 8.26616324007004e-6*x_44 - 4.89376937826042e-6*x_45 - 4.79403389392635e-6*x_46 - 8.76919844408008e-6*x_47 + 1.01573689469206e-6*x_48 + 1.29636195565757e-5*x_49 + 6.06576758218475e-6*x_5 - 3.46522048752404e-5*x_50 + 3.00028804403577e-6*x_51 + 7.20786029582211e-6*x_52 + 5.83679459115162e-6*x_53 + 2.02005810844763e-5*x_54 - 5.06952376748408e-6*x_55 - 1.57873192998546e-5*x_56 - 1.61615363017956e-5*x_57 - 6.28552055358868e-6*x_58 - 6.43556146199049e-6*x_59 + 7.51964087202316e-6*x_6 + 1.55074136391856e-6*x_60 - 1.00718807034978e-5*x_61 - 1.98940747142472e-6*x_62 - 2.11274327029119e-5*x_63 - 1.89718874755758e-5*x_64 - 1.17501094955286e-5*x_65 + 4.37795511336804e-6*x_66 + 7.14593897050507e-6*x_67 + 3.90428776937034e-6*x_68 - 4.36522066543248e-6*x_69 - 2.16246104462658e-6*x_7 + 1.96129085814357e-5*x_70 - 1.12809411511944e-6*x_71 + 1.37397428903591e-5*x_72 + 2.65228664840622e-6*x_73 + 6.37431612477545e-7*x_74 - 1.10906627507372e-5*x_75 - 7.42512612045753e-6*x_76 + 1.28482663169591e-6*x_77 - 4.15685645901159e-6*x_78 + 7.76826063508105e-7*x_79 + 2.49060866613947e-5*x_8 - 1.76301419559384e-6*x_80 + 9.44739323201814e-9*x_81 + 3.79454970527308e-6*x_82 + 2.43594430823326e-5*x_83 - 3.52084831701633e-6*x_84 + 1.09524387428445e-6*x_85 - 4.33385836051247e-6*x_86 - 6.6829665931008e-7*x_87 - 4.20065772352323e-6*x_88 + 1.16029580342591e-6*x_89 + 3.56864520243612e-5*x_9 + 7.18932981086432e-6*x_90 - 7.87818656333354e-6*x_91 + 6.73572635459236e-7*x_92 + 9.5542284434969e-6*x_93 - 2.07802858841229e-5*x_94 - 4.28108274623811e-6*x_95 - 3.58520642322248e-6*x_96 + 4.6818801060958e-7*x_97 - 1.74855842682373e-6*x_98 - 5.59731689372333e-7*x_99 - 3.67701336633051e-5*std::sin(0.670719861984253*x_1 - 3.32943987846375) + 7.82223866153248e-5*std::sin(0.701119899749756*x_1 + 1.60103988647461) + 3.34542193738489e-5*std::sin(1.61799991130829*x_105 + 1.007199883461) - 1.49806597298553e-5*std::sin(1.96023988723755*x_108 + 0.77023983001709) - 2.81585545853006e-6*std::sin(1.13239991664886*x_117 + 1.01463985443115) + 1.13540023610242e-5*std::sin(1.17567980289459*x_12 + 4.21504020690918) + 2.2655424701442e-5*std::sin(1.87639987468719*x_14 + 0.768719851970673) - 1.22054772489638e-5*std::sin(2.1833598613739*x_18 - 4.80199956893921) + 5.48269969636974e-5*std::sin(0.870799839496613*x_20 + 1.14535987377167) - 7.37819217139454e-6*std::sin(1.74535989761353*x_25 - 8.78991985321045) - 2.16103383741286e-5*std::sin(1.72271990776062*x_27 - 3.17679977416992) + 1.82842013651276e-5*std::sin(1.64095985889435*x_29 - 2.00951981544495) - 6.71751202201582e-7*std::sin(1.84607982635498*x_29 + 0.777919828891754) + 4.69573059467028e-7*std::sin(1.39055991172791*x_36 + 9.79512023925781) + 9.5541755963263e-6*std::sin(1.49111998081207*x_43 + 6.57128047943115) + 2.78411031814322e-5*std::sin(0.909519791603088*x_54 - 8.36359977722168) + 3.95016615266217e-5*std::sin(1.82759988307953*x_55 + 7.39031982421875) + 2.77597898622836e-5*std::sin(1.14431989192963*x_57 + 4.40703964233398) - 2.90248447036642e-6*std::sin(1.82799994945526*x_66 - 7.59944009780884) - 6.76404509312022e-5*std::sin(0.662799835205078*x_67 - 1.82927989959717) - 9.34208575976198e-6*std::sin(1.29015982151031*x_75 - 2.24439978599548) + 7.77378226640662e-7*std::sin(1.79999983310699*x_80 + 10.0) - 1.24090351089368e-5*std::sin(2.02975988388062*x_80 + 4.20175981521606) - 1.92756959271076e-6*std::sin(1.31343984603882*x_81 + 0.630799829959869) + 1.87144273598505e-6*std::sin(1.73103988170624*x_83 - 1.99575984477997) + 1.44534491522942e-5*std::sin(0.549839854240417*x_84 - 4.0252799987793) + 2.44545167558312e-5*std::sin(1.47151982784271*x_84 - 2.02431988716125) - 8.20331079427812e-6*std::sin(1.16479980945587*x_86 - 1.57279980182648) - 1.6003170800269e-5*std::sin(1.36223995685577*x_86 + 1.20127987861633) - 1.77198636732258e-5*std::sin(0.874159872531891*x_87 - 2.22207975387573) + 1.39368462735653e-5*std::sin(1.64415991306305*x_90 + 7.17944002151489) + 0.000122116049977516*std::sin(0.255839973688126*x_91 + 7.76056003570557) - 0.000111208990819973*std::sin(0.285119920969009*x_92 + 5.24528026580811) + 1.2644184552889e-5*std::sin(1.87415981292725*x_92 + 7.19328022003174) - 1.22470592658534e-5*std::sin(1.89463984966278*x_92 - 5.60960006713867) - 1.38610959432006e-5*std::sin(0.972719848155975*x_95 + 7.59464025497437) - 2.6460079123999e-5*std::sin(1.46863985061646*x_98 - 8.19791984558105) + 0.046338944004066);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.88500168487257e-6*x_1 + 9.28364393574803e-7*x_10 + 1.20142124093879e-6*x_100 - 6.29180796743122e-6*x_101 - 1.04487748760394e-6*x_102 + 4.33213125284989e-6*x_103 + 3.32778887046432e-6*x_104 + 4.79620808953514e-6*x_105 - 3.88809533323012e-7*x_106 - 9.59344967587667e-6*x_107 - 1.50191052729863e-6*x_108 - 8.69457892323649e-6*x_109 - 1.78813474671235e-5*x_11 - 2.43561188716152e-5*x_110 + 6.07872416921199e-6*x_111 - 5.62489016233752e-6*x_112 + 1.9203625790968e-5*x_113 - 7.20405989342891e-6*x_114 - 1.10474577681677e-5*x_115 - 8.16401836792031e-6*x_116 - 5.62385384529155e-6*x_117 + 2.00734169564708e-5*x_118 - 3.39001386281712e-7*x_119 - 2.54471578728147e-5*x_12 + 4.36930943215943e-6*x_120 - 1.35169792357478e-5*x_13 + 3.15309153400987e-6*x_14 + 8.63745376066723e-6*x_15 - 1.98639261307054e-5*x_16 + 1.82039660004193e-5*x_17 - 4.30277333306893e-6*x_18 + 2.2515004888298e-6*x_19 + 2.01687253326551e-6*x_2 - 1.57636682446483e-5*x_20 + 4.50211337772084e-7*x_21 + 5.30350554945875e-6*x_22 + 2.06029058177433e-6*x_23 - 1.88861115584755e-5*x_24 + 2.42938243174921e-5*x_25 + 4.21777638163933e-6*x_26 + 2.02987545473333e-6*x_27 + 9.48181260261236e-6*x_28 - 1.06102200793236e-6*x_29 - 9.98165654569785e-6*x_3 + 8.80239995924344e-6*x_30 + 9.50899995865528e-6*x_31 + 1.0473708149712e-5*x_32 + 1.11621062624045e-5*x_33 - 2.27629238469342e-5*x_34 + 5.07673428395742e-6*x_35 - 8.39600194486015e-6*x_36 + 2.48649792823932e-5*x_37 - 3.95100207474238e-6*x_38 - 5.60630440427631e-7*x_39 - 1.09743349804035e-5*x_4 + 2.91325135875967e-7*x_40 + 4.98471511404104e-7*x_41 + 2.9118861101178e-5*x_42 + 1.46028522078578e-5*x_43 - 3.65307389589476e-6*x_44 - 5.88692433219175e-6*x_45 + 1.41689863173211e-6*x_46 + 1.38778324581777e-5*x_47 - 4.70506455735464e-6*x_48 + 7.21528781661477e-6*x_49 - 1.03488881904663e-6*x_5 - 1.93158756946017e-5*x_50 - 3.70026194427877e-7*x_51 + 2.53434048058136e-5*x_52 + 5.04405618626315e-6*x_53 + 1.95802304775293e-5*x_54 - 3.00932260116532e-6*x_55 + 4.1722228140105e-6*x_56 - 1.90061991880667e-5*x_57 - 9.64033871125836e-6*x_58 + 3.93366854117316e-6*x_59 - 1.20738681231183e-6*x_6 - 3.82397743197589e-6*x_60 - 7.51436687725067e-6*x_61 - 1.94999274716105e-5*x_62 - 2.03681165813522e-5*x_63 - 1.49434840664939e-5*x_64 + 6.42143641378923e-6*x_65 + 2.1119654363446e-5*x_66 - 1.04521480626801e-5*x_67 + 7.3116384267414e-6*x_68 + 3.25313905466232e-5*x_69 + 1.48161084173713e-6*x_7 - 8.27398091571472e-6*x_70 - 7.81661561467001e-6*x_71 + 5.74248973178269e-7*x_72 + 3.61440535701441e-6*x_73 + 1.91284684136215e-5*x_74 - 1.15851974755756e-5*x_75 - 1.0026506672295e-5*x_76 + 1.09042164574648e-5*x_77 - 9.25721531358243e-6*x_78 - 1.47191506287513e-5*x_79 - 1.22045768144929e-5*x_8 - 5.26498526108804e-6*x_80 + 4.60564223335874e-6*x_81 + 1.34947890448105e-5*x_82 + 2.68043329657761e-5*x_83 - 6.09345164042013e-6*x_84 + 5.22646982941076e-7*x_85 + 3.40759931815258e-6*x_86 - 1.02728935807244e-5*x_87 + 1.61012392223807e-6*x_88 + 2.21099117952653e-5*x_89 + 3.65470313995159e-5*x_9 + 5.16688685981822e-6*x_90 + 1.7788890124612e-5*x_91 + 4.81213543236814e-6*x_92 + 4.37162220943127e-5*x_93 - 2.87304839884503e-5*x_94 - 6.21304521584561e-6*x_95 - 3.51213827545306e-6*x_96 + 7.83295208297974e-6*x_97 - 7.14133405350557e-7*x_98 + 1.71905247959632e-6*x_99 + 1.97176294339252e-5*std::sin(0.670719861984253*x_1 - 3.32943987846375) + 0.000160037750673979*std::sin(0.701119899749756*x_1 + 1.60103988647461) - 4.63803949126972e-5*std::sin(1.61799991130829*x_105 + 1.007199883461) + 8.03323425293368e-6*std::sin(1.96023988723755*x_108 + 0.77023983001709) + 9.4409180828838e-7*std::sin(1.13239991664886*x_117 + 1.01463985443115) + 2.32295264518223e-5*std::sin(1.17567980289459*x_12 + 4.21504020690918) - 1.21487529259929e-5*std::sin(1.87639987468719*x_14 + 0.768719851970673) - 2.49715868991897e-5*std::sin(2.1833598613739*x_18 - 4.80199956893921) - 2.94004481736212e-5*std::sin(0.870799839496613*x_20 + 1.14535987377167) - 1.50952857646383e-5*std::sin(1.74535989761353*x_25 - 8.78991985321045) - 4.42133012599945e-5*std::sin(1.72271990776062*x_27 - 3.17679977416992) - 2.5348924466036e-5*std::sin(1.64095985889435*x_29 - 2.00951981544495) + 2.25222784530797e-7*std::sin(1.84607982635498*x_29 + 0.777919828891754) - 1.57437086300998e-7*std::sin(1.39055991172791*x_36 + 9.79512023925781) - 5.12333448880043e-6*std::sin(1.49111998081207*x_43 + 6.57128047943115) - 1.49295229816091e-5*std::sin(0.909519791603088*x_54 - 8.36359977722168) + 4.8693683941626e-5*std::sin(1.82759988307953*x_55 + 7.39031982421875) - 1.48859194986929e-5*std::sin(1.14431989192963*x_57 + 4.40703964233398) + 9.73136530803192e-7*std::sin(1.82799994945526*x_66 - 7.59944009780884) - 8.33803595095182e-5*std::sin(0.662799835205078*x_67 - 1.82927989959717) + 1.29517183469164e-5*std::sin(1.29015982151031*x_75 - 2.24439978599548) - 2.60637105320853e-7*std::sin(1.79999983310699*x_80 + 10.0) + 1.72036878937881e-5*std::sin(2.02975988388062*x_80 + 4.20175981521606) + 6.46269913063641e-7*std::sin(1.31343984603882*x_81 + 0.630799829959869) - 6.27451864182899e-7*std::sin(1.73103988170624*x_83 - 1.99575984477997) - 4.8459102916159e-6*std::sin(0.549839854240417*x_84 - 4.0252799987793) - 3.3903351079871e-5*std::sin(1.47151982784271*x_84 - 2.02431988716125) - 1.67834230634257e-5*std::sin(1.16479980945587*x_86 - 1.57279980182648) + 8.58154594967963e-6*std::sin(1.36223995685577*x_86 + 1.20127987861633) + 9.5021059408608e-6*std::sin(0.874159872531891*x_87 - 2.22207975387573) + 1.71799453835798e-5*std::sin(1.64415991306305*x_90 + 7.17944002151489) - 0.000169299739439242*std::sin(0.255839973688126*x_91 + 7.76056003570557) + 3.72858262035801e-5*std::sin(0.285119920969009*x_92 + 5.24528026580811) + 2.58691525854644e-5*std::sin(1.87415981292725*x_92 + 7.19328022003174) + 6.56736737675788e-6*std::sin(1.89463984966278*x_92 - 5.60960006713867) + 1.92168018205492e-5*std::sin(0.972719848155975*x_95 + 7.59464025497437) + 3.66838306844969e-5*std::sin(1.46863985061646*x_98 - 8.19791984558105) + 0.0667200243143816);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-7.29756518927681e-6*x_1 + 2.38978387172166e-7*x_10 - 7.47762953603842e-6*x_100 - 7.71468031296868e-7*x_101 + 6.71729517187429e-7*x_102 - 8.23967826019749e-6*x_103 - 1.40844292712279e-6*x_104 - 4.77176210744075e-6*x_105 + 4.62192664265715e-6*x_106 + 6.55980759216988e-6*x_107 + 4.31713183025728e-6*x_108 + 1.654600891826e-6*x_109 + 9.6066429758764e-6*x_11 + 5.99277250763187e-6*x_110 + 2.40195373533036e-8*x_111 + 2.73428788370188e-6*x_112 - 1.05061945443517e-5*x_113 + 2.45046665609195e-6*x_114 + 4.47445730125489e-6*x_115 - 7.71037071296646e-7*x_116 + 5.29676617039141e-6*x_117 - 5.83689547069749e-6*x_118 - 1.81147043424113e-6*x_119 - 2.43373408655359e-7*x_12 - 7.65813908048906e-7*x_120 + 4.87840839866902e-6*x_13 + 3.97839956803868e-6*x_14 - 6.06629796333803e-7*x_15 + 1.07807989035562e-5*x_16 - 8.07280362419708e-6*x_17 - 6.21541487356089e-7*x_18 + 3.96051771071367e-7*x_19 - 1.81792950525584e-5*x_2 + 7.45021555136299e-6*x_20 - 1.13673433797506e-7*x_21 + 2.42442572662584e-6*x_22 + 1.24973131699514e-6*x_23 + 5.31542101008308e-6*x_24 + 1.57092462516684e-7*x_25 + 1.6816159219168e-6*x_26 - 1.84012736860348e-6*x_27 - 6.4959078007332e-6*x_28 + 3.58501956829749e-6*x_29 + 7.36361881500836e-6*x_3 - 5.89363154157402e-6*x_30 - 7.68158254585257e-6*x_31 - 3.35453981205662e-6*x_32 - 7.71565352554885e-6*x_33 + 3.18486684243751e-7*x_34 + 1.53804629238876e-6*x_35 + 2.4890836382542e-6*x_36 - 1.86491700907666e-6*x_37 + 3.23058455959188e-6*x_38 + 3.24251937574922e-7*x_39 + 5.86188041737653e-6*x_4 - 5.58138572757436e-6*x_40 - 8.07615763269855e-7*x_41 - 3.66021928170174e-6*x_42 - 1.437500402446e-5*x_43 - 2.9042969317852e-6*x_44 + 4.60301402596245e-6*x_45 - 4.18406336762196e-6*x_46 - 3.67986364565138e-6*x_47 - 1.57188580644277e-6*x_48 - 3.52874666113246e-6*x_49 - 2.90601206648468e-6*x_5 - 2.12987743869001e-6*x_50 + 3.15712103039318e-6*x_51 - 1.03446838625644e-5*x_52 - 8.39650352093154e-6*x_53 + 7.16628899101851e-6*x_54 + 6.43533152325948e-6*x_55 - 9.77870715729554e-8*x_56 + 9.43016557972139e-6*x_57 + 4.22417610791895e-6*x_58 + 9.21486707877464e-7*x_59 - 4.73435526452877e-6*x_6 - 4.24033292868245e-6*x_60 + 8.98758299347224e-6*x_61 - 9.9462859146113e-7*x_62 - 1.44031256314197e-6*x_63 + 1.64851524588445e-5*x_64 - 5.85419513785872e-5*x_65 - 1.0129994490142e-5*x_66 - 1.7063925938237e-6*x_67 - 6.71931341148314e-6*x_68 - 1.7945170007011e-5*x_69 - 3.77218665024061e-6*x_7 + 1.39008094043665e-6*x_70 - 3.14375222573695e-6*x_71 - 1.81718296227826e-6*x_72 - 7.10259360827328e-6*x_73 - 2.41985628483488e-6*x_74 + 3.59925218709792e-6*x_75 - 4.14824305630874e-6*x_76 - 1.51563869786167e-6*x_77 + 4.19941936574885e-6*x_78 + 2.41346069897069e-6*x_79 - 2.6389839877771e-6*x_8 + 4.75242214696078e-6*x_80 + 1.00418895368242e-6*x_81 - 7.69481873062641e-6*x_82 - 4.56770380782006e-6*x_83 - 1.68530975557786e-6*x_84 - 7.17432229027013e-6*x_85 - 4.83673485459253e-6*x_86 + 8.24728603220483e-7*x_87 - 8.10695022547354e-7*x_88 - 8.33401796479292e-6*x_89 + 4.03452962699055e-6*x_9 - 8.2762065196389e-6*x_90 + 1.80810602460853e-5*x_91 - 7.98264224474116e-7*x_92 - 2.12273688815551e-5*x_93 + 6.62898273158928e-6*x_94 - 2.56837420859394e-7*x_95 - 6.70409785431126e-7*x_96 - 7.17053292090174e-6*x_97 + 1.40470001732839e-5*x_98 - 3.62939959873561e-7*x_99 + 1.60957239469081e-5*std::sin(0.670719861984253*x_1 - 3.32943987846375) - 0.000126107344325269*std::sin(0.701119899749756*x_1 + 1.60103988647461) + 1.75751590321249e-5*std::sin(1.61799991130829*x_105 + 1.007199883461) + 6.55761999024077e-6*std::sin(1.96023988723755*x_108 + 0.77023983001709) - 1.18848115591816e-5*std::sin(1.13239991664886*x_117 + 1.01463985443115) - 1.83045180180054e-5*std::sin(1.17567980289459*x_12 + 4.21504020690918) - 9.91716443658954e-6*std::sin(1.87639987468719*x_14 + 0.768719851970673) + 1.96772354908916e-5*std::sin(2.1833598613739*x_18 - 4.80199956893921) - 2.3999918413305e-5*std::sin(0.870799839496613*x_20 + 1.14535987377167) + 1.18948585042759e-5*std::sin(1.74535989761353*x_25 - 8.78991985321045) + 3.48394174641291e-5*std::sin(1.72271990776062*x_27 - 3.17679977416992) + 9.60559692565146e-6*std::sin(1.64095985889435*x_29 - 2.00951981544495) - 2.83524370138911e-6*std::sin(1.84607982635498*x_29 + 0.777919828891754) + 1.98191540980136e-6*std::sin(1.39055991172791*x_36 + 9.79512023925781) - 4.18223589685292e-6*std::sin(1.49111998081207*x_43 + 6.57128047943115) - 1.21871384882379e-5*std::sin(0.909519791603088*x_54 - 8.36359977722168) + 7.75441870562264e-9*std::sin(1.82759988307953*x_55 + 7.39031982421875) - 1.21515444719037e-5*std::sin(1.14431989192963*x_57 + 4.40703964233398) - 1.22504444889949e-5*std::sin(1.82799994945526*x_66 - 7.59944009780884) - 1.32782358434259e-8*std::sin(0.662799835205078*x_67 - 1.82927989959717) - 4.9078605327707e-6*std::sin(1.29015982151031*x_75 - 2.24439978599548) + 3.28106107358862e-6*std::sin(1.79999983310699*x_80 + 10.0) - 6.51908098759187e-6*std::sin(2.02975988388062*x_80 + 4.20175981521606) - 8.13564535323654e-6*std::sin(1.31343984603882*x_81 + 0.630799829959869) + 7.89875211584624e-6*std::sin(1.73103988170624*x_83 - 1.99575984477997) + 6.10033157188051e-5*std::sin(0.549839854240417*x_84 - 4.0252799987793) + 1.28471693281674e-5*std::sin(1.47151982784271*x_84 - 2.02431988716125) + 1.32250853458178e-5*std::sin(1.16479980945587*x_86 - 1.57279980182648) + 7.0052130306343e-6*std::sin(1.36223995685577*x_86 + 1.20127987861633) + 7.75667656453797e-6*std::sin(0.874159872531891*x_87 - 2.22207975387573) + 2.73588849846956e-9*std::sin(1.64415991306305*x_90 + 7.17944002151489) + 6.41536116788738e-5*std::sin(0.255839973688126*x_91 + 7.76056003570557) - 0.000469377039783174*std::sin(0.285119920969009*x_92 + 5.24528026580811) - 2.03845037733869e-5*std::sin(1.87415981292725*x_92 + 7.19328022003174) + 5.36101627776571e-6*std::sin(1.89463984966278*x_92 - 5.60960006713867) - 7.2819204907744e-6*std::sin(0.972719848155975*x_95 + 7.59464025497437) - 1.39007906120928e-5*std::sin(1.46863985061646*x_98 - 8.19791984558105) + 0.0570938433127282);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-7.83896418287287e-6*x_1 - 1.07424425073987e-6*x_10 + 1.12226458116189e-5*x_100 + 4.19747834040774e-6*x_101 - 2.75236938445921e-6*x_102 + 9.64586839260921e-6*x_103 + 4.29261990983421e-7*x_104 + 3.80554558258116e-6*x_105 - 1.0572451787166e-5*x_106 - 3.93239990703563e-6*x_107 - 2.81904277626702e-6*x_108 - 4.76322169170564e-6*x_109 - 1.62049011081797e-6*x_11 - 3.71581060810507e-6*x_110 - 6.67190602592911e-6*x_111 - 5.93854567444885e-6*x_112 + 1.02829852632527e-5*x_113 - 2.93717442239401e-6*x_114 - 1.89916264970985e-6*x_115 + 8.47236000531568e-6*x_116 - 4.54315711199713e-6*x_117 - 1.68969231995962e-6*x_118 + 1.29314774880281e-6*x_119 + 5.84082766254947e-6*x_12 + 2.67053539084752e-6*x_120 - 5.15336306466412e-6*x_13 - 2.76459566476333e-6*x_14 - 3.74620166806848e-6*x_15 - 3.38194060974459e-6*x_16 - 2.82059754031513e-6*x_17 + 4.64675609776081e-6*x_18 - 1.13709786969253e-5*x_19 + 1.29166958557784e-5*x_2 - 3.68988071199372e-6*x_20 - 9.95268690524668e-8*x_21 - 1.76065003380394e-5*x_22 + 4.45559908773958e-6*x_23 + 2.7207140320028e-7*x_24 - 1.19489032936169e-5*x_25 - 2.57860347043792e-6*x_26 + 2.54658301905887e-6*x_27 + 3.41723223920509e-6*x_28 - 3.47980918549293e-6*x_29 + 2.1858971205518e-6*x_3 + 5.25239673307576e-6*x_30 + 1.28731317362972e-5*x_31 + 6.57309356433637e-6*x_32 + 5.38337607834966e-6*x_33 - 1.29531249586101e-6*x_34 - 1.16045404259072e-5*x_35 + 1.01264508408643e-6*x_36 - 9.09262956732938e-7*x_37 - 4.93930924227509e-7*x_38 - 3.49385700359886e-6*x_39 - 6.64093954085287e-6*x_4 + 4.87920883085133e-6*x_40 - 1.38116973654587e-5*x_41 - 3.79812892261399e-6*x_42 + 8.30827221904698e-6*x_43 + 2.23178512439212e-6*x_44 - 2.0240860630957e-6*x_45 - 1.63085795137417e-6*x_46 - 4.25326306544034e-6*x_47 + 4.40815211232068e-7*x_48 + 1.26872398726826e-6*x_49 + 2.46359757270753e-6*x_5 - 4.63133219528142e-7*x_50 - 4.90975491066845e-6*x_51 - 2.58841396937082e-6*x_52 - 4.72281536843068e-6*x_53 - 1.18042851221977e-5*x_54 - 6.31971139117886e-6*x_55 - 8.989168343486e-6*x_56 - 5.03471920621571e-6*x_57 - 9.78614087937695e-6*x_58 - 8.40511353196823e-7*x_59 + 5.63497805991097e-6*x_6 + 8.54463505890011e-6*x_60 - 7.47520205751534e-6*x_61 + 1.09595083559635e-5*x_62 - 3.03653369613186e-6*x_63 - 1.34483573637566e-5*x_64 - 2.04248251473262e-5*x_65 + 2.82835522602327e-6*x_66 + 8.18337979687663e-6*x_67 + 6.71574846968788e-7*x_68 + 3.90428616550102e-6*x_69 + 3.16998536962802e-6*x_7 + 6.86095716747308e-6*x_70 + 5.06020353961546e-6*x_71 - 1.04393884654855e-7*x_72 + 2.60244155838145e-7*x_73 - 7.54781105662157e-6*x_74 - 1.44614779327018e-6*x_75 + 9.76605345414713e-6*x_76 - 3.49633020133827e-6*x_77 - 1.50212003455471e-7*x_78 + 1.04947785359374e-6*x_79 + 5.31421856300466e-6*x_8 - 2.78021156610763e-6*x_80 - 3.55973365714214e-6*x_81 - 1.87679060231836e-7*x_82 + 6.50564632595803e-6*x_83 + 3.77874584954691e-6*x_84 + 5.89477402752453e-6*x_85 - 2.61472454746981e-6*x_86 - 1.66812887184282e-6*x_87 - 4.06869411703141e-6*x_88 - 7.13606147661255e-6*x_89 + 3.45069984176893e-7*x_9 + 1.02872859957429e-5*x_90 - 3.01250884502622e-5*x_91 - 5.96900369516317e-7*x_92 + 8.06104003502182e-6*x_93 + 1.34705134795113e-6*x_94 - 1.5571214120618e-6*x_95 - 3.28917935020551e-7*x_96 + 4.281163491517e-7*x_97 - 1.70570426835297e-5*x_98 - 2.79622035350351e-6*x_99 - 4.71539830516547e-5*std::sin(0.670719861984253*x_1 - 3.32943987846375) + 7.68136925441518e-5*std::sin(0.701119899749756*x_1 + 1.60103988647461) + 6.76712693199369e-7*std::sin(1.61799991130829*x_105 + 1.007199883461) - 1.92111832247473e-5*std::sin(1.96023988723755*x_108 + 0.77023983001709) - 9.74903496451878e-6*std::sin(1.13239991664886*x_117 + 1.01463985443115) + 1.11495300034021e-5*std::sin(1.17567980289459*x_12 + 4.21504020690918) + 2.90532942355318e-5*std::sin(1.87639987468719*x_14 + 0.768719851970673) - 1.19856708203898e-5*std::sin(2.1833598613739*x_18 - 4.80199956893921) + 7.03100866935204e-5*std::sin(0.870799839496613*x_20 + 1.14535987377167) - 7.24531952434873e-6*std::sin(1.74535989761353*x_25 - 8.78991985321045) - 2.12211613512722e-5*std::sin(1.72271990776062*x_27 - 3.17679977416992) + 3.69853231681357e-7*std::sin(1.64095985889435*x_29 - 2.00951981544495) - 2.32573228781404e-6*std::sin(1.84607982635498*x_29 + 0.777919828891754) + 1.62575254396399e-6*std::sin(1.39055991172791*x_36 + 9.79512023925781) + 1.22522653375965e-5*std::sin(1.49111998081207*x_43 + 6.57128047943115) + 3.57034031906921e-5*std::sin(0.909519791603088*x_54 - 8.36359977722168) - 1.01936865579705e-5*std::sin(1.82759988307953*x_55 + 7.39031982421875) + 3.55991270706182e-5*std::sin(1.14431989192963*x_57 + 4.40703964233398) - 1.00489613200339e-5*std::sin(1.82799994945526*x_66 - 7.59944009780884) + 1.7455102615564e-5*std::sin(0.662799835205078*x_67 - 1.82927989959717) - 1.88971918428018e-7*std::sin(1.29015982151031*x_75 - 2.24439978599548) + 2.69143342894868e-6*std::sin(1.79999983310699*x_80 + 10.0) - 2.51010238043048e-7*std::sin(2.02975988388062*x_80 + 4.20175981521606) - 6.67361788722291e-6*std::sin(1.31343984603882*x_81 + 0.630799829959869) + 6.47929587860917e-6*std::sin(1.73103988170624*x_83 - 1.99575984477997) + 5.00406300034902e-5*std::sin(0.549839854240417*x_84 - 4.0252799987793) + 4.94666508573914e-7*std::sin(1.47151982784271*x_84 - 2.02431988716125) - 8.05557872191477e-6*std::sin(1.16479980945587*x_86 - 1.57279980182648) - 2.05224504103907e-5*std::sin(1.36223995685577*x_86 + 1.20127987861633) - 2.27239356532112e-5*std::sin(0.874159872531891*x_87 - 2.22207975387573) - 3.59650295782112e-6*std::sin(1.64415991306305*x_90 + 7.17944002151489) + 2.47016617365017e-6*std::sin(0.255839973688126*x_91 + 7.76056003570557) - 0.000385026985880423*std::sin(0.285119920969009*x_92 + 5.24528026580811) + 1.24164775167682e-5*std::sin(1.87415981292725*x_92 + 7.19328022003174) - 1.5705616692685e-5*std::sin(1.89463984966278*x_92 - 5.60960006713867) - 2.80382556878624e-7*std::sin(0.972719848155975*x_95 + 7.59464025497437) - 5.35235068741934e-7*std::sin(1.46863985061646*x_98 - 8.19791984558105) + 0.0704908477350012);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.76393484575481e-5*x_1 - 3.3996153898563e-6*x_10 + 1.69034826770139e-5*x_100 - 2.49888235782423e-6*x_101 + 3.12627810480156e-6*x_102 + 3.98155197197966e-6*x_103 + 1.35909263093073e-6*x_104 + 4.04720981929224e-6*x_105 - 6.57554192687897e-6*x_106 + 2.69903553906393e-6*x_107 - 7.34713979825075e-6*x_108 - 4.54893710511312e-6*x_109 - 1.85261062407525e-5*x_11 - 8.80411618686702e-6*x_110 + 8.42823387508583e-7*x_111 - 3.09045988261003e-6*x_112 + 9.16030433388042e-6*x_113 - 4.27267518876643e-6*x_114 - 9.66053848092038e-6*x_115 - 7.46482719739785e-6*x_116 + 6.25703365042916e-7*x_117 + 1.56401329888206e-5*x_118 - 4.08218627788449e-6*x_119 + 2.39409690237994e-6*x_12 + 7.00659513348327e-7*x_120 - 4.22457954220262e-6*x_13 - 7.19919030331931e-7*x_14 + 2.84999613492082e-6*x_15 - 2.0327562481846e-5*x_16 + 1.64858762337203e-5*x_17 + 1.0203361512102e-6*x_18 + 5.8046586418414e-6*x_19 + 2.81010253418036e-5*x_2 - 1.02746907912875e-5*x_20 + 9.77432506902501e-7*x_21 + 2.72991544815092e-6*x_22 + 5.0444288753736e-6*x_23 - 5.71495346963547e-6*x_24 + 4.43598974570617e-8*x_25 + 6.85138388326613e-6*x_26 + 1.43457966743377e-6*x_27 + 8.13965659658666e-6*x_28 - 5.7149718768684e-6*x_29 - 1.87870493453553e-5*x_3 + 5.6281069294215e-6*x_30 + 9.76306677957328e-6*x_31 + 9.75460649987253e-6*x_32 + 1.05892689189594e-5*x_33 - 8.36850733784362e-6*x_34 + 3.44535210715225e-6*x_35 - 6.84885643777105e-6*x_36 - 6.95082903729719e-6*x_37 - 9.6641456656709e-6*x_38 + 1.00920048890243e-5*x_39 - 7.49599136554708e-6*x_4 + 1.63226104352503e-5*x_40 + 3.38913179509853e-6*x_41 + 6.37750088449091e-6*x_42 + 2.28821301579555e-5*x_43 + 7.92855386161725e-7*x_44 - 8.51431139437447e-6*x_45 + 6.18056463882101e-6*x_46 + 1.46573291396719e-5*x_47 - 2.39044076218684e-6*x_48 + 9.04751372786157e-6*x_49 + 7.00770521943716e-6*x_5 - 2.87894809595073e-6*x_50 - 2.17517789682498e-6*x_51 + 1.93175247717018e-5*x_52 + 1.54181208698085e-5*x_53 - 1.11303951280398e-5*x_54 - 7.43636016108126e-6*x_55 + 3.80756977249401e-6*x_56 - 1.92869561916643e-5*x_57 + 8.14325332122962e-6*x_58 - 7.68541172997963e-6*x_59 + 1.25524309332491e-5*x_6 - 2.93182200700346e-7*x_60 - 1.55689596185497e-5*x_61 - 1.51750019520583e-6*x_62 - 8.57059294041954e-7*x_63 - 3.15646609116334e-5*x_64 + 0.000117930357208459*x_65 + 1.66687629280662e-5*x_66 - 4.57014658411594e-6*x_67 + 1.26280773439767e-5*x_68 + 2.93331237733833e-5*x_69 + 4.63081510143468e-6*x_7 - 3.15955746596371e-6*x_70 + 5.73702207406854e-6*x_71 + 6.18250895181351e-6*x_72 + 1.512057886392e-5*x_73 + 4.35572966407185e-6*x_74 - 5.16085702557391e-6*x_75 - 5.50243559103573e-7*x_76 + 5.32500720332182e-7*x_77 - 8.54974082021555e-6*x_78 - 4.98116198244326e-6*x_79 - 7.34984001623256e-6*x_8 - 8.85338780643702e-6*x_80 - 1.22385960327542e-7*x_81 + 1.4856888396144e-5*x_82 - 8.50243186124785e-6*x_83 + 1.60200642888715e-6*x_84 + 1.14743245818218e-5*x_85 + 6.90947577998637e-6*x_86 + 1.82275111897757e-6*x_87 + 7.39206980625374e-7*x_88 + 1.69137572500839e-5*x_89 - 2.36626090863162e-5*x_9 + 8.30823073429309e-6*x_90 - 1.56881072723611e-5*x_91 + 2.84130537291664e-7*x_92 + 3.10413196285691e-5*x_93 - 2.16006590535076e-5*x_94 + 3.1581687271584e-7*x_95 + 2.39746530246259e-6*x_96 + 9.99195989703077e-6*x_97 - 2.07413814509672e-5*x_98 + 1.00525450160853e-6*x_99 + 4.55458258320462e-6*std::sin(0.670719861984253*x_1 - 3.32943987846375) + 0.000227555316713363*std::sin(0.701119899749756*x_1 + 1.60103988647461) - 4.13704488382623e-6*std::sin(1.61799991130829*x_105 + 1.007199883461) + 1.85559977875753e-6*std::sin(1.96023988723755*x_108 + 0.77023983001709) + 2.35025159116693e-5*std::sin(1.13239991664886*x_117 + 1.01463985443115) + 3.30297209663629e-5*std::sin(1.17567980289459*x_12 + 4.21504020690918) - 2.80624497330196e-6*std::sin(1.87639987468719*x_14 + 0.768719851970673) - 3.55067310165857e-5*std::sin(2.1833598613739*x_18 - 4.80199956893921) - 6.79122049832176e-6*std::sin(0.870799839496613*x_20 + 1.14535987377167) - 2.14637641343049e-5*std::sin(1.74535989761353*x_25 - 8.78991985321045) - 6.28662408012538e-5*std::sin(1.72271990776062*x_27 - 3.17679977416992) - 2.26107687246109e-6*std::sin(1.64095985889435*x_29 - 2.00951981544495) + 5.60676623887056e-6*std::sin(1.84607982635498*x_29 + 0.777919828891754) - 3.91928792665239e-6*std::sin(1.39055991172791*x_36 + 9.79512023925781) - 1.18344094602334e-6*std::sin(1.49111998081207*x_43 + 6.57128047943115) - 3.44857608646385e-6*std::sin(0.909519791603088*x_54 - 8.36359977722168) + 1.73075513917568e-6*std::sin(1.82759988307953*x_55 + 7.39031982421875) - 3.43850410166859e-6*std::sin(1.14431989192963*x_57 + 4.40703964233398) + 2.42255642921992e-5*std::sin(1.82799994945526*x_66 - 7.59944009780884) - 2.9636489590809e-6*std::sin(0.662799835205078*x_67 - 1.82927989959717) + 1.15526916544646e-6*std::sin(1.29015982151031*x_75 - 2.24439978599548) - 6.48838138536592e-6*std::sin(1.79999983310699*x_80 + 10.0) + 1.53453693350194e-6*std::sin(2.02975988388062*x_80 + 4.20175981521606) + 1.6088444769528e-5*std::sin(1.31343984603882*x_81 + 0.630799829959869) - 1.56199823918615e-5*std::sin(1.73103988170624*x_83 - 1.99575984477997) - 0.000120635602104955*std::sin(0.549839854240417*x_84 - 4.0252799987793) - 3.02411580137596e-6*std::sin(1.47151982784271*x_84 - 2.02431988716125) - 2.38641016550676e-5*std::sin(1.16479980945587*x_86 - 1.57279980182648) + 1.98225450226449e-6*std::sin(1.36223995685577*x_86 + 1.20127987861633) + 2.19489499825712e-6*std::sin(0.874159872531891*x_87 - 2.22207975387573) + 6.10639334642119e-7*std::sin(1.64415991306305*x_90 + 7.17944002151489) - 1.51012215872377e-5*std::sin(0.255839973688126*x_91 + 7.76056003570557) + 0.00092820498593046*std::sin(0.285119920969009*x_92 + 5.24528026580811) + 3.67829664244888e-5*std::sin(1.87415981292725*x_92 + 7.19328022003174) + 1.51699864184602e-6*std::sin(1.89463984966278*x_92 - 5.60960006713867) + 1.71410294812822e-6*std::sin(0.972719848155975*x_95 + 7.59464025497437) + 3.2721294059292e-6*std::sin(1.46863985061646*x_98 - 8.19791984558105) + 0.0607871166924897);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-2.21410886754495e-6*x_1 - 1.88889211634613e-6*x_10 - 1.12133615780217e-6*x_100 + 7.48865291264659e-6*x_101 - 3.92228499366522e-6*x_102 + 1.44190556572199e-5*x_103 + 3.41003524879796e-6*x_104 + 1.08998286103469e-6*x_105 - 9.76531748966383e-6*x_106 - 2.63272396803474e-5*x_107 - 8.46876223815332e-6*x_108 + 3.02970268874943e-6*x_109 - 1.95477381017365e-5*x_11 - 1.31541773060469e-5*x_110 + 2.54068657451831e-6*x_111 - 1.0569789855025e-6*x_112 + 2.46241741433535e-5*x_113 + 1.43681194097986e-6*x_114 - 3.80512251615162e-6*x_115 + 6.99564394781626e-6*x_116 - 1.95786828392909e-5*x_117 + 7.95005154924885e-6*x_118 + 4.42291845355477e-6*x_119 - 5.77295139663478e-6*x_12 - 4.46410231425615e-6*x_120 - 1.84936721967171e-5*x_13 - 2.03014800162638e-5*x_14 - 3.63843631510434e-6*x_15 - 2.19402053284822e-5*x_16 + 7.74549551147634e-6*x_17 - 9.98736502837308e-6*x_18 + 4.1636770225092e-6*x_19 + 3.21252962878186e-5*x_2 - 1.67027686595942e-5*x_20 - 4.77106651101312e-6*x_21 + 8.65293833942432e-6*x_22 - 2.16852129023689e-5*x_23 - 1.61398048007902e-5*x_24 + 1.39377423171783e-5*x_25 - 1.43450726172402e-5*x_26 - 2.13218078123771e-6*x_27 + 1.36669442483156e-5*x_28 - 6.42650780350247e-6*x_29 - 1.10795107669151e-5*x_3 + 9.5036873840925e-6*x_30 + 1.51640097725761e-5*x_31 - 2.65413195939079e-6*x_32 + 1.18219383132515e-5*x_33 + 5.63429110077405e-6*x_34 - 8.66054609345673e-6*x_35 - 2.71798571583673e-6*x_36 + 4.31140562004139e-6*x_37 - 6.39762694097811e-6*x_38 - 7.83571522805258e-6*x_39 - 1.42647749186602e-5*x_4 + 1.71677330444994e-7*x_40 + 3.63883396054522e-6*x_41 + 1.05993019823573e-5*x_42 + 2.92655975328124e-5*x_43 - 3.61428535199141e-6*x_44 - 5.10335157799571e-6*x_45 + 7.9651822249778e-6*x_46 + 1.40910522086666e-5*x_47 - 7.1139932114273e-7*x_48 - 2.8930204825689e-6*x_49 - 9.4907403198636e-7*x_5 + 2.17623091850794e-5*x_50 - 9.95899329800935e-6*x_51 + 1.54215023431143e-5*x_52 + 2.79725612353456e-6*x_53 - 2.33281141529643e-5*x_54 - 9.04810612878871e-6*x_55 + 8.32666181928657e-6*x_56 - 9.29305656642313e-6*x_57 - 1.28967606224758e-5*x_58 + 6.42006118669938e-6*x_59 + 1.74654483085976e-6*x_6 + 8.3321208114338e-6*x_60 - 1.02531449932984e-5*x_61 + 1.34380564709079e-6*x_62 + 6.98013504944145e-6*x_63 - 1.8459660445516e-5*x_64 + 5.69488020637658e-5*x_65 + 1.96906156464447e-5*x_66 - 2.585437458805e-6*x_67 + 7.79448737314706e-6*x_68 + 4.17397336451498e-5*x_69 + 9.0207886508828e-6*x_7 - 1.68112481717574e-5*x_70 + 3.99061924102156e-6*x_71 - 9.6899187738981e-6*x_72 + 6.87627504618857e-6*x_73 + 6.00046230874737e-6*x_74 - 1.50210449228757e-6*x_75 + 1.35197005158947e-5*x_76 + 3.62382944993843e-6*x_77 - 5.5287499913131e-6*x_78 - 9.70193294836904e-6*x_79 - 1.89767603902433e-5*x_8 - 8.10975810435495e-6*x_80 - 1.54281239610247e-6*x_81 + 1.13178034239411e-5*x_82 + 4.4827302713338e-6*x_83 + 4.5618316710477e-6*x_84 + 1.12712708266667e-5*x_85 + 8.57502574229151e-6*x_86 - 7.05348770364875e-6*x_87 + 2.21385906190116e-6*x_88 + 1.32666165158041e-5*x_89 - 1.35377515207535e-5*x_9 + 1.34647756086901e-5*x_90 - 2.72433115345578e-5*x_91 + 2.36445666197878e-6*x_92 + 4.26687687981239e-5*x_93 - 1.93099669805683e-6*x_94 - 4.28627614591107e-7*x_95 + 1.54448275140492e-6*x_96 + 1.15770946478039e-5*x_97 - 2.65144378179743e-5*x_98 - 4.02814308480889e-7*x_99 - 1.45119534080451e-5*std::sin(0.670719861984253*x_1 - 3.32943987846375) + 0.000202232542563973*std::sin(0.701119899749756*x_1 + 1.60103988647461) - 7.1825696781459e-5*std::sin(1.61799991130829*x_105 + 1.007199883461) - 5.91237002323957e-6*std::sin(1.96023988723755*x_108 + 0.77023983001709) + 7.63465487848765e-6*std::sin(1.13239991664886*x_117 + 1.01463985443115) + 2.9354112871026e-5*std::sin(1.17567980289459*x_12 + 4.21504020690918) + 8.94134546034845e-6*std::sin(1.87639987468719*x_14 + 0.768719851970673) - 3.15554766872978e-5*std::sin(2.1833598613739*x_18 - 4.80199956893921) + 2.16383990530397e-5*std::sin(0.870799839496613*x_20 + 1.14535987377167) - 1.90752369866249e-5*std::sin(1.74535989761353*x_25 - 8.78991985321045) - 5.58703699052263e-5*std::sin(1.72271990776062*x_27 - 3.17679977416992) - 3.92559003833573e-5*std::sin(1.64095985889435*x_29 - 2.00951981544495) + 1.82132523083962e-6*std::sin(1.84607982635498*x_29 + 0.777919828891754) - 1.27315776752894e-6*std::sin(1.39055991172791*x_36 + 9.79512023925781) + 3.77071653793128e-6*std::sin(1.49111998081207*x_43 + 6.57128047943115) + 1.0987960933107e-5*std::sin(0.909519791603088*x_54 - 8.36359977722168) - 1.61981326542447e-5*std::sin(1.82759988307953*x_55 + 7.39031982421875) + 1.09558692602906e-5*std::sin(1.14431989192963*x_57 + 4.40703964233398) + 7.86953291735556e-6*std::sin(1.82799994945526*x_66 - 7.59944009780884) + 2.77367825714912e-5*std::sin(0.662799835205078*x_67 - 1.82927989959717) + 2.00573150904717e-5*std::sin(1.29015982151031*x_75 - 2.24439978599548) - 2.10771275651713e-6*std::sin(1.79999983310699*x_80 + 10.0) + 2.66420083853965e-5*std::sin(2.02975988388062*x_80 + 4.20175981521606) + 5.22623721684065e-6*std::sin(1.31343984603882*x_81 + 0.630799829959869) - 5.07405995247963e-6*std::sin(1.73103988170624*x_83 - 1.99575984477997) - 3.91877700068952e-5*std::sin(0.549839854240417*x_84 - 4.0252799987793) - 5.25034730541184e-5*std::sin(1.47151982784271*x_84 - 2.02431988716125) - 2.12084605335262e-5*std::sin(1.16479980945587*x_86 - 1.57279980182648) - 6.31592126264834e-6*std::sin(1.36223995685577*x_86 + 1.20127987861633) - 6.99344305836413e-6*std::sin(0.874159872531891*x_87 - 2.22207975387573) - 5.71497187704078e-6*std::sin(1.64415991306305*x_90 + 7.17944002151489) - 0.000262181289595145*std::sin(0.255839973688126*x_91 + 7.76056003570557) + 0.000301521962614734*std::sin(0.285119920969009*x_92 + 5.24528026580811) + 3.2689690271837e-5*std::sin(1.87415981292725*x_92 + 7.19328022003174) - 4.83350849575497e-6*std::sin(1.89463984966278*x_92 - 5.60960006713867) + 2.97595607642032e-5*std::sin(0.972719848155975*x_95 + 7.59464025497437) + 5.68093847516106e-5*std::sin(1.46863985061646*x_98 - 8.19791984558105) + 0.0331436889073773);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.13177646507391e-5*x_1 + 4.28247940349548e-6*x_10 + 4.70700386684336e-6*x_100 - 6.95579914380051e-6*x_101 + 3.67725692651065e-7*x_102 + 3.27484261910792e-6*x_103 + 5.86810028476105e-7*x_104 + 8.86920118023787e-6*x_105 + 5.58061205756912e-6*x_106 + 3.30699920030366e-6*x_107 + 2.23655180458934e-6*x_108 - 5.02584534378237e-6*x_109 + 2.88673165841999e-7*x_11 - 4.35658542618601e-6*x_110 + 1.76993227486148e-6*x_111 - 3.61496417506034e-6*x_112 + 1.037482598175e-6*x_113 - 6.07798116385863e-6*x_114 - 4.50437954011438e-6*x_115 - 5.33429808657041e-6*x_116 + 3.50624350969572e-6*x_117 + 4.58538135796316e-6*x_118 + 2.97623474117673e-6*x_119 - 6.85209303500595e-6*x_12 + 6.08517163832358e-6*x_120 + 4.58440944549619e-6*x_13 + 1.09326706817014e-5*x_14 + 7.42505852920582e-6*x_15 + 6.96490705373331e-7*x_16 + 9.90129075691153e-6*x_17 + 6.79184748447535e-6*x_18 - 3.67347170080234e-6*x_19 - 6.0395572495058e-6*x_2 - 9.375490432988e-7*x_20 + 4.20793047094648e-6*x_21 - 7.4418956746227e-6*x_22 + 1.20529161717783e-5*x_23 - 1.72028666367533e-6*x_24 - 1.36976426926013e-7*x_25 + 6.41751851125719e-6*x_26 + 5.49588490962638e-6*x_27 + 6.77254128597847e-7*x_28 + 1.54493418061195e-6*x_29 - 2.16531018126069e-7*x_3 + 3.74260809979247e-6*x_30 - 2.51523627723904e-6*x_31 + 5.36175188788394e-6*x_32 + 3.65659951986362e-6*x_33 - 7.4250397909069e-6*x_34 + 7.89569070981966e-6*x_35 - 2.5096684575755e-6*x_36 + 1.48398217116477e-5*x_37 + 3.06785855160962e-6*x_38 + 4.12882080618887e-7*x_39 + 1.87709889080869e-6*x_4 + 1.14365876715242e-6*x_40 + 2.09253103266432e-6*x_41 + 6.9327279755326e-6*x_42 - 3.56170489243896e-6*x_43 + 8.30474193369467e-6*x_44 - 2.6306844485863e-6*x_45 + 4.66411956142642e-7*x_46 - 7.20352157055442e-6*x_47 + 4.71813461745465e-6*x_48 + 7.55588364503925e-6*x_49 + 2.23672814946124e-6*x_5 - 1.88917928375791e-5*x_50 + 4.23609375572335e-6*x_51 + 9.17972776101034e-6*x_52 + 1.23143300874253e-5*x_53 + 2.19959824025601e-5*x_54 - 1.8838356755705e-6*x_55 - 5.08647587880853e-6*x_56 - 7.18997616760996e-6*x_57 - 4.45044977942735e-6*x_58 - 1.2080231229019e-6*x_59 - 6.92312974131947e-7*x_6 - 1.01873799711281e-6*x_60 - 2.83113056211254e-6*x_61 - 8.66222371919104e-6*x_62 - 7.82914099142804e-6*x_63 - 3.87973908518698e-6*x_64 + 2.89058658379842e-5*x_65 + 2.91691846281004e-6*x_66 + 3.25959737936227e-6*x_67 + 3.85607529168361e-6*x_68 - 2.26730968044734e-6*x_69 - 2.40498825258916e-6*x_7 + 8.48309236487755e-6*x_70 - 4.17618222122087e-6*x_71 + 9.60306915494149e-6*x_72 + 2.83611846362916e-6*x_73 + 7.39766888511129e-6*x_74 - 7.88317020964968e-6*x_75 - 8.50183685159185e-6*x_76 + 5.45290576102902e-6*x_77 - 3.06026233630176e-6*x_78 + 6.17318458481032e-7*x_79 + 2.33952223438942e-5*x_8 + 5.10579236802296e-7*x_80 + 1.87412436546755e-6*x_81 + 4.07665968304069e-6*x_82 + 2.06263995787415e-5*x_83 - 4.51346866323908e-6*x_84 - 1.77245752385029e-6*x_85 + 2.19455905226833e-6*x_86 + 1.63334826187105e-7*x_87 + 1.76686350820865e-6*x_88 + 8.27132114969028e-6*x_89 + 3.11224372124588e-5*x_9 + 1.20543705797709e-6*x_90 + 6.71276944480244e-6*x_91 + 1.62668924491609e-6*x_92 + 6.53357359132015e-6*x_93 - 1.08501839231696e-5*x_94 - 6.6554538919594e-7*x_95 - 2.43637872030951e-6*x_96 + 3.70927224185847e-6*x_97 + 8.67478723165738e-6*x_98 + 2.33521521099117e-6*x_99 - 6.67641310536995e-6*std::sin(0.670719861984253*x_1 - 3.32943987846375) + 9.4586211382601e-6*std::sin(0.701119899749756*x_1 + 1.60103988647461) + 6.4961784110144e-6*std::sin(1.61799991130829*x_105 + 1.007199883461) - 2.72006280595347e-6*std::sin(1.96023988723755*x_108 + 0.77023983001709) + 1.19366965243766e-5*std::sin(1.13239991664886*x_117 + 1.01463985443115) + 1.37292163257518e-6*std::sin(1.17567980289459*x_12 + 4.21504020690918) + 4.11358239187955e-6*std::sin(1.87639987468719*x_14 + 0.768719851970673) - 1.47588165108458e-6*std::sin(2.1833598613739*x_18 - 4.80199956893921) + 9.95502720790506e-6*std::sin(0.870799839496613*x_20 + 1.14535987377167) - 8.92168181695767e-7*std::sin(1.74535989761353*x_25 - 8.78991985321045) - 2.61311386925186e-6*std::sin(1.72271990776062*x_27 - 3.17679977416992) + 3.55044704057958e-6*std::sin(1.64095985889435*x_29 - 2.00951981544495) + 2.84762139202673e-6*std::sin(1.84607982635498*x_29 + 0.777919828891754) - 1.9905677650823e-6*std::sin(1.39055991172791*x_36 + 9.79512023925781) + 1.73476723654056e-6*std::sin(1.49111998081207*x_43 + 6.57128047943115) + 5.05515448626093e-6*std::sin(0.909519791603088*x_54 - 8.36359977722168) + 3.4604583374079e-5*std::sin(1.82759988307953*x_55 + 7.39031982421875) + 5.04039029436062e-6*std::sin(1.14431989192963*x_57 + 4.40703964233398) + 1.23039256807471e-5*std::sin(1.82799994945526*x_66 - 7.59944009780884) - 5.92549663292421e-5*std::sin(0.662799835205078*x_67 - 1.82927989959717) - 1.81405685029526e-6*std::sin(1.29015982151031*x_75 - 2.24439978599548) - 3.29538504824805e-6*std::sin(1.79999983310699*x_80 + 10.0) - 2.40960056713231e-6*std::sin(2.02975988388062*x_80 + 4.20175981521606) + 8.17116275911964e-6*std::sin(1.31343984603882*x_81 + 0.630799829959869) - 7.93323532801784e-6*std::sin(1.73103988170624*x_83 - 1.99575984477997) - 6.12696350371291e-5*std::sin(0.549839854240417*x_84 - 4.0252799987793) + 4.74860590904123e-6*std::sin(1.47151982784271*x_84 - 2.02431988716125) - 9.91941210692682e-7*std::sin(1.16479980945587*x_86 - 1.57279980182648) - 2.90572180772393e-6*std::sin(1.36223995685577*x_86 + 1.20127987861633) - 3.2174245309137e-6*std::sin(0.874159872531891*x_87 - 2.22207975387573) + 1.22090752694108e-5*std::sin(1.64415991306305*x_90 + 7.17944002151489) + 2.37126336333649e-5*std::sin(0.255839973688126*x_91 + 7.76056003570557) + 0.000471426177142334*std::sin(0.285119920969009*x_92 + 5.24528026580811) + 1.52892997085552e-6*std::sin(1.87415981292725*x_92 + 7.19328022003174) - 2.22371851387598e-6*std::sin(1.89463984966278*x_92 - 5.60960006713867) - 2.69156339333407e-6*std::sin(0.972719848155975*x_95 + 7.59464025497437) - 5.13804829334685e-6*std::sin(1.46863985061646*x_98 - 8.19791984558105) + 0.0650651148117067);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-3.31222931088177e-6*x_1 - 3.97872016343297e-6*x_10 + 9.2466257012905e-6*x_100 + 5.45835632081594e-6*x_101 - 1.27734142461207e-6*x_102 + 7.86270953344222e-6*x_103 + 1.30890764458201e-6*x_104 - 1.71808677148363e-7*x_105 - 1.20473473664073e-5*x_106 - 8.33725498283435e-6*x_107 - 6.77949207966658e-6*x_108 - 1.60880320132916e-6*x_109 - 1.24390428586129e-5*x_11 - 7.06320662997165e-6*x_110 - 2.93607241764921e-6*x_111 - 2.95124652007325e-6*x_112 + 1.39344172317228e-5*x_113 - 3.6587058899637e-7*x_114 - 3.73583888495636e-6*x_115 + 4.88960101592152e-6*x_116 - 7.87032902842219e-6*x_117 + 5.39191372856743e-6*x_118 - 1.26605299303354e-6*x_119 + 4.15683434648403e-6*x_12 - 1.8029137979638e-6*x_120 - 1.06131374366545e-5*x_13 - 1.04274449214452e-5*x_14 - 4.41028341441222e-6*x_15 - 1.47271800794528e-5*x_16 + 2.58957726556418e-6*x_17 - 2.64908629965113e-6*x_18 - 9.70812129992458e-7*x_19 + 2.55847016263965e-5*x_2 - 9.31073789887052e-6*x_20 - 2.52741128534858e-6*x_21 - 2.36923182773287e-6*x_22 - 5.66451354074103e-6*x_23 - 5.46045237888995e-6*x_24 - 1.6126688947381e-6*x_25 - 4.38041398926629e-6*x_26 - 1.01060333199048e-6*x_27 + 7.5604013362191e-6*x_28 - 5.78507676292086e-6*x_29 - 8.25108245582086e-6*x_3 + 5.33159813003987e-6*x_30 + 1.45550092695952e-5*x_31 + 4.36884286475143e-6*x_32 + 7.7874876658292e-6*x_33 - 4.63997001838493e-7*x_34 - 9.52497054112681e-6*x_35 - 1.82399110239655e-6*x_36 - 7.2349191687423e-6*x_37 - 6.54534876122763e-6*x_38 + 3.11801539825603e-8*x_39 - 1.0287004852546e-5*x_4 + 7.70551224637308e-6*x_40 - 5.83075032797188e-6*x_41 + 1.09491183481427e-6*x_42 + 2.05168621184419e-5*x_43 - 3.28744337943143e-6*x_44 - 4.1923557601223e-6*x_45 + 2.84269816595945e-6*x_46 + 9.94034489982761e-6*x_47 - 3.16379730821308e-6*x_48 + 2.6515118095835e-7*x_49 + 2.43275989643054e-6*x_5 + 1.04768064739826e-5*x_50 - 7.12472437178967e-6*x_51 + 5.98893884200119e-6*x_52 - 1.58314442228207e-6*x_53 - 2.31846762005027e-5*x_54 - 6.89962150782327e-6*x_55 + 1.09029564898445e-6*x_56 - 9.04546705608686e-6*x_57 - 3.1401758491713e-6*x_58 - 1.05961298272869e-6*x_59 + 7.80485439762289e-6*x_6 + 6.03693552566045e-6*x_60 - 1.04190029455207e-5*x_61 + 7.90893089318565e-6*x_62 + 1.91213256858582e-6*x_63 - 2.0628789062674e-5*x_64 + 3.02486090233961e-5*x_65 + 1.11626602199917e-5*x_66 - 1.54533613604359e-7*x_67 + 5.04511350858997e-6*x_68 + 2.35876105209378e-5*x_69 + 6.18192270326962e-6*x_7 - 5.38878288429085e-6*x_70 + 6.74565330428306e-6*x_71 - 4.10104047734515e-6*x_72 + 5.77515363782378e-6*x_73 - 3.19706189027509e-6*x_74 + 2.2691265356449e-8*x_75 + 1.05901711592621e-5*x_76 - 2.62444317207357e-6*x_77 - 3.36733164937568e-6*x_78 - 4.32833100467257e-6*x_79 - 1.49982534781989e-5*x_8 - 6.66508410098115e-6*x_80 - 2.68760529068918e-6*x_81 + 6.3774841298013e-6*x_82 - 6.55813618679496e-6*x_83 + 5.02188618345953e-6*x_84 + 1.00541686849033e-5*x_85 + 2.07525941286033e-6*x_86 - 2.28031587191449e-6*x_87 - 2.01022329858259e-6*x_88 + 2.67325089611669e-6*x_89 - 2.27123683709716e-5*x_9 + 1.04920378553241e-5*x_90 - 2.78943571585301e-5*x_91 - 1.68008724636181e-7*x_92 + 2.31409408367773e-5*x_93 - 4.1479659605075e-6*x_94 - 8.13761908826116e-7*x_95 + 1.87936088259339e-6*x_96 + 4.85229700978056e-6*x_97 - 2.50243572767344e-5*x_98 - 2.06040808191617e-6*x_99 - 2.05159888881288e-5*std::sin(0.670719861984253*x_1 - 3.32943987846375) + 0.000164027441679476*std::sin(0.701119899749756*x_1 + 1.60103988647461) - 2.12012122070574e-5*std::sin(1.61799991130829*x_105 + 1.007199883461) - 8.35849690862733e-6*std::sin(1.96023988723755*x_108 + 0.77023983001709) - 3.26663450964992e-7*std::sin(1.13239991664886*x_117 + 1.01463985443115) + 2.3808631271507e-5*std::sin(1.17567980289459*x_12 + 4.21504020690918) + 1.264065139623e-5*std::sin(1.87639987468719*x_14 + 0.768719851970673) - 2.55941207402685e-5*std::sin(2.1833598613739*x_18 - 4.80199956893921) + 3.05908613435151e-5*std::sin(0.870799839496613*x_20 + 1.14535987377167) - 1.54716065113806e-5*std::sin(1.74535989761353*x_25 - 8.78991985321045) - 4.53155250141867e-5*std::sin(1.72271990776062*x_27 - 3.17679977416992) - 1.15873943686058e-5*std::sin(1.64095985889435*x_29 - 2.00951981544495) - 7.7928916854135e-8*std::sin(1.84607982635498*x_29 + 0.777919828891754) + 5.44745134630466e-8*std::sin(1.39055991172791*x_36 + 9.79512023925781) + 5.33077638945527e-6*std::sin(1.49111998081207*x_43 + 6.57128047943115) + 1.55340137931978e-5*std::sin(0.909519791603088*x_54 - 8.36359977722168) - 2.03728421020956e-5*std::sin(1.82759988307953*x_55 + 7.39031982421875) + 1.54886448215377e-5*std::sin(1.14431989192963*x_57 + 4.40703964233398) - 3.36713161391153e-7*std::sin(1.82799994945526*x_66 - 7.59944009780884) + 3.48853231301984e-5*std::sin(0.662799835205078*x_67 - 1.82927989959717) + 5.92043533988626e-6*std::sin(1.29015982151031*x_75 - 2.24439978599548) + 9.01825601346908e-8*std::sin(1.79999983310699*x_80 + 10.0) + 7.8640778817589e-6*std::sin(2.02975988388062*x_80 + 4.20175981521606) - 2.2361465082401e-7*std::sin(1.31343984603882*x_81 + 0.630799829959869) + 2.17103452724584e-7*std::sin(1.73103988170624*x_83 - 1.99575984477997) + 1.67672440861015e-6*std::sin(0.549839854240417*x_84 - 4.0252799987793) - 1.54977580964481e-5*std::sin(1.47151982784271*x_84 - 2.02431988716125) - 1.72018285443551e-5*std::sin(1.16479980945587*x_86 - 1.57279980182648) - 8.92900954126238e-6*std::sin(1.36223995685577*x_86 + 1.20127987861633) - 9.88684266279545e-6*std::sin(0.874159872531891*x_87 - 2.22207975387573) - 7.1878791311391e-6*std::sin(1.64415991306305*x_90 + 7.17944002151489) - 7.73895890538929e-5*std::sin(0.255839973688126*x_91 + 7.76056003570557) - 1.29011993884624e-5*std::sin(0.285119920969009*x_92 + 5.24528026580811) + 2.65140624580127e-5*std::sin(1.87415981292725*x_92 + 7.19328022003174) - 6.8332776299165e-6*std::sin(1.89463984966278*x_92 - 5.60960006713867) + 8.78430410317385e-6*std::sin(0.972719848155975*x_95 + 7.59464025497437) + 1.67687593081892e-5*std::sin(1.46863985061646*x_98 - 8.19791984558105) + 0.0756293132278758);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (5.01891470627352e-5*x_1 + 6.09855619301892e-6*x_10 - 3.50593964587725e-6*x_100 - 1.06993555940534e-5*x_101 + 6.17884017580313e-6*x_102 - 2.92688904057783e-6*x_103 + 9.22043369188352e-8*x_104 + 8.72234157764511e-6*x_105 + 2.03617762754506e-5*x_106 + 6.28715154160214e-6*x_107 + 3.14829669841814e-7*x_108 + 8.54080805805257e-6*x_109 - 2.94695072818119e-6*x_11 + 1.04786501146162e-5*x_110 + 1.20422699094683e-5*x_111 + 7.80664394826165e-6*x_112 - 1.46114214535407e-5*x_113 + 9.78031676004654e-9*x_114 - 1.93960542968211e-6*x_115 - 1.70518028075531e-5*x_116 + 7.3120560816235e-6*x_117 + 5.68847366048387e-6*x_118 + 4.91413514380389e-6*x_119 + 1.21062837674979e-6*x_12 - 8.8814567317611e-7*x_120 + 1.76616170614565e-5*x_13 + 7.44195827030835e-6*x_14 + 1.13567354760435e-5*x_15 + 5.44276164531428e-7*x_16 + 2.13554359886222e-5*x_17 + 2.63787471795161e-6*x_18 + 1.89135283174858e-5*x_19 + 3.95952931574417e-6*x_2 + 3.6501177514573e-6*x_20 + 5.12426326705788e-6*x_21 + 2.13059329567351e-5*x_22 - 3.70045262584002e-7*x_23 + 1.38938157608986e-6*x_24 + 5.70464983231479e-6*x_25 + 6.19377379313509e-6*x_26 + 3.20481778233654e-6*x_27 - 1.30326982067489e-7*x_28 + 2.3413489850556e-6*x_29 - 1.39677642208704e-5*x_3 - 1.53897970256441e-6*x_30 - 2.27938690614535e-5*x_31 - 9.78565697448027e-6*x_32 + 3.20177385423191e-7*x_33 + 1.29271802547527e-5*x_34 + 2.80648463418093e-5*x_35 - 3.89911368442493e-6*x_36 + 2.22341314736255e-6*x_37 + 5.40349957497813e-7*x_38 + 8.49171871242924e-6*x_39 + 1.32961165512726e-5*x_4 + 3.18444275711992e-6*x_40 + 3.55543911634827e-5*x_41 + 2.11229660041487e-7*x_42 - 2.33986254328531e-6*x_43 + 1.46121079671709e-5*x_44 - 4.16785039608796e-6*x_45 + 1.28021360974368e-5*x_46 - 2.05546966991008e-6*x_47 + 1.22166463793169e-5*x_48 + 8.14833897422927e-6*x_49 + 4.77285376587037e-6*x_5 + 1.65317857355051e-7*x_50 + 9.28342603785353e-6*x_51 + 1.90538914664695e-5*x_52 + 4.06985947270585e-5*x_53 + 1.94084802894118e-5*x_54 - 1.28992261908288e-7*x_55 + 1.12026320148126e-5*x_56 - 2.67370497683025e-6*x_57 + 1.59816825666442e-5*x_58 - 5.24703800673803e-6*x_59 - 1.46640759671575e-6*x_6 - 7.71307368116597e-6*x_60 - 7.7261595712797e-7*x_61 - 1.61813240838678e-5*x_62 + 1.85801671251476e-5*x_63 + 4.68057140530949e-7*x_64 + 0.00021273204388549*x_65 + 2.3352731501044e-6*x_66 - 1.97291337999582e-6*x_67 + 1.24371653132594e-5*x_68 + 2.05922579293931e-6*x_69 - 2.62115136570209e-6*x_7 - 1.68715698870057e-6*x_70 - 2.3875226175877e-6*x_71 + 1.54821298513698e-5*x_72 + 1.63180256439093e-5*x_73 + 1.51028004396093e-5*x_74 - 4.39664442118032e-6*x_75 - 1.4233402726575e-5*x_76 + 8.49460029941359e-6*x_77 - 5.11267642976924e-6*x_78 + 5.44229216139014e-6*x_79 + 3.20918927508881e-5*x_8 + 4.01802581582195e-7*x_80 + 4.06192556422616e-6*x_81 + 1.15931994329473e-5*x_82 - 3.37681785204787e-6*x_83 - 4.80790417586207e-6*x_84 + 7.14493639835814e-7*x_85 + 1.68914315632687e-5*x_86 + 1.10784833286905e-5*x_87 + 1.18762069803048e-5*x_88 + 2.65001548638327e-5*x_89 - 5.39343693717868e-6*x_9 - 7.37463110815494e-6*x_90 + 1.95397902717972e-5*x_91 + 9.58183800845683e-7*x_92 + 8.80344640679007e-7*x_93 - 6.81605803195262e-6*x_94 + 8.75390116266746e-6*x_95 + 2.50379449816179e-6*x_96 + 1.33285334507286e-5*x_97 + 1.71663866919318e-5*x_98 + 8.53136217278031e-6*x_99 + 4.59617907141054e-5*std::sin(0.670719861984253*x_1 - 3.32943987846375) - 8.10384719265832e-6*std::sin(0.701119899749756*x_1 + 1.60103988647461) + 6.04577003734858e-6*std::sin(1.61799991130829*x_105 + 1.007199883461) + 1.87254676191173e-5*std::sin(1.96023988723755*x_108 + 0.77023983001709) + 6.35001497411191e-5*std::sin(1.13239991664886*x_117 + 1.01463985443115) - 1.17627579699538e-6*std::sin(1.17567980289459*x_12 + 4.21504020690918) - 2.83187409162453e-5*std::sin(1.87639987468719*x_14 + 0.768719851970673) + 1.26448868180778e-6*std::sin(2.1833598613739*x_18 - 4.80199956893921) - 6.85324394793577e-5*std::sin(0.870799839496613*x_20 + 1.14535987377167) + 7.64381457818308e-7*std::sin(1.74535989761353*x_25 - 8.78991985321045) + 2.23883324893681e-6*std::sin(1.72271990776062*x_27 - 3.17679977416992) + 3.3042790667101e-6*std::sin(1.64095985889435*x_29 - 2.00951981544495) + 1.51486120494427e-5*std::sin(1.84607982635498*x_29 + 0.777919828891754) - 1.05893075939762e-5*std::sin(1.39055991172791*x_36 + 9.79512023925781) - 1.19424917849127e-5*std::sin(1.49111998081207*x_43 + 6.57128047943115) - 3.48007154227945e-5*std::sin(0.909519791603088*x_54 - 8.36359977722168) + 2.21993608510018e-5*std::sin(1.82759988307953*x_55 + 7.39031982421875) - 3.46990757118487e-5*std::sin(1.14431989192963*x_57 + 4.40703964233398) + 6.54537142278438e-5*std::sin(1.82799994945526*x_66 - 7.59944009780884) - 3.80129523750354e-5*std::sin(0.662799835205078*x_67 - 1.82927989959717) - 1.68828037927139e-6*std::sin(1.29015982151031*x_75 - 2.24439978599548) - 1.75305993237794e-5*std::sin(1.79999983310699*x_80 + 10.0) - 2.24253245354939e-6*std::sin(2.02975988388062*x_80 + 4.20175981521606) + 4.34684803876466e-5*std::sin(1.31343984603882*x_81 + 0.630799829959869) - 4.2202767761743e-5*std::sin(1.73103988170624*x_83 - 1.99575984477997) - 0.000325938670845501*std::sin(0.549839854240417*x_84 - 4.0252799987793) + 4.41936435664717e-6*std::sin(1.47151982784271*x_84 - 2.02431988716125) + 8.49863830895828e-7*std::sin(1.16479980945587*x_86 - 1.57279980182648) + 2.00035820870043e-5*std::sin(1.36223995685577*x_86 + 1.20127987861633) + 2.21494072632118e-5*std::sin(0.874159872531891*x_87 - 2.22207975387573) + 7.83230546753854e-6*std::sin(1.64415991306305*x_90 + 7.17944002151489) + 2.20685333524938e-5*std::sin(0.255839973688126*x_91 + 7.76056003570557) + 0.00250786578843555*std::sin(0.285119920969009*x_92 + 5.24528026580811) - 1.30993880302175e-6*std::sin(1.87415981292725*x_92 + 7.19328022003174) + 1.53085321906823e-5*std::sin(1.89463984966278*x_92 - 5.60960006713867) - 2.50494556760524e-6*std::sin(0.972719848155975*x_95 + 7.59464025497437) - 4.78180500241459e-6*std::sin(1.46863985061646*x_98 - 8.19791984558105) + 0.0679908543773747);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-2.08127149889219e-6*x_1 - 2.8519531505659e-6*x_10 + 1.61881057357896e-5*x_100 - 8.74653753963545e-7*x_101 - 1.71058595371677e-6*x_102 + 1.24447498911099e-5*x_103 + 3.60580009158677e-6*x_104 + 6.39453256954646e-6*x_105 - 1.32790615232296e-5*x_106 - 1.13315534660496e-5*x_107 - 7.74029194959129e-6*x_108 - 1.12270331580656e-5*x_109 - 2.507318854819e-5*x_11 - 2.57356281040662e-5*x_110 - 1.83704537122568e-7*x_111 - 9.5439805811511e-6*x_112 + 2.81661288861792e-5*x_113 - 8.33906046785396e-6*x_114 - 1.37696755098548e-5*x_115 - 1.8889766832018e-6*x_116 - 9.37527719800104e-6*x_117 + 2.11776606500882e-5*x_118 - 1.76469253325359e-6*x_119 - 1.31066980702434e-5*x_12 + 4.07036826254489e-6*x_120 - 1.85938843831958e-5*x_13 - 3.62790920485278e-6*x_14 + 3.29446081713736e-6*x_15 - 2.90386217581717e-5*x_16 + 1.78857444341776e-5*x_17 - 1.5719249645411e-6*x_18 - 2.98453868644254e-6*x_19 + 2.76254488303489e-5*x_2 - 2.06365308324315e-5*x_20 - 5.39426828164561e-7*x_21 - 5.58999597439882e-6*x_22 + 3.35342931607493e-6*x_23 - 1.77297401436655e-5*x_24 + 1.08514993005071e-5*x_25 + 2.33812856716173e-6*x_26 + 2.72628541418455e-6*x_27 + 1.43805684006393e-5*x_28 - 6.85515625517593e-6*x_29 - 1.55473293145935e-5*x_3 + 1.30857008803789e-5*x_30 + 2.32124477398591e-5*x_31 + 1.63936289717895e-5*x_32 + 1.75184060464057e-5*x_33 - 2.08052121991221e-5*x_34 - 5.54741497152981e-6*x_35 - 8.59348919544176e-6*x_36 + 1.21495399952064e-5*x_37 - 9.12405139036202e-6*x_38 + 1.20574104235141e-6*x_39 - 1.83755252353156e-5*x_4 + 1.13446951203724e-5*x_40 - 8.84355405845348e-6*x_41 + 2.18953572153501e-5*x_42 + 3.08727269106198e-5*x_43 - 3.0894870615227e-6*x_44 - 9.77353928023095e-6*x_45 + 3.04248556275976e-6*x_46 + 1.71292922458426e-5*x_47 - 5.74165814523509e-6*x_48 + 8.89437829392137e-6*x_49 + 3.74432970725908e-6*x_5 - 1.1225437875151e-5*x_50 - 6.56465277004656e-6*x_51 + 2.55770986684802e-5*x_52 + 4.69209677453255e-6*x_53 - 5.32834096519255e-6*x_54 - 1.06132513214102e-5*x_55 - 5.41087748074743e-8*x_56 - 2.65532016866221e-5*x_57 - 1.06677439835767e-5*x_58 - 5.51443346518594e-7*x_59 + 9.49008859992747e-6*x_6 + 3.95042212099831e-6*x_60 - 1.87036897280501e-5*x_61 - 5.58336050547214e-6*x_62 - 1.65253951806357e-5*x_63 - 3.67603122068378e-5*x_64 + 4.04741785332229e-5*x_65 + 2.687112359803e-5*x_66 - 5.16264720066269e-6*x_67 + 1.16272884093953e-5*x_68 + 4.500038615795e-5*x_69 + 6.77719484546501e-6*x_7 - 5.74390287612796e-6*x_70 + 1.59432196458752e-6*x_71 + 4.21188030791751e-7*x_72 + 9.78153813609577e-6*x_73 + 9.86772718107599e-6*x_74 - 1.07707522202266e-5*x_75 + 1.97597320704431e-6*x_76 + 5.01336391263518e-6*x_77 - 1.09469095002333e-5*x_78 - 1.37962516997697e-5*x_79 - 1.58731136512429e-5*x_8 - 1.09457161614334e-5*x_80 + 3.43463026549712e-7*x_81 + 1.70233499661015e-5*x_82 + 1.7118316714959e-5*x_83 + 1.47740548844074e-7*x_84 + 1.1253279410843e-5*x_85 + 3.80590056955448e-6*x_86 - 8.89534930074569e-6*x_87 - 1.80871493681579e-6*x_88 + 1.85691603790331e-5*x_89 + 9.53491879477969e-6*x_9 + 1.61118312504975e-5*x_90 - 1.90969666538385e-5*x_91 + 3.18489333298245e-6*x_92 + 5.5623345587181e-5*x_93 - 2.9239837625393e-5*x_94 - 5.79889586881634e-6*x_95 - 1.21150575618053e-6*x_96 + 1.08210917066596e-5*x_97 - 2.66755284705749e-5*x_98 - 8.94875156414049e-7*x_99 - 1.69721891083114e-5*std::sin(0.670719861984253*x_1 - 3.32943987846375) + 0.000298954309840886*std::sin(0.701119899749756*x_1 + 1.60103988647461) - 4.30406005126776e-5*std::sin(1.61799991130829*x_105 + 1.007199883461) - 6.91470398858256e-6*std::sin(1.96023988723755*x_108 + 0.77023983001709) + 1.76420176759212e-6*std::sin(1.13239991664886*x_117 + 1.01463985443115) + 4.33933057612281e-5*std::sin(1.17567980289459*x_12 + 4.21504020690918) + 1.04571866907764e-5*std::sin(1.87639987468719*x_14 + 0.768719851970673) - 4.66475159494527e-5*std::sin(2.1833598613739*x_18 - 4.80199956893921) + 2.53067929866493e-5*std::sin(0.870799839496613*x_20 + 1.14535987377167) - 2.81983514427895e-5*std::sin(1.74535989761353*x_25 - 8.78991985321045) - 8.25914942462257e-5*std::sin(1.72271990776062*x_27 - 3.17679977416992) - 2.35235800260513e-5*std::sin(1.64095985889435*x_29 - 2.00951981544495) + 4.20868427289522e-7*std::sin(1.84607982635498*x_29 + 0.777919828891754) - 2.94198915294404e-7*std::sin(1.39055991172791*x_36 + 9.79512023925781) + 4.40997241075268e-6*std::sin(1.49111998081207*x_43 + 6.57128047943115) + 1.2850768303049e-5*std::sin(0.909519791603088*x_54 - 8.36359977722168) + 2.21273815277705e-5*std::sin(1.82759988307953*x_55 + 7.39031982421875) + 1.2813236075338e-5*std::sin(1.14431989192963*x_57 + 4.40703964233398) + 1.81847694544029e-6*std::sin(1.82799994945526*x_66 - 7.59944009780884) - 3.78896989802939e-5*std::sin(0.662799835205078*x_67 - 1.82927989959717) + 1.20190812599083e-5*std::sin(1.29015982151031*x_75 - 2.24439978599548) - 4.87046320993696e-7*std::sin(1.79999983310699*x_80 + 10.0) + 1.59648717820342e-5*std::sin(2.02975988388062*x_80 + 4.20175981521606) + 1.20766911963313e-6*std::sin(1.31343984603882*x_81 + 0.630799829959869) - 1.17250428205422e-6*std::sin(1.73103988170624*x_83 - 1.99575984477997) - 9.05543658678818e-6*std::sin(0.549839854240417*x_84 - 4.0252799987793) - 3.14620130470322e-5*std::sin(1.47151982784271*x_84 - 2.02431988716125) - 3.13518319119305e-5*std::sin(1.16479980945587*x_86 - 1.57279980182648) - 7.38666994365117e-6*std::sin(1.36223995685577*x_86 + 1.20127987861633) - 8.17905314104459e-6*std::sin(0.874159872531891*x_87 - 2.22207975387573) + 7.80690995950215e-6*std::sin(1.64415991306305*x_90 + 7.17944002151489) - 0.000157108676323711*std::sin(0.255839973688126*x_91 + 7.76056003570557) + 6.96751310804675e-5*std::sin(0.285119920969009*x_92 + 5.24528026580811) + 4.83241899163579e-5*std::sin(1.87415981292725*x_92 + 7.19328022003174) - 5.65294126434453e-6*std::sin(1.89463984966278*x_92 - 5.60960006713867) + 1.78330238853383e-5*std::sin(0.972719848155975*x_95 + 7.59464025497437) + 3.40422737826645e-5*std::sin(1.46863985061646*x_98 - 8.19791984558105) + 0.0621007689334825);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
