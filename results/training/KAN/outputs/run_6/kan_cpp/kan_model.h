
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000906606237074359*x_1 + 0.00242685120677326*x_10 + 0.0015660577827062*x_101 - 2.83038421321564e-5*x_104 + 0.000569848907696005*x_105 - 0.000113990886384567*x_106 + 0.000476272039057584*x_11 - 0.000868505934755765*x_112 - 0.000311706191854367*x_113 - 1.86713339927282e-5*x_115 - 0.00264784106542296*x_116 + 0.00217867713469554*x_119 + 0.00294576078910163*x_12 - 0.000172318426777443*x_120 - 0.000988754620216391*x_13 + 0.000855123427305107*x_14 + 0.00267123795065862*x_16 + 0.00382334179866118*x_17 + 0.00122023185079498*x_18 - 0.000732951448162074*x_19 - 0.0017543736364894*x_2 - 0.00664343363267537*x_20 + 0.00114794754728343*x_22 - 0.000289068271733042*x_23 - 0.000521671918633997*x_24 + 0.00120716807961983*x_25 - 7.46148724452075e-5*x_27 + 0.000121119735942939*x_28 - 0.00300906383226508*x_29 - 0.00285922309612723*x_3 + 0.00213687378594347*x_30 - 0.0045494516203675*x_31 + 0.00161990608712665*x_35 + 1.22804776951673e-5*x_39 - 0.000465685084156099*x_4 + 4.70371085662143e-5*x_40 + 0.0018848462609693*x_42 - 0.000512545295724662*x_43 + 0.000298826611281977*x_44 + 0.00070867705955478*x_47 - 0.00172705531448415*x_48 - 0.00117834617477972*x_5 + 0.0005274984480594*x_51 - 0.0009578063978871*x_52 - 0.00236814959595456*x_54 + 5.40453700522394e-5*x_56 - 0.00110769374534568*x_58 + 7.86013948746513e-5*x_59 + 0.000296042890679553*x_6 - 0.00419132963099595*x_61 - 0.00178112724023924*x_62 + 0.000373275071733268*x_63 - 0.00172829727256532*x_64 - 6.3470606046214e-5*x_65 - 0.000568339605721756*x_66 + 0.0020629720109055*x_68 - 0.00126638553750771*x_7 + 7.75222496655306e-5*x_70 - 0.00101191038657495*x_72 - 0.000665988140775673*x_73 - 0.00118415628690265*x_74 + 0.0026454462088966*x_76 + 0.000318882439469311*x_78 - 0.000529349760442773*x_79 - 6.27223297691604e-5*x_8 - 0.000266987683750465*x_81 + 0.000185171082434438*x_85 + 0.000283608437984883*x_86 + 1.54252249784034e-5*x_87 + 6.9244785316811e-5*x_88 - 0.000474213837474279*x_90 + 0.00189954763171212*x_91 - 3.97459334613787e-5*x_92 + 0.000251340722582865*x_93 - 0.000521369486404825*x_95 - 0.00141996663681151*x_96 + 0.0016433890725308*x_97 - 0.00114398648022903*x_98 - 0.000202117910782553*x_99 + 3.38100117864202e-5*std::pow(-4.47631978988647*x_100 - 6.92568016052246, 2) + 5.65150088790152e-5*std::pow(-4.37183952331543*x_18 - 6.95983982086182, 2) - 7.94044715001903e-5*std::pow(-3.88375997543335*x_19 - 6.13335990905762, 2) + 1.23613840082107e-5*std::pow(-5.80399990081787*x_22 - 9.99647998809814, 2) + 1.38666132002237e-5*std::pow(-4.18495988845825*x_24 - 7.37408018112183, 2) - 5.03592296872078e-5*std::pow(-5.81879997253418*x_4 - 9.82336044311523, 2) + 2.97502005011016e-5*std::pow(-4.35264015197754*x_55 - 6.33048009872437, 2) - 7.20229767462656e-5*std::pow(-3.86879992485046*x_6 - 6.51087999343872, 2) + 5.54246476137367e-6*std::pow(-5.41200017929077*x_64 - 9.21903991699219, 2) - 7.9234982935637e-6*std::pow(-6.89007997512817*x_66 - 9.33463954925537, 2) - 2.74228812835421e-5*std::pow(-5.21744012832642*x_7 - 9.23895931243896, 2) - 8.10214556821595e-6*std::pow(-6.25472021102905*x_71 - 9.68151950836182, 2) - 2.02882641343013e-5*std::pow(-4.14160013198853*x_71 - 6.69736003875732, 2) - 2.25260331094498e-5*std::pow(-5.3120002746582*x_73 - 7.55503988265991, 2) + 4.79899822685909e-5*std::pow(-1.42991983890533*x_75 - 1.61055982112885, 2) + 1.40334980898142e-5*std::pow(-6.52383947372437*x_77 - 9.1627197265625, 2) - 1.48068896574687e-5*std::pow(-6.66368007659912*x_78 - 9.21712017059326, 2) - 0.000150745120029181*std::pow(-1.82767987251282*x_80 - 2.43895983695984, 2) - 5.88444001929731e-6*std::pow(-8.02295970916748*x_86 - 9.42399978637695, 2) - 3.88686700995943e-5*std::pow(-5.18376016616821*x_87 - 7.56544017791748, 2) + 1.66804196300381e-5*std::pow(-7.48543977737427*x_89 - 9.05047988891602, 2) + 1.42024877757357e-5*std::pow(-5.15536022186279*x_89 - 6.94384002685547, 2) - 0.00165756023488939*std::pow(0.0229794936533373*x_10 - 0.109102693632703*x_100 + 0.0498582397168596*x_101 + 0.0716747843660493*x_103 - 0.122257599313303*x_104 + 0.139090022134787*x_110 - 0.112085476660362*x_111 - 0.230973497145041*x_113 + 0.0600566996424046*x_115 - 0.00138239121850388*x_116 + 0.0351582192559752*x_117 + 0.0218067720087818*x_13 + 0.00634052760062899*x_14 + 0.133991027112826*x_15 + 0.253887833130112*x_16 - 0.055863997853758*x_17 + 0.0430377675778318*x_18 + 0.249963375860227*x_2 - 0.400276006456973*x_20 - 0.0595282556836486*x_21 + 0.0457887267117625*x_22 - 0.179202346728811*x_23 - 0.166328570531133*x_25 - 0.04955458675986*x_28 - 0.031402138975727*x_29 - 0.0745952375986437*x_30 - 0.38825357529319*x_31 - 0.125166371603001*x_32 + 0.0343566083765345*x_34 - 0.288930374518777*x_4 + 0.1877762443842*x_40 + 0.0109754775223988*x_44 + 0.116665491009602*x_48 + 0.0246532033522053*x_5 + 0.0174238308750119*x_52 + 0.0345544795951758*x_54 - 0.151134477811995*x_6 + 0.0527348731171092*x_60 - 0.0217671368362784*x_61 + 0.153646748295398*x_62 - 0.170109681824674*x_63 + 0.0678848472681022*x_65 - 0.175753604610526*x_68 - 0.00829909917848769*x_7 - 0.0650001586010841*x_72 - 0.0130575074750471*x_73 - 0.00664594253242044*x_78 - 0.0944523511809504*x_8 - 0.0279122892893739*x_82 - 0.0589165786708484*x_88 + 0.0408009578240604*x_89 - 0.065871085857069*x_9 - 0.0747576187632103*x_90 - 0.241601296632225*x_91 - 0.376583120920282*x_92 + 0.00349444502221325*x_95 - 0.0811768906469604*x_97 + 0.00116906356413649*std::pow(-4.51200008392334*x_38 - 6.96360015869141, 2) + 0.00136508957590237*std::pow(-6.62088012695313*x_69 - 9.43920040130615, 2) + 0.00178827669046894*std::pow(-3.69936013221741*x_80 - 6.42208003997803, 2) - 0.00155982230490501*std::pow(-7.45847988128662*x_81 - 9.67831993103027, 2) - 0.0123884461827262*std::pow(-1.03719985485077*x_84 - 2.28391981124878, 2) - 0.000878326734448862*std::pow(-6.90776014328003*x_86 - 7.71479988098145, 2) + 1.26628888254103*std::sin(0.364479839801788*x_1 - 4.37279987335205) - 1.05164834076518*std::sin(0.320079833269119*x_102 - 4.26879978179932) + 1.56852098501702*std::sin(0.353279858827591*x_105 - 4.24919986724854) - 0.536055010165413*std::sin(0.452639847993851*x_106 + 2.046719789505) + 0.394776567289874*std::sin(0.382639855146408*x_107 + 5.18391990661621) + 1.5727013873385*std::sin(0.238799974322319*x_108 - 7.55640029907227) - 1.18626851022356*std::sin(0.3643998503685*x_109 + 5.17935991287231) + 0.730918909776008*std::sin(0.300399929285049*x_11 + 8.32439994812012) - 0.118161383359876*std::sin(0.475119858980179*x_112 + 1.8407998085022) - 1.50907765008654*std::sin(0.373439848423004*x_114 - 7.42952013015747) + 0.888902822162763*std::sin(0.372159838676453*x_118 + 1.98983991146088) - 2.18645957978651*std::sin(0.339599847793579*x_119 + 5.15136003494263) + 1.67243143465654*std::sin(0.359199851751328*x_12 + 5.17248010635376) - 1.45050454428755*std::sin(0.371839851140976*x_120 - 7.41567993164063) - 0.149383376187853*std::sin(0.599039852619171*x_19 - 0.798399865627289) + 1.00152467936653*std::sin(0.376079827547073*x_24 + 8.37248039245605) + 2.01973748443663*std::sin(0.338239848613739*x_26 - 4.26504039764404) - 7.3299474281049*std::sin(0.213039994239807*x_27 - 7.5717601776123) - 1.69637609480461*std::sin(0.349679857492447*x_3 - 4.23496007919312) + 1.41225195952728*std::sin(0.218399986624718*x_33 - 7.38711977005005) + 1.45108546150723*std::sin(0.316319853067398*x_35 - 1.20743989944458) - 1.2837611203544*std::sin(0.367839843034744*x_36 + 5.17136001586914) - 1.03856348426689*std::sin(0.403439849615097*x_37 - 4.20223999023438) + 1.08690391556621*std::sin(0.30295991897583*x_39 - 4.30272006988525) - 1.00370558434108*std::sin(0.357199847698212*x_41 - 7.43991994857788) + 1.83045548147419*std::sin(0.303599923849106*x_42 + 5.09543991088867) - 1.19707453373593*std::sin(0.377679854631424*x_43 + 5.18800020217896) + 1.5727418657788*std::sin(0.296639919281006*x_45 + 5.11967945098877) - 2.50207032279491*std::sin(0.290079951286316*x_46 + 5.11967992782593) - 1.34547801345988*std::sin(0.376559853553772*x_47 + 5.1625599861145) - 1.54809427974115*std::sin(0.352319836616516*x_49 - 4.23863983154297) - 0.673752573114612*std::sin(0.350559860467911*x_50 + 5.15431976318359) - 0.58018820640946*std::sin(0.321599841117859*x_51 - 7.47175979614258) + 0.334253673503362*std::sin(0.334159851074219*x_53 - 1.068079829216) - 1.33673524370465*std::sin(0.317279845476151*x_55 - 4.28736019134521) - 0.471809905920928*std::sin(0.342239856719971*x_56 + 5.13784027099609) + 1.20123991431328*std::sin(0.373519837856293*x_57 - 4.21056032180786) + 0.488877961347782*std::sin(0.463439851999283*x_58 - 1.13231992721558) + 0.480429892985086*std::sin(0.307839930057526*x_59 - 7.46871995925903) - 2.06564003573391*std::sin(0.238079980015755*x_64 - 4.35223960876465) + 2.15524852359096*std::sin(0.199680000543594*x_66 + 4.99975967407227) - 0.124940275075591*std::sin(0.343759834766388*x_67 - 4.43192005157471) - 0.467128482564689*std::sin(0.345999836921692*x_70 - 1.06407976150513) - 0.754509698913424*std::sin(0.298959940671921*x_71 + 5.11895942687988) + 1.4809615318616*std::sin(0.33111983537674*x_74 - 4.27975988388062) - 0.91873583400627*std::sin(0.241279974579811*x_75 - 7.54800033569336) + 0.691724083248246*std::sin(0.358159840106964*x_76 - 4.25072002410889) - 6.94576918864755*std::sin(0.144800037145615*x_77 - 7.65912008285522) + 1.65059199741336*std::sin(0.257119983434677*x_79 + 5.05615997314453) + 1.1285538225664*std::sin(0.276319950819016*x_83 + 5.11303997039795) - 0.247956018187665*std::sin(0.50791984796524*x_85 - 0.885199844837189) - 2.10742181300702*std::sin(0.195919990539551*x_87 + 1.79983985424042) + 0.915773683666998*std::sin(0.285359919071198*x_93 + 8.27120018005371) + 1.90774327239708*std::sin(0.390079855918884*x_94 - 7.40775966644287) + 0.651744743266391*std::sin(0.409599870443344*x_96 - 7.38104009628296) - 1.54589835302247*std::sin(0.407839864492416*x_98 + 2.00023984909058) + 0.668316307115688*std::sin(0.42783984541893*x_99 - 1.18479979038239) - 16.4601978505176, 2) + 0.0290427244423249*std::exp(0.0385635642676427*x_1 - 0.0243120147207404*x_101 + 0.0248167356033537*x_104 - 0.00889479455484925*x_106 - 0.0163895061659604*x_107 - 0.0441923172969287*x_111 + 0.0182124002984326*x_113 - 0.00643218642236089*x_114 + 0.0101940567387937*x_116 + 0.0115522578123553*x_119 - 0.0927653302566921*x_12 + 0.00368098491102205*x_13 + 0.00223153789026745*x_15 + 0.0214934267288628*x_16 - 0.00986549655140611*x_19 + 0.0180861883965759*x_2 - 0.0362910494224502*x_20 - 0.0439154196272255*x_22 + 0.00247053320864778*x_26 - 0.111338147207719*x_31 - 0.0246590572591753*x_33 + 0.00187161255719216*x_36 - 0.00535647315554671*x_37 - 0.00548994759605492*x_38 + 0.0193247934417563*x_39 - 0.00127918244321329*x_4 - 0.0112465425096626*x_41 + 0.00299268675283135*x_44 + 0.00848741525039079*x_45 + 0.00682992892652547*x_46 + 0.0201903102983224*x_47 + 0.0169538030326788*x_5 + 0.00363001605460435*x_51 + 0.00795877476085612*x_54 - 0.00829144960922578*x_59 - 0.0127341495737047*x_6 + 0.00858191982814221*x_61 - 0.00563027383755821*x_63 + 0.0281759884740129*x_65 - 0.00851398448704532*x_66 - 0.00661942445295503*x_68 + 0.00880895456155424*x_72 + 0.00410517372961931*x_73 + 0.0026553462042746*x_75 + 0.0158851779407327*x_76 + 0.0190339502558518*x_77 - 0.0069745905885037*x_80 - 0.00303180838471061*x_81 - 0.0269086291519413*x_85 - 0.00363728908864348*x_86 + 0.00890360808186965*x_88 - 0.00660349856688701*x_89 + 0.00406621628165308*x_9 - 0.0119233138517526*x_94 - 0.00323274725374529*x_97 - 0.0212818931306023*x_99 + 0.00120079042338936*std::pow(-3.50639986991882*x_17 - 5.15751981735229, 2) - 0.00886570995105057*std::pow(-0.866319835186005*x_24 - 1.30367994308472, 2) - 0.000579829333623428*std::pow(-6.56744050979614*x_27 - 9.54936027526855, 2) - 8.06934346109988e-5*std::pow(-5.71783971786499*x_43 - 8.27400016784668, 2) - 0.00019801715186981*std::pow(-5.42744016647339*x_60 - 8.43583965301514, 2) + 0.000674908707781079*std::pow(-5.09847974777222*x_7 - 7.94231986999512, 2) - 0.000149879839826313*std::pow(-5.8854398727417*x_71 - 9.54551982879639, 2) - 0.000161378115679794*std::pow(-7.06584024429321*x_78 - 9.41096019744873, 2) + 8.95802904156669e-5*std::pow(-9.20399951934814*x_82 - 9.99767971038818, 2) + 0.000405979715439587*std::pow(-5.88768005371094*x_90 - 8.31655979156494, 2) + 0.0214005108626955*std::exp(0.82207989692688*x_25) + 0.519495505270346*std::sin(0.301679849624634*x_10 + 5.10400009155273) + 0.527730710244199*std::sin(0.208000004291534*x_100 + 5.00311994552612) + 0.253531167441722*std::sin(0.319359838962555*x_102 - 4.27135992050171) - 0.071742877287039*std::sin(0.336479842662811*x_103 - 7.43991994857788) - 0.0949562669021118*std::sin(0.437759846448898*x_105 - 1.18407988548279) + 0.0818803844031581*std::sin(0.301119923591614*x_108 - 4.28095960617065) - 0.143597426429817*std::sin(0.422879844903946*x_109 + 2.01311993598938) + 0.267595863732058*std::sin(0.327679842710495*x_11 - 1.06183981895447) - 0.119660260354522*std::sin(0.384719848632813*x_110 + 8.17407989501953) - 0.225656855642873*std::sin(0.364639848470688*x_112 + 5.16183996200562) - 0.165318782035323*std::sin(0.355759829282761*x_115 - 1.24439990520477) - 0.14664452223016*std::sin(0.478159844875336*x_117 + 2.04239964485168) - 0.290931355439824*std::sin(0.393759846687317*x_118 + 5.18567991256714) - 0.0528242584370773*std::sin(0.426879853010178*x_120 + 2.20191979408264) - 0.086754183623948*std::sin(0.270879954099655*x_14 + 1.8879998922348) + 0.75250335507468*std::sin(0.258959949016571*x_18 + 5.06335973739624) - 0.293762021546025*std::sin(0.325759828090668*x_21 - 4.2579197883606) - 0.455702099120881*std::sin(0.271119952201843*x_23 + 5.0798397064209) + 0.209036869720679*std::sin(0.361359834671021*x_28 + 8.34383964538574) - 0.0567814174624557*std::sin(0.810399830341339*x_29 + 5.61424016952515) + 0.387030840077749*std::sin(0.306319922208786*x_3 + 8.31271934509277) + 0.114573210612251*std::sin(0.330079823732376*x_30 + 8.34352016448975) - 0.579080962129293*std::sin(0.271519958972931*x_32 - 7.43567991256714) - 0.3907977133217*std::sin(0.357199847698212*x_34 - 7.39351987838745) - 0.138125806108076*std::sin(0.272719949483871*x_35 - 1.1399998664856) - 0.346155679720376*std::sin(0.306399941444397*x_40 + 5.12367963790894) + 0.238297683393624*std::sin(0.358479857444763*x_42 + 1.97983980178833) + 0.0639527154935453*std::sin(0.589999854564667*x_48 - 7.40863990783691) + 0.147748961347009*std::sin(0.219999998807907*x_49 - 1.36087989807129) - 0.116566351464479*std::sin(0.428159862756729*x_50 - 1.17399990558624) + 0.504238282185128*std::sin(0.233919993042946*x_52 + 8.23464012145996) + 0.234377754393076*std::sin(0.231279999017715*x_53 - 7.54808044433594) + 0.284086824434848*std::sin(0.198559984564781*x_55 - 4.39231967926025) + 0.298313503671489*std::sin(0.363439828157425*x_56 + 5.15592002868652) - 0.0648161432617362*std::sin(0.319519847631454*x_57 - 7.47119998931885) + 0.157061477712254*std::sin(0.250159978866577*x_58 - 7.52272033691406) + 0.221749953051797*std::sin(0.324959844350815*x_62 + 8.3133602142334) + 0.6945305494895*std::sin(0.206400007009506*x_64 - 4.40303993225098) - 0.574009626062782*std::sin(0.201039999723434*x_67 + 5.00600004196167) + 0.358128535055954*std::sin(0.262479960918427*x_69 + 5.07775974273682) + 1.43106174111468*std::sin(0.13864004611969*x_70 - 7.66880035400391) - 0.198554344941121*std::sin(0.344799846410751*x_74 - 4.25688028335571) + 0.480730076684655*std::sin(0.255679965019226*x_79 + 5.05535984039307) + 0.463902688461175*std::sin(0.266479969024658*x_8 + 5.09807968139648) - 0.171328566146387*std::sin(0.410399854183197*x_83 - 7.39120006561279) + 0.264014767127795*std::sin(0.319039851427078*x_84 - 4.2947998046875) + 0.413719493552165*std::sin(0.242479979991913*x_87 + 5.03991985321045) - 0.942648123342579*std::sin(0.179120019078255*x_91 + 5.2279200553894) - 0.550866014277464*std::sin(0.336719840764999*x_92 + 5.20352029800415) - 0.0521571559674325*std::sin(0.384559839963913*x_93 + 1.77711987495422) - 0.201784019989736*std::sin(0.385119825601578*x_95 - 7.39695978164673) - 0.268892437833918*std::sin(0.383679836988449*x_96 - 7.40807962417603) + 0.232009443838704*std::sin(0.352719843387604*x_98 - 4.2403998374939)) - 0.0372413320538255*std::sin(0.215440005064011*x_1 - 7.3842396736145) - 0.0114360191463049*std::sin(0.414799869060516*x_100 + 5.20456027984619) + 0.0153835395596302*std::sin(0.319119840860367*x_101 + 5.146399974823) - 0.00678862153624714*std::sin(0.322719842195511*x_102 + 5.12976026535034) - 0.0113412443875858*std::sin(0.3503198325634*x_102 - 7.41847991943359) + 0.0095756439936607*std::sin(0.404639840126038*x_103 - 7.39447975158691) + 0.0101953402202024*std::sin(0.442559868097305*x_103 + 5.23320007324219) + 0.0142890456071328*std::sin(0.276479959487915*x_104 - 7.50216007232666) - 0.00644284649981096*std::sin(0.360079854726791*x_106 + 5.16480016708374) + 0.012820192044208*std::sin(0.365039855241776*x_107 - 7.41479969024658) - 0.00470917613114781*std::sin(0.426959842443466*x_107 + 5.22248029708862) - 0.0160092996315078*std::sin(0.211359992623329*x_108 + 5.00783967971802) - 0.00729708849635307*std::sin(0.353679835796356*x_108 - 7.44871950149536) - 0.0119765773560465*std::sin(0.323999851942062*x_109 + 5.12048006057739) - 0.00468393916386191*std::sin(0.359439849853516*x_109 + 5.17456007003784) - 0.0216784466456296*std::sin(0.390239834785461*x_110 + 5.18304014205933) - 0.00700231014384079*std::sin(0.456639856100082*x_110 + 2.05167984962463) - 0.0128404911975287*std::sin(0.480879843235016*x_111 - 7.34032011032104) - 0.00396164937682671*std::sin(0.48431983590126*x_111 + 5.24575996398926) - 0.00916111193544029*std::sin(0.380959838628769*x_112 - 7.40343999862671) - 0.022682758637237*std::sin(0.366319835186005*x_113 - 7.42911958694458) - 0.00539979422774622*std::sin(0.393599838018417*x_114 + 1.99799978733063) + 0.0116928171651494*std::sin(0.44159984588623*x_114 - 7.38136005401611) + 0.013270928965614*std::sin(0.36847984790802*x_115 + 8.36911964416504) + 0.0329861008003408*std::sin(0.306239932775497*x_117 - 4.28335952758789) + 0.0118360369741727*std::sin(0.380719840526581*x_117 + 5.18304014205933) + 0.0088194086871852*std::sin(0.334479838609695*x_118 - 4.26528024673462) + 0.0159720641573709*std::sin(0.365839838981628*x_118 + 5.15880012512207) - 0.0120145126188712*std::sin(0.397039830684662*x_119 + 1.97919988632202) + 0.00707026829032512*std::sin(0.423359870910645*x_12 + 8.41808032989502) + 0.00610324982370595*std::sin(0.4859998524189*x_120 + 2.06983971595764) + 0.0411263443494859*std::sin(0.306239932775497*x_14 + 5.15127992630005) - 0.0116961828904412*std::sin(0.431279867887497*x_15 - 0.968239843845367) - 0.000977825568953863*std::sin(1.49863994121552*x_15 - 2.5971200466156) + 0.0095611359701388*std::sin(0.263439953327179*x_21 - 1.12615990638733) + 0.0285060753278872*std::sin(0.30991992354393*x_21 - 4.27695989608765) - 0.00930276866015818*std::sin(0.310719907283783*x_23 - 4.24408006668091) + 0.0411913535844665*std::sin(0.325119823217392*x_26 - 4.25880002975464) - 0.00536135931504657*std::sin(0.326479852199554*x_26 + 8.31744003295898) - 0.000361809892033438*std::sin(1.74143981933594*x_27 - 1.98255980014801) - 0.00679464155742225*std::sin(0.347439825534821*x_28 + 8.35303974151611) + 0.00058630776163824*std::sin(1.04367983341217*x_29 + 6.00735950469971) + 0.0215616521856795*std::sin(0.338559836149216*x_3 + 8.35519981384277) - 0.0268963593695061*std::sin(0.259839981794357*x_32 + 5.17312002182007) - 0.00982558177497296*std::sin(0.311999946832657*x_32 - 4.44504022598267) - 0.0259334298743129*std::sin(0.279199957847595*x_33 - 1.16039991378784) - 0.0170809495993767*std::sin(0.292239934206009*x_33 + 8.22999954223633) + 0.00852004562875127*std::sin(0.277199953794479*x_34 - 1.12231993675232) - 0.0247360999976672*std::sin(0.386319845914841*x_34 + 1.9748797416687) + 0.013749735009749*std::sin(0.316399842500687*x_35 - 7.42007970809937) + 0.0179344113921587*std::sin(0.343759834766388*x_36 - 7.44807958602905) - 0.0155804734322749*std::sin(0.363919854164124*x_36 - 4.23432016372681) - 0.0163283153003243*std::sin(0.358239859342575*x_37 + 5.17824029922485) - 0.00781006222022778*std::sin(0.450879871845245*x_37 + 2.03239989280701) - 0.0525336660046195*std::sin(0.165120020508766*x_38 - 7.63992023468018) - 0.0101658639428849*std::sin(0.249279975891113*x_38 + 5.06663990020752) + 0.0140160882386125*std::sin(0.271279960870743*x_39 + 8.28528022766113) - 0.0156380976489135*std::sin(0.315039843320847*x_40 - 4.28247976303101) - 0.0215395845034231*std::sin(0.330479830503464*x_41 + 5.14264011383057) - 0.0101219656890943*std::sin(0.365519851446152*x_41 - 7.41623973846436) - 0.0101739620836272*std::sin(0.348079830408096*x_42 - 1.23199987411499) + 0.0105326167047187*std::sin(0.356159836053848*x_43 + 5.15208005905151) + 0.01500850555671*std::sin(0.29351994395256*x_44 - 4.27183961868286) + 0.019304582354639*std::sin(0.220559984445572*x_45 + 8.22208023071289) - 0.00630315056144685*std::sin(0.466559857130051*x_45 + 5.24775981903076) + 0.0325697989003816*std::sin(0.195199996232986*x_46 + 4.97847986221313) + 0.00452368854108741*std::sin(0.439439862966537*x_46 - 4.14663982391357) - 0.00364896358816716*std::sin(0.624079823493958*x_47 - 7.38527965545654) + 0.0057312771172154*std::sin(0.509759843349457*x_48 + 8.27455902099609) + 0.0203809744335123*std::sin(0.326879858970642*x_49 - 4.26919984817505) - 0.00208659351776239*std::sin(0.506479859352112*x_49 + 8.28087997436523) - 0.0266819843024674*std::sin(0.304159939289093*x_50 - 7.47200012207031) + 0.0170601324616233*std::sin(0.375439822673798*x_50 - 4.23304033279419) + 0.0119412817696688*std::sin(0.352479845285416*x_51 + 5.1418399810791) + 0.0923670832729969*std::sin(0.131200045347214*x_53 - 7.68440008163452) - 0.00582853815499296*std::sin(0.295199930667877*x_53 - 4.27360010147095) - 0.0130911246526136*std::sin(0.308479934930801*x_55 - 7.46504020690918) - 0.0172135565323907*std::sin(0.366719841957092*x_57 + 8.35023975372314) - 0.00911549438953327*std::sin(0.41023987531662*x_57 + 5.21224021911621) - 0.0111543285739416*std::sin(0.389519840478897*x_58 + 1.97375977039337) - 0.0123547489130713*std::sin(0.314319908618927*x_59 + 5.13312005996704) - 0.0490924692554406*std::sin(0.228319987654686*x_60 + 5.03671979904175) + 0.01379230411507*std::sin(0.344799846410751*x_60 - 4.26503992080688) + 0.0188911782492812*std::sin(0.196719989180565*x_65 + 5.00432014465332) + 0.0308359536599698*std::sin(0.202800005674362*x_67 - 7.58416032791138) + 0.029075449652844*std::sin(0.225759983062744*x_67 + 5.03471994400024) + 0.0245943398352563*std::sin(0.225199997425079*x_69 + 5.02031993865967) - 0.0424768333626316*std::sin(0.251279979944229*x_69 + 5.05583953857422) - 0.00430454086455065*std::sin(0.365679830312729*x_74 + 1.94711983203888) - 0.000262124129923963*std::sin(0.873279869556427*x_75 + 2.20911979675293) + 0.00843018579329233*std::sin(0.31399992108345*x_77 - 7.46776008605957) + 0.0170334623622666*std::sin(0.255599975585938*x_79 + 5.07967948913574) - 0.00156931535676587*std::sin(0.474159836769104*x_80 + 8.48776054382324) + 0.0118882191320827*std::sin(0.275119960308075*x_82 - 7.49600028991699) + 0.0121389108073569*std::sin(0.326799839735031*x_82 + 5.12800025939941) + 0.0119430941642464*std::sin(0.270079970359802*x_83 + 5.10271978378296) + 0.00736363532552138*std::sin(0.510559856891632*x_83 + 8.3342399597168) + 0.0321342308977452*std::sin(0.234959989786148*x_84 + 5.02799987792969) + 0.00721837036542685*std::sin(0.305039942264557*x_84 + 5.14831972122192) + 0.0180545126205581*std::sin(0.265119940042496*x_85 + 5.06559991836548) + 0.0770331156947267*std::sin(0.148960039019585*x_88 - 7.65576028823853) + 0.128347647701909*std::sin(0.12216005474329*x_9 + 8.07327938079834) + 0.00589483198414746*std::sin(0.497999846935272*x_9 + 2.30663990974426) + 0.00507102199970126*std::sin(0.446799844503403*x_90 - 4.16096019744873) + 0.0246600205182022*std::sin(0.168240025639534*x_91 + 5.22959995269775) + 0.0146024670440753*std::sin(0.324799835681915*x_92 + 2.19455981254578) - 0.0116849440933418*std::sin(0.394639849662781*x_93 + 1.99383985996246) - 0.0112195034180295*std::sin(0.343359857797623*x_94 + 1.96759986877441) + 0.00696791632130132*std::sin(0.370159834623337*x_94 - 7.40679979324341) + 0.00972614013204987*std::sin(0.367199838161469*x_95 + 5.17216014862061) + 0.00536255412996502*std::sin(0.368079841136932*x_96 + 5.16943979263306) - 0.0151119960346676*std::sin(0.345919847488403*x_97 + 5.16247987747192) + 0.00400581053423388*std::sin(0.444959849119186*x_98 + 2.03095984458923) + 0.00877162798603727*std::sin(0.310319930315018*x_99 - 7.48432016372681) + 0.0283401813358068*std::sin(-0.0363348449486668*x_1 + 0.0397663401112194*x_10 + 0.0219307876980015*x_101 + 0.00765362625358198*x_102 + 0.00288414148891757*x_103 - 0.00605213508437886*x_105 - 0.0112260951103309*x_11 + 0.00376715535253694*x_111 - 0.0270496708523722*x_113 + 0.0244927009810666*x_119 + 0.0371035135189555*x_12 + 0.00613892343451126*x_15 - 0.0210715683386351*x_17 - 0.050683499240417*x_19 + 0.0812243773271331*x_2 + 0.134081678499579*x_20 + 0.0682072383937608*x_22 + 0.00675423588299622*x_25 + 0.0166611897852435*x_29 + 0.0333651112037123*x_3 - 0.0383912401900823*x_33 - 0.00726308949230868*x_37 - 0.0524758244169886*x_41 + 0.01185114002694*x_43 + 0.0117330069282759*x_44 - 0.0483839695420452*x_47 + 0.00670468906603434*x_48 + 0.00935043869163092*x_53 + 0.00979893459928107*x_54 + 0.00809253589321823*x_55 - 0.0411150964379958*x_6 - 0.00697999238943698*x_60 + 0.0442240345767805*x_61 - 0.0405771182509071*x_62 - 0.0377321077468876*x_63 - 0.0126057570705401*x_64 + 0.0318414065755581*x_68 + 0.020153954596646*x_73 + 0.00666251304425017*x_74 - 0.0379493052059809*x_76 + 0.0269898348562416*x_78 + 0.00890382623178117*x_84 + 0.0022139633574207*x_86 - 0.0896614104183158*x_9 - 0.00441804266856717*x_90 + 0.142670851275547*x_91 + 0.0043816221576816*x_92 - 0.0272691983132918*x_93 - 0.0122736013807194*x_98 - 0.00306611108651378*std::pow(-3.90320014953613*x_4 - 6.1637601852417, 2) - 0.00133540347529681*std::pow(-5.93743944168091*x_5 - 9.30079936981201, 2) - 0.00242252154377032*std::pow(-3.91991996765137*x_7 - 6.46479988098145, 2) - 0.000743592851717878*std::pow(-5.71959972381592*x_71 - 8.97583961486816, 2) + 0.000911980203848861*std::pow(-4.71984004974365*x_80 - 6.09327983856201, 2) + 0.000644610706136528*std::pow(-7.05999994277954*x_81 - 9.27960014343262, 2) + 0.000763318683952852*std::pow(-5.27831983566284*x_85 - 8.4093599319458, 2) + 0.000309272624790302*std::pow(-7.40399980545044*x_87 - 9.99079990386963, 2) + 0.000469940566802496*std::pow(-5.38815975189209*x_88 - 7.58616018295288, 2) - 0.355605250406029*std::sin(0.426559865474701*x_100 + 5.22328042984009) + 0.290195459191722*std::sin(0.431439846754074*x_104 - 7.38263988494873) + 0.47800602018998*std::sin(0.281599938869476*x_106 + 5.08271980285645) + 0.565991619470879*std::sin(0.361199855804443*x_107 + 5.15944004058838) + 0.229025150125437*std::sin(0.575359880924225*x_108 - 7.20560026168823) - 0.124071977313534*std::sin(0.527999877929688*x_109 + 8.36816024780273) - 0.328133265654969*std::sin(0.398719817399979*x_110 + 2.0097599029541) - 0.441401828889923*std::sin(0.352079838514328*x_112 - 7.44328022003174) + 0.806939942553527*std::sin(0.311119943857193*x_114 + 5.11175966262817) - 0.0988729116501474*std::sin(0.574719846248627*x_115 - 4.20968008041382) + 0.228399721184701*std::sin(0.682319819927216*x_116 + 8.42623996734619) + 0.406091912324769*std::sin(0.461359858512878*x_117 - 7.3459997177124) + 0.344417940452502*std::sin(0.341599822044373*x_118 - 7.44719982147217) + 0.486875073016392*std::sin(0.34639984369278*x_120 + 5.15912008285522) - 4.17755699814597*std::sin(0.171840012073517*x_13 + 8.15135955810547) - 1.35626744811339*std::sin(0.212640002369881*x_14 + 5.00903987884521) + 0.417776273083689*std::sin(0.41951984167099*x_16 - 7.36879968643188) + 2.43370523199565*std::sin(0.185440003871918*x_18 - 7.60567998886108) - 0.169564911158574*std::sin(0.398319840431213*x_21 - 7.18815994262695) - 0.584665313454934*std::sin(0.217999994754791*x_23 - 7.5860800743103) + 0.441398084040031*std::sin(0.264239966869354*x_24 + 8.05335998535156) + 0.60708619786169*std::sin(0.320399850606918*x_26 + 8.32015991210938) + 0.935134736287864*std::sin(0.279119938611984*x_27 + 5.103759765625) - 0.288238209495034*std::sin(0.417199850082397*x_28 + 8.41736030578613) - 0.301636053628016*std::sin(0.29751992225647*x_30 - 7.49848031997681) + 1.02490370330304*std::sin(0.20040000975132*x_31 - 7.39463949203491) - 0.529215360120077*std::sin(0.210400000214577*x_32 - 1.00415980815887) - 0.422052150491595*std::sin(0.369359821081161*x_34 + 1.97839987277985) - 0.661987335643175*std::sin(0.315359860658646*x_35 + 1.97319984436035) + 0.661087479421326*std::sin(0.366559833288193*x_36 + 5.16152000427246) + 0.742674729600594*std::sin(0.308319836854935*x_38 + 5.11079978942871) + 0.467833486539348*std::sin(0.301999926567078*x_39 + 5.10551977157593) - 0.671102690367661*std::sin(0.394879847764969*x_40 + 5.19040012359619) - 0.36440736404063*std::sin(0.417839854955673*x_42 - 1.1794399023056) - 0.355993934617686*std::sin(0.388719856739044*x_45 + 1.97711980342865) - 0.225019877131047*std::sin(0.44871985912323*x_46 + 5.24927997589111) - 0.0112538505236213*std::sin(1.97479975223541*x_49 - 7.4031195640564) + 0.312123369218227*std::sin(0.436799854040146*x_50 + 5.22847986221313) - 0.611043880055377*std::sin(0.276399940252304*x_51 - 4.30975961685181) - 0.0523154700906971*std::sin(0.71399986743927*x_52 - 1.22463989257813) + 1.19170134593162*std::sin(0.203759998083115*x_56 + 5.00360012054443) + 1.13933453531422*std::sin(0.229999989271164*x_57 - 4.37119960784912) + 0.733245665679988*std::sin(0.266959935426712*x_58 + 5.07175970077515) - 0.326160373408214*std::sin(0.303439915180206*x_59 + 5.13167953491211) - 0.776044384824559*std::sin(0.273279964923859*x_65 + 5.09200000762939) + 0.841125194876781*std::sin(0.221759989857674*x_66 + 5.03087949752808) - 0.597867001570421*std::sin(0.244639977812767*x_67 + 5.04016017913818) - 0.611221175292428*std::sin(0.269839972257614*x_69 + 5.09832000732422) + 0.72232271872349*std::sin(0.289679944515228*x_70 - 7.4759202003479) + 0.293508910177508*std::sin(0.34487983584404*x_72 - 1.04951989650726) + 1.00765125787052*std::sin(0.207840010523796*x_75 - 7.58039999008179) + 0.755347067580374*std::sin(0.293919950723648*x_77 + 5.11543989181519) - 0.156106174206002*std::sin(0.320879846811295*x_79 + 5.12488031387329) + 0.819257846094615*std::sin(0.325599819421768*x_8 - 4.28672027587891) + 1.37919419932632*std::sin(0.214560002088547*x_82 + 5.02231979370117) + 0.303858309967808*std::sin(0.375839829444885*x_83 + 8.19039916992188) - 0.277144813355193*std::sin(0.357119828462601*x_89 + 5.16175985336304) - 0.370920438179041*std::sin(0.406239867210388*x_94 - 7.39663982391357) - 0.298576257709101*std::sin(0.381119847297668*x_95 + 5.19063997268677) - 0.208231676058517*std::sin(0.406319856643677*x_96 - 7.39271974563599) - 0.434469253545956*std::sin(0.396479845046997*x_97 - 7.4031195640564) - 0.197627294900343*std::sin(0.45839986205101*x_99 + 2.04295969009399) + 11.8287566505669) - 0.0775080827122149);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000311955361738696*x_1 + 0.00287984272094839*x_10 + 0.00141530809389302*x_100 + 0.00260202064169376*x_101 + 0.000244887677851288*x_102 - 0.000837501826063522*x_103 + 0.00160829339532177*x_104 + 0.00110232817795255*x_105 + 8.9957992721723e-5*x_106 - 0.000191198124097846*x_11 - 0.00180431140196997*x_110 + 0.0015745365307413*x_111 - 0.00141256810303339*x_112 + 0.00237674679376599*x_113 - 0.000764336069583897*x_115 - 0.0041004550792358*x_116 - 0.000456081427717672*x_117 + 0.00432715154329102*x_119 + 0.00597826220926234*x_12 - 0.000280264651615952*x_120 + 0.00292031422976693*x_13 - 0.000757087240127601*x_14 - 0.00154174313146462*x_15 + 0.00265267502661297*x_16 + 0.00619608529399596*x_17 + 0.00142633035548737*x_18 - 0.00104326211643221*x_19 - 0.00534599232545472*x_2 + 0.0050989405836518*x_20 + 0.000772215783856201*x_21 + 0.00345545738757375*x_22 + 0.00185450811431798*x_23 - 0.000848465258579771*x_24 + 0.00540589832567588*x_25 + 5.8883691190132e-5*x_27 + 0.000839828124666711*x_28 - 0.00395359260864141*x_29 - 0.00358277945764833*x_3 + 0.00447496093482887*x_30 + 0.00837890757199294*x_31 + 0.001623690240035*x_32 - 0.00122837741855768*x_33 - 0.00044568272601701*x_34 + 0.00263467130967645*x_35 - 0.000232391948713871*x_37 - 9.69136356562893e-6*x_39 + 0.00411558274304548*x_4 - 0.00235937876951039*x_40 - 0.00167903192016908*x_41 + 0.00306557917547876*x_42 - 0.000454428839543228*x_43 - 2.78844938013574e-6*x_44 - 0.00210737318971951*x_47 - 0.00410783195516816*x_48 - 0.00162046256348853*x_5 + 0.000857941727638124*x_51 - 0.00192213611806113*x_52 + 0.000299179387942111*x_53 - 0.00428800896534663*x_54 + 0.00025893115983955*x_55 - 0.000244929116800511*x_56 + 0.000874156777284217*x_58 + 0.000127840028272332*x_59 + 0.000411396780800071*x_6 - 0.000907424175242783*x_60 - 0.0024875682869657*x_61 - 0.00303590888423803*x_62 + 0.00190847274792634*x_63 - 0.00321429999680407*x_64 - 0.000830530641298357*x_65 - 0.000924367199584985*x_66 + 0.00612708540307008*x_68 + 0.00110704934808727*x_7 - 0.000127199876538542*x_70 + 0.000667827992675242*x_72 - 0.000268948961385916*x_73 - 0.00171277702947819*x_74 + 0.001120865583048*x_76 + 0.000698135658596894*x_78 - 0.000860952766154791*x_79 + 0.00088828695488962*x_8 - 0.000158688280269006*x_81 + 0.000362085367785025*x_82 + 0.00028488944425158*x_84 + 0.000301168655484905*x_85 - 0.000152976162541464*x_86 - 1.21730983971542e-5*x_87 + 0.000709635164213126*x_88 - 0.000529280478091433*x_89 - 0.00201433627061635*x_9 + 0.0012026485126982*x_90 + 0.0107885424529828*x_91 + 0.00505669462733268*x_92 - 0.000463724046045951*x_93 - 0.000893304208442243*x_95 - 0.00230948286967734*x_96 + 0.00372591227263748*x_97 - 0.00225332895550269*x_98 - 0.00032873156347915*x_99 + 5.49897730130199e-5*std::pow(-4.47631978988647*x_100 - 6.92568016052246, 2) - 4.45998528360848e-5*std::pow(-4.37183952331543*x_18 - 6.95983982086182, 2) - 0.000129146179882968*std::pow(-3.88375997543335*x_19 - 6.13335990905762, 2) - 9.75521226222863e-6*std::pow(-5.80399990081787*x_22 - 9.99647998809814, 2) - 1.09430914076088e-5*std::pow(-4.18495988845825*x_24 - 7.37408018112183, 2) - 1.51653920678438e-5*std::pow(-4.51200008392334*x_38 - 6.96360015869141, 2) - 8.19059936182086e-5*std::pow(-5.81879997253418*x_4 - 9.82336044311523, 2) - 9.81041925922422e-5*std::pow(-3.90320014953613*x_4 - 6.1637601852417, 2) - 4.2727962566362e-5*std::pow(-5.93743944168091*x_5 - 9.30079936981201, 2) + 4.83867554670445e-5*std::pow(-4.35264015197754*x_55 - 6.33048009872437, 2) - 0.000117140661411715*std::pow(-3.86879992485046*x_6 - 6.51087999343872, 2) - 4.37393743024321e-6*std::pow(-5.41200017929077*x_64 - 9.21903991699219, 2) + 6.25297358789106e-6*std::pow(-6.89007997512817*x_66 - 9.33463954925537, 2) - 1.77082917142981e-5*std::pow(-6.62088012695313*x_69 - 9.43920040130615, 2) - 4.46015229651784e-5*std::pow(-5.21744012832642*x_7 - 9.23895931243896, 2) - 7.7511712192764e-5*std::pow(-3.91991996765137*x_7 - 6.46479988098145, 2) + 6.39395635188769e-6*std::pow(-6.25472021102905*x_71 - 9.68151950836182, 2) - 2.3792215701516e-5*std::pow(-5.71959972381592*x_71 - 8.97583961486816, 2) - 3.29975347722748e-5*std::pow(-4.14160013198853*x_71 - 6.69736003875732, 2) + 1.77768309974606e-5*std::pow(-5.3120002746582*x_73 - 7.55503988265991, 2) - 3.7872172175845e-5*std::pow(-1.42991983890533*x_75 - 1.61055982112885, 2) + 2.28245668594379e-5*std::pow(-6.52383947372437*x_77 - 9.1627197265625, 2) - 2.40824376648123e-5*std::pow(-6.66368007659912*x_78 - 9.21712017059326, 2) + 2.91799869718448e-5*std::pow(-4.71984004974365*x_80 - 6.09327983856201, 2) - 2.31979833849148e-5*std::pow(-3.69936013221741*x_80 - 6.42208003997803, 2) - 0.000245177079073205*std::pow(-1.82767987251282*x_80 - 2.43895983695984, 2) + 2.02344145654089e-5*std::pow(-7.45847988128662*x_81 - 9.67831993103027, 2) + 2.06251538439017e-5*std::pow(-7.05999994277954*x_81 - 9.27960014343262, 2) + 0.000160706097799906*std::pow(-1.03719985485077*x_84 - 2.28391981124878, 2) + 2.44233692344502e-5*std::pow(-5.27831983566284*x_85 - 8.4093599319458, 2) - 9.57065685199959e-6*std::pow(-8.02295970916748*x_86 - 9.42399978637695, 2) + 1.13938794264148e-5*std::pow(-6.90776014328003*x_86 - 7.71479988098145, 2) + 9.89557791281275e-6*std::pow(-7.40399980545044*x_87 - 9.99079990386963, 2) - 6.32173499257141e-5*std::pow(-5.18376016616821*x_87 - 7.56544017791748, 2) + 1.50363566653808e-5*std::pow(-5.38815975189209*x_88 - 7.58616018295288, 2) + 2.71296116372882e-5*std::pow(-7.48543977737427*x_89 - 9.05047988891602, 2) - 1.12081529715429e-5*std::pow(-5.15536022186279*x_89 - 6.94384002685547, 2) - 0.00144690844101376*std::exp(0.0656410730736202*x_1 - 0.0413827602597948*x_101 + 0.0422418722471482*x_104 - 0.015140298113979*x_106 - 0.0278974413364337*x_107 - 0.0752220699530694*x_111 + 0.0310002854128949*x_113 - 0.0109485631577786*x_114 + 0.0173518406821448*x_116 + 0.0196637062374024*x_119 - 0.15790075263316*x_12 + 0.00626559821727966*x_13 + 0.00379841813129561*x_15 + 0.0365850932429392*x_16 - 0.0167925810888222*x_19 + 0.0307854534898122*x_2 - 0.0617729059099503*x_20 - 0.074750747851078*x_22 + 0.00420522464557883*x_26 - 0.189514522206018*x_31 - 0.0419734796359127*x_33 + 0.00318577027215399*x_36 - 0.00911753497109045*x_37 - 0.00934472884357727*x_38 + 0.0328937483485492*x_39 - 0.00217736378428871*x_4 - 0.0191433321250796*x_41 + 0.00509400968400336*x_44 + 0.0144468763517412*x_45 + 0.0116255816148681*x_46 + 0.0343669901587201*x_47 + 0.0288579607429493*x_5 + 0.00617884144331101*x_51 + 0.0135470495421033*x_54 - 0.0141133129165163*x_59 - 0.021675466429832*x_6 + 0.0146077375691048*x_61 - 0.00958358552727838*x_63 + 0.0479598334196513*x_65 - 0.014492101248295*x_66 - 0.0112672708675507*x_68 + 0.0149941853420005*x_72 + 0.00698763233853744*x_73 + 0.00451980457565739*x_75 + 0.0270389977118894*x_76 + 0.0323986888492138*x_77 - 0.0118718178460152*x_80 - 0.00516060067334042*x_81 - 0.0458025943923335*x_85 - 0.0061912212574671*x_86 + 0.0151553000823439*x_88 - 0.0112401625783921*x_89 + 0.00692132081528286*x_9 - 0.0202953002577954*x_94 - 0.00550262930155784*x_97 - 0.0362250307683044*x_99 + 0.00204392860008379*std::pow(-3.50639986991882*x_17 - 5.15751981735229, 2) - 0.0150907916785775*std::pow(-0.866319835186005*x_24 - 1.30367994308472, 2) - 0.000986958036203599*std::pow(-6.56744050979614*x_27 - 9.54936027526855, 2) - 0.000137352543481213*std::pow(-5.71783971786499*x_43 - 8.27400016784668, 2) - 0.000337055419605561*std::pow(-5.42744016647339*x_60 - 8.43583965301514, 2) + 0.00114879764479271*std::pow(-5.09847974777222*x_7 - 7.94231986999512, 2) - 0.000255118366394271*std::pow(-5.8854398727417*x_71 - 9.54551982879639, 2) - 0.000274690187097377*std::pow(-7.06584024429321*x_78 - 9.41096019744873, 2) + 0.000152479328630542*std::pow(-9.20399951934814*x_82 - 9.99767971038818, 2) + 0.000691039448081764*std::pow(-5.88768005371094*x_90 - 8.31655979156494, 2) + 0.0364269362552069*std::exp(0.82207989692688*x_25) + 0.884260650447196*std::sin(0.301679849624634*x_10 + 5.10400009155273) + 0.898278226408621*std::sin(0.208000004291534*x_100 + 5.00311994552612) + 0.431548748268739*std::sin(0.319359838962555*x_102 - 4.27135992050171) - 0.122117328622076*std::sin(0.336479842662811*x_103 - 7.43991994857788) - 0.161630061247985*std::sin(0.437759846448898*x_105 - 1.18407988548279) + 0.139372913214185*std::sin(0.301119923591614*x_108 - 4.28095960617065) - 0.244424739789219*std::sin(0.422879844903946*x_109 + 2.01311993598938) + 0.455489008316924*std::sin(0.327679842710495*x_11 - 1.06183981895447) - 0.20368002914425*std::sin(0.384719848632813*x_110 + 8.17407989501953) - 0.384102414600864*std::sin(0.364639848470688*x_112 + 5.16183996200562) - 0.281397802773323*std::sin(0.355759829282761*x_115 - 1.24439990520477) - 0.249611361977575*std::sin(0.478159844875336*x_117 + 2.04239964485168) - 0.49520957734336*std::sin(0.393759846687317*x_118 + 5.18567991256714) - 0.089914951430913*std::sin(0.426879853010178*x_120 + 2.20191979408264) - 0.147668863468619*std::sin(0.270879954099655*x_14 + 1.8879998922348) + 1.28087557923288*std::sin(0.258959949016571*x_18 + 5.06335973739624) - 0.500027803154506*std::sin(0.325759828090668*x_21 - 4.2579197883606) - 0.775674535180208*std::sin(0.271119952201843*x_23 + 5.0798397064209) + 0.355812661536813*std::sin(0.361359834671021*x_28 + 8.34383964538574) - 0.0966506401485336*std::sin(0.810399830341339*x_29 + 5.61424016952515) + 0.65878556968876*std::sin(0.306319922208786*x_3 + 8.31271934509277) + 0.195021093949773*std::sin(0.330079823732376*x_30 + 8.34352016448975) - 0.98568419368241*std::sin(0.271519958972931*x_32 - 7.43567991256714) - 0.665197362959454*std::sin(0.357199847698212*x_34 - 7.39351987838745) - 0.235111206764165*std::sin(0.272719949483871*x_35 - 1.1399998664856) - 0.589209807207553*std::sin(0.306399941444397*x_40 + 5.12367963790894) + 0.405619033042544*std::sin(0.358479857444763*x_42 + 1.97983980178833) + 0.108857284089027*std::sin(0.589999854564667*x_48 - 7.40863990783691) + 0.251491285945995*std::sin(0.219999998807907*x_49 - 1.36087989807129) - 0.198413723931251*std::sin(0.428159862756729*x_50 - 1.17399990558624) + 0.858290527756083*std::sin(0.233919993042946*x_52 + 8.23464012145996) + 0.398946715510313*std::sin(0.231279999017715*x_53 - 7.54808044433594) + 0.483559140761976*std::sin(0.198559984564781*x_55 - 4.39231967926025) + 0.507775120511308*std::sin(0.363439828157425*x_56 + 5.15592002868652) - 0.110326969951887*std::sin(0.319519847631454*x_57 - 7.47119998931885) + 0.267342610346091*std::sin(0.250159978866577*x_58 - 7.52272033691406) + 0.377452270006021*std::sin(0.324959844350815*x_62 + 8.3133602142334) + 1.18219701463525*std::sin(0.206400007009506*x_64 - 4.40303993225098) - 0.977052005562754*std::sin(0.201039999723434*x_67 + 5.00600004196167) + 0.609589434633278*std::sin(0.262479960918427*x_69 + 5.07775974273682) + 2.43588553354206*std::sin(0.13864004611969*x_70 - 7.66880035400391) - 0.337969804214925*std::sin(0.344799846410751*x_74 - 4.25688028335571) + 0.818275973489868*std::sin(0.255679965019226*x_79 + 5.05535984039307) + 0.789633190049273*std::sin(0.266479969024658*x_8 + 5.09807968139648) - 0.291627372717979*std::sin(0.410399854183197*x_83 - 7.39120006561279) + 0.4493934352456*std::sin(0.319039851427078*x_84 - 4.2947998046875) + 0.704213731898875*std::sin(0.242479979991913*x_87 + 5.03991985321045) - 1.60453100023639*std::sin(0.179120019078255*x_91 + 5.2279200553894) - 0.937658045454604*std::sin(0.336719840764999*x_92 + 5.20352029800415) - 0.0887794411950429*std::sin(0.384559839963913*x_93 + 1.77711987495422) - 0.343467204154383*std::sin(0.385119825601578*x_95 - 7.39695978164673) - 0.457695975359048*std::sin(0.383679836988449*x_96 - 7.40807962417603) + 0.394915489426499*std::sin(0.352719843387604*x_98 - 4.2403998374939)) + 0.0293896782813233*std::sin(0.215440005064011*x_1 - 7.3842396736145) - 0.0164266238072958*std::sin(0.364479839801788*x_1 - 4.37279987335205) + 0.00902494365784721*std::sin(0.414799869060516*x_100 + 5.20456027984619) - 0.0113780502363703*std::sin(0.426559865474701*x_100 + 5.22328042984009) - 0.0121402015865622*std::sin(0.319119840860367*x_101 + 5.146399974823) + 0.0136422517085131*std::sin(0.320079833269119*x_102 - 4.26879978179932) - 0.0110412489563067*std::sin(0.322719842195511*x_102 + 5.12976026535034) + 0.0089501504237084*std::sin(0.3503198325634*x_102 - 7.41847991943359) - 0.00755679458251991*std::sin(0.404639840126038*x_103 - 7.39447975158691) + 0.0165820540980889*std::sin(0.442559868097305*x_103 + 5.23320007324219) + 0.0232401981836788*std::sin(0.276479959487915*x_104 - 7.50216007232666) + 0.00928517930846042*std::sin(0.431439846754074*x_104 - 7.38263988494873) - 0.0203472560724221*std::sin(0.353279858827591*x_105 - 4.24919986724854) + 0.0152944212853973*std::sin(0.281599938869476*x_106 + 5.08271980285645) - 0.0104788684730549*std::sin(0.360079854726791*x_106 + 5.16480016708374) + 0.00695384292905852*std::sin(0.452639847993851*x_106 + 2.046719789505) + 0.0181096344116156*std::sin(0.361199855804443*x_107 + 5.15944004058838) + 0.0208512039258583*std::sin(0.365039855241776*x_107 - 7.41479969024658) - 0.00512114277256654*std::sin(0.382639855146408*x_107 + 5.18391990661621) + 0.00371633246803544*std::sin(0.426959842443466*x_107 + 5.22248029708862) - 0.0260380788505856*std::sin(0.211359992623329*x_108 + 5.00783967971802) - 0.0204014853223547*std::sin(0.238799974322319*x_108 - 7.55640029907227) + 0.00575863084027716*std::sin(0.353679835796356*x_108 - 7.44871950149536) + 0.00732795609891616*std::sin(0.575359880924225*x_108 - 7.20560026168823) + 0.00945153505510637*std::sin(0.323999851942062*x_109 + 5.12048006057739) - 0.00761812072277991*std::sin(0.359439849853516*x_109 + 5.17456007003784) + 0.0153885790363892*std::sin(0.3643998503685*x_109 + 5.17935991287231) - 0.0039698434969318*std::sin(0.527999877929688*x_109 + 8.36816024780273) - 0.0094816673589016*std::sin(0.300399929285049*x_11 + 8.32439994812012) - 0.0352585757097203*std::sin(0.390239834785461*x_110 + 5.18304014205933) - 0.0104990485280618*std::sin(0.398719817399979*x_110 + 2.0097599029541) + 0.00552600111231488*std::sin(0.456639856100082*x_110 + 2.05167984962463) - 0.0208842191711801*std::sin(0.480879843235016*x_111 - 7.34032011032104) + 0.00312640805866078*std::sin(0.48431983590126*x_111 + 5.24575996398926) - 0.0141232228090019*std::sin(0.352079838514328*x_112 - 7.44328022003174) + 0.00722965902757295*std::sin(0.380959838628769*x_112 - 7.40343999862671) + 0.00153281973786851*std::sin(0.475119858980179*x_112 + 1.8407998085022) - 0.0368920234825758*std::sin(0.366319835186005*x_113 - 7.42911958694458) + 0.025819087861117*std::sin(0.311119943857193*x_114 + 5.11175966262817) + 0.0195761419023327*std::sin(0.373439848423004*x_114 - 7.42952013015747) + 0.00426134636938977*std::sin(0.393599838018417*x_114 + 1.99799978733063) + 0.0190176024148138*std::sin(0.44159984588623*x_114 - 7.38136005401611) + 0.0215842980505595*std::sin(0.36847984790802*x_115 + 8.36911964416504) - 0.00316356677660714*std::sin(0.574719846248627*x_115 - 4.20968008041382) + 0.00730794469048263*std::sin(0.682319819927216*x_116 + 8.42623996734619) + 0.0536497356775217*std::sin(0.306239932775497*x_117 - 4.28335952758789) - 0.00934062504246674*std::sin(0.380719840526581*x_117 + 5.18304014205933) + 0.0129934363278922*std::sin(0.461359858512878*x_117 - 7.3459997177124) + 0.0143441914448596*std::sin(0.334479838609695*x_118 - 4.26528024673462) + 0.0110200977749942*std::sin(0.341599822044373*x_118 - 7.44719982147217) - 0.0126046465361479*std::sin(0.365839838981628*x_118 + 5.15880012512207) - 0.0115310751458312*std::sin(0.372159838676453*x_118 + 1.98983991146088) + 0.0283633138395238*std::sin(0.339599847793579*x_119 + 5.15136003494263) + 0.00948147236154651*std::sin(0.397039830684662*x_119 + 1.97919988632202) - 0.0216952090469837*std::sin(0.359199851751328*x_12 + 5.17248010635376) - 0.00557963152647092*std::sin(0.423359870910645*x_12 + 8.41808032989502) + 0.0155781981095379*std::sin(0.34639984369278*x_120 + 5.15912008285522) + 0.0188163165674896*std::sin(0.371839851140976*x_120 - 7.41567993164063) - 0.0048164912181447*std::sin(0.4859998524189*x_120 + 2.06983971595764) - 0.133666343047333*std::sin(0.171840012073517*x_13 + 8.15135955810547) - 0.043395532380267*std::sin(0.212640002369881*x_14 + 5.00903987884521) + 0.0668893094424139*std::sin(0.306239932775497*x_14 + 5.15127992630005) + 0.00923025663455759*std::sin(0.431279867887497*x_15 - 0.968239843845367) - 0.00159036933860807*std::sin(1.49863994121552*x_15 - 2.5971200466156) + 0.0133672925731053*std::sin(0.41951984167099*x_16 - 7.36879968643188) + 0.0778695487722588*std::sin(0.185440003871918*x_18 - 7.60567998886108) + 0.00193783942790171*std::sin(0.599039852619171*x_19 - 0.798399865627289) - 0.00754534531042648*std::sin(0.263439953327179*x_21 - 1.12615990638733) + 0.0463632672379656*std::sin(0.30991992354393*x_21 - 4.27695989608765) - 0.00542544879549732*std::sin(0.398319840431213*x_21 - 7.18815994262695) - 0.0187071234194596*std::sin(0.217999994754791*x_23 - 7.5860800743103) + 0.00734145002258428*std::sin(0.310719907283783*x_23 - 4.24408006668091) + 0.0141231029876827*std::sin(0.264239966869354*x_24 + 8.05335998535156) - 0.0129920347311771*std::sin(0.376079827547073*x_24 + 8.37248039245605) + 0.0194245086347584*std::sin(0.320399850606918*x_26 + 8.32015991210938) + 0.0669950427115389*std::sin(0.325119823217392*x_26 - 4.25880002975464) + 0.00423101475511289*std::sin(0.326479852199554*x_26 + 8.31744003295898) - 0.0262005521044757*std::sin(0.338239848613739*x_26 - 4.26504039764404) + 0.0950859559685294*std::sin(0.213039994239807*x_27 - 7.5717601776123) + 0.0299208462054749*std::sin(0.279119938611984*x_27 + 5.103759765625) - 0.000588460127209277*std::sin(1.74143981933594*x_27 - 1.98255980014801) + 0.00536211564937932*std::sin(0.347439825534821*x_28 + 8.35303974151611) - 0.00922255457120302*std::sin(0.417199850082397*x_28 + 8.41736030578613) - 0.000462695492832691*std::sin(1.04367983341217*x_29 + 6.00735950469971) - 0.0170157721543104*std::sin(0.338559836149216*x_3 + 8.35519981384277) + 0.0220058253130418*std::sin(0.349679857492447*x_3 - 4.23496007919312) - 0.00965123593468139*std::sin(0.29751992225647*x_30 - 7.49848031997681) + 0.0327931204905128*std::sin(0.20040000975132*x_31 - 7.39463949203491) - 0.0169329303952339*std::sin(0.210400000214577*x_32 - 1.00415980815887) + 0.0212257538926415*std::sin(0.259839981794357*x_32 + 5.17312002182007) - 0.0159806661689377*std::sin(0.311999946832657*x_32 - 4.44504022598267) - 0.0183200942376743*std::sin(0.218399986624718*x_33 - 7.38711977005005) + 0.0204658404708975*std::sin(0.279199957847595*x_33 - 1.16039991378784) - 0.027781047437961*std::sin(0.292239934206009*x_33 + 8.22999954223633) - 0.00672374982745745*std::sin(0.277199953794479*x_34 - 1.12231993675232) - 0.0135041048049162*std::sin(0.369359821081161*x_34 + 1.97839987277985) - 0.0402316489178338*std::sin(0.386319845914841*x_34 + 1.9748797416687) - 0.0211811415950377*std::sin(0.315359860658646*x_35 + 1.97319984436035) - 0.0188238523744942*std::sin(0.316319853067398*x_35 - 1.20743989944458) - 0.0108508548460597*std::sin(0.316399842500687*x_35 - 7.42007970809937) + 0.0291691472279533*std::sin(0.343759834766388*x_36 - 7.44807958602905) + 0.0122956155538005*std::sin(0.363919854164124*x_36 - 4.23432016372681) + 0.0211523495305617*std::sin(0.366559833288193*x_36 + 5.16152000427246) + 0.0166532781525949*std::sin(0.367839843034744*x_36 + 5.17136001586914) - 0.026556936972453*std::sin(0.358239859342575*x_37 + 5.17824029922485) + 0.0134725115976794*std::sin(0.403439849615097*x_37 - 4.20223999023438) + 0.00616345343603341*std::sin(0.450879871845245*x_37 + 2.03239989280701) - 0.0854425720814484*std::sin(0.165120020508766*x_38 - 7.63992023468018) + 0.00802257744973442*std::sin(0.249279975891113*x_38 + 5.06663990020752) + 0.0237628391960745*std::sin(0.308319836854935*x_38 + 5.11079978942871) + 0.0227962508750538*std::sin(0.271279960870743*x_39 + 8.28528022766113) + 0.0149689379052281*std::sin(0.301999926567078*x_39 + 5.10551977157593) - 0.0140995960573036*std::sin(0.30295991897583*x_39 - 4.30272006988525) + 0.0123410907582259*std::sin(0.315039843320847*x_40 - 4.28247976303101) - 0.0214727991671886*std::sin(0.394879847764969*x_40 + 5.19040012359619) - 0.035032725516935*std::sin(0.330479830503464*x_41 + 5.14264011383057) + 0.0130203259892544*std::sin(0.357199847698212*x_41 - 7.43991994857788) + 0.00798793433991888*std::sin(0.365519851446152*x_41 - 7.41623973846436) - 0.0237451374680333*std::sin(0.303599923849106*x_42 + 5.09543991088867) + 0.00802896824560469*std::sin(0.348079830408096*x_42 - 1.23199987411499) - 0.0116596852544314*std::sin(0.417839854955673*x_42 - 1.1794399023056) - 0.00831200709912248*std::sin(0.356159836053848*x_43 + 5.15208005905151) + 0.0155287575418929*std::sin(0.377679854631424*x_43 + 5.18800020217896) + 0.024410352739351*std::sin(0.29351994395256*x_44 - 4.27183961868286) + 0.0313976406899427*std::sin(0.220559984445572*x_45 + 8.22208023071289) - 0.0204020104190528*std::sin(0.296639919281006*x_45 + 5.11967945098877) - 0.011390486690785*std::sin(0.388719856739044*x_45 + 1.97711980342865) + 0.00497424654123338*std::sin(0.466559857130051*x_45 + 5.24775981903076) + 0.0529726478631708*std::sin(0.195199996232986*x_46 + 4.97847986221313) + 0.0324574972572417*std::sin(0.290079951286316*x_46 + 5.11967992782593) - 0.00356995154403482*std::sin(0.439439862966537*x_46 - 4.14663982391357) - 0.00719980220555119*std::sin(0.44871985912323*x_46 + 5.24927997589111) + 0.0174538855018156*std::sin(0.376559853553772*x_47 + 5.1625599861145) - 0.00593480063578919*std::sin(0.624079823493958*x_47 - 7.38527965545654) - 0.00452294215396541*std::sin(0.509759843349457*x_48 + 8.27455902099609) + 0.033148322010735*std::sin(0.326879858970642*x_49 - 4.26919984817505) + 0.0200822756182655*std::sin(0.352319836616516*x_49 - 4.23863983154297) + 0.00164667343537278*std::sin(0.506479859352112*x_49 + 8.28087997436523) - 0.000360081513037732*std::sin(1.97479975223541*x_49 - 7.4031195640564) + 0.0210565758878725*std::sin(0.304159939289093*x_50 - 7.47200012207031) + 0.00874009099372527*std::sin(0.350559860467911*x_50 + 5.15431976318359) + 0.0277471897248352*std::sin(0.375439822673798*x_50 - 4.23304033279419) + 0.00998679117042059*std::sin(0.436799854040146*x_50 + 5.22847986221313) - 0.0195511397988594*std::sin(0.276399940252304*x_51 - 4.30975961685181) + 0.00752635005765288*std::sin(0.321599841117859*x_51 - 7.47175979614258) - 0.00942368089761027*std::sin(0.352479845285416*x_51 + 5.1418399810791) - 0.0016739011759574*std::sin(0.71399986743927*x_52 - 1.22463989257813) + 0.150229020183214*std::sin(0.131200045347214*x_53 - 7.68440008163452) + 0.00459969748069375*std::sin(0.295199930667877*x_53 - 4.27360010147095) - 0.0043360242884139*std::sin(0.334159851074219*x_53 - 1.068079829216) + 0.0103311004376787*std::sin(0.308479934930801*x_55 - 7.46504020690918) + 0.0173404720526548*std::sin(0.317279845476151*x_55 - 4.28736019134521) + 0.0381300269477971*std::sin(0.203759998083115*x_56 + 5.00360012054443) + 0.00612043897721544*std::sin(0.342239856719971*x_56 + 5.13784027099609) + 0.0364544830652393*std::sin(0.229999989271164*x_57 - 4.37119960784912) - 0.0279967239420822*std::sin(0.366719841957092*x_57 + 8.35023975372314) - 0.015582791925912*std::sin(0.373519837856293*x_57 - 4.21056032180786) + 0.00719365910694032*std::sin(0.41023987531662*x_57 + 5.21224021911621) + 0.0234611440921689*std::sin(0.266959935426712*x_58 + 5.07175970077515) - 0.0181417859380945*std::sin(0.389519840478897*x_58 + 1.97375977039337) - 0.00634185016504519*std::sin(0.463439851999283*x_58 - 1.13231992721558) - 0.0104359232871693*std::sin(0.303439915180206*x_59 + 5.13167953491211) - 0.00623225965785076*std::sin(0.307839930057526*x_59 - 7.46871995925903) + 0.00974997605555294*std::sin(0.314319908618927*x_59 + 5.13312005996704) - 0.0798456906214279*std::sin(0.228319987654686*x_60 + 5.03671979904175) - 0.0108844490340522*std::sin(0.344799846410751*x_60 - 4.26503992080688) + 0.0267960117601289*std::sin(0.238079980015755*x_64 - 4.35223960876465) + 0.0307252659489967*std::sin(0.196719989180565*x_65 + 5.00432014465332) - 0.0248305445043485*std::sin(0.273279964923859*x_65 + 5.09200000762939) - 0.0279584360222883*std::sin(0.199680000543594*x_66 + 4.99975967407227) + 0.0269128892541866*std::sin(0.221759989857674*x_66 + 5.03087949752808) - 0.0243347567765427*std::sin(0.202800005674362*x_67 - 7.58416032791138) + 0.0472893173407163*std::sin(0.225759983062744*x_67 + 5.03471994400024) - 0.0191295285172791*std::sin(0.244639977812767*x_67 + 5.04016017913818) + 0.00162075725795555*std::sin(0.343759834766388*x_67 - 4.43192005157471) - 0.0194090730765219*std::sin(0.225199997425079*x_69 + 5.02031993865967) - 0.0690857915010001*std::sin(0.251279979944229*x_69 + 5.05583953857422) - 0.019556812589437*std::sin(0.269839972257614*x_69 + 5.09832000732422) + 0.0231116502670402*std::sin(0.289679944515228*x_70 - 7.4759202003479) + 0.00605971035405853*std::sin(0.345999836921692*x_70 - 1.06407976150513) + 0.0097876931195479*std::sin(0.298959940671921*x_71 + 5.11895942687988) + 0.00939119746125478*std::sin(0.34487983584404*x_72 - 1.04951989650726) - 0.0192114124133746*std::sin(0.33111983537674*x_74 - 4.27975988388062) + 0.00339700714719622*std::sin(0.365679830312729*x_74 + 1.94711983203888) + 0.0322411061695564*std::sin(0.207840010523796*x_75 - 7.58039999008179) + 0.0119180766186772*std::sin(0.241279974579811*x_75 - 7.54800033569336) - 0.000426327754536409*std::sin(0.873279869556427*x_75 + 2.20911979675293) - 0.00897322202747629*std::sin(0.358159840106964*x_76 - 4.25072002410889) + 0.0901022974198959*std::sin(0.144800037145615*x_77 - 7.65912008285522) + 0.0241683070511794*std::sin(0.293919950723648*x_77 + 5.11543989181519) - 0.00665283529489632*std::sin(0.31399992108345*x_77 - 7.46776008605957) - 0.0134422683410064*std::sin(0.255599975585938*x_79 + 5.07967948913574) - 0.0214119022718054*std::sin(0.257119983434677*x_79 + 5.05615997314453) - 0.00499481908744434*std::sin(0.320879846811295*x_79 + 5.12488031387329) + 0.0262132151276217*std::sin(0.325599819421768*x_8 - 4.28672027587891) + 0.00123845391433982*std::sin(0.474159836769104*x_80 + 8.48776054382324) + 0.0441291034587584*std::sin(0.214560002088547*x_82 + 5.02231979370117) + 0.0193354109348415*std::sin(0.275119960308075*x_82 - 7.49600028991699) - 0.00957964346705615*std::sin(0.326799839735031*x_82 + 5.12800025939941) - 0.0094251111819373*std::sin(0.270079970359802*x_83 + 5.10271978378296) - 0.0146398893216085*std::sin(0.276319950819016*x_83 + 5.11303997039795) + 0.00972233990247538*std::sin(0.375839829444885*x_83 + 8.19039916992188) + 0.0119764712789516*std::sin(0.510559856891632*x_83 + 8.3342399597168) + 0.0522642249928086*std::sin(0.234959989786148*x_84 + 5.02799987792969) - 0.00569650898761397*std::sin(0.305039942264557*x_84 + 5.14831972122192) - 0.0142480488258955*std::sin(0.265119940042496*x_85 + 5.06559991836548) + 0.00321654899421562*std::sin(0.50791984796524*x_85 - 0.885199844837189) + 0.0273380156793993*std::sin(0.195919990539551*x_87 + 1.79983985424042) + 0.125289324750846*std::sin(0.148960039019585*x_88 - 7.65576028823853) - 0.0088676070038458*std::sin(0.357119828462601*x_89 + 5.16175985336304) + 0.208749055116207*std::sin(0.12216005474329*x_9 + 8.07327938079834) - 0.00465201446839097*std::sin(0.497999846935272*x_9 + 2.30663990974426) + 0.00824768564025182*std::sin(0.446799844503403*x_90 - 4.16096019744873) - 0.019460906188675*std::sin(0.168240025639534*x_91 + 5.22959995269775) + 0.023749957653263*std::sin(0.324799835681915*x_92 + 2.19455981254578) - 0.0118796508455738*std::sin(0.285359919071198*x_93 + 8.27120018005371) + 0.00922138733228499*std::sin(0.394639849662781*x_93 + 1.99383985996246) - 0.0182477885596019*std::sin(0.343359857797623*x_94 + 1.96759986877441) - 0.00549885859824372*std::sin(0.370159834623337*x_94 - 7.40679979324341) - 0.0247477344930026*std::sin(0.390079855918884*x_94 - 7.40775966644287) - 0.011868079491174*std::sin(0.406239867210388*x_94 - 7.39663982391357) - 0.00767556136249026*std::sin(0.367199838161469*x_95 + 5.17216014862061) - 0.00955333380405*std::sin(0.381119847297668*x_95 + 5.19063997268677) - 0.00423195766515726*std::sin(0.368079841136932*x_96 + 5.16943979263306) - 0.00666264198375069*std::sin(0.406319856643677*x_96 - 7.39271974563599) - 0.00845459978653228*std::sin(0.409599870443344*x_96 - 7.38104009628296) + 0.0119259080476927*std::sin(0.345919847488403*x_97 + 5.16247987747192) - 0.0139014060882391*std::sin(0.396479845046997*x_97 - 7.4031195640564) + 0.0200537894942747*std::sin(0.407839864492416*x_98 + 2.00023984909058) - 0.00316125864367346*std::sin(0.444959849119186*x_98 + 2.03095984458923) - 0.00692229064579354*std::sin(0.310319930315018*x_99 - 7.48432016372681) - 0.00866957035841691*std::sin(0.42783984541893*x_99 - 1.18479979038239) - 0.00632334108364993*std::sin(0.45839986205101*x_99 + 2.04295969009399) + 0.400993964850783);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000574870879568001*x_1 + 0.0012045696040897*x_10 + 0.000713736718770955*x_100 + 0.00108011219494203*x_101 - 9.29957048143423e-5*x_102 - 0.000503931712729985*x_103 - 0.000171910419724865*x_104 + 0.00022814054702894*x_105 + 0.000190459947495981*x_106 + 0.000617970482450568*x_107 + 0.000564366974311842*x_11 - 0.000909910220424707*x_110 + 0.00235375926927238*x_111 - 0.00041929602533697*x_112 + 0.000756683061152207*x_113 + 0.000242527218720835*x_114 - 0.000416621225533965*x_115 - 0.0017150679018682*x_116 - 0.000230000847954021*x_117 + 0.000318638169751527*x_119 + 0.00446906257964315*x_12 - 8.31916381324671e-5*x_120 - 0.0023294265916138*x_13 + 0.00104566885661375*x_14 - 0.00103528515398065*x_15 - 0.00170452625778964*x_16 + 0.00249107895287785*x_17 + 0.000307553842062571*x_18 + 5.59866298478828e-5*x_19 - 0.0035475062037602*x_2 - 0.00294578709238852*x_20 + 0.000389426699480409*x_21 + 0.00108174721779954*x_22 + 0.00103276427294404*x_23 - 0.000251852006140473*x_24 + 0.0012399428035248*x_25 - 9.31520805690337e-5*x_26 - 9.48604538569991e-5*x_27 + 0.000382654164224018*x_28 - 0.00144972489648631*x_29 - 0.00178577572028487*x_3 + 0.00150924674557721*x_30 + 0.00103499219065978*x_31 + 0.000818823370843101*x_32 + 0.00139625036576468*x_33 - 0.000224756805852282*x_34 + 0.00078205589227479*x_35 - 7.05696256627148e-5*x_36 + 0.000290217649069777*x_37 + 0.000206999865048319*x_38 - 0.000713033639168264*x_39 + 0.00134633824277417*x_4 - 0.00120570113278025*x_40 + 0.00106166342665091*x_41 + 0.000909963322032937*x_42 - 0.000391443639355615*x_43 + 5.27058918117133e-5*x_44 - 0.000320020142396704*x_45 - 0.000257524200612832*x_46 + 0.000727576195513545*x_47 - 0.00167846247449519*x_48 - 0.00157044507523816*x_5 + 0.000117794254453832*x_51 - 0.000531245877128729*x_52 - 0.000113612895069779*x_53 - 0.00169002207681276*x_54 - 9.83286946854743e-5*x_55 + 0.000134741981846683*x_56 - 0.00140824915964591*x_58 + 0.000350578274740824*x_59 + 0.00234478814187477*x_6 - 0.000260174518129719*x_60 - 0.00360120638844879*x_61 - 0.00240108570525389*x_62 + 0.0018652345283327*x_63 - 0.00068121805358024*x_64 - 0.0015871696667869*x_65 + 4.66397783165992e-5*x_66 + 0.00218042723547841*x_68 - 0.00155570778339746*x_7 + 0.000120109027235518*x_70 - 0.000875462091570335*x_72 - 0.000635772216089659*x_73 - 0.000652638383285923*x_74 - 0.000100120501393564*x_75 + 0.00178160444659811*x_76 - 0.00071767991685914*x_77 + 0.000120942058320306*x_78 - 0.000255558703383125*x_79 + 0.000664315709500854*x_8 + 0.000262978705229357*x_80 - 0.000104532008993723*x_81 + 0.000182598844331482*x_82 - 0.000108186311760572*x_84 + 0.00110399330421202*x_85 + 0.000470805215027782*x_86 + 1.9610619094366e-5*x_87 + 0.000137745660745471*x_88 - 1.79283794529215e-5*x_89 + 0.0013670377221705*x_9 - 6.01473877136916e-5*x_90 + 0.000764059369869294*x_91 + 0.00235979209531524*x_92 + 0.000452677437309331*x_93 + 0.000449571569684041*x_94 - 0.000274566238011838*x_95 - 0.000685529416783552*x_96 + 0.00144633399734928*x_97 - 0.000403161215132367*x_98 + 0.000704860983042288*x_99 + 1.63227480565561e-5*std::pow(-4.47631978988647*x_100 - 6.92568016052246, 2) - 4.52761071474578e-5*std::pow(-3.50639986991882*x_17 - 5.15751981735229, 2) + 7.1849474726805e-5*std::pow(-4.37183952331543*x_18 - 6.95983982086182, 2) - 3.83347746534112e-5*std::pow(-3.88375997543335*x_19 - 6.13335990905762, 2) + 1.57154526824475e-5*std::pow(-5.80399990081787*x_22 - 9.99647998809814, 2) + 1.76291023294131e-5*std::pow(-4.18495988845825*x_24 - 7.37408018112183, 2) + 0.000334283839930236*std::pow(-0.866319835186005*x_24 - 1.30367994308472, 2) + 2.18626119304592e-5*std::pow(-6.56744050979614*x_27 - 9.54936027526855, 2) - 7.64787343482547e-6*std::pow(-4.51200008392334*x_38 - 6.96360015869141, 2) - 2.43123552780508e-5*std::pow(-5.81879997253418*x_4 - 9.82336044311523, 2) + 3.7254910559027e-5*std::pow(-3.90320014953613*x_4 - 6.1637601852417, 2) + 3.04256639658369e-6*std::pow(-5.71783971786499*x_43 - 8.27400016784668, 2) + 1.62258755891861e-5*std::pow(-5.93743944168091*x_5 - 9.30079936981201, 2) + 1.43627583000889e-5*std::pow(-4.35264015197754*x_55 - 6.33048009872437, 2) - 3.4771147408611e-5*std::pow(-3.86879992485046*x_6 - 6.51087999343872, 2) + 7.46628688109123e-6*std::pow(-5.42744016647339*x_60 - 8.43583965301514, 2) + 7.04632609452514e-6*std::pow(-5.41200017929077*x_64 - 9.21903991699219, 2) - 1.00734159240781e-5*std::pow(-6.89007997512817*x_66 - 9.33463954925537, 2) - 8.93025206153977e-6*std::pow(-6.62088012695313*x_69 - 9.43920040130615, 2) - 1.3239178531014e-5*std::pow(-5.21744012832642*x_7 - 9.23895931243896, 2) - 2.54476038224867e-5*std::pow(-5.09847974777222*x_7 - 7.94231986999512, 2) + 2.94349489936765e-5*std::pow(-3.91991996765137*x_7 - 6.46479988098145, 2) - 1.0300536349249e-5*std::pow(-6.25472021102905*x_71 - 9.68151950836182, 2) + 5.65125733436966e-6*std::pow(-5.8854398727417*x_71 - 9.54551982879639, 2) + 9.03505593940486e-6*std::pow(-5.71959972381592*x_71 - 8.97583961486816, 2) - 9.79473849524281e-6*std::pow(-4.14160013198853*x_71 - 6.69736003875732, 2) - 2.86381207168765e-5*std::pow(-5.3120002746582*x_73 - 7.55503988265991, 2) + 6.1011315162816e-5*std::pow(-1.42991983890533*x_75 - 1.61055982112885, 2) + 6.7750716893924e-6*std::pow(-6.52383947372437*x_77 - 9.1627197265625, 2) + 6.08480273864079e-6*std::pow(-7.06584024429321*x_78 - 9.41096019744873, 2) - 7.14844853964713e-6*std::pow(-6.66368007659912*x_78 - 9.21712017059326, 2) - 1.10810534802324e-5*std::pow(-4.71984004974365*x_80 - 6.09327983856201, 2) - 1.16986913412676e-5*std::pow(-3.69936013221741*x_80 - 6.42208003997803, 2) - 7.277650864292e-5*std::pow(-1.82767987251282*x_80 - 2.43895983695984, 2) + 1.02041701877371e-5*std::pow(-7.45847988128662*x_81 - 9.67831993103027, 2) - 7.8323692537223e-6*std::pow(-7.05999994277954*x_81 - 9.27960014343262, 2) - 3.37764754628211e-6*std::pow(-9.20399951934814*x_82 - 9.99767971038818, 2) + 8.10437271044529e-5*std::pow(-1.03719985485077*x_84 - 2.28391981124878, 2) - 9.27473548619254e-6*std::pow(-5.27831983566284*x_85 - 8.4093599319458, 2) - 2.84088134886379e-6*std::pow(-8.02295970916748*x_86 - 9.42399978637695, 2) + 5.74590801181125e-6*std::pow(-6.90776014328003*x_86 - 7.71479988098145, 2) - 3.75782991868662e-6*std::pow(-7.40399980545044*x_87 - 9.99079990386963, 2) - 1.8764959720715e-5*std::pow(-5.18376016616821*x_87 - 7.56544017791748, 2) - 5.71003244510357e-6*std::pow(-5.38815975189209*x_88 - 7.58616018295288, 2) + 8.05294860051193e-6*std::pow(-7.48543977737427*x_89 - 9.05047988891602, 2) + 1.80561112302927e-5*std::pow(-5.15536022186279*x_89 - 6.94384002685547, 2) - 1.530756803011e-5*std::pow(-5.88768005371094*x_90 - 8.31655979156494, 2) - 0.00080691168413454*std::exp(0.82207989692688*x_25) - 0.0473461864249559*std::sin(0.215440005064011*x_1 - 7.3842396736145) - 0.00828390979129837*std::sin(0.364479839801788*x_1 - 4.37279987335205) - 0.0195877096461622*std::sin(0.301679849624634*x_10 + 5.10400009155273) - 0.0198982201361818*std::sin(0.208000004291534*x_100 + 5.00311994552612) - 0.01453900450386*std::sin(0.414799869060516*x_100 + 5.20456027984619) + 0.00432079641747758*std::sin(0.426559865474701*x_100 + 5.22328042984009) + 0.019557622987632*std::sin(0.319119840860367*x_101 + 5.146399974823) - 0.00955945690332125*std::sin(0.319359838962555*x_102 - 4.27135992050171) + 0.00687975714481966*std::sin(0.320079833269119*x_102 - 4.26879978179932) - 0.00327740077961106*std::sin(0.322719842195511*x_102 + 5.12976026535034) - 0.0144185140931463*std::sin(0.3503198325634*x_102 - 7.41847991943359) + 0.00270508336496089*std::sin(0.336479842662811*x_103 - 7.43991994857788) + 0.0121738455812377*std::sin(0.404639840126038*x_103 - 7.39447975158691) + 0.00492209144488019*std::sin(0.442559868097305*x_103 + 5.23320007324219) + 0.00689844454616688*std::sin(0.276479959487915*x_104 - 7.50216007232666) - 0.00352603202290231*std::sin(0.431439846754074*x_104 - 7.38263988494873) - 0.0102610759083391*std::sin(0.353279858827591*x_105 - 4.24919986724854) + 0.00358035010176674*std::sin(0.437759846448898*x_105 - 1.18407988548279) - 0.00580803207267427*std::sin(0.281599938869476*x_106 + 5.08271980285645) - 0.00311046801307884*std::sin(0.360079854726791*x_106 + 5.16480016708374) + 0.00350680749756951*std::sin(0.452639847993851*x_106 + 2.046719789505) - 0.00687710476417263*std::sin(0.361199855804443*x_107 + 5.15944004058838) + 0.00618931357067202*std::sin(0.365039855241776*x_107 - 7.41479969024658) - 0.00258258089148293*std::sin(0.382639855146408*x_107 + 5.18391990661621) - 0.00598693759640569*std::sin(0.426959842443466*x_107 + 5.22248029708862) - 0.00772894626886748*std::sin(0.211359992623329*x_108 + 5.00783967971802) - 0.0102884235982698*std::sin(0.238799974322319*x_108 - 7.55640029907227) - 0.00308732063922394*std::sin(0.301119923591614*x_108 - 4.28095960617065) - 0.00927703960235343*std::sin(0.353679835796356*x_108 - 7.44871950149536) - 0.00278277963287765*std::sin(0.575359880924225*x_108 - 7.20560026168823) - 0.0152262347494102*std::sin(0.323999851942062*x_109 + 5.12048006057739) - 0.0022613053011316*std::sin(0.359439849853516*x_109 + 5.17456007003784) + 0.00776042612585395*std::sin(0.3643998503685*x_109 + 5.17935991287231) + 0.0054143773455357*std::sin(0.422879844903946*x_109 + 2.01311993598938) + 0.00150754173194454*std::sin(0.527999877929688*x_109 + 8.36816024780273) - 0.00478158372613083*std::sin(0.300399929285049*x_11 + 8.32439994812012) - 0.0100897698403951*std::sin(0.327679842710495*x_11 - 1.06183981895447) + 0.00451182043392042*std::sin(0.384719848632813*x_110 + 8.17407989501953) - 0.010465888775473*std::sin(0.390239834785461*x_110 + 5.18304014205933) + 0.0039869969216663*std::sin(0.398719817399979*x_110 + 2.0097599029541) - 0.0089022777433545*std::sin(0.456639856100082*x_110 + 2.05167984962463) - 0.00619911356623275*std::sin(0.480879843235016*x_111 - 7.34032011032104) - 0.00503658112106331*std::sin(0.48431983590126*x_111 + 5.24575996398926) + 0.00536327132053868*std::sin(0.352079838514328*x_112 - 7.44328022003174) + 0.00850844891467984*std::sin(0.364639848470688*x_112 + 5.16183996200562) - 0.0116468367170204*std::sin(0.380959838628769*x_112 - 7.40343999862671) + 0.000772997579039014*std::sin(0.475119858980179*x_112 + 1.8407998085022) - 0.0109507490503745*std::sin(0.366319835186005*x_113 - 7.42911958694458) - 0.00980475740705129*std::sin(0.311119943857193*x_114 + 5.11175966262817) + 0.00987220475022714*std::sin(0.373439848423004*x_114 - 7.42952013015747) - 0.00686494413770603*std::sin(0.393599838018417*x_114 + 1.99799978733063) + 0.00564504117489738*std::sin(0.44159984588623*x_114 - 7.38136005401611) + 0.00623338656198749*std::sin(0.355759829282761*x_115 - 1.24439990520477) + 0.00640691968256498*std::sin(0.36847984790802*x_115 + 8.36911964416504) + 0.00120135943424836*std::sin(0.574719846248627*x_115 - 4.20968008041382) - 0.00277518033246396*std::sin(0.682319819927216*x_116 + 8.42623996734619) + 0.0159249815153387*std::sin(0.306239932775497*x_117 - 4.28335952758789) + 0.015047560927786*std::sin(0.380719840526581*x_117 + 5.18304014205933) - 0.00493423670751778*std::sin(0.461359858512878*x_117 - 7.3459997177124) + 0.00552926886470313*std::sin(0.478159844875336*x_117 + 2.04239964485168) + 0.00425782123112263*std::sin(0.334479838609695*x_118 - 4.26528024673462) - 0.00418486454157524*std::sin(0.341599822044373*x_118 - 7.44719982147217) + 0.0203058345521386*std::sin(0.365839838981628*x_118 + 5.15880012512207) - 0.0058150955074726*std::sin(0.372159838676453*x_118 + 1.98983991146088) + 0.0109696404675418*std::sin(0.393759846687317*x_118 + 5.18567991256714) + 0.0143035559823646*std::sin(0.339599847793579*x_119 + 5.15136003494263) - 0.0152744631538932*std::sin(0.397039830684662*x_119 + 1.97919988632202) - 0.0109408455904829*std::sin(0.359199851751328*x_12 + 5.17248010635376) + 0.00898867527252696*std::sin(0.423359870910645*x_12 + 8.41808032989502) - 0.00591579586872347*std::sin(0.34639984369278*x_120 + 5.15912008285522) + 0.00948902652658097*std::sin(0.371839851140976*x_120 - 7.41567993164063) + 0.00199175204798132*std::sin(0.426879853010178*x_120 + 2.20191979408264) + 0.00775927143351409*std::sin(0.4859998524189*x_120 + 2.06983971595764) + 0.0507595804358559*std::sin(0.171840012073517*x_13 + 8.15135955810547) + 0.0164793841605507*std::sin(0.212640002369881*x_14 + 5.00903987884521) + 0.00327108847367487*std::sin(0.270879954099655*x_14 + 1.8879998922348) + 0.0198549163941272*std::sin(0.306239932775497*x_14 + 5.15127992630005) - 0.0148697596205967*std::sin(0.431279867887497*x_15 - 0.968239843845367) - 0.000472073198498653*std::sin(1.49863994121552*x_15 - 2.5971200466156) - 0.00507620801994923*std::sin(0.41951984167099*x_16 - 7.36879968643188) - 0.0295708368636194*std::sin(0.185440003871918*x_18 - 7.60567998886108) - 0.0283733296581558*std::sin(0.258959949016571*x_18 + 5.06335973739624) + 0.000977248106432507*std::sin(0.599039852619171*x_19 - 0.798399865627289) + 0.0121554010319038*std::sin(0.263439953327179*x_21 - 1.12615990638733) + 0.0137621213680026*std::sin(0.30991992354393*x_21 - 4.27695989608765) + 0.0110763714502568*std::sin(0.325759828090668*x_21 - 4.2579197883606) + 0.00206030552087554*std::sin(0.398319840431213*x_21 - 7.18815994262695) + 0.00710400026128707*std::sin(0.217999994754791*x_23 - 7.5860800743103) + 0.0171823631045301*std::sin(0.271119952201843*x_23 + 5.0798397064209) - 0.0118269297837009*std::sin(0.310719907283783*x_23 - 4.24408006668091) - 0.00536322581858398*std::sin(0.264239966869354*x_24 + 8.05335998535156) - 0.00655185417168225*std::sin(0.376079827547073*x_24 + 8.37248039245605) - 0.00737642615182378*std::sin(0.320399850606918*x_26 + 8.32015991210938) + 0.019886301457541*std::sin(0.325119823217392*x_26 - 4.25880002975464) - 0.0068160805111506*std::sin(0.326479852199554*x_26 + 8.31744003295898) - 0.0132128800575131*std::sin(0.338239848613739*x_26 - 4.26504039764404) + 0.047951635765398*std::sin(0.213039994239807*x_27 - 7.5717601776123) - 0.011362393591765*std::sin(0.279119938611984*x_27 + 5.103759765625) - 0.000174674050672872*std::sin(1.74143981933594*x_27 - 1.98255980014801) - 0.00863826152629309*std::sin(0.347439825534821*x_28 + 8.35303974151611) - 0.00788178813462588*std::sin(0.361359834671021*x_28 + 8.34383964538574) + 0.00350225037888018*std::sin(0.417199850082397*x_28 + 8.41736030578613) + 0.00214095773162331*std::sin(0.810399830341339*x_29 + 5.61424016952515) + 0.00074539322451736*std::sin(1.04367983341217*x_29 + 6.00735950469971) - 0.0145930958836843*std::sin(0.306319922208786*x_3 + 8.31271934509277) + 0.0274120700768106*std::sin(0.338559836149216*x_3 + 8.35519981384277) + 0.0110974886814747*std::sin(0.349679857492447*x_3 - 4.23496007919312) + 0.00366504144246997*std::sin(0.29751992225647*x_30 - 7.49848031997681) - 0.00432001193452765*std::sin(0.330079823732376*x_30 + 8.34352016448975) - 0.0124531351672534*std::sin(0.20040000975132*x_31 - 7.39463949203491) + 0.00643025329201429*std::sin(0.210400000214577*x_32 - 1.00415980815887) - 0.0341942668167916*std::sin(0.259839981794357*x_32 + 5.17312002182007) + 0.0218343943936647*std::sin(0.271519958972931*x_32 - 7.43567991256714) - 0.00474358000331694*std::sin(0.311999946832657*x_32 - 4.44504022598267) - 0.00923878271112378*std::sin(0.218399986624718*x_33 - 7.38711977005005) - 0.0329700614278003*std::sin(0.279199957847595*x_33 - 1.16039991378784) - 0.0082463158734935*std::sin(0.292239934206009*x_33 + 8.22999954223633) + 0.0108318270706579*std::sin(0.277199953794479*x_34 - 1.12231993675232) + 0.0147351267937265*std::sin(0.357199847698212*x_34 - 7.39351987838745) + 0.00512816224662209*std::sin(0.369359821081161*x_34 + 1.97839987277985) - 0.0119420581901681*std::sin(0.386319845914841*x_34 + 1.9748797416687) + 0.00520806851500882*std::sin(0.272719949483871*x_35 - 1.1399998664856) + 0.00804350471483945*std::sin(0.315359860658646*x_35 + 1.97319984436035) - 0.00949282681726534*std::sin(0.316319853067398*x_35 - 1.20743989944458) + 0.0174805110656198*std::sin(0.316399842500687*x_35 - 7.42007970809937) + 0.00865834890996446*std::sin(0.343759834766388*x_36 - 7.44807958602905) - 0.0198079917938323*std::sin(0.363919854164124*x_36 - 4.23432016372681) - 0.00803257097430786*std::sin(0.366559833288193*x_36 + 5.16152000427246) + 0.00839821107269917*std::sin(0.367839843034744*x_36 + 5.17136001586914) - 0.00788296018702521*std::sin(0.358239859342575*x_37 + 5.17824029922485) + 0.00679415758506798*std::sin(0.403439849615097*x_37 - 4.20223999023438) - 0.00992920074220129*std::sin(0.450879871845245*x_37 + 2.03239989280701) - 0.0253621264641228*std::sin(0.165120020508766*x_38 - 7.63992023468018) - 0.0129242125044*std::sin(0.249279975891113*x_38 + 5.06663990020752) - 0.00902390025834942*std::sin(0.308319836854935*x_38 + 5.11079978942871) + 0.00676666658688421*std::sin(0.271279960870743*x_39 + 8.28528022766113) - 0.0056844302785384*std::sin(0.301999926567078*x_39 + 5.10551977157593) - 0.00711039488105725*std::sin(0.30295991897583*x_39 - 4.30272006988525) + 0.0130518876062346*std::sin(0.306399941444397*x_40 + 5.12367963790894) - 0.0198812514425371*std::sin(0.315039843320847*x_40 - 4.28247976303101) + 0.00815426121236761*std::sin(0.394879847764969*x_40 + 5.19040012359619) - 0.0103988491134892*std::sin(0.330479830503464*x_41 + 5.14264011383057) + 0.00656612139010426*std::sin(0.357199847698212*x_41 - 7.43991994857788) - 0.0128684031443939*std::sin(0.365519851446152*x_41 - 7.41623973846436) - 0.0119746199264515*std::sin(0.303599923849106*x_42 + 5.09543991088867) - 0.0129345079492763*std::sin(0.348079830408096*x_42 - 1.23199987411499) - 0.00898507452771571*std::sin(0.358479857444763*x_42 + 1.97983980178833) + 0.00442774686608651*std::sin(0.417839854955673*x_42 - 1.1794399023056) + 0.0133904779056632*std::sin(0.356159836053848*x_43 + 5.15208005905151) + 0.00783111783389416*std::sin(0.377679854631424*x_43 + 5.18800020217896) + 0.00724578436869981*std::sin(0.29351994395256*x_44 - 4.27183961868286) + 0.00931983804390073*std::sin(0.220559984445572*x_45 + 8.22208023071289) - 0.0102886884033649*std::sin(0.296639919281006*x_45 + 5.11967945098877) + 0.00432551914119254*std::sin(0.388719856739044*x_45 + 1.97711980342865) - 0.00801341211736201*std::sin(0.466559857130051*x_45 + 5.24775981903076) + 0.0157239998927524*std::sin(0.195199996232986*x_46 + 4.97847986221313) + 0.0163682435590254*std::sin(0.290079951286316*x_46 + 5.11967992782593) + 0.00575112084297104*std::sin(0.439439862966537*x_46 - 4.14663982391357) + 0.0027341133964106*std::sin(0.44871985912323*x_46 + 5.24927997589111) + 0.00880195557534307*std::sin(0.376559853553772*x_47 + 5.1625599861145) - 0.00176164130593773*std::sin(0.624079823493958*x_47 - 7.38527965545654) + 0.00728636973705912*std::sin(0.509759843349457*x_48 + 8.27455902099609) - 0.00241135334081338*std::sin(0.589999854564667*x_48 - 7.40863990783691) - 0.00557091202142583*std::sin(0.219999998807907*x_49 - 1.36087989807129) + 0.00983949703794397*std::sin(0.326879858970642*x_49 - 4.26919984817505) + 0.0101274468556231*std::sin(0.352319836616516*x_49 - 4.23863983154297) - 0.00265275811139882*std::sin(0.506479859352112*x_49 + 8.28087997436523) + 0.000136740379872824*std::sin(1.97479975223541*x_49 - 7.4031195640564) - 0.0339217244202359*std::sin(0.304159939289093*x_50 - 7.47200012207031) + 0.00440760841723314*std::sin(0.350559860467911*x_50 + 5.15431976318359) + 0.00823626580616566*std::sin(0.375439822673798*x_50 - 4.23304033279419) + 0.00439516381534521*std::sin(0.428159862756729*x_50 - 1.17399990558624) - 0.00379246800768351*std::sin(0.436799854040146*x_50 + 5.22847986221313) + 0.00742451413428318*std::sin(0.276399940252304*x_51 - 4.30975961685181) + 0.00379552156710609*std::sin(0.321599841117859*x_51 - 7.47175979614258) + 0.0151813622563908*std::sin(0.352479845285416*x_51 + 5.1418399810791) - 0.0190124321841475*std::sin(0.233919993042946*x_52 + 8.23464012145996) + 0.000635661299962368*std::sin(0.71399986743927*x_52 - 1.22463989257813) + 0.0445928454124239*std::sin(0.131200045347214*x_53 - 7.68440008163452) - 0.00883727261159261*std::sin(0.231279999017715*x_53 - 7.54808044433594) - 0.00741002103986014*std::sin(0.295199930667877*x_53 - 4.27360010147095) - 0.00218664738898726*std::sin(0.334159851074219*x_53 - 1.068079829216) - 0.0107115656918614*std::sin(0.198559984564781*x_55 - 4.39231967926025) - 0.0166431970644645*std::sin(0.308479934930801*x_55 - 7.46504020690918) + 0.00874476142559022*std::sin(0.317279845476151*x_55 - 4.28736019134521) - 0.0144798168765093*std::sin(0.203759998083115*x_56 + 5.00360012054443) + 0.00308652374128641*std::sin(0.342239856719971*x_56 + 5.13784027099609) - 0.0112479862369658*std::sin(0.363439828157425*x_56 + 5.15592002868652) - 0.0138435317613373*std::sin(0.229999989271164*x_57 - 4.37119960784912) + 0.00244390910357201*std::sin(0.319519847631454*x_57 - 7.47119998931885) - 0.00831033565472911*std::sin(0.366719841957092*x_57 + 8.35023975372314) - 0.00785836725337886*std::sin(0.373519837856293*x_57 - 4.21056032180786) - 0.0115888415618084*std::sin(0.41023987531662*x_57 + 5.21224021911621) - 0.00592204281040663*std::sin(0.250159978866577*x_58 - 7.52272033691406) - 0.0089093320241577*std::sin(0.266959935426712*x_58 + 5.07175970077515) - 0.00538507044015941*std::sin(0.389519840478897*x_58 + 1.97375977039337) - 0.003198180910056*std::sin(0.463439851999283*x_58 - 1.13231992721558) + 0.00396302521218756*std::sin(0.303439915180206*x_59 + 5.13167953491211) - 0.00314291466142017*std::sin(0.307839930057526*x_59 - 7.46871995925903) - 0.0157070172577704*std::sin(0.314319908618927*x_59 + 5.13312005996704) - 0.0237007905289354*std::sin(0.228319987654686*x_60 + 5.03671979904175) + 0.017534630633458*std::sin(0.344799846410751*x_60 - 4.26503992080688) - 0.00836113816262624*std::sin(0.324959844350815*x_62 + 8.3133602142334) - 0.0261874503355137*std::sin(0.206400007009506*x_64 - 4.40303993225098) + 0.0135131690353125*std::sin(0.238079980015755*x_64 - 4.35223960876465) + 0.00912025541435515*std::sin(0.196719989180565*x_65 + 5.00432014465332) + 0.00942935964506978*std::sin(0.273279964923859*x_65 + 5.09200000762939) - 0.014099377001107*std::sin(0.199680000543594*x_66 + 4.99975967407227) - 0.0102201267403225*std::sin(0.221759989857674*x_66 + 5.03087949752808) + 0.0216431783823977*std::sin(0.201039999723434*x_67 + 5.00600004196167) + 0.0392028085479359*std::sin(0.202800005674362*x_67 - 7.58416032791138) + 0.0140370030721218*std::sin(0.225759983062744*x_67 + 5.03471994400024) + 0.00726440792301007*std::sin(0.244639977812767*x_67 + 5.04016017913818) + 0.00081734427451444*std::sin(0.343759834766388*x_67 - 4.43192005157471) + 0.0312676302006536*std::sin(0.225199997425079*x_69 + 5.02031993865967) - 0.0205069035053407*std::sin(0.251279979944229*x_69 + 5.05583953857422) - 0.0135033271501182*std::sin(0.262479960918427*x_69 + 5.07775974273682) + 0.00742666836745103*std::sin(0.269839972257614*x_69 + 5.09832000732422) - 0.0539585455240813*std::sin(0.13864004611969*x_70 - 7.66880035400391) - 0.00877661230187001*std::sin(0.289679944515228*x_70 - 7.4759202003479) + 0.00305589843191771*std::sin(0.345999836921692*x_70 - 1.06407976150513) + 0.0049359118354701*std::sin(0.298959940671921*x_71 + 5.11895942687988) - 0.00356629224721712*std::sin(0.34487983584404*x_72 - 1.04951989650726) - 0.00968827248147854*std::sin(0.33111983537674*x_74 - 4.27975988388062) + 0.00748654188194881*std::sin(0.344799846410751*x_74 - 4.25688028335571) - 0.00547251086379765*std::sin(0.365679830312729*x_74 + 1.94711983203888) - 0.0122435086099052*std::sin(0.207840010523796*x_75 - 7.58039999008179) + 0.00601025948807901*std::sin(0.241279974579811*x_75 - 7.54800033569336) - 0.00012654790419243*std::sin(0.873279869556427*x_75 + 2.20911979675293) - 0.00452517587819172*std::sin(0.358159840106964*x_76 - 4.25072002410889) + 0.0454383878617614*std::sin(0.144800037145615*x_77 - 7.65912008285522) - 0.00917787602918402*std::sin(0.293919950723648*x_77 + 5.11543989181519) + 0.0107175851709427*std::sin(0.31399992108345*x_77 - 7.46776008605957) + 0.0216552265987893*std::sin(0.255599975585938*x_79 + 5.07967948913574) - 0.0181260493396877*std::sin(0.255679965019226*x_79 + 5.05535984039307) - 0.0107979746149024*std::sin(0.257119983434677*x_79 + 5.05615997314453) + 0.00189677457654317*std::sin(0.320879846811295*x_79 + 5.12488031387329) - 0.0174915684033161*std::sin(0.266479969024658*x_8 + 5.09807968139648) - 0.00995442660746495*std::sin(0.325599819421768*x_8 - 4.28672027587891) - 0.00199512459257887*std::sin(0.474159836769104*x_80 + 8.48776054382324) - 0.0167579566068015*std::sin(0.214560002088547*x_82 + 5.02231979370117) + 0.00573937705079582*std::sin(0.275119960308075*x_82 - 7.49600028991699) + 0.0154326148498223*std::sin(0.326799839735031*x_82 + 5.12800025939941) + 0.015183666415958*std::sin(0.270079970359802*x_83 + 5.10271978378296) - 0.00738286357059767*std::sin(0.276319950819016*x_83 + 5.11303997039795) - 0.0036920430607552*std::sin(0.375839829444885*x_83 + 8.19039916992188) + 0.0064599869945406*std::sin(0.410399854183197*x_83 - 7.39120006561279) + 0.00355500509606797*std::sin(0.510559856891632*x_83 + 8.3342399597168) + 0.0155137170092844*std::sin(0.234959989786148*x_84 + 5.02799987792969) + 0.0091769625348503*std::sin(0.305039942264557*x_84 + 5.14831972122192) - 0.00995474368562084*std::sin(0.319039851427078*x_84 - 4.2947998046875) + 0.0229533229130791*std::sin(0.265119940042496*x_85 + 5.06559991836548) + 0.00162209849205526*std::sin(0.50791984796524*x_85 - 0.885199844837189) + 0.0137865004043411*std::sin(0.195919990539551*x_87 + 1.79983985424042) - 0.0155993983248033*std::sin(0.242479979991913*x_87 + 5.03991985321045) + 0.037189934964814*std::sin(0.148960039019585*x_88 - 7.65576028823853) + 0.00336745960668557*std::sin(0.357119828462601*x_89 + 5.16175985336304) + 0.0619634897001526*std::sin(0.12216005474329*x_9 + 8.07327938079834) + 0.00749430266516389*std::sin(0.497999846935272*x_9 + 2.30663990974426) + 0.00244818058666347*std::sin(0.446799844503403*x_90 - 4.16096019744873) + 0.031351132312092*std::sin(0.168240025639534*x_91 + 5.22959995269775) + 0.0355427863209813*std::sin(0.179120019078255*x_91 + 5.2279200553894) + 0.00704975768923981*std::sin(0.324799835681915*x_92 + 2.19455981254578) + 0.0207705426363417*std::sin(0.336719840764999*x_92 + 5.20352029800415) - 0.00599088145630671*std::sin(0.285359919071198*x_93 + 8.27120018005371) + 0.00196659878034556*std::sin(0.384559839963913*x_93 + 1.77711987495422) - 0.0148554713512649*std::sin(0.394639849662781*x_93 + 1.99383985996246) - 0.00541653545609592*std::sin(0.343359857797623*x_94 + 1.96759986877441) + 0.00885855169372054*std::sin(0.370159834623337*x_94 - 7.40679979324341) - 0.012480227372589*std::sin(0.390079855918884*x_94 - 7.40775966644287) + 0.00450688424488471*std::sin(0.406239867210388*x_94 - 7.39663982391357) + 0.0123651764985666*std::sin(0.367199838161469*x_95 + 5.17216014862061) + 0.00362786326461808*std::sin(0.381119847297668*x_95 + 5.19063997268677) + 0.00760831759793082*std::sin(0.385119825601578*x_95 - 7.39695978164673) + 0.00681759952045432*std::sin(0.368079841136932*x_96 + 5.16943979263306) + 0.0101386574954071*std::sin(0.383679836988449*x_96 - 7.40807962417603) + 0.00253012765950921*std::sin(0.406319856643677*x_96 - 7.39271974563599) - 0.00426363583745414*std::sin(0.409599870443344*x_96 - 7.38104009628296) - 0.0192124003641021*std::sin(0.345919847488403*x_97 + 5.16247987747192) + 0.00527903677485662*std::sin(0.396479845046997*x_97 - 7.4031195640564) - 0.00874797486210228*std::sin(0.352719843387604*x_98 - 4.2403998374939) + 0.0101130813667551*std::sin(0.407839864492416*x_98 + 2.00023984909058) + 0.00509272471948024*std::sin(0.444959849119186*x_98 + 2.03095984458923) + 0.011151672375119*std::sin(0.310319930315018*x_99 - 7.48432016372681) - 0.0043720450179508*std::sin(0.42783984541893*x_99 - 1.18479979038239) + 0.00240127868423258*std::sin(0.45839986205101*x_99 + 2.04295969009399) + 0.0818082726851754);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000620483753776548*x_1 - 0.000518409174702781*x_10 - 2.90827159019254e-5*x_101 + 0.000326805143836596*x_104 + 0.000264598957445449*x_105 - 1.63657480770219e-6*x_106 - 0.00019843753204876*x_107 - 0.000195515938448566*x_11 - 0.000535062758518715*x_111 - 0.000147117788302987*x_112 + 0.000510522274842149*x_113 - 7.78783196031729e-5*x_114 + 1.737195499042e-5*x_115 - 0.000239433109643678*x_116 + 0.000508920132733168*x_119 - 0.000624177475340114*x_12 - 2.9189329418315e-5*x_120 + 0.00206763640104983*x_13 - 0.000795613516216008*x_14 + 2.70185609702914e-5*x_15 + 0.00144190241633978*x_16 + 0.000614497624603155*x_17 + 0.000206697276232545*x_18 + 0.000562496298264615*x_19 - 0.000919985606925794*x_2 + 0.00135888129683819*x_20 - 0.000337257285627696*x_22 - 4.89657964374085e-5*x_23 - 8.83669481323599e-5*x_24 + 0.000691075944298155*x_25 + 2.99122199170814e-5*x_26 + 6.94222601469662e-5*x_27 + 2.0516690742911e-5*x_28 - 0.000509710755160053*x_29 - 0.000484328962340766*x_3 + 0.000376450286886925*x_30 + 0.00277194146017142*x_31 - 0.000298561922220862*x_33 + 0.00027439881670312*x_35 + 2.26607301672117e-5*x_36 - 6.48540171197913e-5*x_37 - 6.64700718256402e-5*x_38 + 0.000222550954440252*x_39 + 0.000417789214581834*x_4 + 7.96770074159012e-6*x_40 - 0.000136168601854156*x_41 + 0.000319277511077615*x_42 - 8.68209730003946e-5*x_43 - 0.000241796368813869*x_44 + 0.000102762201539577*x_45 + 8.26940254650882e-5*x_46 - 0.000414902535838707*x_47 - 0.000292549017774159*x_48 + 0.000286057048097688*x_5 + 0.000133304685158025*x_51 - 0.000225211264796336*x_52 - 0.000442121043193381*x_54 - 0.000142379468671319*x_56 + 0.001030606912972*x_58 - 8.70750963879482e-5*x_59 - 0.000429620566257501*x_6 + 0.00059224398519681*x_61 + 0.00113356597939664*x_62 + 0.000132533848889623*x_63 - 0.00029275939529578*x_64 + 0.000400197054906648*x_65 - 0.000199355963046445*x_66 + 2.93986567391244e-5*x_68 + 0.00117825499595641*x_7 - 0.000102186354673014*x_70 + 0.000604720316320324*x_72 - 6.31091453297267e-5*x_73 - 0.000200586371333415*x_74 + 3.21498611474739e-5*x_75 - 0.000255354017397719*x_76 + 0.000230455394791253*x_77 - 0.000296690712503652*x_78 - 8.96675116180486e-5*x_79 - 0.000117599281275688*x_8 - 8.44455305375627e-5*x_80 + 4.35215703480689e-5*x_81 - 0.000294432367657253*x_85 - 0.000307910335644407*x_86 - 1.43517498078225e-5*x_87 + 4.3375407388597e-5*x_88 - 7.99524979722776e-5*x_89 + 4.92321071505841e-5*x_9 + 0.000441212258515964*x_90 + 0.000321767802809835*x_91 + 3.69799269517758e-5*x_92 + 4.25750587729306e-5*x_93 - 0.00014436267637512*x_94 - 8.83157185910443e-5*x_95 - 0.00024053071224031*x_96 + 0.000239235841763606*x_97 - 0.000193781935257751*x_98 - 0.000291909698513229*x_99 + 5.72713893764563e-6*std::pow(-4.47631978988647*x_100 - 6.92568016052246, 2) + 1.45386862613384e-5*std::pow(-3.50639986991882*x_17 - 5.15751981735229, 2) - 5.25820057052057e-5*std::pow(-4.37183952331543*x_18 - 6.95983982086182, 2) - 1.34504667855386e-5*std::pow(-3.88375997543335*x_19 - 6.13335990905762, 2) - 1.15011282371986e-5*std::pow(-5.80399990081787*x_22 - 9.99647998809814, 2) - 1.29016052349375e-5*std::pow(-4.18495988845825*x_24 - 7.37408018112183, 2) - 0.000107342441238437*std::pow(-0.866319835186005*x_24 - 1.30367994308472, 2) - 7.02033977159602e-6*std::pow(-6.56744050979614*x_27 - 9.54936027526855, 2) - 8.53044083608658e-6*std::pow(-5.81879997253418*x_4 - 9.82336044311523, 2) - 9.77003568905657e-7*std::pow(-5.71783971786499*x_43 - 8.27400016784668, 2) + 5.03944017437634e-6*std::pow(-4.35264015197754*x_55 - 6.33048009872437, 2) - 1.22001020625009e-5*std::pow(-3.86879992485046*x_6 - 6.51087999343872, 2) - 2.39751182997691e-6*std::pow(-5.42744016647339*x_60 - 8.43583965301514, 2) - 5.15675250670739e-6*std::pow(-5.41200017929077*x_64 - 9.21903991699219, 2) + 7.37208470353892e-6*std::pow(-6.89007997512817*x_66 - 9.33463954925537, 2) - 4.64521137033406e-6*std::pow(-5.21744012832642*x_7 - 9.23895931243896, 2) + 8.17152249580589e-6*std::pow(-5.09847974777222*x_7 - 7.94231986999512, 2) + 7.53829952330642e-6*std::pow(-6.25472021102905*x_71 - 9.68151950836182, 2) - 1.81468466577523e-6*std::pow(-5.8854398727417*x_71 - 9.54551982879639, 2) - 3.43666569047058e-6*std::pow(-4.14160013198853*x_71 - 6.69736003875732, 2) + 2.09583971580433e-5*std::pow(-5.3120002746582*x_73 - 7.55503988265991, 2) - 4.46502543570641e-5*std::pow(-1.42991983890533*x_75 - 1.61055982112885, 2) + 2.3771595777388e-6*std::pow(-6.52383947372437*x_77 - 9.1627197265625, 2) - 1.95390115345193e-6*std::pow(-7.06584024429321*x_78 - 9.41096019744873, 2) - 2.50816577167748e-6*std::pow(-6.66368007659912*x_78 - 9.21712017059326, 2) - 2.55349880394289e-5*std::pow(-1.82767987251282*x_80 - 2.43895983695984, 2) + 1.08460203561322e-6*std::pow(-9.20399951934814*x_82 - 9.99767971038818, 2) - 9.96775918732268e-7*std::pow(-8.02295970916748*x_86 - 9.42399978637695, 2) - 6.584034202298e-6*std::pow(-5.18376016616821*x_87 - 7.56544017791748, 2) + 2.82552639623243e-6*std::pow(-7.48543977737427*x_89 - 9.05047988891602, 2) - 1.32141055635425e-5*std::pow(-5.15536022186279*x_89 - 6.94384002685547, 2) + 4.91543869460868e-6*std::pow(-5.88768005371094*x_90 - 8.31655979156494, 2) + 0.000259108756369726*std::exp(0.82207989692688*x_25) - 3.12928777257874e-5*std::exp(0.0233023575336764*x_1 - 0.0255030529616011*x_10 - 0.0140647099679652*x_101 - 0.00490844355169441*x_102 - 0.00184966514230118*x_103 + 0.00388137105793478*x_105 + 0.00719954859687893*x_11 - 0.00241596189645884*x_111 + 0.0173475654639713*x_113 - 0.0157077228768299*x_119 - 0.0237953220660715*x_12 - 0.00393703038900941*x_15 + 0.0135136731673376*x_17 + 0.0325044739292702*x_19 - 0.0520910295227927*x_2 - 0.0859896117769806*x_20 - 0.0437428440297895*x_22 - 0.00433164417337468*x_25 - 0.0106851976900049*x_29 - 0.0213978001424857*x_3 + 0.0246211702935414*x_33 + 0.0046579834973281*x_37 + 0.0336539325863826*x_41 - 0.00760040403308652*x_43 - 0.00752464260612788*x_44 + 0.031029733545309*x_47 - 0.00429986867948905*x_48 - 0.00599664773021414*x_53 - 0.00628427829550813*x_54 - 0.00518992622658213*x_55 + 0.0263680408870141*x_6 + 0.00447642692491987*x_60 - 0.0283618732031391*x_61 + 0.0260230233128764*x_62 + 0.0241984537558744*x_63 + 0.00808435700373545*x_64 - 0.0204206139161201*x_68 - 0.012925186728938*x_73 - 0.00427282024319185*x_74 + 0.0243377473968503*x_76 - 0.0173091912868642*x_78 - 0.00571022506257604*x_84 - 0.00141986475500204*x_86 + 0.0575018895909162*x_9 + 0.00283339064766719*x_90 - 0.0914980424645725*x_91 - 0.00281003335063142*x_92 + 0.0174883533877958*x_93 + 0.00787133805038684*x_98 + 0.00196636635925798*std::pow(-3.90320014953613*x_4 - 6.1637601852417, 2) + 0.00085642443987427*std::pow(-5.93743944168091*x_5 - 9.30079936981201, 2) + 0.00155361783504848*std::pow(-3.91991996765137*x_7 - 6.46479988098145, 2) + 0.000476882907156917*std::pow(-5.71959972381592*x_71 - 8.97583961486816, 2) - 0.000584873523025754*std::pow(-4.71984004974365*x_80 - 6.09327983856201, 2) - 0.000413403419380221*std::pow(-7.05999994277954*x_81 - 9.27960014343262, 2) - 0.000489533529336207*std::pow(-5.27831983566284*x_85 - 8.4093599319458, 2) - 0.000198343526397974*std::pow(-7.40399980545044*x_87 - 9.99079990386963, 2) - 0.0003013835100351*std::pow(-5.38815975189209*x_88 - 7.58616018295288, 2) + 0.228057686705991*std::sin(0.426559865474701*x_100 + 5.22328042984009) - 0.186108908797835*std::sin(0.431439846754074*x_104 - 7.38263988494873) - 0.306556067638466*std::sin(0.281599938869476*x_106 + 5.08271980285645) - 0.362983221659761*std::sin(0.361199855804443*x_107 + 5.15944004058838) - 0.146879006638576*std::sin(0.575359880924225*x_108 - 7.20560026168823) + 0.0795701641043123*std::sin(0.527999877929688*x_109 + 8.36816024780273) + 0.210439281791004*std::sin(0.398719817399979*x_110 + 2.0097599029541) + 0.283080972200187*std::sin(0.352079838514328*x_112 - 7.44328022003174) - 0.517508828678146*std::sin(0.311119943857193*x_114 + 5.11175966262817) + 0.063409433587025*std::sin(0.574719846248627*x_115 - 4.20968008041382) - 0.146477904919013*std::sin(0.682319819927216*x_116 + 8.42623996734619) - 0.260435924410718*std::sin(0.461359858512878*x_117 - 7.3459997177124) - 0.220883011907036*std::sin(0.341599822044373*x_118 - 7.44719982147217) - 0.312243991730012*std::sin(0.34639984369278*x_120 + 5.15912008285522) + 2.67916175026038*std::sin(0.171840012073517*x_13 + 8.15135955810547) + 0.869804977339932*std::sin(0.212640002369881*x_14 + 5.00903987884521) - 0.267929369128632*std::sin(0.41951984167099*x_16 - 7.36879968643188) - 1.56079018715126*std::sin(0.185440003871918*x_18 - 7.60567998886108) + 0.108745811095807*std::sin(0.398319840431213*x_21 - 7.18815994262695) + 0.374959083791708*std::sin(0.217999994754791*x_23 - 7.5860800743103) - 0.283078570543287*std::sin(0.264239966869354*x_24 + 8.05335998535156) - 0.389338103859238*std::sin(0.320399850606918*x_26 + 8.32015991210938) - 0.599723048162879*std::sin(0.279119938611984*x_27 + 5.103759765625) + 0.184853680317314*std::sin(0.417199850082397*x_28 + 8.41736030578613) + 0.193446020661914*std::sin(0.29751992225647*x_30 - 7.49848031997681) - 0.65729391623103*std::sin(0.20040000975132*x_31 - 7.39463949203491) + 0.339397775090378*std::sin(0.210400000214577*x_32 - 1.00415980815887) + 0.270671585980526*std::sin(0.369359821081161*x_34 + 1.97839987277985) + 0.424547444738419*std::sin(0.315359860658646*x_35 + 1.97319984436035) - 0.423970346599152*std::sin(0.366559833288193*x_36 + 5.16152000427246) - 0.476294094685947*std::sin(0.308319836854935*x_38 + 5.11079978942871) - 0.300032191824897*std::sin(0.301999926567078*x_39 + 5.10551977157593) + 0.43039332780566*std::sin(0.394879847764969*x_40 + 5.19040012359619) + 0.23370268118045*std::sin(0.417839854955673*x_42 - 1.1794399023056) + 0.228306958678406*std::sin(0.388719856739044*x_45 + 1.97711980342865) + 0.144310334514968*std::sin(0.44871985912323*x_46 + 5.24927997589111) + 0.007217348770924*std::sin(1.97479975223541*x_49 - 7.4031195640564) - 0.200171773250011*std::sin(0.436799854040146*x_50 + 5.22847986221313) + 0.391876254926409*std::sin(0.276399940252304*x_51 - 4.30975961685181) + 0.0335510937315975*std::sin(0.71399986743927*x_52 - 1.22463989257813) - 0.76426501545539*std::sin(0.203759998083115*x_56 + 5.00360012054443) - 0.730680995883297*std::sin(0.229999989271164*x_57 - 4.37119960784912) - 0.47024702281881*std::sin(0.266959935426712*x_58 + 5.07175970077515) + 0.209174021389473*std::sin(0.303439915180206*x_59 + 5.13167953491211) + 0.497694809011353*std::sin(0.273279964923859*x_65 + 5.09200000762939) - 0.539432603862569*std::sin(0.221759989857674*x_66 + 5.03087949752808) + 0.38342562484754*std::sin(0.244639977812767*x_67 + 5.04016017913818) + 0.391989958370269*std::sin(0.269839972257614*x_69 + 5.09832000732422) - 0.463241889986641*std::sin(0.289679944515228*x_70 - 7.4759202003479) - 0.188233899826424*std::sin(0.34487983584404*x_72 - 1.04951989650726) - 0.646229532927158*std::sin(0.207840010523796*x_75 - 7.58039999008179) - 0.484421151532057*std::sin(0.293919950723648*x_77 + 5.11543989181519) + 0.100114418809323*std::sin(0.320879846811295*x_79 + 5.12488031387329) - 0.525408578705573*std::sin(0.325599819421768*x_8 - 4.28672027587891) - 0.884508421227039*std::sin(0.214560002088547*x_82 + 5.02231979370117) - 0.194871203894*std::sin(0.375839829444885*x_83 + 8.19039916992188) + 0.177739234570304*std::sin(0.357119828462601*x_89 + 5.16175985336304) + 0.237879662874771*std::sin(0.406239867210388*x_94 - 7.39663982391357) + 0.191483704362412*std::sin(0.381119847297668*x_95 + 5.19063997268677) + 0.13354368161492*std::sin(0.406319856643677*x_96 - 7.39271974563599) + 0.278634954898545*std::sin(0.396479845046997*x_97 - 7.4031195640564) + 0.126742852231438*std::sin(0.45839986205101*x_99 + 2.04295969009399)) + 0.0346496262385058*std::sin(0.215440005064011*x_1 - 7.3842396736145) + 0.00628984210582101*std::sin(0.301679849624634*x_10 + 5.10400009155273) + 0.006389550647029*std::sin(0.208000004291534*x_100 + 5.00311994552612) + 0.0106401615415675*std::sin(0.414799869060516*x_100 + 5.20456027984619) - 0.014312965368587*std::sin(0.319119840860367*x_101 + 5.146399974823) + 0.00306965314605182*std::sin(0.319359838962555*x_102 - 4.27135992050171) - 0.00114993685831238*std::sin(0.322719842195511*x_102 + 5.12976026535034) + 0.0105519823657606*std::sin(0.3503198325634*x_102 - 7.41847991943359) - 0.000868633829888358*std::sin(0.336479842662811*x_103 - 7.43991994857788) - 0.00890925396797813*std::sin(0.404639840126038*x_103 - 7.39447975158691) + 0.00172700708673276*std::sin(0.442559868097305*x_103 + 5.23320007324219) + 0.00242044723306703*std::sin(0.276479959487915*x_104 - 7.50216007232666) - 0.00114969219119936*std::sin(0.437759846448898*x_105 - 1.18407988548279) - 0.0010913654006226*std::sin(0.360079854726791*x_106 + 5.16480016708374) + 0.00217163547615114*std::sin(0.365039855241776*x_107 - 7.41479969024658) + 0.00438145425624761*std::sin(0.426959842443466*x_107 + 5.22248029708862) - 0.00271184416803044*std::sin(0.211359992623329*x_108 + 5.00783967971802) + 0.000991374678384908*std::sin(0.301119923591614*x_108 - 4.28095960617065) + 0.00678926813526698*std::sin(0.353679835796356*x_108 - 7.44871950149536) + 0.0111431011222633*std::sin(0.323999851942062*x_109 + 5.12048006057739) - 0.000793420911426342*std::sin(0.359439849853516*x_109 + 5.17456007003784) - 0.00173861973757745*std::sin(0.422879844903946*x_109 + 2.01311993598938) + 0.00323994281754091*std::sin(0.327679842710495*x_11 - 1.06183981895447) - 0.00144879818272865*std::sin(0.384719848632813*x_110 + 8.17407989501953) - 0.00367215121592254*std::sin(0.390239834785461*x_110 + 5.18304014205933) + 0.00651500405354748*std::sin(0.456639856100082*x_110 + 2.05167984962463) - 0.00217507398638055*std::sin(0.480879843235016*x_111 - 7.34032011032104) + 0.00368594952502389*std::sin(0.48431983590126*x_111 + 5.24575996398926) - 0.00273216221832581*std::sin(0.364639848470688*x_112 + 5.16183996200562) + 0.0085235701030601*std::sin(0.380959838628769*x_112 - 7.40343999862671) - 0.00384227343738209*std::sin(0.366319835186005*x_113 - 7.42911958694458) + 0.00502401072780715*std::sin(0.393599838018417*x_114 + 1.99799978733063) + 0.0019806674100065*std::sin(0.44159984588623*x_114 - 7.38136005401611) - 0.00200161315272149*std::sin(0.355759829282761*x_115 - 1.24439990520477) + 0.00224798661703585*std::sin(0.36847984790802*x_115 + 8.36911964416504) + 0.00558757516821138*std::sin(0.306239932775497*x_117 - 4.28335952758789) - 0.0110123412531934*std::sin(0.380719840526581*x_117 + 5.18304014205933) - 0.00177551274487209*std::sin(0.478159844875336*x_117 + 2.04239964485168) + 0.00149393556022586*std::sin(0.334479838609695*x_118 - 4.26528024673462) - 0.0148605332513472*std::sin(0.365839838981628*x_118 + 5.15880012512207) - 0.00352247954175599*std::sin(0.393759846687317*x_118 + 5.18567991256714) + 0.0111783963871114*std::sin(0.397039830684662*x_119 + 1.97919988632202) - 0.00657823284386413*std::sin(0.423359870910645*x_12 + 8.41808032989502) - 0.000639574821255466*std::sin(0.426879853010178*x_120 + 2.20191979408264) - 0.0056785113090474*std::sin(0.4859998524189*x_120 + 2.06983971595764) - 0.00105038467412739*std::sin(0.270879954099655*x_14 + 1.8879998922348) + 0.00696646571952886*std::sin(0.306239932775497*x_14 + 5.15127992630005) + 0.010882219921276*std::sin(0.431279867887497*x_15 - 0.968239843845367) - 0.000165635638507244*std::sin(1.49863994121552*x_15 - 2.5971200466156) + 0.00911100719737157*std::sin(0.258959949016571*x_18 + 5.06335973739624) - 0.0088957555895698*std::sin(0.263439953327179*x_21 - 1.12615990638733) + 0.00482869556512178*std::sin(0.30991992354393*x_21 - 4.27695989608765) - 0.00355675210558315*std::sin(0.325759828090668*x_21 - 4.2579197883606) - 0.00551745726706512*std::sin(0.271119952201843*x_23 + 5.0798397064209) + 0.00865536862623191*std::sin(0.310719907283783*x_23 - 4.24408006668091) + 0.00697747775121095*std::sin(0.325119823217392*x_26 - 4.25880002975464) + 0.00498825058481259*std::sin(0.326479852199554*x_26 + 8.31744003295898) - 6.12876308289942e-5*std::sin(1.74143981933594*x_27 - 1.98255980014801) + 0.00632178757862438*std::sin(0.347439825534821*x_28 + 8.35303974151611) + 0.00253093413032307*std::sin(0.361359834671021*x_28 + 8.34383964538574) - 0.000687486507121357*std::sin(0.810399830341339*x_29 + 5.61424016952515) - 0.000545505321134536*std::sin(1.04367983341217*x_29 + 6.00735950469971) + 0.00468601335233009*std::sin(0.306319922208786*x_3 + 8.31271934509277) - 0.0200611296136952*std::sin(0.338559836149216*x_3 + 8.35519981384277) + 0.00138720623565937*std::sin(0.330079823732376*x_30 + 8.34352016448975) + 0.0250245828474384*std::sin(0.259839981794357*x_32 + 5.17312002182007) - 0.00701127879130485*std::sin(0.271519958972931*x_32 - 7.43567991256714) - 0.00166437303612745*std::sin(0.311999946832657*x_32 - 4.44504022598267) + 0.0241286657235757*std::sin(0.279199957847595*x_33 - 1.16039991378784) - 0.002893372890862*std::sin(0.292239934206009*x_33 + 8.22999954223633) - 0.00792711700388605*std::sin(0.277199953794479*x_34 - 1.12231993675232) - 0.00473162113468185*std::sin(0.357199847698212*x_34 - 7.39351987838745) - 0.00419009263756118*std::sin(0.386319845914841*x_34 + 1.9748797416687) - 0.00167237156499925*std::sin(0.272719949483871*x_35 - 1.1399998664856) - 0.0127928608535731*std::sin(0.316399842500687*x_35 - 7.42007970809937) + 0.00303794232479512*std::sin(0.343759834766388*x_36 - 7.44807958602905) + 0.0144961941819651*std::sin(0.363919854164124*x_36 - 4.23432016372681) - 0.00276588280812734*std::sin(0.358239859342575*x_37 + 5.17824029922485) + 0.0072665428948471*std::sin(0.450879871845245*x_37 + 2.03239989280701) - 0.00889877252965557*std::sin(0.165120020508766*x_38 - 7.63992023468018) + 0.00945839921900112*std::sin(0.249279975891113*x_38 + 5.06663990020752) + 0.00237421049161172*std::sin(0.271279960870743*x_39 + 8.28528022766113) - 0.00419111339248501*std::sin(0.306399941444397*x_40 + 5.12367963790894) + 0.0145498082032339*std::sin(0.315039843320847*x_40 - 4.28247976303101) - 0.00364862910695022*std::sin(0.330479830503464*x_41 + 5.14264011383057) + 0.00941755594078086*std::sin(0.365519851446152*x_41 - 7.41623973846436) + 0.00946593379240311*std::sin(0.348079830408096*x_42 - 1.23199987411499) + 0.00288521226367265*std::sin(0.358479857444763*x_42 + 1.97983980178833) - 0.00979962885335241*std::sin(0.356159836053848*x_43 + 5.15208005905151) + 0.00254231785285058*std::sin(0.29351994395256*x_44 - 4.27183961868286) + 0.00327003805785854*std::sin(0.220559984445572*x_45 + 8.22208023071289) + 0.00586450051688542*std::sin(0.466559857130051*x_45 + 5.24775981903076) + 0.00551705703777909*std::sin(0.195199996232986*x_46 + 4.97847986221313) - 0.00420887515359401*std::sin(0.439439862966537*x_46 - 4.14663982391357) - 0.000618104530097709*std::sin(0.624079823493958*x_47 - 7.38527965545654) - 0.00533242499741401*std::sin(0.509759843349457*x_48 + 8.27455902099609) + 0.000774313692056991*std::sin(0.589999854564667*x_48 - 7.40863990783691) + 0.0017888848483648*std::sin(0.219999998807907*x_49 - 1.36087989807129) + 0.00345237005543461*std::sin(0.326879858970642*x_49 - 4.26919984817505) + 0.00194138290750878*std::sin(0.506479859352112*x_49 + 8.28087997436523) + 0.0248251266105613*std::sin(0.304159939289093*x_50 - 7.47200012207031) + 0.00288984663831434*std::sin(0.375439822673798*x_50 - 4.23304033279419) - 0.00141133838141999*std::sin(0.428159862756729*x_50 - 1.17399990558624) - 0.0111102618330002*std::sin(0.352479845285416*x_51 + 5.1418399810791) + 0.00610511380075249*std::sin(0.233919993042946*x_52 + 8.23464012145996) + 0.0156462269966439*std::sin(0.131200045347214*x_53 - 7.68440008163452) + 0.00283775134393545*std::sin(0.231279999017715*x_53 - 7.54808044433594) + 0.00542291742667756*std::sin(0.295199930667877*x_53 - 4.27360010147095) + 0.0034396087202129*std::sin(0.198559984564781*x_55 - 4.39231967926025) + 0.0121800846328254*std::sin(0.308479934930801*x_55 - 7.46504020690918) + 0.00361185961590076*std::sin(0.363439828157425*x_56 + 5.15592002868652) - 0.000784767727321215*std::sin(0.319519847631454*x_57 - 7.47119998931885) - 0.00291583541865595*std::sin(0.366719841957092*x_57 + 8.35023975372314) + 0.00848112718202516*std::sin(0.41023987531662*x_57 + 5.21224021911621) + 0.00190163704150415*std::sin(0.250159978866577*x_58 - 7.52272033691406) - 0.00188945185534577*std::sin(0.389519840478897*x_58 + 1.97375977039337) + 0.0114949548928536*std::sin(0.314319908618927*x_59 + 5.13312005996704) - 0.0083158619995197*std::sin(0.228319987654686*x_60 + 5.03671979904175) - 0.0128324674816751*std::sin(0.344799846410751*x_60 - 4.26503992080688) + 0.00268485901710195*std::sin(0.324959844350815*x_62 + 8.3133602142334) + 0.00840909584325411*std::sin(0.206400007009506*x_64 - 4.40303993225098) + 0.00320001079008551*std::sin(0.196719989180565*x_65 + 5.00432014465332) - 0.00694987709908557*std::sin(0.201039999723434*x_67 + 5.00600004196167) - 0.0286900121478357*std::sin(0.202800005674362*x_67 - 7.58416032791138) + 0.00492514290998386*std::sin(0.225759983062744*x_67 + 5.03471994400024) - 0.0228827658914764*std::sin(0.225199997425079*x_69 + 5.02031993865967) - 0.00719522749166039*std::sin(0.251279979944229*x_69 + 5.05583953857422) + 0.00433607589717008*std::sin(0.262479960918427*x_69 + 5.07775974273682) + 0.017326718525906*std::sin(0.13864004611969*x_70 - 7.66880035400391) - 0.0024040159470763*std::sin(0.344799846410751*x_74 - 4.25688028335571) + 0.00400497844356063*std::sin(0.365679830312729*x_74 + 1.94711983203888) - 4.44016796109777e-5*std::sin(0.873279869556427*x_75 + 2.20911979675293) - 0.00784351071107124*std::sin(0.31399992108345*x_77 - 7.46776008605957) - 0.0158480664318657*std::sin(0.255599975585938*x_79 + 5.07967948913574) + 0.0058204859275773*std::sin(0.255679965019226*x_79 + 5.05535984039307) + 0.00561674669613976*std::sin(0.266479969024658*x_8 + 5.09807968139648) + 0.00146010326600816*std::sin(0.474159836769104*x_80 + 8.48776054382324) + 0.00201376690196722*std::sin(0.275119960308075*x_82 - 7.49600028991699) - 0.0112941374333647*std::sin(0.326799839735031*x_82 + 5.12800025939941) - 0.011111948099072*std::sin(0.270079970359802*x_83 + 5.10271978378296) - 0.00207437719546137*std::sin(0.410399854183197*x_83 - 7.39120006561279) + 0.00124733948221677*std::sin(0.510559856891632*x_83 + 8.3342399597168) + 0.00544327538743096*std::sin(0.234959989786148*x_84 + 5.02799987792969) - 0.00671602817137833*std::sin(0.305039942264557*x_84 + 5.14831972122192) + 0.00319658434383326*std::sin(0.319039851427078*x_84 - 4.2947998046875) - 0.0167980595677018*std::sin(0.265119940042496*x_85 + 5.06559991836548) + 0.00500914880714733*std::sin(0.242479979991913*x_87 + 5.03991985321045) + 0.0130487785443668*std::sin(0.148960039019585*x_88 - 7.65576028823853) + 0.0217410397651523*std::sin(0.12216005474329*x_9 + 8.07327938079834) - 0.00548459772315039*std::sin(0.497999846935272*x_9 + 2.30663990974426) + 0.000858989571834803*std::sin(0.446799844503403*x_90 - 4.16096019744873) - 0.0229438757119274*std::sin(0.168240025639534*x_91 + 5.22959995269775) - 0.0114132033810144*std::sin(0.179120019078255*x_91 + 5.2279200553894) + 0.00247353825612687*std::sin(0.324799835681915*x_92 + 2.19455981254578) - 0.00666966357960128*std::sin(0.336719840764999*x_92 + 5.20352029800415) - 0.000631497813543369*std::sin(0.384559839963913*x_93 + 1.77711987495422) + 0.0108717632566674*std::sin(0.394639849662781*x_93 + 1.99383985996246) - 0.00190049193985355*std::sin(0.343359857797623*x_94 + 1.96759986877441) - 0.00648300377240331*std::sin(0.370159834623337*x_94 - 7.40679979324341) - 0.00904927675067524*std::sin(0.367199838161469*x_95 + 5.17216014862061) - 0.00244311955028905*std::sin(0.385119825601578*x_95 - 7.39695978164673) - 0.00498936224994554*std::sin(0.368079841136932*x_96 + 5.16943979263306) - 0.00325564121395908*std::sin(0.383679836988449*x_96 - 7.40807962417603) + 0.0140603191519092*std::sin(0.345919847488403*x_97 + 5.16247987747192) + 0.00280907679469792*std::sin(0.352719843387604*x_98 - 4.2403998374939) - 0.00372703741082256*std::sin(0.444959849119186*x_98 + 2.03095984458923) - 0.00816119119423893*std::sin(0.310319930315018*x_99 - 7.48432016372681) + 0.566565334796906*std::sin(-0.00170759916718799*x_10 + 0.00810738789965087*x_100 - 0.00370495059213823*x_101 - 0.0053261313733982*x_103 + 0.00908492492999212*x_104 - 0.0103357371378385*x_110 + 0.00832903759701888*x_111 + 0.017163570151603*x_113 - 0.00446279503980871*x_115 + 0.000102725069971348*x_116 - 0.00261259655356231*x_117 - 0.00162045457933083*x_13 - 0.000471162672846542*x_14 - 0.00995683237238331*x_15 - 0.0188663274723279*x_16 + 0.00415123664820243*x_17 - 0.00319812338697301*x_18 - 0.0185747022491261*x_2 + 0.0297443880001245*x_20 + 0.00442352653035023*x_21 - 0.00340254632147863*x_22 + 0.0133164717486197*x_23 + 0.0123598253644411*x_25 + 0.003682386233484*x_28 + 0.00233348337312409*x_29 + 0.00554314936269865*x_30 + 0.028851004805849*x_31 + 0.00930107491198734*x_32 - 0.0025530290935133*x_34 + 0.0214703280388394*x_4 - 0.0139535954693058*x_40 - 0.00081558438838868*x_44 - 0.00866937706691559*x_48 - 0.00183197202461544*x_5 - 0.0012947595599903*x_52 - 0.0025677328434418*x_54 + 0.0112307569669915*x_6 - 0.00391871234305732*x_60 + 0.00161750930174643*x_61 - 0.0114174430206499*x_62 + 0.0126407985918455*x_63 - 0.00504450230315934*x_65 + 0.0130601967732929*x_68 + 0.000616703529650576*x_7 + 0.00483014196782265*x_72 + 0.000970299399382251*x_73 + 0.000493857963310356*x_78 + 0.00701872541878725*x_8 + 0.00207415370694746*x_82 + 0.00437807299802255*x_88 - 0.00303190673614862*x_89 + 0.00489486030667887*x_9 + 0.00555521585752939*x_90 + 0.017953318691198*x_91 + 0.0279837768995897*x_92 - 0.000259671144183326*x_95 + 0.00603222999404641*x_97 - 8.6872757016531e-5*std::pow(-4.51200008392334*x_38 - 6.96360015869141, 2) - 0.000101439390184708*std::pow(-6.62088012695313*x_69 - 9.43920040130615, 2) - 0.000132886295643115*std::pow(-3.69936013221741*x_80 - 6.42208003997803, 2) + 0.000115909919905055*std::pow(-7.45847988128662*x_81 - 9.67831993103027, 2) + 0.000920581658739213*std::pow(-1.03719985485077*x_84 - 2.28391981124878, 2) + 6.52681918448627e-5*std::pow(-6.90776014328003*x_86 - 7.71479988098145, 2) - 0.094097540784257*std::sin(0.364479839801788*x_1 - 4.37279987335205) + 0.0781476675664026*std::sin(0.320079833269119*x_102 - 4.26879978179932) - 0.116556316172048*std::sin(0.353279858827591*x_105 - 4.24919986724854) + 0.0398340843681937*std::sin(0.452639847993851*x_106 + 2.046719789505) - 0.0293357263523351*std::sin(0.382639855146408*x_107 + 5.18391990661621) - 0.116866960593999*std::sin(0.238799974322319*x_108 - 7.55640029907227) + 0.0881512513146649*std::sin(0.3643998503685*x_109 + 5.17935991287231) - 0.0543143613364259*std::sin(0.300399929285049*x_11 + 8.32439994812012) + 0.00878053637138354*std::sin(0.475119858980179*x_112 + 1.8407998085022) + 0.112139100076974*std::sin(0.373439848423004*x_114 - 7.42952013015747) - 0.0660540976983515*std::sin(0.372159838676453*x_118 + 1.98983991146088) + 0.162475144746779*std::sin(0.339599847793579*x_119 + 5.15136003494263) - 0.124277870003623*std::sin(0.359199851751328*x_12 + 5.17248010635376) + 0.107786550443339*std::sin(0.371839851140976*x_120 - 7.41567993164063) + 0.0111006331391929*std::sin(0.599039852619171*x_19 - 0.798399865627289) - 0.074422993570014*std::sin(0.376079827547073*x_24 + 8.37248039245605) - 0.150086076673038*std::sin(0.338239848613739*x_26 - 4.26504039764404) + 0.544686158563199*std::sin(0.213039994239807*x_27 - 7.5717601776123) + 0.126057190398766*std::sin(0.349679857492447*x_3 - 4.23496007919312) - 0.10494401253259*std::sin(0.218399986624718*x_33 - 7.38711977005005) - 0.107829718224818*std::sin(0.316319853067398*x_35 - 1.20743989944458) + 0.0953958974490776*std::sin(0.367839843034744*x_36 + 5.17136001586914) + 0.0771753358694411*std::sin(0.403439849615097*x_37 - 4.20223999023438) - 0.0807674985808351*std::sin(0.30295991897583*x_39 - 4.30272006988525) + 0.0745850559537393*std::sin(0.357199847698212*x_41 - 7.43991994857788) - 0.136020588742872*std::sin(0.303599923849106*x_42 + 5.09543991088867) + 0.0889542436272333*std::sin(0.377679854631424*x_43 + 5.18800020217896) - 0.116869968534556*std::sin(0.296639919281006*x_45 + 5.11967945098877) + 0.185928082833534*std::sin(0.290079951286316*x_46 + 5.11967992782593) + 0.0999820609589532*std::sin(0.376559853553772*x_47 + 5.1625599861145) + 0.115038413930873*std::sin(0.352319836616516*x_49 - 4.23863983154297) + 0.0500663482884964*std::sin(0.350559860467911*x_50 + 5.15431976318359) + 0.0431136087253692*std::sin(0.321599841117859*x_51 - 7.47175979614258) - 0.0248382885678151*std::sin(0.334159851074219*x_53 - 1.068079829216) + 0.0993323884040151*std::sin(0.317279845476151*x_55 - 4.28736019134521) + 0.0350600502594023*std::sin(0.342239856719971*x_56 + 5.13784027099609) - 0.0892637717879579*std::sin(0.373519837856293*x_57 - 4.21056032180786) - 0.036328372254312*std::sin(0.463439851999283*x_58 - 1.13231992721558) - 0.0357005988700019*std::sin(0.307839930057526*x_59 - 7.46871995925903) + 0.153497081264762*std::sin(0.238079980015755*x_64 - 4.35223960876465) - 0.16015586067679*std::sin(0.199680000543594*x_66 + 4.99975967407227) + 0.00928427374796981*std::sin(0.343759834766388*x_67 - 4.43192005157471) + 0.034712175117114*std::sin(0.345999836921692*x_70 - 1.06407976150513) + 0.0560673856846585*std::sin(0.298959940671921*x_71 + 5.11895942687988) - 0.11004979990397*std::sin(0.33111983537674*x_74 - 4.27975988388062) + 0.0682709797126897*std::sin(0.241279974579811*x_75 - 7.54800033569336) - 0.0514018057272136*std::sin(0.358159840106964*x_76 - 4.25072002410889) + 0.516137990720786*std::sin(0.144800037145615*x_77 - 7.65912008285522) - 0.122654988080683*std::sin(0.257119983434677*x_79 + 5.05615997314453) - 0.0838624904714269*std::sin(0.276319950819016*x_83 + 5.11303997039795) + 0.018425536112499*std::sin(0.50791984796524*x_85 - 0.885199844837189) + 0.156601872395129*std::sin(0.195919990539551*x_87 + 1.79983985424042) - 0.068050863224105*std::sin(0.285359919071198*x_93 + 8.27120018005371) - 0.141763820922166*std::sin(0.390079855918884*x_94 - 7.40775966644287) - 0.0484309531624172*std::sin(0.409599870443344*x_96 - 7.38104009628296) + 0.114875235285921*std::sin(0.407839864492416*x_98 + 2.00023984909058) - 0.0496623810195733*std::sin(0.42783984541893*x_99 - 1.18479979038239) + 2.83283181641385) - 0.465092661738234);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000394129899933816*x_1 - 0.000607497413484362*x_10 + 0.0018740424484284*x_100 - 0.00125109815543725*x_101 - 0.00123114823210621*x_103 + 0.00239704568985447*x_104 - 3.05186876095358e-5*x_105 - 9.11034919819214e-5*x_106 - 0.000193860405296723*x_107 - 4.64786413757374e-5*x_11 - 0.00238913079919874*x_110 + 0.00140255622463835*x_111 + 5.94063847838648e-5*x_112 + 0.00422139864696341*x_113 - 7.60819913764555e-5*x_114 - 0.00102927525190321*x_115 + 0.000329749495414716*x_116 - 0.000603908053073957*x_117 - 1.23791083391809e-5*x_119 - 0.00129875047502326*x_12 + 1.17866952393017e-5*x_120 - 0.00015314566563392*x_13 - 0.000214736847812154*x_14 - 0.00227515068492873*x_15 - 0.00425277952324619*x_16 + 0.000696381068346369*x_17 - 0.000822718677797778*x_18 - 2.59853363526464e-5*x_19 - 0.00400202692618879*x_2 + 0.00704779233388316*x_20 + 0.00102250892546815*x_21 - 0.00138447309745167*x_22 + 0.00309790732278595*x_23 + 3.56827069213099e-5*x_24 + 0.00279892373580614*x_25 + 2.92222696814494e-5*x_26 + 9.23402019572465e-6*x_27 + 0.000842907871062337*x_28 + 0.000745212333608081*x_29 + 0.0001955727654057*x_3 + 0.00113587775390754*x_30 + 0.00590937624965744*x_31 + 0.00214996610706481*x_32 - 0.000291675343118473*x_33 - 0.000590138889681426*x_34 - 0.000110802656003304*x_35 + 2.21380415749975e-5*x_36 - 6.3358105264452e-5*x_37 - 6.4936884324154e-5*x_38 + 0.000227060157281199*x_39 + 0.00500541921590048*x_4 - 0.00322862492887128*x_40 - 0.000133027759777059*x_41 - 0.000128924740472912*x_42 + 3.505843983155e-5*x_43 - 0.000190107359402069*x_44 + 0.000100391905875703*x_45 + 8.07866189765977e-5*x_46 + 0.000151114684168707*x_47 - 0.00188581587789686*x_48 - 0.00012821748227152*x_5 + 6.85576418221411e-6*x_51 - 0.000236941467292642*x_52 - 0.000344328182753062*x_54 - 1.13237613394789e-5*x_56 + 0.000137083480544861*x_58 - 0.000103450348381958*x_59 + 0.00240875613910246*x_6 - 0.000905819897230521*x_60 + 0.000822404229167254*x_61 - 0.00244509925684836*x_62 + 0.00283674169120585*x_63 + 0.000118216685328456*x_64 - 0.000824919385436713*x_65 - 6.18313676200448e-5*x_66 + 0.00278741593878964*x_68 + 0.000299275025871539*x_7 - 1.11067562909765e-5*x_70 + 0.00132360556696547*x_72 + 0.000318398429820144*x_73 + 8.0997079247079e-5*x_74 + 3.14082978554239e-5*x_75 - 3.81427383596614e-5*x_76 + 0.000225139749400184*x_77 + 7.46929319647866e-5*x_78 + 3.62078764182e-5*x_79 + 0.00162130146993811*x_8 - 8.24977241275414e-5*x_80 - 1.12846802667792e-5*x_81 + 0.000479445678373431*x_82 - 0.00033094983599861*x_85 - 7.81212150010199e-5*x_86 - 1.90896042982276e-6*x_87 + 0.00110874755978313*x_88 - 0.000778940949581394*x_89 + 0.00117955540285581*x_9 + 0.00134278836179726*x_90 + 0.00402002299433992*x_91 + 0.00647343693807645*x_92 - 1.7191872939603e-5*x_93 - 0.000141032831152746*x_94 - 2.43615967276746e-5*x_95 + 9.71266643450132e-5*x_96 + 0.00124371775411889*x_97 + 7.8249437698012e-5*x_98 - 0.000237904148467304*x_99 - 2.31262734007213e-6*std::pow(-4.47631978988647*x_100 - 6.92568016052246, 2) + 1.4203339368343e-5*std::pow(-3.50639986991882*x_17 - 5.15751981735229, 2) - 6.99405783657415e-6*std::pow(-4.37183952331543*x_18 - 6.95983982086182, 2) + 5.43131877253809e-6*std::pow(-3.88375997543335*x_19 - 6.13335990905762, 2) - 1.52979246413302e-6*std::pow(-5.80399990081787*x_22 - 9.99647998809814, 2) - 1.71607324573523e-6*std::pow(-4.18495988845825*x_24 - 7.37408018112183, 2) - 0.00010486649853572*std::pow(-0.866319835186005*x_24 - 1.30367994308472, 2) - 6.85840979471512e-6*std::pow(-6.56744050979614*x_27 - 9.54936027526855, 2) - 2.00808492545418e-5*std::pow(-4.51200008392334*x_38 - 6.96360015869141, 2) + 3.44460487429897e-6*std::pow(-5.81879997253418*x_4 - 9.82336044311523, 2) - 9.54468168843463e-7*std::pow(-5.71783971786499*x_43 - 8.27400016784668, 2) - 2.03493354235117e-6*std::pow(-4.35264015197754*x_55 - 6.33048009872437, 2) + 4.92641961171077e-6*std::pow(-3.86879992485046*x_6 - 6.51087999343872, 2) - 2.34221122518701e-6*std::pow(-5.42744016647339*x_60 - 8.43583965301514, 2) - 6.85911935026084e-7*std::pow(-5.41200017929077*x_64 - 9.21903991699219, 2) + 9.80578547759167e-7*std::pow(-6.89007997512817*x_66 - 9.33463954925537, 2) - 2.34479619702197e-5*std::pow(-6.62088012695313*x_69 - 9.43920040130615, 2) + 1.87574335674571e-6*std::pow(-5.21744012832642*x_7 - 9.23895931243896, 2) + 7.98303953175033e-6*std::pow(-5.09847974777222*x_7 - 7.94231986999512, 2) + 1.00268717688349e-6*std::pow(-6.25472021102905*x_71 - 9.68151950836182, 2) - 1.77282745436732e-6*std::pow(-5.8854398727417*x_71 - 9.54551982879639, 2) + 1.3877307886191e-6*std::pow(-4.14160013198853*x_71 - 6.69736003875732, 2) + 2.78772633183777e-6*std::pow(-5.3120002746582*x_73 - 7.55503988265991, 2) - 5.93903669521181e-6*std::pow(-1.42991983890533*x_75 - 1.61055982112885, 2) - 9.59900622465609e-7*std::pow(-6.52383947372437*x_77 - 9.1627197265625, 2) - 1.90883279794496e-6*std::pow(-7.06584024429321*x_78 - 9.41096019744873, 2) + 1.0128011211474e-6*std::pow(-6.66368007659912*x_78 - 9.21712017059326, 2) - 3.07169907166187e-5*std::pow(-3.69936013221741*x_80 - 6.42208003997803, 2) + 1.03110666794255e-5*std::pow(-1.82767987251282*x_80 - 2.43895983695984, 2) + 2.67928601399919e-5*std::pow(-7.45847988128662*x_81 - 9.67831993103027, 2) + 1.05958478740788e-6*std::pow(-9.20399951934814*x_82 - 9.99767971038818, 2) + 0.000212794691345187*std::pow(-1.03719985485077*x_84 - 2.28391981124878, 2) + 4.02499619213601e-7*std::pow(-8.02295970916748*x_86 - 9.42399978637695, 2) + 1.50869014241576e-5*std::pow(-6.90776014328003*x_86 - 7.71479988098145, 2) + 2.65864294021541e-6*std::pow(-5.18376016616821*x_87 - 7.56544017791748, 2) - 1.14095181995162e-6*std::pow(-7.48543977737427*x_89 - 9.05047988891602, 2) - 1.75763965886267e-6*std::pow(-5.15536022186279*x_89 - 6.94384002685547, 2) + 4.80206001208425e-6*std::pow(-5.88768005371094*x_90 - 8.31655979156494, 2) + 0.000253132197357818*std::exp(0.82207989692688*x_25) - 7.95836166076473e-6*std::exp(0.0248535536713992*x_1 - 0.0272007454460205*x_10 - 0.0150009724791282*x_101 - 0.00523518983342214*x_102 - 0.00197279403261503*x_103 + 0.00413974696627094*x_105 + 0.00767880963133377*x_11 - 0.00257678814578817*x_111 + 0.0185023617762207*x_113 - 0.016753357809851*x_119 - 0.0253793339683615*x_12 - 0.00419911143916508*x_15 + 0.0144132541472161*x_17 + 0.0346682384472993*x_19 - 0.0555586359093562*x_2 - 0.0917137859718005*x_20 - 0.0466547266843218*x_22 - 0.00461999395523764*x_25 - 0.0113964921315045*x_29 - 0.0228222133113601*x_3 + 0.0262601574308026*x_33 + 0.0049680571025498*x_37 + 0.0358942145051428*x_41 - 0.00810634929481457*x_43 - 0.00802554456557561*x_44 + 0.0330953272415901*x_47 - 0.00458610322372773*x_48 - 0.00639583381192065*x_53 - 0.00670261142795104*x_54 - 0.00553541030501092*x_55 + 0.0281233140658821*x_6 + 0.00477441463482*x_60 - 0.0302498722224535*x_61 + 0.0277553292907787*x_62 + 0.0258093014115559*x_63 + 0.00862251814653156*x_64 - 0.0217799775509298*x_68 - 0.0137855932223281*x_73 - 0.0045572542215498*x_74 + 0.0259578675803257*x_76 - 0.0184614330989849*x_78 - 0.0060903445011262*x_84 - 0.00151438260457433*x_86 + 0.0613296872253953*x_9 + 0.00302200438011763*x_90 - 0.0975889030084091*x_91 - 0.00299709222972004*x_92 + 0.0186525216995675*x_93 + 0.00839531890360416*x_98 + 0.00209726384022835*std::pow(-3.90320014953613*x_4 - 6.1637601852417, 2) + 0.000913435078452984*std::pow(-5.93743944168091*x_5 - 9.30079936981201, 2) + 0.00165703938721296*std::pow(-3.91991996765137*x_7 - 6.46479988098145, 2) + 0.000508628146781653*std::pow(-5.71959972381592*x_71 - 8.97583961486816, 2) - 0.000623807504218976*std::pow(-4.71984004974365*x_80 - 6.09327983856201, 2) - 0.000440922943382771*std::pow(-7.05999994277954*x_81 - 9.27960014343262, 2) - 0.000522120898184819*std::pow(-5.27831983566284*x_85 - 8.4093599319458, 2) - 0.000211546899131665*std::pow(-7.40399980545044*x_87 - 9.99079990386963, 2) - 0.000321446069630804*std::pow(-5.38815975189209*x_88 - 7.58616018295288, 2) + 0.243239077785631*std::sin(0.426559865474701*x_100 + 5.22328042984009) - 0.198497844986193*std::sin(0.431439846754074*x_104 - 7.38263988494873) - 0.32696295511451*std::sin(0.281599938869476*x_106 + 5.08271980285645) - 0.387146363551437*std::sin(0.361199855804443*x_107 + 5.15944004058838) - 0.156656478616725*std::sin(0.575359880924225*x_108 - 7.20560026168823) + 0.084867007183739*std::sin(0.527999877929688*x_109 + 8.36816024780273) + 0.224447847262013*std::sin(0.398719817399979*x_110 + 2.0097599029541) + 0.301925164686082*std::sin(0.352079838514328*x_112 - 7.44328022003174) - 0.551958463017627*std::sin(0.311119943857193*x_114 + 5.11175966262817) + 0.067630485827479*std::sin(0.574719846248627*x_115 - 4.20968008041382) - 0.156228676275248*std::sin(0.682319819927216*x_116 + 8.42623996734619) - 0.277772676689381*std::sin(0.461359858512878*x_117 - 7.3459997177124) - 0.235586797756326*std::sin(0.341599822044373*x_118 - 7.44719982147217) - 0.333029514108972*std::sin(0.34639984369278*x_120 + 5.15912008285522) + 2.85750874168957*std::sin(0.171840012073517*x_13 + 8.15135955810547) + 0.927706334293703*std::sin(0.212640002369881*x_14 + 5.00903987884521) - 0.285764946579292*std::sin(0.41951984167099*x_16 - 7.36879968643188) - 1.66468918992837*std::sin(0.185440003871918*x_18 - 7.60567998886108) + 0.115984824655769*std::sin(0.398319840431213*x_21 - 7.18815994262695) + 0.399919437341396*std::sin(0.217999994754791*x_23 - 7.5860800743103) - 0.301922603155191*std::sin(0.264239966869354*x_24 + 8.05335998535156) - 0.41525564297956*std::sin(0.320399850606918*x_26 + 8.32015991210938) - 0.639645535605155*std::sin(0.279119938611984*x_27 + 5.103759765625) + 0.197159058197542*std::sin(0.417199850082397*x_28 + 8.41736030578613) + 0.206323375224642*std::sin(0.29751992225647*x_30 - 7.49848031997681) - 0.70104879308127*std::sin(0.20040000975132*x_31 - 7.39463949203491) + 0.361990876115073*std::sin(0.210400000214577*x_32 - 1.00415980815887) + 0.288689707887613*std::sin(0.369359821081161*x_34 + 1.97839987277985) + 0.452808806517226*std::sin(0.315359860658646*x_35 + 1.97319984436035) - 0.452193291990113*std::sin(0.366559833288193*x_36 + 5.16152000427246) - 0.508000138120792*std::sin(0.308319836854935*x_38 + 5.11079978942871) - 0.320004796591547*std::sin(0.301999926567078*x_39 + 5.10551977157593) + 0.459043839533024*std::sin(0.394879847764969*x_40 + 5.19040012359619) + 0.249259849415409*std::sin(0.417839854955673*x_42 - 1.1794399023056) + 0.243504943346068*std::sin(0.388719856739044*x_45 + 1.97711980342865) + 0.15391681459792*std::sin(0.44871985912323*x_46 + 5.24927997589111) + 0.00769779473103238*std::sin(1.97479975223541*x_49 - 7.4031195640564) - 0.213496849096856*std::sin(0.436799854040146*x_50 + 5.22847986221313) + 0.417962754209952*std::sin(0.276399940252304*x_51 - 4.30975961685181) + 0.0357845298522825*std::sin(0.71399986743927*x_52 - 1.22463989257813) - 0.815140766480056*std::sin(0.203759998083115*x_56 + 5.00360012054443) - 0.779321118973144*std::sin(0.229999989271164*x_57 - 4.37119960784912) - 0.501550523527612*std::sin(0.266959935426712*x_58 + 5.07175970077515) + 0.223098360745368*std::sin(0.303439915180206*x_59 + 5.13167953491211) + 0.530825459607001*std::sin(0.273279964923859*x_65 + 5.09200000762939) - 0.575341664585892*std::sin(0.221759989857674*x_66 + 5.03087949752808) + 0.408949580846752*std::sin(0.244639977812767*x_67 + 5.04016017913818) + 0.418084026688092*std::sin(0.269839972257614*x_69 + 5.09832000732422) - 0.494079071569672*std::sin(0.289679944515228*x_70 - 7.4759202003479) - 0.200764292855425*std::sin(0.34487983584404*x_72 - 1.04951989650726) - 0.689247873629824*std::sin(0.207840010523796*x_75 - 7.58039999008179) - 0.516668198561604*std::sin(0.293919950723648*x_77 + 5.11543989181519) + 0.10677885606907*std::sin(0.320879846811295*x_79 + 5.12488031387329) - 0.560384085232613*std::sin(0.325599819421768*x_8 - 4.28672027587891) - 0.943388560063113*std::sin(0.214560002088547*x_82 + 5.02231979370117) - 0.207843430347779*std::sin(0.375839829444885*x_83 + 8.19039916992188) + 0.189571016560123*std::sin(0.357119828462601*x_89 + 5.16175985336304) + 0.25371488528782*std::sin(0.406239867210388*x_94 - 7.39663982391357) + 0.204230431049382*std::sin(0.381119847297668*x_95 + 5.19063997268677) + 0.142433444929168*std::sin(0.406319856643677*x_96 - 7.39271974563599) + 0.297183183988608*std::sin(0.396479845046997*x_97 - 7.4031195640564) + 0.135179896533984*std::sin(0.45839986205101*x_99 + 2.04295969009399)) + 0.00460882932626122*std::sin(0.215440005064011*x_1 - 7.3842396736145) - 0.021750875609395*std::sin(0.364479839801788*x_1 - 4.37279987335205) + 0.00614476166528437*std::sin(0.301679849624634*x_10 + 5.10400009155273) + 0.0062421703460443*std::sin(0.208000004291534*x_100 + 5.00311994552612) + 0.00141527323300351*std::sin(0.414799869060516*x_100 + 5.20456027984619) - 0.00190380161917007*std::sin(0.319119840860367*x_101 + 5.146399974823) + 0.00299884904266873*std::sin(0.319359838962555*x_102 - 4.27135992050171) + 0.0180640235890793*std::sin(0.320079833269119*x_102 - 4.26879978179932) + 0.000464346237596797*std::sin(0.322719842195511*x_102 + 5.12976026535034) + 0.00140354431077424*std::sin(0.3503198325634*x_102 - 7.41847991943359) - 0.000848598068006735*std::sin(0.336479842662811*x_103 - 7.43991994857788) - 0.00118504109337537*std::sin(0.404639840126038*x_103 - 7.39447975158691) - 0.000697368066107779*std::sin(0.442559868097305*x_103 + 5.23320007324219) - 0.000977380242968903*std::sin(0.276479959487915*x_104 - 7.50216007232666) - 0.0269422762105987*std::sin(0.353279858827591*x_105 - 4.24919986724854) - 0.00112317358440852*std::sin(0.437759846448898*x_105 - 1.18407988548279) + 0.000440694994650531*std::sin(0.360079854726791*x_106 + 5.16480016708374) + 0.00920774556790206*std::sin(0.452639847993851*x_106 + 2.046719789505) - 0.000876909680295313*std::sin(0.365039855241776*x_107 - 7.41479969024658) - 0.00678102455688878*std::sin(0.382639855146408*x_107 + 5.18391990661621) + 0.000582787667863075*std::sin(0.426959842443466*x_107 + 5.22248029708862) + 0.00109504676476043*std::sin(0.211359992623329*x_108 + 5.00783967971802) - 0.0270140824249194*std::sin(0.238799974322319*x_108 - 7.55640029907227) + 0.000968507796727601*std::sin(0.301119923591614*x_108 - 4.28095960617065) + 0.000903056727662371*std::sin(0.353679835796356*x_108 - 7.44871950149536) + 0.00148217042470459*std::sin(0.323999851942062*x_109 + 5.12048006057739) + 0.000320384560585465*std::sin(0.359439849853516*x_109 + 5.17456007003784) + 0.0203763763237326*std::sin(0.3643998503685*x_109 + 5.17935991287231) - 0.00169851702701497*std::sin(0.422879844903946*x_109 + 2.01311993598938) - 0.0125548968377501*std::sin(0.300399929285049*x_11 + 8.32439994812012) + 0.00316521084122511*std::sin(0.327679842710495*x_11 - 1.06183981895447) - 0.00141538044742423*std::sin(0.384719848632813*x_110 + 8.17407989501953) + 0.00148282019893037*std::sin(0.390239834785461*x_110 + 5.18304014205933) + 0.000866576208817287*std::sin(0.456639856100082*x_110 + 2.05167984962463) + 0.000878298155911539*std::sin(0.480879843235016*x_111 - 7.34032011032104) + 0.000490276926773028*std::sin(0.48431983590126*x_111 + 5.24575996398926) - 0.00266914262394117*std::sin(0.364639848470688*x_112 + 5.16183996200562) + 0.00113374036374947*std::sin(0.380959838628769*x_112 - 7.40343999862671) + 0.00202964235628233*std::sin(0.475119858980179*x_112 + 1.8407998085022) + 0.00155151580851565*std::sin(0.366319835186005*x_113 - 7.42911958694458) + 0.0259212259576059*std::sin(0.373439848423004*x_114 - 7.42952013015747) + 0.000668255634804996*std::sin(0.393599838018417*x_114 + 1.99799978733063) - 0.00079979648718875*std::sin(0.44159984588623*x_114 - 7.38136005401611) - 0.00195544428026092*std::sin(0.355759829282761*x_115 - 1.24439990520477) - 0.000907740386129085*std::sin(0.36847984790802*x_115 + 8.36911964416504) - 0.00225627127949961*std::sin(0.306239932775497*x_117 - 4.28335952758789) - 0.00146477774303123*std::sin(0.380719840526581*x_117 + 5.18304014205933) - 0.00173455906640597*std::sin(0.478159844875336*x_117 + 2.04239964485168) - 0.000603253432211052*std::sin(0.334479838609695*x_118 - 4.26528024673462) - 0.00197663492763962*std::sin(0.365839838981628*x_118 + 5.15880012512207) - 0.0152685654752843*std::sin(0.372159838676453*x_118 + 1.98983991146088) - 0.00344123062086077*std::sin(0.393759846687317*x_118 + 5.18567991256714) + 0.0375565252136417*std::sin(0.339599847793579*x_119 + 5.15136003494263) + 0.00148686513196031*std::sin(0.397039830684662*x_119 + 1.97919988632202) - 0.0287271321749741*std::sin(0.359199851751328*x_12 + 5.17248010635376) - 0.000874986420837165*std::sin(0.423359870910645*x_12 + 8.41808032989502) + 0.024915123514589*std::sin(0.371839851140976*x_120 - 7.41567993164063) - 0.000624822495956551*std::sin(0.426879853010178*x_120 + 2.20191979408264) - 0.000755312316228097*std::sin(0.4859998524189*x_120 + 2.06983971595764) - 0.00102615667782931*std::sin(0.270879954099655*x_14 + 1.8879998922348) - 0.00281306936361503*std::sin(0.306239932775497*x_14 + 5.15127992630005) + 0.0014474699947056*std::sin(0.431279867887497*x_15 - 0.968239843845367) + 6.68839206229605e-5*std::sin(1.49863994121552*x_15 - 2.5971200466156) + 0.00890085423714004*std::sin(0.258959949016571*x_18 + 5.06335973739624) + 0.00256593837186133*std::sin(0.599039852619171*x_19 - 0.798399865627289) - 0.00118324564190824*std::sin(0.263439953327179*x_21 - 1.12615990638733) - 0.00194983455131198*std::sin(0.30991992354393*x_21 - 4.27695989608765) - 0.00347471265949275*std::sin(0.325759828090668*x_21 - 4.2579197883606) - 0.00539019252536245*std::sin(0.271119952201843*x_23 + 5.0798397064209) + 0.00115127119927915*std::sin(0.310719907283783*x_23 - 4.24408006668091) - 0.0172030561280195*std::sin(0.376079827547073*x_24 + 8.37248039245605) - 0.00281751603861542*std::sin(0.325119823217392*x_26 - 4.25880002975464) + 0.000663499092999606*std::sin(0.326479852199554*x_26 + 8.31744003295898) - 0.0346927619702844*std::sin(0.338239848613739*x_26 - 4.26504039764404) + 0.12590553145518*std::sin(0.213039994239807*x_27 - 7.5717601776123) + 2.47480377561166e-5*std::sin(1.74143981933594*x_27 - 1.98255980014801) + 0.000840876025218977*std::sin(0.347439825534821*x_28 + 8.35303974151611) + 0.00247255602918494*std::sin(0.361359834671021*x_28 + 8.34383964538574) - 0.000671629058931384*std::sin(0.810399830341339*x_29 + 5.61424016952515) - 7.25589622344166e-5*std::sin(1.04367983341217*x_29 + 6.00735950469971) + 0.00457792655617864*std::sin(0.306319922208786*x_3 + 8.31271934509277) - 0.00266837863834669*std::sin(0.338559836149216*x_3 + 8.35519981384277) + 0.0291384264156252*std::sin(0.349679857492447*x_3 - 4.23496007919312) + 0.00135520916985093*std::sin(0.330079823732376*x_30 + 8.34352016448975) + 0.00332857937660978*std::sin(0.259839981794357*x_32 + 5.17312002182007) - 0.00684955781347198*std::sin(0.271519958972931*x_32 - 7.43567991256714) + 0.00067207634201546*std::sin(0.311999946832657*x_32 - 4.44504022598267) - 0.0242580639570662*std::sin(0.218399986624718*x_33 - 7.38711977005005) + 0.00320941130576435*std::sin(0.279199957847595*x_33 - 1.16039991378784) + 0.00116834833680178*std::sin(0.292239934206009*x_33 + 8.22999954223633) - 0.00105440471619325*std::sin(0.277199953794479*x_34 - 1.12231993675232) - 0.00462248235709047*std::sin(0.357199847698212*x_34 - 7.39351987838745) + 0.00169196572609122*std::sin(0.386319845914841*x_34 + 1.9748797416687) - 0.00163379692364752*std::sin(0.272719949483871*x_35 - 1.1399998664856) - 0.0249251018523592*std::sin(0.316319853067398*x_35 - 1.20743989944458) - 0.00170160889652556*std::sin(0.316399842500687*x_35 - 7.42007970809937) - 0.00122672569224794*std::sin(0.343759834766388*x_36 - 7.44807958602905) + 0.00192817332011426*std::sin(0.363919854164124*x_36 - 4.23432016372681) + 0.0220509939129954*std::sin(0.367839843034744*x_36 + 5.17136001586914) + 0.00111686764912678*std::sin(0.358239859342575*x_37 + 5.17824029922485) + 0.0178392667504265*std::sin(0.403439849615097*x_37 - 4.20223999023438) + 0.000966540180369652*std::sin(0.450879871845245*x_37 + 2.03239989280701) + 0.0035933377676401*std::sin(0.165120020508766*x_38 - 7.63992023468018) + 0.00125808421135507*std::sin(0.249279975891113*x_38 + 5.06663990020752) - 0.000958709777039999*std::sin(0.271279960870743*x_39 + 8.28528022766113) - 0.0186696039053939*std::sin(0.30295991897583*x_39 - 4.30272006988525) - 0.00409444187560257*std::sin(0.306399941444397*x_40 + 5.12367963790894) + 0.00193530464879936*std::sin(0.315039843320847*x_40 - 4.28247976303101) + 0.00147332193585385*std::sin(0.330479830503464*x_41 + 5.14264011383057) + 0.0172405172425183*std::sin(0.357199847698212*x_41 - 7.43991994857788) + 0.00125265154962457*std::sin(0.365519851446152*x_41 - 7.41623973846436) - 0.0314414901962864*std::sin(0.303599923849106*x_42 + 5.09543991088867) + 0.00125908640291168*std::sin(0.348079830408096*x_42 - 1.23199987411499) + 0.00281866244267349*std::sin(0.358479857444763*x_42 + 1.97983980178833) - 0.00130347197787706*std::sin(0.356159836053848*x_43 + 5.15208005905151) + 0.0205619899514683*std::sin(0.377679854631424*x_43 + 5.18800020217896) - 0.00102659178302957*std::sin(0.29351994395256*x_44 - 4.27183961868286) - 0.0013204462992806*std::sin(0.220559984445572*x_45 + 8.22208023071289) - 0.0270147777177013*std::sin(0.296639919281006*x_45 + 5.11967945098877) + 0.000780051183815054*std::sin(0.466559857130051*x_45 + 5.24775981903076) - 0.00222779595208324*std::sin(0.195199996232986*x_46 + 4.97847986221313) + 0.0429777289427535*std::sin(0.290079951286316*x_46 + 5.11967992782593) - 0.000559832510311453*std::sin(0.439439862966537*x_46 - 4.14663982391357) + 0.0231110967721802*std::sin(0.376559853553772*x_47 + 5.1625599861145) + 0.00024959154141178*std::sin(0.624079823493958*x_47 - 7.38527965545654) - 0.000709278551491523*std::sin(0.509759843349457*x_48 + 8.27455902099609) + 0.000756453502617065*std::sin(0.589999854564667*x_48 - 7.40863990783691) + 0.0017476227312077*std::sin(0.219999998807907*x_49 - 1.36087989807129) - 0.0013940722348752*std::sin(0.326879858970642*x_49 - 4.26919984817505) + 0.0265914094125947*std::sin(0.352319836616516*x_49 - 4.23863983154297) + 0.00025822796517457*std::sin(0.506479859352112*x_49 + 8.28087997436523) + 0.00330204922740998*std::sin(0.304159939289093*x_50 - 7.47200012207031) + 0.0115729582809876*std::sin(0.350559860467911*x_50 + 5.15431976318359) - 0.00116692443070512*std::sin(0.375439822673798*x_50 - 4.23304033279419) - 0.00137878468759464*std::sin(0.428159862756729*x_50 - 1.17399990558624) + 0.00996581560625145*std::sin(0.321599841117859*x_51 - 7.47175979614258) - 0.00147780239261191*std::sin(0.352479845285416*x_51 + 5.1418399810791) + 0.00596429427224321*std::sin(0.233919993042946*x_52 + 8.23464012145996) - 0.00631797005719023*std::sin(0.131200045347214*x_53 - 7.68440008163452) + 0.00277229624853161*std::sin(0.231279999017715*x_53 - 7.54808044433594) + 0.000721315165073549*std::sin(0.295199930667877*x_53 - 4.27360010147095) - 0.00574143086510069*std::sin(0.334159851074219*x_53 - 1.068079829216) + 0.00336027128375478*std::sin(0.198559984564781*x_55 - 4.39231967926025) + 0.00162010207168486*std::sin(0.308479934930801*x_55 - 7.46504020690918) + 0.0229609233796397*std::sin(0.317279845476151*x_55 - 4.28736019134521) + 0.00810421596245351*std::sin(0.342239856719971*x_56 + 5.13784027099609) + 0.00352854906924229*std::sin(0.363439828157425*x_56 + 5.15592002868652) - 0.000766666406861464*std::sin(0.319519847631454*x_57 - 7.47119998931885) + 0.00117741873940053*std::sin(0.366719841957092*x_57 + 8.35023975372314) - 0.0206335381392893*std::sin(0.373519837856293*x_57 - 4.21056032180786) + 0.00112809492971761*std::sin(0.41023987531662*x_57 + 5.21224021911621) + 0.00185777420121649*std::sin(0.250159978866577*x_58 - 7.52272033691406) + 0.000762963508655323*std::sin(0.389519840478897*x_58 + 1.97375977039337) - 0.00839739167899206*std::sin(0.463439851999283*x_58 - 1.13231992721558) - 0.00825228033305025*std::sin(0.307839930057526*x_59 - 7.46871995925903) + 0.00152897133289592*std::sin(0.314319908618927*x_59 + 5.13312005996704) + 0.0033579576164887*std::sin(0.228319987654686*x_60 + 5.03671979904175) - 0.00170687706847796*std::sin(0.344799846410751*x_60 - 4.26503992080688) + 0.00262293051040392*std::sin(0.324959844350815*x_62 + 8.3133602142334) + 0.0082151330523082*std::sin(0.206400007009506*x_64 - 4.40303993225098) + 0.0354812239849058*std::sin(0.238079980015755*x_64 - 4.35223960876465) - 0.00129216918294631*std::sin(0.196719989180565*x_65 + 5.00432014465332) - 0.0370204170551422*std::sin(0.199680000543594*x_66 + 4.99975967407227) - 0.0067895724023623*std::sin(0.201039999723434*x_67 + 5.00600004196167) - 0.00381612685942317*std::sin(0.202800005674362*x_67 - 7.58416032791138) - 0.00198878013461873*std::sin(0.225759983062744*x_67 + 5.03471994400024) + 0.00214608247710389*std::sin(0.343759834766388*x_67 - 4.43192005157471) - 0.00304369120118839*std::sin(0.225199997425079*x_69 + 5.02031993865967) + 0.00290544371219548*std::sin(0.251279979944229*x_69 + 5.05583953857422) + 0.00423606069952631*std::sin(0.262479960918427*x_69 + 5.07775974273682) + 0.0169270633494324*std::sin(0.13864004611969*x_70 - 7.66880035400391) + 0.00802380377649786*std::sin(0.345999836921692*x_70 - 1.06407976150513) + 0.0129601126831469*std::sin(0.298959940671921*x_71 + 5.11895942687988) - 0.0254382791367331*std::sin(0.33111983537674*x_74 - 4.27975988388062) - 0.00234856531941489*std::sin(0.344799846410751*x_74 - 4.25688028335571) + 0.000532711723199304*std::sin(0.365679830312729*x_74 + 1.94711983203888) + 0.0157810031493478*std::sin(0.241279974579811*x_75 - 7.54800033569336) + 1.79294651887182e-5*std::sin(0.873279869556427*x_75 + 2.20911979675293) - 0.0118816525187868*std::sin(0.358159840106964*x_76 - 4.25072002410889) + 0.119306552964975*std::sin(0.144800037145615*x_77 - 7.65912008285522) - 0.00104328404402402*std::sin(0.31399992108345*x_77 - 7.46776008605957) - 0.00210798906842316*std::sin(0.255599975585938*x_79 + 5.07967948913574) + 0.00568623157773777*std::sin(0.255679965019226*x_79 + 5.05535984039307) - 0.0283519990679831*std::sin(0.257119983434677*x_79 + 5.05615997314453) + 0.00548719176115903*std::sin(0.266479969024658*x_8 + 5.09807968139648) + 0.000194211813582852*std::sin(0.474159836769104*x_80 + 8.48776054382324) - 0.000813162111959559*std::sin(0.275119960308075*x_82 - 7.49600028991699) - 0.0015022601242339*std::sin(0.326799839735031*x_82 + 5.12800025939941) - 0.00147802668687904*std::sin(0.270079970359802*x_83 + 5.10271978378296) - 0.019385018814894*std::sin(0.276319950819016*x_83 + 5.11303997039795) - 0.00202652995982438*std::sin(0.410399854183197*x_83 - 7.39120006561279) - 0.00050367756402148*std::sin(0.510559856891632*x_83 + 8.3342399597168) - 0.00219800281040317*std::sin(0.234959989786148*x_84 + 5.02799987792969) - 0.000893314905597659*std::sin(0.305039942264557*x_84 + 5.14831972122192) + 0.00312285246678238*std::sin(0.319039851427078*x_84 - 4.2947998046875) - 0.00223434991843784*std::sin(0.265119940042496*x_85 + 5.06559991836548) + 0.00425910752479975*std::sin(0.50791984796524*x_85 - 0.885199844837189) + 0.0361989040125337*std::sin(0.195919990539551*x_87 + 1.79983985424042) + 0.00489360862292204*std::sin(0.242479979991913*x_87 + 5.03991985321045) - 0.00526911645497023*std::sin(0.148960039019585*x_88 - 7.65576028823853) - 0.00877906464465058*std::sin(0.12216005474329*x_9 + 8.07327938079834) - 0.000729519408238531*std::sin(0.497999846935272*x_9 + 2.30663990974426) - 0.000346861284541955*std::sin(0.446799844503403*x_90 - 4.16096019744873) - 0.00305181956397875*std::sin(0.168240025639534*x_91 + 5.22959995269775) - 0.0111499483506665*std::sin(0.179120019078255*x_91 + 5.2279200553894) - 0.000998818478146596*std::sin(0.324799835681915*x_92 + 2.19455981254578) - 0.0065158222408077*std::sin(0.336719840764999*x_92 + 5.20352029800415) - 0.0157301226871925*std::sin(0.285359919071198*x_93 + 8.27120018005371) - 0.000616931791146398*std::sin(0.384559839963913*x_93 + 1.77711987495422) + 0.00144607912883676*std::sin(0.394639849662781*x_93 + 1.99383985996246) + 0.000767421511429026*std::sin(0.343359857797623*x_94 + 1.96759986877441) - 0.000862319775193136*std::sin(0.370159834623337*x_94 - 7.40679979324341) - 0.0327690522950039*std::sin(0.390079855918884*x_94 - 7.40775966644287) - 0.00120366585725585*std::sin(0.367199838161469*x_95 + 5.17216014862061) - 0.00238676696549021*std::sin(0.385119825601578*x_95 - 7.39695978164673) - 0.000663646958227081*std::sin(0.368079841136932*x_96 + 5.16943979263306) - 0.00318054714107078*std::sin(0.383679836988449*x_96 - 7.40807962417603) - 0.0111949327166307*std::sin(0.409599870443344*x_96 - 7.38104009628296) + 0.00187019654405098*std::sin(0.345919847488403*x_97 + 5.16247987747192) + 0.0027442831016259*std::sin(0.352719843387604*x_98 - 4.2403998374939) + 0.0265536902715962*std::sin(0.407839864492416*x_98 + 2.00023984909058) - 0.000495742124340226*std::sin(0.444959849119186*x_98 + 2.03095984458923) - 0.0010855394818497*std::sin(0.310319930315018*x_99 - 7.48432016372681) - 0.0114795802634179*std::sin(0.42783984541893*x_99 - 1.18479979038239) + 0.273199424997147);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00138158623757745*x_1 - 0.002403545715911*x_10 + 5.63387474923165e-6*x_100 - 0.00221049327347946*x_101 - 0.00018450690372328*x_102 - 7.3229513577774e-5*x_103 + 0.000717665190803311*x_104 - 0.000234998010000288*x_105 - 0.000190766030981485*x_106 - 0.000460125445281471*x_107 - 2.52909010554171e-6*x_11 - 7.18236862431012e-6*x_110 - 0.00132569987931106*x_111 + 0.000552742831371606*x_112 + 0.00133651649865332*x_113 - 0.000180579732650463*x_114 + 6.55458147605992e-6*x_115 + 0.00196213655820817*x_116 - 1.81550974681725e-6*x_117 - 0.00165270038882455*x_119 - 0.00537355850041492*x_12 + 0.000109668536854903*x_120 + 0.000493901815216363*x_13 - 0.000442551077382037*x_14 - 9.22617701920909e-5*x_15 - 0.00118883683340762*x_16 - 0.00191883316234148*x_17 - 0.000778813989867035*x_18 + 0.00132390839251235*x_19 - 0.000255399782471119*x_2 - 0.000319519738957491*x_20 + 3.07393635661242e-6*x_21 - 0.00361013118384395*x_22 + 0.000193225286635722*x_23 + 0.00033200741850302*x_24 - 0.000975289091052559*x_25 + 6.93587214404704e-5*x_26 + 3.85867831349263e-5*x_27 - 7.45252643561237e-5*x_28 + 0.00151502531985989*x_29 + 0.00101535722141407*x_3 - 0.00135768826910755*x_30 - 0.000740730062391201*x_31 + 6.46337534800994e-6*x_32 + 0.000233214243758699*x_33 - 1.77411594486773e-6*x_34 - 0.00103095608368673*x_35 + 5.25443873996048e-5*x_36 + 2.47124511667413e-5*x_37 - 0.000154126949075081*x_38 + 0.0005361810553121*x_39 + 0.000219834774943822*x_4 - 3.96322463958123e-5*x_40 + 0.00094930125433308*x_41 - 0.00119957183629532*x_42 + 4.05020847068697e-5*x_43 - 0.000353934909502078*x_44 + 0.000238279035489534*x_45 + 0.000191746112221812*x_46 + 0.00136673947502518*x_47 + 0.000931493853531961*x_48 + 0.00119421815085875*x_5 - 0.000233805094829341*x_51 + 0.00061550587482027*x_52 - 0.00022541216859652*x_53 + 0.00150748521978402*x_54 - 0.00019508775206111*x_55 - 1.79607593497378e-5*x_56 + 0.000572839394223386*x_58 - 0.000282801668445431*x_59 + 0.000488370055606228*x_6 + 0.000165544392002363*x_60 + 0.00171345959899882*x_61 + 0.00194815658545611*x_62 + 0.00050785664813276*x_63 + 0.00140382796253701*x_64 + 0.000820341901490045*x_65 + 0.000122683162371938*x_66 - 0.00223128161261348*x_68 + 0.000655334771585185*x_7 - 3.68301372993338e-5*x_70 + 0.000822061468044659*x_72 + 5.3925207763033e-5*x_73 + 0.000593018022937325*x_74 + 7.454723420257e-5*x_75 - 0.000225666717697645*x_76 + 0.000534366609234925*x_77 - 0.000815212842654156*x_78 + 0.000336893823823208*x_79 + 5.63980972158566e-5*x_8 - 0.000195807400643738*x_80 + 7.11958999553813e-5*x_81 + 1.44134243238809e-6*x_82 - 0.000214645627430161*x_84 - 0.000873291789770618*x_85 - 0.000302153940879762*x_86 - 7.9770934606393e-6*x_87 + 0.000217196083187089*x_88 - 0.000187496108231356*x_89 + 0.00227903660681918*x_9 + 0.000355604440236387*x_90 - 0.00463583600172229*x_91 - 6.56277480738663e-5*x_92 + 0.000497421237182143*x_93 - 0.000334739804830898*x_94 + 0.000331634494590639*x_95 + 0.000903708711564683*x_96 - 0.0011324669332302*x_97 + 0.00102394799672273*x_98 - 0.000468842433341233*x_99 - 2.15176902029905e-5*std::pow(-4.47631978988647*x_100 - 6.92568016052246, 2) + 3.37114628504963e-5*std::pow(-3.50639986991882*x_17 - 5.15751981735229, 2) - 2.92265110160764e-5*std::pow(-4.37183952331543*x_18 - 6.95983982086182, 2) + 5.05353511636322e-5*std::pow(-3.88375997543335*x_19 - 6.13335990905762, 2) - 6.39264034556435e-6*std::pow(-5.80399990081787*x_22 - 9.99647998809814, 2) - 7.17106360753826e-6*std::pow(-4.18495988845825*x_24 - 7.37408018112183, 2) - 0.000248899429772689*std::pow(-0.866319835186005*x_24 - 1.30367994308472, 2) - 1.62783568717187e-5*std::pow(-6.56744050979614*x_27 - 9.54936027526855, 2) - 6.0368424233488e-8*std::pow(-4.51200008392334*x_38 - 6.96360015869141, 2) + 3.20501013166111e-5*std::pow(-5.81879997253418*x_4 - 9.82336044311523, 2) + 7.39151147835989e-5*std::pow(-3.90320014953613*x_4 - 6.1637601852417, 2) - 2.26541923568088e-6*std::pow(-5.71783971786499*x_43 - 8.27400016784668, 2) + 3.21927348272342e-5*std::pow(-5.93743944168091*x_5 - 9.30079936981201, 2) - 1.89339063796682e-5*std::pow(-4.35264015197754*x_55 - 6.33048009872437, 2) + 4.58375498628427e-5*std::pow(-3.86879992485046*x_6 - 6.51087999343872, 2) - 5.5592114402262e-6*std::pow(-5.42744016647339*x_60 - 8.43583965301514, 2) - 2.86626350446617e-6*std::pow(-5.41200017929077*x_64 - 9.21903991699219, 2) + 4.09760548137664e-6*std::pow(-6.89007997512817*x_66 - 9.33463954925537, 2) - 7.04908690706277e-8*std::pow(-6.62088012695313*x_69 - 9.43920040130615, 2) + 1.7452731683745e-5*std::pow(-5.21744012832642*x_7 - 9.23895931243896, 2) + 1.89476526350184e-5*std::pow(-5.09847974777222*x_7 - 7.94231986999512, 2) + 5.84000230001842e-5*std::pow(-3.91991996765137*x_7 - 6.46479988098145, 2) + 4.18999220561467e-6*std::pow(-6.25472021102905*x_71 - 9.68151950836182, 2) - 4.2077856001561e-6*std::pow(-5.8854398727417*x_71 - 9.54551982879639, 2) + 1.79258837779045e-5*std::pow(-5.71959972381592*x_71 - 8.97583961486816, 2) + 1.29120505830076e-5*std::pow(-4.14160013198853*x_71 - 6.69736003875732, 2) + 1.16492480118196e-5*std::pow(-5.3120002746582*x_73 - 7.55503988265991, 2) - 2.48178275692544e-5*std::pow(-1.42991983890533*x_75 - 1.61055982112885, 2) - 8.93133271494947e-6*std::pow(-6.52383947372437*x_77 - 9.1627197265625, 2) - 4.53059272097347e-6*std::pow(-7.06584024429321*x_78 - 9.41096019744873, 2) + 9.42354195354779e-6*std::pow(-6.66368007659912*x_78 - 9.21712017059326, 2) - 2.1985218260472e-5*std::pow(-4.71984004974365*x_80 - 6.09327983856201, 2) - 9.23435210957299e-8*std::pow(-3.69936013221741*x_80 - 6.42208003997803, 2) + 9.59386471939468e-5*std::pow(-1.82767987251282*x_80 - 2.43895983695984, 2) + 8.05465310185384e-8*std::pow(-7.45847988128662*x_81 - 9.67831993103027, 2) - 1.5539709094165e-5*std::pow(-7.05999994277954*x_81 - 9.27960014343262, 2) + 2.5149123224688e-6*std::pow(-9.20399951934814*x_82 - 9.99767971038818, 2) + 6.39717974022186e-7*std::pow(-1.03719985485077*x_84 - 2.28391981124878, 2) - 1.84014168270048e-5*std::pow(-5.27831983566284*x_85 - 8.4093599319458, 2) + 3.74503144669639e-6*std::pow(-8.02295970916748*x_86 - 9.42399978637695, 2) + 4.53552762633467e-8*std::pow(-6.90776014328003*x_86 - 7.71479988098145, 2) - 7.45567297328168e-6*std::pow(-7.40399980545044*x_87 - 9.99079990386963, 2) + 2.47371697794331e-5*std::pow(-5.18376016616821*x_87 - 7.56544017791748, 2) - 1.13289146924455e-5*std::pow(-5.38815975189209*x_88 - 7.58616018295288, 2) - 1.06159117696375e-5*std::pow(-7.48543977737427*x_89 - 9.05047988891602, 2) - 7.34475980215864e-6*std::pow(-5.15536022186279*x_89 - 6.94384002685547, 2) + 1.13976342819807e-5*std::pow(-5.88768005371094*x_90 - 8.31655979156494, 2) + 0.000600806362939714*std::exp(0.82207989692688*x_25) + 0.0192592060607221*std::sin(0.215440005064011*x_1 - 7.3842396736145) - 6.53889718305017e-5*std::sin(0.364479839801788*x_1 - 4.37279987335205) + 0.0145845212335129*std::sin(0.301679849624634*x_10 + 5.10400009155273) + 0.0148157196184556*std::sin(0.208000004291534*x_100 + 5.00311994552612) + 0.00591409160485236*std::sin(0.414799869060516*x_100 + 5.20456027984619) + 0.00857261924299622*std::sin(0.426559865474701*x_100 + 5.22328042984009) - 0.00795553601288957*std::sin(0.319119840860367*x_101 + 5.146399974823) + 0.00711773375784427*std::sin(0.319359838962555*x_102 - 4.27135992050171) + 5.43053047989309e-5*std::sin(0.320079833269119*x_102 - 4.26879978179932) + 0.00432047927238484*std::sin(0.322719842195511*x_102 + 5.12976026535034) + 0.00586507921708687*std::sin(0.3503198325634*x_102 - 7.41847991943359) - 0.00201413776737417*std::sin(0.336479842662811*x_103 - 7.43991994857788) - 0.00495200602844932*std::sin(0.404639840126038*x_103 - 7.39447975158691) - 0.00648861567272565*std::sin(0.442559868097305*x_103 + 5.23320007324219) - 0.00909397070349975*std::sin(0.276479959487915*x_104 - 7.50216007232666) - 0.00699577741008208*std::sin(0.431439846754074*x_104 - 7.38263988494873) - 8.09957158425143e-5*std::sin(0.353279858827591*x_105 - 4.24919986724854) - 0.0026658396017657*std::sin(0.437759846448898*x_105 - 1.18407988548279) - 0.0115233495632302*std::sin(0.281599938869476*x_106 + 5.08271980285645) + 0.004100417825469*std::sin(0.360079854726791*x_106 + 5.16480016708374) + 2.76809553037907e-5*std::sin(0.452639847993851*x_106 + 2.046719789505) - 0.0136444291610166*std::sin(0.361199855804443*x_107 + 5.15944004058838) - 0.00815914890810274*std::sin(0.365039855241776*x_107 - 7.41479969024658) - 2.03855804104189e-5*std::sin(0.382639855146408*x_107 + 5.18391990661621) + 0.0024353316190443*std::sin(0.426959842443466*x_107 + 5.22248029708862) + 0.0101887911785939*std::sin(0.211359992623329*x_108 + 5.00783967971802) - 8.12115846015379e-5*std::sin(0.238799974322319*x_108 - 7.55640029907227) + 0.00229874213120401*std::sin(0.301119923591614*x_108 - 4.28095960617065) + 0.00377366015779105*std::sin(0.353679835796356*x_108 - 7.44871950149536) - 0.00552113729157171*std::sin(0.575359880924225*x_108 - 7.20560026168823) + 0.00619363912302872*std::sin(0.323999851942062*x_109 + 5.12048006057739) + 0.00298099724112242*std::sin(0.359439849853516*x_109 + 5.17456007003784) + 6.12568579475827e-5*std::sin(0.3643998503685*x_109 + 5.17935991287231) - 0.0040314106543686*std::sin(0.422879844903946*x_109 + 2.01311993598938) + 0.00299101832444867*std::sin(0.527999877929688*x_109 + 8.36816024780273) - 3.77433906754494e-5*std::sin(0.300399929285049*x_11 + 8.32439994812012) + 0.0075125915758779*std::sin(0.327679842710495*x_11 - 1.06183981895447) - 0.00335938923483086*std::sin(0.384719848632813*x_110 + 8.17407989501953) + 0.0137968037973318*std::sin(0.390239834785461*x_110 + 5.18304014205933) + 0.00791034874825147*std::sin(0.398719817399979*x_110 + 2.0097599029541) + 0.00362121671068049*std::sin(0.456639856100082*x_110 + 2.05167984962463) + 0.00817206788888561*std::sin(0.480879843235016*x_111 - 7.34032011032104) + 0.00204875114505468*std::sin(0.48431983590126*x_111 + 5.24575996398926) + 0.0106409278488294*std::sin(0.352079838514328*x_112 - 7.44328022003174) - 0.00633517936001881*std::sin(0.364639848470688*x_112 + 5.16183996200562) + 0.00473763243095009*std::sin(0.380959838628769*x_112 - 7.40343999862671) + 6.10164984823017e-6*std::sin(0.475119858980179*x_112 + 1.8407998085022) + 0.0144359776148115*std::sin(0.366319835186005*x_113 - 7.42911958694458) - 0.0194529998406327*std::sin(0.311119943857193*x_114 + 5.11175966262817) + 7.79261646469922e-5*std::sin(0.373439848423004*x_114 - 7.42952013015747) + 0.00279248200809131*std::sin(0.393599838018417*x_114 + 1.99799978733063) - 0.00744165423393762*std::sin(0.44159984588623*x_114 - 7.38136005401611) - 0.00464122453886858*std::sin(0.355759829282761*x_115 - 1.24439990520477) - 0.00844601119904579*std::sin(0.36847984790802*x_115 + 8.36911964416504) + 0.00238354136800661*std::sin(0.574719846248627*x_115 - 4.20968008041382) - 0.00550605999964095*std::sin(0.682319819927216*x_116 + 8.42623996734619) - 0.0209933289142312*std::sin(0.306239932775497*x_117 - 4.28335952758789) - 0.00612095922612146*std::sin(0.380719840526581*x_117 + 5.18304014205933) - 0.00978970737368343*std::sin(0.461359858512878*x_117 - 7.3459997177124) - 0.00411695602088245*std::sin(0.478159844875336*x_117 + 2.04239964485168) - 0.00561293220195318*std::sin(0.334479838609695*x_118 - 4.26528024673462) - 0.00830292539433828*std::sin(0.341599822044373*x_118 - 7.44719982147217) - 0.00825988915695297*std::sin(0.365839838981628*x_118 + 5.15880012512207) - 4.59014071748125e-5*std::sin(0.372159838676453*x_118 + 1.98983991146088) - 0.00816772135246617*std::sin(0.393759846687317*x_118 + 5.18567991256714) + 0.000112904998095139*std::sin(0.339599847793579*x_119 + 5.15136003494263) + 0.00621325719261474*std::sin(0.397039830684662*x_119 + 1.97919988632202) - 8.63614720755938e-5*std::sin(0.359199851751328*x_12 + 5.17248010635376) - 0.00365636099458405*std::sin(0.423359870910645*x_12 + 8.41808032989502) - 0.0117371569039262*std::sin(0.34639984369278*x_120 + 5.15912008285522) + 7.49015505814963e-5*std::sin(0.371839851140976*x_120 - 7.41567993164063) - 0.00148300901741046*std::sin(0.426879853010178*x_120 + 2.20191979408264) - 0.00315627125863625*std::sin(0.4859998524189*x_120 + 2.06983971595764) + 0.100708877245566*std::sin(0.171840012073517*x_13 + 8.15135955810547) + 0.0326957051704686*std::sin(0.212640002369881*x_14 + 5.00903987884521) - 0.00243557108834099*std::sin(0.270879954099655*x_14 + 1.8879998922348) - 0.0261740203607142*std::sin(0.306239932775497*x_14 + 5.15127992630005) + 0.0060486342455562*std::sin(0.431279867887497*x_15 - 0.968239843845367) + 0.000622317075729715*std::sin(1.49863994121552*x_15 - 2.5971200466156) - 0.0100713836868696*std::sin(0.41951984167099*x_16 - 7.36879968643188) - 0.0586696295393976*std::sin(0.185440003871918*x_18 - 7.60567998886108) + 0.0211260752961954*std::sin(0.258959949016571*x_18 + 5.06335973739624) + 7.71389965762904e-6*std::sin(0.599039852619171*x_19 - 0.798399865627289) - 0.00494450326205691*std::sin(0.263439953327179*x_21 - 1.12615990638733) - 0.0181421083696562*std::sin(0.30991992354393*x_21 - 4.27695989608765) - 0.00824719058658281*std::sin(0.325759828090668*x_21 - 4.2579197883606) + 0.00408772204199797*std::sin(0.398319840431213*x_21 - 7.18815994262695) + 0.014094598184682*std::sin(0.217999994754791*x_23 - 7.5860800743103) - 0.0127935600469271*std::sin(0.271119952201843*x_23 + 5.0798397064209) + 0.0048108896400984*std::sin(0.310719907283783*x_23 - 4.24408006668091) - 0.0106408375712753*std::sin(0.264239966869354*x_24 + 8.05335998535156) - 5.17170054555287e-5*std::sin(0.376079827547073*x_24 + 8.37248039245605) - 0.0146351011859478*std::sin(0.320399850606918*x_26 + 8.32015991210938) - 0.0262153941581409*std::sin(0.325119823217392*x_26 - 4.25880002975464) + 0.00277260554656897*std::sin(0.326479852199554*x_26 + 8.31744003295898) - 0.000104295756912764*std::sin(0.338239848613739*x_26 - 4.26504039764404) + 0.000378505831097256*std::sin(0.213039994239807*x_27 - 7.5717601776123) - 0.0225434074045371*std::sin(0.279119938611984*x_27 + 5.103759765625) + 0.000230266502665934*std::sin(1.74143981933594*x_27 - 1.98255980014801) + 0.00351382173102743*std::sin(0.347439825534821*x_28 + 8.35303974151611) + 0.00586858333536835*std::sin(0.361359834671021*x_28 + 8.34383964538574) + 0.00694859375237733*std::sin(0.417199850082397*x_28 + 8.41736030578613) - 0.00159410385700871*std::sin(0.810399830341339*x_29 + 5.61424016952515) - 0.000303206716131188*std::sin(1.04367983341217*x_29 + 6.00735950469971) + 0.0108656560987968*std::sin(0.306319922208786*x_3 + 8.31271934509277) - 0.0111505222706169*std::sin(0.338559836149216*x_3 + 8.35519981384277) + 8.75979329886602e-5*std::sin(0.349679857492447*x_3 - 4.23496007919312) + 0.00727157721872919*std::sin(0.29751992225647*x_30 - 7.49848031997681) + 0.00321657339864094*std::sin(0.330079823732376*x_30 + 8.34352016448975) - 0.0247074788663041*std::sin(0.20040000975132*x_31 - 7.39463949203491) + 0.0127578593810819*std::sin(0.210400000214577*x_32 - 1.00415980815887) + 0.0139093447740235*std::sin(0.259839981794357*x_32 + 5.17312002182007) - 0.0162573467959124*std::sin(0.271519958972931*x_32 - 7.43567991256714) + 0.00625329047601624*std::sin(0.311999946832657*x_32 - 4.44504022598267) - 7.29262531420099e-5*std::sin(0.218399986624718*x_33 - 7.38711977005005) + 0.0134113696333097*std::sin(0.279199957847595*x_33 - 1.16039991378784) + 0.0108708208732393*std::sin(0.292239934206009*x_33 + 8.22999954223633) - 0.00440610755205302*std::sin(0.277199953794479*x_34 - 1.12231993675232) - 0.0109714087804909*std::sin(0.357199847698212*x_34 - 7.39351987838745) + 0.0101744627862526*std::sin(0.369359821081161*x_34 + 1.97839987277985) + 0.0157427847095215*std::sin(0.386319845914841*x_34 + 1.9748797416687) - 0.00387779823240429*std::sin(0.272719949483871*x_35 - 1.1399998664856) + 0.0159586096259119*std::sin(0.315359860658646*x_35 + 1.97319984436035) - 7.49315481438513e-5*std::sin(0.316319853067398*x_35 - 1.20743989944458) - 0.00711062051836243*std::sin(0.316399842500687*x_35 - 7.42007970809937) - 0.0114139891682752*std::sin(0.343759834766388*x_36 - 7.44807958602905) + 0.00805737957820883*std::sin(0.363919854164124*x_36 - 4.23432016372681) - 0.0159369166819677*std::sin(0.366559833288193*x_36 + 5.16152000427246) + 6.62912080279019e-5*std::sin(0.367839843034744*x_36 + 5.17136001586914) + 0.010391822173521*std::sin(0.358239859342575*x_37 + 5.17824029922485) + 5.3629625398464e-5*std::sin(0.403439849615097*x_37 - 4.20223999023438) + 0.00403894246932492*std::sin(0.450879871845245*x_37 + 2.03239989280701) + 0.0334339768189257*std::sin(0.165120020508766*x_38 - 7.63992023468018) + 0.00525723591675806*std::sin(0.249279975891113*x_38 + 5.06663990020752) - 0.0179037504957861*std::sin(0.308319836854935*x_38 + 5.11079978942871) - 0.00892025257138119*std::sin(0.271279960870743*x_39 + 8.28528022766113) - 0.0112781190509589*std::sin(0.301999926567078*x_39 + 5.10551977157593) - 5.61258418180244e-5*std::sin(0.30295991897583*x_39 - 4.30272006988525) - 0.00971811076277872*std::sin(0.306399941444397*x_40 + 5.12367963790894) + 0.00808717971158554*std::sin(0.315039843320847*x_40 - 4.28247976303101) + 0.0161783545965743*std::sin(0.394879847764969*x_40 + 5.19040012359619) + 0.0137084278282314*std::sin(0.330479830503464*x_41 + 5.14264011383057) + 5.18296236233987e-5*std::sin(0.357199847698212*x_41 - 7.43991994857788) + 0.00523453411022125*std::sin(0.365519851446152*x_41 - 7.41623973846436) - 9.45215610476819e-5*std::sin(0.303599923849106*x_42 + 5.09543991088867) + 0.00526142383788395*std::sin(0.348079830408096*x_42 - 1.23199987411499) + 0.00669006293238786*std::sin(0.358479857444763*x_42 + 1.97983980178833) + 0.00878481287241217*std::sin(0.417839854955673*x_42 - 1.1794399023056) - 0.00544690064205005*std::sin(0.356159836053848*x_43 + 5.15208005905151) + 6.18148623467309e-5*std::sin(0.377679854631424*x_43 + 5.18800020217896) - 0.0095518562672865*std::sin(0.29351994395256*x_44 - 4.27183961868286) - 0.0122860064417984*std::sin(0.220559984445572*x_45 + 8.22208023071289) - 8.12136748383147e-5*std::sin(0.296639919281006*x_45 + 5.11967945098877) + 0.00858198930080188*std::sin(0.388719856739044*x_45 + 1.97711980342865) + 0.00325964912638486*std::sin(0.466559857130051*x_45 + 5.24775981903076) - 0.0207283820881009*std::sin(0.195199996232986*x_46 + 4.97847986221313) + 0.000129202592007965*std::sin(0.290079951286316*x_46 + 5.11967992782593) - 0.00233940745302584*std::sin(0.439439862966537*x_46 - 4.14663982391357) + 0.00542458168586577*std::sin(0.44871985912323*x_46 + 5.24927997589111) + 6.94781618426131e-5*std::sin(0.376559853553772*x_47 + 5.1625599861145) + 0.00232230821296874*std::sin(0.624079823493958*x_47 - 7.38527965545654) - 0.00296390705982317*std::sin(0.509759843349457*x_48 + 8.27455902099609) + 0.00179543369979887*std::sin(0.589999854564667*x_48 - 7.40863990783691) + 0.00414796247923945*std::sin(0.219999998807907*x_49 - 1.36087989807129) - 0.0129710541559625*std::sin(0.326879858970642*x_49 - 4.26919984817505) + 7.99409160458097e-5*std::sin(0.352319836616516*x_49 - 4.23863983154297) + 0.00107907349998843*std::sin(0.506479859352112*x_49 + 8.28087997436523) + 0.000271297950315537*std::sin(1.97479975223541*x_49 - 7.4031195640564) + 0.0137984815647158*std::sin(0.304159939289093*x_50 - 7.47200012207031) + 3.47914197396358e-5*std::sin(0.350559860467911*x_50 + 5.15431976318359) - 0.0108575722318628*std::sin(0.375439822673798*x_50 - 4.23304033279419) - 0.00327252961921606*std::sin(0.428159862756729*x_50 - 1.17399990558624) - 0.00752439621769888*std::sin(0.436799854040146*x_50 + 5.22847986221313) + 0.0147305095144034*std::sin(0.276399940252304*x_51 - 4.30975961685181) + 2.99599173682772e-5*std::sin(0.321599841117859*x_51 - 7.47175979614258) - 0.00617538615156948*std::sin(0.352479845285416*x_51 + 5.1418399810791) + 0.0141561839489872*std::sin(0.233919993042946*x_52 + 8.23464012145996) + 0.00126117543285379*std::sin(0.71399986743927*x_52 - 1.22463989257813) - 0.0587851401939016*std::sin(0.131200045347214*x_53 - 7.68440008163452) + 0.00658001330315653*std::sin(0.231279999017715*x_53 - 7.54808044433594) + 0.00301420521686896*std::sin(0.295199930667877*x_53 - 4.27360010147095) - 1.72602826592729e-5*std::sin(0.334159851074219*x_53 - 1.068079829216) + 0.0079755652957481*std::sin(0.198559984564781*x_55 - 4.39231967926025) + 0.00677002280388047*std::sin(0.308479934930801*x_55 - 7.46504020690918) + 6.90267003055757e-5*std::sin(0.317279845476151*x_55 - 4.28736019134521) - 0.0287284900275609*std::sin(0.203759998083115*x_56 + 5.00360012054443) + 2.4363449030451e-5*std::sin(0.342239856719971*x_56 + 5.13784027099609) + 0.00837497068675565*std::sin(0.363439828157425*x_56 + 5.15592002868652) - 0.0274660769223537*std::sin(0.229999989271164*x_57 - 4.37119960784912) - 0.00181967391071703*std::sin(0.319519847631454*x_57 - 7.47119998931885) + 0.0109552158424392*std::sin(0.366719841957092*x_57 + 8.35023975372314) - 6.20299554088203e-5*std::sin(0.373519837856293*x_57 - 4.21056032180786) + 0.00471404149936531*std::sin(0.41023987531662*x_57 + 5.21224021911621) + 0.00440940572810004*std::sin(0.250159978866577*x_58 - 7.52272033691406) - 0.017676442899183*std::sin(0.266959935426712*x_58 + 5.07175970077515) + 0.0070989441882668*std::sin(0.389519840478897*x_58 + 1.97375977039337) - 2.5244813947174e-5*std::sin(0.463439851999283*x_58 - 1.13231992721558) + 0.00786278799367999*std::sin(0.303439915180206*x_59 + 5.13167953491211) - 2.48085702812879e-5*std::sin(0.307839930057526*x_59 - 7.46871995925903) + 0.00638920903262589*std::sin(0.314319908618927*x_59 + 5.13312005996704) + 0.0312438975594411*std::sin(0.228319987654686*x_60 + 5.03671979904175) - 0.00713263496107928*std::sin(0.344799846410751*x_60 - 4.26503992080688) + 0.00622549543933279*std::sin(0.324959844350815*x_62 + 8.3133602142334) + 0.0194985239402248*std::sin(0.206400007009506*x_64 - 4.40303993225098) + 0.000106666085417665*std::sin(0.238079980015755*x_64 - 4.35223960876465) - 0.0120229038577495*std::sin(0.196719989180565*x_65 + 5.00432014465332) + 0.0187081968535901*std::sin(0.273279964923859*x_65 + 5.09200000762939) - 0.000111293313034558*std::sin(0.199680000543594*x_66 + 4.99975967407227) - 0.0202771078974131*std::sin(0.221759989857674*x_66 + 5.03087949752808) - 0.0161149721116391*std::sin(0.201039999723434*x_67 + 5.00600004196167) - 0.0159466902192944*std::sin(0.202800005674362*x_67 - 7.58416032791138) - 0.0185044750086078*std::sin(0.225759983062744*x_67 + 5.03471994400024) + 0.0144128528939407*std::sin(0.244639977812767*x_67 + 5.04016017913818) + 6.45170011365731e-6*std::sin(0.343759834766388*x_67 - 4.43192005157471) - 0.0127188645704194*std::sin(0.225199997425079*x_69 + 5.02031993865967) + 0.0270335114603027*std::sin(0.251279979944229*x_69 + 5.05583953857422) + 0.0100542414147208*std::sin(0.262479960918427*x_69 + 5.07775974273682) + 0.0147347835923567*std::sin(0.269839972257614*x_69 + 5.09832000732422) + 0.0401761904347825*std::sin(0.13864004611969*x_70 - 7.66880035400391) - 0.0174131220816119*std::sin(0.289679944515228*x_70 - 7.4759202003479) + 2.41217084101326e-5*std::sin(0.345999836921692*x_70 - 1.06407976150513) + 3.89615783004329e-5*std::sin(0.298959940671921*x_71 + 5.11895942687988) - 0.00707565517805384*std::sin(0.34487983584404*x_72 - 1.04951989650726) - 7.64742968402524e-5*std::sin(0.33111983537674*x_74 - 4.27975988388062) - 0.00557429280989262*std::sin(0.344799846410751*x_74 - 4.25688028335571) + 0.00222607610778691*std::sin(0.365679830312729*x_74 + 1.94711983203888) - 0.0242915720552132*std::sin(0.207840010523796*x_75 - 7.58039999008179) + 4.74419324040475e-5*std::sin(0.241279974579811*x_75 - 7.54800033569336) + 0.000166823539076603*std::sin(0.873279869556427*x_75 + 2.20911979675293) - 3.57194374977335e-5*std::sin(0.358159840106964*x_76 - 4.25072002410889) + 0.000358667530039634*std::sin(0.144800037145615*x_77 - 7.65912008285522) - 0.0182092440966122*std::sin(0.293919950723648*x_77 + 5.11543989181519) - 0.00435963689721219*std::sin(0.31399992108345*x_77 - 7.46776008605957) - 0.0088087869974229*std::sin(0.255599975585938*x_79 + 5.07967948913574) + 0.0134962053374206*std::sin(0.255679965019226*x_79 + 5.05535984039307) - 8.52337212389734e-5*std::sin(0.257119983434677*x_79 + 5.05615997314453) + 0.00376327062500032*std::sin(0.320879846811295*x_79 + 5.12488031387329) + 0.0130237866189522*std::sin(0.266479969024658*x_8 + 5.09807968139648) - 0.0197499490471169*std::sin(0.325599819421768*x_8 - 4.28672027587891) + 0.000811565165996925*std::sin(0.474159836769104*x_80 + 8.48776054382324) - 0.0332484031646714*std::sin(0.214560002088547*x_82 + 5.02231979370117) - 0.00756601381760435*std::sin(0.275119960308075*x_82 - 7.49600028991699) - 0.00627758921871318*std::sin(0.326799839735031*x_82 + 5.12800025939941) - 0.00617632342418322*std::sin(0.270079970359802*x_83 + 5.10271978378296) - 5.82765711129966e-5*std::sin(0.276319950819016*x_83 + 5.11303997039795) - 0.00732514942397537*std::sin(0.375839829444885*x_83 + 8.19039916992188) - 0.00480994558281878*std::sin(0.410399854183197*x_83 - 7.39120006561279) - 0.00468643503301018*std::sin(0.510559856891632*x_83 + 8.3342399597168) - 0.0204511737451322*std::sin(0.234959989786148*x_84 + 5.02799987792969) - 0.00373295139092869*std::sin(0.305039942264557*x_84 + 5.14831972122192) + 0.0074120544606685*std::sin(0.319039851427078*x_84 - 4.2947998046875) - 0.00933681905853088*std::sin(0.265119940042496*x_85 + 5.06559991836548) + 1.28040207191436e-5*std::sin(0.50791984796524*x_85 - 0.885199844837189) + 0.000108823624265876*std::sin(0.195919990539551*x_87 + 1.79983985424042) + 0.0116149238582723*std::sin(0.242479979991913*x_87 + 5.03991985321045) - 0.0490261502823853*std::sin(0.148960039019585*x_88 - 7.65576028823853) + 0.00668116389550654*std::sin(0.357119828462601*x_89 + 5.16175985336304) - 0.0816842342137695*std::sin(0.12216005474329*x_9 + 8.07327938079834) - 0.00304848880571577*std::sin(0.497999846935272*x_9 + 2.30663990974426) - 0.00322734819175509*std::sin(0.446799844503403*x_90 - 4.16096019744873) - 0.0127528310731545*std::sin(0.168240025639534*x_91 + 5.22959995269775) - 0.0264642743414429*std::sin(0.179120019078255*x_91 + 5.2279200553894) - 0.00929344136401614*std::sin(0.324799835681915*x_92 + 2.19455981254578) - 0.0154652292474972*std::sin(0.336719840764999*x_92 + 5.20352029800415) - 4.728897207425e-5*std::sin(0.285359919071198*x_93 + 8.27120018005371) - 0.0014642805201766*std::sin(0.384559839963913*x_93 + 1.77711987495422) + 0.00604282214654485*std::sin(0.394639849662781*x_93 + 1.99383985996246) + 0.00714042338422131*std::sin(0.343359857797623*x_94 + 1.96759986877441) - 0.00360343008278689*std::sin(0.370159834623337*x_94 - 7.40679979324341) - 9.85125691447897e-5*std::sin(0.390079855918884*x_94 - 7.40775966644287) + 0.00894182434686665*std::sin(0.406239867210388*x_94 - 7.39663982391357) - 0.00502983450505673*std::sin(0.367199838161469*x_95 + 5.17216014862061) + 0.0071978143444629*std::sin(0.381119847297668*x_95 + 5.19063997268677) - 0.00566496397806638*std::sin(0.385119825601578*x_95 - 7.39695978164673) - 0.00277322344032974*std::sin(0.368079841136932*x_96 + 5.16943979263306) - 0.00754899210740811*std::sin(0.383679836988449*x_96 - 7.40807962417603) + 0.00501986647031333*std::sin(0.406319856643677*x_96 - 7.39271974563599) - 3.36549733995968e-5*std::sin(0.409599870443344*x_96 - 7.38104009628296) + 0.00781510836400335*std::sin(0.345919847488403*x_97 + 5.16247987747192) + 0.0104738034075301*std::sin(0.396479845046997*x_97 - 7.4031195640564) + 0.00651352442073623*std::sin(0.352719843387604*x_98 - 4.2403998374939) + 7.98275221810055e-5*std::sin(0.407839864492416*x_98 + 2.00023984909058) - 0.00207158891114628*std::sin(0.444959849119186*x_98 + 2.03095984458923) - 0.00453621236283719*std::sin(0.310319930315018*x_99 - 7.48432016372681) - 3.45107003483753e-5*std::sin(0.42783984541893*x_99 - 1.18479979038239) + 0.00476422535738591*std::sin(0.45839986205101*x_99 + 2.04295969009399) - 0.194856132743275);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00212237510959131*x_1 - 0.00279272478668645*x_10 + 0.0012667954546694*x_100 - 0.00324561923140617*x_101 - 0.000832218600899*x_103 + 0.00319965369152617*x_104 - 0.000170227760239849*x_105 - 0.000411426528486457*x_106 - 0.00114150512465597*x_107 - 0.000598363100117324*x_11 - 0.00161497944700972*x_110 - 0.0017765015811802*x_111 + 0.000539838651453928*x_112 + 0.00451930818472966*x_113 - 0.000447992373261191*x_114 - 0.000663237287356345*x_115 + 0.00246564450557825*x_116 - 0.000408223398202052*x_117 - 0.000549606048381716*x_119 - 0.0082919708674261*x_12 + 0.000107108245792652*x_120 + 0.00301558404456285*x_13 - 0.00163459191963823*x_14 - 0.00140035147612841*x_15 - 0.00231310284805009*x_16 - 0.0017641231805065*x_17 - 0.00125817463152945*x_18 + 0.00065083746903034*x_19 - 0.00147362830476583*x_2 + 0.00944962667555331*x_20 + 0.000691184802258997*x_21 - 0.00430383097190061*x_22 + 0.00226040178498791*x_23 + 0.000324256465945687*x_24 + 0.00171353877390945*x_25 + 0.000172069023297442*x_26 + 0.000136204563304746*x_27 + 0.000500095567547095*x_28 + 0.00223496012730168*x_29 + 0.00177721196672456*x_3 - 0.000446240425090795*x_30 + 0.00493466780680762*x_31 + 0.00145331142013725*x_32 - 0.00171746725895839*x_33 - 0.000398915864311939*x_34 - 0.00100688767060916*x_35 + 0.000130355076215936*x_36 - 0.00037307051812445*x_37 - 0.000382366817616814*x_38 + 0.0013235263809253*x_39 + 0.00411576581943951*x_4 - 0.002209513926071*x_40 - 0.000783305230764332*x_41 - 0.00117156696690367*x_42 + 0.000318583616047328*x_43 - 0.000464488835641002*x_44 + 0.000591136054088461*x_45 + 0.00047569455673151*x_46 + 0.000112582008740652*x_47 - 0.000281118787006146*x_48 + 0.00193390479255687*x_5 - 7.50527642942199e-5*x_51 + 0.00032411190165678*x_52 + 0.00147474582310039*x_54 - 0.00019946558777496*x_56 + 0.00202202239199695*x_58 - 0.000626343731208991*x_59 + 0.000327506276125401*x_6 - 0.00061230658330233*x_60 + 0.00476736801045246*x_61 + 0.000894180315766752*x_62 + 0.00150147328249089*x_63 + 0.00107426055665991*x_64 + 0.00129006430762111*x_65 - 0.000239722786166995*x_66 + 3.47569821818861e-5*x_68 + 0.00240806501708518*x_7 - 0.000174415031323389*x_70 + 0.00273004503427217*x_72 + 0.000851489887065427*x_73 + 0.000736037956046876*x_74 + 0.000184940978039385*x_75 - 0.00151851816439041*x_76 + 0.00132568678637966*x_77 - 0.000504932723218361*x_78 + 0.000329028794610651*x_79 + 0.0010185796075143*x_8 - 0.000485770029831021*x_80 + 9.21165403836692e-5*x_81 + 0.000324090634464385*x_82 - 0.00198924374184509*x_85 - 0.000771040493960307*x_86 - 2.81577380381334e-5*x_87 + 0.00117780405253086*x_88 - 0.000933665460152156*x_89 + 0.00104803765519238*x_9 + 0.0017336598115535*x_90 + 0.00162453676576149*x_91 + 0.0044450742945669*x_92 - 0.000156226263177747*x_93 - 0.000830441364543673*x_94 + 0.00028349435085555*x_95 + 0.000882610980132751*x_96 - 0.000304092232333213*x_97 + 0.000711069543747026*x_98 - 0.00135662195889253*x_99 - 2.10153442112692e-5*std::pow(-4.47631978988647*x_100 - 6.92568016052246, 2) + 8.36332960893972e-5*std::pow(-3.50639986991882*x_17 - 5.15751981735229, 2) - 0.000103164447680089*std::pow(-4.37183952331543*x_18 - 6.95983982086182, 2) + 4.93555669554854e-5*std::pow(-3.88375997543335*x_19 - 6.13335990905762, 2) - 2.25648969904357e-5*std::pow(-5.80399990081787*x_22 - 9.99647998809814, 2) - 2.53125943067078e-5*std::pow(-4.18495988845825*x_24 - 7.37408018112183, 2) - 0.000617483726499129*std::pow(-0.866319835186005*x_24 - 1.30367994308472, 2) - 4.03842647273696e-5*std::pow(-6.56744050979614*x_27 - 9.54936027526855, 2) - 1.35740407496575e-5*std::pow(-4.51200008392334*x_38 - 6.96360015869141, 2) + 3.13018685937314e-5*std::pow(-5.81879997253418*x_4 - 9.82336044311523, 2) - 5.62017965653263e-6*std::pow(-5.71783971786499*x_43 - 8.27400016784668, 2) - 1.84918806841717e-5*std::pow(-4.35264015197754*x_55 - 6.33048009872437, 2) + 4.47674392131072e-5*std::pow(-3.86879992485046*x_6 - 6.51087999343872, 2) - 1.3791604905011e-5*std::pow(-5.42744016647339*x_60 - 8.43583965301514, 2) - 1.01174064595393e-5*std::pow(-5.41200017929077*x_64 - 9.21903991699219, 2) + 1.44638272445383e-5*std::pow(-6.89007997512817*x_66 - 9.33463954925537, 2) - 1.58501061008758e-5*std::pow(-6.62088012695313*x_69 - 9.43920040130615, 2) + 1.70452850794296e-5*std::pow(-5.21744012832642*x_7 - 9.23895931243896, 2) + 4.70064040249804e-5*std::pow(-5.09847974777222*x_7 - 7.94231986999512, 2) + 1.47899361452465e-5*std::pow(-6.25472021102905*x_71 - 9.68151950836182, 2) - 1.04389115518129e-5*std::pow(-5.8854398727417*x_71 - 9.54551982879639, 2) + 1.2610609452752e-5*std::pow(-4.14160013198853*x_71 - 6.69736003875732, 2) + 4.11197982669462e-5*std::pow(-5.3120002746582*x_73 - 7.55503988265991, 2) - 8.76025698857272e-5*std::pow(-1.42991983890533*x_75 - 1.61055982112885, 2) - 8.72282431336177e-6*std::pow(-6.52383947372437*x_77 - 9.1627197265625, 2) - 1.12397496416583e-5*std::pow(-7.06584024429321*x_78 - 9.41096019744873, 2) + 9.20354257240951e-6*std::pow(-6.66368007659912*x_78 - 9.21712017059326, 2) - 2.07637475093305e-5*std::pow(-3.69936013221741*x_80 - 6.42208003997803, 2) + 9.36988903048755e-5*std::pow(-1.82767987251282*x_80 - 2.43895983695984, 2) + 1.81111550975797e-5*std::pow(-7.45847988128662*x_81 - 9.67831993103027, 2) + 6.23913616079731e-6*std::pow(-9.20399951934814*x_82 - 9.99767971038818, 2) + 0.000143842711780581*std::pow(-1.03719985485077*x_84 - 2.28391981124878, 2) + 3.65760098746164e-6*std::pow(-8.02295970916748*x_86 - 9.42399978637695, 2) + 1.01982845507026e-5*std::pow(-6.90776014328003*x_86 - 7.71479988098145, 2) + 2.41596627158031e-5*std::pow(-5.18376016616821*x_87 - 7.56544017791748, 2) - 1.03680756554618e-5*std::pow(-7.48543977737427*x_89 - 9.05047988891602, 2) - 2.59257113487074e-5*std::pow(-5.15536022186279*x_89 - 6.94384002685547, 2) + 2.82758931836007e-5*std::pow(-5.88768005371094*x_90 - 8.31655979156494, 2) + 0.00144742510747164*std::pow(-0.108904610858816*x_1 + 0.119189659436006*x_10 + 0.0657320515183811*x_101 + 0.0229398306221683*x_102 + 0.00864449282654386*x_103 - 0.0181397613547117*x_105 - 0.0336474125920139*x_11 + 0.0112911060523954*x_111 - 0.0810746236071317*x_113 + 0.0734107458829892*x_119 + 0.111208502664188*x_12 + 0.0183998877295896*x_15 - 0.0631567563683302*x_17 - 0.151911113685466*x_19 + 0.243449757871765*x_2 + 0.401876299208737*x_20 + 0.204434139337082*x_22 + 0.0202441329122376*x_25 + 0.0499377496331767*x_29 + 0.100003576650318*x_3 - 0.115068141317104*x_33 - 0.0217692943484448*x_37 - 0.157283160164892*x_41 + 0.0355208284138996*x_43 + 0.0351667539942142*x_44 - 0.145018848497235*x_47 + 0.0200956287194125*x_48 + 0.0280256015543736*x_53 + 0.0293698558745287*x_54 + 0.0242553525013534*x_55 - 0.123232219219004*x_6 - 0.0209207815815111*x_60 + 0.132550483784789*x_61 - 0.121619764144592*x_62 - 0.113092556659127*x_63 - 0.0377826042821276*x_64 + 0.0954366530862473*x_68 + 0.0604064386600474*x_73 + 0.019969216641792*x_74 - 0.113743551724484*x_76 + 0.080895280172939*x_78 + 0.0266869923979743*x_84 + 0.00663580148026545*x_86 - 0.268737654569723*x_9 - 0.013241978003696*x_90 + 0.427620196563672*x_91 + 0.0131328166306153*x_92 - 0.0817326022702592*x_93 - 0.0367870506697321*x_98 - 0.00918990118709551*std::pow(-3.90320014953613*x_4 - 6.1637601852417, 2) - 0.00400253795006345*std::pow(-5.93743944168091*x_5 - 9.30079936981201, 2) - 0.00726090248614325*std::pow(-3.91991996765137*x_7 - 6.46479988098145, 2) - 0.00222873361006881*std::pow(-5.71959972381592*x_71 - 8.97583961486816, 2) + 0.00273343258658237*std::pow(-4.71984004974365*x_80 - 6.09327983856201, 2) + 0.00193205938284322*std::pow(-7.05999994277954*x_81 - 9.27960014343262, 2) + 0.00228785685901761*std::pow(-5.27831983566284*x_85 - 8.4093599319458, 2) + 0.00092696734772521*std::pow(-7.40399980545044*x_87 - 9.99079990386963, 2) + 0.00140852932293234*std::pow(-5.38815975189209*x_88 - 7.58616018295288, 2) - 1.06583780581789*std::sin(0.426559865474701*x_100 + 5.22328042984009) + 0.869788314795862*std::sin(0.431439846754074*x_104 - 7.38263988494873) + 1.43270350239574*std::sin(0.281599938869476*x_106 + 5.08271980285645) + 1.69641833217975*std::sin(0.361199855804443*x_107 + 5.15944004058838) + 0.686445611272873*std::sin(0.575359880924225*x_108 - 7.20560026168823) - 0.371874723200381*std::sin(0.527999877929688*x_109 + 8.36816024780273) - 0.98349740191469*std::sin(0.398719817399979*x_110 + 2.0097599029541) - 1.32299159320867*std::sin(0.352079838514328*x_112 - 7.44328022003174) + 2.4186006725605*std::sin(0.311119943857193*x_114 + 5.11175966262817) - 0.29634682583481*std::sin(0.574719846248627*x_115 - 4.20968008041382) + 0.684571044434705*std::sin(0.682319819927216*x_116 + 8.42623996734619) + 1.2171589488581*std::sin(0.461359858512878*x_117 - 7.3459997177124) + 1.03230664203373*std::sin(0.341599822044373*x_118 - 7.44719982147217) + 1.4592862702075*std::sin(0.34639984369278*x_120 + 5.15912008285522) - 12.5211823489645*std::sin(0.171840012073517*x_13 + 8.15135955810547) - 4.06507249077134*std::sin(0.212640002369881*x_14 + 5.00903987884521) + 1.25217989812545*std::sin(0.41951984167099*x_16 - 7.36879968643188) + 7.29442279470288*std::sin(0.185440003871918*x_18 - 7.60567998886108) - 0.508228415206482*std::sin(0.398319840431213*x_21 - 7.18815994262695) - 1.75238805984759*std::sin(0.217999994754791*x_23 - 7.5860800743103) + 1.32298036895766*std::sin(0.264239966869354*x_24 + 8.05335998535156) + 1.81958905368361*std::sin(0.320399850606918*x_26 + 8.32015991210938) + 2.80283250691917*std::sin(0.279119938611984*x_27 + 5.103759765625) - 0.863921948312878*std::sin(0.417199850082397*x_28 + 8.41736030578613) - 0.904078635473944*std::sin(0.29751992225647*x_30 - 7.49848031997681) + 3.07189253548947*std::sin(0.20040000975132*x_31 - 7.39463949203491) - 1.58619069204256*std::sin(0.210400000214577*x_32 - 1.00415980815887) - 1.26499577131401*std::sin(0.369359821081161*x_34 + 1.97839987277985) - 1.98414148411908*std::sin(0.315359860658646*x_35 + 1.97319984436035) + 1.98144439013649*std::sin(0.366559833288193*x_36 + 5.16152000427246) + 2.22598176863272*std::sin(0.308319836854935*x_38 + 5.11079978942871) + 1.40221387679708*std::sin(0.301999926567078*x_39 + 5.10551977157593) - 2.01146248027339*std::sin(0.394879847764969*x_40 + 5.19040012359619) - 1.09221994014283*std::sin(0.417839854955673*x_42 - 1.1794399023056) - 1.06700278953744*std::sin(0.388719856739044*x_45 + 1.97711980342865) - 0.674440807139163*std::sin(0.44871985912323*x_46 + 5.24927997589111) - 0.0337306025020818*std::sin(1.97479975223541*x_49 - 7.4031195640564) + 0.935511741213602*std::sin(0.436799854040146*x_50 + 5.22847986221313) - 1.83145121629406*std::sin(0.276399940252304*x_51 - 4.30975961685181) - 0.156802538174377*std::sin(0.71399986743927*x_52 - 1.22463989257813) + 3.57182675533537*std::sin(0.203759998083115*x_56 + 5.00360012054443) + 3.4148703367718*std::sin(0.229999989271164*x_57 - 4.37119960784912) + 2.19772050761765*std::sin(0.266959935426712*x_58 + 5.07175970077515) - 0.977584150799878*std::sin(0.303439915180206*x_59 + 5.13167953491211) - 2.32599896484734*std::sin(0.273279964923859*x_65 + 5.09200000762939) + 2.52106241710996*std::sin(0.221759989857674*x_66 + 5.03087949752808) - 1.7919568184023*std::sin(0.244639977812767*x_67 + 5.04016017913818) - 1.83198261442787*std::sin(0.269839972257614*x_69 + 5.09832000732422) + 2.16498170580331*std::sin(0.289679944515228*x_70 - 7.4759202003479) + 0.879719555474516*std::sin(0.34487983584404*x_72 - 1.04951989650726) + 3.02018264491898*std::sin(0.207840010523796*x_75 - 7.58039999008179) + 2.26396393253927*std::sin(0.293919950723648*x_77 + 5.11543989181519) - 0.467889217047201*std::sin(0.320879846811295*x_79 + 5.12488031387329) + 2.45552050787654*std::sin(0.325599819421768*x_8 - 4.28672027587891) + 4.13378969384814*std::sin(0.214560002088547*x_82 + 5.02231979370117) + 0.910739293094899*std::sin(0.375839829444885*x_83 + 8.19039916992188) - 0.83067226769861*std::sin(0.357119828462601*x_89 + 5.16175985336304) - 1.1117412510371*std::sin(0.406239867210388*x_94 - 7.39663982391357) - 0.894907662422384*std::sin(0.381119847297668*x_95 + 5.19063997268677) - 0.624122372936228*std::sin(0.406319856643677*x_96 - 7.39271974563599) - 1.30221293236256*std::sin(0.396479845046997*x_97 - 7.4031195640564) - 0.592338392433184*std::sin(0.45839986205101*x_99 + 2.04295969009399) + 27.6032838415596, 2) + 0.00149051427008577*std::exp(0.82207989692688*x_25) + 0.0679816128212672*std::sin(0.215440005064011*x_1 - 7.3842396736145) - 0.0147029275565066*std::sin(0.364479839801788*x_1 - 4.37279987335205) + 0.0361821018581675*std::sin(0.301679849624634*x_10 + 5.10400009155273) + 0.0367556718355089*std::sin(0.208000004291534*x_100 + 5.00311994552612) + 0.0208757040348893*std::sin(0.414799869060516*x_100 + 5.20456027984619) - 0.0280816440360382*std::sin(0.319119840860367*x_101 + 5.146399974823) + 0.0176580748659658*std::sin(0.319359838962555*x_102 - 4.27135992050171) + 0.012210728201422*std::sin(0.320079833269119*x_102 - 4.26879978179932) + 0.00421961456877013*std::sin(0.322719842195511*x_102 + 5.12976026535034) + 0.0207026989194129*std::sin(0.3503198325634*x_102 - 7.41847991943359) - 0.0049967864346522*std::sin(0.336479842662811*x_103 - 7.43991994857788) - 0.017479711025118*std::sin(0.404639840126038*x_103 - 7.39447975158691) - 0.00633713426165109*std::sin(0.442559868097305*x_103 + 5.23320007324219) - 0.00888166540080979*std::sin(0.276479959487915*x_104 - 7.50216007232666) - 0.018212155797568*std::sin(0.353279858827591*x_105 - 4.24919986724854) - 0.00661356505738312*std::sin(0.437759846448898*x_105 - 1.18407988548279) + 0.00400469061499354*std::sin(0.360079854726791*x_106 + 5.16480016708374) + 0.00622415476391825*std::sin(0.452639847993851*x_106 + 2.046719789505) - 0.00796866769421884*std::sin(0.365039855241776*x_107 - 7.41479969024658) - 0.00458376548187163*std::sin(0.382639855146408*x_107 + 5.18391990661621) + 0.0085962926350793*std::sin(0.426959842443466*x_107 + 5.22248029708862) + 0.00995092650256373*std::sin(0.211359992623329*x_108 + 5.00783967971802) - 0.0182606946052108*std::sin(0.238799974322319*x_108 - 7.55640029907227) + 0.00570284897290735*std::sin(0.301119923591614*x_108 - 4.28095960617065) + 0.0133203571817631*std::sin(0.353679835796356*x_108 - 7.44871950149536) + 0.0218624576469486*std::sin(0.323999851942062*x_109 + 5.12048006057739) + 0.00291140371127403*std::sin(0.359439849853516*x_109 + 5.17456007003784) + 0.0137738080218965*std::sin(0.3643998503685*x_109 + 5.17935991287231) - 0.0100013506506673*std::sin(0.422879844903946*x_109 + 2.01311993598938) - 0.00848672678745501*std::sin(0.300399929285049*x_11 + 8.32439994812012) + 0.0186376603842588*std::sin(0.327679842710495*x_11 - 1.06183981895447) - 0.00833416205645334*std::sin(0.384719848632813*x_110 + 8.17407989501953) + 0.0134747074653941*std::sin(0.390239834785461*x_110 + 5.18304014205933) + 0.0127822586035592*std::sin(0.456639856100082*x_110 + 2.05167984962463) + 0.00798128507208095*std::sin(0.480879843235016*x_111 - 7.34032011032104) + 0.00723173149874972*std::sin(0.48431983590126*x_111 + 5.24575996398926) - 0.0157166698326202*std::sin(0.364639848470688*x_112 + 5.16183996200562) + 0.0167230098995188*std::sin(0.380959838628769*x_112 - 7.40343999862671) + 0.00137197623975868*std::sin(0.475119858980179*x_112 + 1.8407998085022) + 0.0140989593092699*std::sin(0.366319835186005*x_113 - 7.42911958694458) + 0.0175219570133489*std::sin(0.373439848423004*x_114 - 7.42952013015747) + 0.00985697074354377*std::sin(0.393599838018417*x_114 + 1.99799978733063) - 0.00726792345052502*std::sin(0.44159984588623*x_114 - 7.38136005401611) - 0.0115142112876557*std::sin(0.355759829282761*x_115 - 1.24439990520477) - 0.00824883297815641*std::sin(0.36847984790802*x_115 + 8.36911964416504) - 0.0205032245148525*std::sin(0.306239932775497*x_117 - 4.28335952758789) - 0.0216059103834809*std::sin(0.380719840526581*x_117 + 5.18304014205933) - 0.0102135764148965*std::sin(0.478159844875336*x_117 + 2.04239964485168) - 0.00548189425285848*std::sin(0.334479838609695*x_118 - 4.26528024673462) - 0.0291559571481893*std::sin(0.365839838981628*x_118 + 5.15880012512207) - 0.010321083900545*std::sin(0.372159838676453*x_118 + 1.98983991146088) - 0.0202629432390959*std::sin(0.393759846687317*x_118 + 5.18567991256714) + 0.0253870639236141*std::sin(0.339599847793579*x_119 + 5.15136003494263) + 0.0219317059849482*std::sin(0.397039830684662*x_119 + 1.97919988632202) - 0.0194186639131161*std::sin(0.359199851751328*x_12 + 5.17248010635376) - 0.0129063117495549*std::sin(0.423359870910645*x_12 + 8.41808032989502) + 0.0168418624921099*std::sin(0.371839851140976*x_120 - 7.41567993164063) - 0.00367913231194918*std::sin(0.426879853010178*x_120 + 2.20191979408264) - 0.0111410828663962*std::sin(0.4859998524189*x_120 + 2.06983971595764) - 0.00604230195768555*std::sin(0.270879954099655*x_14 + 1.8879998922348) - 0.0255629689843164*std::sin(0.306239932775497*x_14 + 5.15127992630005) + 0.0213506159123282*std::sin(0.431279867887497*x_15 - 0.968239843845367) + 0.000607788634915507*std::sin(1.49863994121552*x_15 - 2.5971200466156) + 0.0524107576787518*std::sin(0.258959949016571*x_18 + 5.06335973739624) + 0.00173449596574596*std::sin(0.599039852619171*x_19 - 0.798399865627289) - 0.0174532275782735*std::sin(0.263439953327179*x_21 - 1.12615990638733) - 0.017718567769578*std::sin(0.30991992354393*x_21 - 4.27695989608765) - 0.0204600949917905*std::sin(0.325759828090668*x_21 - 4.2579197883606) - 0.0317389844572225*std::sin(0.271119952201843*x_23 + 5.0798397064209) + 0.0169815949737418*std::sin(0.310719907283783*x_23 - 4.24408006668091) - 0.011628740495005*std::sin(0.376079827547073*x_24 + 8.37248039245605) - 0.0256033768806123*std::sin(0.325119823217392*x_26 - 4.25880002975464) + 0.0097868103274182*std::sin(0.326479852199554*x_26 + 8.31744003295898) - 0.0234512474414546*std::sin(0.338239848613739*x_26 - 4.26504039764404) + 0.0851082936242522*std::sin(0.213039994239807*x_27 - 7.5717601776123) + 0.000224890765142495*std::sin(1.74143981933594*x_27 - 1.98255980014801) + 0.0124031731987557*std::sin(0.347439825534821*x_28 + 8.35303974151611) + 0.0145591121301619*std::sin(0.361359834671021*x_28 + 8.34383964538574) - 0.00395474264827095*std::sin(0.810399830341339*x_29 + 5.61424016952515) - 0.00107026642302126*std::sin(1.04367983341217*x_29 + 6.00735950469971) + 0.0269561317391144*std::sin(0.306319922208786*x_3 + 8.31271934509277) - 0.0393593840455318*std::sin(0.338559836149216*x_3 + 8.35519981384277) + 0.0196966862572874*std::sin(0.349679857492447*x_3 - 4.23496007919312) + 0.00797985648486493*std::sin(0.330079823732376*x_30 + 8.34352016448975) + 0.0490975426527903*std::sin(0.259839981794357*x_32 + 5.17312002182007) - 0.0403321417477598*std::sin(0.271519958972931*x_32 - 7.43567991256714) + 0.0061073029013248*std::sin(0.311999946832657*x_32 - 4.44504022598267) - 0.0163977103003519*std::sin(0.218399986624718*x_33 - 7.38711977005005) + 0.047339777919193*std::sin(0.279199957847595*x_33 - 1.16039991378784) + 0.0106170337222544*std::sin(0.292239934206009*x_33 + 8.22999954223633) - 0.0155527853385094*std::sin(0.277199953794479*x_34 - 1.12231993675232) - 0.0272184889491705*std::sin(0.357199847698212*x_34 - 7.39351987838745) + 0.0153752580501656*std::sin(0.386319845914841*x_34 + 1.9748797416687) - 0.00962026030089153*std::sin(0.272719949483871*x_35 - 1.1399998664856) - 0.0168486075436657*std::sin(0.316319853067398*x_35 - 1.20743989944458) - 0.0250992408240607*std::sin(0.316399842500687*x_35 - 7.42007970809937) - 0.0111475213618264*std::sin(0.343759834766388*x_36 - 7.44807958602905) + 0.0284411339238374*std::sin(0.363919854164124*x_36 - 4.23432016372681) + 0.0149057983629726*std::sin(0.367839843034744*x_36 + 5.17136001586914) + 0.0101492175925319*std::sin(0.358239859342575*x_37 + 5.17824029922485) + 0.0120587994434314*std::sin(0.403439849615097*x_37 - 4.20223999023438) + 0.0142567571213123*std::sin(0.450879871845245*x_37 + 2.03239989280701) + 0.0326534365246911*std::sin(0.165120020508766*x_38 - 7.63992023468018) + 0.0185571188903779*std::sin(0.249279975891113*x_38 + 5.06663990020752) - 0.00871200284373371*std::sin(0.271279960870743*x_39 + 8.28528022766113) - 0.0126200819984973*std::sin(0.30295991897583*x_39 - 4.30272006988525) - 0.0241092366254603*std::sin(0.306399941444397*x_40 + 5.12367963790894) + 0.0285463231576434*std::sin(0.315039843320847*x_40 - 4.28247976303101) + 0.01338839469701*std::sin(0.330479830503464*x_41 + 5.14264011383057) + 0.0116540630641996*std::sin(0.357199847698212*x_41 - 7.43991994857788) + 0.0184769855028715*std::sin(0.365519851446152*x_41 - 7.41623973846436) - 0.0212534870285836*std::sin(0.303599923849106*x_42 + 5.09543991088867) + 0.0185719015159757*std::sin(0.348079830408096*x_42 - 1.23199987411499) + 0.0165970849904206*std::sin(0.358479857444763*x_42 + 1.97983980178833) - 0.0192266020393717*std::sin(0.356159836053848*x_43 + 5.15208005905151) + 0.0138992771648913*std::sin(0.377679854631424*x_43 + 5.18800020217896) - 0.00932886129598129*std::sin(0.29351994395256*x_44 - 4.27183961868286) - 0.0119991807633879*std::sin(0.220559984445572*x_45 + 8.22208023071289) - 0.0182611646018944*std::sin(0.296639919281006*x_45 + 5.11967945098877) + 0.0115059885721358*std::sin(0.466559857130051*x_45 + 5.24775981903076) - 0.020244463063401*std::sin(0.195199996232986*x_46 + 4.97847986221313) + 0.0290516320600695*std::sin(0.290079951286316*x_46 + 5.11967992782593) - 0.00825769718654888*std::sin(0.439439862966537*x_46 - 4.14663982391357) + 0.0156223955161606*std::sin(0.376559853553772*x_47 + 5.1625599861145) + 0.00226809225338753*std::sin(0.624079823493958*x_47 - 7.38527965545654) - 0.0104620710502728*std::sin(0.509759843349457*x_48 + 8.27455902099609) + 0.00445421306367162*std::sin(0.589999854564667*x_48 - 7.40863990783691) + 0.0102904989834588*std::sin(0.219999998807907*x_49 - 1.36087989807129) - 0.0126682355447557*std::sin(0.326879858970642*x_49 - 4.26919984817505) + 0.0179749805589396*std::sin(0.352319836616516*x_49 - 4.23863983154297) + 0.00380893982081174*std::sin(0.506479859352112*x_49 + 8.28087997436523) + 0.0487062150068056*std::sin(0.304159939289093*x_50 - 7.47200012207031) + 0.00782296631526581*std::sin(0.350559860467911*x_50 + 5.15431976318359) - 0.0106040943799629*std::sin(0.375439822673798*x_50 - 4.23304033279419) - 0.00811867582901967*std::sin(0.428159862756729*x_50 - 1.17399990558624) + 0.00673658695546621*std::sin(0.321599841117859*x_51 - 7.47175979614258) - 0.0217980278654369*std::sin(0.352479845285416*x_51 + 5.1418399810791) + 0.03511945859342*std::sin(0.233919993042946*x_52 + 8.23464012145996) - 0.0574127587128688*std::sin(0.131200045347214*x_53 - 7.68440008163452) + 0.0163240676708564*std::sin(0.231279999017715*x_53 - 7.54808044433594) + 0.0106396147053503*std::sin(0.295199930667877*x_53 - 4.27360010147095) - 0.00388103189941486*std::sin(0.334159851074219*x_53 - 1.068079829216) + 0.0197862316689648*std::sin(0.198559984564781*x_55 - 4.39231967926025) + 0.023896990747878*std::sin(0.308479934930801*x_55 - 7.46504020690918) + 0.0155208828896765*std::sin(0.317279845476151*x_55 - 4.28736019134521) + 0.00547820245667586*std::sin(0.342239856719971*x_56 + 5.13784027099609) + 0.0207770990624676*std::sin(0.363439828157425*x_56 + 5.15592002868652) - 0.00451434954442826*std::sin(0.319519847631454*x_57 - 7.47119998931885) + 0.0106994584300508*std::sin(0.366719841957092*x_57 + 8.35023975372314) - 0.0139476415545013*std::sin(0.373519837856293*x_57 - 4.21056032180786) + 0.0166397380568461*std::sin(0.41023987531662*x_57 + 5.21224021911621) + 0.0109391021229755*std::sin(0.250159978866577*x_58 - 7.52272033691406) + 0.00693321421795921*std::sin(0.389519840478897*x_58 + 1.97375977039337) - 0.00567638028634132*std::sin(0.463439851999283*x_58 - 1.13231992721558) - 0.00557828944874359*std::sin(0.307839930057526*x_59 - 7.46871995925903) + 0.0225527850587748*std::sin(0.314319908618927*x_59 + 5.13312005996704) + 0.0305144862445334*std::sin(0.228319987654686*x_60 + 5.03671979904175) - 0.0251769479380785*std::sin(0.344799846410751*x_60 - 4.26503992080688) + 0.0154445597834164*std::sin(0.324959844350815*x_62 + 8.3133602142334) + 0.0483730365908761*std::sin(0.206400007009506*x_64 - 4.40303993225098) + 0.0239842236806744*std::sin(0.238079980015755*x_64 - 4.35223960876465) - 0.0117422204988566*std::sin(0.196719989180565*x_65 + 5.00432014465332) - 0.0250246711832747*std::sin(0.199680000543594*x_66 + 4.99975967407227) - 0.0399789306106972*std::sin(0.201039999723434*x_67 + 5.00600004196167) - 0.0562890140357176*std::sin(0.202800005674362*x_67 - 7.58416032791138) - 0.0180724746980823*std::sin(0.225759983062744*x_67 + 5.03471994400024) + 0.00145068620490467*std::sin(0.343759834766388*x_67 - 4.43192005157471) - 0.0448953567465993*std::sin(0.225199997425079*x_69 + 5.02031993865967) + 0.0264023946445048*std::sin(0.251279979944229*x_69 + 5.05583953857422) + 0.0249431284818674*std::sin(0.262479960918427*x_69 + 5.07775974273682) + 0.099671356454551*std::sin(0.13864004611969*x_70 - 7.66880035400391) + 0.00542384627506744*std::sin(0.345999836921692*x_70 - 1.06407976150513) + 0.00876064032209193*std::sin(0.298959940671921*x_71 + 5.11895942687988) - 0.0171954997134933*std::sin(0.33111983537674*x_74 - 4.27975988388062) - 0.0138290196164503*std::sin(0.344799846410751*x_74 - 4.25688028335571) + 0.00785765745447189*std::sin(0.365679830312729*x_74 + 1.94711983203888) + 0.0106674761163934*std::sin(0.241279974579811*x_75 - 7.54800033569336) + 0.000162928923279585*std::sin(0.873279869556427*x_75 + 2.20911979675293) - 0.00803163419130813*std::sin(0.358159840106964*x_76 - 4.25072002410889) + 0.0806475857230718*std::sin(0.144800037145615*x_77 - 7.65912008285522) - 0.0153887520935782*std::sin(0.31399992108345*x_77 - 7.46776008605957) - 0.0310934700628757*std::sin(0.255599975585938*x_79 + 5.07967948913574) + 0.0334821464756217*std::sin(0.255679965019226*x_79 + 5.05535984039307) - 0.0191650853907989*std::sin(0.257119983434677*x_79 + 5.05615997314453) + 0.0323101435063333*std::sin(0.266479969024658*x_8 + 5.09807968139648) + 0.00286468241318365*std::sin(0.474159836769104*x_80 + 8.48776054382324) - 0.00738937977004966*std::sin(0.275119960308075*x_82 - 7.49600028991699) - 0.0221587867314984*std::sin(0.326799839735031*x_82 + 5.12800025939941) - 0.0218013362730491*std::sin(0.270079970359802*x_83 + 5.10271978378296) - 0.0131036806257949*std::sin(0.276319950819016*x_83 + 5.11303997039795) - 0.0119327839579601*std::sin(0.410399854183197*x_83 - 7.39120006561279) - 0.00457702682831504*std::sin(0.510559856891632*x_83 + 8.3342399597168) - 0.0199737263490619*std::sin(0.234959989786148*x_84 + 5.02799987792969) - 0.0131766623888135*std::sin(0.305039942264557*x_84 + 5.14831972122192) + 0.0183882422453436*std::sin(0.319039851427078*x_84 - 4.2947998046875) - 0.0329573304433235*std::sin(0.265119940042496*x_85 + 5.06559991836548) + 0.00287902659723062*std::sin(0.50791984796524*x_85 - 0.885199844837189) + 0.024469353458641*std::sin(0.195919990539551*x_87 + 1.79983985424042) + 0.0288149574049229*std::sin(0.242479979991913*x_87 + 5.03991985321045) - 0.0478815994569225*std::sin(0.148960039019585*x_88 - 7.65576028823853) - 0.0797772568729389*std::sin(0.12216005474329*x_9 + 8.07327938079834) - 0.0107606297490524*std::sin(0.497999846935272*x_9 + 2.30663990974426) - 0.00315200342134882*std::sin(0.446799844503403*x_90 - 4.16096019744873) - 0.0450152525320511*std::sin(0.168240025639534*x_91 + 5.22959995269775) - 0.0656540625841263*std::sin(0.179120019078255*x_91 + 5.2279200553894) - 0.00907647927494106*std::sin(0.324799835681915*x_92 + 2.19455981254578) - 0.0383670119117153*std::sin(0.336719840764999*x_92 + 5.20352029800415) - 0.0106330824780615*std::sin(0.285359919071198*x_93 + 8.27120018005371) - 0.00363266960098894*std::sin(0.384559839963913*x_93 + 1.77711987495422) + 0.0213301002242243*std::sin(0.394639849662781*x_93 + 1.99383985996246) + 0.00697372505217828*std::sin(0.343359857797623*x_94 + 1.96759986877441) - 0.01271947493288*std::sin(0.370159834623337*x_94 - 7.40679979324341) - 0.0221508784584613*std::sin(0.390079855918884*x_94 - 7.40775966644287) - 0.0177544318701265*std::sin(0.367199838161469*x_95 + 5.17216014862061) - 0.0140539617581863*std::sin(0.385119825601578*x_95 - 7.39695978164673) - 0.00978899138380635*std::sin(0.368079841136932*x_96 + 5.16943979263306) - 0.0187279648734107*std::sin(0.383679836988449*x_96 - 7.40807962417603) - 0.00756743258011606*std::sin(0.409599870443344*x_96 - 7.38104009628296) + 0.0275859591139347*std::sin(0.345919847488403*x_97 + 5.16247987747192) + 0.0161591183058653*std::sin(0.352719843387604*x_98 - 4.2403998374939) + 0.0179494835717123*std::sin(0.407839864492416*x_98 + 2.00023984909058) - 0.00731234479959122*std::sin(0.444959849119186*x_98 + 2.03095984458923) - 0.0160120324562269*std::sin(0.310319930315018*x_99 - 7.48432016372681) - 0.00775984562751272*std::sin(0.42783984541893*x_99 - 1.18479979038239) - 0.0101209257317318);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00221664448395123*x_1 + 0.00249731483704509*x_10 - 0.00105251804893031*x_100 + 0.00215896921155707*x_101 + 0.00069144951134224*x_103 - 0.000592341616400314*x_104 + 0.00103972189498204*x_105 - 0.000210421581183596*x_106 - 0.000387721805264127*x_107 + 0.000323917773036492*x_11 + 0.00134180700630381*x_110 - 0.00212673793987628*x_111 - 0.00124954153007884*x_112 - 0.00179736508019373*x_113 - 0.000152164373118989*x_114 + 0.000579369383359295*x_115 - 0.00346963123586934*x_116 + 0.000339172747281017*x_117 + 0.00340780650672869*x_119 + 0.00204361823015431*x_12 - 0.000247918893860887*x_120 + 0.00174052437934895*x_13 + 6.11673233464736e-5*x_14 + 0.00134540764359938*x_15 + 0.0077548031641721*x_16 + 0.0049184571561515*x_17 + 0.00217076559698639*x_18 - 0.000233385197455341*x_19 - 0.000785999453384547*x_2 - 0.0104534862311189*x_20 - 0.000574271463354576*x_21 + 0.00105441257208401*x_22 - 0.00214466206469949*x_23 - 0.000750542628810471*x_24 + 0.000768749694468944*x_25 + 5.84446892982857e-5*x_26 - 0.00030379704237002*x_28 - 0.00463215419287742*x_29 - 0.0041136368324026*x_3 + 0.00237369541839351*x_30 - 0.00652704068729321*x_31 - 0.00120748499276088*x_32 - 0.00058335218278242*x_33 + 0.000331439575067408*x_34 + 0.00233059999902186*x_35 + 4.42761967371963e-5*x_36 - 0.000126716535610498*x_37 - 0.000129874101830398*x_38 + 0.000457161047058007*x_39 - 0.00281758412741388*x_4 + 0.00187915842134718*x_40 - 0.000266056202100986*x_41 + 0.00271177615102569*x_42 - 0.000737411924806946*x_43 + 0.000176677995226347*x_44 + 0.000200784326848262*x_45 + 0.000161573652458061*x_46 + 0.00047763632890703*x_47 - 0.00135928165406118*x_48 - 0.000689617732349354*x_5 + 0.000844799644068684*x_51 - 0.00129230316968094*x_52 - 0.00306515096468312*x_54 - 0.000120476265641938*x_56 - 8.3062602750541e-5*x_59 - 0.00175924844392211*x_6 + 0.000508735430040472*x_60 - 0.0044695411773789*x_61 + 0.000797266864820109*x_62 - 0.00105736996896995*x_63 - 0.00248654514836407*x_64 + 0.00132143904353413*x_65 - 0.00101909748219161*x_66 + 0.000802115630436755*x_68 - 8.00617416892329e-5*x_7 - 3.93223589526376e-5*x_70 - 0.000998742789947561*x_72 - 0.000987025429890518*x_73 - 0.00170367570257871*x_74 + 6.28167568624401e-5*x_75 + 0.00300999960116357*x_76 + 0.000450280653960996*x_77 - 6.41136734082374e-5*x_78 - 0.000761588934676117*x_79 - 0.00114136687221244*x_8 - 0.00016499587153939*x_80 - 0.000291728031665599*x_81 - 0.000269270971099325*x_82 - 0.000370159318422185*x_85 - 8.60462955647403e-5*x_86 - 0.000357740510506437*x_88 + 0.000237391416968189*x_89 - 0.000539267697647948*x_9 - 0.000721189738066603*x_90 + 0.000402190014999503*x_91 - 0.0036329124285919*x_92 + 0.000361610276336951*x_93 - 0.000282066385925264*x_94 - 0.000716396461000751*x_95 - 0.00204294203760544*x_96 + 0.00150479268900825*x_97 - 0.00164588238225093*x_98 - 0.000794251755911942*x_99 + 4.8643322018827e-5*std::pow(-4.47631978988647*x_100 - 6.92568016052246, 2) + 2.84067516120377e-5*std::pow(-3.50639986991882*x_17 - 5.15751981735229, 2) - 0.000114241228347335*std::pow(-3.88375997543335*x_19 - 6.13335990905762, 2) - 0.000209733535126806*std::pow(-0.866319835186005*x_24 - 1.30367994308472, 2) - 1.37168547789736e-5*std::pow(-6.56744050979614*x_27 - 9.54936027526855, 2) + 1.12780029587796e-5*std::pow(-4.51200008392334*x_38 - 6.96360015869141, 2) - 7.24531018140259e-5*std::pow(-5.81879997253418*x_4 - 9.82336044311523, 2) - 1.90894123492988e-6*std::pow(-5.71783971786499*x_43 - 8.27400016784668, 2) + 4.28023684889989e-5*std::pow(-4.35264015197754*x_55 - 6.33048009872437, 2) - 0.000103621284510473*std::pow(-3.86879992485046*x_6 - 6.51087999343872, 2) - 4.68443446793289e-6*std::pow(-5.42744016647339*x_60 - 8.43583965301514, 2) + 1.31690737341538e-5*std::pow(-6.62088012695313*x_69 - 9.43920040130615, 2) - 3.94539952658396e-5*std::pow(-5.21744012832642*x_7 - 9.23895931243896, 2) + 1.59661200233622e-5*std::pow(-5.09847974777222*x_7 - 7.94231986999512, 2) - 3.54566400486485e-6*std::pow(-5.8854398727417*x_71 - 9.54551982879639, 2) - 2.91892405043236e-5*std::pow(-4.14160013198853*x_71 - 6.69736003875732, 2) + 2.01903498568908e-5*std::pow(-6.52383947372437*x_77 - 9.1627197265625, 2) - 3.81767538984457e-6*std::pow(-7.06584024429321*x_78 - 9.41096019744873, 2) - 2.13030479331208e-5*std::pow(-6.66368007659912*x_78 - 9.21712017059326, 2) + 1.72515767533326e-5*std::pow(-3.69936013221741*x_80 - 6.42208003997803, 2) - 0.00021688082993486*std::pow(-1.82767987251282*x_80 - 2.43895983695984, 2) - 1.50476681589875e-5*std::pow(-7.45847988128662*x_81 - 9.67831993103027, 2) + 2.11917501139742e-6*std::pow(-9.20399951934814*x_82 - 9.99767971038818, 2) - 0.000119511835788559*std::pow(-1.03719985485077*x_84 - 2.28391981124878, 2) - 8.4660931965164e-6*std::pow(-8.02295970916748*x_86 - 9.42399978637695, 2) - 8.47325313504765e-6*std::pow(-6.90776014328003*x_86 - 7.71479988098145, 2) - 5.59213421172931e-5*std::pow(-5.18376016616821*x_87 - 7.56544017791748, 2) + 2.39985430528303e-5*std::pow(-7.48543977737427*x_89 - 9.05047988891602, 2) + 9.60414466286815e-6*std::pow(-5.88768005371094*x_90 - 8.31655979156494, 2) - 0.000526944699231535*std::pow(-0.142026160228982*x_10 + 0.00475640578200159*x_104 + 0.0256810809230321*x_105 + 0.0191559473997721*x_106 - 0.0422018852491643*x_11 + 0.052381621063997*x_113 + 0.00313768146903981*x_115 + 0.0130893472201043*x_116 + 0.334714242343596*x_13 - 0.143701833658056*x_14 + 0.111418264320016*x_16 - 0.0050645384152244*x_17 + 0.123171069485432*x_19 - 0.128624404233938*x_2 + 0.446725916675453*x_20 + 0.0743506066498668*x_25 + 0.012538884617311*x_27 + 0.00221273722079548*x_30 + 0.747280660995448*x_31 - 0.00206371046172116*x_39 + 0.0782574753112931*x_4 - 0.0502172325255704*x_44 - 0.119091805554154*x_47 + 0.042843167149984*x_5 - 0.00962123764897213*x_52 - 0.0209850116978204*x_54 - 0.0231542608292816*x_56 + 0.186145785807058*x_58 - 0.0497494336766713*x_6 + 0.183101009559835*x_61 + 0.219308195392669*x_62 + 0.0210057392608128*x_63 + 0.0106661122605109*x_65 - 0.0366574365050827*x_68 + 0.212813633736373*x_7 - 0.017620450167798*x_70 + 0.102294880394721*x_72 - 0.136877509040459*x_76 - 0.0535875755591294*x_78 - 0.0163455954039432*x_8 + 0.0191693748114047*x_81 - 0.0476598480148802*x_86 - 0.00259217914420877*x_87 - 0.0116364518893409*x_88 + 0.0796907157670038*x_90 + 0.00667922704076887*x_92 - 0.00949723764522492*std::pow(-4.37183952331543*x_18 - 6.95983982086182, 2) - 0.0020773066107303*std::pow(-5.80399990081787*x_22 - 9.99647998809814, 2) - 0.00233025745742804*std::pow(-4.18495988845825*x_24 - 7.37408018112183, 2) - 0.00093140045490811*std::pow(-5.41200017929077*x_64 - 9.21903991699219, 2) + 0.00133152852256652*std::pow(-6.89007997512817*x_66 - 9.33463954925537, 2) + 0.00136154985062958*std::pow(-6.25472021102905*x_71 - 9.68151950836182, 2) + 0.00378545618036852*std::pow(-5.3120002746582*x_73 - 7.55503988265991, 2) - 0.0080646234555255*std::pow(-1.42991983890533*x_75 - 1.61055982112885, 2) - 0.0023867005284971*std::pow(-5.15536022186279*x_89 - 6.94384002685547, 2) + 6.25833363128504*std::sin(0.215440005064011*x_1 - 7.3842396736145) + 1.9218008402035*std::sin(0.414799869060516*x_100 + 5.20456027984619) - 2.5851739904225*std::sin(0.319119840860367*x_101 + 5.146399974823) + 1.90587412579299*std::sin(0.3503198325634*x_102 - 7.41847991943359) - 1.60916840353951*std::sin(0.404639840126038*x_103 - 7.39447975158691) + 0.791367916556027*std::sin(0.426959842443466*x_107 + 5.22248029708862) + 1.22626157091227*std::sin(0.353679835796356*x_108 - 7.44871950149536) + 2.01264059907152*std::sin(0.323999851942062*x_109 + 5.12048006057739) + 1.17672464042235*std::sin(0.456639856100082*x_110 + 2.05167984962463) + 0.665747495135776*std::sin(0.48431983590126*x_111 + 5.24575996398926) + 1.53950709503806*std::sin(0.380959838628769*x_112 - 7.40343999862671) + 0.907424948406259*std::sin(0.393599838018417*x_114 + 1.99799978733063) - 1.98902306044096*std::sin(0.380719840526581*x_117 + 5.18304014205933) - 2.6840744077748*std::sin(0.365839838981628*x_118 + 5.15880012512207) + 2.01901554642313*std::sin(0.397039830684662*x_119 + 1.97919988632202) - 1.18814487515101*std::sin(0.423359870910645*x_12 + 8.41808032989502) - 1.025639297129*std::sin(0.4859998524189*x_120 + 2.06983971595764) + 1.96552085288232*std::sin(0.431279867887497*x_15 - 0.968239843845367) - 1.60673035832139*std::sin(0.263439953327179*x_21 - 1.12615990638733) + 1.56331223291869*std::sin(0.310719907283783*x_23 - 4.24408006668091) + 0.900966035862098*std::sin(0.326479852199554*x_26 + 8.31744003295898) + 1.14182633719662*std::sin(0.347439825534821*x_28 + 8.35303974151611) - 0.0985278823442925*std::sin(1.04367983341217*x_29 + 6.00735950469971) - 3.6233938363074*std::sin(0.338559836149216*x_3 + 8.35519981384277) + 4.51988103320321*std::sin(0.259839981794357*x_32 + 5.17312002182007) + 4.35806259889978*std::sin(0.279199957847595*x_33 - 1.16039991378784) - 1.43177714538865*std::sin(0.277199953794479*x_34 - 1.12231993675232) - 2.31061630417514*std::sin(0.316399842500687*x_35 - 7.42007970809937) + 2.61826834581586*std::sin(0.363919854164124*x_36 - 4.23432016372681) + 1.31246581042365*std::sin(0.450879871845245*x_37 + 2.03239989280701) + 1.70835372142091*std::sin(0.249279975891113*x_38 + 5.06663990020752) + 2.62795198367405*std::sin(0.315039843320847*x_40 - 4.28247976303101) + 1.70097670500121*std::sin(0.365519851446152*x_41 - 7.41623973846436) + 1.70971459826831*std::sin(0.348079830408096*x_42 - 1.23199987411499) - 1.76998581182073*std::sin(0.356159836053848*x_43 + 5.15208005905151) + 1.05923222844828*std::sin(0.466559857130051*x_45 + 5.24775981903076) - 0.76019708675372*std::sin(0.439439862966537*x_46 - 4.14663982391357) - 0.963130005152408*std::sin(0.509759843349457*x_48 + 8.27455902099609) + 0.350647994227486*std::sin(0.506479859352112*x_49 + 8.28087997436523) + 4.48385571891481*std::sin(0.304159939289093*x_50 - 7.47200012207031) - 2.00670924422781*std::sin(0.352479845285416*x_51 + 5.1418399810791) + 0.979474533937179*std::sin(0.295199930667877*x_53 - 4.27360010147095) + 2.19993811087056*std::sin(0.308479934930801*x_55 - 7.46504020690918) + 1.53184115491234*std::sin(0.41023987531662*x_57 + 5.21224021911621) + 2.07619159585926*std::sin(0.314319908618927*x_59 + 5.13312005996704) - 2.31776995977208*std::sin(0.344799846410751*x_60 - 4.26503992080688) - 5.18192221384606*std::sin(0.202800005674362*x_67 - 7.58416032791138) - 4.13303111467053*std::sin(0.225199997425079*x_69 + 5.02031993865967) + 0.72336974469448*std::sin(0.365679830312729*x_74 + 1.94711983203888) - 1.41667637430072*std::sin(0.31399992108345*x_77 - 7.46776008605957) - 2.86244031778801*std::sin(0.255599975585938*x_79 + 5.07967948913574) + 0.263720402405184*std::sin(0.474159836769104*x_80 + 8.48776054382324) - 2.03992042075862*std::sin(0.326799839735031*x_82 + 5.12800025939941) - 2.00701381362188*std::sin(0.270079970359802*x_83 + 5.10271978378296) - 1.21303314166448*std::sin(0.305039942264557*x_84 + 5.14831972122192) - 3.03402583361924*std::sin(0.265119940042496*x_85 + 5.06559991836548) - 0.990615083366094*std::sin(0.497999846935272*x_9 + 2.30663990974426) - 4.14406862606813*std::sin(0.168240025639534*x_91 + 5.22959995269775) + 1.96363219482464*std::sin(0.394639849662781*x_93 + 1.99383985996246) - 1.17094482524291*std::sin(0.370159834623337*x_94 - 7.40679979324341) - 1.63445898774575*std::sin(0.367199838161469*x_95 + 5.17216014862061) - 0.901166822192096*std::sin(0.368079841136932*x_96 + 5.16943979263306) + 2.5395416276441*std::sin(0.345919847488403*x_97 + 5.16247987747192) - 0.673168691998399*std::sin(0.444959849119186*x_98 + 2.03095984458923) - 1.47405507264875*std::sin(0.310319930315018*x_99 - 7.48432016372681) - 16.3282114945907, 2) + 0.000506265693501609*std::exp(0.82207989692688*x_25) + 0.0122159394938598*std::sin(0.364479839801788*x_1 - 4.37279987335205) + 0.0122895548584831*std::sin(0.301679849624634*x_10 + 5.10400009155273) + 0.0124843727197933*std::sin(0.208000004291534*x_100 + 5.00311994552612) + 0.00599771347201331*std::sin(0.319359838962555*x_102 - 4.27135992050171) - 0.0101452936030095*std::sin(0.320079833269119*x_102 - 4.26879978179932) - 0.00976696209210571*std::sin(0.322719842195511*x_102 + 5.12976026535034) - 0.00169720049005171*std::sin(0.336479842662811*x_103 - 7.43991994857788) + 0.0146682947215652*std::sin(0.442559868097305*x_103 + 5.23320007324219) + 0.020558012555578*std::sin(0.276479959487915*x_104 - 7.50216007232666) + 0.0151315846739233*std::sin(0.353279858827591*x_105 - 4.24919986724854) - 0.00224635293166392*std::sin(0.437759846448898*x_105 - 1.18407988548279) - 0.00926948677178678*std::sin(0.360079854726791*x_106 + 5.16480016708374) - 0.00517134412206206*std::sin(0.452639847993851*x_106 + 2.046719789505) + 0.0184447356566757*std::sin(0.365039855241776*x_107 - 7.41479969024658) + 0.00380842533334846*std::sin(0.382639855146408*x_107 + 5.18391990661621) - 0.0230329856786416*std::sin(0.211359992623329*x_108 + 5.00783967971802) + 0.0151719131823097*std::sin(0.238799974322319*x_108 - 7.55640029907227) + 0.00193702056273352*std::sin(0.301119923591614*x_108 - 4.28095960617065) - 0.00673890214838207*std::sin(0.359439849853516*x_109 + 5.17456007003784) - 0.0114439797617765*std::sin(0.3643998503685*x_109 + 5.17935991287231) - 0.00339704276888373*std::sin(0.422879844903946*x_109 + 2.01311993598938) + 0.00705120395499672*std::sin(0.300399929285049*x_11 + 8.32439994812012) + 0.00633043792270523*std::sin(0.327679842710495*x_11 - 1.06183981895447) - 0.00283076815696797*std::sin(0.384719848632813*x_110 + 8.17407989501953) - 0.0311893313647073*std::sin(0.390239834785461*x_110 + 5.18304014205933) - 0.0184739405637289*std::sin(0.480879843235016*x_111 - 7.34032011032104) - 0.00533829894288058*std::sin(0.364639848470688*x_112 + 5.16183996200562) - 0.00113990759102179*std::sin(0.475119858980179*x_112 + 1.8407998085022) - 0.0326342605153902*std::sin(0.366319835186005*x_113 - 7.42911958694458) - 0.0145581324444708*std::sin(0.373439848423004*x_114 - 7.42952013015747) + 0.0168227528066133*std::sin(0.44159984588623*x_114 - 7.38136005401611) - 0.0039108985936335*std::sin(0.355759829282761*x_115 - 1.24439990520477) + 0.0190932223047204*std::sin(0.36847984790802*x_115 + 8.36911964416504) + 0.0474579403731806*std::sin(0.306239932775497*x_117 - 4.28335952758789) - 0.00346912703259239*std::sin(0.478159844875336*x_117 + 2.04239964485168) + 0.0126887071053521*std::sin(0.334479838609695*x_118 - 4.26528024673462) + 0.00857528107620394*std::sin(0.372159838676453*x_118 + 1.98983991146088) - 0.00688247889819552*std::sin(0.393759846687317*x_118 + 5.18567991256714) - 0.0210928630115149*std::sin(0.339599847793579*x_119 + 5.15136003494263) + 0.0161340129373927*std::sin(0.359199851751328*x_12 + 5.17248010635376) - 0.0139930753502539*std::sin(0.371839851140976*x_120 - 7.41567993164063) - 0.00124964819779011*std::sin(0.426879853010178*x_120 + 2.20191979408264) - 0.0020523186207253*std::sin(0.270879954099655*x_14 + 1.8879998922348) + 0.0591695153579544*std::sin(0.306239932775497*x_14 + 5.15127992630005) - 0.00140682246221428*std::sin(1.49863994121552*x_15 - 2.5971200466156) + 0.0178017541433208*std::sin(0.258959949016571*x_18 + 5.06335973739624) - 0.00144110740452637*std::sin(0.599039852619171*x_19 - 0.798399865627289) + 0.0410124140277377*std::sin(0.30991992354393*x_21 - 4.27695989608765) - 0.00694944314725115*std::sin(0.325759828090668*x_21 - 4.2579197883606) - 0.0107804127070504*std::sin(0.271119952201843*x_23 + 5.0798397064209) + 0.00966174863684977*std::sin(0.376079827547073*x_24 + 8.37248039245605) + 0.0592630457941853*std::sin(0.325119823217392*x_26 - 4.25880002975464) + 0.0194844882897873*std::sin(0.338239848613739*x_26 - 4.26504039764404) - 0.0707122959930128*std::sin(0.213039994239807*x_27 - 7.5717601776123) - 0.000520545074014095*std::sin(1.74143981933594*x_27 - 1.98255980014801) + 0.00494512474470974*std::sin(0.361359834671021*x_28 + 8.34383964538574) - 0.00134326156389772*std::sin(0.810399830341339*x_29 + 5.61424016952515) + 0.00915587660105945*std::sin(0.306319922208786*x_3 + 8.31271934509277) - 0.0163650080314843*std::sin(0.349679857492447*x_3 - 4.23496007919312) + 0.00271042529309095*std::sin(0.330079823732376*x_30 + 8.34352016448975) - 0.013699150771069*std::sin(0.271519958972931*x_32 - 7.43567991256714) - 0.0141363138623423*std::sin(0.311999946832657*x_32 - 4.44504022598267) + 0.0136240511351968*std::sin(0.218399986624718*x_33 - 7.38711977005005) - 0.0245747956847373*std::sin(0.292239934206009*x_33 + 8.22999954223633) - 0.00924498843149269*std::sin(0.357199847698212*x_34 - 7.39351987838745) - 0.0355884548422345*std::sin(0.386319845914841*x_34 + 1.9748797416687) - 0.00326760223007901*std::sin(0.272719949483871*x_35 - 1.1399998664856) + 0.0139986794819054*std::sin(0.316319853067398*x_35 - 1.20743989944458) + 0.0258026928259544*std::sin(0.343759834766388*x_36 - 7.44807958602905) - 0.0123844948708305*std::sin(0.367839843034744*x_36 + 5.17136001586914) - 0.0234919616176422*std::sin(0.358239859342575*x_37 + 5.17824029922485) - 0.0100190634690544*std::sin(0.403439849615097*x_37 - 4.20223999023438) - 0.0755815185287393*std::sin(0.165120020508766*x_38 - 7.63992023468018) + 0.0201653018621236*std::sin(0.271279960870743*x_39 + 8.28528022766113) + 0.0104854055431273*std::sin(0.30295991897583*x_39 - 4.30272006988525) - 0.00818890475921489*std::sin(0.306399941444397*x_40 + 5.12367963790894) - 0.0309895468765431*std::sin(0.330479830503464*x_41 + 5.14264011383057) - 0.00968278791436243*std::sin(0.357199847698212*x_41 - 7.43991994857788) + 0.0176584772370598*std::sin(0.303599923849106*x_42 + 5.09543991088867) + 0.00563733934751054*std::sin(0.358479857444763*x_42 + 1.97983980178833) - 0.0115482259027768*std::sin(0.377679854631424*x_43 + 5.18800020217896) + 0.0215931178441538*std::sin(0.29351994395256*x_44 - 4.27183961868286) + 0.0277739925631388*std::sin(0.220559984445572*x_45 + 8.22208023071289) + 0.0151723036794421*std::sin(0.296639919281006*x_45 + 5.11967945098877) + 0.0468589962644153*std::sin(0.195199996232986*x_46 + 4.97847986221313) - 0.0241375724718601*std::sin(0.290079951286316*x_46 + 5.11967992782593) - 0.0129798802069259*std::sin(0.376559853553772*x_47 + 5.1625599861145) - 0.00524985652106402*std::sin(0.624079823493958*x_47 - 7.38527965545654) + 0.00151291088649147*std::sin(0.589999854564667*x_48 - 7.40863990783691) + 0.00349525442922369*std::sin(0.219999998807907*x_49 - 1.36087989807129) + 0.0293226251646861*std::sin(0.326879858970642*x_49 - 4.26919984817505) - 0.0149345274311809*std::sin(0.352319836616516*x_49 - 4.23863983154297) - 0.00649971801891246*std::sin(0.350559860467911*x_50 + 5.15431976318359) + 0.0245448455403348*std::sin(0.375439822673798*x_50 - 4.23304033279419) - 0.00275757644954106*std::sin(0.428159862756729*x_50 - 1.17399990558624) - 0.00559709883129244*std::sin(0.321599841117859*x_51 - 7.47175979614258) + 0.0119286191464478*std::sin(0.233919993042946*x_52 + 8.23464012145996) + 0.132890866882005*std::sin(0.131200045347214*x_53 - 7.68440008163452) + 0.0055446067213283*std::sin(0.231279999017715*x_53 - 7.54808044433594) + 0.00322455855643598*std::sin(0.334159851074219*x_53 - 1.068079829216) + 0.00672055980859249*std::sin(0.198559984564781*x_55 - 4.39231967926025) - 0.0128955383574386*std::sin(0.317279845476151*x_55 - 4.28736019134521) - 0.00455156903199535*std::sin(0.342239856719971*x_56 + 5.13784027099609) + 0.00705711624297734*std::sin(0.363439828157425*x_56 + 5.15592002868652) - 0.00153333674738125*std::sin(0.319519847631454*x_57 - 7.47119998931885) - 0.0247655806446857*std::sin(0.366719841957092*x_57 + 8.35023975372314) + 0.0115884094957968*std::sin(0.373519837856293*x_57 - 4.21056032180786) + 0.00371555793441311*std::sin(0.250159978866577*x_58 - 7.52272033691406) - 0.0160480156041818*std::sin(0.389519840478897*x_58 + 1.97375977039337) + 0.00471622524531841*std::sin(0.463439851999283*x_58 - 1.13231992721558) + 0.00463472639195124*std::sin(0.307839930057526*x_59 - 7.46871995925903) - 0.0706305814318264*std::sin(0.228319987654686*x_60 + 5.03671979904175) + 0.00524587447869817*std::sin(0.324959844350815*x_62 + 8.3133602142334) + 0.0164303082553174*std::sin(0.206400007009506*x_64 - 4.40303993225098) - 0.0199273120379798*std::sin(0.238079980015755*x_64 - 4.35223960876465) + 0.0271792175850094*std::sin(0.196719989180565*x_65 + 5.00432014465332) + 0.0207917687041406*std::sin(0.199680000543594*x_66 + 4.99975967407227) - 0.0135791796410729*std::sin(0.201039999723434*x_67 + 5.00600004196167) + 0.0418315873191605*std::sin(0.225759983062744*x_67 + 5.03471994400024) - 0.00120530383051844*std::sin(0.343759834766388*x_67 - 4.43192005157471) - 0.0611124981751245*std::sin(0.251279979944229*x_69 + 5.05583953857422) + 0.0084721431336888*std::sin(0.262479960918427*x_69 + 5.07775974273682) + 0.0338542135492642*std::sin(0.13864004611969*x_70 - 7.66880035400391) - 0.00450640715364876*std::sin(0.345999836921692*x_70 - 1.06407976150513) - 0.00727878524129593*std::sin(0.298959940671921*x_71 + 5.11895942687988) + 0.0142868951274781*std::sin(0.33111983537674*x_74 - 4.27975988388062) - 0.00469714268899061*std::sin(0.344799846410751*x_74 - 4.25688028335571) - 0.00886308133460042*std::sin(0.241279974579811*x_75 - 7.54800033569336) - 0.000377124638149858*std::sin(0.873279869556427*x_75 + 2.20911979675293) + 0.00667308989592462*std::sin(0.358159840106964*x_76 - 4.25072002410889) - 0.0670061131521344*std::sin(0.144800037145615*x_77 - 7.65912008285522) + 0.0113724923307361*std::sin(0.255679965019226*x_79 + 5.05535984039307) + 0.0159233270128607*std::sin(0.257119983434677*x_79 + 5.05615997314453) + 0.0109744116763331*std::sin(0.266479969024658*x_8 + 5.09807968139648) + 0.0171038825755319*std::sin(0.275119960308075*x_82 - 7.49600028991699) + 0.0108872038617054*std::sin(0.276319950819016*x_83 + 5.11303997039795) - 0.00405307031749112*std::sin(0.410399854183197*x_83 - 7.39120006561279) + 0.0105942490239656*std::sin(0.510559856891632*x_83 + 8.3342399597168) + 0.0462323335247751*std::sin(0.234959989786148*x_84 + 5.02799987792969) + 0.00624572095648487*std::sin(0.319039851427078*x_84 - 4.2947998046875) - 0.00239204162421506*std::sin(0.50791984796524*x_85 - 0.885199844837189) - 0.0203303825143549*std::sin(0.195919990539551*x_87 + 1.79983985424042) + 0.00978724235426687*std::sin(0.242479979991913*x_87 + 5.03991985321045) + 0.110829498567557*std::sin(0.148960039019585*x_88 - 7.65576028823853) + 0.184657018073875*std::sin(0.12216005474329*x_9 + 8.07327938079834) + 0.00729580804804984*std::sin(0.446799844503403*x_90 - 4.16096019744873) - 0.0222999539101616*std::sin(0.179120019078255*x_91 + 5.2279200553894) + 0.0210089399312058*std::sin(0.324799835681915*x_92 + 2.19455981254578) - 0.0130316779133898*std::sin(0.336719840764999*x_92 + 5.20352029800415) + 0.00883450535180915*std::sin(0.285359919071198*x_93 + 8.27120018005371) - 0.0012338667476837*std::sin(0.384559839963913*x_93 + 1.77711987495422) - 0.0161417843064386*std::sin(0.343359857797623*x_94 + 1.96759986877441) + 0.0184040756471427*std::sin(0.390079855918884*x_94 - 7.40775966644287) - 0.00477354617714857*std::sin(0.385119825601578*x_95 - 7.39695978164673) - 0.00636111060108499*std::sin(0.383679836988449*x_96 - 7.40807962417603) + 0.00628740760418503*std::sin(0.409599870443344*x_96 - 7.38104009628296) + 0.00548858028378534*std::sin(0.352719843387604*x_98 - 4.2403998374939) - 0.0149133432383018*std::sin(0.407839864492416*x_98 + 2.00023984909058) + 0.0064472741434027*std::sin(0.42783984541893*x_99 - 1.18479979038239) + 0.053784504532814*std::sin(-0.0172885589741869*x_1 + 0.0189213059026861*x_10 + 0.0104349342071758*x_101 + 0.0036416880005509*x_102 + 0.00137230942615816*x_103 - 0.00287967911997018*x_105 - 0.00534151191890276*x_11 + 0.00179245810926871*x_111 - 0.0128705607640344*x_113 + 0.0116539235531768*x_119 + 0.0176543007828506*x_12 + 0.00292097406733148*x_15 - 0.0100261072371652*x_17 - 0.0241158223428241*x_19 + 0.0386475417617897*x_2 + 0.063797685372619*x_20 + 0.0324538295155221*x_22 + 0.00321374717722676*x_25 + 0.00792759574422985*x_29 + 0.015875523716714*x_3 - 0.0182670167178673*x_33 - 0.00345586588301056*x_37 - 0.0249686323537063*x_41 + 0.00563891585492008*x_43 + 0.00558270669685313*x_44 - 0.0230216782819546*x_47 + 0.00319017220206891*x_48 + 0.00444905189448763*x_53 + 0.00466245167533287*x_54 + 0.00385052651905596*x_55 - 0.0195630604864809*x_6 - 0.00332116485524138*x_60 + 0.0210423308792791*x_61 - 0.0193070839541068*x_62 - 0.0179533935241515*x_63 - 0.00599797177712475*x_64 + 0.015150526613787*x_68 + 0.00958949551317639*x_73 + 0.00317010434046273*x_74 - 0.0180567387038511*x_76 + 0.0128420900729018*x_78 + 0.00423654828090052*x_84 + 0.00105343056026612*x_86 - 0.0426619842169633*x_9 - 0.00210215817169189*x_90 + 0.0678845177311056*x_91 + 0.00208482885182814*x_92 - 0.0129750145868021*x_93 - 0.0058399280799467*x_98 - 0.00145889276300729*std::pow(-3.90320014953613*x_4 - 6.1637601852417, 2) - 0.000635401135456071*std::pow(-5.93743944168091*x_5 - 9.30079936981201, 2) - 0.00115266506943628*std::pow(-3.91991996765137*x_7 - 6.46479988098145, 2) - 0.000353810478285255*std::pow(-5.71959972381592*x_71 - 8.97583961486816, 2) + 0.000433931218360974*std::pow(-4.71984004974365*x_80 - 6.09327983856201, 2) + 0.000306713575472201*std::pow(-7.05999994277954*x_81 - 9.27960014343262, 2) + 0.000363196267997336*std::pow(-5.27831983566284*x_85 - 8.4093599319458, 2) + 0.000147155657891005*std::pow(-7.40399980545044*x_87 - 9.99079990386963, 2) + 0.000223603409206949*std::pow(-5.38815975189209*x_88 - 7.58616018295288, 2) - 0.169201281906137*std::sin(0.426559865474701*x_100 + 5.22328042984009) + 0.1380785116151*std::sin(0.431439846754074*x_104 - 7.38263988494873) + 0.227441049542007*std::sin(0.281599938869476*x_106 + 5.08271980285645) + 0.269305662538045*std::sin(0.361199855804443*x_107 + 5.15944004058838) + 0.108972938239026*std::sin(0.575359880924225*x_108 - 7.20560026168823) - 0.0590349484044714*std::sin(0.527999877929688*x_109 + 8.36816024780273) - 0.156129779077993*std::sin(0.398719817399979*x_110 + 2.0097599029541) - 0.210024332314026*std::sin(0.352079838514328*x_112 - 7.44328022003174) + 0.383951790772002*std::sin(0.311119943857193*x_114 + 5.11175966262817) - 0.0470449279865681*std::sin(0.574719846248627*x_115 - 4.20968008041382) + 0.108675351579681*std::sin(0.682319819927216*x_116 + 8.42623996734619) + 0.193223446669055*std::sin(0.461359858512878*x_117 - 7.3459997177124) + 0.163878224434244*std::sin(0.341599822044373*x_118 - 7.44719982147217) + 0.231661052215783*std::sin(0.34639984369278*x_120 + 5.15912008285522) - 1.98773217919357*std::sin(0.171840012073517*x_13 + 8.15135955810547) - 0.645328466231383*std::sin(0.212640002369881*x_14 + 5.00903987884521) + 0.198783006929782*std::sin(0.41951984167099*x_16 - 7.36879968643188) + 1.15798640364606*std::sin(0.185440003871918*x_18 - 7.60567998886108) - 0.0806810369126216*std::sin(0.398319840431213*x_21 - 7.18815994262695) - 0.278190832136687*std::sin(0.217999994754791*x_23 - 7.5860800743103) + 0.210022550469125*std::sin(0.264239966869354*x_24 + 8.05335998535156) + 0.288858960289353*std::sin(0.320399850606918*x_26 + 8.32015991210938) + 0.444948425126462*std::sin(0.279119938611984*x_27 + 5.103759765625) - 0.137147228521524*std::sin(0.417199850082397*x_28 + 8.41736030578613) - 0.143522084909304*std::sin(0.29751992225647*x_30 - 7.49848031997681) + 0.48766158607393*std::sin(0.20040000975132*x_31 - 7.39463949203491) - 0.251807073249042*std::sin(0.210400000214577*x_32 - 1.00415980815887) - 0.200817521149876*std::sin(0.369359821081161*x_34 + 1.97839987277985) - 0.314981586094586*std::sin(0.315359860658646*x_35 + 1.97319984436035) + 0.314553423613592*std::sin(0.366559833288193*x_36 + 5.16152000427246) + 0.353373624670148*std::sin(0.308319836854935*x_38 + 5.11079978942871) + 0.222600834916506*std::sin(0.301999926567078*x_39 + 5.10551977157593) - 0.319318782192369*std::sin(0.394879847764969*x_40 + 5.19040012359619) - 0.173389434102308*std::sin(0.417839854955673*x_42 - 1.1794399023056) - 0.169386222558149*std::sin(0.388719856739044*x_45 + 1.97711980342865) - 0.10706718087391*std::sin(0.44871985912323*x_46 + 5.24927997589111) - 0.00535471828046014*std::sin(1.97479975223541*x_49 - 7.4031195640564) + 0.14851207659135*std::sin(0.436799854040146*x_50 + 5.22847986221313) - 0.290742073375519*std::sin(0.276399940252304*x_51 - 4.30975961685181) - 0.0248923338245459*std::sin(0.71399986743927*x_52 - 1.22463989257813) + 0.567025923128721*std::sin(0.203759998083115*x_56 + 5.00360012054443) + 0.542109160860214*std::sin(0.229999989271164*x_57 - 4.37119960784912) + 0.348887161940141*std::sin(0.266959935426712*x_58 + 5.07175970077515) - 0.155191053069779*std::sin(0.303439915180206*x_59 + 5.13167953491211) - 0.369251310486693*std::sin(0.273279964923859*x_65 + 5.09200000762939) + 0.400217547559269*std::sin(0.221759989857674*x_66 + 5.03087949752808) - 0.284472355117337*std::sin(0.244639977812767*x_67 + 5.04016017913818) - 0.290826432595049*std::sin(0.269839972257614*x_69 + 5.09832000732422) + 0.343689891581725*std::sin(0.289679944515228*x_70 - 7.4759202003479) + 0.139655091695647*std::sin(0.34487983584404*x_72 - 1.04951989650726) + 0.479452663736971*std::sin(0.207840010523796*x_75 - 7.58039999008179) + 0.359403276449694*std::sin(0.293919950723648*x_77 + 5.11543989181519) - 0.0742772069843163*std::sin(0.320879846811295*x_79 + 5.12488031387329) + 0.389812798356026*std::sin(0.325599819421768*x_8 - 4.28672027587891) + 0.656237291932754*std::sin(0.214560002088547*x_82 + 5.02231979370117) + 0.14457946137095*std::sin(0.375839829444885*x_83 + 8.19039916992188) - 0.131868856378788*std::sin(0.357119828462601*x_89 + 5.16175985336304) - 0.176488433602767*std::sin(0.406239867210388*x_94 - 7.39663982391357) - 0.142066196979471*std::sin(0.381119847297668*x_95 + 5.19063997268677) - 0.0990791516220177*std::sin(0.406319856643677*x_96 - 7.39271974563599) - 0.206725729062891*std::sin(0.396479845046997*x_97 - 7.4031195640564) - 0.0940334587259324*std::sin(0.45839986205101*x_99 + 2.04295969009399) + 12.5715508353357) - 0.230143975591384);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00424469313588622*x_1 - 0.00227231829068008*x_10 + 0.000417531830273193*x_101 - 0.00209502876911956*x_104 - 0.000654827843290803*x_105 + 0.000839199598085973*x_106 + 0.00139689854943356*x_107 - 0.000416508761327677*x_11 + 0.00376656766244731*x_111 + 0.000917616559430624*x_112 - 0.00133054084385318*x_113 + 0.000548223466411908*x_114 + 1.32814402311321e-5*x_115 + 0.00190182445512977*x_116 - 0.00328648652520924*x_119 + 0.00479417553547232*x_12 + 0.000182062362015386*x_120 + 4.33320993291875e-5*x_13 - 0.000608273125766849*x_14 - 0.000190196825356144*x_15 - 0.00488308288051258*x_16 - 0.00402913287790278*x_17 - 0.00128923120479197*x_18 + 0.00136221766716104*x_19 + 0.00057629857693411*x_2 + 0.00919452506843661*x_20 + 0.00253010781457689*x_22 + 0.00030541395554519*x_23 + 0.000551170431855616*x_24 - 0.00142816589675339*x_25 - 0.000210566701677389*x_26 + 5.30756382549058e-5*x_27 - 0.000127968584816129*x_28 + 0.00317921466091845*x_29 + 0.00302090101531736*x_3 - 0.00226225125567194*x_30 + 0.0127610721340324*x_31 + 0.0021017229541231*x_33 - 0.00171150546102819*x_35 - 0.000159519929384654*x_36 + 0.000456539050371352*x_37 + 0.000467915247460171*x_38 - 0.00165581228005082*x_39 + 0.000440281132697896*x_4 - 4.96968736779352e-5*x_40 + 0.000958557186458696*x_41 - 0.00199142696881248*x_42 + 0.000541527734001583*x_43 - 0.000467634212116099*x_44 - 0.000723393245144576*x_45 - 0.000582123568189807*x_46 - 0.00222494768445523*x_47 + 0.00182471355946344*x_48 - 0.000288029214327086*x_5 - 0.00086671733477547*x_51 + 0.00103173135811411*x_52 + 0.0018668318298314*x_54 - 9.53602648868071e-6*x_56 + 0.000787933432016007*x_58 + 0.000623644845864883*x_59 + 0.000874764278335053*x_6 + 0.00332074374548333*x_61 + 0.00143132199975561*x_62 + 4.23413827521125e-5*x_63 + 0.00182602574543223*x_64 - 0.00235632708374607*x_65 + 0.00132613476983968*x_66 - 0.00154013829313994*x_68 + 0.000900815326453335*x_7 - 4.57084438845253e-5*x_70 + 0.000108188914603202*x_72 + 0.000353757972067604*x_73 + 0.00125111570840482*x_74 - 0.000226318549408089*x_75 - 0.00386776478374877*x_76 - 0.00162228789770443*x_77 - 0.000226829966311926*x_78 + 0.000559282425686035*x_79 + 9.98475076169173e-5*x_8 + 0.000594453266457088*x_80 + 0.000501110382457334*x_81 + 0.00209781505530933*x_85 + 0.000108272209968951*x_86 - 1.09723924215709e-5*x_87 - 0.000808121637509687*x_88 + 0.000562824619354874*x_89 - 0.000346568808602748*x_9 + 0.000337321518732586*x_90 - 0.00200695964475641*x_91 + 2.82723901732702e-5*x_92 - 0.000265553060574253*x_93 + 0.0010162392725747*x_94 + 0.000550850898262939*x_95 + 0.00150026021427668*x_96 - 0.00146078513917613*x_97 + 0.00120867445576882*x_98 + 0.00202742983151222*x_99 - 3.57218361420734e-5*std::pow(-4.47631978988647*x_100 - 6.92568016052246, 2) - 0.000102344901891558*std::pow(-3.50639986991882*x_17 - 5.15751981735229, 2) - 4.02007008648054e-5*std::pow(-4.37183952331543*x_18 - 6.95983982086182, 2) + 8.38944847992335e-5*std::pow(-3.88375997543335*x_19 - 6.13335990905762, 2) - 8.79299695153347e-6*std::pow(-5.80399990081787*x_22 - 9.99647998809814, 2) - 9.86370842590706e-6*std::pow(-4.18495988845825*x_24 - 7.37408018112183, 2) + 0.000755635785783633*std::pow(-0.866319835186005*x_24 - 1.30367994308472, 2) + 4.94195948832073e-5*std::pow(-6.56744050979614*x_27 - 9.54936027526855, 2) + 5.32068477967823e-5*std::pow(-5.81879997253418*x_4 - 9.82336044311523, 2) + 6.87760452423067e-6*std::pow(-5.71783971786499*x_43 - 8.27400016784668, 2) - 3.14324583560491e-5*std::pow(-4.35264015197754*x_55 - 6.33048009872437, 2) + 7.60955952942857e-5*std::pow(-3.86879992485046*x_6 - 6.51087999343872, 2) + 1.68772548366586e-5*std::pow(-5.42744016647339*x_60 - 8.43583965301514, 2) - 3.94250965089101e-6*std::pow(-5.41200017929077*x_64 - 9.21903991699219, 2) + 5.63620516072546e-6*std::pow(-6.89007997512817*x_66 - 9.33463954925537, 2) + 2.89735383099653e-5*std::pow(-5.21744012832642*x_7 - 9.23895931243896, 2) - 5.75233314141908e-5*std::pow(-5.09847974777222*x_7 - 7.94231986999512, 2) + 5.76328194600885e-6*std::pow(-6.25472021102905*x_71 - 9.68151950836182, 2) + 1.27744502319141e-5*std::pow(-5.8854398727417*x_71 - 9.54551982879639, 2) + 2.14354863757754e-5*std::pow(-4.14160013198853*x_71 - 6.69736003875732, 2) + 1.60233951416744e-5*std::pow(-5.3120002746582*x_73 - 7.55503988265991, 2) - 3.41366118479597e-5*std::pow(-1.42991983890533*x_75 - 1.61055982112885, 2) - 1.48270376961475e-5*std::pow(-6.52383947372437*x_77 - 9.1627197265625, 2) + 1.3754462972876e-5*std::pow(-7.06584024429321*x_78 - 9.41096019744873, 2) + 1.56441615418277e-5*std::pow(-6.66368007659912*x_78 - 9.21712017059326, 2) + 0.000159269168875666*std::pow(-1.82767987251282*x_80 - 2.43895983695984, 2) - 7.63504259813365e-6*std::pow(-9.20399951934814*x_82 - 9.99767971038818, 2) + 6.21718216145744e-6*std::pow(-8.02295970916748*x_86 - 9.42399978637695, 2) + 4.10665418612983e-5*std::pow(-5.18376016616821*x_87 - 7.56544017791748, 2) - 1.76236323302487e-5*std::pow(-7.48543977737427*x_89 - 9.05047988891602, 2) - 1.01026253721497e-5*std::pow(-5.15536022186279*x_89 - 6.94384002685547, 2) - 3.46021698185666e-5*std::pow(-5.88768005371094*x_90 - 8.31655979156494, 2) - 0.00182399288169672*std::exp(0.82207989692688*x_25) - 5.86219077789754e-5*std::exp(0.0214236005987138*x_1 - 0.0234468645461121*x_10 - 0.0129307400959312*x_101 - 0.00451269937219277*x_102 - 0.00170053554421503*x_103 + 0.00356843479036101*x_105 + 0.00661908364454786*x_11 - 0.00222117451664038*x_111 + 0.015948914753499*x_113 - 0.0144412847816858*x_119 - 0.0218768197734733*x_12 - 0.00361960657745642*x_15 + 0.0124241307404282*x_17 + 0.0298837946386159*x_19 - 0.0478911805236579*x_2 - 0.0790566832427208*x_20 - 0.0402160690475935*x_22 - 0.00398240455164296*x_25 - 0.00982370162753433*x_29 - 0.0196725985034437*x_3 + 0.0226360838331248*x_33 + 0.00428243270655942*x_37 + 0.0309405779764871*x_41 - 0.00698762003622941*x_43 - 0.00691796688849083*x_44 + 0.0285279554739683*x_47 - 0.00395319096289561*x_48 - 0.00551316688526589*x_53 - 0.00577760718243048*x_54 - 0.00477148745376507*x_55 + 0.0242421126582389*x_6 + 0.00411551416676257*x_60 - 0.026075191870921*x_61 + 0.023924912190553*x_62 + 0.0222474488953782*x_63 + 0.00743255420809421*x_64 - 0.0187741980993659*x_68 - 0.0118830911312035*x_73 - 0.0039283233118344*x_74 + 0.022375511960495*x_76 - 0.0159136345015993*x_78 - 0.00524983709878276*x_84 - 0.00130538789353796*x_86 + 0.0528657889866634*x_9 + 0.00260494799670066*x_90 - 0.084120995675749*x_91 - 0.00258347388610748*x_92 + 0.0160783516246302*x_93 + 0.00723670994770548*x_98 + 0.0018078277037252*std::pow(-3.90320014953613*x_4 - 6.1637601852417, 2) + 0.000787375059211393*std::pow(-5.93743944168091*x_5 - 9.30079936981201, 2) + 0.00142835710648654*std::pow(-3.91991996765137*x_7 - 6.46479988098145, 2) + 0.000438434133564314*std::pow(-5.71959972381592*x_71 - 8.97583961486816, 2) - 0.000537717985828599*std::pow(-4.71984004974365*x_80 - 6.09327983856201, 2) - 0.000380072691363736*std::pow(-7.05999994277954*x_81 - 9.27960014343262, 2) - 0.000450064796964043*std::pow(-5.27831983566284*x_85 - 8.4093599319458, 2) - 0.000182352042481095*std::pow(-7.40399980545044*x_87 - 9.99079990386963, 2) - 0.000277084408163389*std::pow(-5.38815975189209*x_88 - 7.58616018295288, 2) + 0.209670493056112*std::sin(0.426559865474701*x_100 + 5.22328042984009) - 0.171103843213507*std::sin(0.431439846754074*x_104 - 7.38263988494873) - 0.281839927342434*std::sin(0.281599938869476*x_106 + 5.08271980285645) - 0.33371763151581*std::sin(0.361199855804443*x_107 + 5.15944004058838) - 0.135036859253967*std::sin(0.575359880924225*x_108 - 7.20560026168823) + 0.0731548047394477*std::sin(0.527999877929688*x_109 + 8.36816024780273) + 0.193472575332997*std::sin(0.398719817399979*x_110 + 2.0097599029541) + 0.260257515864987*std::sin(0.352079838514328*x_112 - 7.44328022003174) - 0.475784582563634*std::sin(0.311119943857193*x_114 + 5.11175966262817) + 0.0582970361430535*std::sin(0.574719846248627*x_115 - 4.20968008041382) - 0.134668096435572*std::sin(0.682319819927216*x_116 + 8.42623996734619) - 0.239438229289402*std::sin(0.461359858512878*x_117 - 7.3459997177124) - 0.203074277754878*std::sin(0.341599822044373*x_118 - 7.44719982147217) - 0.287069261490148*std::sin(0.34639984369278*x_120 + 5.15912008285522) + 2.46315383299647*std::sin(0.171840012073517*x_13 + 8.15135955810547) + 0.799676788340996*std::sin(0.212640002369881*x_14 + 5.00903987884521) - 0.246327513625252*std::sin(0.41951984167099*x_16 - 7.36879968643188) - 1.43495118635941*std::sin(0.185440003871918*x_18 - 7.60567998886108) + 0.0999781597348184*std::sin(0.398319840431213*x_21 - 7.18815994262695) + 0.344727937523231*std::sin(0.217999994754791*x_23 - 7.5860800743103) - 0.260255307842124*std::sin(0.264239966869354*x_24 + 8.05335998535156) - 0.357947646408157*std::sin(0.320399850606918*x_26 + 8.32015991210938) - 0.551370265223873*std::sin(0.279119938611984*x_27 + 5.103759765625) + 0.169949817764024*std::sin(0.417199850082397*x_28 + 8.41736030578613) + 0.177849399061105*std::sin(0.29751992225647*x_30 - 7.49848031997681) - 0.604299471285142*std::sin(0.20040000975132*x_31 - 7.39463949203491) + 0.312033765987847*std::sin(0.210400000214577*x_32 - 1.00415980815887) + 0.248848638730518*std::sin(0.369359821081161*x_34 + 1.97839987277985) + 0.390318227592889*std::sin(0.315359860658646*x_35 + 1.97319984436035) - 0.389787658099049*std::sin(0.366559833288193*x_36 + 5.16152000427246) - 0.437892794208956*std::sin(0.308319836854935*x_38 + 5.11079978942871) - 0.275842040236654*std::sin(0.301999926567078*x_39 + 5.10551977157593) + 0.395692785244336*std::sin(0.394879847764969*x_40 + 5.19040012359619) + 0.214860358795146*std::sin(0.417839854955673*x_42 - 1.1794399023056) + 0.209899667429124*std::sin(0.388719856739044*x_45 + 1.97711980342865) + 0.132675286800806*std::sin(0.44871985912323*x_46 + 5.24927997589111) + 0.00663544867623095*std::sin(1.97479975223541*x_49 - 7.4031195640564) - 0.184032886588705*std::sin(0.436799854040146*x_50 + 5.22847986221313) + 0.360281158570764*std::sin(0.276399940252304*x_51 - 4.30975961685181) + 0.0308460305236056*std::sin(0.71399986743927*x_52 - 1.22463989257813) - 0.702646005625116*std::sin(0.203759998083115*x_56 + 5.00360012054443) - 0.671769703913064*std::sin(0.229999989271164*x_57 - 4.37119960784912) - 0.432333268642239*std::sin(0.266959935426712*x_58 + 5.07175970077515) + 0.192309326788012*std::sin(0.303439915180206*x_59 + 5.13167953491211) + 0.457568071938777*std::sin(0.273279964923859*x_65 + 5.09200000762939) - 0.495940749272872*std::sin(0.221759989857674*x_66 + 5.03087949752808) + 0.352511862122732*std::sin(0.244639977812767*x_67 + 5.04016017913818) + 0.360385694653194*std::sin(0.269839972257614*x_69 + 5.09832000732422) - 0.425892925955004*std::sin(0.289679944515228*x_70 - 7.4759202003479) - 0.173057506442928*std::sin(0.34487983584404*x_72 - 1.04951989650726) - 0.594127155954787*std::sin(0.207840010523796*x_75 - 7.58039999008179) - 0.445364605576646*std::sin(0.293919950723648*x_77 + 5.11543989181519) + 0.0920426750659722*std::sin(0.320879846811295*x_79 + 5.12488031387329) - 0.483047413767416*std::sin(0.325599819421768*x_8 - 4.28672027587891) - 0.81319476431436*std::sin(0.214560002088547*x_82 + 5.02231979370117) - 0.179159676628518*std::sin(0.375839829444885*x_83 + 8.19039916992188) + 0.163408975536156*std::sin(0.357119828462601*x_89 + 5.16175985336304) + 0.21870057055904*std::sin(0.406239867210388*x_94 - 7.39663982391357) + 0.176045294880311*std::sin(0.381119847297668*x_95 + 5.19063997268677) + 0.122776697304776*std::sin(0.406319856643677*x_96 - 7.39271974563599) + 0.256169959539937*std::sin(0.396479845046997*x_97 - 7.4031195640564) + 0.116524186062462*std::sin(0.45839986205101*x_99 + 2.04295969009399)) + 0.026490797389906*std::sin(0.215440005064011*x_1 - 7.3842396736145) - 0.044277265611369*std::sin(0.301679849624634*x_10 + 5.10400009155273) - 0.0449791626524254*std::sin(0.208000004291534*x_100 + 5.00311994552612) + 0.00813475913573636*std::sin(0.414799869060516*x_100 + 5.20456027984619) - 0.0109427404214427*std::sin(0.319119840860367*x_101 + 5.146399974823) - 0.0216087853074604*std::sin(0.319359838962555*x_102 - 4.27135992050171) + 0.00717249161817127*std::sin(0.322719842195511*x_102 + 5.12976026535034) + 0.00806734320852746*std::sin(0.3503198325634*x_102 - 7.41847991943359) + 0.00611473708845466*std::sin(0.336479842662811*x_103 - 7.43991994857788) - 0.00681142244179955*std::sin(0.404639840126038*x_103 - 7.39447975158691) - 0.0107718469623557*std::sin(0.442559868097305*x_103 + 5.23320007324219) - 0.0150970354292993*std::sin(0.276479959487915*x_104 - 7.50216007232666) + 0.00809324394231452*std::sin(0.437759846448898*x_105 - 1.18407988548279) + 0.00680716435145457*std::sin(0.360079854726791*x_106 + 5.16480016708374) - 0.0135451239238269*std::sin(0.365039855241776*x_107 - 7.41479969024658) + 0.00334976822481309*std::sin(0.426959842443466*x_107 + 5.22248029708862) + 0.0169145631122132*std::sin(0.211359992623329*x_108 + 5.00783967971802) - 0.00697876977143998*std::sin(0.301119923591614*x_108 - 4.28095960617065) + 0.00519062241419601*std::sin(0.353679835796356*x_108 - 7.44871950149536) + 0.00851927325545203*std::sin(0.323999851942062*x_109 + 5.12048006057739) + 0.00494879766288988*std::sin(0.359439849853516*x_109 + 5.17456007003784) + 0.0122389921118437*std::sin(0.422879844903946*x_109 + 2.01311993598938) - 0.0228075373410635*std::sin(0.327679842710495*x_11 - 1.06183981895447) + 0.0101987968655967*std::sin(0.384719848632813*x_110 + 8.17407989501953) + 0.0229042782883884*std::sin(0.390239834785461*x_110 + 5.18304014205933) + 0.00498093835670723*std::sin(0.456639856100082*x_110 + 2.05167984962463) + 0.0135665709151301*std::sin(0.480879843235016*x_111 - 7.34032011032104) + 0.00281803161121309*std::sin(0.48431983590126*x_111 + 5.24575996398926) + 0.0192330221011754*std::sin(0.364639848470688*x_112 + 5.16183996200562) + 0.00651655423595594*std::sin(0.380959838628769*x_112 - 7.40343999862671) + 0.0239653802077356*std::sin(0.366319835186005*x_113 - 7.42911958694458) + 0.00384102412415496*std::sin(0.393599838018417*x_114 + 1.99799978733063) - 0.0123540003905132*std::sin(0.44159984588623*x_114 - 7.38136005401611) + 0.014090331000875*std::sin(0.355759829282761*x_115 - 1.24439990520477) - 0.0140213482609067*std::sin(0.36847984790802*x_115 + 8.36911964416504) - 0.03485133620181*std::sin(0.306239932775497*x_117 - 4.28335952758789) - 0.00841930296502474*std::sin(0.380719840526581*x_117 + 5.18304014205933) + 0.0124986999798162*std::sin(0.478159844875336*x_117 + 2.04239964485168) - 0.00931811186531873*std::sin(0.334479838609695*x_118 - 4.26528024673462) - 0.0113613743697449*std::sin(0.365839838981628*x_118 + 5.15880012512207) + 0.0247964511122787*std::sin(0.393759846687317*x_118 + 5.18567991256714) + 0.00854625766513878*std::sin(0.397039830684662*x_119 + 1.97919988632202) - 0.00502927888026605*std::sin(0.423359870910645*x_12 + 8.41808032989502) + 0.00450227903381935*std::sin(0.426879853010178*x_120 + 2.20191979408264) - 0.00434141169456815*std::sin(0.4859998524189*x_120 + 2.06983971595764) + 0.00739416990569734*std::sin(0.270879954099655*x_14 + 1.8879998922348) - 0.0434518787883088*std::sin(0.306239932775497*x_14 + 5.15127992630005) + 0.00831982085759297*std::sin(0.431279867887497*x_15 - 0.968239843845367) + 0.00103311779275182*std::sin(1.49863994121552*x_15 - 2.5971200466156) - 0.0641368223364104*std::sin(0.258959949016571*x_18 + 5.06335973739624) - 0.006801102480336*std::sin(0.263439953327179*x_21 - 1.12615990638733) - 0.0301179827546048*std::sin(0.30991992354393*x_21 - 4.27695989608765) + 0.0250377124009132*std::sin(0.325759828090668*x_21 - 4.2579197883606) + 0.0388400721040568*std::sin(0.271119952201843*x_23 + 5.0798397064209) + 0.00661731861216019*std::sin(0.310719907283783*x_23 - 4.24408006668091) - 0.0435205640420841*std::sin(0.325119823217392*x_26 - 4.25880002975464) + 0.00381368429958709*std::sin(0.326479852199554*x_26 + 8.31744003295898) + 0.000382268830884906*std::sin(1.74143981933594*x_27 - 1.98255980014801) + 0.00483321790355291*std::sin(0.347439825534821*x_28 + 8.35303974151611) - 0.0178164794676616*std::sin(0.361359834671021*x_28 + 8.34383964538574) + 0.00483955275314042*std::sin(0.810399830341339*x_29 + 5.61424016952515) - 0.000417057051000206*std::sin(1.04367983341217*x_29 + 6.00735950469971) - 0.032987132962769*std::sin(0.306319922208786*x_3 + 8.31271934509277) - 0.015337404113712*std::sin(0.338559836149216*x_3 + 8.35519981384277) - 0.0097652211169488*std::sin(0.330079823732376*x_30 + 8.34352016448975) + 0.0191321300095789*std::sin(0.259839981794357*x_32 + 5.17312002182007) + 0.0493558102246576*std::sin(0.271519958972931*x_32 - 7.43567991256714) + 0.0103811801185796*std::sin(0.311999946832657*x_32 - 4.44504022598267) + 0.0184471714232141*std::sin(0.279199957847595*x_33 - 1.16039991378784) + 0.0180468107078573*std::sin(0.292239934206009*x_33 + 8.22999954223633) - 0.00606054590576385*std::sin(0.277199953794479*x_34 - 1.12231993675232) + 0.0333081883818336*std::sin(0.357199847698212*x_34 - 7.39351987838745) + 0.0261348300169926*std::sin(0.386319845914841*x_34 + 1.9748797416687) + 0.0117726389213879*std::sin(0.272719949483871*x_35 - 1.1399998664856) - 0.00978056971167718*std::sin(0.316399842500687*x_35 - 7.42007970809937) - 0.0189485324377363*std::sin(0.343759834766388*x_36 - 7.44807958602905) + 0.0110828249735178*std::sin(0.363919854164124*x_36 - 4.23432016372681) + 0.0172516178733948*std::sin(0.358239859342575*x_37 + 5.17824029922485) + 0.0055555149203467*std::sin(0.450879871845245*x_37 + 2.03239989280701) + 0.0555042400107404*std::sin(0.165120020508766*x_38 - 7.63992023468018) + 0.00723126234086064*std::sin(0.249279975891113*x_38 + 5.06663990020752) - 0.0148086433857339*std::sin(0.271279960870743*x_39 + 8.28528022766113) + 0.0295032908242141*std::sin(0.306399941444397*x_40 + 5.12367963790894) + 0.0111238146847752*std::sin(0.315039843320847*x_40 - 4.28247976303101) + 0.0227575640334046*std::sin(0.330479830503464*x_41 + 5.14264011383057) + 0.0072000362895138*std::sin(0.365519851446152*x_41 - 7.41623973846436) + 0.00723702277406236*std::sin(0.348079830408096*x_42 - 1.23199987411499) - 0.0203104160000433*std::sin(0.358479857444763*x_42 + 1.97983980178833) - 0.00749214380159589*std::sin(0.356159836053848*x_43 + 5.15208005905151) - 0.0158571780341565*std::sin(0.29351994395256*x_44 - 4.27183961868286) - 0.0203961812264305*std::sin(0.220559984445572*x_45 + 8.22208023071289) + 0.00448360666047144*std::sin(0.466559857130051*x_45 + 5.24775981903076) - 0.0344114940523924*std::sin(0.195199996232986*x_46 + 4.97847986221313) - 0.00321782573254321*std::sin(0.439439862966537*x_46 - 4.14663982391357) + 0.00385529825331955*std::sin(0.624079823493958*x_47 - 7.38527965545654) - 0.00407681714172095*std::sin(0.509759843349457*x_48 + 8.27455902099609) - 0.00545077164623864*std::sin(0.589999854564667*x_48 - 7.40863990783691) - 0.0125928327367548*std::sin(0.219999998807907*x_49 - 1.36087989807129) - 0.0215334390809687*std::sin(0.326879858970642*x_49 - 4.26919984817505) + 0.00148425212165462*std::sin(0.506479859352112*x_49 + 8.28087997436523) + 0.0189796390498526*std::sin(0.304159939289093*x_50 - 7.47200012207031) - 0.018024816442121*std::sin(0.375439822673798*x_50 - 4.23304033279419) + 0.00993509905818145*std::sin(0.428159862756729*x_50 - 1.17399990558624) - 0.00849416652118863*std::sin(0.352479845285416*x_51 + 5.1418399810791) - 0.0429768729954895*std::sin(0.233919993042946*x_52 + 8.23464012145996) - 0.0975900817320773*std::sin(0.131200045347214*x_53 - 7.68440008163452) - 0.0199763154433029*std::sin(0.231279999017715*x_53 - 7.54808044433594) + 0.00414600162851571*std::sin(0.295199930667877*x_53 - 4.27360010147095) - 0.0242130829902873*std::sin(0.198559984564781*x_55 - 4.39231967926025) + 0.00931208180945736*std::sin(0.308479934930801*x_55 - 7.46504020690918) - 0.02542564103735*std::sin(0.363439828157425*x_56 + 5.15592002868652) + 0.00552436269801978*std::sin(0.319519847631454*x_57 - 7.47119998931885) + 0.0181869160459552*std::sin(0.366719841957092*x_57 + 8.35023975372314) + 0.00648410520421075*std::sin(0.41023987531662*x_57 + 5.21224021911621) - 0.0133865504040513*std::sin(0.250159978866577*x_58 - 7.52272033691406) + 0.0117850623688107*std::sin(0.389519840478897*x_58 + 1.97375977039337) + 0.00878827722344357*std::sin(0.314319908618927*x_59 + 5.13312005996704) + 0.0518684570011593*std::sin(0.228319987654686*x_60 + 5.03671979904175) - 0.0098108503026748*std::sin(0.344799846410751*x_60 - 4.26503992080688) - 0.0189000318019565*std::sin(0.324959844350815*x_62 + 8.3133602142334) - 0.0591957260514762*std::sin(0.206400007009506*x_64 - 4.40303993225098) - 0.0199594007306017*std::sin(0.196719989180565*x_65 + 5.00432014465332) + 0.0489235737726703*std::sin(0.201039999723434*x_67 + 5.00600004196167) - 0.0219344732231961*std::sin(0.202800005674362*x_67 - 7.58416032791138) - 0.0307195529778894*std::sin(0.225759983062744*x_67 + 5.03471994400024) - 0.0174946393585657*std::sin(0.225199997425079*x_69 + 5.02031993865967) + 0.044878732690165*std::sin(0.251279979944229*x_69 + 5.05583953857422) - 0.0305237525807485*std::sin(0.262479960918427*x_69 + 5.07775974273682) - 0.121971220491365*std::sin(0.13864004611969*x_70 - 7.66880035400391) + 0.0169230404884337*std::sin(0.344799846410751*x_74 - 4.25688028335571) + 0.00306193988267046*std::sin(0.365679830312729*x_74 + 1.94711983203888) + 0.000276946227560566*std::sin(0.873279869556427*x_75 + 2.20911979675293) - 0.00599662610044667*std::sin(0.31399992108345*x_77 - 7.46776008605957) - 0.0121163764936019*std::sin(0.255599975585938*x_79 + 5.07967948913574) - 0.0409732386070661*std::sin(0.255679965019226*x_79 + 5.05535984039307) - 0.0395390188104407*std::sin(0.266479969024658*x_8 + 5.09807968139648) + 0.00111629774941636*std::sin(0.474159836769104*x_80 + 8.48776054382324) - 0.0125604515768873*std::sin(0.275119960308075*x_82 - 7.49600028991699) - 0.00863474556353309*std::sin(0.326799839735031*x_82 + 5.12800025939941) - 0.00849545572796234*std::sin(0.270079970359802*x_83 + 5.10271978378296) + 0.0146025525786423*std::sin(0.410399854183197*x_83 - 7.39120006561279) - 0.00778002019549456*std::sin(0.510559856891632*x_83 + 8.3342399597168) - 0.0339512963773014*std::sin(0.234959989786148*x_84 + 5.02799987792969) - 0.0051346280138275*std::sin(0.305039942264557*x_84 + 5.14831972122192) - 0.022502315902344*std::sin(0.319039851427078*x_84 - 4.2947998046875) - 0.0128426779985593*std::sin(0.265119940042496*x_85 + 5.06559991836548) - 0.035261840995289*std::sin(0.242479979991913*x_87 + 5.03991985321045) - 0.0813890380678795*std::sin(0.148960039019585*x_88 - 7.65576028823853) - 0.135605206806513*std::sin(0.12216005474329*x_9 + 8.07327938079834) - 0.00419315827677402*std::sin(0.497999846935272*x_9 + 2.30663990974426) - 0.00535776852402445*std::sin(0.446799844503403*x_90 - 4.16096019744873) - 0.0175413598588377*std::sin(0.168240025639534*x_91 + 5.22959995269775) + 0.0803431038610766*std::sin(0.179120019078255*x_91 + 5.2279200553894) - 0.0154281796266038*std::sin(0.324799835681915*x_92 + 2.19455981254578) + 0.0469510141723872*std::sin(0.336719840764999*x_92 + 5.20352029800415) + 0.00444542103805462*std::sin(0.384559839963913*x_93 + 1.77711987495422) + 0.00831182638799571*std::sin(0.394639849662781*x_93 + 1.99383985996246) + 0.0118539225962428*std::sin(0.343359857797623*x_94 + 1.96759986877441) - 0.00495647307219376*std::sin(0.370159834623337*x_94 - 7.40679979324341) - 0.00691847453929887*std::sin(0.367199838161469*x_95 + 5.17216014862061) + 0.0171983098189961*std::sin(0.385119825601578*x_95 - 7.39695978164673) - 0.00381453420473757*std::sin(0.368079841136932*x_96 + 5.16943979263306) + 0.0229180460082424*std::sin(0.383679836988449*x_96 - 7.40807962417603) + 0.0107495839443348*std::sin(0.345919847488403*x_97 + 5.16247987747192) - 0.019774461309047*std::sin(0.352719843387604*x_98 - 4.2403998374939) - 0.00284944467322941*std::sin(0.444959849119186*x_98 + 2.03095984458923) - 0.00623950344799424*std::sin(0.310319930315018*x_99 - 7.48432016372681) + 0.42826572060585*std::sin(-0.0023483072566995*x_10 + 0.011149359992357*x_100 - 0.00509508468287599*x_101 - 0.00732454852088185*x_103 + 0.0124936785807896*x_104 - 0.0142138078950307*x_110 + 0.0114541748474917*x_111 + 0.0236035113581448*x_113 - 0.00613727985965432*x_115 + 0.000141268531804176*x_116 - 0.00359286860959394*x_117 - 0.0022284651579334*x_13 - 0.000647947565794086*x_14 - 0.0136927343155785*x_15 - 0.0259451600597199*x_16 + 0.00570882167933119*x_17 - 0.00439809089964396*x_18 - 0.0255441141696535*x_2 + 0.0409047764422388*x_20 + 0.00608327741722341*x_21 - 0.00467921534017989*x_22 + 0.0183129436004667*x_23 + 0.0169973540351699*x_25 + 0.00506405395377475*x_28 + 0.00320902940443497*x_29 + 0.0076229938052912*x_30 + 0.0396761870411411*x_31 + 0.0127909301729713*x_32 - 0.0035109508496277*x_34 + 0.0295262073829382*x_4 - 0.0191891224400045*x_40 - 0.00112159971409327*x_44 - 0.0119222130512206*x_48 - 0.00251934603983167*x_5 - 0.00178056614738998*x_52 - 0.00353117159189631*x_54 + 0.0154446480125925*x_6 - 0.00538905195607085*x_60 + 0.00222441478308118*x_61 - 0.0157013805192338*x_62 + 0.0173837511953059*x_63 - 0.00693724943919599*x_65 + 0.0179605117207643*x_68 + 0.00084809679094392*x_7 + 0.0066424589867922*x_72 + 0.00133436532678378*x_73 + 0.000679158353614299*x_78 + 0.00965222058573704*x_8 + 0.00285239668367598*x_82 + 0.00602076927019527*x_88 - 0.00416950811814848*x_89 + 0.00673146028621768*x_9 + 0.00763958776827645*x_90 + 0.0246895813575538*x_91 + 0.0384835666507044*x_92 - 0.000357102324689782*x_95 + 0.00829558232475999*x_97 - 0.000119468274306644*std::pow(-4.51200008392334*x_38 - 6.96360015869141, 2) - 0.000139500452250862*std::pow(-6.62088012695313*x_69 - 9.43920040130615, 2) - 0.000182746547533474*std::pow(-3.69936013221741*x_80 - 6.42208003997803, 2) + 0.00015940046778351*std::pow(-7.45847988128662*x_81 - 9.67831993103027, 2) + 0.00126599299832275*std::pow(-1.03719985485077*x_84 - 2.28391981124878, 2) + 8.97574626915199e-5*std::pow(-6.90776014328003*x_86 - 7.71479988098145, 2) - 0.129403868371014*std::sin(0.364479839801788*x_1 - 4.37279987335205) + 0.107469445035235*std::sin(0.320079833269119*x_102 - 4.26879978179932) - 0.160289398320401*std::sin(0.353279858827591*x_105 - 4.24919986724854) + 0.0547802266382291*std::sin(0.452639847993851*x_106 + 2.046719789505) - 0.0403427809040124*std::sin(0.382639855146408*x_107 + 5.18391990661621) - 0.160716599600619*std::sin(0.238799974322319*x_108 - 7.55640029907227) + 0.121226472305125*std::sin(0.3643998503685*x_109 + 5.17935991287231) - 0.0746936466825332*std::sin(0.300399929285049*x_11 + 8.32439994812012) + 0.0120750804256886*std::sin(0.475119858980179*x_112 + 1.8407998085022) + 0.154214799076158*std::sin(0.373439848423004*x_114 - 7.42952013015747) - 0.0908382481910053*std::sin(0.372159838676453*x_118 + 1.98983991146088) + 0.223437425347583*std::sin(0.339599847793579*x_119 + 5.15136003494263) - 0.170908155487837*std::sin(0.359199851751328*x_12 + 5.17248010635376) + 0.148229129789001*std::sin(0.371839851140976*x_120 - 7.41567993164063) + 0.0152657004381496*std::sin(0.599039852619171*x_19 - 0.798399865627289) - 0.102347236531841*std::sin(0.376079827547073*x_24 + 8.37248039245605) - 0.20639985644948*std::sin(0.338239848613739*x_26 - 4.26504039764404) + 0.74905779023311*std::sin(0.213039994239807*x_27 - 7.5717601776123) + 0.173355094486283*std::sin(0.349679857492447*x_3 - 4.23496007919312) - 0.144320043551716*std::sin(0.218399986624718*x_33 - 7.38711977005005) - 0.148288494548865*std::sin(0.316319853067398*x_35 - 1.20743989944458) + 0.131189381292529*std::sin(0.367839843034744*x_36 + 5.17136001586914) + 0.106132284872729*std::sin(0.403439849615097*x_37 - 4.20223999023438) - 0.111072262546941*std::sin(0.30295991897583*x_39 - 4.30272006988525) + 0.102570106324151*std::sin(0.357199847698212*x_41 - 7.43991994857788) - 0.187056858391088*std::sin(0.303599923849106*x_42 + 5.09543991088867) + 0.12233075527206*std::sin(0.377679854631424*x_43 + 5.18800020217896) - 0.160720736150211*std::sin(0.296639919281006*x_45 + 5.11967945098877) + 0.255690137669262*std::sin(0.290079951286316*x_46 + 5.11967992782593) + 0.137496318691888*std::sin(0.376559853553772*x_47 + 5.1625599861145) + 0.158201964151772*std::sin(0.352319836616516*x_49 - 4.23863983154297) + 0.0688517371415287*std::sin(0.350559860467911*x_50 + 5.15431976318359) + 0.0592902609568569*std::sin(0.321599841117859*x_51 - 7.47175979614258) - 0.0341578599993397*std::sin(0.334159851074219*x_53 - 1.068079829216) + 0.136602882571424*std::sin(0.317279845476151*x_55 - 4.28736019134521) + 0.0482149277338806*std::sin(0.342239856719971*x_56 + 5.13784027099609) - 0.122756421458803*std::sin(0.373519837856293*x_57 - 4.21056032180786) - 0.0499591366803998*std::sin(0.463439851999283*x_58 - 1.13231992721558) - 0.0490958165158872*std::sin(0.307839930057526*x_59 - 7.46871995925903) + 0.211090703686523*std::sin(0.238079980015755*x_64 - 4.35223960876465) - 0.2202479229652*std::sin(0.199680000543594*x_66 + 4.99975967407227) + 0.0127678250461116*std::sin(0.343759834766388*x_67 - 4.43192005157471) + 0.0477365263989782*std::sin(0.345999836921692*x_70 - 1.06407976150513) + 0.0771044230972961*std::sin(0.298959940671921*x_71 + 5.11895942687988) - 0.151341572822616*std::sin(0.33111983537674*x_74 - 4.27975988388062) + 0.093886926254072*std::sin(0.241279974579811*x_75 - 7.54800033569336) - 0.0706882714140988*std::sin(0.358159840106964*x_76 - 4.25072002410889) + 0.709798067578049*std::sin(0.144800037145615*x_77 - 7.65912008285522) - 0.168676352222974*std::sin(0.257119983434677*x_79 + 5.05615997314453) - 0.115328525993164*std::sin(0.276319950819016*x_83 + 5.11303997039795) + 0.0253389794238501*std::sin(0.50791984796524*x_85 - 0.885199844837189) + 0.215360443144164*std::sin(0.195919990539551*x_87 + 1.79983985424042) - 0.0935842198828141*std::sin(0.285359919071198*x_93 + 8.27120018005371) - 0.194955008063857*std::sin(0.390079855918884*x_94 - 7.40775966644287) - 0.0666027255959989*std::sin(0.409599870443344*x_96 - 7.38104009628296) + 0.157977559265987*std::sin(0.407839864492416*x_98 + 2.00023984909058) - 0.0682961973595297*std::sin(0.42783984541893*x_99 - 1.18479979038239) + 0.197813966435749) + 0.673364023222655);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00043456919527962*x_1 - 0.000596987675738412*x_10 + 0.000168456513302161*x_101 - 0.000233481144758341*x_104 + 5.81587429185238e-5*x_105 + 0.000159902064706176*x_106 + 0.000165672954198337*x_107 - 0.000165304218955394*x_11 + 0.000446717044755048*x_111 + 4.2869634928132e-5*x_112 + 7.28476368315947e-6*x_113 + 6.50196116805645e-5*x_114 + 1.14640074137065e-5*x_115 + 7.16308719265101e-5*x_116 - 0.000224315697981587*x_119 + 0.000792312883210038*x_12 + 8.50567365370556e-6*x_120 + 0.00113621201778611*x_13 - 0.000525037006679747*x_14 - 2.25574505383194e-5*x_15 + 2.52387541637421e-5*x_16 - 0.000205737441010607*x_17 - 6.02308998452266e-5*x_18 + 0.000549749815405107*x_19 - 0.000528396423210436*x_2 + 0.00219573582303115*x_20 + 0.000387255099415727*x_22 + 1.42684704647256e-5*x_23 + 2.57498352160214e-5*x_24 + 0.000190226678116747*x_25 - 2.49733293350752e-5*x_26 + 4.5812765773338e-5*x_27 - 5.97849554583145e-6*x_28 + 0.000148528021286262*x_29 + 0.00014113185115255*x_3 - 9.80418982380046e-5*x_30 + 0.00386083088413223*x_31 + 0.000249265525300477*x_33 - 7.99589038991508e-5*x_35 - 1.89191534098038e-5*x_36 + 5.41457883341607e-5*x_37 + 5.54950117119152e-5*x_38 - 0.000202884326808888*x_39 + 0.000298856448436158*x_4 - 2.32176153508447e-6*x_40 + 0.000113685421831854*x_41 - 9.30364063961534e-5*x_42 + 2.52993431968046e-5*x_43 - 0.000213727978610913*x_44 - 8.57948460314616e-5*x_45 - 6.90401828318814e-5*x_46 - 0.000639213737351464*x_47 + 8.52478122137944e-5*x_48 + 3.07362705863652e-5*x_5 - 6.27313695161922e-5*x_51 + 1.49508506569377e-5*x_52 - 3.40668812477954e-5*x_54 - 8.04643594963816e-5*x_56 + 0.000680112589368535*x_58 + 7.99341504370468e-5*x_59 - 5.30444316941147e-5*x_6 + 0.000735341127885921*x_61 + 0.000824776744126296*x_62 + 0.000109066349734933*x_63 + 8.53091155249235e-5*x_64 - 0.000245846044731524*x_65 + 0.000114116782591707*x_66 - 0.00015808280571612*x_68 + 0.000777547720813798*x_7 - 6.30299731624551e-5*x_70 + 0.000304606508517111*x_72 - 8.62374206903255e-6*x_73 + 5.84502024521505e-5*x_74 - 2.68415073417642e-5*x_75 - 0.00075105343292245*x_76 - 0.000192404257762233*x_77 - 0.000195790544564236*x_78 + 2.6128815096534e-5*x_79 - 5.18240500478095e-5*x_8 + 7.05024919860737e-5*x_80 + 0.000108233270088986*x_81 + 0.000262865188717052*x_85 - 0.000137365214846252*x_86 - 9.47092979962641e-6*x_87 - 0.000132517509300636*x_88 + 6.6751316637767e-5*x_89 - 4.11032557643489e-5*x_9 + 0.000291162428490894*x_90 - 9.37620691365757e-5*x_91 + 2.44035951605487e-5*x_92 - 1.24062307331617e-5*x_93 + 0.00012052654971121*x_94 + 2.57349070978172e-5*x_95 + 7.00898507358563e-5*x_96 - 4.84398761246598e-5*x_97 + 5.64674123774739e-5*x_98 + 0.000225104120145417*x_99 - 1.66886926639974e-6*std::pow(-4.47631978988647*x_100 - 6.92568016052246, 2) - 1.21381629685198e-5*std::pow(-3.50639986991882*x_17 - 5.15751981735229, 2) - 3.46996353354852e-5*std::pow(-4.37183952331543*x_18 - 6.95983982086182, 2) + 3.91942135183184e-6*std::pow(-3.88375997543335*x_19 - 6.13335990905762, 2) - 7.58976289369528e-6*std::pow(-5.80399990081787*x_22 - 9.99647998809814, 2) - 8.51395816668889e-6*std::pow(-4.18495988845825*x_24 - 7.37408018112183, 2) + 8.96188294987639e-5*std::pow(-0.866319835186005*x_24 - 1.30367994308472, 2) + 5.86119176865495e-6*std::pow(-6.56744050979614*x_27 - 9.54936027526855, 2) + 2.48574212974106e-6*std::pow(-5.81879997253418*x_4 - 9.82336044311523, 2) + 8.15687767589985e-7*std::pow(-5.71783971786499*x_43 - 8.27400016784668, 2) - 1.46847613065489e-6*std::pow(-4.35264015197754*x_55 - 6.33048009872437, 2) + 3.55506922404395e-6*std::pow(-3.86879992485046*x_6 - 6.51087999343872, 2) + 2.0016519228839e-6*std::pow(-5.42744016647339*x_60 - 8.43583965301514, 2) - 3.40301647109632e-6*std::pow(-5.41200017929077*x_64 - 9.21903991699219, 2) + 4.86494661898725e-6*std::pow(-6.89007997512817*x_66 - 9.33463954925537, 2) + 1.35359916640472e-6*std::pow(-5.21744012832642*x_7 - 9.23895931243896, 2) - 6.82229948236647e-6*std::pow(-5.09847974777222*x_7 - 7.94231986999512, 2) + 4.97463421184213e-6*std::pow(-6.25472021102905*x_71 - 9.68151950836182, 2) + 1.51505698752357e-6*std::pow(-5.8854398727417*x_71 - 9.54551982879639, 2) + 1.00143296891528e-6*std::pow(-4.14160013198853*x_71 - 6.69736003875732, 2) + 1.38307531035921e-5*std::pow(-5.3120002746582*x_73 - 7.55503988265991, 2) - 2.94653565045237e-5*std::pow(-1.42991983890533*x_75 - 1.61055982112885, 2) - 6.92696406322374e-7*std::pow(-6.52383947372437*x_77 - 9.1627197265625, 2) + 1.63128705019562e-6*std::pow(-7.06584024429321*x_78 - 9.41096019744873, 2) + 7.30871176159918e-7*std::pow(-6.66368007659912*x_78 - 9.21712017059326, 2) + 7.44081071209461e-6*std::pow(-1.82767987251282*x_80 - 2.43895983695984, 2) - 9.0552034947411e-7*std::pow(-9.20399951934814*x_82 - 9.99767971038818, 2) + 2.90457192390637e-7*std::pow(-8.02295970916748*x_86 - 9.42399978637695, 2) + 1.91856570074007e-6*std::pow(-5.18376016616821*x_87 - 7.56544017791748, 2) - 8.23349008189414e-7*std::pow(-7.48543977737427*x_89 - 9.05047988891602, 2) - 8.72018170836218e-6*std::pow(-5.15536022186279*x_89 - 6.94384002685547, 2) - 4.10383681609453e-6*std::pow(-5.88768005371094*x_90 - 8.31655979156494, 2) - 0.000216326582392094*std::exp(0.82207989692688*x_25) - 0.000213821203091877*std::exp(0.0185121943146699*x_1 - 0.0202605024560359*x_10 - 0.0111734893574679*x_101 - 0.00389943638450472*x_102 - 0.0014694376086997*x_103 + 0.00308349466906872*x_105 + 0.00571956903548137*x_11 - 0.00191932322810893*x_111 + 0.0137815026780609*x_113 - 0.0124787553240749*x_119 - 0.0189038222948324*x_12 - 0.00312771235608983*x_15 + 0.0107357267700126*x_17 + 0.0258226720882278*x_19 - 0.0413829055357818*x_2 - 0.068313105227999*x_20 - 0.0347508198423905*x_22 - 0.00344120711922097*x_25 - 0.00848868856475848*x_29 - 0.0169991484154208*x_3 + 0.0195599045319731*x_33 + 0.00370046230268526*x_37 + 0.0267358415813313*x_41 - 0.00603802238151909*x_43 - 0.00597783489811154*x_44 + 0.0246510876031762*x_47 - 0.00341596357395284*x_48 - 0.00476394321295241*x_53 - 0.00499244682714104*x_54 - 0.0041230559030965*x_55 + 0.0209476786154415*x_6 + 0.00355622751688433*x_60 - 0.0225316475856898*x_61 + 0.0206735847875881*x_62 + 0.0192240839750185*x_63 + 0.00642249126707573*x_64 - 0.0162228380666523*x_68 - 0.0102682129022223*x_73 - 0.00339447536582119*x_74 + 0.0193347436344464*x_76 - 0.0137510169118784*x_78 - 0.00453639919420754*x_84 - 0.00112798939794663*x_86 + 0.0456814788816688*x_9 + 0.00225094298562623*x_90 - 0.0726891920299554*x_91 - 0.00223238714548144*x_92 + 0.0138933494471799*x_93 + 0.00625326168369997*x_98 + 0.00156214906941524*std::pow(-3.90320014953613*x_4 - 6.1637601852417, 2) + 0.000680373031950621*std::pow(-5.93743944168091*x_5 - 9.30079936981201, 2) + 0.00123424744520331*std::pow(-3.91991996765137*x_7 - 6.46479988098145, 2) + 0.000378852183942124*std::pow(-5.71959972381592*x_71 - 8.97583961486816, 2) - 0.000464643643550262*std::pow(-4.71984004974365*x_80 - 6.09327983856201, 2) - 0.000328421895460815*std::pow(-7.05999994277954*x_81 - 9.27960014343262, 2) - 0.000388902273322396*std::pow(-5.27831983566284*x_85 - 8.4093599319458, 2) - 0.000157570919441508*std::pow(-7.40399980545044*x_87 - 9.99079990386963, 2) - 0.000239429426526647*std::pow(-5.38815975189209*x_88 - 7.58616018295288, 2) + 0.181176870415538*std::sin(0.426559865474701*x_100 + 5.22328042984009) - 0.147851318407487*std::sin(0.431439846754074*x_104 - 7.38263988494873) - 0.243538684198063*std::sin(0.281599938869476*x_106 + 5.08271980285645) - 0.288366356177448*std::sin(0.361199855804443*x_107 + 5.15944004058838) - 0.116685734810714*std::sin(0.575359880924225*x_108 - 7.20560026168823) + 0.0632132751984602*std::sin(0.527999877929688*x_109 + 8.36816024780273) + 0.167180203562005*std::sin(0.398719817399979*x_110 + 2.0097599029541) + 0.224889260950617*std::sin(0.352079838514328*x_112 - 7.44328022003174) - 0.411126813336452*std::sin(0.311119943857193*x_114 + 5.11175966262817) + 0.0503746350235046*std::sin(0.574719846248627*x_115 - 4.20968008041382) - 0.116367085808708*std::sin(0.682319819927216*x_116 + 8.42623996734619) - 0.206899256105064*std::sin(0.461359858512878*x_117 - 7.3459997177124) - 0.175477061980667*std::sin(0.341599822044373*x_118 - 7.44719982147217) - 0.248057366733837*std::sin(0.34639984369278*x_120 + 5.15912008285522) + 2.12841824478805*std::sin(0.171840012073517*x_13 + 8.15135955810547) + 0.691002991139989*std::sin(0.212640002369881*x_14 + 5.00903987884521) - 0.21285230632772*std::sin(0.41951984167099*x_16 - 7.36879968643188) - 1.23994540840845*std::sin(0.185440003871918*x_18 - 7.60567998886108) + 0.0863914126715555*std::sin(0.398319840431213*x_21 - 7.18815994262695) + 0.297880392967585*std::sin(0.217999994754791*x_23 - 7.5860800743103) - 0.22488735299177*std::sin(0.264239966869354*x_24 + 8.05335998535156) - 0.309303581078915*std::sin(0.320399850606918*x_26 + 8.32015991210938) - 0.476440617072008*std::sin(0.279119938611984*x_27 + 5.103759765625) + 0.146854121728691*std::sin(0.417199850082397*x_28 + 8.41736030578613) + 0.153680172433952*std::sin(0.29751992225647*x_30 - 7.49848031997681) - 0.522176894828522*std::sin(0.20040000975132*x_31 - 7.39463949203491) + 0.269629266195901*std::sin(0.210400000214577*x_32 - 1.00415980815887) + 0.215030817714041*std::sin(0.369359821081161*x_34 + 1.97839987277985) + 0.337275092506669*std::sin(0.315359860658646*x_35 + 1.97319984436035) - 0.336816625895413*std::sin(0.366559833288193*x_36 + 5.16152000427246) - 0.378384411062846*std::sin(0.308319836854935*x_38 + 5.11079978942871) - 0.238355892861563*std::sin(0.301999926567078*x_39 + 5.10551977157593) + 0.341919263085771*std::sin(0.394879847764969*x_40 + 5.19040012359619) + 0.185661448186924*std::sin(0.417839854955673*x_42 - 1.1794399023056) + 0.18137490064419*std::sin(0.388719856739044*x_45 + 1.97711980342865) + 0.114645093325654*std::sin(0.44871985912323*x_46 + 5.24927997589111) + 0.00573371010598384*std::sin(1.97479975223541*x_49 - 7.4031195640564) - 0.159023341623735*std::sin(0.436799854040146*x_50 + 5.22847986221313) + 0.311319975586962*std::sin(0.276399940252304*x_51 - 4.30975961685181) + 0.0266541428579241*std::sin(0.71399986743927*x_52 - 1.22463989257813) - 0.607158415347779*std::sin(0.203759998083115*x_56 + 5.00360012054443) - 0.580478115069674*std::sin(0.229999989271164*x_57 - 4.37119960784912) - 0.373580409181173*std::sin(0.266959935426712*x_58 + 5.07175970077515) + 0.166175037180108*std::sin(0.303439915180206*x_59 + 5.13167953491211) + 0.395385874605413*std::sin(0.273279964923859*x_65 + 5.09200000762939) - 0.428543814416219*std::sin(0.221759989857674*x_66 + 5.03087949752808) + 0.304606504390954*std::sin(0.244639977812767*x_67 + 5.04016017913818) + 0.31141030551362*std::sin(0.269839972257614*x_69 + 5.09832000732422) - 0.368015290716151*std::sin(0.289679944515228*x_70 - 7.4759202003479) - 0.149539484370151*std::sin(0.34487983584404*x_72 - 1.04951989650726) - 0.513386968169932*std::sin(0.207840010523796*x_75 - 7.58039999008179) - 0.384840824553375*std::sin(0.293919950723648*x_77 + 5.11543989181519) + 0.0795343377604603*std::sin(0.320879846811295*x_79 + 5.12488031387329) - 0.417402646471949*std::sin(0.325599819421768*x_8 - 4.28672027587891) - 0.702683912692223*std::sin(0.214560002088547*x_82 + 5.02231979370117) - 0.154812387013025*std::sin(0.375839829444885*x_83 + 8.19039916992188) + 0.141202161324277*std::sin(0.357119828462601*x_89 + 5.16175985336304) + 0.188979786113133*std::sin(0.406239867210388*x_94 - 7.39663982391357) + 0.15212124087131*std::sin(0.381119847297668*x_95 + 5.19063997268677) + 0.106091693940368*std::sin(0.406319856643677*x_96 - 7.39271974563599) + 0.22135719188441*std::sin(0.396479845046997*x_97 - 7.4031195640564) + 0.100688881162047*std::sin(0.45839986205101*x_99 + 2.04295969009399)) + 0.0228657956055864*std::sin(0.215440005064011*x_1 - 7.3842396736145) - 0.00525130862268739*std::sin(0.301679849624634*x_10 + 5.10400009155273) - 0.005334554006815*std::sin(0.208000004291534*x_100 + 5.00311994552612) + 0.00702159836718619*std::sin(0.414799869060516*x_100 + 5.20456027984619) - 0.00944533538039286*std::sin(0.319119840860367*x_101 + 5.146399974823) - 0.00256281409983301*std::sin(0.319359838962555*x_102 - 4.27135992050171) + 0.000335087781531406*std::sin(0.322719842195511*x_102 + 5.12976026535034) + 0.00696340763817827*std::sin(0.3503198325634*x_102 - 7.41847991943359) + 0.000725211260331836*std::sin(0.336479842662811*x_103 - 7.43991994857788) - 0.00587934711987336*std::sin(0.404639840126038*x_103 - 7.39447975158691) - 0.000503244129622543*std::sin(0.442559868097305*x_103 + 5.23320007324219) - 0.000705310285325191*std::sin(0.276479959487915*x_104 - 7.50216007232666) + 0.000959863286789691*std::sin(0.437759846448898*x_105 - 1.18407988548279) + 0.000318020253278477*std::sin(0.360079854726791*x_106 + 5.16480016708374) - 0.000632807365672511*std::sin(0.365039855241776*x_107 - 7.41479969024658) + 0.00289138580569303*std::sin(0.426959842443466*x_107 + 5.22248029708862) + 0.000790222384434041*std::sin(0.211359992623329*x_108 + 5.00783967971802) - 0.000827686022849228*std::sin(0.301119923591614*x_108 - 4.28095960617065) + 0.00448033743348193*std::sin(0.353679835796356*x_108 - 7.44871950149536) + 0.00735349555923638*std::sin(0.323999851942062*x_109 + 5.12048006057739) + 0.000231200218610834*std::sin(0.359439849853516*x_109 + 5.17456007003784) + 0.001451551353104*std::sin(0.422879844903946*x_109 + 2.01311993598938) - 0.00270498676572833*std::sin(0.327679842710495*x_11 - 1.06183981895447) + 0.0012095830485881*std::sin(0.384719848632813*x_110 + 8.17407989501953) + 0.00107005266897626*std::sin(0.390239834785461*x_110 + 5.18304014205933) + 0.00429934655088526*std::sin(0.456639856100082*x_110 + 2.05167984962463) + 0.000633809336133948*std::sin(0.480879843235016*x_111 - 7.34032011032104) + 0.00243241205176529*std::sin(0.48431983590126*x_111 + 5.24575996398926) + 0.0022810472463843*std::sin(0.364639848470688*x_112 + 5.16183996200562) + 0.00562482869122179*std::sin(0.380959838628769*x_112 - 7.40343999862671) + 0.00111962571932768*std::sin(0.366319835186005*x_113 - 7.42911958694458) + 0.003315418227936*std::sin(0.393599838018417*x_114 + 1.99799978733063) - 0.000577159905409641*std::sin(0.44159984588623*x_114 - 7.38136005401611) + 0.00167112118735751*std::sin(0.355759829282761*x_115 - 1.24439990520477) - 0.000655055834561488*std::sin(0.36847984790802*x_115 + 8.36911964416504) - 0.00162820084748279*std::sin(0.306239932775497*x_117 - 4.28335952758789) - 0.00726720520738716*std::sin(0.380719840526581*x_117 + 5.18304014205933) + 0.00148235285242047*std::sin(0.478159844875336*x_117 + 2.04239964485168) - 0.000435327860837183*std::sin(0.334479838609695*x_118 - 4.26528024673462) - 0.00980668344230826*std::sin(0.365839838981628*x_118 + 5.15880012512207) + 0.00294087305844201*std::sin(0.393759846687317*x_118 + 5.18567991256714) + 0.00737678742121219*std::sin(0.397039830684662*x_119 + 1.97919988632202) - 0.0043410721552487*std::sin(0.423359870910645*x_12 + 8.41808032989502) + 0.000533972827490267*std::sin(0.426879853010178*x_120 + 2.20191979408264) - 0.00374733274301223*std::sin(0.4859998524189*x_120 + 2.06983971595764) + 0.000876952712577491*std::sin(0.270879954099655*x_14 + 1.8879998922348) - 0.0020300049747926*std::sin(0.306239932775497*x_14 + 5.15127992630005) + 0.00718133623555264*std::sin(0.431279867887497*x_15 - 0.968239843845367) + 4.82656749792196e-5*std::sin(1.49863994121552*x_15 - 2.5971200466156) - 0.00760666322810326*std::sin(0.258959949016571*x_18 + 5.06335973739624) - 0.00587043934235312*std::sin(0.263439953327179*x_21 - 1.12615990638733) - 0.00140706585140838*std::sin(0.30991992354393*x_21 - 4.27695989608765) + 0.00296948678306645*std::sin(0.325759828090668*x_21 - 4.2579197883606) + 0.00460645441243018*std::sin(0.271119952201843*x_23 + 5.0798397064209) + 0.0057118044661182*std::sin(0.310719907283783*x_23 - 4.24408006668091) - 0.00203321384425342*std::sin(0.325119823217392*x_26 - 4.25880002975464) + 0.00329181958606576*std::sin(0.326479852199554*x_26 + 8.31744003295898) + 1.78590120851875e-5*std::sin(1.74143981933594*x_27 - 1.98255980014801) + 0.00417184017050434*std::sin(0.347439825534821*x_28 + 8.35303974151611) - 0.00211304449275751*std::sin(0.361359834671021*x_28 + 8.34383964538574) + 0.000573973680434126*std::sin(0.810399830341339*x_29 + 5.61424016952515) - 0.000359986947303936*std::sin(1.04367983341217*x_29 + 6.00735950469971) - 0.00391229253598365*std::sin(0.306319922208786*x_3 + 8.31271934509277) - 0.0132386331155909*std::sin(0.338559836149216*x_3 + 8.35519981384277) - 0.0011581607207631*std::sin(0.330079823732376*x_30 + 8.34352016448975) + 0.0165140885666669*std::sin(0.259839981794357*x_32 + 5.17312002182007) + 0.00585362687225016*std::sin(0.271519958972931*x_32 - 7.43567991256714) + 0.000484992775286043*std::sin(0.311999946832657*x_32 - 4.44504022598267) + 0.0159228597409134*std::sin(0.279199957847595*x_33 - 1.16039991378784) + 0.000843119251403873*std::sin(0.292239934206009*x_33 + 8.22999954223633) - 0.00523122055934313*std::sin(0.277199953794479*x_34 - 1.12231993675232) + 0.00395036988938873*std::sin(0.357199847698212*x_34 - 7.39351987838745) + 0.00122097907914005*std::sin(0.386319845914841*x_34 + 1.9748797416687) + 0.00139624160223199*std::sin(0.272719949483871*x_35 - 1.1399998664856) - 0.0084421961574707*std::sin(0.316399842500687*x_35 - 7.42007970809937) - 0.0008852463043318*std::sin(0.343759834766388*x_36 - 7.44807958602905) + 0.00956625075670651*std::sin(0.363919854164124*x_36 - 4.23432016372681) + 0.000805969064694048*std::sin(0.358239859342575*x_37 + 5.17824029922485) + 0.00479529803435954*std::sin(0.450879871845245*x_37 + 2.03239989280701) + 0.00259307276200453*std::sin(0.165120020508766*x_38 - 7.63992023468018) + 0.00624173611019718*std::sin(0.249279975891113*x_38 + 5.06663990020752) - 0.00069183705241896*std::sin(0.271279960870743*x_39 + 8.28528022766113) + 0.00349910689749251*std::sin(0.306399941444397*x_40 + 5.12367963790894) + 0.00960163143422056*std::sin(0.315039843320847*x_40 - 4.28247976303101) + 0.00106319840453948*std::sin(0.330479830503464*x_41 + 5.14264011383057) + 0.0062147830329773*std::sin(0.365519851446152*x_41 - 7.41623973846436) + 0.00624670828548702*std::sin(0.348079830408096*x_42 - 1.23199987411499) - 0.00240882676919438*std::sin(0.358479857444763*x_42 + 1.97983980178833) - 0.00646691854131313*std::sin(0.356159836053848*x_43 + 5.15208005905151) - 0.000740822979193496*std::sin(0.29351994395256*x_44 - 4.27183961868286) - 0.000952878230148374*std::sin(0.220559984445572*x_45 + 8.22208023071289) + 0.00387006974404063*std::sin(0.466559857130051*x_45 + 5.24775981903076) - 0.00160765209846802*std::sin(0.195199996232986*x_46 + 4.97847986221313) - 0.00277749832939213*std::sin(0.439439862966537*x_46 - 4.14663982391357) + 0.00018011360732355*std::sin(0.624079823493958*x_47 - 7.38527965545654) - 0.00351894531945884*std::sin(0.509759843349457*x_48 + 8.27455902099609) - 0.000646464585176265*std::sin(0.589999854564667*x_48 - 7.40863990783691) - 0.00149351705037542*std::sin(0.219999998807907*x_49 - 1.36087989807129) - 0.00100600916871105*std::sin(0.326879858970642*x_49 - 4.26919984817505) + 0.00128114700140526*std::sin(0.506479859352112*x_49 + 8.28087997436523) + 0.016382464476026*std::sin(0.304159939289093*x_50 - 7.47200012207031) - 0.000842091713122295*std::sin(0.375439822673798*x_50 - 4.23304033279419) + 0.00117830834020802*std::sin(0.428159862756729*x_50 - 1.17399990558624) - 0.00733182443150319*std::sin(0.352479845285416*x_51 + 5.1418399810791) - 0.00509708132652633*std::sin(0.233919993042946*x_52 + 8.23464012145996) - 0.00455925858515091*std::sin(0.131200045347214*x_53 - 7.68440008163452) - 0.00236920225511858*std::sin(0.231279999017715*x_53 - 7.54808044433594) + 0.00357866259828749*std::sin(0.295199930667877*x_53 - 4.27360010147095) - 0.00287168527082876*std::sin(0.198559984564781*x_55 - 4.39231967926025) + 0.00803781615870441*std::sin(0.308479934930801*x_55 - 7.46504020690918) - 0.00301549533769104*std::sin(0.363439828157425*x_56 + 5.15592002868652) + 0.000655192525337767*std::sin(0.319519847631454*x_57 - 7.47119998931885) + 0.000849664757404184*std::sin(0.366719841957092*x_57 + 8.35023975372314) + 0.00559681998629064*std::sin(0.41023987531662*x_57 + 5.21224021911621) - 0.00158765241245575*std::sin(0.250159978866577*x_58 - 7.52272033691406) + 0.000550579995711574*std::sin(0.389519840478897*x_58 + 1.97375977039337) + 0.00758568901338775*std::sin(0.314319908618927*x_59 + 5.13312005996704) + 0.00242321456938934*std::sin(0.228319987654686*x_60 + 5.03671979904175) - 0.00846833315117372*std::sin(0.344799846410751*x_60 - 4.26503992080688) - 0.00224155440947546*std::sin(0.324959844350815*x_62 + 8.3133602142334) - 0.00702064642764526*std::sin(0.206400007009506*x_64 - 4.40303993225098) - 0.000932472516882336*std::sin(0.196719989180565*x_65 + 5.00432014465332) + 0.00580236338576291*std::sin(0.201039999723434*x_67 + 5.00600004196167) - 0.0189329590217967*std::sin(0.202800005674362*x_67 - 7.58416032791138) - 0.00143517028739616*std::sin(0.225759983062744*x_67 + 5.03471994400024) - 0.015100672202447*std::sin(0.225199997425079*x_69 + 5.02031993865967) + 0.00209666539546582*std::sin(0.251279979944229*x_69 + 5.05583953857422) - 0.00362013423617794*std::sin(0.262479960918427*x_69 + 5.07775974273682) - 0.0144658554010063*std::sin(0.13864004611969*x_70 - 7.66880035400391) + 0.00200708212695459*std::sin(0.344799846410751*x_74 - 4.25688028335571) + 0.00264294390550938*std::sin(0.365679830312729*x_74 + 1.94711983203888) + 1.29385019790965e-5*std::sin(0.873279869556427*x_75 + 2.20911979675293) - 0.00517604754276612*std::sin(0.31399992108345*x_77 - 7.46776008605957) - 0.0104583710450558*std::sin(0.255599975585938*x_79 + 5.07967948913574) - 0.00485944916032636*std::sin(0.255679965019226*x_79 + 5.05535984039307) - 0.00468934988520505*std::sin(0.266479969024658*x_8 + 5.09807968139648) + 0.00096354352031912*std::sin(0.474159836769104*x_80 + 8.48776054382324) - 0.000586804987442415*std::sin(0.275119960308075*x_82 - 7.49600028991699) - 0.00745316663201779*std::sin(0.326799839735031*x_82 + 5.12800025939941) - 0.00733293722316994*std::sin(0.270079970359802*x_83 + 5.10271978378296) + 0.00173187095478139*std::sin(0.410399854183197*x_83 - 7.39120006561279) - 0.000363470582659599*std::sin(0.510559856891632*x_83 + 8.3342399597168) - 0.00158615237058803*std::sin(0.234959989786148*x_84 + 5.02799987792969) - 0.00443200530912045*std::sin(0.305039942264557*x_84 + 5.14831972122192) - 0.00266878733130425*std::sin(0.319039851427078*x_84 - 4.2947998046875) - 0.0110852854227526*std::sin(0.265119940042496*x_85 + 5.06559991836548) - 0.00418207418894556*std::sin(0.242479979991913*x_87 + 5.03991985321045) - 0.0038023707323752*std::sin(0.148960039019585*x_88 - 7.65576028823853) - 0.0063352667848063*std::sin(0.12216005474329*x_9 + 8.07327938079834) - 0.00361936632889433*std::sin(0.497999846935272*x_9 + 2.30663990974426) - 0.000250306708498028*std::sin(0.446799844503403*x_90 - 4.16096019744873) - 0.0151409994675756*std::sin(0.168240025639534*x_91 + 5.22959995269775) + 0.00952873733853178*std::sin(0.179120019078255*x_91 + 5.2279200553894) - 0.000720780833127669*std::sin(0.324799835681915*x_92 + 2.19455981254578) + 0.00556841670692663*std::sin(0.336719840764999*x_92 + 5.20352029800415) + 0.000527229437190406*std::sin(0.384559839963913*x_93 + 1.77711987495422) + 0.00717443572949782*std::sin(0.394639849662781*x_93 + 1.99383985996246) + 0.000553797039672632*std::sin(0.343359857797623*x_94 + 1.96759986877441) - 0.00427822909689233*std::sin(0.370159834623337*x_94 - 7.40679979324341) - 0.00597175020402897*std::sin(0.367199838161469*x_95 + 5.17216014862061) + 0.00203972922449289*std::sin(0.385119825601578*x_95 - 7.39695978164673) - 0.00329255319016113*std::sin(0.368079841136932*x_96 + 5.16943979263306) + 0.00271809315585485*std::sin(0.383679836988449*x_96 - 7.40807962417603) + 0.00927861044341043*std::sin(0.345919847488403*x_97 + 5.16247987747192) - 0.00234526224118352*std::sin(0.352719843387604*x_98 - 4.2403998374939) - 0.00245952654910709*std::sin(0.444959849119186*x_98 + 2.03095984458923) - 0.00538568954426985*std::sin(0.310319930315018*x_99 - 7.48432016372681) + 0.246168568730354*std::sin(-0.00324845207302564*x_10 + 0.0154230931564658*x_100 - 0.0070481144888987*x_101 - 0.010132168505103*x_103 + 0.0172827111825748*x_104 - 0.0196621943702103*x_110 + 0.0158447485617483*x_111 + 0.0326511256920505*x_113 - 0.00848980022778329*x_115 + 0.000195419084825188*x_116 - 0.00497007427356329*x_117 - 0.00308267252562534*x_13 - 0.000896316530688582*x_14 - 0.0189413847127255*x_15 - 0.0358903668761963*x_16 + 0.0078971069760358*x_17 - 0.00608395151850091*x_18 - 0.0353355934966704*x_2 + 0.0565842504005192*x_20 + 0.00841509776047938*x_21 - 0.00647283558340842*x_22 + 0.0253325962488179*x_23 + 0.0235127195531909*x_25 + 0.00700518917067688*x_28 + 0.00443910318443093*x_29 + 0.0105450127783805*x_30 + 0.0548847224637439*x_31 + 0.0176939042017498*x_32 - 0.00485675608812535*x_34 + 0.0408440885697797*x_4 - 0.0265446288563558*x_40 - 0.00155152734207025*x_44 - 0.0164921935112203*x_48 - 0.0034850528364259*x_5 - 0.00246308645350681*x_52 - 0.00488472777366743*x_54 + 0.0213648357601092*x_6 - 0.00745476425557092*x_60 + 0.00307706957543742*x_61 - 0.0217199780614552*x_62 + 0.0240472291035379*x_63 - 0.00959641131183367*x_65 + 0.0248450714298431*x_68 + 0.00117318624758681*x_7 + 0.00918862282781511*x_72 + 0.00184584951547462*x_73 + 0.00093949092709948*x_78 + 0.0133520755776681*x_8 + 0.00394576727289158*x_82 + 0.0083286292120323*x_88 - 0.00576774919519396*x_89 + 0.00931173978995703*x_9 + 0.0105679674804559*x_90 + 0.0341535041951045*x_91 + 0.0532349510513386*x_92 - 0.000493985522384833*x_95 + 0.0114754155457902*x_97 - 0.000165262429873705*std::pow(-4.51200008392334*x_38 - 6.96360015869141, 2) - 0.000192973271282752*std::pow(-6.62088012695313*x_69 - 9.43920040130615, 2) - 0.000252796306564988*std::pow(-3.69936013221741*x_80 - 6.42208003997803, 2) + 0.000220501290252948*std::pow(-7.45847988128662*x_81 - 9.67831993103027, 2) + 0.00175126894834773*std::pow(-1.03719985485077*x_84 - 2.28391981124878, 2) + 0.00012416297523161*std::pow(-6.90776014328003*x_86 - 7.71479988098145, 2) - 0.179006500647692*std::sin(0.364479839801788*x_1 - 4.37279987335205) + 0.148664251884266*std::sin(0.320079833269119*x_102 - 4.26879978179932) - 0.221730962493282*std::sin(0.353279858827591*x_105 - 4.24919986724854) + 0.0757783889974757*std::sin(0.452639847993851*x_106 + 2.046719789505) - 0.0558068327240315*std::sin(0.382639855146408*x_107 + 5.18391990661621) - 0.22232191705443*std::sin(0.238799974322319*x_108 - 7.55640029907227) + 0.167694574098725*std::sin(0.3643998503685*x_109 + 5.17935991287231) - 0.103324950649236*std::sin(0.300399929285049*x_11 + 8.32439994812012) + 0.0167036574659782*std::sin(0.475119858980179*x_112 + 1.8407998085022) + 0.213327869392298*std::sin(0.373439848423004*x_114 - 7.42952013015747) - 0.125658043598955*std::sin(0.372159838676453*x_118 + 1.98983991146088) + 0.309084667473201*std::sin(0.339599847793579*x_119 + 5.15136003494263) - 0.236420064030188*std::sin(0.359199851751328*x_12 + 5.17248010635376) + 0.205047794564425*std::sin(0.371839851140976*x_120 - 7.41567993164063) + 0.021117294635538*std::sin(0.599039852619171*x_19 - 0.798399865627289) - 0.141578616568083*std::sin(0.376079827547073*x_24 + 8.37248039245605) - 0.285516318038319*std::sin(0.338239848613739*x_26 - 4.26504039764404) + 1.03618396807182*std::sin(0.213039994239807*x_27 - 7.5717601776123) + 0.239804955014701*std::sin(0.349679857492447*x_3 - 4.23496007919312) - 0.199640291242652*std::sin(0.218399986624718*x_33 - 7.38711977005005) - 0.205129914813678*std::sin(0.316319853067398*x_35 - 1.20743989944458) + 0.181476430055252*std::sin(0.367839843034744*x_36 + 5.17136001586914) + 0.146814536226543*std::sin(0.403439849615097*x_37 - 4.20223999023438) - 0.153648088637844*std::sin(0.30295991897583*x_39 - 4.30272006988525) + 0.141886916019434*std::sin(0.357199847698212*x_41 - 7.43991994857788) - 0.2587588305068*std::sin(0.303599923849106*x_42 + 5.09543991088867) + 0.169222146899479*std::sin(0.377679854631424*x_43 + 5.18800020217896) - 0.222327639211553*std::sin(0.296639919281006*x_45 + 5.11967945098877) + 0.35370037519337*std::sin(0.290079951286316*x_46 + 5.11967992782593) + 0.190200920349671*std::sin(0.376559853553772*x_47 + 5.1625599861145) + 0.218843380456033*std::sin(0.352319836616516*x_49 - 4.23863983154297) + 0.0952437410439924*std::sin(0.350559860467911*x_50 + 5.15431976318359) + 0.0820171936896497*std::sin(0.321599841117859*x_51 - 7.47175979614258) - 0.0472511298546712*std::sin(0.334159851074219*x_53 - 1.068079829216) + 0.188965015461434*std::sin(0.317279845476151*x_55 - 4.28736019134521) + 0.066696502981487*std::sin(0.342239856719971*x_56 + 5.13784027099609) - 0.169810977940561*std::sin(0.373519837856293*x_57 - 4.21056032180786) - 0.0691092959207182*std::sin(0.463439851999283*x_58 - 1.13231992721558) - 0.0679150509299511*std::sin(0.307839930057526*x_59 - 7.46871995925903) + 0.292005244216078*std::sin(0.238079980015755*x_64 - 4.35223960876465) - 0.304672576339719*std::sin(0.199680000543594*x_66 + 4.99975967407227) + 0.0176619424995361*std::sin(0.343759834766388*x_67 - 4.43192005157471) + 0.0660347225421223*std::sin(0.345999836921692*x_70 - 1.06407976150513) + 0.106659817336633*std::sin(0.298959940671921*x_71 + 5.11895942687988) - 0.209353288232631*std::sin(0.33111983537674*x_74 - 4.27975988388062) + 0.129875330134055*std::sin(0.241279974579811*x_75 - 7.54800033569336) - 0.0977842491260983*std::sin(0.358159840106964*x_76 - 4.25072002410889) + 0.981875347646877*std::sin(0.144800037145615*x_77 - 7.65912008285522) - 0.233332773846314*std::sin(0.257119983434677*x_79 + 5.05615997314453) - 0.159535847906049*std::sin(0.276319950819016*x_83 + 5.11303997039795) + 0.0350518272270079*std::sin(0.50791984796524*x_85 - 0.885199844837189) + 0.297911645072645*std::sin(0.195919990539551*x_87 + 1.79983985424042) - 0.129456591429218*std::sin(0.285359919071198*x_93 + 8.27120018005371) - 0.269684470924755*std::sin(0.390079855918884*x_94 - 7.40775966644287) - 0.092132646362284*std::sin(0.409599870443344*x_96 - 7.38104009628296) + 0.218532957484616*std::sin(0.407839864492416*x_98 + 2.00023984909058) - 0.0944752537213329*std::sin(0.42783984541893*x_99 - 1.18479979038239) + 3.8492024321263) - 0.0363993940562201);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00248377363604619*x_1 + 0.000436273169388071*x_10 + 0.00191600220138873*x_100 - 0.00137476860665693*x_101 + 0.000133233557898699*x_102 - 0.00120850675761501*x_103 + 0.00145897370894747*x_104 - 0.00109845217638222*x_105 + 2.34716501461724e-6*x_106 + 0.000417620267063849*x_107 + 8.30174761793805e-5*x_11 - 0.0024426233645397*x_110 + 0.00316002492092423*x_111 + 0.000832119774264571*x_112 + 0.00250793716797589*x_113 + 0.000163898251985765*x_114 - 0.00109142283380053*x_115 + 0.00207353898391038*x_116 - 0.000617429535865868*x_117 - 0.00195539727318665*x_119 + 0.000187295648053816*x_12 + 0.000165099125582826*x_120 - 0.00535698802150299*x_13 + 0.00157128366906392*x_14 - 0.00230307353867491*x_15 - 0.00950549450258645*x_16 - 0.0029607445286287*x_17 - 0.00192491597125328*x_18 - 0.0020731448761017*x_19 + 0.000483669358500721*x_2 + 0.0088755950366147*x_20 + 0.00104540286895826*x_21 + 0.000402380712004694*x_22 + 0.00342401192724*x_23 + 0.000499816410921775*x_24 + 0.000587469111118581*x_25 - 6.29515452105835e-5*x_26 - 0.000146820225534293*x_27 + 0.000754205306583637*x_28 + 0.00372450235719869*x_29 + 0.00332025210912601*x_3 - 0.000775873197514553*x_30 + 0.00100357184750014*x_31 + 0.00219810378228191*x_32 - 3.99745319391669e-5*x_33 - 0.000603352081327155*x_34 - 0.00155203992696803*x_35 - 4.76904751162063e-5*x_36 + 1.00529176311514e-5*x_37 + 0.000139889106969724*x_38 - 0.000468249804683018*x_39 + 0.00419030105882548*x_4 - 0.00334269081890539*x_40 - 0.000626921244103249*x_41 - 0.00180588040039387*x_42 + 0.000697375605485209*x_43 + 0.000523248410664309*x_44 - 0.000216267445013788*x_45 - 0.00017403311078687*x_46 + 3.77373157657146e-5*x_47 - 0.000277401258944829*x_48 - 0.000481889886728167*x_5 - 0.00059789511248536*x_51 + 0.000779202345887132*x_52 + 0.00016277149857123*x_53 + 0.00199525135163455*x_54 + 0.000140874052867657*x_55 + 0.000351347691862248*x_56 - 0.00217961701447664*x_58 + 0.000135965673361815*x_59 + 0.002845418107939*x_6 - 0.00104760818413664*x_60 + 0.00176127552819985*x_61 - 0.00551639655251802*x_62 + 0.00175064326237875*x_63 + 0.00143645029637892*x_64 - 0.00203499945067418*x_65 + 0.000761473404185762*x_66 + 0.00247113376533117*x_68 - 0.00234613173588054*x_7 + 0.000232507594036017*x_70 + 0.000105541223570207*x_72 + 0.00111362960920957*x_73 + 0.00125052627557517*x_74 - 6.76607568127515e-5*x_75 - 0.00121688699038898*x_76 - 0.000485003227591942*x_77 + 0.0012140160557522*x_78 + 0.000507172588625447*x_79 + 0.00200340151548475*x_8 + 0.000177719228068105*x_80 - 6.94121730142707e-7*x_81 + 0.000490180452411936*x_82 + 0.000154996913680855*x_84 + 0.000508244247523784*x_85 + 0.000689280430964543*x_86 + 3.03523270365366e-5*x_87 + 0.000944041960125675*x_88 - 0.000548260794404366*x_89 - 0.000507635705273928*x_9 + 0.000302829815283114*x_90 + 0.0049065046546631*x_91 + 0.00661141455037377*x_92 - 0.000715510241003848*x_93 + 0.000303817422235505*x_94 + 0.000438159105098135*x_95 + 0.0013604769639474*x_96 - 6.65811741904006e-5*x_97 + 0.000882401407816628*x_98 + 0.000735933115173544*x_99 - 3.23935372802145e-5*std::pow(-4.47631978988647*x_100 - 6.92568016052246, 2) - 3.0597286594583e-5*std::pow(-3.50639986991882*x_17 - 5.15751981735229, 2) + 0.000111204992755068*std::pow(-4.37183952331543*x_18 - 6.95983982086182, 2) + 7.60778116259123e-5*std::pow(-3.88375997543335*x_19 - 6.13335990905762, 2) + 2.43235849439299e-5*std::pow(-5.80399990081787*x_22 - 9.99647998809814, 2) + 2.72854353392976e-5*std::pow(-4.18495988845825*x_24 - 7.37408018112183, 2) + 0.00022590675521134*std::pow(-0.866319835186005*x_24 - 1.30367994308472, 2) + 1.47746050861612e-5*std::pow(-6.56744050979614*x_27 - 9.54936027526855, 2) - 2.05304588536524e-5*std::pow(-4.51200008392334*x_38 - 6.96360015869141, 2) + 4.82494237085913e-5*std::pow(-5.81879997253418*x_4 - 9.82336044311523, 2) - 5.33745541569515e-5*std::pow(-3.90320014953613*x_4 - 6.1637601852417, 2) + 2.05614576615706e-6*std::pow(-5.71783971786499*x_43 - 8.27400016784668, 2) - 2.32465697107712e-5*std::pow(-5.93743944168091*x_5 - 9.30079936981201, 2) - 2.85038122764976e-5*std::pow(-4.35264015197754*x_55 - 6.33048009872437, 2) + 6.90055654816205e-5*std::pow(-3.86879992485046*x_6 - 6.51087999343872, 2) + 5.04566611157848e-6*std::pow(-5.42744016647339*x_60 - 8.43583965301514, 2) + 1.09059480987295e-5*std::pow(-5.41200017929077*x_64 - 9.21903991699219, 2) - 1.55911250446201e-5*std::pow(-6.89007997512817*x_66 - 9.33463954925537, 2) - 2.39729611197953e-5*std::pow(-6.62088012695313*x_69 - 9.43920040130615, 2) + 2.62739963771949e-5*std::pow(-5.21744012832642*x_7 - 9.23895931243896, 2) - 1.71973183287634e-5*std::pow(-5.09847974777222*x_7 - 7.94231986999512, 2) - 4.21710119711834e-5*std::pow(-3.91991996765137*x_7 - 6.46479988098145, 2) - 1.59426505823042e-5*std::pow(-6.25472021102905*x_71 - 9.68151950836182, 2) + 3.8190814355195e-6*std::pow(-5.8854398727417*x_71 - 9.54551982879639, 2) - 1.29443897546011e-5*std::pow(-5.71959972381592*x_71 - 8.97583961486816, 2) + 1.94382848706754e-5*std::pow(-4.14160013198853*x_71 - 6.69736003875732, 2) - 4.43246386831396e-5*std::pow(-5.3120002746582*x_73 - 7.55503988265991, 2) + 9.44302360797481e-5*std::pow(-1.42991983890533*x_75 - 1.61055982112885, 2) - 1.34455630011583e-5*std::pow(-6.52383947372437*x_77 - 9.1627197265625, 2) + 4.11206848370023e-6*std::pow(-7.06584024429321*x_78 - 9.41096019744873, 2) + 1.41865532361596e-5*std::pow(-6.66368007659912*x_78 - 9.21712017059326, 2) + 1.58756598854169e-5*std::pow(-4.71984004974365*x_80 - 6.09327983856201, 2) - 3.14047431969506e-5*std::pow(-3.69936013221741*x_80 - 6.42208003997803, 2) + 0.000144429635112906*std::pow(-1.82767987251282*x_80 - 2.43895983695984, 2) + 2.73927514570309e-5*std::pow(-7.45847988128662*x_81 - 9.67831993103027, 2) + 1.12213184956566e-5*std::pow(-7.05999994277954*x_81 - 9.27960014343262, 2) - 2.28259133791026e-6*std::pow(-9.20399951934814*x_82 - 9.99767971038818, 2) + 0.000217559157959911*std::pow(-1.03719985485077*x_84 - 2.28391981124878, 2) + 1.32877750629637e-5*std::pow(-5.27831983566284*x_85 - 8.4093599319458, 2) + 5.6379106976489e-6*std::pow(-8.02295970916748*x_86 - 9.42399978637695, 2) + 1.54246966844653e-5*std::pow(-6.90776014328003*x_86 - 7.71479988098145, 2) + 5.38378682159935e-6*std::pow(-7.40399980545044*x_87 - 9.99079990386963, 2) + 3.72402624955394e-5*std::pow(-5.18376016616821*x_87 - 7.56544017791748, 2) + 8.18067823559125e-6*std::pow(-5.38815975189209*x_88 - 7.58616018295288, 2) - 1.59815914454158e-5*std::pow(-7.48543977737427*x_89 - 9.05047988891602, 2) + 2.79463381769205e-5*std::pow(-5.15536022186279*x_89 - 6.94384002685547, 2) - 1.03447508099126e-5*std::pow(-5.88768005371094*x_90 - 8.31655979156494, 2) - 0.000545305451627558*std::exp(0.82207989692688*x_25) - 0.0732800391149279*std::sin(0.215440005064011*x_1 - 7.3842396736145) - 0.0222378770473861*std::sin(0.364479839801788*x_1 - 4.37279987335205) - 0.0132372415283666*std::sin(0.301679849624634*x_10 + 5.10400009155273) - 0.0134470824147045*std::sin(0.208000004291534*x_100 + 5.00311994552612) - 0.0225027377954437*std::sin(0.414799869060516*x_100 + 5.20456027984619) - 0.00619034051955169*std::sin(0.426559865474701*x_100 + 5.22328042984009) + 0.0302703023357604*std::sin(0.319119840860367*x_101 + 5.146399974823) - 0.0064602162373827*std::sin(0.319359838962555*x_102 - 4.27135992050171) + 0.0184684765233781*std::sin(0.320079833269119*x_102 - 4.26879978179932) + 0.00650421142130494*std::sin(0.322719842195511*x_102 + 5.12976026535034) - 0.0223162488155113*std::sin(0.3503198325634*x_102 - 7.41847991943359) + 0.00182807701886523*std::sin(0.336479842662811*x_103 - 7.43991994857788) + 0.0188420641182194*std::sin(0.404639840126038*x_103 - 7.39447975158691) - 0.0097682052166645*std::sin(0.442559868097305*x_103 + 5.23320007324219) - 0.0136904043245337*std::sin(0.276479959487915*x_104 - 7.50216007232666) + 0.00505169343695935*std::sin(0.431439846754074*x_104 - 7.38263988494873) - 0.0275455129488773*std::sin(0.353279858827591*x_105 - 4.24919986724854) + 0.00241957635217878*std::sin(0.437759846448898*x_105 - 1.18407988548279) + 0.0083210808389164*std::sin(0.281599938869476*x_106 + 5.08271980285645) + 0.00617292267156657*std::sin(0.360079854726791*x_106 + 5.16480016708374) + 0.00941390670884885*std::sin(0.452639847993851*x_106 + 2.046719789505) + 0.00985272532319691*std::sin(0.361199855804443*x_107 + 5.15944004058838) - 0.0122830885581165*std::sin(0.365039855241776*x_107 - 7.41479969024658) - 0.00693285148880464*std::sin(0.382639855146408*x_107 + 5.18391990661621) - 0.00926628001895404*std::sin(0.426959842443466*x_107 + 5.22248029708862) + 0.0153385880998618*std::sin(0.211359992623329*x_108 + 5.00783967971802) - 0.027618926902135*std::sin(0.238799974322319*x_108 - 7.55640029907227) - 0.00208639038025181*std::sin(0.301119923591614*x_108 - 4.28095960617065) - 0.0143585339446234*std::sin(0.353679835796356*x_108 - 7.44871950149536) + 0.00398684683423298*std::sin(0.575359880924225*x_108 - 7.20560026168823) - 0.0235663981042776*std::sin(0.323999851942062*x_109 + 5.12048006057739) + 0.00448770496979714*std::sin(0.359439849853516*x_109 + 5.17456007003784) + 0.0208326027648612*std::sin(0.3643998503685*x_109 + 5.17935991287231) + 0.00365899954324751*std::sin(0.422879844903946*x_109 + 2.01311993598938) - 0.00215983253235972*std::sin(0.527999877929688*x_109 + 8.36816024780273) - 0.0128360005930019*std::sin(0.300399929285049*x_11 + 8.32439994812012) - 0.00681859812890921*std::sin(0.327679842710495*x_11 - 1.06183981895447) + 0.00304905769461035*std::sin(0.384719848632813*x_110 + 8.17407989501953) + 0.0207702255186554*std::sin(0.390239834785461*x_110 + 5.18304014205933) - 0.0057121109653963*std::sin(0.398719817399979*x_110 + 2.0097599029541) - 0.013778496442981*std::sin(0.456639856100082*x_110 + 2.05167984962463) + 0.0123025372759698*std::sin(0.480879843235016*x_111 - 7.34032011032104) - 0.0077953662042459*std::sin(0.48431983590126*x_111 + 5.24575996398926) - 0.00768387874943251*std::sin(0.352079838514328*x_112 - 7.44328022003174) + 0.00574995215622122*std::sin(0.364639848470688*x_112 + 5.16183996200562) - 0.0180263863815349*std::sin(0.380959838628769*x_112 - 7.40343999862671) + 0.00207508598640866*std::sin(0.475119858980179*x_112 + 1.8407998085022) + 0.0217324617387021*std::sin(0.366319835186005*x_113 - 7.42911958694458) + 0.014047129555962*std::sin(0.311119943857193*x_114 + 5.11175966262817) + 0.0265016014120264*std::sin(0.373439848423004*x_114 - 7.42952013015747) - 0.0106252142552231*std::sin(0.393599838018417*x_114 + 1.99799978733063) - 0.0112029451850748*std::sin(0.44159984588623*x_114 - 7.38136005401611) + 0.00421248042528901*std::sin(0.355759829282761*x_115 - 1.24439990520477) - 0.0127149418020423*std::sin(0.36847984790802*x_115 + 8.36911964416504) - 0.00172116972563008*std::sin(0.574719846248627*x_115 - 4.20968008041382) + 0.00397595942998482*std::sin(0.682319819927216*x_116 + 8.42623996734619) - 0.0316041441438933*std::sin(0.306239932775497*x_117 - 4.28335952758789) + 0.0232898557758223*std::sin(0.380719840526581*x_117 + 5.18304014205933) + 0.00706920726467324*std::sin(0.461359858512878*x_117 - 7.3459997177124) + 0.0037366424538406*std::sin(0.478159844875336*x_117 + 2.04239964485168) - 0.00844991850054693*std::sin(0.334479838609695*x_118 - 4.26528024673462) + 0.00599559295035514*std::sin(0.341599822044373*x_118 - 7.44719982147217) + 0.0314283464540589*std::sin(0.365839838981628*x_118 + 5.15880012512207) - 0.0156104281881267*std::sin(0.372159838676453*x_118 + 1.98983991146088) + 0.007413208740137*std::sin(0.393759846687317*x_118 + 5.18567991256714) + 0.0383974146616552*std::sin(0.339599847793579*x_119 + 5.15136003494263) - 0.023641043596002*std::sin(0.397039830684662*x_119 + 1.97919988632202) - 0.0293703317835696*std::sin(0.359199851751328*x_12 + 5.17248010635376) + 0.0139122181805749*std::sin(0.423359870910645*x_12 + 8.41808032989502) + 0.00847547242064558*std::sin(0.34639984369278*x_120 + 5.15912008285522) + 0.0254729723661585*std::sin(0.371839851140976*x_120 - 7.41567993164063) + 0.00134601254562262*std::sin(0.426879853010178*x_120 + 2.20191979408264) + 0.0120094089320687*std::sin(0.4859998524189*x_120 + 2.06983971595764) - 0.0727224930701454*std::sin(0.171840012073517*x_13 + 8.15135955810547) - 0.0236097676561834*std::sin(0.212640002369881*x_14 + 5.00903987884521) + 0.00221057943827415*std::sin(0.270879954099655*x_14 + 1.8879998922348) - 0.0394033512114628*std::sin(0.306239932775497*x_14 + 5.15127992630005) - 0.0230146638811981*std::sin(0.431279867887497*x_15 - 0.968239843845367) + 0.000936859449252731*std::sin(1.49863994121552*x_15 - 2.5971200466156) + 0.00727260744441867*std::sin(0.41951984167099*x_16 - 7.36879968643188) + 0.0423656964936988*std::sin(0.185440003871918*x_18 - 7.60567998886108) - 0.0191745040351138*std::sin(0.258959949016571*x_18 + 5.06335973739624) + 0.00262338965333311*std::sin(0.599039852619171*x_19 - 0.798399865627289) + 0.0188135165751394*std::sin(0.263439953327179*x_21 - 1.12615990638733) - 0.0273118098769019*std::sin(0.30991992354393*x_21 - 4.27695989608765) + 0.00748533681545969*std::sin(0.325759828090668*x_21 - 4.2579197883606) - 0.0029517689602181*std::sin(0.398319840431213*x_21 - 7.18815994262695) - 0.0101777951144534*std::sin(0.217999994754791*x_23 - 7.5860800743103) + 0.0116117246248503*std::sin(0.271119952201843*x_23 + 5.0798397064209) - 0.0183051253458988*std::sin(0.310719907283783*x_23 - 4.24408006668091) + 0.00768381355946133*std::sin(0.264239966869354*x_24 + 8.05335998535156) - 0.0175882320272632*std::sin(0.376079827547073*x_24 + 8.37248039245605) + 0.0105680956206154*std::sin(0.320399850606918*x_26 + 8.32015991210938) - 0.0394656368767328*std::sin(0.325119823217392*x_26 - 4.25880002975464) - 0.0105495855988169*std::sin(0.326479852199554*x_26 + 8.31744003295898) - 0.0354695318470849*std::sin(0.338239848613739*x_26 - 4.26504039764404) + 0.128724552444074*std::sin(0.213039994239807*x_27 - 7.5717601776123) + 0.0162787316629139*std::sin(0.279119938611984*x_27 + 5.103759765625) + 0.000346651823133733*std::sin(1.74143981933594*x_27 - 1.98255980014801) - 0.0133698654597042*std::sin(0.347439825534821*x_28 + 8.35303974151611) - 0.00532645904488882*std::sin(0.361359834671021*x_28 + 8.34383964538574) - 0.00501762183061932*std::sin(0.417199850082397*x_28 + 8.41736030578613) + 0.00144684473618764*std::sin(0.810399830341339*x_29 + 5.61424016952515) + 0.00115368203382571*std::sin(1.04367983341217*x_29 + 6.00735950469971) - 0.00986191537185611*std::sin(0.306319922208786*x_3 + 8.31271934509277) + 0.0424270193468217*std::sin(0.338559836149216*x_3 + 8.35519981384277) + 0.0297908348896583*std::sin(0.349679857492447*x_3 - 4.23496007919312) - 0.00525085015701871*std::sin(0.29751992225647*x_30 - 7.49848031997681) - 0.00291943480967275*std::sin(0.330079823732376*x_30 + 8.34352016448975) + 0.0178414208337792*std::sin(0.20040000975132*x_31 - 7.39463949203491) - 0.00921252789035004*std::sin(0.210400000214577*x_32 - 1.00415980815887) - 0.0529241613537855*std::sin(0.259839981794357*x_32 + 5.17312002182007) + 0.0147555358658883*std::sin(0.271519958972931*x_32 - 7.43567991256714) + 0.00941393784592594*std::sin(0.311999946832657*x_32 - 4.44504022598267) - 0.0248012012652888*std::sin(0.218399986624718*x_33 - 7.38711977005005) - 0.0510293980040028*std::sin(0.279199957847595*x_33 - 1.16039991378784) + 0.0163653411635637*std::sin(0.292239934206009*x_33 + 8.22999954223633) + 0.0167649555615648*std::sin(0.277199953794479*x_34 - 1.12231993675232) + 0.00995789889901092*std::sin(0.357199847698212*x_34 - 7.39351987838745) - 0.00734704148931698*std::sin(0.369359821081161*x_34 + 1.97839987277985) + 0.0236997781161196*std::sin(0.386319845914841*x_34 + 1.9748797416687) + 0.0035195774327276*std::sin(0.272719949483871*x_35 - 1.1399998664856) - 0.0115238091186309*std::sin(0.315359860658646*x_35 + 1.97319984436035) - 0.0254831741186054*std::sin(0.316319853067398*x_35 - 1.20743989944458) + 0.0270554532764303*std::sin(0.316399842500687*x_35 - 7.42007970809937) - 0.0171830470719901*std::sin(0.343759834766388*x_36 - 7.44807958602905) - 0.0306578105449082*std::sin(0.363919854164124*x_36 - 4.23432016372681) + 0.0115081445118077*std::sin(0.366559833288193*x_36 + 5.16152000427246) + 0.0225447149906022*std::sin(0.367839843034744*x_36 + 5.17136001586914) + 0.0156442385689022*std::sin(0.358239859342575*x_37 + 5.17824029922485) + 0.018238687385999*std::sin(0.403439849615097*x_37 - 4.20223999023438) - 0.0153679160606051*std::sin(0.450879871845245*x_37 + 2.03239989280701) + 0.0503327617552175*std::sin(0.165120020508766*x_38 - 7.63992023468018) - 0.0200034441919248*std::sin(0.249279975891113*x_38 + 5.06663990020752) + 0.0129284071769029*std::sin(0.308319836854935*x_38 + 5.11079978942871) - 0.0134288825377645*std::sin(0.271279960870743*x_39 + 8.28528022766113) + 0.00814399839378347*std::sin(0.301999926567078*x_39 + 5.10551977157593) - 0.0190876157644073*std::sin(0.30295991897583*x_39 - 4.30272006988525) + 0.00882037725521795*std::sin(0.306399941444397*x_40 + 5.12367963790894) - 0.0307711981338145*std::sin(0.315039843320847*x_40 - 4.28247976303101) - 0.0116824882990891*std::sin(0.394879847764969*x_40 + 5.19040012359619) + 0.0206371810225815*std::sin(0.330479830503464*x_41 + 5.14264011383057) + 0.017626531894967*std::sin(0.357199847698212*x_41 - 7.43991994857788) - 0.0199170652796399*std::sin(0.365519851446152*x_41 - 7.41623973846436) - 0.0321454641977542*std::sin(0.303599923849106*x_42 + 5.09543991088867) - 0.0200193789621822*std::sin(0.348079830408096*x_42 - 1.23199987411499) - 0.0060720525177404*std::sin(0.358479857444763*x_42 + 1.97983980178833) - 0.00634356683054614*std::sin(0.417839854955673*x_42 - 1.1794399023056) + 0.0207251062606674*std::sin(0.356159836053848*x_43 + 5.15208005905151) + 0.0210223722760308*std::sin(0.377679854631424*x_43 + 5.18800020217896) - 0.0143797224130773*std::sin(0.29351994395256*x_44 - 4.27183961868286) - 0.0184958145573655*std::sin(0.220559984445572*x_45 + 8.22208023071289) - 0.0276196377625009*std::sin(0.296639919281006*x_45 + 5.11967945098877) - 0.00619710669530974*std::sin(0.388719856739044*x_45 + 1.97711980342865) - 0.0124027550631787*std::sin(0.466559857130051*x_45 + 5.24775981903076) - 0.0312052832620533*std::sin(0.195199996232986*x_46 + 4.97847986221313) + 0.0439399989760423*std::sin(0.290079951286316*x_46 + 5.11967992782593) + 0.00890129474304303*std::sin(0.439439862966537*x_46 - 4.14663982391357) - 0.00391712344381416*std::sin(0.44871985912323*x_46 + 5.24927997589111) + 0.0236285535203004*std::sin(0.376559853553772*x_47 + 5.1625599861145) + 0.00349608982020274*std::sin(0.624079823493958*x_47 - 7.38527965545654) + 0.0112774755403759*std::sin(0.509759843349457*x_48 + 8.27455902099609) - 0.00162957625772416*std::sin(0.589999854564667*x_48 - 7.40863990783691) - 0.00376478461714094*std::sin(0.219999998807907*x_49 - 1.36087989807129) - 0.0195271110607614*std::sin(0.326879858970642*x_49 - 4.26919984817505) + 0.0271867902540239*std::sin(0.352319836616516*x_49 - 4.23863983154297) - 0.00410580519455066*std::sin(0.506479859352112*x_49 + 8.28087997436523) - 0.000195905900764421*std::sin(1.97479975223541*x_49 - 7.4031195640564) - 0.0525023339799644*std::sin(0.304159939289093*x_50 - 7.47200012207031) + 0.0118320764620606*std::sin(0.350559860467911*x_50 + 5.15431976318359) - 0.0163453961622977*std::sin(0.375439822673798*x_50 - 4.23304033279419) + 0.00297022194179097*std::sin(0.428159862756729*x_50 - 1.17399990558624) + 0.00543341229457232*std::sin(0.436799854040146*x_50 + 5.22847986221313) - 0.0106369905551506*std::sin(0.276399940252304*x_51 - 4.30975961685181) + 0.0101889499121137*std::sin(0.321599841117859*x_51 - 7.47175979614258) + 0.0234969467230379*std::sin(0.352479845285416*x_51 + 5.1418399810791) - 0.0128484729153906*std::sin(0.233919993042946*x_52 + 8.23464012145996) - 0.000910702454286222*std::sin(0.71399986743927*x_52 - 1.22463989257813) - 0.0884973532209854*std::sin(0.131200045347214*x_53 - 7.68440008163452) - 0.00597216898375816*std::sin(0.231279999017715*x_53 - 7.54808044433594) - 0.0114688567896394*std::sin(0.295199930667877*x_53 - 4.27360010147095) - 0.00586998132613237*std::sin(0.334159851074219*x_53 - 1.068079829216) - 0.00723880355444802*std::sin(0.198559984564781*x_55 - 4.39231967926025) - 0.0257595009011869*std::sin(0.308479934930801*x_55 - 7.46504020690918) + 0.0234750177501053*std::sin(0.317279845476151*x_55 - 4.28736019134521) + 0.02074501746108*std::sin(0.203759998083115*x_56 + 5.00360012054443) + 0.00828566910936961*std::sin(0.342239856719971*x_56 + 5.13784027099609) - 0.00760131292612009*std::sin(0.363439828157425*x_56 + 5.15592002868652) + 0.0198334212760561*std::sin(0.229999989271164*x_57 - 4.37119960784912) + 0.00165157722172459*std::sin(0.319519847631454*x_57 - 7.47119998931885) + 0.0164923925131858*std::sin(0.366719841957092*x_57 + 8.35023975372314) - 0.0210955224255834*std::sin(0.373519837856293*x_57 - 4.21056032180786) - 0.017936624405686*std::sin(0.41023987531662*x_57 + 5.21224021911621) - 0.00400207642643093*std::sin(0.250159978866577*x_58 - 7.52272033691406) + 0.0127642669782345*std::sin(0.266959935426712*x_58 + 5.07175970077515) + 0.0106870166380973*std::sin(0.389519840478897*x_58 + 1.97375977039337) - 0.0085854090212124*std::sin(0.463439851999283*x_58 - 1.13231992721558) - 0.00567776705511418*std::sin(0.303439915180206*x_59 + 5.13167953491211) - 0.00843704863668421*std::sin(0.307839930057526*x_59 - 7.46871995925903) - 0.0243105290191138*std::sin(0.314319908618927*x_59 + 5.13312005996704) + 0.0470357343573195*std::sin(0.228319987654686*x_60 + 5.03671979904175) + 0.0271392168136341*std::sin(0.344799846410751*x_60 - 4.26503992080688) - 0.00565040054759091*std::sin(0.324959844350815*x_62 + 8.3133602142334) - 0.0176973015919306*std::sin(0.206400007009506*x_64 - 4.40303993225098) + 0.0362756475020386*std::sin(0.238079980015755*x_64 - 4.35223960876465) - 0.018099730066674*std::sin(0.196719989180565*x_65 + 5.00432014465332) - 0.0135093027869101*std::sin(0.273279964923859*x_65 + 5.09200000762939) - 0.0378493030579245*std::sin(0.199680000543594*x_66 + 4.99975967407227) + 0.0146422229984411*std::sin(0.221759989857674*x_66 + 5.03087949752808) + 0.0146263133804137*std::sin(0.201039999723434*x_67 + 5.00600004196167) + 0.060676129604676*std::sin(0.202800005674362*x_67 - 7.58416032791138) - 0.0278573301961019*std::sin(0.225759983062744*x_67 + 5.03471994400024) - 0.0104076087765815*std::sin(0.244639977812767*x_67 + 5.04016017913818) + 0.00219413319796525*std::sin(0.343759834766388*x_67 - 4.43192005157471) + 0.0483944608245633*std::sin(0.225199997425079*x_69 + 5.02031993865967) + 0.0406972613251359*std::sin(0.251279979944229*x_69 + 5.05583953857422) - 0.00912545704176734*std::sin(0.262479960918427*x_69 + 5.07775974273682) - 0.0106400768928483*std::sin(0.269839972257614*x_69 + 5.09832000732422) - 0.0364648196509066*std::sin(0.13864004611969*x_70 - 7.66880035400391) + 0.0125741214135655*std::sin(0.289679944515228*x_70 - 7.4759202003479) + 0.00820345649703592*std::sin(0.345999836921692*x_70 - 1.06407976150513) + 0.0132502892087527*std::sin(0.298959940671921*x_71 + 5.11895942687988) + 0.00510937365926608*std::sin(0.34487983584404*x_72 - 1.04951989650726) - 0.0260078414266419*std::sin(0.33111983537674*x_74 - 4.27975988388062) + 0.00505935430398854*std::sin(0.344799846410751*x_74 - 4.25688028335571) - 0.00847007627090705*std::sin(0.365679830312729*x_74 + 1.94711983203888) + 0.0175410919947074*std::sin(0.207840010523796*x_75 - 7.58039999008179) + 0.0161343393260006*std::sin(0.241279974579811*x_75 - 7.54800033569336) + 0.000251142408005494*std::sin(0.873279869556427*x_75 + 2.20911979675293) - 0.0121476823543793*std::sin(0.358159840106964*x_76 - 4.25072002410889) + 0.121977823027805*std::sin(0.144800037145615*x_77 - 7.65912008285522) + 0.0131490059649807*std::sin(0.293919950723648*x_77 + 5.11543989181519) + 0.0165881377117689*std::sin(0.31399992108345*x_77 - 7.46776008605957) + 0.0335168673979086*std::sin(0.255599975585938*x_79 + 5.07967948913574) - 0.0122494613918043*std::sin(0.255679965019226*x_79 + 5.05535984039307) - 0.0289867994578151*std::sin(0.257119983434677*x_79 + 5.05615997314453) - 0.00271748061772494*std::sin(0.320879846811295*x_79 + 5.12488031387329) - 0.0118206834717915*std::sin(0.266479969024658*x_8 + 5.09807968139648) + 0.0142615583848932*std::sin(0.325599819421768*x_8 - 4.28672027587891) - 0.00308795320643337*std::sin(0.474159836769104*x_80 + 8.48776054382324) + 0.0240088742409514*std::sin(0.214560002088547*x_82 + 5.02231979370117) - 0.0113901607631251*std::sin(0.275119960308075*x_82 - 7.49600028991699) + 0.0238858228134823*std::sin(0.326799839735031*x_82 + 5.12800025939941) + 0.0235005129849898*std::sin(0.270079970359802*x_83 + 5.10271978378296) - 0.0198190487917957*std::sin(0.276319950819016*x_83 + 5.11303997039795) + 0.00528953497241257*std::sin(0.375839829444885*x_83 + 8.19039916992188) + 0.00436561546304089*std::sin(0.410399854183197*x_83 - 7.39120006561279) - 0.00705513493878725*std::sin(0.510559856891632*x_83 + 8.3342399597168) - 0.0307879634332226*std::sin(0.234959989786148*x_84 + 5.02799987792969) + 0.0142036397076237*std::sin(0.305039942264557*x_84 + 5.14831972122192) - 0.00672734836792741*std::sin(0.319039851427078*x_84 - 4.2947998046875) + 0.0355259953946666*std::sin(0.265119940042496*x_85 + 5.06559991836548) + 0.00435446881169159*std::sin(0.50791984796524*x_85 - 0.885199844837189) + 0.0370093963634803*std::sin(0.195919990539551*x_87 + 1.79983985424042) - 0.0105419677467537*std::sin(0.242479979991913*x_87 + 5.03991985321045) - 0.0738058040568468*std::sin(0.148960039019585*x_88 - 7.65576028823853) - 0.0048245091036686*std::sin(0.357119828462601*x_89 + 5.16175985336304) - 0.122970507579934*std::sin(0.12216005474329*x_9 + 8.07327938079834) + 0.0115993036379557*std::sin(0.497999846935272*x_9 + 2.30663990974426) - 0.00485857092371939*std::sin(0.446799844503403*x_90 - 4.16096019744873) + 0.048523701180639*std::sin(0.168240025639534*x_91 + 5.22959995269775) + 0.0240195742953611*std::sin(0.179120019078255*x_91 + 5.2279200553894) - 0.0139906949327166*std::sin(0.324799835681915*x_92 + 2.19455981254578) + 0.0140365920528315*std::sin(0.336719840764999*x_92 + 5.20352029800415) - 0.0160823196518577*std::sin(0.285359919071198*x_93 + 8.27120018005371) + 0.00132901413769556*std::sin(0.384559839963913*x_93 + 1.77711987495422) - 0.0229925492186544*std::sin(0.394639849662781*x_93 + 1.99383985996246) + 0.0107494609742612*std::sin(0.343359857797623*x_94 + 1.96759986877441) + 0.0137108194689845*std::sin(0.370159834623337*x_94 - 7.40679979324341) - 0.0335027503711576*std::sin(0.390079855918884*x_94 - 7.40775966644287) - 0.0064569457716608*std::sin(0.406239867210388*x_94 - 7.39663982391357) + 0.019138196460958*std::sin(0.367199838161469*x_95 + 5.17216014862061) - 0.00519758553666568*std::sin(0.381119847297668*x_95 + 5.19063997268677) + 0.00514164950816824*std::sin(0.385119825601578*x_95 - 7.39695978164673) + 0.0105519366447954*std::sin(0.368079841136932*x_96 + 5.16943979263306) + 0.0068516360750928*std::sin(0.383679836988449*x_96 - 7.40807962417603) - 0.00362487612398129*std::sin(0.406319856643677*x_96 - 7.39271974563599) - 0.0114455869169084*std::sin(0.409599870443344*x_96 - 7.38104009628296) - 0.0297359841727606*std::sin(0.345919847488403*x_97 + 5.16247987747192) - 0.00756319717342202*std::sin(0.396479845046997*x_97 - 7.4031195640564) - 0.00591182216938853*std::sin(0.352719843387604*x_98 - 4.2403998374939) + 0.0271482265826149*std::sin(0.407839864492416*x_98 + 2.00023984909058) + 0.00788226243388346*std::sin(0.444959849119186*x_98 + 2.03095984458923) + 0.0172599959901912*std::sin(0.310319930315018*x_99 - 7.48432016372681) - 0.0117366077135406*std::sin(0.42783984541893*x_99 - 1.18479979038239) - 0.00344027612076631*std::sin(0.45839986205101*x_99 + 2.04295969009399) + 0.739054491470576);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00420881233139323*x_1 + 0.000381285842607594*x_10 - 0.00150301532034227*x_100 + 0.00225590972546696*x_101 + 0.000163902517140438*x_102 + 0.00104916667499232*x_103 - 0.0036017427007952*x_104 - 0.000489127222931475*x_105 + 0.000687270036023066*x_106 + 0.00126636050148443*x_107 - 0.00035241302963883*x_11 + 0.00191612532390003*x_110 + 0.00195115472770301*x_111 + 0.000432073231067606*x_112 - 0.00516840439130245*x_113 + 0.000496992816072745*x_114 + 0.000827350238992368*x_115 + 0.000471821772740914*x_116 + 0.000484344981945006*x_117 - 0.00145196211514811*x_119 + 0.00649674150458641*x_12 + 8.57267365146492e-5*x_120 - 0.000482997362744399*x_13 + 8.73480736862559e-5*x_14 + 0.00180492270549953*x_15 + 0.000178116680163345*x_16 - 0.00310792105111716*x_17 - 1.41586041049671e-5*x_18 - 0.000323115046083157*x_19 + 0.00503906151609282*x_2 + 0.00214373583518661*x_20 - 0.000820070314551396*x_21 + 0.00491355147116235*x_22 - 0.002324910169741*x_23 + 0.000259526691092576*x_24 - 0.00296738787487612*x_25 - 0.000190889563197148*x_26 - 0.000742927420006258*x_28 + 0.00142117887855255*x_29 + 0.0021369499412128*x_3 - 0.00209725981427547*x_30 + 0.00330512821941074*x_31 - 0.00172431099404656*x_32 + 0.00108317117093081*x_33 + 0.000473301868410078*x_34 - 0.000805887477657504*x_35 - 0.0001446130342495*x_36 + 0.000258337002730449*x_37 + 0.000424189278216484*x_38 - 0.00149316000532171*x_39 - 0.00388151082754305*x_4 + 0.0025634336322576*x_40 - 0.000254789067231831*x_41 - 0.000937692629897479*x_42 + 0.000508778620646221*x_43 + 0.000171227799910005*x_44 - 0.000655793245016401*x_45 - 0.000527725004824206*x_46 - 0.00259617891066344*x_47 + 0.00260997575522184*x_48 - 0.000510952866236208*x_5 - 0.000542904128334595*x_51 + 0.000745015443501956*x_52 + 0.000200239780092267*x_53 + 0.00131118052687078*x_54 + 0.000173301773434135*x_55 + 4.16589349852077e-5*x_56 + 0.000601548229888728*x_59 - 0.00197860823534624*x_6 + 0.000577007003722248*x_60 + 0.00152718820732426*x_61 + 0.00148455387092113*x_62 - 0.00296434490497582*x_63 + 0.000589858564803091*x_64 - 0.00124186926424718*x_65 + 0.000940589568331481*x_66 - 0.00214565179459859*x_68 - 0.000114329653970779*x_7 + 1.35970980370651e-5*x_70 - 0.00137550824240472*x_72 + 0.000265845035334717*x_73 + 0.000731784015781891*x_74 - 0.000205169424680034*x_75 - 0.00295094860601497*x_76 - 0.00147068755746233*x_77 + 0.000486432188304335*x_78 + 0.000263346342502185*x_79 - 0.0012215966494586*x_8 + 0.000538902511513749*x_80 + 0.000310332020135349*x_81 - 0.000384523947401232*x_82 + 0.000190675567792065*x_84 + 0.00198701597457922*x_85 + 0.000328452815275829*x_86 - 0.00149959478568172*x_88 + 0.00107230972111617*x_89 - 0.00314173299213416*x_9 - 0.00112448478705711*x_90 - 0.0012180443212964*x_91 - 0.00509403391338089*x_92 - 0.000709009834965616*x_93 + 0.000921273255933812*x_94 + 0.000307516240726969*x_95 + 0.000706419551350429*x_96 - 0.00168609203169219*x_97 + 0.000306282763939268*x_98 + 0.00174493002394265*x_99 - 1.68201510783003e-5*std::pow(-4.47631978988647*x_100 - 6.92568016052246, 2) - 9.27809262428708e-5*std::pow(-3.50639986991882*x_17 - 5.15751981735229, 2) + 3.95029500540499e-5*std::pow(-3.88375997543335*x_19 - 6.13335990905762, 2) + 0.000685022769200075*std::pow(-0.866319835186005*x_24 - 1.30367994308472, 2) + 4.48014087958165e-5*std::pow(-6.56744050979614*x_27 - 9.54936027526855, 2) + 1.61051976706135e-5*std::pow(-4.51200008392334*x_38 - 6.96360015869141, 2) + 2.50532255616036e-5*std::pow(-5.81879997253418*x_4 - 9.82336044311523, 2) - 6.5660813353228e-5*std::pow(-3.90320014953613*x_4 - 6.1637601852417, 2) + 6.23490282658541e-6*std::pow(-5.71783971786499*x_43 - 8.27400016784668, 2) - 2.85976847767815e-5*std::pow(-5.93743944168091*x_5 - 9.30079936981201, 2) - 1.48004345635644e-5*std::pow(-4.35264015197754*x_55 - 6.33048009872437, 2) + 3.58307284136373e-5*std::pow(-3.86879992485046*x_6 - 6.51087999343872, 2) + 1.53001010039693e-5*std::pow(-5.42744016647339*x_60 - 8.43583965301514, 2) + 1.88056818572056e-5*std::pow(-6.62088012695313*x_69 - 9.43920040130615, 2) + 1.36426159536785e-5*std::pow(-5.21744012832642*x_7 - 9.23895931243896, 2) - 5.21478634552728e-5*std::pow(-5.09847974777222*x_7 - 7.94231986999512, 2) - 5.1878333968172e-5*std::pow(-3.91991996765137*x_7 - 6.46479988098145, 2) + 1.15806972585335e-5*std::pow(-5.8854398727417*x_71 - 9.54551982879639, 2) - 1.59240516960385e-5*std::pow(-5.71959972381592*x_71 - 8.97583961486816, 2) + 1.00932135135331e-5*std::pow(-4.14160013198853*x_71 - 6.69736003875732, 2) - 6.98152841586769e-6*std::pow(-6.52383947372437*x_77 - 9.1627197265625, 2) + 1.24691292972158e-5*std::pow(-7.06584024429321*x_78 - 9.41096019744873, 2) + 7.36628317705522e-6*std::pow(-6.66368007659912*x_78 - 9.21712017059326, 2) + 1.95300692822728e-5*std::pow(-4.71984004974365*x_80 - 6.09327983856201, 2) + 2.46355719853659e-5*std::pow(-3.69936013221741*x_80 - 6.42208003997803, 2) + 7.49942268350748e-5*std::pow(-1.82767987251282*x_80 - 2.43895983695984, 2) - 2.14883495835255e-5*std::pow(-7.45847988128662*x_81 - 9.67831993103027, 2) + 1.38043476139177e-5*std::pow(-7.05999994277954*x_81 - 9.27960014343262, 2) - 6.92155946281724e-6*std::pow(-9.20399951934814*x_82 - 9.99767971038818, 2) - 0.000170665120978203*std::pow(-1.03719985485077*x_84 - 2.28391981124878, 2) + 1.63464806792266e-5*std::pow(-5.27831983566284*x_85 - 8.4093599319458, 2) + 2.9274515123219e-6*std::pow(-8.02295970916748*x_86 - 9.42399978637695, 2) - 1.20999628348967e-5*std::pow(-6.90776014328003*x_86 - 7.71479988098145, 2) + 6.62307774200982e-6*std::pow(-7.40399980545044*x_87 - 9.99079990386963, 2) + 1.93367842465639e-5*std::pow(-5.18376016616821*x_87 - 7.56544017791748, 2) + 1.00637840486769e-5*std::pow(-5.38815975189209*x_88 - 7.58616018295288, 2) - 8.29834606385369e-6*std::pow(-7.48543977737427*x_89 - 9.05047988891602, 2) - 3.13686495999713e-5*std::pow(-5.88768005371094*x_90 - 8.31655979156494, 2) - 0.000745316036045551*std::pow(-0.0942358533173571*x_10 + 0.00315592533704974*x_104 + 0.0170396676991918*x_105 + 0.0127101728752613*x_106 - 0.0280013953883169*x_11 + 0.034755757327761*x_113 + 0.00208188470487628*x_115 + 0.00868491975467766*x_116 + 0.222086425443507*x_13 - 0.0953476802879338*x_14 + 0.0739271919793334*x_16 - 0.0033603745848493*x_17 + 0.081725302002515*x_19 - 0.0853436470498087*x_2 + 0.296407351216268*x_20 + 0.0493324106700985*x_25 + 0.00831968201953168*x_27 + 0.00146817445344262*x_30 + 0.495828589908569*x_31 - 0.00136929362905191*x_39 + 0.0519246591792096*x_4 - 0.0333196627343418*x_44 - 0.0790186674159647*x_47 + 0.0284268926843312*x_5 - 0.00638379252356183*x_52 - 0.0139237763031158*x_54 - 0.0153630959512116*x_56 + 0.123509689614058*x_58 - 0.0330092732706274*x_6 + 0.121489448502457*x_61 + 0.145513297684017*x_62 + 0.013937529259491*x_63 + 0.0070770778343049*x_65 - 0.0243225952452271*x_68 + 0.14120408761584*x_7 - 0.0116913542879798*x_70 + 0.0678737306454785*x_72 - 0.0908196690214384*x_76 - 0.0355559208379727*x_78 - 0.010845474723723*x_8 + 0.0127190821043147*x_81 - 0.0316228111737776*x_86 - 0.00171993816640635*x_87 - 0.00772090839892076*x_88 + 0.0528756293183382*x_90 + 0.00443173749591224*x_92 - 0.00630151721494521*std::pow(-4.37183952331543*x_18 - 6.95983982086182, 2) - 0.00137831481713191*std::pow(-5.80399990081787*x_22 - 9.99647998809814, 2) - 0.00154615036832528*std::pow(-4.18495988845825*x_24 - 7.37408018112183, 2) - 0.000617994012560297*std::pow(-5.41200017929077*x_64 - 9.21903991699219, 2) + 0.000883483200124213*std::pow(-6.89007997512817*x_66 - 9.33463954925537, 2) + 0.000903402667517983*std::pow(-6.25472021102905*x_71 - 9.68151950836182, 2) + 0.00251169004905405*std::pow(-5.3120002746582*x_73 - 7.55503988265991, 2) - 0.00535096260991175*std::pow(-1.42991983890533*x_75 - 1.61055982112885, 2) - 0.00158360094051191*std::pow(-5.15536022186279*x_89 - 6.94384002685547, 2) + 4.1524702853194*std::sin(0.215440005064011*x_1 - 7.3842396736145) + 1.27513510039705*std::sin(0.414799869060516*x_100 + 5.20456027984619) - 1.71529017308171*std::sin(0.319119840860367*x_101 + 5.146399974823) + 1.26456755762467*std::sin(0.3503198325634*x_102 - 7.41847991943359) - 1.06770018561645*std::sin(0.404639840126038*x_103 - 7.39447975158691) + 0.525080948357697*std::sin(0.426959842443466*x_107 + 5.22248029708862) + 0.813637468892296*std::sin(0.353679835796356*x_108 - 7.44871950149536) + 1.33540823724923*std::sin(0.323999851942062*x_109 + 5.12048006057739) + 0.780769193724439*std::sin(0.456639856100082*x_110 + 2.05167984962463) + 0.441730475546649*std::sin(0.48431983590126*x_111 + 5.24575996398926) + 1.02147917366165*std::sin(0.380959838628769*x_112 - 7.40343999862671) + 0.602086011454901*std::sin(0.393599838018417*x_114 + 1.99799978733063) - 1.31973775159702*std::sin(0.380719840526581*x_117 + 5.18304014205933) - 1.78091164174361*std::sin(0.365839838981628*x_118 + 5.15880012512207) + 1.33963808196631*std::sin(0.397039830684662*x_119 + 1.97919988632202) - 0.788346639759766*std::sin(0.423359870910645*x_12 + 8.41808032989502) - 0.680522477020702*std::sin(0.4859998524189*x_120 + 2.06983971595764) + 1.30414378932585*std::sin(0.431279867887497*x_15 - 0.968239843845367) - 1.06608251693353*std::sin(0.263439953327179*x_21 - 1.12615990638733) + 1.03727413339232*std::sin(0.310719907283783*x_23 - 4.24408006668091) + 0.597800454948128*std::sin(0.326479852199554*x_26 + 8.31744003295898) + 0.757613801939556*std::sin(0.347439825534821*x_28 + 8.35303974151611) - 0.0653742877600649*std::sin(1.04367983341217*x_29 + 6.00735950469971) - 2.40415997671676*std::sin(0.338559836149216*x_3 + 8.35519981384277) + 2.99898867483375*std::sin(0.259839981794357*x_32 + 5.17312002182007) + 2.89162043918986*std::sin(0.279199957847595*x_33 - 1.16039991378784) - 0.949999217316417*std::sin(0.277199953794479*x_34 - 1.12231993675232) - 1.53311825625565*std::sin(0.316399842500687*x_35 - 7.42007970809937) + 1.73724862647828*std::sin(0.363919854164124*x_36 - 4.23432016372681) + 0.870834889823982*std::sin(0.450879871845245*x_37 + 2.03239989280701) + 1.13351068878035*std::sin(0.249279975891113*x_38 + 5.06663990020752) + 1.74367382219793*std::sin(0.315039843320847*x_40 - 4.28247976303101) + 1.12861596068149*std::sin(0.365519851446152*x_41 - 7.41623973846436) + 1.13441364490313*std::sin(0.348079830408096*x_42 - 1.23199987411499) - 1.17440422995048*std::sin(0.356159836053848*x_43 + 5.15208005905151) + 0.702811740795767*std::sin(0.466559857130051*x_45 + 5.24775981903076) - 0.504398774451886*std::sin(0.439439862966537*x_46 - 4.14663982391357) - 0.639046903364545*std::sin(0.509759843349457*x_48 + 8.27455902099609) + 0.2326586376536*std::sin(0.506479859352112*x_49 + 8.28087997436523) + 2.97508549933764*std::sin(0.304159939289093*x_50 - 7.47200012207031) - 1.33147272083363*std::sin(0.352479845285416*x_51 + 5.1418399810791) + 0.649891670375212*std::sin(0.295199930667877*x_53 - 4.27360010147095) + 1.45968210919045*std::sin(0.308479934930801*x_55 - 7.46504020690918) + 1.01639274164052*std::sin(0.41023987531662*x_57 + 5.21224021911621) + 1.37757499302018*std::sin(0.314319908618927*x_59 + 5.13312005996704) - 1.53786478209588*std::sin(0.344799846410751*x_60 - 4.26503992080688) - 3.4382599716746*std::sin(0.202800005674362*x_67 - 7.58416032791138) - 2.74230967907761*std::sin(0.225199997425079*x_69 + 5.02031993865967) + 0.479963445081808*std::sin(0.365679830312729*x_74 + 1.94711983203888) - 0.939979696638488*std::sin(0.31399992108345*x_77 - 7.46776008605957) - 1.89925930182062*std::sin(0.255599975585938*x_79 + 5.07967948913574) + 0.17498126484432*std::sin(0.474159836769104*x_80 + 8.48776054382324) - 1.35350868628541*std::sin(0.326799839735031*x_82 + 5.12800025939941) - 1.33167480583472*std::sin(0.270079970359802*x_83 + 5.10271978378296) - 0.804860266747255*std::sin(0.305039942264557*x_84 + 5.14831972122192) - 2.01310809893789*std::sin(0.265119940042496*x_85 + 5.06559991836548) - 0.657283542268146*std::sin(0.497999846935272*x_9 + 2.30663990974426) - 2.74963318415143*std::sin(0.168240025639534*x_91 + 5.22959995269775) + 1.30289064481076*std::sin(0.394639849662781*x_93 + 1.99383985996246) - 0.776934225472303*std::sin(0.370159834623337*x_94 - 7.40679979324341) - 1.08448075463082*std::sin(0.367199838161469*x_95 + 5.17216014862061) - 0.597933678793027*std::sin(0.368079841136932*x_96 + 5.16943979263306) + 1.68501261971846*std::sin(0.345919847488403*x_97 + 5.16247987747192) - 0.446654517834759*std::sin(0.444959849119186*x_98 + 2.03095984458923) - 0.978051067379965*std::sin(0.310319930315018*x_99 - 7.48432016372681) - 9.95548362857489, 2) - 0.0016535435170336*std::exp(0.82207989692688*x_25) + 0.0174445884612675*std::sin(0.364479839801788*x_1 - 4.37279987335205) - 0.0401396223846816*std::sin(0.301679849624634*x_10 + 5.10400009155273) - 0.0407759282132353*std::sin(0.208000004291534*x_100 + 5.00311994552612) - 0.00761529159104499*std::sin(0.426559865474701*x_100 + 5.22328042984009) - 0.0195894771381367*std::sin(0.319359838962555*x_102 - 4.27135992050171) - 0.0144876676748593*std::sin(0.320079833269119*x_102 - 4.26879978179932) + 0.00337727299754869*std::sin(0.322719842195511*x_102 + 5.12976026535034) + 0.0055433241941019*std::sin(0.336479842662811*x_103 - 7.43991994857788) - 0.00507208231342156*std::sin(0.442559868097305*x_103 + 5.23320007324219) - 0.00710866081310363*std::sin(0.276479959487915*x_104 - 7.50216007232666) + 0.00621453996424089*std::sin(0.431439846754074*x_104 - 7.38263988494873) + 0.0216081839252799*std::sin(0.353279858827591*x_105 - 4.24919986724854) + 0.0073369425872632*std::sin(0.437759846448898*x_105 - 1.18407988548279) + 0.0102365058498583*std::sin(0.281599938869476*x_106 + 5.08271980285645) + 0.00320525328963788*std::sin(0.360079854726791*x_106 + 5.16480016708374) - 0.00738477544410818*std::sin(0.452639847993851*x_106 + 2.046719789505) + 0.0121207187335877*std::sin(0.361199855804443*x_107 + 5.15944004058838) - 0.00637792049285865*std::sin(0.365039855241776*x_107 - 7.41479969024658) + 0.00543850210285692*std::sin(0.382639855146408*x_107 + 5.18391990661621) + 0.00796447041074072*std::sin(0.211359992623329*x_108 + 5.00783967971802) + 0.0216657737842025*std::sin(0.238799974322319*x_108 - 7.55640029907227) - 0.00632661433508452*std::sin(0.301119923591614*x_108 - 4.28095960617065) + 0.0049045769090773*std::sin(0.575359880924225*x_108 - 7.20560026168823) + 0.00233021404652006*std::sin(0.359439849853516*x_109 + 5.17456007003784) - 0.0163422156276732*std::sin(0.3643998503685*x_109 + 5.17935991287231) + 0.0110952768865736*std::sin(0.422879844903946*x_109 + 2.01311993598938) - 0.00265700319227924*std::sin(0.527999877929688*x_109 + 8.36816024780273) + 0.0100692501966964*std::sin(0.300399929285049*x_11 + 8.32439994812012) - 0.0206762076147662*std::sin(0.327679842710495*x_11 - 1.06183981895447) + 0.00924573478760645*std::sin(0.384719848632813*x_110 + 8.17407989501953) + 0.0107848157529723*std::sin(0.390239834785461*x_110 + 5.18304014205933) - 0.00702697863946402*std::sin(0.398719817399979*x_110 + 2.0097599029541) + 0.0063880191236362*std::sin(0.480879843235016*x_111 - 7.34032011032104) - 0.00945262656268226*std::sin(0.352079838514328*x_112 - 7.44328022003174) + 0.0174357253953638*std::sin(0.364639848470688*x_112 + 5.16183996200562) - 0.00162780920937313*std::sin(0.475119858980179*x_112 + 1.8407998085022) + 0.0112844511726609*std::sin(0.366319835186005*x_113 - 7.42911958694458) + 0.01728063056434*std::sin(0.311119943857193*x_114 + 5.11175966262817) - 0.0207892834919549*std::sin(0.373439848423004*x_114 - 7.42952013015747) - 0.0058170624870279*std::sin(0.44159984588623*x_114 - 7.38136005401611) + 0.0127736109680873*std::sin(0.355759829282761*x_115 - 1.24439990520477) - 0.0066021577147357*std::sin(0.36847984790802*x_115 + 8.36911964416504) - 0.00211736483590102*std::sin(0.574719846248627*x_115 - 4.20968008041382) + 0.00489118333924741*std::sin(0.682319819927216*x_116 + 8.42623996734619) - 0.0164102633992167*std::sin(0.306239932775497*x_117 - 4.28335952758789) + 0.00869646418771144*std::sin(0.461359858512878*x_117 - 7.3459997177124) + 0.0113307154487072*std::sin(0.478159844875336*x_117 + 2.04239964485168) - 0.00438756979668702*std::sin(0.334479838609695*x_118 - 4.26528024673462) + 0.0073757151862584*std::sin(0.341599822044373*x_118 - 7.44719982147217) + 0.012245660629644*std::sin(0.372159838676453*x_118 + 1.98983991146088) + 0.0224792604146613*std::sin(0.393759846687317*x_118 + 5.18567991256714) - 0.0301210000991506*std::sin(0.339599847793579*x_119 + 5.15136003494263) + 0.0230396701017592*std::sin(0.359199851751328*x_12 + 5.17248010635376) + 0.0104264367446704*std::sin(0.34639984369278*x_120 + 5.15912008285522) - 0.0199823714676535*std::sin(0.371839851140976*x_120 - 7.41567993164063) + 0.00408154789580265*std::sin(0.426879853010178*x_120 + 2.20191979408264) - 0.0894624436584326*std::sin(0.171840012073517*x_13 + 8.15135955810547) - 0.029044487057019*std::sin(0.212640002369881*x_14 + 5.00903987884521) + 0.00670319595767133*std::sin(0.270879954099655*x_14 + 1.8879998922348) - 0.0204599551643575*std::sin(0.306239932775497*x_14 + 5.15127992630005) + 0.000486458682769077*std::sin(1.49863994121552*x_15 - 2.5971200466156) + 0.00894668494269901*std::sin(0.41951984167099*x_16 - 7.36879968643188) + 0.0521178328135968*std::sin(0.185440003871918*x_18 - 7.60567998886108) - 0.0581433336948408*std::sin(0.258959949016571*x_18 + 5.06335973739624) - 0.00205792813668437*std::sin(0.599039852619171*x_19 - 0.798399865627289) - 0.0141814944251825*std::sin(0.30991992354393*x_21 - 4.27695989608765) + 0.0226979762022808*std::sin(0.325759828090668*x_21 - 4.2579197883606) - 0.00363123502987594*std::sin(0.398319840431213*x_21 - 7.18815994262695) - 0.0125206161608843*std::sin(0.217999994754791*x_23 - 7.5860800743103) + 0.0352105263530623*std::sin(0.271119952201843*x_23 + 5.0798397064209) + 0.00945254636666757*std::sin(0.264239966869354*x_24 + 8.05335998535156) + 0.0137971564831975*std::sin(0.376079827547073*x_24 + 8.37248039245605) + 0.0130007597253891*std::sin(0.320399850606918*x_26 + 8.32015991210938) - 0.0204922966246553*std::sin(0.325119823217392*x_26 - 4.25880002975464) + 0.0278242111271565*std::sin(0.338239848613739*x_26 - 4.26504039764404) - 0.100978471886626*std::sin(0.213039994239807*x_27 - 7.5717601776123) + 0.0200259239300205*std::sin(0.279119938611984*x_27 + 5.103759765625) + 0.000179996892165245*std::sin(1.74143981933594*x_27 - 1.98255980014801) - 0.0161515565196227*std::sin(0.361359834671021*x_28 + 8.34383964538574) - 0.00617262543362094*std::sin(0.417199850082397*x_28 + 8.41736030578613) + 0.00438730389827695*std::sin(0.810399830341339*x_29 + 5.61424016952515) - 0.0299045354855619*std::sin(0.306319922208786*x_3 + 8.31271934509277) - 0.0233695353859664*std::sin(0.349679857492447*x_3 - 4.23496007919312) - 0.00645954045989665*std::sin(0.29751992225647*x_30 - 7.49848031997681) - 0.00885267603419029*std::sin(0.330079823732376*x_30 + 8.34352016448975) + 0.0219483276596249*std::sin(0.20040000975132*x_31 - 7.39463949203491) - 0.0113331546066113*std::sin(0.210400000214577*x_32 - 1.00415980815887) + 0.0447435847167373*std::sin(0.271519958972931*x_32 - 7.43567991256714) + 0.00488813109357209*std::sin(0.311999946832657*x_32 - 4.44504022598267) + 0.0194553980353482*std::sin(0.218399986624718*x_33 - 7.38711977005005) + 0.00849760581679967*std::sin(0.292239934206009*x_33 + 8.22999954223633) + 0.0301955887633077*std::sin(0.357199847698212*x_34 - 7.39351987838745) - 0.00903825291935736*std::sin(0.369359821081161*x_34 + 1.97839987277985) + 0.0123059684710261*std::sin(0.386319845914841*x_34 + 1.9748797416687) + 0.0106725036935068*std::sin(0.272719949483871*x_35 - 1.1399998664856) - 0.0141764683866329*std::sin(0.315359860658646*x_35 + 1.97319984436035) + 0.019990374271727*std::sin(0.316319853067398*x_35 - 1.20743989944458) - 0.00892219473397706*std::sin(0.343759834766388*x_36 - 7.44807958602905) + 0.0141571979526009*std::sin(0.366559833288193*x_36 + 5.16152000427246) - 0.0176852886698486*std::sin(0.367839843034744*x_36 + 5.17136001586914) + 0.00812317759427367*std::sin(0.358239859342575*x_37 + 5.17824029922485) - 0.0143074086993328*std::sin(0.403439849615097*x_37 - 4.20223999023438) + 0.0261349864198976*std::sin(0.165120020508766*x_38 - 7.63992023468018) + 0.015904390097591*std::sin(0.308319836854935*x_38 + 5.11079978942871) - 0.00697286718471186*std::sin(0.271279960870743*x_39 + 8.28528022766113) + 0.0100186608943048*std::sin(0.301999926567078*x_39 + 5.10551977157593) + 0.0149733538416171*std::sin(0.30295991897583*x_39 - 4.30272006988525) + 0.02674625310388*std::sin(0.306399941444397*x_40 + 5.12367963790894) - 0.0143716738401618*std::sin(0.394879847764969*x_40 + 5.19040012359619) + 0.0107157331916965*std::sin(0.330479830503464*x_41 + 5.14264011383057) - 0.0138272009622092*std::sin(0.357199847698212*x_41 - 7.43991994857788) + 0.0252166334327379*std::sin(0.303599923849106*x_42 + 5.09543991088867) - 0.0184124384706404*std::sin(0.358479857444763*x_42 + 1.97983980178833) - 0.00780378898209438*std::sin(0.417839854955673*x_42 - 1.1794399023056) - 0.0164910810529921*std::sin(0.377679854631424*x_43 + 5.18800020217896) - 0.00746658512035086*std::sin(0.29351994395256*x_44 - 4.27183961868286) - 0.00960384142305851*std::sin(0.220559984445572*x_45 + 8.22208023071289) + 0.0216663314213596*std::sin(0.296639919281006*x_45 + 5.11967945098877) - 0.00762361526907062*std::sin(0.388719856739044*x_45 + 1.97711980342865) - 0.0162031572646276*std::sin(0.195199996232986*x_46 + 4.97847986221313) - 0.0344689017522774*std::sin(0.290079951286316*x_46 + 5.11967992782593) - 0.0048188039298561*std::sin(0.44871985912323*x_46 + 5.24927997589111) - 0.0185355099867829*std::sin(0.376559853553772*x_47 + 5.1625599861145) + 0.00181532379284293*std::sin(0.624079823493958*x_47 - 7.38527965545654) - 0.00494140531408448*std::sin(0.589999854564667*x_48 - 7.40863990783691) - 0.0114160516424711*std::sin(0.219999998807907*x_49 - 1.36087989807129) - 0.0101393359830872*std::sin(0.326879858970642*x_49 - 4.26919984817505) - 0.0213267825230643*std::sin(0.352319836616516*x_49 - 4.23863983154297) - 0.000241001372059487*std::sin(1.97479975223541*x_49 - 7.4031195640564) - 0.00928171803824047*std::sin(0.350559860467911*x_50 + 5.15431976318359) - 0.00848724949381928*std::sin(0.375439822673798*x_50 - 4.23304033279419) + 0.00900667913981149*std::sin(0.428159862756729*x_50 - 1.17399990558624) + 0.00668412647524818*std::sin(0.436799854040146*x_50 + 5.22847986221313) - 0.0130855135469235*std::sin(0.276399940252304*x_51 - 4.30975961685181) - 0.00799276107564342*std::sin(0.321599841117859*x_51 - 7.47175979614258) - 0.0389607494838261*std::sin(0.233919993042946*x_52 + 8.23464012145996) - 0.00112033655017287*std::sin(0.71399986743927*x_52 - 1.22463989257813) - 0.0459517229727134*std::sin(0.131200045347214*x_53 - 7.68440008163452) - 0.0181095591035228*std::sin(0.231279999017715*x_53 - 7.54808044433594) + 0.00460472950234883*std::sin(0.334159851074219*x_53 - 1.068079829216) - 0.021950407157698*std::sin(0.198559984564781*x_55 - 4.39231967926025) - 0.01841506825939*std::sin(0.317279845476151*x_55 - 4.28736019134521) + 0.0255203015938265*std::sin(0.203759998083115*x_56 + 5.00360012054443) - 0.00649972510555721*std::sin(0.342239856719971*x_56 + 5.13784027099609) - 0.0230496534967969*std::sin(0.363439828157425*x_56 + 5.15592002868652) + 0.0243988655855302*std::sin(0.229999989271164*x_57 - 4.37119960784912) + 0.00500811939384076*std::sin(0.319519847631454*x_57 - 7.47119998931885) + 0.00856357647251596*std::sin(0.366719841957092*x_57 + 8.35023975372314) + 0.0165484639700802*std::sin(0.373519837856293*x_57 - 4.21056032180786) - 0.0121355975991923*std::sin(0.250159978866577*x_58 - 7.52272033691406) + 0.0157024665570807*std::sin(0.266959935426712*x_58 + 5.07175970077515) + 0.00554916966536095*std::sin(0.389519840478897*x_58 + 1.97375977039337) + 0.00673485723603766*std::sin(0.463439851999283*x_58 - 1.13231992721558) - 0.00698472912340767*std::sin(0.303439915180206*x_59 + 5.13167953491211) + 0.00661847535990197*std::sin(0.307839930057526*x_59 - 7.46871995925903) + 0.0244230246028777*std::sin(0.228319987654686*x_60 + 5.03671979904175) - 0.0171338525338885*std::sin(0.324959844350815*x_62 + 8.3133602142334) - 0.0536639753536003*std::sin(0.206400007009506*x_64 - 4.40303993225098) - 0.0284565716633213*std::sin(0.238079980015755*x_64 - 4.35223960876465) - 0.00939817691301832*std::sin(0.196719989180565*x_65 + 5.00432014465332) - 0.0166190017478211*std::sin(0.273279964923859*x_65 + 5.09200000762939) + 0.0296910318365528*std::sin(0.199680000543594*x_66 + 4.99975967407227) + 0.0180127082382714*std::sin(0.221759989857674*x_66 + 5.03087949752808) + 0.0443517401047428*std::sin(0.201039999723434*x_67 + 5.00600004196167) - 0.0144647525981277*std::sin(0.225759983062744*x_67 + 5.03471994400024) - 0.0128033305032026*std::sin(0.244639977812767*x_67 + 5.04016017913818) - 0.00172119625385768*std::sin(0.343759834766388*x_67 - 4.43192005157471) + 0.0211318102756242*std::sin(0.251279979944229*x_69 + 5.05583953857422) - 0.0276713542590602*std::sin(0.262479960918427*x_69 + 5.07775974273682) - 0.0130893103269944*std::sin(0.269839972257614*x_69 + 5.09832000732422) - 0.110573195176376*std::sin(0.13864004611969*x_70 - 7.66880035400391) + 0.0154685514897068*std::sin(0.289679944515228*x_70 - 7.4759202003479) - 0.0064352331045703*std::sin(0.345999836921692*x_70 - 1.06407976150513) - 0.0103942404999777*std::sin(0.298959940671921*x_71 + 5.11895942687988) + 0.0062854975651216*std::sin(0.34487983584404*x_72 - 1.04951989650726) + 0.0204019515661007*std::sin(0.33111983537674*x_74 - 4.27975988388062) + 0.0153416080561214*std::sin(0.344799846410751*x_74 - 4.25688028335571) + 0.0215788662906569*std::sin(0.207840010523796*x_75 - 7.58039999008179) - 0.0126566447434158*std::sin(0.241279974579811*x_75 - 7.54800033569336) + 0.000130404197858338*std::sin(0.873279869556427*x_75 + 2.20911979675293) + 0.00952929629832883*std::sin(0.358159840106964*x_76 - 4.25072002410889) - 0.0956859739617767*std::sin(0.144800037145615*x_77 - 7.65912008285522) + 0.0161757683990815*std::sin(0.293919950723648*x_77 + 5.11543989181519) - 0.0371443516860445*std::sin(0.255679965019226*x_79 + 5.05535984039307) + 0.0227388066888478*std::sin(0.257119983434677*x_79 + 5.05615997314453) - 0.00334301598298622*std::sin(0.320879846811295*x_79 + 5.12488031387329) - 0.0358441575512379*std::sin(0.266479969024658*x_8 + 5.09807968139648) + 0.0175444186471893*std::sin(0.325599819421768*x_8 - 4.28672027587891) + 0.0295354637665094*std::sin(0.214560002088547*x_82 + 5.02231979370117) - 0.00591427305961148*std::sin(0.275119960308075*x_82 - 7.49600028991699) + 0.0155471293024033*std::sin(0.276319950819016*x_83 + 5.11303997039795) + 0.00650713011161929*std::sin(0.375839829444885*x_83 + 8.19039916992188) + 0.0132379662173326*std::sin(0.410399854183197*x_83 - 7.39120006561279) - 0.00366333674898411*std::sin(0.510559856891632*x_83 + 8.3342399597168) - 0.0159864664318796*std::sin(0.234959989786148*x_84 + 5.02799987792969) - 0.0203995086559497*std::sin(0.319039851427078*x_84 - 4.2947998046875) - 0.00341587986234114*std::sin(0.50791984796524*x_85 - 0.885199844837189) - 0.0290321637890669*std::sin(0.195919990539551*x_87 + 1.79983985424042) - 0.0319666755070837*std::sin(0.242479979991913*x_87 + 5.03991985321045) - 0.0383232236712178*std::sin(0.148960039019585*x_88 - 7.65576028823853) - 0.00593506019451548*std::sin(0.357119828462601*x_89 + 5.16175985336304) - 0.0638517028189169*std::sin(0.12216005474329*x_9 + 8.07327938079834) - 0.00252278398171452*std::sin(0.446799844503403*x_90 - 4.16096019744873) + 0.072835162823804*std::sin(0.179120019078255*x_91 + 5.2279200553894) - 0.00726458492084582*std::sin(0.324799835681915*x_92 + 2.19455981254578) + 0.0425635132033437*std::sin(0.336719840764999*x_92 + 5.20352029800415) + 0.012615837709301*std::sin(0.285359919071198*x_93 + 8.27120018005371) + 0.00403000319339085*std::sin(0.384559839963913*x_93 + 1.77711987495422) + 0.0055815935145743*std::sin(0.343359857797623*x_94 + 1.96759986877441) + 0.0262813618089556*std::sin(0.390079855918884*x_94 - 7.40775966644287) - 0.00794326655915901*std::sin(0.406239867210388*x_94 - 7.39663982391357) - 0.00639401488594907*std::sin(0.381119847297668*x_95 + 5.19063997268677) + 0.0155911538857994*std::sin(0.385119825601578*x_95 - 7.39695978164673) + 0.0207763894148288*std::sin(0.383679836988449*x_96 - 7.40807962417603) - 0.00445928436058532*std::sin(0.406319856643677*x_96 - 7.39271974563599) + 0.00897853482316129*std::sin(0.409599870443344*x_96 - 7.38104009628296) - 0.00930416536122104*std::sin(0.396479845046997*x_97 - 7.4031195640564) - 0.0179265679315536*std::sin(0.352719843387604*x_98 - 4.2403998374939) - 0.0212965311022182*std::sin(0.407839864492416*x_98 + 2.00023984909058) + 0.00920682721006949*std::sin(0.42783984541893*x_99 - 1.18479979038239) - 0.0042321913843993*std::sin(0.45839986205101*x_99 + 2.04295969009399) + 0.341096423323586);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
