
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.133131145092826*x_1 - 0.123303863213652*x_10 + 0.00181935185835336*x_100 - 0.115123470321894*x_101 + 0.000268635591002577*x_102 - 0.0557097053300028*x_103 - 0.00215012751220284*x_104 + 5.62425157249e-5*x_105 - 0.00213459789318538*x_106 - 0.00683896682984861*x_107 - 3.7339628278906e-5*x_108 - 0.0378314898378872*x_109 - 0.00876847169832678*x_11 - 1.47071760718758e-6*x_110 + 1.8922645928628e-5*x_111 - 0.0132504184592127*x_113 + 0.00266419485926116*x_114 + 3.03774582497547e-6*x_115 + 0.0143268477821768*x_116 + 0.0329356660077645*x_117 + 0.00707243302584621*x_118 + 4.61451671981393e-5*x_119 - 0.0157667499372677*x_12 - 1.33611495574461e-6*x_120 + 0.0304579335547268*x_13 + 0.000684766933508044*x_14 - 0.00580335929096986*x_15 + 3.01758687603981e-5*x_16 - 0.00361754500884717*x_17 + 0.00826138132753626*x_18 - 0.054066431162441*x_19 - 0.0074512201795517*x_2 - 0.0263014859028353*x_20 - 0.00526731403170064*x_21 - 0.00820467761339014*x_22 - 0.00207995167946694*x_23 - 0.00482433602742944*x_24 + 0.0499352616912763*x_25 - 0.00427444314292161*x_26 + 0.00463083920296054*x_27 - 0.000933768502934388*x_28 - 0.024548520796822*x_29 + 0.0348813239943503*x_3 + 0.00286804178382546*x_30 - 0.0111763446425594*x_31 + 0.0589024329219971*x_32 + 0.0481122186120095*x_33 + 0.0344148420355526*x_34 - 0.0096033031876006*x_36 + 0.0139117732135109*x_37 + 0.0110571325048673*x_38 - 0.0150214247591648*x_39 - 0.00394873724516855*x_4 + 0.0016317449691257*x_40 - 0.0334994481966187*x_41 - 0.0208039328437827*x_42 - 0.000296278057084862*x_43 + 0.0100895705466495*x_44 - 2.89649712230615e-5*x_45 - 0.00139665346962733*x_46 - 0.0153252760415915*x_47 - 0.0166125569245955*x_48 + 0.00490710162925366*x_49 - 0.0197924315457412*x_5 - 0.00639265674983986*x_50 + 2.07412688045909e-5*x_51 + 0.0024868218969824*x_52 + 2.87434662783649e-5*x_53 + 0.0106878913032913*x_54 + 0.000282650342284597*x_55 - 0.00737249810140634*x_56 - 0.00551305201523171*x_57 + 0.0365570930276992*x_58 + 0.00140660813658198*x_59 - 0.00764678549973521*x_6 + 0.0210119293309694*x_60 - 0.0592856898797714*x_61 + 0.0399195334620834*x_62 + 0.00373707179726258*x_63 + 0.00596620824885692*x_64 + 0.0556741701252934*x_65 + 0.000183297210026417*x_66 + 0.00602486602467033*x_67 + 0.00225741711805706*x_68 - 0.0216301610198393*x_69 - 0.0248377687429351*x_7 + 1.43239642239372e-5*x_70 - 0.000363362099497864*x_71 - 0.00396028562009223*x_72 + 1.29996173583523e-5*x_73 + 0.00156672956824221*x_74 + 0.000653206523988969*x_75 - 0.0188046836527199*x_76 + 0.00588811704648634*x_77 - 0.0010514452901644*x_78 - 0.022387677148151*x_79 + 0.108831757893446*x_8 + 0.00538825974859553*x_80 + 0.0273728329629417*x_81 + 0.0158190385305076*x_82 + 0.00527482621622131*x_83 - 0.000110303576620028*x_84 + 0.0129809404588279*x_85 + 0.000999531434122974*x_86 + 0.00477554723428103*x_87 + 0.000459424049214366*x_88 + 0.00669707226877157*x_89 + 0.0100089211402279*x_9 - 0.00869241647232667*x_90 - 0.00270034760811625*x_91 + 0.00116872603886928*x_92 + 0.039203509540188*x_93 - 0.0157423169011098*x_94 - 0.00013151205053958*x_95 + 0.00478359074948185*x_96 - 0.00180005745852291*x_97 + 0.00288747889887366*x_98 + 5.28750613441231e-5*x_99 + 5.83512215770091e-7*std::pow(-7.87296009063721*x_106 - 9.04559993743896, 2) + 4.71484469027927e-5*std::pow(-7.23343992233276*x_107 - 9.84928035736084, 2) - 0.00041208215843955*std::pow(-3.99151992797852*x_110 - 5.38871955871582, 2) - 2.27741919961576e-5*std::pow(-8.07431983947754*x_116 - 9.47160053253174, 2) + 0.000128461948113894*std::pow(-8.54367923736572*x_120 - 9.14231967926025, 2) + 3.98919007719217e-5*std::pow(-7.97567987442017*x_13 - 9.75928020477295, 2) + 0.00027126683863051*std::pow(-2.19231986999512*x_13 - 3.18535995483398, 2) - 5.32770414320052e-5*std::pow(-6.53927993774414*x_14 - 9.78439998626709, 2) - 1.13642824443543e-7*std::pow(-6.46400022506714*x_14 - 8.68704032897949, 2) - 1.36456579137017e-7*std::pow(-5.62559986114502*x_15 - 7.82880020141602, 2) - 0.000661646041952173*std::pow(-6.89976024627686*x_17 - 9.1307201385498, 2) - 4.18655317223842e-5*std::pow(-6.92984008789063*x_19 - 9.97432041168213, 2) - 7.46118131756192e-5*std::pow(-6.88104009628296*x_23 - 8.10231971740723, 2) + 0.000524179827933384*std::pow(-5.86168003082275*x_27 - 8.08047962188721, 2) - 6.44871263787669e-5*std::pow(-4.25631999969482*x_27 - 5.47039985656738, 2) - 2.06079259983053e-8*std::pow(-7.61320018768311*x_36 - 9.01000022888184, 2) + 3.9546863201723e-5*std::pow(-5.53175973892212*x_52 - 7.57728004455566, 2) + 5.60501531510727e-7*std::pow(-8.06855964660645*x_56 - 7.47832012176514, 2) + 2.40186178031152e-5*std::pow(-7.14911985397339*x_68 - 9.59352016448975, 2) + 6.78677924721222e-5*std::pow(-7.14143991470337*x_68 - 9.17271995544434, 2) - 6.78215489959498e-8*std::pow(-5.12191963195801*x_7 - 7.37095975875854, 2) - 2.05440719893485e-5*std::pow(-4.89592027664185*x_7 - 7.74936008453369, 2) + 8.73888625537792e-6*std::pow(-7.63944053649902*x_70 - 9.65192031860352, 2) + 1.29152630215738e-8*std::pow(-9.15408039093018*x_72 - 9.7540807723999, 2) + 5.92103453787358e-5*std::pow(-6.66584014892578*x_74 - 8.27351951599121, 2) + 6.4686176043937e-5*std::pow(-6.94191980361938*x_77 - 9.79944038391113, 2) + 1.01951849382787e-5*std::pow(-1.50623989105225*x_77 - 2.36735987663269, 2) + 5.08324712397149e-5*std::pow(-7.40000009536743*x_78 - 9.99612045288086, 2) + 2.41799164535981e-5*std::pow(-7.37215995788574*x_78 - 8.56719970703125, 2) + 1.90197045883513e-5*std::pow(-7.31472015380859*x_80 - 9.95207977294922, 2) + 4.11303996655131e-7*std::pow(-7.1406397819519*x_80 - 9.58688068389893, 2) - 1.00816806916337e-5*std::pow(-6.15687990188599*x_84 - 6.77792024612427, 2) - 0.000134708586882161*std::pow(-8.07520008087158*x_88 - 7.66735982894897, 2) + 7.83517407061195e-7*std::pow(-5.88727998733521*x_90 - 8.93711948394775, 2) - 0.000132275688698541*std::pow(-4.83951997756958*x_90 - 7.24056005477905, 2) - 7.4689418110211e-6*std::exp(0.460399866104126*x_1) + 0.000200139992535283*std::exp(1.18103992938995*x_1) + 8.00758928514139e-6*std::exp(1.18375980854034*x_1) - 1.12570691628426e-5*std::exp(0.595759809017181*x_100) + 4.67618235981262e-6*std::exp(1.62599992752075*x_100) - 0.00361256287462785*std::exp(1.66631984710693*x_100) + 0.00644181159555136*std::exp(0.609039843082428*x_104) + 3.16674957100607e-6*std::exp(0.729839861392975*x_104) + 3.41280818212927e-5*std::exp(0.828719913959503*x_104) - 0.00180540768534398*std::exp(0.893679857254028*x_104) + 8.52258983451829e-7*std::exp(0.863839864730835*x_106) - 0.00705563722554584*std::exp(0.912479817867279*x_106) - 0.00187778480864462*std::exp(1.19687986373901*x_106) - 0.000121898389386362*std::exp(0.576399862766266*x_110) - 0.00453762823555031*std::exp(0.783999860286713*x_110) + 0.0695475876429505*std::exp(0.562159836292267*x_112) - 0.00139963759001407*std::exp(1.24383985996246*x_26) + 5.55615324140781e-5*std::exp(0.575999855995178*x_31) + 0.000242116738529711*std::exp(0.60319983959198*x_31) - 0.0241945076363918*std::exp(0.629599869251251*x_31) - 4.27163552942401e-6*std::exp(0.646159827709198*x_31) - 8.66291758842677e-7*std::exp(1.33207988739014*x_50) - 0.00421193105944374*std::exp(0.898319840431213*x_6) - 4.66257536392802e-7*std::exp(1.28559982776642*x_60) - 0.0010180019713734*std::exp(1.3447197675705*x_60) - 0.000114992452591139*std::exp(1.45263981819153*x_60) - 3.55438740952116e-6*std::exp(0.721199870109558*x_70) + 0.000627318100767744*std::exp(0.880959868431091*x_72) + 5.78978725192794e-5*std::exp(0.898639857769012*x_74) - 0.0512197583606323*std::exp(0.675999820232391*x_76) - 1.79779996360859e-6*std::exp(0.759759843349457*x_77) + 0.00142309958492381*std::exp(0.727279841899872*x_81) + 8.40776022505298e-8*std::exp(2.27735996246338*x_81) + 6.35446432757576e-7*std::exp(2.64103984832764*x_81) + 0.00138802974045714*std::exp(0.677599847316742*x_87) - 0.00784980186587688*std::sin(0.347919851541519*x_10 - 4.24720001220703) - 0.0287976081813174*std::sin(0.371759831905365*x_100 + 5.16815996170044) + 0.000958615789569683*std::sin(0.315839856863022*x_101 + 5.13479995727539) - 0.22035072110502*std::sin(0.362959831953049*x_102 - 7.41792011260986) - 0.0851836177081104*std::sin(0.364479839801788*x_102 - 7.41215991973877) - 3.12041451825778e-5*std::sin(0.372399836778641*x_102 - 7.42935991287231) + 1.07371940568081e-5*std::sin(0.353599846363068*x_103 - 4.24520015716553) - 0.143848717628679*std::sin(0.331999838352203*x_105 + 5.13535976409912) + 0.0333139304887867*std::sin(0.368959844112396*x_105 - 7.41703987121582) - 0.0234762160774948*std::sin(0.512159824371338*x_107 + 5.27336025238037) - 0.000240351907681471*std::sin(0.141760036349297*x_108 - 7.67880010604858) - 0.21580983606183*std::sin(0.290719926357269*x_108 - 7.48176002502441) - 0.0229142047142465*std::sin(0.500319838523865*x_108 + 5.28128004074097) + 0.025877069381344*std::sin(0.532639861106873*x_108 + 2.15879988670349) - 0.058195707798731*std::sin(0.234479993581772*x_110 - 7.55600023269653) - 0.0223800694485668*std::sin(0.350399851799011*x_111 + 5.14800024032593) - 0.0286302083842625*std::sin(0.36167985200882*x_111 - 7.41599988937378) - 0.200804018050132*std::sin(0.364639848470688*x_111 - 7.42519998550415) + 9.69513684292745e-6*std::sin(0.411199867725372*x_111 + 8.19527912139893) - 0.0309544523016642*std::sin(0.238559976220131*x_112 - 7.55352020263672) - 0.034560822736969*std::sin(0.42647984623909*x_112 + 5.22016000747681) - 1.0721022222385e-5*std::sin(0.483759850263596*x_112 - 7.34975957870483) - 0.000190739319037452*std::sin(0.561359822750092*x_112 + 2.18031978607178) - 0.0969913863375328*std::sin(0.352079838514328*x_113 + 5.14792013168335) - 0.0930292642778888*std::sin(0.23335999250412*x_114 - 7.55904006958008) - 0.00010173540352058*std::sin(0.335279852151871*x_114 + 5.12943983078003) - 0.0370003623487331*std::sin(0.456959843635559*x_114 + 5.24592018127441) + 0.0868683186787067*std::sin(0.163440018892288*x_115 - 7.64416027069092) + 0.000481159472237713*std::sin(0.368639826774597*x_115 - 7.41511964797974) - 0.0369576968901558*std::sin(0.389999836683273*x_115 + 5.18383979797363) + 0.0510845851245914*std::sin(0.458079844713211*x_115 - 4.15824031829834) + 2.2936760700127e-5*std::sin(0.383359849452972*x_116 + 5.17575979232788) - 5.71318698955271e-5*std::sin(0.291759938001633*x_117 + 5.08567953109741) - 0.000987039715869206*std::sin(0.370319843292236*x_117 + 5.17880010604858) - 0.079918432942556*std::sin(0.399759858846664*x_117 + 5.18656015396118) + 3.35917420680914e-5*std::sin(0.28687995672226*x_118 + 1.89631986618042) + 0.238482840901767*std::sin(0.529999852180481*x_118 - 7.22975969314575) + 0.017229472353272*std::sin(0.331279844045639*x_119 + 5.1526403427124) - 0.0537515457133765*std::sin(0.344959855079651*x_119 + 5.15152025222778) + 0.667495903234517*std::sin(0.345199823379517*x_119 + 5.15088033676147) + 3.53472176672559e-5*std::sin(0.411679863929749*x_119 + 2.01143980026245) - 0.00852029428606405*std::sin(0.413199841976166*x_120 + 5.21072006225586) + 0.0176777447742048*std::sin(0.438319861888885*x_120 - 4.1812801361084) + 1.72929665910419e-5*std::sin(0.783199846744537*x_120 - 4.01696014404297) + 0.603525111146494*std::sin(0.221440002322197*x_14 - 4.37151956558228) - 0.0254917245211445*std::sin(0.384319841861725*x_16 + 5.19271993637085) - 0.134893133070875*std::sin(0.385279834270477*x_16 + 5.19063997268677) + 0.0083504169718282*std::sin(0.414559870958328*x_16 + 5.20528030395508) + 0.20047501818035*std::sin(0.417759865522385*x_2 - 4.17151975631714) - 0.0535096722444317*std::sin(0.447039872407913*x_2 - 4.14039993286133) - 0.0337804828427885*std::sin(0.258479982614517*x_24 - 7.51384019851685) + 0.118942962127505*std::sin(0.270639955997467*x_24 - 7.49720001220703) - 0.000681132681268747*std::sin(0.297439932823181*x_28 + 5.12983989715576) + 0.228698870688247*std::sin(0.305759936571121*x_28 + 5.13399982452393) - 0.0498382722182078*std::sin(0.316559851169586*x_28 - 4.28560018539429) + 0.0494105112724431*std::sin(0.281359940767288*x_3 - 4.31383991241455) + 0.0641491658688829*std::sin(0.2882399559021*x_33 - 1.16303980350494) + 0.000480392270603251*std::sin(0.314479857683182*x_33 - 1.18263983726501) + 0.014259011353842*std::sin(0.341279834508896*x_34 - 7.41287994384766) + 0.0418421827997354*std::sin(0.352959841489792*x_34 + 1.99951982498169) - 2.15578309711804e-5*std::sin(0.311919927597046*x_35 + 8.2792797088623) - 0.0401773791458062*std::sin(0.316639840602875*x_35 - 7.43399953842163) + 0.00102507195795465*std::sin(0.319359838962555*x_35 - 7.43088006973267) - 0.046302546932932*std::sin(0.320079833269119*x_35 - 7.43167972564697) - 0.134208607973093*std::sin(0.320479840040207*x_35 + 1.98279976844788) + 0.000501916468793606*std::sin(0.264559954404831*x_36 - 7.52311992645264) - 0.017504843762457*std::sin(0.300559937953949*x_36 + 5.09175968170166) - 0.0299747892020627*std::sin(0.311679929494858*x_36 + 5.10960006713867) - 5.56814099119009e-5*std::sin(0.202240005135536*x_37 + 4.99927997589111) - 0.0043755473657885*std::sin(0.678639829158783*x_38 + 2.21391987800598) - 0.000313258649777704*std::sin(0.47343984246254*x_39 + 8.44896030426025) + 0.219571875079676*std::sin(0.342319846153259*x_4 + 8.3264799118042) + 0.000120093699759943*std::sin(0.398239850997925*x_4 - 4.21464014053345) + 0.0513882405274174*std::sin(0.243759974837303*x_40 + 1.85207998752594) + 0.0334387195973101*std::sin(0.337839841842651*x_41 - 4.25608015060425) - 0.181044249941225*std::sin(0.198319986462593*x_42 - 7.60856008529663) - 0.0269502948961865*std::sin(0.370559841394424*x_43 - 7.410560131073) + 2.18213023154778e-5*std::sin(0.370959848165512*x_43 - 4.21415996551514) - 0.409466683903825*std::sin(0.37271985411644*x_43 - 7.42679977416992) - 0.339920492173761*std::sin(0.294719934463501*x_45 + 5.10903978347778) - 0.065310792603595*std::sin(0.342879861593246*x_45 - 7.43375968933105) + 0.0207025307006323*std::sin(0.519439876079559*x_45 + 5.34327983856201) + 0.0205043567449753*std::sin(0.367279827594757*x_46 - 4.23912000656128) - 0.000160334831663866*std::sin(0.57127982378006*x_46 + 2.17831993103027) - 0.0252138159383075*std::sin(0.667999863624573*x_46 - 7.14032030105591) + 0.0906552705254059*std::sin(0.356239855289459*x_47 - 4.23776006698608) + 0.0239218773255964*std::sin(0.314479827880859*x_48 - 1.26639986038208) - 0.0253971422417744*std::sin(0.370799839496613*x_48 - 7.42199993133545) + 0.101394544361346*std::sin(0.499119848012924*x_49 + 8.48079967498779) - 0.0180240255629588*std::sin(0.324479848146439*x_51 - 7.46815967559814) + 0.0318698252364585*std::sin(0.344719856977463*x_51 - 4.25576019287109) + 0.155369112113379*std::sin(0.392559856176376*x_51 + 2.00583982467651) + 0.0460679107604678*std::sin(0.256319969892502*x_53 + 5.06504011154175) - 0.23116225208757*std::sin(0.331999838352203*x_53 - 4.27663993835449) + 0.0115646512512665*std::sin(0.430319845676422*x_53 + 8.42768001556396) - 0.000903593899666891*std::sin(0.0974400714039803*x_54 + 4.85640001296997) + 0.015866024670268*std::sin(0.376319825649261*x_55 - 7.40751981735229) + 0.119230468596057*std::sin(0.419439852237701*x_55 + 8.40575981140137) + 0.000730586891476768*std::sin(0.096000075340271*x_56 - 1.48439979553223) - 0.779545645549304*std::sin(0.198959991335869*x_56 + 1.79975986480713) - 0.168234568643603*std::sin(0.32151985168457*x_57 - 4.28575992584229) + 0.000186186414620525*std::sin(0.677679836750031*x_57 - 3.95703983306885) - 0.0176301537488821*std::sin(0.270799964666367*x_58 - 7.50408029556274) + 0.069511619142984*std::sin(0.356159836053848*x_58 + 5.15912008285522) - 0.000392141165588451*std::sin(0.425279855728149*x_58 + 5.21239995956421) + 0.621174717164547*std::sin(0.272079944610596*x_59 - 7.50024032592773) + 3.34948319260432e-5*std::sin(0.396159827709198*x_59 - 4.19447994232178) + 0.0219824572868049*std::sin(0.403359860181808*x_59 - 4.1878399848938) + 0.4548784133498*std::sin(0.133280038833618*x_63 - 7.67183971405029) + 0.0129304725927784*std::sin(0.405439853668213*x_63 + 5.19360017776489) + 7.53017499836379e-5*std::sin(0.202399998903275*x_64 - 4.39472007751465) + 0.0753456593531499*std::sin(0.229839980602264*x_64 - 4.35567998886108) - 0.580881117616221*std::sin(0.294319927692413*x_64 - 4.28071975708008) + 0.403855780432879*std::sin(0.199039995670319*x_66 + 4.99455976486206) - 0.11629595108352*std::sin(0.165360018610954*x_67 - 4.45287990570068) - 0.0897763249801468*std::sin(0.220559984445572*x_67 - 7.56264019012451) + 0.000295000596365527*std::sin(0.289759933948517*x_67 - 7.48559999465942) - 0.396056248725572*std::sin(0.246639966964722*x_70 + 5.05167961120605) + 0.00283541124396242*std::sin(0.760799884796143*x_70 + 2.37687993049622) - 0.483111675748872*std::sin(0.101840071380138*x_71 - 7.71872043609619) - 0.619188689699678*std::sin(0.218639999628067*x_71 + 5.03167963027954) + 0.116077715044682*std::sin(0.172000005841255*x_72 - 7.62408018112183) + 0.000135381840526768*std::sin(0.417839854955673*x_72 - 0.988559782505035) + 0.144131486374319*std::sin(0.186880007386208*x_73 + 4.96799993515015) - 4.50298607643367e-5*std::sin(0.214399993419647*x_73 + 8.20792007446289) - 0.261149148195538*std::sin(0.252239972352982*x_73 + 5.07247972488403) - 0.0103581423494456*std::sin(0.510879814624786*x_73 + 2.10727977752686) + 0.206743880497841*std::sin(0.12896004319191*x_74 - 7.67944049835205) + 0.469786698251112*std::sin(0.321839839220047*x_75 + 5.12048006057739) - 1.06949933092582e-5*std::sin(0.450239837169647*x_75 - 7.35103988647461) - 0.0297231436742651*std::sin(0.280479967594147*x_76 + 5.09592008590698) + 7.07947363050114e-5*std::sin(0.379359841346741*x_76 - 4.20864009857178) + 0.000228382942072973*std::sin(0.612719833850861*x_76 - 3.99183988571167) - 0.0253768435607228*std::sin(0.14144004881382*x_79 - 4.48799991607666) - 0.000777332995034481*std::sin(0.324319839477539*x_79 - 4.27648019790649) - 0.0595843325007306*std::sin(0.344319850206375*x_79 + 5.13976001739502) - 2.39989145330226e-5*std::sin(0.428879857063293*x_79 - 1.18207991123199) - 0.0465860248031846*std::sin(0.297279924154282*x_81 - 7.47096014022827) - 0.146281565517352*std::sin(0.23463998734951*x_82 + 5.0479998588562) - 0.393034049360889*std::sin(0.296399921178818*x_83 - 7.48288011550903) + 5.26308928187238e-5*std::sin(0.281279951334*x_84 - 7.50392007827759) + 0.0534697638451515*std::sin(0.285679936408997*x_84 + 5.08895969390869) + 0.137707674333286*std::sin(0.324639827013016*x_84 - 1.08567988872528) - 0.0533887629608183*std::sin(0.184720009565353*x_85 + 1.77711987495422) - 0.00180815549213832*std::sin(0.202799841761589*x_85 - 1.36799991130829) + 5.58111620818598e-5*std::sin(0.213839992880821*x_85 + 5.00920009613037) - 0.00126783463896791*std::sin(0.271919965744019*x_86 + 5.07535982131958) - 2.08609743324781e-5*std::sin(0.294719934463501*x_86 - 7.4986400604248) + 0.452423241475846*std::sin(0.310959845781326*x_86 - 4.30808019638062) - 0.0435576063850984*std::sin(0.434079855680466*x_86 + 5.24151992797852) - 0.0781653516071024*std::sin(0.150880038738251*x_87 + 4.91951942443848) + 3.9512946449067e-5*std::sin(0.306479841470718*x_87 - 4.31288003921509) + 1.28841090394179e-5*std::sin(0.950239837169647*x_87 - 3.83208012580872) - 0.16801074691466*std::sin(0.191359996795654*x_88 - 7.60824012756348) + 0.000359308441559561*std::sin(0.212960004806519*x_88 - 7.57991981506348) + 0.136083076761901*std::sin(0.204080000519753*x_89 - 4.40327978134155) - 2.58374687406013e-5*std::sin(0.285919934511185*x_89 - 7.49544048309326) - 0.000118280692663206*std::sin(0.274079948663712*x_90 - 7.50888013839722) + 2.87451918885699e-5*std::sin(0.361039847135544*x_92 + 1.97879981994629) + 0.000770017095453393*std::sin(0.362799853086472*x_92 + 1.98575985431671) - 0.0627361487641579*std::sin(0.363679856061935*x_92 + 2.00567984580994) - 0.203864933332187*std::sin(0.369039833545685*x_92 + 2.00383973121643) + 0.0859651617677637*std::sin(0.270719945430756*x_93 - 1.36999988555908) - 0.10374539049303*std::sin(0.343679845333099*x_93 + 1.97367978096008) + 0.000575249284152091*std::sin(0.365119844675064*x_95 + 5.18239974975586) + 0.15951988217803*std::sin(0.376399844884872*x_95 + 1.9883998632431) - 0.0509515106043623*std::sin(0.381439834833145*x_95 - 7.42175960540771) - 3.44654656764723e-6*std::sin(0.43615984916687*x_95 + 5.22552013397217) + 0.013837252477452*std::sin(0.403999865055084*x_96 - 7.39807987213135) + 0.000205536569468198*std::sin(0.421199858188629*x_96 + 5.20864009857178) - 1.9346464876975*std::sin(0.114480063319206*x_97 + 1.71391987800598) - 4.3831230225469e-6*std::sin(0.437599837779999*x_97 + 5.21184015274048) + 0.0936239129074519*std::sin(0.363839834928513*x_98 + 5.17519998550415) + 0.000550003717742793*std::sin(0.42375984787941*x_98 + 2.02567982673645) - 0.464664032227139*std::sin(0.366159856319427*x_99 - 7.4347996711731) - 0.0445107448637216*std::sin(0.376159846782684*x_99 + 1.98311984539032) - 0.0297666905794845*std::sin(0.406079858541489*x_99 + 5.20360040664673) + 3.11025693400531e-5*std::sin(0.441999852657318*x_99 - 4.16584014892578) + 0.557911759440076 - 8.31896794411558e-6*std::exp(-1.2125598192215*x_9));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0459790716249306*x_1 - 0.0412883709297736*x_10 + 0.00705606213754026*x_100 - 0.130753794780055*x_101 + 0.00073744012266651*x_102 - 0.0316930665812394*x_103 - 0.000782264859158163*x_104 - 0.000456308047229594*x_105 - 0.0082786929333233*x_106 - 0.00180985991440111*x_107 - 9.09740842733627e-5*x_108 - 0.0338590238029663*x_109 + 0.0159249420899708*x_11 - 0.000396495836878613*x_110 + 4.6103040247953e-5*x_111 + 0.00270485419409038*x_113 + 0.000930810221680654*x_114 + 0.000818956383748891*x_115 + 0.0266514472253749*x_116 + 0.00964290291979266*x_117 + 0.0211048573655649*x_118 + 0.000112427855417712*x_119 - 0.00807121096929598*x_12 - 0.000360207843405809*x_120 + 0.0113893990919298*x_13 + 0.0018546893716864*x_14 - 0.00491576772770666*x_15 + 0.000175156741587266*x_16 - 0.0112088852960208*x_17 + 0.000477796591709963*x_18 - 0.0288622891612721*x_19 - 0.027756238934554*x_2 - 0.00671134513647267*x_20 - 0.0377066731977454*x_21 - 0.0175817456284781*x_22 + 0.00277511618990738*x_23 - 0.00175717078392947*x_24 - 0.00474052601043124*x_25 - 0.0176226329789471*x_26 + 0.012849940859986*x_27 - 0.00355837569900419*x_28 - 0.00480516386447741*x_29 + 0.0188675277778544*x_3 + 0.0223435165560492*x_30 - 0.0305779573068646*x_31 + 0.0646855175783745*x_32 + 0.0402091982027504*x_33 + 0.0118009770880516*x_34 - 0.00349389818644059*x_36 - 0.00503444998951748*x_37 + 0.0201732696551133*x_38 + 0.00154902088787206*x_39 - 0.0167613131098212*x_4 + 0.00395155101709134*x_40 - 0.0184183610499695*x_41 - 0.000360862207787121*x_42 - 0.000814187659607026*x_43 - 0.0135060491233136*x_44 - 9.26414232037071e-5*x_45 - 0.0038407403396145*x_46 + 0.0186882774607284*x_47 - 0.0067783612661297*x_48 + 0.0158043306866705*x_49 - 0.0395378431977631*x_5 - 0.00110847174825381*x_50 - 0.00133324473037982*x_51 + 0.01270253840848*x_52 + 0.000686104157470372*x_53 - 0.00730582360912116*x_54 + 0.00154498164170162*x_55 - 0.0261524383205594*x_56 - 0.0245719506862948*x_57 + 0.0116506816767577*x_58 + 0.00384136680859847*x_59 - 0.00104699826756382*x_6 + 0.00771099141458218*x_60 - 0.0280539637812664*x_61 + 0.0395072043210642*x_62 + 0.00214570989322396*x_63 + 0.0163007188181716*x_64 - 0.0253687560033305*x_65 + 0.00129374100520201*x_66 + 0.00337469865407615*x_67 + 0.000763511849070758*x_68 - 0.0131515856085378*x_69 - 0.00884788016110797*x_7 + 3.48988350581212e-5*x_70 - 0.00262988939022607*x_71 - 0.00144084118511353*x_72 + 3.16722029541014e-5*x_73 + 0.00139855814288302*x_74 + 0.00262103129885726*x_75 - 0.0729309263192608*x_76 + 0.00723695310372732*x_77 - 0.00295455638667651*x_78 - 0.00814514163080233*x_79 + 0.00812522866569612*x_8 - 0.000577857131190684*x_80 + 0.00995885369634555*x_81 + 0.00123392771305655*x_82 + 0.0170915579828085*x_83 - 0.000268743084428417*x_84 + 0.0169505781669051*x_85 + 0.0038765211221867*x_86 + 0.0017374517387579*x_87 + 0.000141356734096843*x_88 - 0.00879991504230089*x_89 - 0.0207885169900887*x_9 - 0.00127478431845859*x_90 + 0.0121978861215473*x_91 + 0.00319757989422398*x_92 + 0.0115963740189703*x_93 - 0.021175199325083*x_94 - 0.000510048232936358*x_95 - 0.00410703715807161*x_96 - 0.00570461722019008*x_97 + 0.011494811670631*x_98 + 0.000128824535979564*x_99 + 1.42166625482969e-6*std::pow(-7.87296009063721*x_106 - 9.04559993743896, 2) + 0.000128995950159641*std::pow(-7.23343992233276*x_107 - 9.84928035736084, 2) - 0.000149924778788141*std::pow(-3.99151992797852*x_110 - 5.38871955871582, 2) - 8.83260228742125e-5*std::pow(-8.07431983947754*x_116 - 9.47160053253174, 2) + 4.67373526352135e-5*std::pow(-8.54367923736572*x_120 - 9.14231967926025, 2) + 0.000154714289783411*std::pow(-7.97567987442017*x_13 - 9.75928020477295, 2) + 0.000742173409616002*std::pow(-2.19231986999512*x_13 - 3.18535995483398, 2) - 0.000206626394516548*std::pow(-6.53927993774414*x_14 - 9.78439998626709, 2) - 3.0637361355289e-5*std::pow(-6.46400022506714*x_14 - 8.68704032897949, 2) - 3.67878002399028e-5*std::pow(-5.62559986114502*x_15 - 7.82880020141602, 2) - 0.000240721745516387*std::pow(-6.89976024627686*x_17 - 9.1307201385498, 2) - 0.000162368698444988*std::pow(-6.92984008789063*x_19 - 9.97432041168213, 2) - 0.000289369858581507*std::pow(-6.88104009628296*x_23 - 8.10231971740723, 2) + 0.000190708437962249*std::pow(-5.86168003082275*x_27 - 8.08047962188721, 2) - 0.000250102897199786*std::pow(-4.25631999969482*x_27 - 5.47039985656738, 2) - 5.55576191180287e-6*std::pow(-7.61320018768311*x_36 - 9.01000022888184, 2) + 0.00015337611733264*std::pow(-5.53175973892212*x_52 - 7.57728004455566, 2) + 1.36560313836364e-6*std::pow(-8.06855964660645*x_56 - 7.47832012176514, 2) + 9.31523272414166e-5*std::pow(-7.14911985397339*x_68 - 9.59352016448975, 2) + 0.000185683112600262*std::pow(-7.14143991470337*x_68 - 9.17271995544434, 2) - 1.82842455248605e-5*std::pow(-5.12191963195801*x_7 - 7.37095975875854, 2) - 7.96768628615588e-5*std::pow(-4.89592027664185*x_7 - 7.74936008453369, 2) + 3.38923579557896e-5*std::pow(-7.63944053649902*x_70 - 9.65192031860352, 2) + 3.48187034357927e-6*std::pow(-9.15408039093018*x_72 - 9.7540807723999, 2) + 0.000161996741423059*std::pow(-6.66584014892578*x_74 - 8.27351951599121, 2) + 0.000250874879155584*std::pow(-6.94191980361938*x_77 - 9.79944038391113, 2) + 2.48394977804706e-5*std::pow(-1.50623989105225*x_77 - 2.36735987663269, 2) + 0.000197145524119113*std::pow(-7.40000009536743*x_78 - 9.99612045288086, 2) + 8.79719869248652e-6*std::pow(-7.37215995788574*x_78 - 8.56719970703125, 2) + 5.20370240442583e-5*std::pow(-7.31472015380859*x_80 - 9.95207977294922, 2) + 1.00209900790076e-6*std::pow(-7.1406397819519*x_80 - 9.58688068389893, 2) - 3.91001691533111e-5*std::pow(-6.15687990188599*x_84 - 6.77792024612427, 2) - 4.90100206367795e-5*std::pow(-8.07520008087158*x_88 - 7.66735982894897, 2) + 1.90895790625477e-6*std::pow(-5.88727998733521*x_90 - 8.93711948394775, 2) - 0.000513009880116086*std::pow(-4.83951997756958*x_90 - 7.24056005477905, 2) - 0.00201357780683778*std::exp(0.460399866104126*x_1) + 0.000547573678413214*std::exp(1.18103992938995*x_1) + 1.9509650632073e-5*std::exp(1.18375980854034*x_1) - 0.00303483213684845*std::exp(0.595759809017181*x_100) + 1.13930273997808e-5*std::exp(1.62599992752075*x_100) - 0.00131433181161684*std::exp(1.66631984710693*x_100) + 0.0176244958658081*std::exp(0.609039843082428*x_104) + 0.000853734948983242*std::exp(0.729839861392975*x_104) + 8.31494884873415e-5*std::exp(0.828719913959503*x_104) - 0.00700198191619161*std::exp(0.893679857254028*x_104) + 0.000229763441485712*std::exp(0.863839864730835*x_106) - 0.00256699987753658*std::exp(0.912479817867279*x_106) - 0.00513753159432503*std::exp(1.19687986373901*x_106) - 0.000296992628474741*std::exp(0.576399862766266*x_110) - 0.0124147390670754*std::exp(0.783999860286713*x_110) + 0.0253029801923535*std::exp(0.562159836292267*x_112) - 0.00050921970720848*std::exp(1.24383985996246*x_26) + 0.000135369840707574*std::exp(0.575999855995178*x_31) + 0.000939010639289115*std::exp(0.60319983959198*x_31) - 0.00880250729371519*std::exp(0.629599869251251*x_31) - 0.00115160496875956*std::exp(0.646159827709198*x_31) - 0.000233546585846758*std::exp(1.33207988739014*x_50) - 0.0163352938784305*std::exp(0.898319840431213*x_6) - 0.000125699978833153*std::exp(1.28559982776642*x_60) - 0.00394815611568969*std::exp(1.3447197675705*x_60) - 0.000314613983229697*std::exp(1.45263981819153*x_60) - 0.00095823957205753*std::exp(0.721199870109558*x_70) + 0.00171631304479053*std::exp(0.880959868431091*x_72) + 0.000141062088097779*std::exp(0.898639857769012*x_74) - 0.0186349027360919*std::exp(0.675999820232391*x_76) - 0.000484675098487765*std::exp(0.759759843349457*x_77) + 0.00551926173764891*std::exp(0.727279841899872*x_81) + 2.26667710403083e-5*std::exp(2.27735996246338*x_81) + 1.54819852230701e-6*std::exp(2.64103984832764*x_81) + 0.00538324901390085*std::exp(0.677599847316742*x_87) - 0.0304441878456305*std::sin(0.347919851541519*x_10 - 4.24720001220703) - 0.0787889119090805*std::sin(0.371759831905365*x_100 + 5.16815996170044) + 0.00233556673287385*std::sin(0.315839856863022*x_101 + 5.13479995727539) - 0.0801685596934759*std::sin(0.362959831953049*x_102 - 7.41792011260986) - 0.330370893837382*std::sin(0.364479839801788*x_102 - 7.41215991973877) - 0.00841243322156675*std::sin(0.372399836778641*x_102 - 7.42935991287231) + 0.002894677212319*std::sin(0.353599846363068*x_103 - 4.24520015716553) - 0.0523354062478807*std::sin(0.331999838352203*x_105 + 5.13535976409912) + 0.129202695177021*std::sin(0.368959844112396*x_105 - 7.41703987121582) - 0.0910487098119928*std::sin(0.512159824371338*x_107 + 5.27336025238037) - 0.0647973005258116*std::sin(0.141760036349297*x_108 - 7.67880010604858) - 0.0785164833498151*std::sin(0.290719926357269*x_108 - 7.48176002502441) - 0.0888690395723543*std::sin(0.500319838523865*x_108 + 5.28128004074097) + 0.0707984540630904*std::sin(0.532639861106873*x_108 + 2.15879988670349) - 0.225702647061153*std::sin(0.234479993581772*x_110 - 7.55600023269653) - 0.0612308254630044*std::sin(0.350399851799011*x_111 + 5.14800024032593) - 0.111037635981487*std::sin(0.36167985200882*x_111 - 7.41599988937378) - 0.0730570284817421*std::sin(0.364639848470688*x_111 - 7.42519998550415) + 0.00261374541067755*std::sin(0.411199867725372*x_111 + 8.19527912139893) - 0.120051840368993*std::sin(0.238559976220131*x_112 - 7.55352020263672) - 0.0945567979459823*std::sin(0.42647984623909*x_112 + 5.22016000747681) - 0.00289031739164906*std::sin(0.483759850263596*x_112 - 7.34975957870483) - 0.000464716326438626*std::sin(0.561359822750092*x_112 + 2.18031978607178) - 0.376165416085712*std::sin(0.352079838514328*x_113 + 5.14792013168335) - 0.360798966038677*std::sin(0.23335999250412*x_114 - 7.55904006958008) - 0.0274271986423095*std::sin(0.335279852151871*x_114 + 5.12943983078003) - 0.101231264462778*std::sin(0.456959843635559*x_114 + 5.24592018127441) + 0.237667665487122*std::sin(0.163440018892288*x_115 - 7.64416027069092) + 0.00117229454051659*std::sin(0.368639826774597*x_115 - 7.41511964797974) - 0.143334454256329*std::sin(0.389999836683273*x_115 + 5.18383979797363) + 0.0185857236656166*std::sin(0.458079844713211*x_115 - 4.15824031829834) + 0.00618360049858398*std::sin(0.383359849452972*x_116 + 5.17575979232788) - 0.0154023780336628*std::sin(0.291759938001633*x_117 + 5.08567953109741) - 0.00240481864527207*std::sin(0.370319843292236*x_117 + 5.17880010604858) - 0.309950725687496*std::sin(0.399759858846664*x_117 + 5.18656015396118) + 0.00905611370830599*std::sin(0.28687995672226*x_118 + 1.89631986618042) + 0.0867654336270172*std::sin(0.529999852180481*x_118 - 7.22975969314575) + 0.0471390322048541*std::sin(0.331279844045639*x_119 + 5.1526403427124) - 0.20846668268209*std::sin(0.344959855079651*x_119 + 5.15152025222778) + 0.242850056924038*std::sin(0.345199823379517*x_119 + 5.15088033676147) + 0.00952937843527268*std::sin(0.411679863929749*x_119 + 2.01143980026245) - 0.0233111274977224*std::sin(0.413199841976166*x_120 + 5.21072006225586) + 0.068560276015691*std::sin(0.438319861888885*x_120 - 4.1812801361084) + 4.21324976306376e-5*std::sin(0.783199846744537*x_120 - 4.01696014404297) + 0.219576040671995*std::sin(0.221440002322197*x_14 - 4.37151956558228) - 0.0988655335626225*std::sin(0.384319841861725*x_16 + 5.19271993637085) - 0.0490771627004496*std::sin(0.385279834270477*x_16 + 5.19063997268677) + 0.022846351094682*std::sin(0.414559870958328*x_16 + 5.20528030395508) + 0.0729373309124873*std::sin(0.417759865522385*x_2 - 4.17151975631714) - 0.146399965795959*std::sin(0.447039872407913*x_2 - 4.14039993286133) - 0.131012143077457*std::sin(0.258479982614517*x_24 - 7.51384019851685) + 0.325422392938482*std::sin(0.270639955997467*x_24 - 7.49720001220703) - 0.00165950827052261*std::sin(0.297439932823181*x_28 + 5.12983989715576) + 0.0832058047037795*std::sin(0.305759936571121*x_28 + 5.13399982452393) - 0.136355186680004*std::sin(0.316559851169586*x_28 - 4.28560018539429) + 0.191630682204342*std::sin(0.281359940767288*x_3 - 4.31383991241455) + 0.248792171983646*std::sin(0.2882399559021*x_33 - 1.16303980350494) + 0.0011704253342774*std::sin(0.314479857683182*x_33 - 1.18263983726501) + 0.0390119895511767*std::sin(0.341279834508896*x_34 - 7.41287994384766) + 0.162278143422166*std::sin(0.352959841489792*x_34 + 1.99951982498169) - 0.00581185007266707*std::sin(0.311919927597046*x_35 + 8.2792797088623) - 0.155821471517282*std::sin(0.316639840602875*x_35 - 7.43399953842163) + 0.00249748021037234*std::sin(0.319359838962555*x_35 - 7.43088006973267) - 0.126681607322916*std::sin(0.320079833269119*x_35 - 7.43167972564697) - 0.0488281170386607*std::sin(0.320479840040207*x_35 + 1.98279976844788) + 0.00122286678349215*std::sin(0.264559954404831*x_36 - 7.52311992645264) - 0.0478924355279337*std::sin(0.300559937953949*x_36 + 5.09175968170166) - 0.116252375371112*std::sin(0.311679929494858*x_36 + 5.10960006713867) - 0.0150113435194527*std::sin(0.202240005135536*x_37 + 4.99927997589111) - 0.0119712933722313*std::sin(0.678639829158783*x_38 + 2.21391987800598) - 0.000763221813333801*std::sin(0.47343984246254*x_39 + 8.44896030426025) + 0.079885197951968*std::sin(0.342319846153259*x_4 + 8.3264799118042) + 0.0323764751013104*std::sin(0.398239850997925*x_4 - 4.21464014053345) + 0.140595827632103*std::sin(0.243759974837303*x_40 + 1.85207998752594) + 0.129686669565915*std::sin(0.337839841842651*x_41 - 4.25608015060425) - 0.702150862882478*std::sin(0.198319986462593*x_42 - 7.60856008529663) - 0.104522363026928*std::sin(0.370559841394424*x_43 - 7.410560131073) + 0.00588288022192223*std::sin(0.370959848165512*x_43 - 4.21415996551514) - 0.14897321019153*std::sin(0.37271985411644*x_43 - 7.42679977416992) - 0.123670737863753*std::sin(0.294719934463501*x_45 + 5.10903978347778) - 0.253297353531196*std::sin(0.342879861593246*x_45 - 7.43375968933105) + 0.0566411577446684*std::sin(0.519439876079559*x_45 + 5.34327983856201) + 0.0795228337050665*std::sin(0.367279827594757*x_46 - 4.23912000656128) - 0.000390638984908806*std::sin(0.57127982378006*x_46 + 2.17831993103027) - 0.00917335463216901*std::sin(0.667999863624573*x_46 - 7.14032030105591) + 0.351591814956416*std::sin(0.356239855289459*x_47 - 4.23776006698608) + 0.0654491398535316*std::sin(0.314479827880859*x_48 - 1.26639986038208) - 0.0984987114785483*std::sin(0.370799839496613*x_48 - 7.42199993133545) + 0.0368896209708848*std::sin(0.499119848012924*x_49 + 8.48079967498779) - 0.0699032700886988*std::sin(0.324479848146439*x_51 - 7.46815967559814) + 0.0871943543819081*std::sin(0.344719856977463*x_51 - 4.25576019287109) + 0.0565267854651009*std::sin(0.392559856176376*x_51 + 2.00583982467651) + 0.126039653706263*std::sin(0.256319969892502*x_53 + 5.06504011154175) - 0.0841020383887388*std::sin(0.331999838352203*x_53 - 4.27663993835449) + 0.0448516307899745*std::sin(0.430319845676422*x_53 + 8.42768001556396) - 0.243602998764629*std::sin(0.0974400714039803*x_54 + 4.85640001296997) + 0.0615338124042052*std::sin(0.376319825649261*x_55 - 7.40751981735229) + 0.0433787322818358*std::sin(0.419439852237701*x_55 + 8.40575981140137) + 0.19696144217826*std::sin(0.096000075340271*x_56 - 1.48439979553223) - 0.283616279109989*std::sin(0.198959991335869*x_56 + 1.79975986480713) - 0.0612075285761503*std::sin(0.32151985168457*x_57 - 4.28575992584229) + 0.00045362365280459*std::sin(0.677679836750031*x_57 - 3.95703983306885) - 0.068375701915676*std::sin(0.270799964666367*x_58 - 7.50408029556274) + 0.190180545649176*std::sin(0.356159836053848*x_58 + 5.15912008285522) - 0.000955410781779312*std::sin(0.425279855728149*x_58 + 5.21239995956421) + 0.225997365215564*std::sin(0.272079944610596*x_59 - 7.50024032592773) + 0.00902998736856161*std::sin(0.396159827709198*x_59 - 4.19447994232178) + 0.0852554077647764*std::sin(0.403359860181808*x_59 - 4.1878399848938) + 1.24452610831794*std::sin(0.133280038833618*x_63 - 7.67183971405029) + 0.0501487481179055*std::sin(0.405439853668213*x_63 + 5.19360017776489) + 0.0203008587320044*std::sin(0.202399998903275*x_64 - 4.39472007751465) + 0.292215962376262*std::sin(0.229839980602264*x_64 - 4.35567998886108) - 0.211337645363249*std::sin(0.294319927692413*x_64 - 4.28071975708008) + 0.146931837022479*std::sin(0.199039995670319*x_66 + 4.99455976486206) - 0.318180294266475*std::sin(0.165360018610954*x_67 - 4.45287990570068) - 0.348182966715001*std::sin(0.220559984445572*x_67 - 7.56264019012451) + 0.000718737982981228*std::sin(0.289759933948517*x_67 - 7.48559999465942) - 0.144094191562901*std::sin(0.246639966964722*x_70 + 5.05167961120605) + 0.00775755282591498*std::sin(0.760799884796143*x_70 + 2.37687993049622) - 1.87367055350167*std::sin(0.101840071380138*x_71 - 7.71872043609619) - 0.225274803652925*std::sin(0.218639999628067*x_71 + 5.03167963027954) + 0.450188657228879*std::sin(0.172000005841255*x_72 - 7.62408018112183) + 0.000329843641644468*std::sin(0.417839854955673*x_72 - 0.988559782505035) + 0.558990675258213*std::sin(0.186880007386208*x_73 + 4.96799993515015) - 0.012139755613877*std::sin(0.214399993419647*x_73 + 8.20792007446289) - 0.0950119471859421*std::sin(0.252239972352982*x_73 + 5.07247972488403) - 0.0283393940209812*std::sin(0.510879814624786*x_73 + 2.10727977752686) + 0.801822726401739*std::sin(0.12896004319191*x_74 - 7.67944049835205) + 0.170918991202191*std::sin(0.321839839220047*x_75 + 5.12048006057739) - 0.00288330016710314*std::sin(0.450239837169647*x_75 - 7.35103988647461) - 0.0813211338201312*std::sin(0.280479967594147*x_76 + 5.09592008590698) + 0.0190857973554376*std::sin(0.379359841346741*x_76 - 4.20864009857178) + 0.000556431062022182*std::sin(0.612719833850861*x_76 - 3.99183988571167) - 0.0984199863247785*std::sin(0.14144004881382*x_79 - 4.48799991607666) - 0.00189389023561014*std::sin(0.324319839477539*x_79 - 4.27648019790649) - 0.163019952733681*std::sin(0.344319850206375*x_79 + 5.13976001739502) - 0.00646995021712248*std::sin(0.428879857063293*x_79 - 1.18207991123199) - 0.127457189545123*std::sin(0.297279924154282*x_81 - 7.47096014022827) - 0.567329409716978*std::sin(0.23463998734951*x_82 + 5.0479998588562) - 0.142994647304738*std::sin(0.296399921178818*x_83 - 7.48288011550903) + 0.0141889440854208*std::sin(0.281279951334*x_84 - 7.50392007827759) + 0.146290778278179*std::sin(0.285679936408997*x_84 + 5.08895969390869) + 0.05010115625978*std::sin(0.324639827013016*x_84 - 1.08567988872528) - 0.207059688409528*std::sin(0.184720009565353*x_85 + 1.77711987495422) - 0.00440538103091032*std::sin(0.202799841761589*x_85 - 1.36799991130829) + 0.0150463238548776*std::sin(0.213839992880821*x_85 + 5.00920009613037) - 0.00308894599669363*std::sin(0.271919965744019*x_86 + 5.07535982131958) - 0.0056239820857766*std::sin(0.294719934463501*x_86 - 7.4986400604248) + 0.164601774203797*std::sin(0.310959845781326*x_86 - 4.30808019638062) - 0.119171578099058*std::sin(0.434079855680466*x_86 + 5.24151992797852) - 0.213856753774075*std::sin(0.150880038738251*x_87 + 4.91951942443848) + 0.0106524316383359*std::sin(0.306479841470718*x_87 - 4.31288003921509) + 3.13907790614337e-5*std::sin(0.950239837169647*x_87 - 3.83208012580872) - 0.651602527878993*std::sin(0.191359996795654*x_88 - 7.60824012756348) + 0.000875417296562542*std::sin(0.212960004806519*x_88 - 7.57991981506348) + 0.527776219366763*std::sin(0.204080000519753*x_89 - 4.40327978134155) - 0.00696561239293242*std::sin(0.285919934511185*x_89 - 7.49544048309326) - 0.0318877002593051*std::sin(0.274079948663712*x_90 - 7.50888013839722) + 0.00774951551432755*std::sin(0.361039847135544*x_92 + 1.97879981994629) + 0.0018760658143263*std::sin(0.362799853086472*x_92 + 1.98575985431671) - 0.243312013515909*std::sin(0.363679856061935*x_92 + 2.00567984580994) - 0.0741706584634164*std::sin(0.369039833545685*x_92 + 2.00383973121643) + 0.235196670331958*std::sin(0.270719945430756*x_93 - 1.36999988555908) - 0.402359729615324*std::sin(0.343679845333099*x_93 + 1.97367978096008) + 0.00140153448941022*std::sin(0.365119844675064*x_95 + 5.18239974975586) + 0.0580369291852266*std::sin(0.376399844884872*x_95 + 1.9883998632431) - 0.139400954946184*std::sin(0.381439834833145*x_95 - 7.42175960540771) - 0.000929166387212573*std::sin(0.43615984916687*x_95 + 5.22552013397217) + 0.0536655473461311*std::sin(0.403999865055084*x_96 - 7.39807987213135) + 0.000500768273652606*std::sin(0.421199858188629*x_96 + 5.20864009857178) - 0.703868004864982*std::sin(0.114480063319206*x_97 + 1.71391987800598) - 0.00118166126690356*std::sin(0.437599837779999*x_97 + 5.21184015274048) + 0.0340624900749955*std::sin(0.363839834928513*x_98 + 5.17519998550415) + 0.00134002631721061*std::sin(0.42375984787941*x_98 + 2.02567982673645) - 0.169055249822661*std::sin(0.366159856319427*x_99 - 7.4347996711731) - 0.121779320490598*std::sin(0.376159846782684*x_99 + 1.98311984539032) - 0.115445298496506*std::sin(0.406079858541489*x_99 + 5.20360040664673) + 0.00838504903952414*std::sin(0.441999852657318*x_99 - 4.16584014892578) - 3.71891839232888 - 2.02682920451812e-5*std::exp(-1.2125598192215*x_9));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0898409166024064*x_1 + 0.0814090340723082*x_10 - 0.00197055225522393*x_100 - 0.0083895733296553*x_101 + 0.000255880160946746*x_102 + 0.0365886435061754*x_103 + 0.00145555672573179*x_104 + 0.00144265160204551*x_105 + 0.00231199735944411*x_106 + 0.00308167542963365*x_107 + 4.11056807232456e-5*x_108 + 0.0212729566498339*x_109 + 0.00534526616827058*x_11 + 0.000796160448376346*x_110 - 2.0831172612948e-5*x_111 + 0.0142561204608484*x_113 - 0.00179569029758512*x_114 - 0.00164445782538141*x_115 + 0.00449020869882656*x_116 - 0.0238433078797867*x_117 + 0.00329653801004954*x_118 - 5.0799341000378e-5*x_119 + 0.0231668812533686*x_12 + 0.000723294449627334*x_120 - 0.0212839937322885*x_13 + 0.000485407151263348*x_14 - 0.00223849874253455*x_15 - 0.000238746861671076*x_16 - 0.000775588437482981*x_17 + 0.00449569510032103*x_18 + 0.0317800925430984*x_19 + 0.00571820802570128*x_2 + 0.010355778699041*x_20 + 0.00734815531696565*x_21 + 0.0110877397416533*x_22 + 0.00541914757653981*x_23 + 0.00338414607686138*x_24 - 0.0218607210967368*x_25 + 0.00607658376283124*x_26 + 0.00382801475529573*x_27 + 0.000883085650963828*x_28 + 0.0205290370890724*x_29 - 0.0136730515723011*x_3 + 0.00143931400096613*x_30 - 0.0099634001374668*x_31 - 0.0373703817000457*x_32 - 0.0208152593375883*x_33 - 0.021783027027682*x_34 + 0.00650108073340856*x_36 - 0.00979218444191389*x_37 - 0.00923590268109995*x_38 + 0.0201991300347951*x_39 + 0.00688045531398076*x_4 - 0.00158271892136067*x_40 + 0.019414380960605*x_41 + 0.0244660540092091*x_42 - 0.000287965269465352*x_43 - 0.00417414338931586*x_44 + 7.65186054535956e-5*x_45 - 0.00120533002684087*x_46 + 0.0264710502958031*x_47 + 0.0124910316760433*x_48 + 0.000718993290041275*x_49 + 0.0222664833837189*x_5 + 0.00050138861129206*x_50 + 0.00277542129329156*x_51 + 0.00912781639925957*x_52 - 0.0012774566927334*x_53 - 0.00245803360972471*x_54 - 0.00126750095095521*x_55 + 0.00376669023762919*x_56 + 0.0116553394230024*x_57 - 0.0214350608785712*x_58 + 0.00120708044974025*x_59 + 0.00687014239405611*x_6 - 0.0142378743164698*x_60 + 0.0339986326639278*x_61 - 0.0332368928726673*x_62 - 0.00407809164886719*x_63 + 0.00516874088987769*x_64 - 0.0231482546019758*x_65 - 0.00109003762691842*x_66 - 0.00645373203264761*x_67 - 0.00158685946931808*x_68 + 0.0262918365194941*x_69 + 0.0170194993157159*x_7 - 1.57686706381322e-5*x_70 + 0.00316900518418609*x_71 + 0.00268096675077581*x_72 - 1.4310750944424e-5*x_73 - 0.00272449775362284*x_74 - 0.000890932821678273*x_75 + 0.0203674795562512*x_76 - 0.000617444236496905*x_77 - 0.000874943680138829*x_78 + 0.015155628613448*x_79 - 0.0917442470503717*x_8 - 0.00438971205198165*x_80 - 0.0185303945442394*x_81 - 0.0115170674244803*x_82 + 0.000379104042541718*x_83 + 0.000121428728998257*x_84 - 0.00070267333999785*x_85 - 0.00108259923039894*x_86 - 0.00323286868172116*x_87 + 0.00267638537303273*x_88 - 0.0119389685300401*x_89 - 0.000214259872052452*x_9 + 0.00713258570651976*x_90 + 0.0147842389594276*x_91 + 0.00104188673029902*x_92 - 0.0225980232787796*x_93 + 0.0143108941771268*x_94 + 0.000142441587969928*x_95 - 0.00731327701808727*x_96 - 0.000216713785849951*x_97 - 0.00371425141448481*x_98 - 5.82080082211583e-5*x_99 - 6.42364906806238e-7*std::pow(-7.87296009063721*x_106 - 9.04559993743896, 2) + 4.20315279616373e-5*std::pow(-7.23343992233276*x_107 - 9.84928035736084, 2) + 0.000278964365539533*std::pow(-3.99151992797852*x_110 - 5.38871955871582, 2) + 2.46668807866272e-5*std::pow(-8.07431983947754*x_116 - 9.47160053253174, 2) - 8.69639830738308e-5*std::pow(-8.54367923736572*x_120 - 9.14231967926025, 2) - 4.3207186488064e-5*std::pow(-7.97567987442017*x_13 - 9.75928020477295, 2) + 0.000241826835494084*std::pow(-2.19231986999512*x_13 - 3.18535995483398, 2) + 5.77047225161357e-5*std::pow(-6.53927993774414*x_14 - 9.78439998626709, 2) + 6.15195749486839e-5*std::pow(-6.46400022506714*x_14 - 8.68704032897949, 2) + 7.38696067135434e-5*std::pow(-5.62559986114502*x_15 - 7.82880020141602, 2) + 0.000447909875554603*std::pow(-6.89976024627686*x_17 - 9.1307201385498, 2) + 4.53448394673692e-5*std::pow(-6.92984008789063*x_19 - 9.97432041168213, 2) + 8.08125575294884e-5*std::pow(-6.88104009628296*x_23 - 8.10231971740723, 2) - 0.000354850337810751*std::pow(-5.86168003082275*x_27 - 8.08047962188721, 2) + 6.98464410471987e-5*std::pow(-4.25631999969482*x_27 - 5.47039985656738, 2) + 1.11559251910314e-5*std::pow(-7.61320018768311*x_36 - 9.01000022888184, 2) - 4.28334739711749e-5*std::pow(-5.53175973892212*x_52 - 7.57728004455566, 2) - 6.17033378775918e-7*std::pow(-8.06855964660645*x_56 - 7.47832012176514, 2) - 2.60147267621598e-5*std::pow(-7.14911985397339*x_68 - 9.59352016448975, 2) + 6.05022477806716e-5*std::pow(-7.14143991470337*x_68 - 9.17271995544434, 2) + 3.67146178126274e-5*std::pow(-5.12191963195801*x_7 - 7.37095975875854, 2) + 2.22514227823602e-5*std::pow(-4.89592027664185*x_7 - 7.74936008453369, 2) - 9.46514657932414e-6*std::pow(-7.63944053649902*x_70 - 9.65192031860352, 2) - 6.99156761835322e-6*std::pow(-9.15408039093018*x_72 - 9.7540807723999, 2) + 5.27843746907626e-5*std::pow(-6.66584014892578*x_74 - 8.27351951599121, 2) - 7.00620330805932e-5*std::pow(-6.94191980361938*x_77 - 9.79944038391113, 2) - 1.12234651576345e-5*std::pow(-1.50623989105225*x_77 - 2.36735987663269, 2) - 5.50569920711679e-5*std::pow(-7.40000009536743*x_78 - 9.99612045288086, 2) - 1.63689082726119e-5*std::pow(-7.37215995788574*x_78 - 8.56719970703125, 2) + 1.69555371967091e-5*std::pow(-7.31472015380859*x_80 - 9.95207977294922, 2) - 4.52787870313424e-7*std::pow(-7.1406397819519*x_80 - 9.58688068389893, 2) + 1.09195362799843e-5*std::pow(-6.15687990188599*x_84 - 6.77792024612427, 2) + 9.1192726262672e-5*std::pow(-8.07520008087158*x_88 - 7.66735982894897, 2) - 8.62542501365963e-7*std::pow(-5.88727998733521*x_90 - 8.93711948394775, 2) + 0.000143268689604725*std::pow(-4.83951997756958*x_90 - 7.24056005477905, 2) + 0.0040432480253845*std::exp(0.460399866104126*x_1) + 0.00017841923212937*std::exp(1.18103992938995*x_1) - 8.81522992299989e-6*std::exp(1.18375980854034*x_1) + 0.00609391849821598*std::exp(0.595759809017181*x_100) - 5.14781929938813e-6*std::exp(1.62599992752075*x_100) + 0.00244557132516589*std::exp(1.66631984710693*x_100) + 0.00574269571933617*std::exp(0.609039843082428*x_104) - 0.00171429290437959*std::exp(0.729839861392975*x_104) - 3.7570219622014e-5*std::exp(0.828719913959503*x_104) + 0.00195544922749198*std::exp(0.893679857254028*x_104) - 0.000461363140742787*std::exp(0.863839864730835*x_106) + 0.00477640519442736*std::exp(0.912479817867279*x_106) - 0.00167399288577222*std::exp(1.19687986373901*x_106) + 0.000134192987604655*std::exp(0.576399862766266*x_110) - 0.00404516925987547*std::exp(0.783999860286713*x_110) - 0.0470811421078954*std::exp(0.562159836292267*x_112) + 0.000947502832352865*std::exp(1.24383985996246*x_26) - 6.11654351470227e-5*std::exp(0.575999855995178*x_31) - 0.000262238270704269*std::exp(0.60319983959198*x_31) + 0.016378785963182*std::exp(0.629599869251251*x_31) + 0.00231241350602311*std::exp(0.646159827709198*x_31) + 0.000468959664162743*std::exp(1.33207988739014*x_50) + 0.00456197090734636*std::exp(0.898319840431213*x_6) + 0.000252404545521973*std::exp(1.28559982776642*x_60) + 0.00110260479373564*std::exp(1.3447197675705*x_60) - 0.000102512570486716*std::exp(1.45263981819153*x_60) + 0.00192413734617558*std::exp(0.721199870109558*x_70) + 0.000559236624434788*std::exp(0.880959868431091*x_72) - 6.37374171096705e-5*std::exp(0.898639857769012*x_74) + 0.0346738801996884*std::exp(0.675999820232391*x_76) + 0.000973223695781213*std::exp(0.759759843349457*x_77) - 0.0015413687482189*std::exp(0.727279841899872*x_81) - 4.55146937651725e-5*std::exp(2.27735996246338*x_81) - 6.99537177674968e-7*std::exp(2.64103984832764*x_81) - 0.00150338436340248*std::exp(0.677599847316742*x_87) + 0.00850217328706536*std::sin(0.347919851541519*x_10 - 4.24720001220703) - 0.0256722660663001*std::sin(0.371759831905365*x_100 + 5.16815996170044) - 0.00105530120139343*std::sin(0.315839856863022*x_101 + 5.13479995727539) + 0.149169280567767*std::sin(0.362959831953049*x_102 - 7.41792011260986) + 0.0922629502435959*std::sin(0.364479839801788*x_102 - 7.41215991973877) + 0.016892098182784*std::sin(0.372399836778641*x_102 - 7.42935991287231) - 0.00581248853810853*std::sin(0.353599846363068*x_103 - 4.24520015716553) + 0.0973802564006089*std::sin(0.331999838352203*x_105 + 5.13535976409912) - 0.0360825425569229*std::sin(0.368959844112396*x_105 - 7.41703987121582) + 0.0254272477988403*std::sin(0.512159824371338*x_107 + 5.27336025238037) + 0.130112457791079*std::sin(0.141760036349297*x_108 - 7.67880010604858) + 0.146095269501968*std::sin(0.290719926357269*x_108 - 7.48176002502441) + 0.024818529504891*std::sin(0.500319838523865*x_108 + 5.28128004074097) + 0.0230686870239784*std::sin(0.532639861106873*x_108 + 2.15879988670349) + 0.0630321631962567*std::sin(0.234479993581772*x_110 - 7.55600023269653) - 0.019951208928477*std::sin(0.350399851799011*x_111 + 5.14800024032593) + 0.0310095715900722*std::sin(0.36167985200882*x_111 - 7.41599988937378) + 0.135936886239547*std::sin(0.364639848470688*x_111 - 7.42519998550415) - 0.00524837974211501*std::sin(0.411199867725372*x_111 + 8.19527912139893) + 0.033526975836039*std::sin(0.238559976220131*x_112 - 7.55352020263672) - 0.0308100114143963*std::sin(0.42647984623909*x_112 + 5.22016000747681) + 0.00580373405330297*std::sin(0.483759850263596*x_112 - 7.34975957870483) + 0.000209977172005006*std::sin(0.561359822750092*x_112 + 2.18031978607178) + 0.105052023998097*std::sin(0.352079838514328*x_113 + 5.14792013168335) + 0.100760622901462*std::sin(0.23335999250412*x_114 - 7.55904006958008) + 0.0550735940651337*std::sin(0.335279852151871*x_114 + 5.12943983078003) - 0.0329847930698088*std::sin(0.456959843635559*x_114 + 5.24592018127441) + 0.0774406879838965*std::sin(0.163440018892288*x_115 - 7.64416027069092) - 0.000529688927137555*std::sin(0.368639826774597*x_115 - 7.41511964797974) + 0.0400291304952371*std::sin(0.389999836683273*x_115 + 5.18383979797363) - 0.0345823729231471*std::sin(0.458079844713211*x_115 - 4.15824031829834) - 0.0124166200187369*std::sin(0.383359849452972*x_116 + 5.17575979232788) + 0.030927851091403*std::sin(0.291759938001633*x_117 + 5.08567953109741) + 0.00108659194779942*std::sin(0.370319843292236*x_117 + 5.17880010604858) + 0.0865601931511199*std::sin(0.399759858846664*x_117 + 5.18656015396118) - 0.0181846034180668*std::sin(0.28687995672226*x_118 + 1.89631986618042) - 0.161444054399618*std::sin(0.529999852180481*x_118 - 7.22975969314575) + 0.015359594993105*std::sin(0.331279844045639*x_119 + 5.1526403427124) + 0.0582186613001463*std::sin(0.344959855079651*x_119 + 5.15152025222778) - 0.451870015074603*std::sin(0.345199823379517*x_119 + 5.15088033676147) - 0.0191349151796953*std::sin(0.411679863929749*x_119 + 2.01143980026245) - 0.0075956051800482*std::sin(0.413199841976166*x_120 + 5.21072006225586) - 0.0191468844644545*std::sin(0.438319861888885*x_120 - 4.1812801361084) - 1.90371247978034e-5*std::sin(0.783199846744537*x_120 - 4.01696014404297) - 0.408564157098433*std::sin(0.221440002322197*x_14 - 4.37151956558228) + 0.027610258573156*std::sin(0.384319841861725*x_16 + 5.19271993637085) + 0.0913176572003337*std::sin(0.385279834270477*x_16 + 5.19063997268677) + 0.00744416428321287*std::sin(0.414559870958328*x_16 + 5.20528030395508) - 0.135714165507633*std::sin(0.417759865522385*x_2 - 4.17151975631714) - 0.0477023832788575*std::sin(0.447039872407913*x_2 - 4.14039993286133) + 0.0365878685548254*std::sin(0.258479982614517*x_24 - 7.51384019851685) + 0.106034339769654*std::sin(0.270639955997467*x_24 - 7.49720001220703) + 0.0007498313137257*std::sin(0.297439932823181*x_28 + 5.12983989715576) - 0.15482066877815*std::sin(0.305759936571121*x_28 + 5.13399982452393) - 0.044429432354753*std::sin(0.316559851169586*x_28 - 4.28560018539429) - 0.0535168576505058*std::sin(0.281359940767288*x_3 - 4.31383991241455) - 0.0694803937420165*std::sin(0.2882399559021*x_33 - 1.16303980350494) - 0.000528844346007797*std::sin(0.314479857683182*x_33 - 1.18263983726501) + 0.0127115116996317*std::sin(0.341279834508896*x_34 - 7.41287994384766) - 0.0453195500919406*std::sin(0.352959841489792*x_34 + 1.99951982498169) + 0.0116701481563533*std::sin(0.311919927597046*x_35 + 8.2792797088623) + 0.0435163900381595*std::sin(0.316639840602875*x_35 - 7.43399953842163) - 0.00112846009894105*std::sin(0.319359838962555*x_35 - 7.43088006973267) - 0.041277431685481*std::sin(0.320079833269119*x_35 - 7.43167972564697) + 0.0908542590509893*std::sin(0.320479840040207*x_35 + 1.98279976844788) - 0.000552539461878472*std::sin(0.264559954404831*x_36 - 7.52311992645264) - 0.0156050809389911*std::sin(0.300559937953949*x_36 + 5.09175968170166) + 0.0324658961326184*std::sin(0.311679929494858*x_36 + 5.10960006713867) + 0.0301426569349775*std::sin(0.202240005135536*x_37 + 4.99927997589111) - 0.00390067867626228*std::sin(0.678639829158783*x_38 + 2.21391987800598) + 0.00034485372873494*std::sin(0.47343984246254*x_39 + 8.44896030426025) - 0.148642030642325*std::sin(0.342319846153259*x_4 + 8.3264799118042) - 0.0650117013495818*std::sin(0.398239850997925*x_4 - 4.21464014053345) + 0.0458111859565739*std::sin(0.243759974837303*x_40 + 1.85207998752594) - 0.0362177024811008*std::sin(0.337839841842651*x_41 - 4.25608015060425) + 0.196090246853017*std::sin(0.198319986462593*x_42 - 7.60856008529663) + 0.0291900459731279*std::sin(0.370559841394424*x_43 - 7.410560131073) - 0.011812776124214*std::sin(0.370959848165512*x_43 - 4.21415996551514) + 0.277193786106523*std::sin(0.37271985411644*x_43 - 7.42679977416992) + 0.230113588979974*std::sin(0.294719934463501*x_45 + 5.10903978347778) + 0.0707385594845612*std::sin(0.342879861593246*x_45 - 7.43375968933105) + 0.0184557298316594*std::sin(0.519439876079559*x_45 + 5.34327983856201) - 0.0222084069336077*std::sin(0.367279827594757*x_46 - 4.23912000656128) + 0.000176506106326544*std::sin(0.57127982378006*x_46 + 2.17831993103027) + 0.0170688199476909*std::sin(0.667999863624573*x_46 - 7.14032030105591) - 0.0981893342739409*std::sin(0.356239855289459*x_47 - 4.23776006698608) + 0.0213256877321681*std::sin(0.314479827880859*x_48 - 1.26639986038208) + 0.0275078158691452*std::sin(0.370799839496613*x_48 - 7.42199993133545) - 0.0686403527977106*std::sin(0.499119848012924*x_49 + 8.48079967498779) + 0.0195219435197366*std::sin(0.324479848146439*x_51 - 7.46815967559814) + 0.0284110620508978*std::sin(0.344719856977463*x_51 - 4.25576019287109) - 0.105179136969375*std::sin(0.392559856176376*x_51 + 2.00583982467651) + 0.0410682600692012*std::sin(0.256319969892502*x_53 + 5.06504011154175) + 0.156488286788466*std::sin(0.331999838352203*x_53 - 4.27663993835449) - 0.0125257516842766*std::sin(0.430319845676422*x_53 + 8.42768001556396) + 0.489152860340488*std::sin(0.0974400714039803*x_54 + 4.85640001296997) - 0.0171845982138562*std::sin(0.376319825649261*x_55 - 7.40751981735229) - 0.0807146131995411*std::sin(0.419439852237701*x_55 + 8.40575981140137) - 0.395496990213049*std::sin(0.096000075340271*x_56 - 1.48439979553223) + 0.527723542419922*std::sin(0.198959991335869*x_56 + 1.79975986480713) + 0.11388857474732*std::sin(0.32151985168457*x_57 - 4.28575992584229) - 0.000204965064387657*std::sin(0.677679836750031*x_57 - 3.95703983306885) + 0.0190953383042945*std::sin(0.270799964666367*x_58 - 7.50408029556274) + 0.0619676734992083*std::sin(0.356159836053848*x_58 + 5.15912008285522) + 0.000431692287633897*std::sin(0.425279855728149*x_58 + 5.21239995956421) - 0.420512286965286*std::sin(0.272079944610596*x_59 - 7.50024032592773) - 0.0181321419381958*std::sin(0.396159827709198*x_59 - 4.19447994232178) - 0.0238093475888069*std::sin(0.403359860181808*x_59 - 4.1878399848938) + 0.405511443235362*std::sin(0.133280038833618*x_63 - 7.67183971405029) - 0.0140050819811579*std::sin(0.405439853668213*x_63 + 5.19360017776489) - 0.0407639608973895*std::sin(0.202399998903275*x_64 - 4.39472007751465) - 0.0816073912684824*std::sin(0.229839980602264*x_64 - 4.35567998886108) + 0.393235011783396*std::sin(0.294319927692413*x_64 - 4.28071975708008) - 0.273395412178365*std::sin(0.199039995670319*x_66 + 4.99455976486206) - 0.103674603107715*std::sin(0.165360018610954*x_67 - 4.45287990570068) + 0.0972373424321885*std::sin(0.220559984445572*x_67 - 7.56264019012451) - 0.000324754179039826*std::sin(0.289759933948517*x_67 - 7.48559999465942) + 0.268115417959557*std::sin(0.246639966964722*x_70 + 5.05167961120605) + 0.00252769019579918*std::sin(0.760799884796143*x_70 + 2.37687993049622) + 0.523261510851217*std::sin(0.101840071380138*x_71 - 7.71872043609619) + 0.41916781989644*std::sin(0.218639999628067*x_71 + 5.03167963027954) - 0.125724555210316*std::sin(0.172000005841255*x_72 - 7.62408018112183) - 0.000149036371515312*std::sin(0.417839854955673*x_72 - 0.988559782505035) - 0.156109783942918*std::sin(0.186880007386208*x_73 + 4.96799993515015) + 0.024376531538924*std::sin(0.214399993419647*x_73 + 8.20792007446289) + 0.176788305306464*std::sin(0.252239972352982*x_73 + 5.07247972488403) - 0.00923399556912138*std::sin(0.510879814624786*x_73 + 2.10727977752686) - 0.223925689853908*std::sin(0.12896004319191*x_74 - 7.67944049835205) - 0.318028202707927*std::sin(0.321839839220047*x_75 + 5.12048006057739) + 0.00578964352290846*std::sin(0.450239837169647*x_75 - 7.35103988647461) - 0.0264973551945067*std::sin(0.280479967594147*x_76 + 5.09592008590698) - 0.0383241274353591*std::sin(0.379359841346741*x_76 - 4.20864009857178) - 0.000251417508213132*std::sin(0.612719833850861*x_76 - 3.99183988571167) + 0.0274858302309407*std::sin(0.14144004881382*x_79 - 4.48799991607666) + 0.000855734333262834*std::sin(0.324319839477539*x_79 - 4.27648019790649) - 0.0531177737994931*std::sin(0.344319850206375*x_79 + 5.13976001739502) + 0.0129916079482415*std::sin(0.428879857063293*x_79 - 1.18207991123199) - 0.0415301443157527*std::sin(0.297279924154282*x_81 - 7.47096014022827) + 0.158438549148374*std::sin(0.23463998734951*x_82 + 5.0479998588562) + 0.266069500874733*std::sin(0.296399921178818*x_83 - 7.48288011550903) - 0.0284912854923468*std::sin(0.281279951334*x_84 - 7.50392007827759) + 0.0476668060518131*std::sin(0.285679936408997*x_84 + 5.08895969390869) - 0.093222997437646*std::sin(0.324639827013016*x_84 - 1.08567988872528) + 0.0578257288566898*std::sin(0.184720009565353*x_85 + 1.77711987495422) + 0.00199052496727207*std::sin(0.202799841761589*x_85 - 1.36799991130829) - 0.0302128971668938*std::sin(0.213839992880821*x_85 + 5.00920009613037) + 0.001395707677913*std::sin(0.271919965744019*x_86 + 5.07535982131958) + 0.0112929107511493*std::sin(0.294719934463501*x_86 - 7.4986400604248) - 0.306273785284889*std::sin(0.310959845781326*x_86 - 4.30808019638062) - 0.0388303935968846*std::sin(0.434079855680466*x_86 + 5.24151992797852) - 0.0696822351005274*std::sin(0.150880038738251*x_87 + 4.91951942443848) - 0.0213899969700624*std::sin(0.306479841470718*x_87 - 4.31288003921509) - 1.41835925259327e-5*std::sin(0.950239837169647*x_87 - 3.83208012580872) + 0.181973571914882*std::sin(0.191359996795654*x_88 - 7.60824012756348) - 0.000395548074811928*std::sin(0.212960004806519*x_88 - 7.57991981506348) - 0.147392497267503*std::sin(0.204080000519753*x_89 - 4.40327978134155) + 0.0139868936068318*std::sin(0.285919934511185*x_89 - 7.49544048309326) + 0.0640302454018233*std::sin(0.274079948663712*x_90 - 7.50888013839722) - 0.0155609647636108*std::sin(0.361039847135544*x_92 + 1.97879981994629) - 0.000847680556451312*std::sin(0.362799853086472*x_92 + 1.98575985431671) + 0.0679499453960291*std::sin(0.363679856061935*x_92 + 2.00567984580994) + 0.138009012567127*std::sin(0.369039833545685*x_92 + 2.00383973121643) + 0.0766355487386036*std::sin(0.270719945430756*x_93 - 1.36999988555908) + 0.112367331402379*std::sin(0.343679845333099*x_93 + 1.97367978096008) - 0.000633268580876303*std::sin(0.365119844675064*x_95 + 5.18239974975586) - 0.107989054637179*std::sin(0.376399844884872*x_95 + 1.9883998632431) - 0.0454218533872441*std::sin(0.381439834833145*x_95 - 7.42175960540771) + 0.0018657586250669*std::sin(0.43615984916687*x_95 + 5.22552013397217) - 0.014987221383457*std::sin(0.403999865055084*x_96 - 7.39807987213135) - 0.000226266864212032*std::sin(0.421199858188629*x_96 + 5.20864009857178) + 1.30968404948061*std::sin(0.114480063319206*x_97 + 1.71391987800598) + 0.0023727663107215*std::sin(0.437599837779999*x_97 + 5.21184015274048) - 0.0633799229805458*std::sin(0.363839834928513*x_98 + 5.17519998550415) - 0.000605476761826933*std::sin(0.42375984787941*x_98 + 2.02567982673645) + 0.314560347456295*std::sin(0.366159856319427*x_99 - 7.4347996711731) - 0.0396800900184478*std::sin(0.376159846782684*x_99 + 1.98311984539032) + 0.03224050311249*std::sin(0.406079858541489*x_99 + 5.20360040664673) - 0.0168371109657048*std::sin(0.441999852657318*x_99 - 4.16584014892578) + 1.69418745845957 + 9.1580140461899e-6*std::exp(-1.2125598192215*x_9));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.140150842107183*x_1 - 0.124186002144971*x_10 - 0.000474966457964684*x_100 + 0.0382496869246229*x_101 - 0.000402932010374388*x_102 - 0.0518948654591123*x_103 - 0.00224874226926266*x_104 - 0.00291010076524619*x_105 + 0.000557265707482638*x_106 - 0.0037119426261632*x_107 + 3.83556914594143e-6*x_108 - 0.0306100935834572*x_109 - 0.0129908014359168*x_11 - 0.00171618573438219*x_110 - 1.94375574232541e-6*x_111 - 0.0224907805938325*x_113 + 0.00280771427657438*x_114 + 0.00354475667118129*x_115 - 0.00765702513024129*x_116 + 0.0369163999840713*x_117 - 0.00849163474124884*x_118 - 4.74008413306779e-6*x_119 - 0.0272196037822959*x_12 - 0.00155911740998905*x_120 + 0.0333146300577295*x_13 - 0.000913567619594844*x_14 + 0.000704430526572926*x_15 + 0.000440872595712583*x_16 + 0.00278173421035511*x_17 - 0.00296109931603936*x_18 - 0.0492473203195621*x_19 + 0.0070282443720384*x_2 - 0.0239917061423925*x_20 + 0.0063770889798993*x_21 - 0.00825492054432476*x_22 - 0.00925398492156522*x_23 - 0.00536365342911808*x_24 + 0.0474144574665765*x_25 + 0.00313045390912295*x_26 - 0.00603220239712351*x_27 + 0.000520918243653269*x_28 - 0.0269932804090168*x_29 + 0.0182128353746126*x_3 - 0.0107412179310426*x_30 + 0.0162993866339231*x_31 + 0.0348919142999072*x_32 + 0.0329218545588058*x_33 + 0.0326894141306486*x_34 - 0.0100437549307843*x_36 + 0.019636195279084*x_37 + 0.00530735058068899*x_38 - 0.0309595928197359*x_39 - 0.000553882340293934*x_4 + 0.000664544257909928*x_40 - 0.030400968820055*x_41 - 0.0406858542275485*x_42 + 0.000448309555798198*x_43 + 0.0216843094878148*x_44 - 9.34374898518434e-5*x_45 + 0.00195120990821747*x_46 - 0.0416292985258887*x_47 - 0.019932246462209*x_48 - 0.00772295049447044*x_49 - 0.0182131374193406*x_5 - 0.00388968356595837*x_50 - 0.006046808982193*x_51 - 0.0157492832202938*x_52 + 0.00268820581309018*x_53 + 0.012241384824694*x_54 + 0.00291658773492185*x_55 + 0.00448265616497241*x_56 - 0.00376459080177427*x_57 + 0.031090373279138*x_58 - 0.00201947957882058*x_59 - 0.0109078866580388*x_6 + 0.0219388477284133*x_60 - 0.0592754583458882*x_61 + 0.0357494597169933*x_62 + 0.00723023598770345*x_63 - 0.00859897037352998*x_64 + 0.0628021952259267*x_65 + 0.00138621501514892*x_66 + 0.0114227675878056*x_67 + 0.00258387448233804*x_68 - 0.0322602330487986*x_69 - 0.0262227495720971*x_7 - 1.47137391980787e-6*x_70 - 0.00680528030396223*x_71 - 0.00414192257050397*x_72 - 1.33533550136889e-6*x_73 + 0.00522648150643079*x_74 - 5.74209469760322e-5*x_75 + 0.00490921750329399*x_76 + 0.000779697920330993*x_77 + 0.00129079409821423*x_78 - 0.0234144792008519*x_79 + 0.148190249392087*x_8 + 0.0091516629413705*x_80 + 0.0286282772365299*x_81 + 0.0170456735771794*x_82 - 0.0066995125582971*x_83 + 1.13305090241022e-5*x_84 + 0.00066745528120724*x_85 - 0.000260941226244947*x_86 + 0.00499457583963748*x_87 - 0.00555438960380024*x_88 + 0.0188525103007649*x_89 + 0.0166526654400663*x_9 - 0.0110839401445542*x_90 - 0.0280342770450102*x_91 - 0.00170444972716065*x_92 + 0.0332829946685339*x_93 - 0.0145442183902644*x_94 + 3.43330030074506e-5*x_95 + 0.0115971646893226*x_96 + 0.00178117824507738*x_97 + 0.000377994089209178*x_98 - 5.43138652496572e-6*x_99 - 5.99390394133097e-8*std::pow(-7.87296009063721*x_106 - 9.04559993743896, 2) - 6.87604748990296e-5*std::pow(-7.23343992233276*x_107 - 9.84928035736084, 2) - 0.000430982145399658*std::pow(-3.99151992797852*x_110 - 5.38871955871582, 2) + 5.94551145000217e-6*std::pow(-8.07431983947754*x_116 - 9.47160053253174, 2) + 0.000134353805100414*std::pow(-8.54367923736572*x_120 - 9.14231967926025, 2) - 1.04143213002607e-5*std::pow(-7.97567987442017*x_13 - 9.75928020477295, 2) - 0.000395610839250942*std::pow(-2.19231986999512*x_13 - 3.18535995483398, 2) + 1.3908693661214e-5*std::pow(-6.53927993774414*x_14 - 9.78439998626709, 2) - 0.000132610225900445*std::pow(-6.46400022506714*x_14 - 8.68704032897949, 2) - 0.000159231679374105*std::pow(-5.62559986114502*x_15 - 7.82880020141602, 2) - 0.000691992178781917*std::pow(-6.89976024627686*x_17 - 9.1307201385498, 2) + 1.09295644059671e-5*std::pow(-6.92984008789063*x_19 - 9.97432041168213, 2) + 1.94784249476737e-5*std::pow(-6.88104009628296*x_23 - 8.10231971740723, 2) + 0.000548221130644008*std::pow(-5.86168003082275*x_27 - 8.08047962188721, 2) + 1.6835238252465e-5*std::pow(-4.25631999969482*x_27 - 5.47039985656738, 2) - 2.40474639323364e-5*std::pow(-7.61320018768311*x_36 - 9.01000022888184, 2) - 1.03242445667088e-5*std::pow(-5.53175973892212*x_52 - 7.57728004455566, 2) - 5.75753557174525e-8*std::pow(-8.06855964660645*x_56 - 7.47832012176514, 2) - 6.27038567101485e-6*std::pow(-7.14911985397339*x_68 - 9.59352016448975, 2) - 9.89772081008993e-5*std::pow(-7.14143991470337*x_68 - 9.17271995544434, 2) - 7.91412126309756e-5*std::pow(-5.12191963195801*x_7 - 7.37095975875854, 2) + 5.3633084002694e-6*std::pow(-4.89592027664185*x_7 - 7.74936008453369, 2) - 2.28140468387998e-6*std::pow(-7.63944053649902*x_70 - 9.65192031860352, 2) + 1.50708674765948e-5*std::pow(-9.15408039093018*x_72 - 9.7540807723999, 2) - 8.63513378409138e-5*std::pow(-6.66584014892578*x_74 - 8.27351951599121, 2) - 1.68872028650224e-5*std::pow(-6.94191980361938*x_77 - 9.79944038391113, 2) - 1.0472610089833e-6*std::pow(-1.50623989105225*x_77 - 2.36735987663269, 2) - 1.32705054843931e-5*std::pow(-7.40000009536743*x_78 - 9.99612045288086, 2) + 2.52889188607881e-5*std::pow(-7.37215995788574*x_78 - 8.56719970703125, 2) - 2.77380063574655e-5*std::pow(-7.31472015380859*x_80 - 9.95207977294922, 2) - 4.22496150039081e-8*std::pow(-7.1406397819519*x_80 - 9.58688068389893, 2) + 2.63195936863477e-6*std::pow(-6.15687990188599*x_84 - 6.77792024612427, 2) - 0.000140886943511645*std::pow(-8.07520008087158*x_88 - 7.66735982894897, 2) - 8.04838004648718e-8*std::pow(-5.88727998733521*x_90 - 8.93711948394775, 2) + 3.45323610974556e-5*std::pow(-4.83951997756958*x_90 - 7.24056005477905, 2) - 0.00871553541234665*std::exp(0.460399866104126*x_1) - 0.000291880684031591*std::exp(1.18103992938995*x_1) - 8.22548691862858e-7*std::exp(1.18375980854034*x_1) - 0.0131359150212174*std::exp(0.595759809017181*x_100) - 4.80342778083445e-7*std::exp(1.62599992752075*x_100) - 0.00377825165737347*std::exp(1.66631984710693*x_100) - 0.00939462598701106*std::exp(0.609039843082428*x_104) + 0.00369529161244915*std::exp(0.729839861392975*x_104) - 3.50567543592456e-6*std::exp(0.828719913959503*x_104) + 0.000471326142633098*std::exp(0.893679857254028*x_104) + 0.00099450411299288*std::exp(0.863839864730835*x_106) - 0.00737924126621344*std::exp(0.912479817867279*x_106) + 0.00273852870417541*std::exp(1.19687986373901*x_106) + 1.2521541397733e-5*std::exp(0.576399862766266*x_110) + 0.00661759809469365*std::exp(0.783999860286713*x_110) + 0.0727373605380843*std::exp(0.562159836292267*x_112) - 0.00146383142043933*std::exp(1.24383985996246*x_26) - 5.70734389311137e-6*std::exp(0.575999855995178*x_31) - 6.32078556907067e-5*std::exp(0.60319983959198*x_31) - 0.0253041792624715*std::exp(0.629599869251251*x_31) - 0.00498458706297557*std::exp(0.646159827709198*x_31) - 0.00101087900972483*std::exp(1.33207988739014*x_50) + 0.0010995816819656*std::exp(0.898319840431213*x_6) - 0.000544077618024636*std::exp(1.28559982776642*x_60) + 0.000265763210301666*std::exp(1.3447197675705*x_60) + 0.000167702992768199*std::exp(1.45263981819153*x_60) - 0.00414762761856966*std::exp(0.721199870109558*x_70) - 0.000914869807068713*std::exp(0.880959868431091*x_72) - 5.94733540976495e-6*std::exp(0.898639857769012*x_74) - 0.0535689325369218*std::exp(0.675999820232391*x_76) - 0.00209785932781341*std::exp(0.759759843349457*x_77) - 0.000371519432087223*std::exp(0.727279841899872*x_81) + 9.81104604026241e-5*std::exp(2.27735996246338*x_81) - 6.52737813343576e-8*std::exp(2.64103984832764*x_81) - 0.000362363973932589*std::exp(0.677599847316742*x_87) + 0.00204929715538069*std::sin(0.347919851541519*x_10 - 4.24720001220703) + 0.0419979308880751*std::sin(0.371759831905365*x_100 + 5.16815996170044) - 9.84701057498982e-5*std::sin(0.315839856863022*x_101 + 5.13479995727539) - 0.230457020711161*std::sin(0.362959831953049*x_102 - 7.41792011260986) + 0.0222383377869839*std::sin(0.364479839801788*x_102 - 7.41215991973877) - 0.0364122307057555*std::sin(0.372399836778641*x_102 - 7.42935991287231) + 0.0125292708658224*std::sin(0.353599846363068*x_103 - 4.24520015716553) - 0.150446282778564*std::sin(0.331999838352203*x_105 + 5.13535976409912) - 0.00869705301505649*std::sin(0.368959844112396*x_105 - 7.41703987121582) + 0.00612878435006694*std::sin(0.512159824371338*x_107 + 5.27336025238037) - 0.280467516794933*std::sin(0.141760036349297*x_108 - 7.67880010604858) - 0.225707869752191*std::sin(0.290719926357269*x_108 - 7.48176002502441) + 0.00598206366747201*std::sin(0.500319838523865*x_108 + 5.28128004074097) - 0.0377386678998107*std::sin(0.532639861106873*x_108 + 2.15879988670349) + 0.0151927781726224*std::sin(0.234479993581772*x_110 - 7.55600023269653) + 0.0326387040219891*std::sin(0.350399851799011*x_111 + 5.14800024032593) + 0.0074743038871939*std::sin(0.36167985200882*x_111 - 7.41599988937378) - 0.210013815768762*std::sin(0.364639848470688*x_111 - 7.42519998550415) + 0.0113132905062128*std::sin(0.411199867725372*x_111 + 8.19527912139893) + 0.00808107925932745*std::sin(0.238559976220131*x_112 - 7.55352020263672) + 0.0504029027550939*std::sin(0.42647984623909*x_112 + 5.22016000747681) - 0.012510399893312*std::sin(0.483759850263596*x_112 - 7.34975957870483) + 1.95929601000132e-5*std::sin(0.561359822750092*x_112 + 2.18031978607178) + 0.0253209158032337*std::sin(0.352079838514328*x_113 + 5.14792013168335) + 0.0242865501460067*std::sin(0.23335999250412*x_114 - 7.55904006958008) - 0.118715413040789*std::sin(0.335279852151871*x_114 + 5.12943983078003) + 0.0539606848934056*std::sin(0.456959843635559*x_114 + 5.24592018127441) - 0.12668724503997*std::sin(0.163440018892288*x_115 - 7.64416027069092) - 4.94252490198198e-5*std::sin(0.368639826774597*x_115 - 7.41511964797974) + 0.00964830761342504*std::sin(0.389999836683273*x_115 + 5.18383979797363) + 0.0534275596332995*std::sin(0.458079844713211*x_115 - 4.15824031829834) + 0.0267649896309941*std::sin(0.383359849452972*x_116 + 5.17575979232788) - 0.0666673871408799*std::sin(0.291759938001633*x_117 + 5.08567953109741) + 0.000101389843833701*std::sin(0.370319843292236*x_117 + 5.17880010604858) + 0.0208637899516419*std::sin(0.399759858846664*x_117 + 5.18656015396118) + 0.039198326210663*std::sin(0.28687995672226*x_118 + 1.89631986618042) + 0.249420763087772*std::sin(0.529999852180481*x_118 - 7.22975969314575) - 0.0251271628037554*std::sin(0.331279844045639*x_119 + 5.1526403427124) + 0.0140325694342137*std::sin(0.344959855079651*x_119 + 5.15152025222778) + 0.698110341663082*std::sin(0.345199823379517*x_119 + 5.15088033676147) + 0.041246797083398*std::sin(0.411679863929749*x_119 + 2.01143980026245) + 0.0124258489913175*std::sin(0.413199841976166*x_120 + 5.21072006225586) - 0.00461501483710085*std::sin(0.438319861888885*x_120 - 4.1812801361084) - 1.77635322459455e-6*std::sin(0.783199846744537*x_120 - 4.01696014404297) + 0.631205554226001*std::sin(0.221440002322197*x_14 - 4.37151956558228) + 0.00665496014288175*std::sin(0.384319841861725*x_16 + 5.19271993637085) - 0.141079953839097*std::sin(0.385279834270477*x_16 + 5.19063997268677) - 0.0121781028709519*std::sin(0.414559870958328*x_16 + 5.20528030395508) + 0.209669726448681*std::sin(0.417759865522385*x_2 - 4.17151975631714) + 0.0780375752949906*std::sin(0.447039872407913*x_2 - 4.14039993286133) + 0.00881885282965413*std::sin(0.258479982614517*x_24 - 7.51384019851685) - 0.173464347163896*std::sin(0.270639955997467*x_24 - 7.49720001220703) + 6.99667248172003e-5*std::sin(0.297439932823181*x_28 + 5.12983989715576) + 0.239188054908615*std::sin(0.305759936571121*x_28 + 5.13399982452393) + 0.072683269354268*std::sin(0.316559851169586*x_28 - 4.28560018539429) - 0.0128992835649377*std::sin(0.281359940767288*x_3 - 4.31383991241455) - 0.0167470090814146*std::sin(0.2882399559021*x_33 - 1.16303980350494) - 4.93464411940997e-5*std::sin(0.314479857683182*x_33 - 1.18263983726501) - 0.0207950941481119*std::sin(0.341279834508896*x_34 - 7.41287994384766) - 0.0109234688532916*std::sin(0.352959841489792*x_34 + 1.99951982498169) - 0.0251559115061602*std::sin(0.311919927597046*x_35 + 8.2792797088623) + 0.0104888492984854*std::sin(0.316639840602875*x_35 - 7.43399953842163) - 0.000105296559058724*std::sin(0.319359838962555*x_35 - 7.43088006973267) + 0.0675268290959215*std::sin(0.320079833269119*x_35 - 7.43167972564697) - 0.140364033265542*std::sin(0.320479840040207*x_35 + 1.98279976844788) - 5.15574313478687e-5*std::sin(0.264559954404831*x_36 - 7.52311992645264) + 0.0255287596773111*std::sin(0.300559937953949*x_36 + 5.09175968170166) + 0.00782532493105939*std::sin(0.311679929494858*x_36 + 5.10960006713867) - 0.06497484010124*std::sin(0.202240005135536*x_37 + 4.99927997589111) + 0.00638122217334362*std::sin(0.678639829158783*x_38 + 2.21391987800598) + 3.21782853008583e-5*std::sin(0.47343984246254*x_39 + 8.44896030426025) + 0.229642453217605*std::sin(0.342319846153259*x_4 + 8.3264799118042) + 0.140137775810897*std::sin(0.398239850997925*x_4 - 4.21464014053345) - 0.0749437161774567*std::sin(0.243759974837303*x_40 + 1.85207998752594) - 0.0087296309029432*std::sin(0.337839841842651*x_41 - 4.25608015060425) + 0.0472640549075996*std::sin(0.198319986462593*x_42 - 7.60856008529663) + 0.00703573970541945*std::sin(0.370559841394424*x_43 - 7.410560131073) + 0.0254633571777778*std::sin(0.370959848165512*x_43 - 4.21415996551514) - 0.428246713147717*std::sin(0.37271985411644*x_43 - 7.42679977416992) - 0.355510812545518*std::sin(0.294719934463501*x_45 + 5.10903978347778) + 0.017050267482548*std::sin(0.342879861593246*x_45 - 7.43375968933105) - 0.0301922106898265*std::sin(0.519439876079559*x_45 + 5.34327983856201) - 0.00535294019751602*std::sin(0.367279827594757*x_46 - 4.23912000656128) + 1.64697765268609e-5*std::sin(0.57127982378006*x_46 + 2.17831993103027) - 0.0263702377408264*std::sin(0.667999863624573*x_46 - 7.14032030105591) - 0.0236667869052295*std::sin(0.356239855289459*x_47 - 4.23776006698608) - 0.0348872498128228*std::sin(0.314479827880859*x_48 - 1.26639986038208) + 0.00663026815709991*std::sin(0.370799839496613*x_48 - 7.42199993133545) + 0.106044965465507*std::sin(0.499119848012924*x_49 + 8.48079967498779) + 0.00470541612970433*std::sin(0.324479848146439*x_51 - 7.46815967559814) - 0.0464783988055006*std::sin(0.344719856977463*x_51 - 4.25576019287109) + 0.162495055648682*std::sin(0.392559856176376*x_51 + 2.00583982467651) - 0.0671846397830817*std::sin(0.256319969892502*x_53 + 5.06504011154175) - 0.241764418331962*std::sin(0.331999838352203*x_53 - 4.27663993835449) - 0.00301910893002427*std::sin(0.430319845676422*x_53 + 8.42768001556396) - 1.05440701376284*std::sin(0.0974400714039803*x_54 + 4.85640001296997) - 0.00414204075204999*std::sin(0.376319825649261*x_55 - 7.40751981735229) + 0.124698927386523*std::sin(0.419439852237701*x_55 + 8.40575981140137) + 0.852524505555295*std::sin(0.096000075340271*x_56 - 1.48439979553223) - 0.815299201567071*std::sin(0.198959991335869*x_56 + 1.79975986480713) - 0.175950581308756*std::sin(0.32151985168457*x_57 - 4.28575992584229) - 1.91252805726342e-5*std::sin(0.677679836750031*x_57 - 3.95703983306885) + 0.00460259055500025*std::sin(0.270799964666367*x_58 - 7.50408029556274) - 0.101374536326221*std::sin(0.356159836053848*x_58 + 5.15912008285522) + 4.02811871706357e-5*std::sin(0.425279855728149*x_58 + 5.21239995956421) + 0.649664652518253*std::sin(0.272079944610596*x_59 - 7.50024032592773) + 0.0390852414128152*std::sin(0.396159827709198*x_59 - 4.19447994232178) - 0.0057388183747609*std::sin(0.403359860181808*x_59 - 4.1878399848938) - 0.66338676622234*std::sin(0.133280038833618*x_63 - 7.67183971405029) - 0.00337567510045029*std::sin(0.405439853668213*x_63 + 5.19360017776489) + 0.0878698864175976*std::sin(0.202399998903275*x_64 - 4.39472007751465) - 0.0196700054371938*std::sin(0.229839980602264*x_64 - 4.35567998886108) - 0.60752300279245*std::sin(0.294319927692413*x_64 - 4.28071975708008) + 0.422378467784473*std::sin(0.199039995670319*x_66 + 4.99455976486206) + 0.169603992297433*std::sin(0.165360018610954*x_67 - 4.45287990570068) + 0.0234373262594183*std::sin(0.220559984445572*x_67 - 7.56264019012451) - 3.0302797258781e-5*std::sin(0.289759933948517*x_67 - 7.48559999465942) - 0.414221213607157*std::sin(0.246639966964722*x_70 + 5.05167961120605) - 0.00413511444122152*std::sin(0.760799884796143*x_70 + 2.37687993049622) + 0.12612284994696*std::sin(0.101840071380138*x_71 - 7.71872043609619) - 0.647587536680788*std::sin(0.218639999628067*x_71 + 5.03167963027954) - 0.0303036605647604*std::sin(0.172000005841255*x_72 - 7.62408018112183) - 1.3906576856272e-5*std::sin(0.417839854955673*x_72 - 0.988559782505035) - 0.0376274777471325*std::sin(0.186880007386208*x_73 + 4.96799993515015) - 0.0525455085920614*std::sin(0.214399993419647*x_73 + 8.20792007446289) - 0.273126651696853*std::sin(0.252239972352982*x_73 + 5.07247972488403) + 0.0151061346408304*std::sin(0.510879814624786*x_73 + 2.10727977752686) - 0.0539732917385249*std::sin(0.12896004319191*x_74 - 7.67944049835205) + 0.491333281351435*std::sin(0.321839839220047*x_75 + 5.12048006057739) - 0.012480026659748*std::sin(0.450239837169647*x_75 - 7.35103988647461) + 0.043347715752934*std::sin(0.280479967594147*x_76 + 5.09592008590698) + 0.0826106357347182*std::sin(0.379359841346741*x_76 - 4.20864009857178) - 2.34597559335984e-5*std::sin(0.612719833850861*x_76 - 3.99183988571167) + 0.0066249689113294*std::sin(0.14144004881382*x_79 - 4.48799991607666) + 7.9848530617559e-5*std::sin(0.324319839477539*x_79 - 4.27648019790649) + 0.0868967541547852*std::sin(0.344319850206375*x_79 + 5.13976001739502) - 0.0280044208085542*std::sin(0.428879857063293*x_79 - 1.18207991123199) + 0.0679402482913008*std::sin(0.297279924154282*x_81 - 7.47096014022827) + 0.0381887850446854*std::sin(0.23463998734951*x_82 + 5.0479998588562) - 0.41106040225112*std::sin(0.296399921178818*x_83 - 7.48288011550903) + 0.0614151805906622*std::sin(0.281279951334*x_84 - 7.50392007827759) - 0.0779793735796164*std::sin(0.285679936408997*x_84 + 5.08895969390869) + 0.144023582935254*std::sin(0.324639827013016*x_84 - 1.08567988872528) + 0.0139378600803292*std::sin(0.184720009565353*x_85 + 1.77711987495422) + 0.000185735791607443*std::sin(0.202799841761589*x_85 - 1.36799991130829) + 0.0651262483811167*std::sin(0.213839992880821*x_85 + 5.00920009613037) + 0.00013023341815452*std::sin(0.271919965744019*x_86 + 5.07535982131958) - 0.0243427469554634*std::sin(0.294719934463501*x_86 - 7.4986400604248) + 0.473173456425028*std::sin(0.310959845781326*x_86 - 4.30808019638062) + 0.0635236555443563*std::sin(0.434079855680466*x_86 + 5.24151992797852) + 0.113994989235491*std::sin(0.150880038738251*x_87 + 4.91951942443848) + 0.0461078011767131*std::sin(0.306479841470718*x_87 - 4.31288003921509) - 1.32347035528615e-6*std::sin(0.950239837169647*x_87 - 3.83208012580872) + 0.0438614823161701*std::sin(0.191359996795654*x_88 - 7.60824012756348) - 3.69085723625347e-5*std::sin(0.212960004806519*x_88 - 7.57991981506348) - 0.0355263313480413*std::sin(0.204080000519753*x_89 - 4.40327978134155) - 0.0301498364121442*std::sin(0.285919934511185*x_89 - 7.49544048309326) - 0.138022171224029*std::sin(0.274079948663712*x_90 - 7.50888013839722) + 0.0335428691477889*std::sin(0.361039847135544*x_92 + 1.97879981994629) - 7.90970330799181e-5*std::sin(0.362799853086472*x_92 + 1.98575985431671) + 0.0163781218174182*std::sin(0.363679856061935*x_92 + 2.00567984580994) - 0.213215118732575*std::sin(0.369039833545685*x_92 + 2.00383973121643) - 0.125370096709871*std::sin(0.270719945430756*x_93 - 1.36999988555908) + 0.0270841401163792*std::sin(0.343679845333099*x_93 + 1.97367978096008) - 5.90902616661855e-5*std::sin(0.365119844675064*x_95 + 5.18239974975586) + 0.166836199158264*std::sin(0.376399844884872*x_95 + 1.9883998632431) + 0.0743067968538192*std::sin(0.381439834833145*x_95 - 7.42175960540771) - 0.0040217877472692*std::sin(0.43615984916687*x_95 + 5.22552013397217) - 0.0036124022777687*std::sin(0.403999865055084*x_96 - 7.39807987213135) - 2.11129505180486e-5*std::sin(0.421199858188629*x_96 + 5.20864009857178) - 2.02337829188034*std::sin(0.114480063319206*x_97 + 1.71391987800598) - 0.005114682224905*std::sin(0.437599837779999*x_97 + 5.21184015274048) + 0.0979179370404202*std::sin(0.363839834928513*x_98 + 5.17519998550415) - 5.64970083303985e-5*std::sin(0.42375984787941*x_98 + 2.02567982673645) - 0.485975666254634*std::sin(0.366159856319427*x_99 - 7.4347996711731) + 0.0649136961234191*std::sin(0.376159846782684*x_99 + 1.98311984539032) + 0.0077709979655417*std::sin(0.406079858541489*x_99 + 5.20360040664673) + 0.0362937014850221*std::sin(0.441999852657318*x_99 - 4.16584014892578) + 0.0831952494016 + 8.54533862367106e-7*std::exp(-1.2125598192215*x_9));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0164663627025936*x_1 - 0.0165453373318496*x_10 - 0.000644819414339505*x_100 + 0.0284906865699837*x_101 - 0.000173949906023355*x_102 - 0.00477555238012874*x_103 - 0.000260569017100538*x_104 + 0.000238402711816954*x_105 + 0.000756549733364882*x_106 - 0.000260622783666969*x_107 + 0.00030025936553431*x_108 + 0.00176658619431804*x_109 - 0.00507519445133669*x_11 - 8.24315682514391e-5*x_110 - 0.000152162780473365*x_111 - 0.00499992191507085*x_113 + 0.000474430416373441*x_114 + 0.000170261205195494*x_115 - 0.0071425081328423*x_116 + 0.0049664700672869*x_117 - 0.00527572459579546*x_118 - 0.000371067395794491*x_119 - 0.00568511328823275*x_12 - 7.48872867421808e-5*x_120 + 0.00386166300802664*x_13 - 0.00104418304079097*x_14 + 0.00226962454279491*x_15 - 0.000218271244111545*x_16 + 0.00286445643581898*x_17 - 0.00162569226659476*x_18 - 0.00262491465526447*x_19 + 0.00280803372121253*x_2 - 0.000733285213701183*x_20 + 0.00428100406714335*x_21 - 0.000514722834582022*x_22 - 0.00202222747252602*x_23 - 0.000847790309609029*x_24 + 0.00582433247389418*x_25 + 0.000603196666609327*x_26 - 0.00379805386876277*x_27 + 0.000344341641869623*x_28 - 0.00579434679888698*x_29 + 0.000488642672774749*x_3 - 0.00418839756284459*x_30 + 0.00969372654540328*x_31 - 0.00215664486502347*x_32 - 0.00286912242195637*x_33 + 0.00386292502244092*x_34 - 0.00116380226675388*x_36 + 0.00324703517836202*x_37 - 0.000521592663242786*x_38 - 0.00634748019721135*x_39 + 0.00103835736981612*x_4 - 0.000401995200366197*x_40 - 0.00230750416038305*x_41 - 0.00679548327654797*x_42 + 0.000171126120209198*x_43 + 0.00242931914568042*x_44 + 0.000227621374296631*x_45 + 0.0012072057494237*x_46 - 0.0116172676392308*x_47 - 0.00163766605335922*x_48 - 0.00245138249916814*x_49 + 0.000743890598141499*x_5 + 0.000457975732128832*x_50 - 0.000498749494671763*x_51 - 0.00478281001291363*x_52 - 8.33415349508045e-5*x_53 + 0.00106833414280293*x_54 + 5.19571596199586e-5*x_55 + 0.00370878916760392*x_56 + 0.000653107066290605*x_57 + 0.00408759439998513*x_58 - 0.00138878648975481*x_59 - 0.00170677156114804*x_6 + 0.00228496897780299*x_60 - 0.00361637853381174*x_61 + 0.00268862627811231*x_62 + 0.00054638208471504*x_63 - 0.00571475192345698*x_64 + 0.0107275259457705*x_65 + 0.000698945454868873*x_66 + 0.000975826613256502*x_67 + 0.000663194036196337*x_68 - 0.00619495434549105*x_69 - 0.00276115452432079*x_7 - 0.000115183375091209*x_70 + 0.000428874154834884*x_71 - 0.000479937922568882*x_72 - 0.000104533897098615*x_73 + 0.000361983198759378*x_74 - 0.000281596691517499*x_75 + 0.00666480485570341*x_76 - 0.00140954132115616*x_77 + 0.000633491516277394*x_78 - 0.00271311119761513*x_79 + 0.025070344556566*x_8 + 0.00118415612554409*x_80 + 0.00331725078625851*x_81 + 0.00367740739367885*x_82 - 0.00292874648835007*x_83 + 0.000886984778871106*x_84 - 0.00352253191908406*x_85 - 0.00035425652877747*x_86 + 0.000578737605975255*x_87 - 0.00063641691648382*x_88 + 0.00559244046942581*x_89 + 0.00312060513080865*x_9 - 0.001840074835535*x_90 - 0.00693421927278409*x_91 - 0.00101368658444455*x_92 + 0.00744744951852954*x_93 - 0.000137798692066865*x_94 + 4.66108427669788e-5*x_95 + 0.00306530906501758*x_96 + 0.0013239720573984*x_97 - 0.000948537904136875*x_98 - 0.000425184531918412*x_99 - 4.69220010386725e-6*std::pow(-7.87296009063721*x_106 - 9.04559993743896, 2) - 4.08938848911047e-5*std::pow(-7.23343992233276*x_107 - 9.84928035736084, 2) - 4.99392907536231e-5*std::pow(-3.99151992797852*x_110 - 5.38871955871582, 2) + 8.07168831998717e-6*std::pow(-8.07431983947754*x_116 - 9.47160053253174, 2) + 1.55680085785069e-5*std::pow(-8.54367923736572*x_120 - 9.14231967926025, 2) - 1.41385911551608e-5*std::pow(-7.97567987442017*x_13 - 9.75928020477295, 2) - 0.000235281448328532*std::pow(-2.19231986999512*x_13 - 3.18535995483398, 2) + 1.88825874974069e-5*std::pow(-6.53927993774414*x_14 - 9.78439998626709, 2) - 6.36951389826491e-6*std::pow(-6.46400022506714*x_14 - 8.68704032897949, 2) - 7.64819144172815e-6*std::pow(-5.62559986114502*x_15 - 7.82880020141602, 2) - 8.01833648662577e-5*std::pow(-6.89976024627686*x_17 - 9.1307201385498, 2) + 1.48380905663145e-5*std::pow(-6.92984008789063*x_19 - 9.97432041168213, 2) + 2.6444112750271e-5*std::pow(-6.88104009628296*x_23 - 8.10231971740723, 2) + 6.35241499740625e-5*std::pow(-5.86168003082275*x_27 - 8.08047962188721, 2) + 2.28556949405208e-5*std::pow(-4.25631999969482*x_27 - 5.47039985656738, 2) - 1.15504407518339e-6*std::pow(-7.61320018768311*x_36 - 9.01000022888184, 2) - 1.40163020427392e-5*std::pow(-5.53175973892212*x_52 - 7.57728004455566, 2) - 4.5071641574829e-6*std::pow(-8.06855964660645*x_56 - 7.47832012176514, 2) - 8.51274094889296e-6*std::pow(-7.14911985397339*x_68 - 9.59352016448975, 2) - 5.88646684140078e-5*std::pow(-7.14143991470337*x_68 - 9.17271995544434, 2) - 3.80129850737887e-6*std::pow(-5.12191963195801*x_7 - 7.37095975875854, 2) + 7.28128339083894e-6*std::pow(-4.89592027664185*x_7 - 7.74936008453369, 2) - 3.09725877998795e-6*std::pow(-7.63944053649902*x_70 - 9.65192031860352, 2) + 7.23881580015897e-7*std::pow(-9.15408039093018*x_72 - 9.7540807723999, 2) - 5.13556905336187e-5*std::pow(-6.66584014892578*x_74 - 8.27351951599121, 2) - 2.29262426402031e-5*std::pow(-6.94191980361938*x_77 - 9.79944038391113, 2) - 8.19825987073859e-5*std::pow(-1.50623989105225*x_77 - 2.36735987663269, 2) - 1.801617657614e-5*std::pow(-7.40000009536743*x_78 - 9.99612045288086, 2) + 2.93030856455216e-6*std::pow(-7.37215995788574*x_78 - 8.56719970703125, 2) - 1.64966114727478e-5*std::pow(-7.31472015380859*x_80 - 9.95207977294922, 2) - 3.30742117074482e-6*std::pow(-7.1406397819519*x_80 - 9.58688068389893, 2) + 3.57317547416082e-6*std::pow(-6.15687990188599*x_84 - 6.77792024612427, 2) - 1.63250243902631e-5*std::pow(-8.07520008087158*x_88 - 7.66735982894897, 2) - 6.30050298765789e-6*std::pow(-5.88727998733521*x_90 - 8.93711948394775, 2) + 4.688149338806e-5*std::pow(-4.83951997756958*x_90 - 7.24056005477905, 2) - 0.000418623251433399*std::exp(0.460399866104126*x_1) - 0.0001735900619106*std::exp(1.18103992938995*x_1) - 6.43914733231066e-5*std::exp(1.18375980854034*x_1) - 0.000630942242394519*std::exp(0.595759809017181*x_100) - 3.76026118415662e-5*std::exp(1.62599992752075*x_100) - 0.000437798201322151*std::exp(1.66631984710693*x_100) - 0.00558726149393178*std::exp(0.609039843082428*x_104) + 0.000177491676255093*std::exp(0.729839861392975*x_104) - 0.000274434338714435*std::exp(0.828719913959503*x_104) + 0.000639877284299031*std::exp(0.893679857254028*x_104) + 4.77678680250894e-5*std::exp(0.863839864730835*x_106) - 0.00085505647755509*std::exp(0.912479817867279*x_106) + 0.00162868388800374*std::exp(1.19687986373901*x_106) + 0.000980222212803337*std::exp(0.576399862766266*x_110) + 0.00393568100187474*std::exp(0.783999860286713*x_110) + 0.00842831248425398*std::exp(0.562159836292267*x_112) - 0.000169618866349601*std::exp(1.24383985996246*x_26) - 0.000446787267033122*std::exp(0.575999855995178*x_31) - 8.58116437585745e-5*std::exp(0.60319983959198*x_31) - 0.00293207683649757*std::exp(0.629599869251251*x_31) - 0.00023941891629511*std::exp(0.646159827709198*x_31) - 4.85543845369845e-5*std::exp(1.33207988739014*x_50) + 0.00149280355337477*std::exp(0.898319840431213*x_6) - 2.61330521550009e-5*std::exp(1.28559982776642*x_60) + 0.00036080290459679*std::exp(1.3447197675705*x_60) + 9.97379219999145e-5*std::exp(1.45263981819153*x_60) - 0.000199218209470059*std::exp(0.721199870109558*x_70) - 0.000544100089994333*std::exp(0.880959868431091*x_72) - 0.000465574492026907*std::exp(0.898639857769012*x_74) - 0.00620720492920141*std::exp(0.675999820232391*x_76) - 0.00010076405536888*std::exp(0.759759843349457*x_77) - 0.000504378653685985*std::exp(0.727279841899872*x_81) + 4.71242648790017e-6*std::exp(2.27735996246338*x_81) - 5.10981901870236e-6*std::exp(2.64103984832764*x_81) - 0.000491949108259601*std::exp(0.677599847316742*x_87) + 0.00278214717982978*std::sin(0.347919851541519*x_10 - 4.24720001220703) + 0.0249774096808303*std::sin(0.371759831905365*x_100 + 5.16815996170044) - 0.00770852260813664*std::sin(0.315839856863022*x_101 + 5.13479995727539) - 0.0267037980258695*std::sin(0.362959831953049*x_102 - 7.41792011260986) + 0.030190999189996*std::sin(0.364479839801788*x_102 - 7.41215991973877) - 0.00174894664398848*std::sin(0.372399836778641*x_102 - 7.42935991287231) + 0.000601804003975483*std::sin(0.353599846363068*x_103 - 4.24520015716553) - 0.0174326958521991*std::sin(0.331999838352203*x_105 + 5.13535976409912) - 0.011807209830521*std::sin(0.368959844112396*x_105 - 7.41703987121582) + 0.00832050151953494*std::sin(0.512159824371338*x_107 + 5.27336025238037) - 0.0134713724685026*std::sin(0.141760036349297*x_108 - 7.67880010604858) - 0.0261534985921125*std::sin(0.290719926357269*x_108 - 7.48176002502441) + 0.00812131199144118*std::sin(0.500319838523865*x_108 + 5.28128004074097) - 0.0224443002074185*std::sin(0.532639861106873*x_108 + 2.15879988670349) + 0.0206258740152738*std::sin(0.234479993581772*x_110 - 7.55600023269653) + 0.0194112010894342*std::sin(0.350399851799011*x_111 + 5.14800024032593) + 0.0101471928687103*std::sin(0.36167985200882*x_111 - 7.41599988937378) - 0.0243349779565193*std::sin(0.364639848470688*x_111 - 7.42519998550415) + 0.0005433982230641*std::sin(0.411199867725372*x_111 + 8.19527912139893) + 0.0109709574388895*std::sin(0.238559976220131*x_112 - 7.55352020263672) + 0.029976094645522*std::sin(0.42647984623909*x_112 + 5.22016000747681) - 0.000600897596337139*std::sin(0.483759850263596*x_112 - 7.34975957870483) + 0.00153379317246673*std::sin(0.561359822750092*x_112 + 2.18031978607178) + 0.0343759392373663*std::sin(0.352079838514328*x_113 + 5.14792013168335) + 0.0329716736389824*std::sin(0.23335999250412*x_114 - 7.55904006958008) - 0.00570212039205212*std::sin(0.335279852151871*x_114 + 5.12943983078003) + 0.0320920127430249*std::sin(0.456959843635559*x_114 + 5.24592018127441) - 0.075344645647711*std::sin(0.163440018892288*x_115 - 7.64416027069092) - 0.00386915040438512*std::sin(0.368639826774597*x_115 - 7.41511964797974) + 0.0130986429890565*std::sin(0.389999836683273*x_115 + 5.18383979797363) + 0.00619082359504631*std::sin(0.458079844713211*x_115 - 4.15824031829834) + 0.00128557185001342*std::sin(0.383359849452972*x_116 + 5.17575979232788) - 0.00320215764713071*std::sin(0.291759938001633*x_117 + 5.08567953109741) + 0.00793708808856779*std::sin(0.370319843292236*x_117 + 5.17880010604858) + 0.0283248987205756*std::sin(0.399759858846664*x_117 + 5.18656015396118) + 0.00188276795316659*std::sin(0.28687995672226*x_118 + 1.89631986618042) + 0.028901187997661*std::sin(0.529999852180481*x_118 - 7.22975969314575) - 0.014943865714216*std::sin(0.331279844045639*x_119 + 5.1526403427124) + 0.0190507625381009*std::sin(0.344959855079651*x_119 + 5.15152025222778) + 0.0808922961253872*std::sin(0.345199823379517*x_119 + 5.15088033676147) + 0.00198115978988566*std::sin(0.411679863929749*x_119 + 2.01143980026245) + 0.0073900193253662*std::sin(0.413199841976166*x_120 + 5.21072006225586) - 0.00626539224933808*std::sin(0.438319861888885*x_120 - 4.1812801361084) - 0.000139058030734751*std::sin(0.783199846744537*x_120 - 4.01696014404297) + 0.073139822691641*std::sin(0.221440002322197*x_14 - 4.37151956558228) + 0.00903484326066837*std::sin(0.384319841861725*x_16 + 5.19271993637085) - 0.0163473891192059*std::sin(0.385279834270477*x_16 + 5.19063997268677) - 0.00724267739174337*std::sin(0.414559870958328*x_16 + 5.20528030395508) + 0.0242951072175938*std::sin(0.417759865522385*x_2 - 4.17151975631714) + 0.0464112504455564*std::sin(0.447039872407913*x_2 - 4.14039993286133) + 0.0119725665284488*std::sin(0.258479982614517*x_24 - 7.51384019851685) - 0.10316436958947*std::sin(0.270639955997467*x_24 - 7.49720001220703) + 0.00547719610904572*std::sin(0.297439932823181*x_28 + 5.12983989715576) + 0.027715491108798*std::sin(0.305759936571121*x_28 + 5.13399982452393) + 0.043226886592148*std::sin(0.316559851169586*x_28 - 4.28560018539429) - 0.0175122018287043*std::sin(0.281359940767288*x_3 - 4.31383991241455) - 0.02273591409821*std::sin(0.2882399559021*x_33 - 1.16303980350494) - 0.00386298110151259*std::sin(0.314479857683182*x_33 - 1.18263983726501) - 0.0123674565604923*std::sin(0.341279834508896*x_34 - 7.41287994384766) - 0.0148298151804628*std::sin(0.352959841489792*x_34 + 1.99951982498169) - 0.00120828485792868*std::sin(0.311919927597046*x_35 + 8.2792797088623) + 0.0142397711424236*std::sin(0.316639840602875*x_35 - 7.43399953842163) - 0.00824291697344915*std::sin(0.319359838962555*x_35 - 7.43088006973267) + 0.0401601993029412*std::sin(0.320079833269119*x_35 - 7.43167972564697) - 0.0162644330940877*std::sin(0.320479840040207*x_35 + 1.98279976844788) - 0.00403606375900443*std::sin(0.264559954404831*x_36 - 7.52311992645264) + 0.0151827072339108*std::sin(0.300559937953949*x_36 + 5.09175968170166) + 0.0106237426968732*std::sin(0.311679929494858*x_36 + 5.10960006713867) - 0.00312086148901582*std::sin(0.202240005135536*x_37 + 4.99927997589111) + 0.00379510126136377*std::sin(0.678639829158783*x_38 + 2.21391987800598) + 0.00251900856451547*std::sin(0.47343984246254*x_39 + 8.44896030426025) + 0.026609411464075*std::sin(0.342319846153259*x_4 + 8.3264799118042) + 0.00673107601347086*std::sin(0.398239850997925*x_4 - 4.21464014053345) - 0.0445712410679669*std::sin(0.243759974837303*x_40 + 1.85207998752594) - 0.0118514379107049*std::sin(0.337839841842651*x_41 - 4.25608015060425) + 0.0641661736187161*std::sin(0.198319986462593*x_42 - 7.60856008529663) + 0.00955179356398068*std::sin(0.370559841394424*x_43 - 7.410560131073) + 0.00122305204096477*std::sin(0.370959848165512*x_43 - 4.21415996551514) - 0.0496223273990511*std::sin(0.37271985411644*x_43 - 7.42679977416992) - 0.0411941840822752*std::sin(0.294719934463501*x_45 + 5.10903978347778) + 0.0231476208647264*std::sin(0.342879861593246*x_45 - 7.43375968933105) - 0.0179561992608514*std::sin(0.519439876079559*x_45 + 5.34327983856201) - 0.00726720741070376*std::sin(0.367279827594757*x_46 - 4.23912000656128) + 0.00128930139499111*std::sin(0.57127982378006*x_46 + 2.17831993103027) - 0.0030556044695543*std::sin(0.667999863624573*x_46 - 7.14032030105591) - 0.0321302766029483*std::sin(0.356239855289459*x_47 - 4.23776006698608) - 0.0207484776698789*std::sin(0.314479827880859*x_48 - 1.26639986038208) + 0.00900132116338395*std::sin(0.370799839496613*x_48 - 7.42199993133545) + 0.0122877720570743*std::sin(0.499119848012924*x_49 + 8.48079967498779) + 0.00638812198651132*std::sin(0.324479848146439*x_51 - 7.46815967559814) - 0.0276420762577052*std::sin(0.344719856977463*x_51 - 4.25576019287109) + 0.0188288260121324*std::sin(0.392559856176376*x_51 + 2.00583982467651) - 0.0399566892138851*std::sin(0.256319969892502*x_53 + 5.06504011154175) - 0.0280140226453335*std::sin(0.331999838352203*x_53 - 4.27663993835449) - 0.00409877375431461*std::sin(0.430319845676422*x_53 + 8.42768001556396) - 0.0506451149071444*std::sin(0.0974400714039803*x_54 + 4.85640001296997) - 0.00562327770123469*std::sin(0.376319825649261*x_55 - 7.40751981735229) + 0.0144492667686866*std::sin(0.419439852237701*x_55 + 8.40575981140137) + 0.0409483254392649*std::sin(0.096000075340271*x_56 - 1.48439979553223) - 0.0944713471610256*std::sin(0.198959991335869*x_56 + 1.79975986480713) - 0.0203879611534691*std::sin(0.32151985168457*x_57 - 4.28575992584229) - 0.00149718187624938*std::sin(0.677679836750031*x_57 - 3.95703983306885) + 0.00624852491444874*std::sin(0.270799964666367*x_58 - 7.50408029556274) - 0.0602904303017269*std::sin(0.356159836053848*x_58 + 5.15912008285522) + 0.00315332698815295*std::sin(0.425279855728149*x_58 + 5.21239995956421) + 0.075278737926312*std::sin(0.272079944610596*x_59 - 7.50024032592773) + 0.00187733628161423*std::sin(0.396159827709198*x_59 - 4.19447994232178) - 0.00779107964649002*std::sin(0.403359860181808*x_59 - 4.1878399848938) - 0.394535699411834*std::sin(0.133280038833618*x_63 - 7.67183971405029) - 0.00458285170409791*std::sin(0.405439853668213*x_63 + 5.19360017776489) + 0.00422055281917718*std::sin(0.202399998903275*x_64 - 4.39472007751465) - 0.0267042044198609*std::sin(0.229839980602264*x_64 - 4.35567998886108) - 0.0703956491001087*std::sin(0.294319927692413*x_64 - 4.28071975708008) + 0.0489423548885033*std::sin(0.199039995670319*x_66 + 4.99455976486206) + 0.100868502555687*std::sin(0.165360018610954*x_67 - 4.45287990570068) + 0.0318187584383184*std::sin(0.220559984445572*x_67 - 7.56264019012451) - 0.00237218997562959*std::sin(0.289759933948517*x_67 - 7.48559999465942) - 0.0479971475464813*std::sin(0.246639966964722*x_70 + 5.05167961120605) - 0.00245927466642968*std::sin(0.760799884796143*x_70 + 2.37687993049622) + 0.171225695780975*std::sin(0.101840071380138*x_71 - 7.71872043609619) - 0.0750380558172192*std::sin(0.218639999628067*x_71 + 5.03167963027954) - 0.0411405654652878*std::sin(0.172000005841255*x_72 - 7.62408018112183) - 0.00108864676524909*std::sin(0.417839854955673*x_72 - 0.988559782505035) - 0.0510834560148725*std::sin(0.186880007386208*x_73 + 4.96799993515015) - 0.00252385775679015*std::sin(0.214399993419647*x_73 + 8.20792007446289) - 0.0316480657429655*std::sin(0.252239972352982*x_73 + 5.07247972488403) + 0.00898406434886862*std::sin(0.510879814624786*x_73 + 2.10727977752686) - 0.0732747034768476*std::sin(0.12896004319191*x_74 - 7.67944049835205) + 0.0569323714595822*std::sin(0.321839839220047*x_75 + 5.12048006057739) - 0.000599438713871572*std::sin(0.450239837169647*x_75 - 7.35103988647461) + 0.0257801665985559*std::sin(0.280479967594147*x_76 + 5.09592008590698) + 0.00396794130229304*std::sin(0.379359841346741*x_76 - 4.20864009857178) - 0.00183649705276871*std::sin(0.612719833850861*x_76 - 3.99183988571167) + 0.00899412685208706*std::sin(0.14144004881382*x_79 - 4.48799991607666) + 0.00625077224000626*std::sin(0.324319839477539*x_79 - 4.27648019790649) + 0.0516800657213983*std::sin(0.344319850206375*x_79 + 5.13976001739502) - 0.0013451040169923*std::sin(0.428879857063293*x_79 - 1.18207991123199) + 0.0404060719065327*std::sin(0.297279924154282*x_81 - 7.47096014022827) + 0.0518454926530459*std::sin(0.23463998734951*x_82 + 5.0479998588562) - 0.0476308941436167*std::sin(0.296399921178818*x_83 - 7.48288011550903) + 0.00294988447293911*std::sin(0.281279951334*x_84 - 7.50392007827759) - 0.0463766361667506*std::sin(0.285679936408997*x_84 + 5.08895969390869) + 0.0166884769133824*std::sin(0.324639827013016*x_84 - 1.08567988872528) + 0.0189221841320257*std::sin(0.184720009565353*x_85 + 1.77711987495422) + 0.014539931056666*std::sin(0.202799841761589*x_85 - 1.36799991130829) + 0.00312813390814066*std::sin(0.213839992880821*x_85 + 5.00920009613037) + 0.0101950459028533*std::sin(0.271919965744019*x_86 + 5.07535982131958) - 0.00116922706376484*std::sin(0.294719934463501*x_86 - 7.4986400604248) + 0.0548281339947244*std::sin(0.310959845781326*x_86 - 4.30808019638062) + 0.0377793937797505*std::sin(0.434079855680466*x_86 + 5.24151992797852) + 0.0677961863236737*std::sin(0.150880038738251*x_87 + 4.91951942443848) + 0.00221464278806061*std::sin(0.306479841470718*x_87 - 4.31288003921509) - 0.000103605059395729*std::sin(0.950239837169647*x_87 - 3.83208012580872) + 0.0595468056004879*std::sin(0.191359996795654*x_88 - 7.60824012756348) - 0.00288930901743183*std::sin(0.212960004806519*x_88 - 7.57991981506348) - 0.0482309177613095*std::sin(0.204080000519753*x_89 - 4.40327978134155) - 0.00144815228805761*std::sin(0.285919934511185*x_89 - 7.49544048309326) - 0.00662945962055857*std::sin(0.274079948663712*x_90 - 7.50888013839722) + 0.00161112591260434*std::sin(0.361039847135544*x_92 + 1.97879981994629) - 0.00619194285503964*std::sin(0.362799853086472*x_92 + 1.98575985431671) + 0.0222351089033616*std::sin(0.363679856061935*x_92 + 2.00567984580994) - 0.0247059232525292*std::sin(0.369039833545685*x_92 + 2.00383973121643) - 0.0745612986409505*std::sin(0.270719945430756*x_93 - 1.36999988555908) + 0.0367697109445806*std::sin(0.343679845333099*x_93 + 1.97367978096008) - 0.00462575534478871*std::sin(0.365119844675064*x_95 + 5.18239974975586) + 0.0193318483072374*std::sin(0.376399844884872*x_95 + 1.9883998632431) + 0.044192446338233*std::sin(0.381439834833145*x_95 - 7.42175960540771) - 0.000193173888198743*std::sin(0.43615984916687*x_95 + 5.22552013397217) - 0.0049042349876477*std::sin(0.403999865055084*x_96 - 7.39807987213135) - 0.0016527823866282*std::sin(0.421199858188629*x_96 + 5.20864009857178) - 0.234455366426096*std::sin(0.114480063319206*x_97 + 1.71391987800598) - 0.000245667627028991*std::sin(0.437599837779999*x_97 + 5.21184015274048) + 0.0113460670704165*std::sin(0.363839834928513*x_98 + 5.17519998550415) - 0.00442274802784409*std::sin(0.42375984787941*x_98 + 2.02567982673645) - 0.0563115673243737*std::sin(0.366159856319427*x_99 - 7.4347996711731) + 0.0386060919594479*std::sin(0.376159846782684*x_99 + 1.98311984539032) + 0.0105499878421871*std::sin(0.406079858541489*x_99 + 5.20360040664673) + 0.00174325346675659*std::sin(0.441999852657318*x_99 - 4.16584014892578) + 0.135510278809451 + 6.6895364306867e-5*std::exp(-1.2125598192215*x_9));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0774623749304446*x_1 + 0.0669442902832347*x_10 + 0.00135384583467638*x_100 + 0.109161693826258*x_101 - 0.000654422343312301*x_102 + 0.0312604997086376*x_103 + 0.00123615852141213*x_104 + 0.000833694476974555*x_105 - 0.00158843186551807*x_106 + 0.00258929825474288*x_107 + 1.73952590843482e-5*x_108 + 0.0311041917501082*x_109 + 0.00224819474062773*x_11 + 0.000678459118720719*x_110 - 8.81541524814329e-6*x_111 + 0.00206554353848019*x_113 - 0.00153373284504781*x_114 - 0.00140134744103022*x_115 - 0.0245413072626573*x_116 - 0.0171574255908119*x_117 - 0.0120465154456828*x_118 - 2.14974592919466e-5*x_119 - 0.00828409042618006*x_12 + 0.000616365351821373*x_120 - 0.018083584457817*x_13 - 0.00150806911440112*x_14 + 0.0117994282785014*x_15 - 0.000189380641748413*x_16 + 0.00634443875823048*x_17 - 0.013723435649474*x_18 + 0.0383991259209702*x_19 - 0.00756867885949223*x_2 + 0.0293136060274097*x_20 - 0.00717096722480494*x_21 - 0.00370775280571419*x_22 - 0.000918968330421245*x_23 + 0.00288877057818911*x_24 - 0.0427900659803175*x_25 - 0.0100341198819505*x_26 - 0.0113551603952707*x_27 - 0.000804567032185768*x_28 + 0.00268405942390227*x_29 - 0.0227226045199849*x_3 - 0.00102469860117098*x_30 + 0.0265720194393295*x_31 - 0.0224325867154121*x_32 - 0.0460754274546056*x_33 - 0.0184865917202333*x_34 + 0.00552116328063468*x_36 - 0.00957791144616071*x_37 - 0.000147566801877918*x_38 + 0.000375242687627641*x_39 - 0.00700368967201257*x_4 + 0.000213363424170783*x_40 + 0.0244931827465833*x_41 + 0.00847197617913599*x_42 + 0.000727284199953922*x_43 - 0.0218176522469926*x_44 + 5.15667904536773e-5*x_45 + 0.00335421767294766*x_46 - 0.00971805942691259*x_47 + 0.0105829457909562*x_48 - 0.00144893765636352*x_49 - 0.000217640986804823*x_5 + 0.00952590930921145*x_50 + 0.00237735464004266*x_51 - 0.00948341799287088*x_52 - 0.00107611737067857*x_53 - 0.0154941063317284*x_54 - 0.00202512332973701*x_55 + 0.0011830042338165*x_56 - 0.0103339374486822*x_57 - 0.0181945193505854*x_58 - 0.00329926996393567*x_59 + 0.00325123267667993*x_6 - 0.0120767561294487*x_60 + 0.0507917520887751*x_61 - 0.00927632012694588*x_62 - 0.00346406309607611*x_63 - 0.0140409037921779*x_64 - 0.0557597720173841*x_65 + 0.000226639546627723*x_66 - 0.00548783676102161*x_67 - 0.00136982054998353*x_68 - 0.00278095435814707*x_69 + 0.0140608870573755*x_7 - 6.6730463123299e-6*x_70 + 0.00358615806401302*x_71 + 0.00227686069254905*x_72 - 6.05607828382363e-6*x_73 - 0.00231865362761683*x_74 + 0.000760347918422689*x_75 - 0.0139932484850312*x_76 - 0.00725673438600185*x_77 + 0.0026851552589779*x_78 + 0.0128711984402066*x_79 - 0.0483044186805325*x_8 - 0.00519199115476963*x_80 - 0.0157372809427774*x_81 - 0.00499775795044224*x_82 - 0.00310641037098222*x_83 + 5.13866736675467e-5*x_84 - 0.0167550571915283*x_85 + 0.000743787663998235*x_86 - 0.0027455736343816*x_87 + 0.000826296799862533*x_88 + 0.00466568675523876*x_89 - 0.0210118177802941*x_9 + 0.00356298620838742*x_90 - 0.0026728200737112*x_91 - 0.00277867335137702*x_92 - 0.019358257552481*x_93 + 0.00402969065907199*x_94 - 9.78628960721784e-5*x_95 + 0.00161891428472256*x_96 + 0.00210521487840773*x_97 + 0.00185987647168376*x_98 - 2.46326874041601e-5*x_99 - 2.71838436536793e-7*std::pow(-7.87296009063721*x_106 - 9.04559993743896, 2) - 0.000112096529563382*std::pow(-7.23343992233276*x_107 - 9.84928035736084, 2) + 0.000236915656762638*std::pow(-3.99151992797852*x_110 - 5.38871955871582, 2) - 1.69471038988708e-5*std::pow(-8.07431983947754*x_116 - 9.47160053253174, 2) - 7.3855774104997e-5*std::pow(-8.54367923736572*x_120 - 9.14231967926025, 2) + 2.96850130717815e-5*std::pow(-7.97567987442017*x_13 - 9.75928020477295, 2) - 0.000644943220691941*std::pow(-2.19231986999512*x_13 - 3.18535995483398, 2) - 3.96453826649468e-5*std::pow(-6.53927993774414*x_14 - 9.78439998626709, 2) + 5.24247551971175e-5*std::pow(-6.46400022506714*x_14 - 8.68704032897949, 2) + 6.29490052831991e-5*std::pow(-5.62559986114502*x_15 - 7.82880020141602, 2) + 0.000380395761775*std::pow(-6.89976024627686*x_17 - 9.1307201385498, 2) - 3.11536635855366e-5*std::pow(-6.92984008789063*x_19 - 9.97432041168213, 2) - 5.55213616440789e-5*std::pow(-6.88104009628296*x_23 - 8.10231971740723, 2) - 0.00030136322491327*std::pow(-5.86168003082275*x_27 - 8.08047962188721, 2) - 4.7987214258357e-5*std::pow(-4.25631999969482*x_27 - 5.47039985656738, 2) + 9.50667568209018e-6*std::pow(-7.61320018768311*x_36 - 9.01000022888184, 2) + 2.94282580768224e-5*std::pow(-5.53175973892212*x_52 - 7.57728004455566, 2) - 2.61118543681676e-7*std::pow(-8.06855964660645*x_56 - 7.47832012176514, 2) + 1.78731263653761e-5*std::pow(-7.14911985397339*x_68 - 9.59352016448975, 2) - 0.000161357255753044*std::pow(-7.14143991470337*x_68 - 9.17271995544434, 2) + 3.12868684900414e-5*std::pow(-5.12191963195801*x_7 - 7.37095975875854, 2) - 1.52875905572461e-5*std::pow(-4.89592027664185*x_7 - 7.74936008453369, 2) + 6.50292284157832e-6*std::pow(-7.63944053649902*x_70 - 9.65192031860352, 2) - 5.95796087898853e-6*std::pow(-9.15408039093018*x_72 - 9.7540807723999, 2) - 0.000140773973846684*std::pow(-6.66584014892578*x_74 - 8.27351951599121, 2) + 4.81353343478531e-5*std::pow(-6.94191980361938*x_77 - 9.79944038391113, 2) - 4.74958888421474e-6*std::pow(-1.50623989105225*x_77 - 2.36735987663269, 2) + 3.78262891469938e-5*std::pow(-7.40000009536743*x_78 - 9.99612045288086, 2) - 1.3901598673339e-5*std::pow(-7.37215995788574*x_78 - 8.56719970703125, 2) - 4.52197902100699e-5*std::pow(-7.31472015380859*x_80 - 9.95207977294922, 2) - 1.91612501624334e-7*std::pow(-7.1406397819519*x_80 - 9.58688068389893, 2) - 7.50214497994845e-6*std::pow(-6.15687990188599*x_84 - 6.77792024612427, 2) + 7.74471126185279e-5*std::pow(-8.07520008087158*x_88 - 7.66735982894897, 2) - 3.65014032574765e-7*std::pow(-5.88727998733521*x_90 - 8.93711948394775, 2) - 9.84311469775557e-5*std::pow(-4.83951997756958*x_90 - 7.24056005477905, 2) + 0.00344550963020829*std::exp(0.460399866104126*x_1) - 0.000475837489118173*std::exp(1.18103992938995*x_1) - 3.73046269276268e-6*std::exp(1.18375980854034*x_1) + 0.00519301678736637*std::exp(0.595759809017181*x_100) - 2.17847384732944e-6*std::exp(1.62599992752075*x_100) + 0.00207694676537259*std::exp(1.66631984710693*x_100) - 0.0153155569567592*std::exp(0.609039843082428*x_104) - 0.00146085836781579*std::exp(0.729839861392975*x_104) - 1.58991091421389e-5*std::exp(0.828719913959503*x_104) - 0.00134346946879636*std::exp(0.893679857254028*x_104) - 0.000393156970453537*std::exp(0.863839864730835*x_106) + 0.00405645062018456*std::exp(0.912479817867279*x_106) + 0.00446447707492638*std::exp(1.19687986373901*x_106) + 5.67883014126956e-5*std::exp(0.576399862766266*x_110) + 0.0107883167117404*std::exp(0.783999860286713*x_110) - 0.0399845323686921*std::exp(0.562159836292267*x_112) + 0.000804684338005626*std::exp(1.24383985996246*x_26) - 2.58842226346507e-5*std::exp(0.575999855995178*x_31) + 0.000180167863879036*std::exp(0.60319983959198*x_31) + 0.0139099874850934*std::exp(0.629599869251251*x_31) + 0.00197055509679466*std::exp(0.646159827709198*x_31) + 0.000399630452771524*std::exp(1.33207988739014*x_50) - 0.00313425096667829*std::exp(0.898319840431213*x_6) + 0.000215090018431803*std::exp(1.28559982776642*x_60) - 0.000757532262002143*std::exp(1.3447197675705*x_60) + 0.000273397231684526*std::exp(1.45263981819153*x_60) + 0.0016396802062275*std::exp(0.721199870109558*x_70) - 0.00149146338103855*std::exp(0.880959868431091*x_72) - 2.6972643792343e-5*std::exp(0.898639857769012*x_74) + 0.0294474352813139*std::exp(0.675999820232391*x_76) + 0.000829346009720042*std::exp(0.759759843349457*x_77) + 0.00105898011785501*std::exp(0.727279841899872*x_81) - 3.87859747161986e-5*std::exp(2.27735996246338*x_81) - 2.96032816649313e-7*std::exp(2.64103984832764*x_81) + 0.00103288337211781*std::exp(0.677599847316742*x_87) - 0.00584132283722776*std::sin(0.347919851541519*x_10 - 4.24720001220703) + 0.0684669835150079*std::sin(0.371759831905365*x_100 + 5.16815996170044) - 0.000446586396022908*std::sin(0.315839856863022*x_101 + 5.13479995727539) + 0.126684775692308*std::sin(0.362959831953049*x_102 - 7.41792011260986) - 0.0633882255855487*std::sin(0.364479839801788*x_102 - 7.41215991973877) + 0.0143948346967094*std::sin(0.372399836778641*x_102 - 7.42935991287231) - 0.00495319236113985*std::sin(0.353599846363068*x_103 - 4.24520015716553) + 0.0827019872457326*std::sin(0.331999838352203*x_105 + 5.13535976409912) + 0.0247901063347706*std::sin(0.368959844112396*x_105 - 7.41703987121582) - 0.0174695055299775*std::sin(0.512159824371338*x_107 + 5.27336025238037) + 0.110877127377463*std::sin(0.141760036349297*x_108 - 7.67880010604858) + 0.124074114831948*std::sin(0.290719926357269*x_108 - 7.48176002502441) - 0.0170512924505883*std::sin(0.500319838523865*x_108 + 5.28128004074097) - 0.0615233345628548*std::sin(0.532639861106873*x_108 + 2.15879988670349) - 0.0433055410571675*std::sin(0.234479993581772*x_110 - 7.55600023269653) + 0.0532091358543395*std::sin(0.350399851799011*x_111 + 5.14800024032593) - 0.0213047785061389*std::sin(0.36167985200882*x_111 - 7.41599988937378) + 0.115446919607179*std::sin(0.364639848470688*x_111 - 7.42519998550415) - 0.00447247926194875*std::sin(0.411199867725372*x_111 + 8.19527912139893) - 0.0230343328701826*std::sin(0.238559976220131*x_112 - 7.55352020263672) + 0.0821691602197817*std::sin(0.42647984623909*x_112 + 5.22016000747681) + 0.00494573210603907*std::sin(0.483759850263596*x_112 - 7.34975957870483) + 8.8858942232776e-5*std::sin(0.561359822750092*x_112 + 2.18031978607178) - 0.072174815327587*std::sin(0.352079838514328*x_113 + 5.14792013168335) - 0.0692264563159424*std::sin(0.23335999250412*x_114 - 7.55904006958008) + 0.0469317235871414*std::sin(0.335279852151871*x_114 + 5.12943983078003) + 0.0879692224100583*std::sin(0.456959843635559*x_114 + 5.24592018127441) - 0.20653144891422*std::sin(0.163440018892288*x_115 - 7.64416027069092) - 0.000224155784785667*std::sin(0.368639826774597*x_115 - 7.41511964797974) - 0.0275015653317631*std::sin(0.389999836683273*x_115 + 5.18383979797363) - 0.0293697210310425*std::sin(0.458079844713211*x_115 - 4.15824031829834) - 0.0105809941860113*std::sin(0.383359849452972*x_116 + 5.17575979232788) + 0.0263555953303021*std::sin(0.291759938001633*x_117 + 5.08567953109741) + 0.00045982813368782*std::sin(0.370319843292236*x_117 + 5.17880010604858) - 0.0594702102599707*std::sin(0.399759858846664*x_117 + 5.18656015396118) - 0.0154962608786557*std::sin(0.28687995672226*x_118 + 1.89631986618042) - 0.13710935482578*std::sin(0.529999852180481*x_118 - 7.22975969314575) - 0.0409634714159722*std::sin(0.331279844045639*x_119 + 5.1526403427124) - 0.0399984785446256*std::sin(0.344959855079651*x_119 + 5.15152025222778) - 0.383758983645427*std::sin(0.345199823379517*x_119 + 5.15088033676147) - 0.0163060821673411*std::sin(0.411679863929749*x_119 + 2.01143980026245) + 0.0202571979156734*std::sin(0.413199841976166*x_120 + 5.21072006225586) + 0.0131546523115601*std::sin(0.438319861888885*x_120 - 4.1812801361084) - 8.05620323644438e-6*std::sin(0.783199846744537*x_120 - 4.01696014404297) - 0.346980681283221*std::sin(0.221440002322197*x_14 - 4.37151956558228) - 0.0189693186082788*std::sin(0.384319841861725*x_16 + 5.19271993637085) + 0.0775532125323605*std::sin(0.385279834270477*x_16 + 5.19063997268677) - 0.0198533106483654*std::sin(0.414559870958328*x_16 + 5.20528030395508) - 0.115257769898491*std::sin(0.417759865522385*x_2 - 4.17151975631714) + 0.12722049082638*std::sin(0.447039872407913*x_2 - 4.14039993286133) - 0.0251372848963136*std::sin(0.258479982614517*x_24 - 7.51384019851685) - 0.282789660027854*std::sin(0.270639955997467*x_24 - 7.49720001220703) + 0.000317316481379653*std::sin(0.297439932823181*x_28 + 5.12983989715576) - 0.131484321852599*std::sin(0.305759936571121*x_28 + 5.13399982452393) + 0.118491651837747*std::sin(0.316559851169586*x_28 - 4.28560018539429) + 0.0367681570600484*std::sin(0.281359940767288*x_3 - 4.31383991241455) + 0.0477357255611648*std::sin(0.2882399559021*x_33 - 1.16303980350494) - 0.000223798371714982*std::sin(0.314479857683182*x_33 - 1.18263983726501) - 0.0339011312730191*std::sin(0.341279834508896*x_34 - 7.41287994384766) + 0.0311362888036729*std::sin(0.352959841489792*x_34 + 1.99951982498169) + 0.00994487788189772*std::sin(0.311919927597046*x_35 + 8.2792797088623) - 0.0298974479043287*std::sin(0.316639840602875*x_35 - 7.43399953842163) - 0.000477546057918166*std::sin(0.319359838962555*x_35 - 7.43088006973267) + 0.110085382702603*std::sin(0.320079833269119*x_35 - 7.43167972564697) + 0.0771596630670652*std::sin(0.320479840040207*x_35 + 1.98279976844788) - 0.000233825761417616*std::sin(0.264559954404831*x_36 - 7.52311992645264) + 0.0416181733486626*std::sin(0.300559937953949*x_36 + 5.09175968170166) - 0.0223053299559349*std::sin(0.311679929494858*x_36 + 5.10960006713867) + 0.0256864812886796*std::sin(0.202240005135536*x_37 + 4.99927997589111) + 0.0104029656725773*std::sin(0.678639829158783*x_38 + 2.21391987800598) + 0.000145936519040674*std::sin(0.47343984246254*x_39 + 8.44896030426025) - 0.126236998922962*std::sin(0.342319846153259*x_4 + 8.3264799118042) - 0.055400618925649*std::sin(0.398239850997925*x_4 - 4.21464014053345) - 0.122176737557619*std::sin(0.243759974837303*x_40 + 1.85207998752594) + 0.0248829664453707*std::sin(0.337839841842651*x_41 - 4.25608015060425) - 0.134721605691421*std::sin(0.198319986462593*x_42 - 7.60856008529663) - 0.0200546938301011*std::sin(0.370559841394424*x_43 - 7.410560131073) - 0.0100664202739834*std::sin(0.370959848165512*x_43 - 4.21415996551514) + 0.235411959369565*std::sin(0.37271985411644*x_43 - 7.42679977416992) + 0.195428229543792*std::sin(0.294719934463501*x_45 + 5.10903978347778) - 0.0486001342290197*std::sin(0.342879861593246*x_45 - 7.43375968933105) - 0.0492207484480849*std::sin(0.519439876079559*x_45 + 5.34327983856201) + 0.0152580370006205*std::sin(0.367279827594757*x_46 - 4.23912000656128) + 7.46945287244307e-5*std::sin(0.57127982378006*x_46 + 2.17831993103027) + 0.0144960116330604*std::sin(0.667999863624573*x_46 - 7.14032030105591) + 0.0674598812916612*std::sin(0.356239855289459*x_47 - 4.23776006698608) - 0.0568748199568262*std::sin(0.314479827880859*x_48 - 1.26639986038208) - 0.0188989364969948*std::sin(0.370799839496613*x_48 - 7.42199993133545) - 0.0582940915483495*std::sin(0.499119848012924*x_49 + 8.48079967498779) - 0.0134123324306259*std::sin(0.324479848146439*x_51 - 7.46815967559814) - 0.0757712510480782*std::sin(0.344719856977463*x_51 - 4.25576019287109) - 0.0893253310853269*std::sin(0.392559856176376*x_51 + 2.00583982467651) - 0.109527529743045*std::sin(0.256319969892502*x_53 + 5.06504011154175) + 0.132900577349531*std::sin(0.331999838352203*x_53 - 4.27663993835449) + 0.00860567726584923*std::sin(0.430319845676422*x_53 + 8.42768001556396) + 0.416838363703105*std::sin(0.0974400714039803*x_54 + 4.85640001296997) + 0.0118064855426899*std::sin(0.376319825649261*x_55 - 7.40751981735229) - 0.0685483809357781*std::sin(0.419439852237701*x_55 + 8.40575981140137) - 0.337028220861585*std::sin(0.096000075340271*x_56 - 1.48439979553223) + 0.448178997341522*std::sin(0.198959991335869*x_56 + 1.79975986480713) + 0.0967219825078281*std::sin(0.32151985168457*x_57 - 4.28575992584229) - 8.6737899373775e-5*std::sin(0.677679836750031*x_57 - 3.95703983306885) - 0.0131192381001171*std::sin(0.270799964666367*x_58 - 7.50408029556274) - 0.165265491911644*std::sin(0.356159836053848*x_58 + 5.15912008285522) + 0.000182685192313577*std::sin(0.425279855728149*x_58 + 5.21239995956421) - 0.357127851976568*std::sin(0.272079944610596*x_59 - 7.50024032592773) - 0.0154515551042448*std::sin(0.396159827709198*x_59 - 4.19447994232178) + 0.0163579453292931*std::sin(0.403359860181808*x_59 - 4.1878399848938) - 1.08148401186869*std::sin(0.133280038833618*x_63 - 7.67183971405029) + 0.00962203456123884*std::sin(0.405439853668213*x_63 + 5.19360017776489) - 0.0347375721092532*std::sin(0.202399998903275*x_64 - 4.39472007751465) + 0.0560674432534068*std::sin(0.229839980602264*x_64 - 4.35567998886108) + 0.333962120568852*std::sin(0.294319927692413*x_64 - 4.28071975708008) - 0.232186119925594*std::sin(0.199039995670319*x_66 + 4.99455976486206) + 0.276496329680019*std::sin(0.165360018610954*x_67 - 4.45287990570068) - 0.0668058259697657*std::sin(0.220559984445572*x_67 - 7.56264019012451) - 0.00013743071477534*std::sin(0.289759933948517*x_67 - 7.48559999465942) + 0.227701986994736*std::sin(0.246639966964722*x_70 + 5.05167961120605) - 0.00674125620698552*std::sin(0.760799884796143*x_70 + 2.37687993049622) - 0.359500954635626*std::sin(0.101840071380138*x_71 - 7.71872043609619) + 0.355986038404804*std::sin(0.218639999628067*x_71 + 5.03167963027954) + 0.0863776461328521*std::sin(0.172000005841255*x_72 - 7.62408018112183) - 6.30697813510219e-5*std::sin(0.417839854955673*x_72 - 0.988559782505035) + 0.107253476878406*std::sin(0.186880007386208*x_73 + 4.96799993515015) + 0.0207727979191807*std::sin(0.214399993419647*x_73 + 8.20792007446289) + 0.150140744243906*std::sin(0.252239972352982*x_73 + 5.07247972488403) + 0.024626724449487*std::sin(0.510879814624786*x_73 + 2.10727977752686) + 0.153845634736186*std::sin(0.12896004319191*x_74 - 7.67944049835205) - 0.270091344347393*std::sin(0.321839839220047*x_75 + 5.12048006057739) + 0.00493372466601456*std::sin(0.450239837169647*x_75 - 7.35103988647461) + 0.0706674656848888*std::sin(0.280479967594147*x_76 + 5.09592008590698) - 0.0326584343376517*std::sin(0.379359841346741*x_76 - 4.20864009857178) - 0.00010639582210435*std::sin(0.612719833850861*x_76 - 3.99183988571167) - 0.0188838315107521*std::sin(0.14144004881382*x_79 - 4.48799991607666) + 0.000362132925974413*std::sin(0.324319839477539*x_79 - 4.27648019790649) + 0.141663136931174*std::sin(0.344319850206375*x_79 + 5.13976001739502) + 0.0110709780890328*std::sin(0.428879857063293*x_79 - 1.18207991123199) + 0.110759357935103*std::sin(0.297279924154282*x_81 - 7.47096014022827) - 0.108853428904538*std::sin(0.23463998734951*x_82 + 5.0479998588562) + 0.225964453998737*std::sin(0.296399921178818*x_83 - 7.48288011550903) - 0.0242792423132537*std::sin(0.281279951334*x_84 - 7.50392007827759) - 0.127125607678501*std::sin(0.285679936408997*x_84 + 5.08895969390869) - 0.0791713580356619*std::sin(0.324639827013016*x_84 - 1.08567988872528) - 0.039728518714597*std::sin(0.184720009565353*x_85 + 1.77711987495422) + 0.000842357963919578*std::sin(0.202799841761589*x_85 - 1.36799991130829) - 0.0257463374721183*std::sin(0.213839992880821*x_85 + 5.00920009613037) + 0.000590640909872604*std::sin(0.271919965744019*x_86 + 5.07535982131958) + 0.00962340981851282*std::sin(0.294719934463501*x_86 - 7.4986400604248) - 0.260108687536529*std::sin(0.310959845781326*x_86 - 4.30808019638062) + 0.10355922268074*std::sin(0.434079855680466*x_86 + 5.24151992797852) + 0.185839942200486*std::sin(0.150880038738251*x_87 + 4.91951942443848) - 0.0182277812510569*std::sin(0.306479841470718*x_87 - 4.31288003921509) - 6.00226689825617e-6*std::sin(0.950239837169647*x_87 - 3.83208012580872) - 0.125022902440184*std::sin(0.191359996795654*x_88 - 7.60824012756348) - 0.000167389546179625*std::sin(0.212960004806519*x_88 - 7.57991981506348) + 0.101264362799393*std::sin(0.204080000519753*x_89 - 4.40327978134155) + 0.0119191245049715*std::sin(0.285919934511185*x_89 - 7.49544048309326) + 0.0545642576887434*std::sin(0.274079948663712*x_90 - 7.50888013839722) - 0.013260490974519*std::sin(0.361039847135544*x_92 + 1.97879981994629) - 0.000358724697919824*std::sin(0.362799853086472*x_92 + 1.98575985431671) - 0.046684248183232*std::sin(0.363679856061935*x_92 + 2.00567984580994) + 0.117206711288258*std::sin(0.369039833545685*x_92 + 2.00383973121643) - 0.204384172343761*std::sin(0.270719945430756*x_93 - 1.36999988555908) - 0.077200715266251*std::sin(0.343679845333099*x_93 + 1.97367978096008) - 0.000267989018561399*std::sin(0.365119844675064*x_95 + 5.18239974975586) - 0.0917117057336772*std::sin(0.376399844884872*x_95 + 1.9883998632431) + 0.121138402003706*std::sin(0.381439834833145*x_95 - 7.42175960540771) + 0.00158993197299611*std::sin(0.43615984916687*x_95 + 5.22552013397217) + 0.0102968024266174*std::sin(0.403999865055084*x_96 - 7.39807987213135) - 9.57524764441013e-5*std::sin(0.421199858188629*x_96 + 5.20864009857178) + 1.11227344802316*std::sin(0.114480063319206*x_97 + 1.71391987800598) + 0.00202198557261332*std::sin(0.437599837779999*x_97 + 5.21184015274048) - 0.0538265740481234*std::sin(0.363839834928513*x_98 + 5.17519998550415) - 0.000256227970349011*std::sin(0.42375984787941*x_98 + 2.02567982673645) + 0.267146204014113*std::sin(0.366159856319427*x_99 - 7.4347996711731) + 0.105825331591331*std::sin(0.376159846782684*x_99 + 1.98311984539032) - 0.0221504762083842*std::sin(0.406079858541489*x_99 + 5.20360040664673) - 0.0143479765804634*std::sin(0.441999852657318*x_99 - 4.16584014892578) - 2.80160127678239 + 3.87552338821831e-6*std::exp(-1.2125598192215*x_9));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.107652138612799*x_1 + 0.096147426761998*x_10 - 0.000208325564032728*x_100 - 0.00642970681413786*x_101 + 0.000177066273567057*x_102 + 0.0413626527484889*x_103 + 0.00173083391020743*x_104 + 0.00183731054413516*x_105 + 0.000244422928989335*x_106 + 0.00308928343781232*x_107 - 6.47007034580298e-5*x_108 + 0.025598758856009*x_109 + 0.00857853395137509*x_11 + 0.00116157334524299*x_110 + 3.27884491437504e-5*x_111 + 0.0159135805489113*x_113 - 0.0021917751462893*x_114 - 0.00239921284865983*x_115 + 0.00197869248269873*x_116 - 0.0279885973728418*x_117 + 0.003641536782127*x_118 + 7.99586101020364e-5*x_119 + 0.019579900581685*x_12 + 0.00105526411813435*x_120 - 0.0255280867741994*x_13 + 0.000538588670676715*x_14 + 0.000424128584140846*x_15 - 0.000248840817678705*x_16 - 0.000883371630193845*x_17 + 0.000966543870710273*x_18 + 0.0392189731187889*x_19 - 0.00256594303838765*x_2 + 0.0188885585249441*x_20 - 0.00174932118541198*x_21 + 0.00712520959413507*x_22 + 0.00609357437459849*x_23 + 0.00415261538445491*x_24 - 0.0358689079359741*x_25 - 0.000818325161260849*x_26 + 0.00266249754410161*x_27 - 8.05907982112549e-5*x_28 + 0.0202945757458922*x_29 - 0.0164672675902793*x_3 + 0.00551295028422538*x_30 - 0.0077234149914951*x_31 - 0.0317087787868147*x_32 - 0.0287562100262178*x_33 - 0.0254353569186772*x_34 + 0.00773057537879371*x_36 - 0.0139417184205505*x_37 - 0.00564278080407037*x_38 + 0.0216408167495034*x_39 + 0.00143832099322567*x_4 - 0.000752868485879733*x_40 + 0.0244817930560348*x_41 + 0.0287657321265528*x_42 - 0.000192277150296026*x_43 - 0.0146940800010882*x_44 + 1.52034882274877e-5*x_45 - 0.000907211712726171*x_46 + 0.0275395528292575*x_47 + 0.014995736127235*x_48 + 0.00363995712436465*x_49 + 0.0158558670984957*x_5 + 0.00330748777378999*x_50 + 0.00413580026445724*x_51 + 0.00920331939654476*x_52 - 0.00177549814272877*x_53 - 0.00872079646897377*x_54 - 0.00209339097444339*x_55 - 0.000876807117166881*x_56 + 0.00414166682201204*x_57 - 0.0245938406710054*x_58 + 0.000996544106437914*x_59 + 0.00794549158403205*x_6 - 0.0168331438887873*x_60 + 0.0466210309231798*x_61 - 0.0293478234250315*x_62 - 0.00524201840510656*x_63 + 0.00420136152577821*x_64 - 0.0458756464415074*x_65 - 0.0011488101087112*x_66 - 0.00831599452688164*x_67 - 0.00205034466881155*x_68 + 0.0239459589063343*x_69 + 0.0200579516893646*x_7 + 2.48200264521633e-5*x_70 + 0.0045843055577871*x_71 + 0.00318799541257898*x_72 + 2.25252480150093e-5*x_73 - 0.00368931479279827*x_74 - 0.000126067206931644*x_75 + 0.00215323732483254*x_76 - 0.00152677278202672*x_77 - 0.000490304056399028*x_78 + 0.0180218850086228*x_79 - 0.108385216926705*x_8 - 0.00654685488069588*x_80 - 0.0220348919967839*x_81 - 0.0128570230439327*x_82 + 0.0028937167265873*x_83 - 0.000191129888812637*x_84 - 0.00273777485204236*x_85 - 0.000114451720169495*x_86 - 0.00384427390746822*x_87 + 0.00362215898596055*x_88 - 0.0124942041507556*x_89 - 0.0110335881802396*x_9 + 0.00818785106419586*x_90 + 0.0181109113520791*x_91 + 0.000807648341048884*x_92 - 0.0270008480432312*x_93 + 0.0121414709192273*x_94 + 1.50588364641874e-5*x_95 - 0.00781698475431108*x_96 - 0.000707399496237219*x_97 - 0.00109619625700372*x_98 + 9.16199175524164e-5*x_99 + 1.01108802033807e-6*std::pow(-7.87296009063721*x_106 - 9.04559993743896, 2) + 3.25819427801172e-5*std::pow(-7.23343992233276*x_107 - 9.84928035736084, 2) + 0.000331722546486517*std::pow(-3.99151992797852*x_110 - 5.38871955871582, 2) + 2.60776736023082e-6*std::pow(-8.07431983947754*x_116 - 9.47160053253174, 2) - 0.000103410748760215*std::pow(-8.54367923736572*x_120 - 9.14231967926025, 2) - 4.56783699672575e-6*std::pow(-7.97567987442017*x_13 - 9.75928020477295, 2) + 0.000187458998015882*std::pow(-2.19231986999512*x_13 - 3.18535995483398, 2) + 6.10050752709421e-6*std::pow(-6.53927993774414*x_14 - 9.78439998626709, 2) + 8.97551474916909e-5*std::pow(-6.46400022506714*x_14 - 8.68704032897949, 2) + 0.000107773459931376*std::pow(-5.62559986114502*x_15 - 7.82880020141602, 2) + 0.000532619297909488*std::pow(-6.89976024627686*x_17 - 9.1307201385498, 2) + 4.79382834582062e-6*std::pow(-6.92984008789063*x_19 - 9.97432041168213, 2) + 8.54345353371249e-6*std::pow(-6.88104009628296*x_23 - 8.10231971740723, 2) - 0.000421960193562794*std::pow(-5.86168003082275*x_27 - 8.08047962188721, 2) + 7.38412249066842e-6*std::pow(-4.25631999969482*x_27 - 5.47039985656738, 2) + 1.62761480677089e-5*std::pow(-7.61320018768311*x_36 - 9.01000022888184, 2) - 4.52832834088542e-6*std::pow(-5.53175973892212*x_52 - 7.57728004455566, 2) + 9.71215972134729e-7*std::pow(-8.06855964660645*x_56 - 7.47832012176514, 2) - 2.75026080202496e-6*std::pow(-7.14911985397339*x_68 - 9.59352016448975, 2) + 4.69000502921884e-5*std::pow(-7.14143991470337*x_68 - 9.17271995544434, 2) + 5.35654861013296e-5*std::pow(-5.12191963195801*x_7 - 7.37095975875854, 2) + 2.35240663594537e-6*std::pow(-4.89592027664185*x_7 - 7.74936008453369, 2) - 1.00064943447342e-6*std::pow(-7.63944053649902*x_70 - 9.65192031860352, 2) - 1.02004798197463e-5*std::pow(-9.15408039093018*x_72 - 9.7540807723999, 2) + 4.09173199087217e-5*std::pow(-6.66584014892578*x_74 - 8.27351951599121, 2) - 7.40691474691984e-6*std::pow(-6.94191980361938*x_77 - 9.79944038391113, 2) + 1.76658329982354e-5*std::pow(-1.50623989105225*x_77 - 2.36735987663269, 2) - 5.82059110422733e-6*std::pow(-7.40000009536743*x_78 - 9.99612045288086, 2) - 1.94646220311803e-5*std::pow(-7.37215995788574*x_78 - 8.56719970703125, 2) + 1.31435703040239e-5*std::pow(-7.31472015380859*x_80 - 9.95207977294922, 2) + 7.12692095376848e-7*std::pow(-7.1406397819519*x_80 - 9.58688068389893, 2) + 1.15440661290409e-6*std::pow(-6.15687990188599*x_84 - 6.77792024612427, 2) + 0.000108439238532832*std::pow(-8.07520008087158*x_88 - 7.66735982894897, 2) + 1.35764949318226e-6*std::pow(-5.88727998733521*x_90 - 8.93711948394775, 2) + 1.5146277136783e-5*std::pow(-4.83951997756958*x_90 - 7.24056005477905, 2) + 0.00589897318319553*std::exp(0.460399866104126*x_1) + 0.000138306778126586*std::exp(1.18103992938995*x_1) + 1.38752495306525e-5*std::exp(1.18375980854034*x_1) + 0.00889083765721661*std::exp(0.595759809017181*x_100) + 8.10271291181613e-6*std::exp(1.62599992752075*x_100) + 0.00290808163268247*std::exp(1.66631984710693*x_100) + 0.00445161507099649*std::exp(0.609039843082428*x_104) - 0.00250110005806926*std::exp(0.729839861392975*x_104) + 5.91358565494411e-5*std::exp(0.828719913959503*x_104) + 0.000206728881294416*std::exp(0.893679857254028*x_104) - 0.00067311448070212*std::exp(0.863839864730835*x_106) + 0.0056797264807728*std::exp(0.912479817867279*x_106) - 0.00129764353245342*std::exp(1.19687986373901*x_106) - 0.000211220944268316*std::exp(0.576399862766266*x_110) - 0.0031357288148422*std::exp(0.783999860286713*x_110) - 0.0559852019856327*std::exp(0.562159836292267*x_112) + 0.00112669606293044*std::exp(1.24383985996246*x_26) + 9.62749335784846e-5*std::exp(0.575999855995178*x_31) - 2.77236675711632e-5*std::exp(0.60319983959198*x_31) + 0.0194763678061755*std::exp(0.629599869251251*x_31) + 0.00337373942306996*std::exp(0.646159827709198*x_31) + 0.000684197572231133*std::exp(1.33207988739014*x_50) + 0.000482288739034647*std::exp(0.898319840431213*x_6) + 0.000368250385829145*std::exp(1.28559982776642*x_60) + 0.000116566695935737*std::exp(1.3447197675705*x_60) - 7.94655552110647e-5*std::exp(1.45263981819153*x_60) + 0.00280725657555855*std::exp(0.721199870109558*x_70) + 0.000433508287267375*std::exp(0.880959868431091*x_72) + 0.000100323255838005*std::exp(0.898639857769012*x_74) + 0.0412314591297828*std::exp(0.675999820232391*x_76) + 0.00141990311913103*std::exp(0.759759843349457*x_77) - 0.000162952549471282*std::exp(0.727279841899872*x_81) - 6.64045233625203e-5*std::exp(2.27735996246338*x_81) + 1.10107767817648e-6*std::exp(2.64103984832764*x_81) - 0.000158936863832731*std::exp(0.677599847316742*x_87) + 0.000898844494398151*std::sin(0.347919851541519*x_10 - 4.24720001220703) - 0.0199005923546623*std::sin(0.371759831905365*x_100 + 5.16815996170044) + 0.00166105338456654*std::sin(0.315839856863022*x_101 + 5.13479995727539) + 0.17738041026064*std::sin(0.362959831953049*x_102 - 7.41792011260986) + 0.00975398196006554*std::sin(0.364479839801788*x_102 - 7.41215991973877) + 0.0246450461516451*std::sin(0.372399836778641*x_102 - 7.42935991287231) - 0.00848024009377287*std::sin(0.353599846363068*x_103 - 4.24520015716553) + 0.115796964132833*std::sin(0.331999838352203*x_105 + 5.13535976409912) - 0.00381462405271343*std::sin(0.368959844112396*x_105 - 7.41703987121582) + 0.00268815288985646*std::sin(0.512159824371338*x_107 + 5.27336025238037) + 0.189830031323949*std::sin(0.141760036349297*x_108 - 7.67880010604858) + 0.173725037372055*std::sin(0.290719926357269*x_108 - 7.48176002502441) + 0.00262379956880757*std::sin(0.500319838523865*x_108 + 5.28128004074097) + 0.0178823534874514*std::sin(0.532639861106873*x_108 + 2.15879988670349) + 0.00666372125644086*std::sin(0.234479993581772*x_110 - 7.55600023269653) - 0.0154657510499049*std::sin(0.350399851799011*x_111 + 5.14800024032593) + 0.00327831270385721*std::sin(0.36167985200882*x_111 - 7.41599988937378) + 0.161645484639651*std::sin(0.364639848470688*x_111 - 7.42519998550415) - 0.00765722289594611*std::sin(0.411199867725372*x_111 + 8.19527912139893) + 0.00354445112167847*std::sin(0.238559976220131*x_112 - 7.55352020263672) - 0.0238832628182074*std::sin(0.42647984623909*x_112 + 5.22016000747681) + 0.0084674675725779*std::sin(0.483759850263596*x_112 - 7.34975957870483) - 0.00033050591791243*std::sin(0.561359822750092*x_112 + 2.18031978607178) + 0.0111060349169459*std::sin(0.352079838514328*x_113 + 5.14792013168335) + 0.010652350650732*std::sin(0.23335999250412*x_114 - 7.55904006958008) + 0.0803506617582594*std::sin(0.335279852151871*x_114 + 5.12943983078003) - 0.0255691071092018*std::sin(0.456959843635559*x_114 + 5.24592018127441) + 0.0600303673720154*std::sin(0.163440018892288*x_115 - 7.64416027069092) + 0.000833735036051797*std::sin(0.368639826774597*x_115 - 7.41511964797974) + 0.00423185488537696*std::sin(0.389999836683273*x_115 + 5.18383979797363) - 0.0411226458527264*std::sin(0.458079844713211*x_115 - 4.15824031829834) - 0.0181154626321724*std::sin(0.383359849452972*x_116 + 5.17575979232788) + 0.0451227733388186*std::sin(0.291759938001633*x_117 + 5.08567953109741) - 0.0017103052949734*std::sin(0.370319843292236*x_117 + 5.17880010604858) + 0.00915109001204324*std::sin(0.399759858846664*x_117 + 5.18656015396118) - 0.0265307711119257*std::sin(0.28687995672226*x_118 + 1.89631986618042) - 0.1919766086861*std::sin(0.529999852180481*x_118 - 7.22975969314575) + 0.011906429993406*std::sin(0.331279844045639*x_119 + 5.1526403427124) + 0.00615484081705061*std::sin(0.344959855079651*x_119 + 5.15152025222778) - 0.537328385263622*std::sin(0.345199823379517*x_119 + 5.15088033676147) - 0.0279172464313538*std::sin(0.411679863929749*x_119 + 2.01143980026245) - 0.00588795091110106*std::sin(0.413199841976166*x_120 + 5.21072006225586) - 0.00202419676765876*std::sin(0.438319861888885*x_120 - 4.1812801361084) + 2.99646020833232e-5*std::sin(0.783199846744537*x_120 - 4.01696014404297) - 0.485832455101163*std::sin(0.221440002322197*x_14 - 4.37151956558228) + 0.00291893943694915*std::sin(0.384319841861725*x_16 + 5.19271993637085) + 0.108587796606534*std::sin(0.385279834270477*x_16 + 5.19063997268677) + 0.00577055716229988*std::sin(0.414559870958328*x_16 + 5.20528030395508) - 0.161380642611519*std::sin(0.417759865522385*x_2 - 4.17151975631714) - 0.0369778687057374*std::sin(0.447039872407913*x_2 - 4.14039993286133) + 0.00386804680425648*std::sin(0.258479982614517*x_24 - 7.51384019851685) + 0.082195555542392*std::sin(0.270639955997467*x_24 - 7.49720001220703) - 0.00118024109123866*std::sin(0.297439932823181*x_28 + 5.12983989715576) - 0.18410059792585*std::sin(0.305759936571121*x_28 + 5.13399982452393) - 0.0344407470519961*std::sin(0.316559851169586*x_28 - 4.28560018539429) - 0.00565776904710093*std::sin(0.281359940767288*x_3 - 4.31383991241455) - 0.00734542419626258*std::sin(0.2882399559021*x_33 - 1.16303980350494) + 0.000832405657915704*std::sin(0.314479857683182*x_33 - 1.18263983726501) + 0.00985369238120974*std::sin(0.341279834508896*x_34 - 7.41287994384766) - 0.00479115476871236*std::sin(0.352959841489792*x_34 + 1.99951982498169) + 0.017026383389305*std::sin(0.311919927597046*x_35 + 8.2792797088623) + 0.00460052580454792*std::sin(0.316639840602875*x_35 - 7.43399953842163) + 0.00177620613358471*std::sin(0.319359838962555*x_35 - 7.43088006973267) - 0.0319973834525846*std::sin(0.320079833269119*x_35 - 7.43167972564697) + 0.108036759868059*std::sin(0.320479840040207*x_35 + 1.98279976844788) + 0.000869701978968604*std::sin(0.264559954404831*x_36 - 7.52311992645264) - 0.0120967254556477*std::sin(0.300559937953949*x_36 + 5.09175968170166) + 0.00343227443257379*std::sin(0.311679929494858*x_36 + 5.10960006713867) + 0.0439771994726407*std::sin(0.202240005135536*x_37 + 4.99927997589111) - 0.00302372280040828*std::sin(0.678639829158783*x_38 + 2.21391987800598) - 0.000542802806003828*std::sin(0.47343984246254*x_39 + 8.44896030426025) - 0.17675344599743*std::sin(0.342319846153259*x_4 + 8.3264799118042) - 0.0948500513565772*std::sin(0.398239850997925*x_4 - 4.21464014053345) + 0.0355118529330823*std::sin(0.243759974837303*x_40 + 1.85207998752594) - 0.00382891307619116*std::sin(0.337839841842651*x_41 - 4.25608015060425) + 0.0207305394559707*std::sin(0.198319986462593*x_42 - 7.60856008529663) + 0.00308595358249056*std::sin(0.370559841394424*x_43 - 7.410560131073) - 0.0172344731607714*std::sin(0.370959848165512*x_43 - 4.21415996551514) + 0.329617112277604*std::sin(0.37271985411644*x_43 - 7.42679977416992) + 0.27363303398968*std::sin(0.294719934463501*x_45 + 5.10903978347778) + 0.00747843669936542*std::sin(0.342879861593246*x_45 - 7.43375968933105) + 0.0143064875940095*std::sin(0.519439876079559*x_45 + 5.34327983856201) - 0.00234785902705556*std::sin(0.367279827594757*x_46 - 4.23912000656128) - 0.000277822165769586*std::sin(0.57127982378006*x_46 + 2.17831993103027) + 0.0202969021065362*std::sin(0.667999863624573*x_46 - 7.14032030105591) - 0.0103805156094642*std::sin(0.356239855289459*x_47 - 4.23776006698608) + 0.0165312176628537*std::sin(0.314479827880859*x_48 - 1.26639986038208) + 0.00290810925772526*std::sin(0.370799839496613*x_48 - 7.42199993133545) - 0.0816217246161597*std::sin(0.499119848012924*x_49 + 8.48079967498779) + 0.00206384777870407*std::sin(0.324479848146439*x_51 - 7.46815967559814) + 0.0220236485076059*std::sin(0.344719856977463*x_51 - 4.25576019287109) - 0.125070781299452*std::sin(0.392559856176376*x_51 + 2.00583982467651) + 0.031835238083064*std::sin(0.256319969892502*x_53 + 5.06504011154175) + 0.186083598485362*std::sin(0.331999838352203*x_53 - 4.27663993835449) - 0.00132421471069504*std::sin(0.430319845676422*x_53 + 8.42768001556396) + 0.713658817741592*std::sin(0.0974400714039803*x_54 + 4.85640001296997) - 0.00181674508051581*std::sin(0.376319825649261*x_55 - 7.40751981735229) - 0.0959794881953539*std::sin(0.419439852237701*x_55 + 8.40575981140137) - 0.577017814552561*std::sin(0.096000075340271*x_56 - 1.48439979553223) + 0.627527451378424*std::sin(0.198959991335869*x_56 + 1.79975986480713) + 0.135427361691281*std::sin(0.32151985168457*x_57 - 4.28575992584229) + 0.000322616816383297*std::sin(0.677679836750031*x_57 - 3.95703983306885) + 0.00201874733952988*std::sin(0.270799964666367*x_58 - 7.50408029556274) + 0.0480360170111108*std::sin(0.356159836053848*x_58 + 5.15912008285522) - 0.000679487462459761*std::sin(0.425279855728149*x_58 + 5.21239995956421) - 0.500040234139602*std::sin(0.272079944610596*x_59 - 7.50024032592773) - 0.0264542314435782*std::sin(0.396159827709198*x_59 - 4.19447994232178) - 0.00251710948163911*std::sin(0.403359860181808*x_59 - 4.1878399848938) + 0.314343810014149*std::sin(0.133280038833618*x_63 - 7.67183971405029) - 0.00148060859351216*std::sin(0.405439853668213*x_63 + 5.19360017776489) - 0.0594733517866898*std::sin(0.202399998903275*x_64 - 4.39472007751465) - 0.0086274828643477*std::sin(0.229839980602264*x_64 - 4.35567998886108) + 0.46760423763858*std::sin(0.294319927692413*x_64 - 4.28071975708008) - 0.325100383879266*std::sin(0.199039995670319*x_66 + 4.99455976486206) - 0.0803663380805473*std::sin(0.165360018610954*x_67 - 4.45287990570068) + 0.0102798716215355*std::sin(0.220559984445572*x_67 - 7.56264019012451) + 0.00051116593777583*std::sin(0.289759933948517*x_67 - 7.48559999465942) + 0.318821828823284*std::sin(0.246639966964722*x_70 + 5.05167961120605) + 0.00195941145419601*std::sin(0.760799884796143*x_70 + 2.37687993049622) + 0.0553188828642912*std::sin(0.101840071380138*x_71 - 7.71872043609619) + 0.498441499337462*std::sin(0.218639999628067*x_71 + 5.03167963027954) - 0.0132915221139246*std::sin(0.172000005841255*x_72 - 7.62408018112183) + 0.000234584561262839*std::sin(0.417839854955673*x_72 - 0.988559782505035) - 0.0165038296775541*std::sin(0.186880007386208*x_73 + 4.96799993515015) + 0.0355646017619109*std::sin(0.214399993419647*x_73 + 8.20792007446289) + 0.210222788533847*std::sin(0.252239972352982*x_73 + 5.07247972488403) - 0.00715799614849996*std::sin(0.510879814624786*x_73 + 2.10727977752686) - 0.0236732852511603*std::sin(0.12896004319191*x_74 - 7.67944049835205) - 0.378174198173184*std::sin(0.321839839220047*x_75 + 5.12048006057739) + 0.0084469099267416*std::sin(0.450239837169647*x_75 - 7.35103988647461) - 0.020540183824862*std::sin(0.280479967594147*x_76 + 5.09592008590698) - 0.0559137106087011*std::sin(0.379359841346741*x_76 - 4.20864009857178) + 0.000395733372050825*std::sin(0.612719833850861*x_76 - 3.99183988571167) + 0.00290578494967029*std::sin(0.14144004881382*x_79 - 4.48799991607666) - 0.0013469333766314*std::sin(0.324319839477539*x_79 - 4.27648019790649) - 0.0411757637771795*std::sin(0.344319850206375*x_79 + 5.13976001739502) + 0.01895435214761*std::sin(0.428879857063293*x_79 - 1.18207991123199) - 0.0321932808862168*std::sin(0.297279924154282*x_81 - 7.47096014022827) + 0.0167500252928392*std::sin(0.23463998734951*x_82 + 5.0479998588562) + 0.316388984671432*std::sin(0.296399921178818*x_83 - 7.48288011550903) - 0.0415678998713266*std::sin(0.281279951334*x_84 - 7.50392007827759) + 0.0369502899991794*std::sin(0.285679936408997*x_84 + 5.08895969390869) - 0.110853477795678*std::sin(0.324639827013016*x_84 - 1.08567988872528) + 0.00611330024247674*std::sin(0.184720009565353*x_85 + 1.77711987495422) - 0.00313310382816368*std::sin(0.202799841761589*x_85 - 1.36799991130829) - 0.0440796777875634*std::sin(0.213839992880821*x_85 + 5.00920009613037) - 0.00219685617641838*std::sin(0.271919965744019*x_86 + 5.07535982131958) + 0.0164760057416748*std::sin(0.294719934463501*x_86 - 7.4986400604248) - 0.364196766781563*std::sin(0.310959845781326*x_86 - 4.30808019638062) - 0.0301004917893506*std::sin(0.434079855680466*x_86 + 5.24151992797852) - 0.0540161803993484*std::sin(0.150880038738251*x_87 + 4.91951942443848) - 0.0312073406634589*std::sin(0.306479841470718*x_87 - 4.31288003921509) + 2.23250995444758e-5*std::sin(0.950239837169647*x_87 - 3.83208012580872) + 0.019238133324158*std::sin(0.191359996795654*x_88 - 7.60824012756348) + 0.000622596153171804*std::sin(0.212960004806519*x_88 - 7.57991981506348) - 0.0155822435289622*std::sin(0.204080000519753*x_89 - 4.40327978134155) + 0.0204064429846753*std::sin(0.285919934511185*x_89 - 7.49544048309326) + 0.093418137637714*std::sin(0.274079948663712*x_90 - 7.50888013839722) - 0.0227029638718395*std::sin(0.361039847135544*x_92 + 1.97879981994629) + 0.00133425666100399*std::sin(0.362799853086472*x_92 + 1.98575985431671) + 0.00718362614495206*std::sin(0.363679856061935*x_92 + 2.00567984580994) + 0.164109494767601*std::sin(0.369039833545685*x_92 + 2.00383973121643) + 0.0594062406249672*std::sin(0.270719945430756*x_93 - 1.36999988555908) + 0.0118794046852582*std::sin(0.343679845333099*x_93 + 1.97367978096008) + 0.000996770323217016*std::sin(0.365119844675064*x_95 + 5.18239974975586) - 0.128412115029939*std::sin(0.376399844884872*x_95 + 1.9883998632431) - 0.0352100506405766*std::sin(0.381439834833145*x_95 - 7.42175960540771) + 0.00272208383618484*std::sin(0.43615984916687*x_95 + 5.22552013397217) - 0.00158443976287107*std::sin(0.403999865055084*x_96 - 7.39807987213135) + 0.00035614603690244*std::sin(0.421199858188629*x_96 + 5.20864009857178) + 1.55737356327295*std::sin(0.114480063319206*x_97 + 1.71391987800598) + 0.00346179228903596*std::sin(0.437599837779999*x_97 + 5.21184015274048) - 0.0753664340123274*std::sin(0.363839834928513*x_98 + 5.17519998550415) + 0.000953025755282987*std::sin(0.42375984787941*x_98 + 2.02567982673645) + 0.374050496664952*std::sin(0.366159856319427*x_99 - 7.4347996711731) - 0.0307591583078057*std::sin(0.376159846782684*x_99 + 1.98311984539032) + 0.00340844602207474*std::sin(0.406079858541489*x_99 + 5.20360040664673) - 0.0245648215112242*std::sin(0.441999852657318*x_99 - 4.16584014892578) + 0.276370512768035 - 1.44147947593025e-5*std::exp(-1.2125598192215*x_9));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0199652303674871*x_1 - 0.0181786083053712*x_10 + 0.000673586389572933*x_100 + 0.00188925428300956*x_101 - 6.61285003478984e-5*x_102 - 0.0084249748550411*x_103 - 0.00032492143967651*x_104 - 0.000327579398068702*x_105 - 0.000790301272103611*x_106 - 0.000731480140106564*x_107 - 2.36537497328583e-5*x_108 - 0.00486113418892802*x_109 - 0.00085554027986437*x_11 - 0.000165419571912436*x_110 + 1.19870376784686e-5*x_111 - 0.00323633186656336*x_113 + 0.000393649377651493*x_114 + 0.000341671719635666*x_115 - 0.00119532626530644*x_116 + 0.00534322619302935*x_117 - 0.000659350133173967*x_118 + 2.92318452699302e-5*x_119 - 0.005930462855549*x_12 - 0.000150280082950613*x_120 + 0.00473600826884371*x_13 - 9.70907527861538e-5*x_14 + 0.000767497639645672*x_15 + 6.16644830970642e-5*x_16 + 0.000113980859290012*x_17 - 0.0014432587834949*x_18 - 0.00702365607821423*x_19 - 0.0022679490650078*x_2 - 0.00169432990627928*x_20 - 0.00281757938024586*x_21 - 0.00312278703925877*x_22 - 0.00123215095660823*x_23 - 0.000741551645788018*x_24 + 0.00381952159993364*x_25 - 0.00217661412177055*x_26 - 0.000967570102378989*x_27 - 0.000319093517991537*x_28 - 0.00492067513549795*x_29 + 0.00303503923821682*x_3 + 0.000142403223442197*x_30 + 0.00245894341520622*x_31 + 0.0097602054869241*x_32 + 0.00441832800111364*x_33 + 0.00489328518465223*x_34 - 0.00145122513881439*x_36 + 0.00192075565012722*x_37 + 0.00264225776399427*x_38 - 0.00470452597786414*x_39 - 0.00225078798219774*x_4 + 0.000479325405772414*x_40 - 0.00423640001548007*x_41 - 0.00548097461003523*x_42 + 7.53985294875488e-5*x_43 - 3.9357116970565e-5*x_44 - 2.75884841497793e-5*x_45 + 0.00029902121945503*x_46 - 0.0061434128780693*x_47 - 0.00279331761547493*x_48 + 0.00015679124705903*x_49 - 0.00615950283199879*x_5 + 0.000145657062247684*x_50 - 0.000566162420030307*x_51 - 0.00214629322804578*x_52 + 0.000276119795402319*x_53 - 4.59109577066899e-5*x_54 + 0.000245424170593727*x_55 - 0.00146854018904081*x_56 - 0.0036368621666239*x_57 + 0.00483617989790086*x_58 - 0.000289393202599815*x_59 - 0.00154829185855845*x_6 + 0.00319071418366938*x_60 - 0.00707155937829759*x_61 + 0.00850344529415942*x_62 + 0.000889587694556624*x_63 - 0.0012484003947211*x_64 + 0.00318334763972222*x_65 + 0.000260202259245699*x_66 + 0.00140389822064156*x_67 + 0.000334895182542034*x_68 - 0.00657990407395703*x_69 - 0.00381912613077869*x_7 + 9.07388424985559e-6*x_70 - 0.000674600604033285*x_71 - 0.000598467624783901*x_72 + 8.2349426009443e-6*x_73 + 0.000582434786169053*x_74 + 0.000299951635194829*x_75 - 0.00696213814306424*x_76 + 9.27039712500551e-5*x_77 + 0.000234548634917932*x_78 - 0.0033831650675162*x_79 + 0.0203844322575797*x_8 + 0.000850139910622025*x_80 + 0.00413650829723656*x_81 + 0.00260806331726558*x_82 + 0.000215057833741856*x_83 - 6.98746430071785e-5*x_84 + 4.85473674651233e-5*x_85 + 0.0003700607811976*x_86 + 0.000721667749377363*x_87 - 0.000572206074986242*x_88 + 0.00275917438698885*x_89 - 0.0010865668367842*x_9 - 0.00160891552934546*x_90 - 0.00320644923084167*x_91 - 0.000257135162646483*x_92 + 0.00495636689054258*x_93 - 0.0037442124152324*x_94 - 4.86902667571209e-5*x_95 + 0.0016825871475976*x_96 - 2.29984443076693e-5*x_97 + 0.0011988024604232*x_98 + 3.34950701383914e-5*x_99 + 3.69640849523094e-7*std::pow(-7.87296009063721*x_106 - 9.04559993743896, 2) - 1.03732809569366e-5*std::pow(-7.23343992233276*x_107 - 9.84928035736084, 2) - 6.22727384423846e-5*std::pow(-3.99151992797852*x_110 - 5.38871955871582, 2) - 8.4317861285044e-6*std::pow(-8.07431983947754*x_116 - 9.47160053253174, 2) + 1.94128212805631e-5*std::pow(-8.54367923736572*x_120 - 9.14231967926025, 2) + 1.47693483757893e-5*std::pow(-7.97567987442017*x_13 - 9.75928020477295, 2) - 5.96822868251805e-5*std::pow(-2.19231986999512*x_13 - 3.18535995483398, 2) - 1.97249860276021e-5*std::pow(-6.53927993774414*x_14 - 9.78439998626709, 2) - 1.2782023740315e-5*std::pow(-6.46400022506714*x_14 - 8.68704032897949, 2) - 1.53480102469474e-5*std::pow(-5.62559986114502*x_15 - 7.82880020141602, 2) - 9.99861558383166e-5*std::pow(-6.89976024627686*x_17 - 9.1307201385498, 2) - 1.55000541709149e-5*std::pow(-6.92984008789063*x_19 - 9.97432041168213, 2) - 2.76238494635897e-5*std::pow(-6.88104009628296*x_23 - 8.10231971740723, 2) + 7.92126343088406e-5*std::pow(-5.86168003082275*x_27 - 8.08047962188721, 2) - 2.38753435361981e-5*std::pow(-4.25631999969482*x_27 - 5.47039985656738, 2) - 2.31788501067972e-6*std::pow(-7.61320018768311*x_36 - 9.01000022888184, 2) + 1.46416036461978e-5*std::pow(-5.53175973892212*x_52 - 7.57728004455566, 2) + 3.55064138619941e-7*std::pow(-8.06855964660645*x_56 - 7.47832012176514, 2) + 8.8925151966895e-6*std::pow(-7.14911985397339*x_68 - 9.59352016448975, 2) - 1.49318106000792e-5*std::pow(-7.14143991470337*x_68 - 9.17271995544434, 2) - 7.62825680913837e-6*std::pow(-5.12191963195801*x_7 - 7.37095975875854, 2) - 7.60611929731732e-6*std::pow(-4.89592027664185*x_7 - 7.74936008453369, 2) + 3.23543508894213e-6*std::pow(-7.63944053649902*x_70 - 9.65192031860352, 2) + 1.45264955673626e-6*std::pow(-9.15408039093018*x_72 - 9.7540807723999, 2) - 1.30270579100348e-5*std::pow(-6.66584014892578*x_74 - 8.27351951599121, 2) + 2.3949038541753e-5*std::pow(-6.94191980361938*x_77 - 9.79944038391113, 2) + 6.45840261742734e-6*std::pow(-1.50623989105225*x_77 - 2.36735987663269, 2) + 1.88199223906139e-5*std::pow(-7.40000009536743*x_78 - 9.99612045288086, 2) + 3.65400341178448e-6*std::pow(-7.37215995788574*x_78 - 8.56719970703125, 2) - 4.18458618201522e-6*std::pow(-7.31472015380859*x_80 - 9.95207977294922, 2) + 2.60551115515548e-7*std::pow(-7.1406397819519*x_80 - 9.58688068389893, 2) - 3.73258359383594e-6*std::pow(-6.15687990188599*x_84 - 6.77792024612427, 2) - 2.03567963937623e-5*std::pow(-8.07520008087158*x_88 - 7.66735982894897, 2) + 4.96339291851852e-7*std::pow(-5.88727998733521*x_90 - 8.93711948394775, 2) - 4.897299176607e-5*std::pow(-4.83951997756958*x_90 - 7.24056005477905, 2) - 0.000840072323184219*std::exp(0.460399866104126*x_1) - 4.40334413892373e-5*std::exp(1.18103992938995*x_1) + 5.0726137791054e-6*std::exp(1.18375980854034*x_1) - 0.00126614351579501*std::exp(0.595759809017181*x_100) + 2.96224821570332e-6*std::exp(1.62599992752075*x_100) - 0.000545920706322864*std::exp(1.66631984710693*x_100) - 0.00141728362102949*std::exp(0.609039843082428*x_104) + 0.000356181469392651*std::exp(0.729839861392975*x_104) + 2.1619312871398e-5*std::exp(0.828719913959503*x_104) - 0.000668423778992772*std::exp(0.893679857254028*x_104) + 9.58581820956934e-5*std::exp(0.863839864730835*x_106) - 0.00106622876650269*std::exp(0.912479817867279*x_106) + 0.000413137455766001*std::exp(1.19687986373901*x_106) - 7.72196759390984e-5*std::exp(0.576399862766266*x_110) + 0.00099833813534808*std::exp(0.783999860286713*x_110) + 0.0105098428696558*std::exp(0.562159836292267*x_112) - 0.000211509437552758*std::exp(1.24383985996246*x_26) + 3.51968844649464e-5*std::exp(0.575999855995178*x_31) + 8.96399116051176e-5*std::exp(0.60319983959198*x_31) - 0.00365620839176498*std::exp(0.629599869251251*x_31) - 0.000480453975113897*std::exp(0.646159827709198*x_31) - 9.74365243189408e-5*std::exp(1.33207988739014*x_50) - 0.00155940118038991*std::exp(0.898319840431213*x_6) - 5.24425094893198e-5*std::exp(1.28559982776642*x_60) - 0.000376899206894567*std::exp(1.3447197675705*x_60) + 2.52998581504589e-5*std::exp(1.45263981819153*x_60) - 0.000399781195805697*std::exp(0.721199870109558*x_70) - 0.000138018266477623*std::exp(0.880959868431091*x_72) + 3.6676899309403e-5*std::exp(0.898639857769012*x_74) - 0.00774019100354157*std::exp(0.675999820232391*x_76) - 0.000202208295400109*std::exp(0.759759843349457*x_77) + 0.000526880222212293*std::exp(0.727279841899872*x_81) + 9.45666313079832e-6*std::exp(2.27735996246338*x_81) + 4.02539917559288e-7*std::exp(2.64103984832764*x_81) + 0.000513896164285988*std::exp(0.677599847316742*x_87) - 0.0029062655876167*std::sin(0.347919851541519*x_10 - 4.24720001220703) + 0.00633585409861906*std::sin(0.371759831905365*x_100 + 5.16815996170044) + 0.000607259874337239*std::sin(0.315839856863022*x_101 + 5.13479995727539) - 0.0332988035029831*std::sin(0.362959831953049*x_102 - 7.41792011260986) - 0.0315378936951198*std::sin(0.364479839801788*x_102 - 7.41215991973877) - 0.00350969915146816*std::sin(0.372399836778641*x_102 - 7.42935991287231) + 0.00120767034795649*std::sin(0.353599846363068*x_103 - 4.24520015716553) - 0.0217380281691502*std::sin(0.331999838352203*x_105 + 5.13535976409912) + 0.0123339584134842*std::sin(0.368959844112396*x_105 - 7.41703987121582) - 0.00869169949499809*std::sin(0.512159824371338*x_107 + 5.27336025238037) - 0.0270336803494427*std::sin(0.141760036349297*x_108 - 7.67880010604858) - 0.0326125972676481*std::sin(0.290719926357269*x_108 - 7.48176002502441) - 0.00848362363362403*std::sin(0.500319838523865*x_108 + 5.28128004074097) - 0.00569329699424148*std::sin(0.532639861106873*x_108 + 2.15879988670349) - 0.0215460448317386*std::sin(0.234479993581772*x_110 - 7.55600023269653) + 0.00492391082795107*std::sin(0.350399851799011*x_111 + 5.14800024032593) - 0.0105998840244846*std::sin(0.36167985200882*x_111 - 7.41599988937378) - 0.030344958737276*std::sin(0.364639848470688*x_111 - 7.42519998550415) + 0.0010904645312953*std::sin(0.411199867725372*x_111 + 8.19527912139893) - 0.01146039875209*std::sin(0.238559976220131*x_112 - 7.55352020263672) + 0.00760383740937663*std::sin(0.42647984623909*x_112 + 5.22016000747681) - 0.00120585141418277*std::sin(0.483759850263596*x_112 - 7.34975957870483) - 0.000120828736778734*std::sin(0.561359822750092*x_112 + 2.18031978607178) - 0.0359095341798822*std::sin(0.352079838514328*x_113 + 5.14792013168335) - 0.034442620849759*std::sin(0.23335999250412*x_114 - 7.55904006958008) - 0.0114427316409811*std::sin(0.335279852151871*x_114 + 5.12943983078003) + 0.00814056834031438*std::sin(0.456959843635559*x_114 + 5.24592018127441) - 0.0191121772848377*std::sin(0.163440018892288*x_115 - 7.64416027069092) + 0.000304802866619177*std::sin(0.368639826774597*x_115 - 7.41511964797974) - 0.0136830055719413*std::sin(0.389999836683273*x_115 + 5.18383979797363) + 0.00771976399062682*std::sin(0.458079844713211*x_115 - 4.15824031829834) + 0.002579821658169*std::sin(0.383359849452972*x_116 + 5.17575979232788) - 0.00642593072557791*std::sin(0.291759938001633*x_117 + 5.08567953109741) - 0.000625265742903797*std::sin(0.370319843292236*x_117 + 5.17880010604858) - 0.0295885419078993*std::sin(0.399759858846664*x_117 + 5.18656015396118) + 0.0037782450999024*std::sin(0.28687995672226*x_118 + 1.89631986618042) + 0.0360388802822947*std::sin(0.529999852180481*x_118 - 7.22975969314575) - 0.00379071144864534*std::sin(0.331279844045639*x_119 + 5.1526403427124) - 0.019900663769243*std::sin(0.344959855079651*x_119 + 5.15152025222778) + 0.100870171013686*std::sin(0.345199823379517*x_119 + 5.15088033676147) + 0.00397569294488457*std::sin(0.411679863929749*x_119 + 2.01143980026245) + 0.00187457726120537*std::sin(0.413199841976166*x_120 + 5.21072006225586) + 0.00654490676093051*std::sin(0.438319861888885*x_120 - 4.1812801361084) + 1.0954675307099e-5*std::sin(0.783199846744537*x_120 - 4.01696014404297) + 0.0912030783670774*std::sin(0.221440002322197*x_14 - 4.37151956558228) - 0.00943790977283872*std::sin(0.384319841861725*x_16 + 5.19271993637085) - 0.0203846845134127*std::sin(0.385279834270477*x_16 + 5.19063997268677) - 0.00183720200868833*std::sin(0.414559870958328*x_16 + 5.20528030395508) + 0.0302952411690218*std::sin(0.417759865522385*x_2 - 4.17151975631714) + 0.0117728345378903*std::sin(0.447039872407913*x_2 - 4.14039993286133) - 0.0125066920791772*std::sin(0.258479982614517*x_24 - 7.51384019851685) - 0.0261690224185476*std::sin(0.270639955997467*x_24 - 7.49720001220703) - 0.000431481048961148*std::sin(0.297439932823181*x_28 + 5.12983989715576) + 0.0345603532323934*std::sin(0.305759936571121*x_28 + 5.13399982452393) + 0.010965078047929*std::sin(0.316559851169586*x_28 - 4.28560018539429) + 0.0182934640939001*std::sin(0.281359940767288*x_3 - 4.31383991241455) + 0.0237502189767976*std::sin(0.2882399559021*x_33 - 1.16303980350494) + 0.000304316862973918*std::sin(0.314479857683182*x_33 - 1.18263983726501) - 0.00313717080111903*std::sin(0.341279834508896*x_34 - 7.41287994384766) + 0.0154914095998083*std::sin(0.352959841489792*x_34 + 1.99951982498169) - 0.00242472596587232*std::sin(0.311919927597046*x_35 + 8.2792797088623) - 0.014875042250387*std::sin(0.316639840602875*x_35 - 7.43399953842163) + 0.000649358246700273*std::sin(0.319359838962555*x_35 - 7.43088006973267) + 0.0101871717926853*std::sin(0.320079833269119*x_35 - 7.43167972564697) - 0.0202812409366928*std::sin(0.320479840040207*x_35 + 1.98279976844788) + 0.000317951920971609*std::sin(0.264559954404831*x_36 - 7.52311992645264) + 0.0038512967951971*std::sin(0.300559937953949*x_36 + 5.09175968170166) - 0.0110976939090282*std::sin(0.311679929494858*x_36 + 5.10960006713867) - 0.00626278963826449*std::sin(0.202240005135536*x_37 + 4.99927997589111) + 0.000962678203574498*std::sin(0.678639829158783*x_38 + 2.21391987800598) - 0.000198441764019404*std::sin(0.47343984246254*x_39 + 8.44896030426025) + 0.0331811064034367*std::sin(0.342319846153259*x_4 + 8.3264799118042) + 0.0135075886129217*std::sin(0.398239850997925*x_4 - 4.21464014053345) - 0.0113060915447029*std::sin(0.243759974837303*x_40 + 1.85207998752594) + 0.0123801596167766*std::sin(0.337839841842651*x_41 - 4.25608015060425) - 0.067028783965528*std::sin(0.198319986462593*x_42 - 7.60856008529663) - 0.00997792249679407*std::sin(0.370559841394424*x_43 - 7.410560131073) + 0.0024543600144292*std::sin(0.370959848165512*x_43 - 4.21415996551514) - 0.0618774950222796*std::sin(0.37271985411644*x_43 - 7.42679977416992) - 0.0513678630991943*std::sin(0.294719934463501*x_45 + 5.10903978347778) - 0.0241802929917132*std::sin(0.342879861593246*x_45 - 7.43375968933105) - 0.0045548301499735*std::sin(0.519439876079559*x_45 + 5.34327983856201) + 0.00759141535319265*std::sin(0.367279827594757*x_46 - 4.23912000656128) - 0.000101568230763013*std::sin(0.57127982378006*x_46 + 2.17831993103027) - 0.00381024349854491*std::sin(0.667999863624573*x_46 - 7.14032030105591) + 0.0335636870287603*std::sin(0.356239855289459*x_47 - 4.23776006698608) - 0.0052631289218794*std::sin(0.314479827880859*x_48 - 1.26639986038208) - 0.00940289217259501*std::sin(0.370799839496613*x_48 - 7.42199993133545) + 0.0153224686174446*std::sin(0.499119848012924*x_49 + 8.48079967498779) - 0.00667311177262426*std::sin(0.324479848146439*x_51 - 7.46815967559814) - 0.0070117824221835*std::sin(0.344719856977463*x_51 - 4.25576019287109) + 0.0234789589466812*std::sin(0.392559856176376*x_51 + 2.00583982467651) - 0.0101355487361581*std::sin(0.256319969892502*x_53 + 5.06504011154175) - 0.0349326127501186*std::sin(0.331999838352203*x_53 - 4.27663993835449) + 0.00428163010208536*std::sin(0.430319845676422*x_53 + 8.42768001556396) - 0.101632098055464*std::sin(0.0974400714039803*x_54 + 4.85640001296997) + 0.00587414590830907*std::sin(0.376319825649261*x_55 - 7.40751981735229) + 0.0180177851265415*std::sin(0.419439852237701*x_55 + 8.40575981140137) + 0.0821730631647429*std::sin(0.096000075340271*x_56 - 1.48439979553223) - 0.117802824254797*std::sin(0.198959991335869*x_56 + 1.79975986480713) - 0.0254231518534606*std::sin(0.32151985168457*x_57 - 4.28575992584229) + 0.000117944582152684*std::sin(0.677679836750031*x_57 - 3.95703983306885) - 0.00652728693287141*std::sin(0.270799964666367*x_58 - 7.50408029556274) - 0.015293474175902*std::sin(0.356159836053848*x_58 + 5.15912008285522) - 0.000248411926372084*std::sin(0.425279855728149*x_58 + 5.21239995956421) + 0.0938702389724658*std::sin(0.272079944610596*x_59 - 7.50024032592773) + 0.00376734509154373*std::sin(0.396159827709198*x_59 - 4.19447994232178) + 0.00813865881400287*std::sin(0.403359860181808*x_59 - 4.1878399848938) - 0.10007925802204*std::sin(0.133280038833618*x_63 - 7.67183971405029) + 0.00478730395621458*std::sin(0.405439853668213*x_63 + 5.19360017776489) + 0.00846959551288077*std::sin(0.202399998903275*x_64 - 4.39472007751465) + 0.0278955444603301*std::sin(0.229839980602264*x_64 - 4.35567998886108) - 0.0877811794628846*std::sin(0.294319927692413*x_64 - 4.28071975708008) + 0.0610295905034458*std::sin(0.199039995670319*x_66 + 4.99455976486206) + 0.0255866450326715*std::sin(0.165360018610954*x_67 - 4.45287990570068) - 0.0332382712749335*std::sin(0.220559984445572*x_67 - 7.56264019012451) + 0.000186875729596271*std::sin(0.289759933948517*x_67 - 7.48559999465942) - 0.0598509464198934*std::sin(0.246639966964722*x_70 + 5.05167961120605) - 0.000623827917868004*std::sin(0.760799884796143*x_70 + 2.37687993049622) - 0.178864493931777*std::sin(0.101840071380138*x_71 - 7.71872043609619) - 0.0935701158869931*std::sin(0.218639999628067*x_71 + 5.03167963027954) + 0.0429759469713509*std::sin(0.172000005841255*x_72 - 7.62408018112183) + 8.57611155171285e-5*std::sin(0.417839854955673*x_72 - 0.988559782505035) + 0.0533624142492845*std::sin(0.186880007386208*x_73 + 4.96799993515015) - 0.00506475223694194*std::sin(0.214399993419647*x_73 + 8.20792007446289) - 0.0394641511819248*std::sin(0.252239972352982*x_73 + 5.07247972488403) + 0.00227892810561229*std::sin(0.510879814624786*x_73 + 2.10727977752686) + 0.0765436676756294*std::sin(0.12896004319191*x_74 - 7.67944049835205) + 0.070992892035617*std::sin(0.321839839220047*x_75 + 5.12048006057739) - 0.0012029238013999*std::sin(0.450239837169647*x_75 - 7.35103988647461) + 0.00653948412960943*std::sin(0.280479967594147*x_76 + 5.09592008590698) + 0.00796266728296206*std::sin(0.379359841346741*x_76 - 4.20864009857178) + 0.000144675059823768*std::sin(0.612719833850861*x_76 - 3.99183988571167) - 0.00939537690543002*std::sin(0.14144004881382*x_79 - 4.48799991607666) - 0.000492421616688293*std::sin(0.324319839477539*x_79 - 4.27648019790649) + 0.0131093400157153*std::sin(0.344319850206375*x_79 + 5.13976001739502) - 0.00269928785037617*std::sin(0.428879857063293*x_79 - 1.18207991123199) + 0.0102495406677251*std::sin(0.297279924154282*x_81 - 7.47096014022827) - 0.0541584472104746*std::sin(0.23463998734951*x_82 + 5.0479998588562) - 0.0593942398464512*std::sin(0.296399921178818*x_83 - 7.48288011550903) + 0.00591968146494909*std::sin(0.281279951334*x_84 - 7.50392007827759) - 0.0117640541630218*std::sin(0.285679936408997*x_84 + 5.08895969390869) + 0.0208100103574947*std::sin(0.324639827013016*x_84 - 1.08567988872528) - 0.0197663491651861*std::sin(0.184720009565353*x_85 + 1.77711987495422) - 0.00114542269059745*std::sin(0.202799841761589*x_85 - 1.36799991130829) + 0.00627738356731274*std::sin(0.213839992880821*x_85 + 5.00920009613037) - 0.000803142522705219*std::sin(0.271919965744019*x_86 + 5.07535982131958) - 0.00234634672685653*std::sin(0.294719934463501*x_86 - 7.4986400604248) + 0.0683689735279187*std::sin(0.310959845781326*x_86 - 4.30808019638062) + 0.0095832486227138*std::sin(0.434079855680466*x_86 + 5.24151992797852) + 0.0171974095984524*std::sin(0.150880038738251*x_87 + 4.91951942443848) + 0.00444423501470329*std::sin(0.306479841470718*x_87 - 4.31288003921509) + 8.16177087979779e-6*std::sin(0.950239837169647*x_87 - 3.83208012580872) - 0.0622033346128682*std::sin(0.191359996795654*x_88 - 7.60824012756348) + 0.000227613191274174*std::sin(0.212960004806519*x_88 - 7.57991981506348) + 0.0503826172695296*std::sin(0.204080000519753*x_89 - 4.40327978134155) - 0.00290607999624369*std::sin(0.285919934511185*x_89 - 7.49544048309326) - 0.0133036698889255*std::sin(0.274079948663712*x_90 - 7.50888013839722) + 0.00323312736143886*std::sin(0.361039847135544*x_92 + 1.97879981994629) + 0.000487787171576275*std::sin(0.362799853086472*x_92 + 1.98575985431671) - 0.0232270716341841*std::sin(0.363679856061935*x_92 + 2.00567984580994) - 0.0308075159551752*std::sin(0.369039833545685*x_92 + 2.00383973121643) - 0.018913470837418*std::sin(0.270719945430756*x_93 - 1.36999988555908) - 0.0384100979127157*std::sin(0.343679845333099*x_93 + 1.97367978096008) + 0.000364406482563359*std::sin(0.365119844675064*x_95 + 5.18239974975586) + 0.0241062120642374*std::sin(0.376399844884872*x_95 + 1.9883998632431) + 0.0112100051942131*std::sin(0.381439834833145*x_95 - 7.42175960540771) - 0.000387651752457578*std::sin(0.43615984916687*x_95 + 5.22552013397217) + 0.0051230249361065*std::sin(0.403999865055084*x_96 - 7.39807987213135) + 0.000130202436372338*std::sin(0.421199858188629*x_96 + 5.20864009857178) - 0.292358531519723*std::sin(0.114480063319206*x_97 + 1.71391987800598) - 0.00049299357707137*std::sin(0.437599837779999*x_97 + 5.21184015274048) + 0.0141481918618265*std::sin(0.363839834928513*x_98 + 5.17519998550415) + 0.000348414027971969*std::sin(0.42375984787941*x_98 + 2.02567982673645) - 0.0702187686359372*std::sin(0.366159856319427*x_99 - 7.4347996711731) + 0.00979295167507543*std::sin(0.376159846782684*x_99 + 1.98311984539032) - 0.0110206486694204*std::sin(0.406079858541489*x_99 + 5.20360040664673) + 0.00349827436651626*std::sin(0.441999852657318*x_99 - 4.16584014892578) - 0.426581951496379 - 5.26986461450511e-6*std::exp(-1.2125598192215*x_9));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.106823074960086*x_1 - 0.0989357677843754*x_10 - 0.00131267172027435*x_100 - 0.114482669376725*x_101 + 0.000605933391834532*x_102 - 0.0428116110706501*x_103 - 0.00170812404741662*x_104 + 0.000785159857630965*x_105 + 0.00154012335529075*x_106 - 0.0041335640786558*x_107 + 0.000606609188707953*x_108 - 0.0313053323286503*x_109 - 0.00945212889831758*x_11 - 0.000230336543697929*x_110 - 0.000307412029097714*x_111 - 0.00809017966961127*x_113 + 0.00243291896123067*x_114 + 0.00047575678059345*x_115 + 0.019751942906439*x_116 + 0.0252663243066442*x_117 + 0.00852005963014298*x_118 - 0.000749661518528547*x_119 + 0.000956593409415383*x_12 - 0.000209255739773076*x_120 + 0.0246011215833206*x_13 + 4.12481409327091e-5*x_14 - 0.00972996353904283*x_15 - 0.000424466123271594*x_16 - 0.00361189720805655*x_17 + 0.0143362598451384*x_18 - 0.0456644142233687*x_19 + 0.00590273433490736*x_2 - 0.0311307755709441*x_20 + 0.00869243208018296*x_21 + 0.00155341925820757*x_22 - 0.00019990311263232*x_23 - 0.00439140936777498*x_24 + 0.0531910527942836*x_25 + 0.00718881006921061*x_26 + 0.00845295231543747*x_27 + 0.000711078624158882*x_28 - 0.0130571112227445*x_29 + 0.0301345889653704*x_3 - 0.000699229780810884*x_30 - 0.0190619716355602*x_31 + 0.0297777145300539*x_32 + 0.0471802369746333*x_33 + 0.0265877337663658*x_34 - 0.00762914432575561*x_36 + 0.0130593149992261*x_37 + 0.00246410719097707*x_38 - 0.00663555043924107*x_39 + 0.00668438111567742*x_4 - 0.000435760470017479*x_40 - 0.0305674613763535*x_41 - 0.0140671599674968*x_42 - 0.00072013880115777*x_43 + 0.0208707562788291*x_44 + 0.000456275866070899*x_45 - 0.00239343738325134*x_46 - 0.0020119340778484*x_47 - 0.0125015222879603*x_48 + 0.00232916755789356*x_49 - 0.00123283570646123*x_5 - 0.00934772408337459*x_50 - 0.00123231437184847*x_51 + 0.00753659703829014*x_52 - 6.83351728908433e-5*x_53 + 0.0160135407844687*x_54 + 0.00126139185062954*x_55 + 0.000134077915181432*x_56 + 0.00924521233241245*x_57 + 0.0280872836998931*x_58 + 0.00197673872679051*x_59 - 0.00528346208535362*x_6 + 0.0161467485001543*x_60 - 0.0580678508109649*x_61 + 0.0179332937795622*x_62 + 0.00327563946867547*x_63 + 0.00882451302342514*x_64 + 0.0707831716449033*x_65 + 0.00091316028651409*x_66 + 0.00547084417253361*x_67 + 0.00261241172015604*x_68 - 0.00614341490524448*x_69 - 0.0188590717921094*x_7 - 0.000232703128484891*x_70 - 0.000412662340655781*x_71 - 0.00314616647799986*x_72 - 0.000211188158606248*x_73 + 0.00172418933612457*x_74 - 0.000893759211490933*x_75 + 0.0135676759425589*x_76 + 0.00663457405795214*x_77 - 0.00249325141917441*x_78 - 0.0177854241134648*x_79 + 0.0810641071818096*x_8 + 0.00592800297506302*x_80 + 0.0217457773850895*x_81 + 0.0115709063595391*x_82 + 0.00282439484703963*x_83 + 0.00179196114715637*x_84 + 0.0150091404491399*x_85 - 0.000721167068961575*x_86 + 0.00379383409781691*x_87 + 0.000135973157000216*x_88 + 0.00124464846277695*x_89 + 0.0227992927000127*x_9 - 0.0061804393214998*x_90 - 0.000924252618308908*x_91 + 0.00199333711648723*x_92 + 0.0365004038187378*x_93 - 0.00581951565691884*x_94 + 9.48866206533799e-5*x_95 + 0.00156945245274191*x_96 - 0.00111564264202116*x_97 - 0.00204540824832914*x_98 - 0.000858993502165135*x_99 - 9.47957674258471e-6*std::pow(-7.87296009063721*x_106 - 9.04559993743896, 2) + 8.04146960625522e-5*std::pow(-7.23343992233276*x_107 - 9.84928035736084, 2) - 0.000327370093330325*std::pow(-3.99151992797852*x_110 - 5.38871955871582, 2) + 1.64316966221759e-5*std::pow(-8.07431983947754*x_116 - 9.47160053253174, 2) + 0.000102053920758644*std::pow(-8.54367923736572*x_120 - 9.14231967926025, 2) - 2.87822115171751e-5*std::pow(-7.97567987442017*x_13 - 9.75928020477295, 2) + 0.000462662967993327*std::pow(-2.19231986999512*x_13 - 3.18535995483398, 2) + 3.84396593251478e-5*std::pow(-6.53927993774414*x_14 - 9.78439998626709, 2) - 1.77981791136996e-5*std::pow(-6.46400022506714*x_14 - 8.68704032897949, 2) - 2.13711569438325e-5*std::pow(-5.62559986114502*x_15 - 7.82880020141602, 2) - 0.000525630925943855*std::pow(-6.89976024627686*x_17 - 9.1307201385498, 2) + 3.02061963956554e-5*std::pow(-6.92984008789063*x_19 - 9.97432041168213, 2) + 5.38328068341169e-5*std::pow(-6.88104009628296*x_23 - 8.10231971740723, 2) + 0.00041642375355981*std::pow(-5.86168003082275*x_27 - 8.08047962188721, 2) + 4.65277932525814e-5*std::pow(-4.25631999969482*x_27 - 5.47039985656738, 2) - 3.22751181058441e-6*std::pow(-7.61320018768311*x_36 - 9.01000022888184, 2) - 2.85332651362139e-5*std::pow(-5.53175973892212*x_52 - 7.57728004455566, 2) - 9.10575158273239e-6*std::pow(-8.06855964660645*x_56 - 7.47832012176514, 2) - 1.73295562402991e-5*std::pow(-7.14911985397339*x_68 - 9.59352016448975, 2) + 0.00011575286701032*std::pow(-7.14143991470337*x_68 - 9.17271995544434, 2) - 1.0621876767927e-5*std::pow(-5.12191963195801*x_7 - 7.37095975875854, 2) + 1.48226535707643e-5*std::pow(-4.89592027664185*x_7 - 7.74936008453369, 2) - 6.30515136555887e-6*std::pow(-7.63944053649902*x_70 - 9.65192031860352, 2) + 2.02272484588508e-6*std::pow(-9.15408039093018*x_72 - 9.7540807723999, 2) + 0.000100987036480893*std::pow(-6.66584014892578*x_74 - 8.27351951599121, 2) - 4.66714086094456e-5*std::pow(-6.94191980361938*x_77 - 9.79944038391113, 2) - 0.000165628131537414*std::pow(-1.50623989105225*x_77 - 2.36735987663269, 2) - 3.66758893622835e-5*std::pow(-7.40000009536743*x_78 - 9.99612045288086, 2) + 1.92092313244255e-5*std::pow(-7.37215995788574*x_78 - 8.56719970703125, 2) + 3.24393243922782e-5*std::pow(-7.31472015380859*x_80 - 9.95207977294922, 2) - 6.68193003582354e-6*std::pow(-7.1406397819519*x_80 - 9.58688068389893, 2) + 7.27398445549784e-6*std::pow(-6.15687990188599*x_84 - 6.77792024612427, 2) - 0.000107016432905037*std::pow(-8.07520008087158*x_88 - 7.66735982894897, 2) - 1.27288053080178e-5*std::pow(-5.88727998733521*x_90 - 8.93711948394775, 2) + 9.54375895114311e-5*std::pow(-4.83951997756958*x_90 - 7.24056005477905, 2) - 0.00116974885826068*std::exp(0.460399866104126*x_1) + 0.000341351576285601*std::exp(1.18103992938995*x_1) - 0.000130089062576721*std::exp(1.18375980854034*x_1) - 0.0017630266955844*std::exp(0.595759809017181*x_100) - 7.59679546445524e-5*std::exp(1.62599992752075*x_100) - 0.002869925380674*std::exp(1.66631984710693*x_100) + 0.0109869222758598*std::exp(0.609039843082428*x_104) + 0.000495960711544951*std::exp(0.729839861392975*x_104) - 0.000554435300510699*std::exp(0.828719913959503*x_104) + 0.001302610927752*std::exp(0.893679857254028*x_104) + 0.000133476601914896*std::exp(0.863839864730835*x_106) - 0.0056052041315705*std::exp(0.912479817867279*x_106) - 0.00320268226373097*std::exp(1.19687986373901*x_106) + 0.00198032724209631*std::exp(0.576399862766266*x_110) - 0.00773921559195666*std::exp(0.783999860286713*x_110) + 0.0552506333780319*std::exp(0.562159836292267*x_112) - 0.00111191295009379*std::exp(1.24383985996246*x_26) - 0.000902637162033957*std::exp(0.575999855995178*x_31) - 0.00017468847172897*std::exp(0.60319983959198*x_31) - 0.0192208229858822*std::exp(0.629599869251251*x_31) - 0.000669002505291493*std::exp(0.646159827709198*x_31) - 0.000135674346040771*std::exp(1.33207988739014*x_50) + 0.00303892991566842*std::exp(0.898319840431213*x_6) - 7.30229575555302e-5*std::exp(1.28559982776642*x_60) + 0.000734493656556817*std::exp(1.3447197675705*x_60) - 0.000196126993189593*std::exp(1.45263981819153*x_60) - 0.000556670639469758*std::exp(0.721199870109558*x_70) + 0.00106993120074094*std::exp(0.880959868431091*x_72) - 0.00094059269188487*std::exp(0.898639857769012*x_74) - 0.0406904708963191*std::exp(0.675999820232391*x_76) - 0.0002815625704446*std::exp(0.759759843349457*x_77) - 0.00102677366760401*std::exp(0.727279841899872*x_81) + 1.31678197161383e-5*std::exp(2.27735996246338*x_81) - 1.03232855496903e-5*std::exp(2.64103984832764*x_81) - 0.0010014705945044*std::exp(0.677599847316742*x_87) + 0.00566367240717218*std::sin(0.347919851541519*x_10 - 4.24720001220703) - 0.0491161652472574*std::sin(0.371759831905365*x_100 + 5.16815996170044) - 0.0155734048033361*std::sin(0.315839856863022*x_101 + 5.13479995727539) - 0.175053043807372*std::sin(0.362959831953049*x_102 - 7.41792011260986) + 0.0614604181608392*std::sin(0.364479839801788*x_102 - 7.41215991973877) - 0.00488703943930323*std::sin(0.372399836778641*x_102 - 7.42935991287231) + 0.00168160641850785*std::sin(0.353599846363068*x_103 - 4.24520015716553) - 0.114277619525855*std::sin(0.331999838352203*x_105 + 5.13535976409912) - 0.0240361721362654*std::sin(0.368959844112396*x_105 - 7.41703987121582) + 0.0169382106064236*std::sin(0.512159824371338*x_107 + 5.27336025238037) - 0.0376427312870899*std::sin(0.141760036349297*x_108 - 7.67880010604858) - 0.171445632202801*std::sin(0.290719926357269*x_108 - 7.48176002502441) + 0.0165327165181736*std::sin(0.500319838523865*x_108 + 5.28128004074097) + 0.0441349992626607*std::sin(0.532639861106873*x_108 + 2.15879988670349) + 0.0419885023988066*std::sin(0.234479993581772*x_110 - 7.55600023269653) - 0.0381706418935872*std::sin(0.350399851799011*x_111 + 5.14800024032593) + 0.0206568425557865*std::sin(0.36167985200882*x_111 - 7.41599988937378) - 0.159524572427756*std::sin(0.364639848470688*x_111 - 7.42519998550415) + 0.00151840455310028*std::sin(0.411199867725372*x_111 + 8.19527912139893) + 0.0223337964926429*std::sin(0.238559976220131*x_112 - 7.55352020263672) - 0.0589456968072577*std::sin(0.42647984623909*x_112 + 5.22016000747681) - 0.00167907366549797*std::sin(0.483759850263596*x_112 - 7.34975957870483) + 0.00309869778862744*std::sin(0.561359822750092*x_112 + 2.18031978607178) + 0.0699797839383934*std::sin(0.352079838514328*x_113 + 5.14792013168335) + 0.0671210925005112*std::sin(0.23335999250412*x_114 - 7.55904006958008) - 0.0159332975304863*std::sin(0.335279852151871*x_114 + 5.12943983078003) - 0.0631064878682448*std::sin(0.456959843635559*x_114 + 5.24592018127441) + 0.148159481444115*std::sin(0.163440018892288*x_115 - 7.64416027069092) - 0.0078167826126473*std::sin(0.368639826774597*x_115 - 7.41511964797974) + 0.0266651683298285*std::sin(0.389999836683273*x_115 + 5.18383979797363) + 0.0405830853325616*std::sin(0.458079844713211*x_115 - 4.15824031829834) + 0.00359224242470086*std::sin(0.383359849452972*x_116 + 5.17575979232788) - 0.00894771190772662*std::sin(0.291759938001633*x_117 + 5.08567953109741) + 0.0160351719838677*std::sin(0.370319843292236*x_117 + 5.17880010604858) + 0.0576615602807489*std::sin(0.399759858846664*x_117 + 5.18656015396118) + 0.00526097309703974*std::sin(0.28687995672226*x_118 + 1.89631986618042) + 0.189457728961942*std::sin(0.529999852180481*x_118 - 7.22975969314575) + 0.0293859686505273*std::sin(0.331279844045639*x_119 + 5.1526403427124) + 0.0387820166038927*std::sin(0.344959855079651*x_119 + 5.15152025222778) + 0.530278226475434*std::sin(0.345199823379517*x_119 + 5.15088033676147) + 0.00553590703410658*std::sin(0.411679863929749*x_119 + 2.01143980026245) - 0.0145319076318664*std::sin(0.413199841976166*x_120 + 5.21072006225586) - 0.0127545837473838*std::sin(0.438319861888885*x_120 - 4.1812801361084) - 0.000280936713022175*std::sin(0.783199846744537*x_120 - 4.01696014404297) + 0.479457962245666*std::sin(0.221440002322197*x_14 - 4.37151956558228) + 0.0183924103115579*std::sin(0.384319841861725*x_16 + 5.19271993637085) - 0.107163041783354*std::sin(0.385279834270477*x_16 + 5.19063997268677) + 0.0142421709917526*std::sin(0.414559870958328*x_16 + 5.20528030395508) + 0.159263205329301*std::sin(0.417759865522385*x_2 - 4.17151975631714) - 0.0912641733207948*std::sin(0.447039872407913*x_2 - 4.14039993286133) + 0.024372792058527*std::sin(0.258479982614517*x_24 - 7.51384019851685) + 0.202864840234991*std::sin(0.270639955997467*x_24 - 7.49720001220703) + 0.0110654916032017*std::sin(0.297439932823181*x_28 + 5.12983989715576) + 0.181685057478008*std::sin(0.305759936571121*x_28 + 5.13399982452393) - 0.0850023654219783*std::sin(0.316559851169586*x_28 - 4.28560018539429) - 0.0356499379346749*std::sin(0.281359940767288*x_3 - 4.31383991241455) - 0.0462839530070252*std::sin(0.2882399559021*x_33 - 1.16303980350494) - 0.00780431886883122*std::sin(0.314479857683182*x_33 - 1.18263983726501) + 0.0243196571572279*std::sin(0.341279834508896*x_34 - 7.41287994384766) - 0.0301893500279122*std::sin(0.352959841489792*x_34 + 1.99951982498169) - 0.00337628124614718*std::sin(0.311919927597046*x_35 + 8.2792797088623) + 0.0289881856317629*std::sin(0.316639840602875*x_35 - 7.43399953842163) - 0.0166530331833384*std::sin(0.319359838962555*x_35 - 7.43088006973267) - 0.0789719594838498*std::sin(0.320079833269119*x_35 - 7.43167972564697) - 0.106619235067731*std::sin(0.320479840040207*x_35 + 1.98279976844788) - 0.00815399499051925*std::sin(0.264559954404831*x_36 - 7.52311992645264) - 0.0298556322265*std::sin(0.300559937953949*x_36 + 5.09175968170166) + 0.0216269645291947*std::sin(0.311679929494858*x_36 + 5.10960006713867) - 0.00872054801319795*std::sin(0.202240005135536*x_37 + 4.99927997589111) - 0.00746277628725756*std::sin(0.678639829158783*x_38 + 2.21391987800598) + 0.00508911267080695*std::sin(0.47343984246254*x_39 + 8.44896030426025) + 0.174434305794126*std::sin(0.342319846153259*x_4 + 8.3264799118042) + 0.0188084834147729*std::sin(0.398239850997925*x_4 - 4.21464014053345) + 0.0876459356491939*std::sin(0.243759974837303*x_40 + 1.85207998752594) - 0.024126208119687*std::sin(0.337839841842651*x_41 - 4.25608015060425) + 0.130624357198952*std::sin(0.198319986462593*x_42 - 7.60856008529663) + 0.0194447763366106*std::sin(0.370559841394424*x_43 - 7.410560131073) + 0.00341754482966065*std::sin(0.370959848165512*x_43 - 4.21415996551514) - 0.325292284026215*std::sin(0.37271985411644*x_43 - 7.42679977416992) - 0.27004275960212*std::sin(0.294719934463501*x_45 + 5.10903978347778) + 0.0471220726687992*std::sin(0.342879861593246*x_45 - 7.43375968933105) + 0.0353094921122077*std::sin(0.519439876079559*x_45 + 5.34327983856201) - 0.0147939988177471*std::sin(0.367279827594757*x_46 - 4.23912000656128) + 0.00260475496517433*std::sin(0.57127982378006*x_46 + 2.17831993103027) - 0.0200305912495559*std::sin(0.667999863624573*x_46 - 7.14032030105591) - 0.0654082438018474*std::sin(0.356239855289459*x_47 - 4.23776006698608) + 0.0408002939810421*std::sin(0.314479827880859*x_48 - 1.26639986038208) + 0.0183241687106833*std::sin(0.370799839496613*x_48 - 7.42199993133545) + 0.0805507852522782*std::sin(0.499119848012924*x_49 + 8.48079967498779) + 0.0130044271169247*std::sin(0.324479848146439*x_51 - 7.46815967559814) + 0.0543560282110729*std::sin(0.344719856977463*x_51 - 4.25576019287109) + 0.12342975712856*std::sin(0.392559856176376*x_51 + 2.00583982467651) + 0.0785717724632065*std::sin(0.256319969892502*x_53 + 5.06504011154175) - 0.183642039555704*std::sin(0.331999838352203*x_53 - 4.27663993835449) - 0.00834395533919003*std::sin(0.430319845676422*x_53 + 8.42768001556396) - 0.141516423505536*std::sin(0.0974400714039803*x_54 + 4.85640001296997) - 0.0114474183771608*std::sin(0.376319825649261*x_55 - 7.40751981735229) + 0.0947201640078661*std::sin(0.419439852237701*x_55 + 8.40575981140137) + 0.11442091848997*std::sin(0.096000075340271*x_56 - 1.48439979553223) - 0.619293811955124*std::sin(0.198959991335869*x_56 + 1.79975986480713) - 0.133650451276022*std::sin(0.32151985168457*x_57 - 4.28575992584229) - 0.00302473257306643*std::sin(0.677679836750031*x_57 - 3.95703983306885) + 0.012720246577917*std::sin(0.270799964666367*x_58 - 7.50408029556274) + 0.118556518684985*std::sin(0.356159836053848*x_58 + 5.15912008285522) + 0.00637061602594966*std::sin(0.425279855728149*x_58 + 5.21239995956421) + 0.493479324372221*std::sin(0.272079944610596*x_59 - 7.50024032592773) + 0.00524579550818137*std::sin(0.396159827709198*x_59 - 4.19447994232178) - 0.0158604559585543*std::sin(0.403359860181808*x_59 - 4.1878399848938) + 0.775824269044449*std::sin(0.133280038833618*x_63 - 7.67183971405029) - 0.00932940245966764*std::sin(0.405439853668213*x_63 + 5.19360017776489) + 0.0117933889829501*std::sin(0.202399998903275*x_64 - 4.39472007751465) - 0.0543622806243863*std::sin(0.229839980602264*x_64 - 4.35567998886108) - 0.46146891291762*std::sin(0.294319927692413*x_64 - 4.28071975708008) + 0.320834818554022*std::sin(0.199039995670319*x_66 + 4.99455976486206) - 0.198350193357754*std::sin(0.165360018610954*x_67 - 4.45287990570068) + 0.0647740800717116*std::sin(0.220559984445572*x_67 - 7.56264019012451) - 0.00479249742640709*std::sin(0.289759933948517*x_67 - 7.48559999465942) - 0.314638642935493*std::sin(0.246639966964722*x_70 + 5.05167961120605) + 0.00483597548537862*std::sin(0.760799884796143*x_70 + 2.37687993049622) + 0.348567558044466*std::sin(0.101840071380138*x_71 - 7.71872043609619) - 0.491901566191687*std::sin(0.218639999628067*x_71 + 5.03167963027954) - 0.0837506682358433*std::sin(0.172000005841255*x_72 - 7.62408018112183) - 0.00219937562940672*std::sin(0.417839854955673*x_72 - 0.988559782505035) - 0.103991608492879*std::sin(0.186880007386208*x_73 + 4.96799993515015) - 0.0070523548783036*std::sin(0.214399993419647*x_73 + 8.20792007446289) - 0.207464504994941*std::sin(0.252239972352982*x_73 + 5.07247972488403) - 0.0176664752185927*std::sin(0.510879814624786*x_73 + 2.10727977752686) - 0.149166772784083*std::sin(0.12896004319191*x_74 - 7.67944049835205) + 0.373212263870367*std::sin(0.321839839220047*x_75 + 5.12048006057739) - 0.00167499714539884*std::sin(0.450239837169647*x_75 - 7.35103988647461) - 0.05069472531126*std::sin(0.280479967594147*x_76 + 5.09592008590698) + 0.011087522711913*std::sin(0.379359841346741*x_76 - 4.20864009857178) - 0.00371024559138114*std::sin(0.612719833850861*x_76 - 3.99183988571167) + 0.0183095231079358*std::sin(0.14144004881382*x_79 - 4.48799991607666) + 0.0126283350747809*std::sin(0.324319839477539*x_79 - 4.27648019790649) - 0.101624895471424*std::sin(0.344319850206375*x_79 + 5.13976001739502) - 0.00375859172353909*std::sin(0.428879857063293*x_79 - 1.18207991123199) - 0.0794554491483943*std::sin(0.297279924154282*x_81 - 7.47096014022827) + 0.105542901649534*std::sin(0.23463998734951*x_82 + 5.0479998588562) - 0.312237719556948*std::sin(0.296399921178818*x_83 - 7.48288011550903) + 0.00824279105951767*std::sin(0.281279951334*x_84 - 7.50392007827759) + 0.0911961069896794*std::sin(0.285679936408997*x_84 + 5.08895969390869) + 0.109398995504929*std::sin(0.324639827013016*x_84 - 1.08567988872528) + 0.0385202669826196*std::sin(0.184720009565353*x_85 + 1.77711987495422) + 0.0293747899135752*std::sin(0.202799841761589*x_85 - 1.36799991130829) + 0.00874086915861674*std::sin(0.213839992880821*x_85 + 5.00920009613037) + 0.0205968880036933*std::sin(0.271919965744019*x_86 + 5.07535982131958) - 0.00326714299361847*std::sin(0.294719934463501*x_86 - 7.4986400604248) + 0.359418227053581*std::sin(0.310959845781326*x_86 - 4.30808019638062) - 0.0742902875653897*std::sin(0.434079855680466*x_86 + 5.24151992797852) - 0.133316013676271*std::sin(0.150880038738251*x_87 + 4.91951942443848) + 0.00618832294651292*std::sin(0.306479841470718*x_87 - 4.31288003921509) - 0.000209311642666816*std::sin(0.950239837169647*x_87 - 3.83208012580872) + 0.121220617751561*std::sin(0.191359996795654*x_88 - 7.60824012756348) - 0.0058372247469184*std::sin(0.212960004806519*x_88 - 7.57991981506348) - 0.0981846395754059*std::sin(0.204080000519753*x_89 - 4.40327978134155) - 0.00404653702283062*std::sin(0.285919934511185*x_89 - 7.49544048309326) - 0.0185245391780811*std::sin(0.274079948663712*x_90 - 7.50888013839722) + 0.00450193029252452*std::sin(0.361039847135544*x_92 + 1.97879981994629) - 0.0125094830102557*std::sin(0.362799853086472*x_92 + 1.98575985431671) + 0.0452644539007251*std::sin(0.363679856061935*x_92 + 2.00567984580994) - 0.161956252860991*std::sin(0.369039833545685*x_92 + 2.00383973121643) + 0.146619089485075*std::sin(0.270719945430756*x_93 - 1.36999988555908) + 0.074852832663317*std::sin(0.343679845333099*x_93 + 1.97367978096008) - 0.00934533945967163*std::sin(0.365119844675064*x_95 + 5.18239974975586) + 0.126727250008629*std::sin(0.376399844884872*x_95 + 1.9883998632431) - 0.0869010647927624*std::sin(0.381439834833145*x_95 - 7.42175960540771) - 0.000539781138272981*std::sin(0.43615984916687*x_95 + 5.22552013397217) - 0.00998364880880533*std::sin(0.403999865055084*x_96 - 7.39807987213135) - 0.00333908979285031*std::sin(0.421199858188629*x_96 + 5.20864009857178) - 1.5369396327107*std::sin(0.114480063319206*x_97 + 1.71391987800598) - 0.000686463127035582*std::sin(0.437599837779999*x_97 + 5.21184015274048) + 0.0743775688385181*std::sin(0.363839834928513*x_98 + 5.17519998550415) - 0.00893520702761771*std::sin(0.42375984787941*x_98 + 2.02567982673645) - 0.369142668475316*std::sin(0.366159856319427*x_99 - 7.4347996711731) - 0.07591592628944*std::sin(0.376159846782684*x_99 + 1.98311984539032) + 0.021476820303034*std::sin(0.406079858541489*x_99 + 5.20360040664673) + 0.00487113113142957*std::sin(0.441999852657318*x_99 - 4.16584014892578) + 3.16084747478107 + 0.000135147633441178*std::exp(-1.2125598192215*x_9));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.112623979492391*x_1 - 0.10820603547726*x_10 + 0.000909871513587477*x_100 - 0.0869974698383274*x_101 - 4.29486462377815e-5*x_102 - 0.0449227561705598*x_103 - 0.00181504297831374*x_104 + 0.00131862828351005*x_105 - 0.00106752842066023*x_106 - 0.00744707017858207*x_107 - 2.03421617027186e-5*x_108 - 0.0231044853609682*x_109 - 0.014359005503953*x_11 + 0.000854567591753951*x_110 + 1.03088204426742e-5*x_111 - 0.0140596451340979*x_113 + 0.00225455473118858*x_114 - 0.00176509693045295*x_115 + 0.00320485530874867*x_116 + 0.0287725384330463*x_117 - 9.35503608357358e-6*x_118 + 2.51393089918312e-5*x_119 - 0.0172604222271657*x_12 + 0.000776356068940078*x_120 + 0.0249934768331355*x_13 - 5.2221530676373e-5*x_14 - 0.0019739296644854*x_15 - 0.000204822531897899*x_16 + 0.000612906978991923*x_17 + 0.00689836595847158*x_18 - 0.0410966050531546*x_19 - 0.00625782252607564*x_2 - 0.0179984697060091*x_20 + 0.000799905023134573*x_21 - 0.005487880161644*x_22 - 0.00214382489836747*x_23 - 0.00394042856129832*x_24 + 0.0453662589817297*x_25 - 0.0052058448820183*x_26 - 0.00103638438342209*x_27 - 0.000605075884697631*x_28 - 0.0267401689484833*x_29 + 0.0306716604025159*x_3 - 0.00138048854085761*x_30 + 0.00155270457420572*x_31 + 0.0460862500918041*x_32 + 0.0290729018657907*x_33 + 0.030684437689544*x_34 - 0.0081066857292639*x_36 + 0.0133522074754708*x_37 + 0.00787455040326035*x_38 - 0.0148930867638931*x_39 - 0.00281897873734199*x_4 + 0.000952695062163535*x_40 - 0.0249917713545964*x_41 - 0.0168830855504077*x_42 + 4.93430614328541e-5*x_43 + 0.00492054049624551*x_44 + 3.22693862083165e-5*x_45 + 0.000236617210346714*x_46 - 0.0230395335261708*x_47 - 0.0126933362954908*x_48 + 0.00299581729333162*x_49 - 0.0109402179458447*x_5 - 0.0040123247662097*x_50 + 0.00302377908077234*x_51 - 0.000940338045416563*x_52 - 0.00132553045378537*x_53 + 0.00868811493244303*x_54 - 0.00171967367307148*x_55 - 0.00232179962416477*x_56 - 0.0030135597336491*x_57 + 0.0344252763391302*x_58 - 0.00017933185392531*x_59 - 0.0068325120225133*x_6 + 0.0177277577981705*x_60 - 0.0412814549581913*x_61 + 0.0322758201600981*x_62 + 0.00148963521437091*x_63 - 0.000777407049925031*x_64 + 0.0516960122760289*x_65 - 0.000438707064227798*x_66 + 0.00252966417390621*x_67 + 0.00183513452885749*x_68 - 0.0205236285510493*x_69 - 0.0210702451886664*x_7 + 7.80351626135215e-6*x_70 + 0.00360924547856634*x_71 - 0.00334309875394366*x_72 + 7.08202868014247e-6*x_73 - 0.000468213677657088*x_74 + 0.000386535270012756*x_75 - 0.00940436337208545*x_76 + 0.00285907956875236*x_77 + 0.000316711655511846*x_78 - 0.0188986913463917*x_79 + 0.100491286651194*x_8 + 0.00366817413901125*x_80 + 0.023106940394917*x_81 + 0.0165682708841858*x_82 + 0.00212522242734606*x_83 - 6.00920066807521e-5*x_84 + 0.00589035508927177*x_85 + 0.000499873168935471*x_86 + 0.00403130671366885*x_87 + 0.00236471019198942*x_88 + 0.0103025711441756*x_89 + 0.00895214065900278*x_9 - 0.00812008131631687*x_90 - 0.00244638011278051*x_91 - 0.000162368495656027*x_92 + 0.0372764331744974*x_93 - 0.0104942164903576*x_94 - 6.57701631105817e-5*x_95 + 0.0063248686064925*x_96 - 0.000199741896940348*x_97 + 0.000934838655724906*x_98 + 2.88056710117531e-5*x_99 + 3.17890145023549e-7*std::pow(-7.87296009063721*x_106 - 9.04559993743896, 2) - 6.55022831829005e-6*std::pow(-7.23343992233276*x_107 - 9.84928035736084, 2) - 0.000347861614680607*std::pow(-3.99151992797852*x_110 - 5.38871955871582, 2) - 1.13895442748662e-5*std::pow(-8.07431983947754*x_116 - 9.47160053253174, 2) + 0.000108441920575095*std::pow(-8.54367923736572*x_120 - 9.14231967926025, 2) + 1.99502388548858e-5*std::pow(-7.97567987442017*x_13 - 9.75928020477295, 2) - 3.7686495418905e-5*std::pow(-2.19231986999512*x_13 - 3.18535995483398, 2) - 2.66442481176097e-5*std::pow(-6.53927993774414*x_14 - 9.78439998626709, 2) + 6.60327137787838e-5*std::pow(-6.46400022506714*x_14 - 8.68704032897949, 2) + 7.92887564833719e-5*std::pow(-5.62559986114502*x_15 - 7.82880020141602, 2) - 0.000558532457149025*std::pow(-6.89976024627686*x_17 - 9.1307201385498, 2) - 2.09372664998767e-5*std::pow(-6.92984008789063*x_19 - 9.97432041168213, 2) - 3.73139275252942e-5*std::pow(-6.88104009628296*x_23 - 8.10231971740723, 2) + 0.000442489531743846*std::pow(-5.86168003082275*x_27 - 8.08047962188721, 2) - 3.22504957002987e-5*std::pow(-4.25631999969482*x_27 - 5.47039985656738, 2) + 1.19743352533137e-5*std::pow(-7.61320018768311*x_36 - 9.01000022888184, 2) + 1.97776829774727e-5*std::pow(-5.53175973892212*x_52 - 7.57728004455566, 2) + 3.05354212512442e-7*std::pow(-8.06855964660645*x_56 - 7.47832012176514, 2) + 1.20118909569141e-5*std::pow(-7.14911985397339*x_68 - 9.59352016448975, 2) - 9.42872067593803e-6*std::pow(-7.14143991470337*x_68 - 9.17271995544434, 2) + 3.94080396612124e-5*std::pow(-5.12191963195801*x_7 - 7.37095975875854, 2) - 1.02742445285523e-5*std::pow(-4.89592027664185*x_7 - 7.74936008453369, 2) + 4.37038257758779e-6*std::pow(-7.63944053649902*x_70 - 9.65192031860352, 2) - 7.50447615726916e-6*std::pow(-9.15408039093018*x_72 - 9.7540807723999, 2) - 8.22596090673259e-6*std::pow(-6.66584014892578*x_74 - 8.27351951599121, 2) + 3.23500419311698e-5*std::pow(-6.94191980361938*x_77 - 9.79944038391113, 2) + 5.5542090310724e-6*std::pow(-1.50623989105225*x_77 - 2.36735987663269, 2) + 2.54217002246787e-5*std::pow(-7.40000009536743*x_78 - 9.99612045288086, 2) + 2.04116208579428e-5*std::pow(-7.37215995788574*x_78 - 8.56719970703125, 2) - 2.64236503605277e-6*std::pow(-7.31472015380859*x_80 - 9.95207977294922, 2) + 2.24073264640926e-7*std::pow(-7.1406397819519*x_80 - 9.58688068389893, 2) - 5.04192414913332e-6*std::pow(-6.15687990188599*x_84 - 6.77792024612427, 2) - 0.000113715057991391*std::pow(-8.07520008087158*x_88 - 7.66735982894897, 2) + 4.26850467612652e-7*std::pow(-5.88727998733521*x_90 - 8.93711948394775, 2) - 6.61520642828792e-5*std::pow(-4.83951997756958*x_90 - 7.24056005477905, 2) + 0.00433986482870782*std::exp(0.460399866104126*x_1) - 2.78050017093844e-5*std::exp(1.18103992938995*x_1) + 4.36243432501775e-6*std::exp(1.18375980854034*x_1) + 0.00654097458117338*std::exp(0.595759809017181*x_100) + 2.54752556731922e-6*std::exp(1.62599992752075*x_100) - 0.00304956652203036*std::exp(1.66631984710693*x_100) - 0.000894946482993706*std::exp(0.609039843082428*x_104) - 0.00184005518214848*std::exp(0.729839861392975*x_104) + 1.85925514262428e-5*std::exp(0.828719913959503*x_104) - 0.00090289792805287*std::exp(0.893679857254028*x_104) - 0.000495209211802282*std::exp(0.863839864730835*x_106) - 0.0059560582947175*std::exp(0.912479817867279*x_106) + 0.000260876445296236*std::exp(1.19687986373901*x_106) - 6.64087154182828e-5*std::exp(0.576399862766266*x_110) + 0.000630402545976837*std::exp(0.783999860286713*x_110) + 0.05870901139285*std::exp(0.562159836292267*x_112) - 0.0011815124291565*std::exp(1.24383985996246*x_26) + 3.02692267950755e-5*std::exp(0.575999855995178*x_31) + 0.00012108439735801*std::exp(0.60319983959198*x_31) - 0.0204239380920253*std::exp(0.629599869251251*x_31) + 0.00248205452181338*std::exp(0.646159827709198*x_31) + 0.000503363023936424*std::exp(1.33207988739014*x_50) - 0.0021064183217702*std::exp(0.898319840431213*x_6) + 0.000270921200688058*std::exp(1.28559982776642*x_60) - 0.000509110423184922*std::exp(1.3447197675705*x_60) + 1.59756443495383e-5*std::exp(1.45263981819153*x_60) + 0.00206529402644709*std::exp(0.721199870109558*x_70) - 8.71519012428259e-5*std::exp(0.880959868431091*x_72) + 3.15420356151729e-5*std::exp(0.898639857769012*x_74) - 0.0432374648646522*std::exp(0.675999820232391*x_76) + 0.0010446203797711*std::exp(0.759759843349457*x_77) + 0.000711702778863378*std::exp(0.727279841899872*x_81) - 4.88536981705679e-5*std::exp(2.27735996246338*x_81) + 3.46183255816521e-7*std::exp(2.64103984832764*x_81) + 0.000694164086542998*std::exp(0.677599847316742*x_87) - 0.00392574480426864*std::sin(0.347919851541519*x_10 - 4.24720001220703) + 0.00400078732173707*std::sin(0.371759831905365*x_100 + 5.16815996170044) + 0.000522241872804662*std::sin(0.315839856863022*x_101 + 5.13479995727539) - 0.186010376983775*std::sin(0.362959831953049*x_102 - 7.41792011260986) - 0.04260096628427*std::sin(0.364479839801788*x_102 - 7.41215991973877) + 0.0181313197524092*std::sin(0.372399836778641*x_102 - 7.42935991287231) - 0.00623889863185073*std::sin(0.353599846363068*x_103 - 4.24520015716553) - 0.12143075393881*std::sin(0.331999838352203*x_105 + 5.13535976409912) + 0.0166605465667396*std::sin(0.368959844112396*x_105 - 7.41703987121582) - 0.0117406317847002*std::sin(0.512159824371338*x_107 + 5.27336025238037) + 0.139657640540252*std::sin(0.141760036349297*x_108 - 7.67880010604858) - 0.182177161759935*std::sin(0.290719926357269*x_108 - 7.48176002502441) - 0.0114595656855923*std::sin(0.500319838523865*x_108 + 5.28128004074097) - 0.00359504339571355*std::sin(0.532639861106873*x_108 + 2.15879988670349) - 0.0291041100686537*std::sin(0.234479993581772*x_110 - 7.55600023269653) + 0.00310921301330537*std::sin(0.350399851799011*x_111 + 5.14800024032593) - 0.0143181820038322*std::sin(0.36167985200882*x_111 - 7.41599988937378) - 0.169509910882297*std::sin(0.364639848470688*x_111 - 7.42519998550415) - 0.00563340623862457*std::sin(0.411199867725372*x_111 + 8.19527912139893) - 0.0154805538239741*std::sin(0.238559976220131*x_112 - 7.55352020263672) + 0.00480145783511881*std::sin(0.42647984623909*x_112 + 5.22016000747681) + 0.00622950190910145*std::sin(0.483759850263596*x_112 - 7.34975957870483) - 0.000103912391466367*std::sin(0.561359822750092*x_112 + 2.18031978607178) - 0.0485061199606275*std::sin(0.352079838514328*x_113 + 5.14792013168335) - 0.0465246329937857*std::sin(0.23335999250412*x_114 - 7.55904006958008) + 0.0591138491562303*std::sin(0.335279852151871*x_114 + 5.12943983078003) + 0.00514037761929564*std::sin(0.456959843635559*x_114 + 5.24592018127441) - 0.0120684213022891*std::sin(0.163440018892288*x_115 - 7.64416027069092) + 0.000262129652602451*std::sin(0.368639826774597*x_115 - 7.41511964797974) - 0.0184828214804957*std::sin(0.389999836683273*x_115 + 5.18383979797363) + 0.0431233575702989*std::sin(0.458079844713211*x_115 - 4.15824031829834) - 0.0133275159407568*std::sin(0.383359849452972*x_116 + 5.17575979232788) + 0.0331967498249945*std::sin(0.291759938001633*x_117 + 5.08567953109741) - 0.0005377268717632*std::sin(0.370319843292236*x_117 + 5.17880010604858) - 0.0399678078823056*std::sin(0.399759858846664*x_117 + 5.18656015396118) - 0.0195186444914081*std::sin(0.28687995672226*x_118 + 1.89631986618042) + 0.201316714181103*std::sin(0.529999852180481*x_118 - 7.22975969314575) - 0.00239365207406044*std::sin(0.331279844045639*x_119 + 5.1526403427124) - 0.0268815512685713*std::sin(0.344959855079651*x_119 + 5.15152025222778) + 0.563470652481333*std::sin(0.345199823379517*x_119 + 5.15088033676147) - 0.0205386720941439*std::sin(0.411679863929749*x_119 + 2.01143980026245) + 0.00118370543631705*std::sin(0.413199841976166*x_120 + 5.21072006225586) + 0.00884077278436751*std::sin(0.438319861888885*x_120 - 4.1812801361084) + 9.42099155586431e-6*std::sin(0.783199846744537*x_120 - 4.01696014404297) + 0.509469326356456*std::sin(0.221440002322197*x_14 - 4.37151956558228) - 0.0127486026782093*std::sin(0.384319841861725*x_16 + 5.19271993637085) - 0.113870843758561*std::sin(0.385279834270477*x_16 + 5.19063997268677) - 0.00116010476084546*std::sin(0.414559870958328*x_16 + 5.20528030395508) + 0.169232183677689*std::sin(0.417759865522385*x_2 - 4.17151975631714) + 0.00743397913319464*std::sin(0.447039872407913*x_2 - 4.14039993286133) - 0.0168938728991663*std::sin(0.258479982614517*x_24 - 7.51384019851685) - 0.0165244798072604*std::sin(0.270639955997467*x_24 - 7.49720001220703) - 0.000371072551656937*std::sin(0.297439932823181*x_28 + 5.12983989715576) + 0.193057517303107*std::sin(0.305759936571121*x_28 + 5.13399982452393) + 0.00692391973571068*std::sin(0.316559851169586*x_28 - 4.28560018539429) + 0.0247105673771528*std::sin(0.281359940767288*x_3 - 4.31383991241455) + 0.0320814791138429*std::sin(0.2882399559021*x_33 - 1.16303980350494) + 0.00026171169076335*std::sin(0.314479857683182*x_33 - 1.18263983726501) - 0.0019809725684776*std::sin(0.341279834508896*x_34 - 7.41287994384766) + 0.0209255895284907*std::sin(0.352959841489792*x_34 + 1.99951982498169) + 0.0125262821403965*std::sin(0.311919927597046*x_35 + 8.2792797088623) - 0.0200930087313943*std::sin(0.316639840602875*x_35 - 7.43399953842163) + 0.000558446360790788*std::sin(0.319359838962555*x_35 - 7.43088006973267) + 0.00643270932665825*std::sin(0.320079833269119*x_35 - 7.43167972564697) - 0.113292997809817*std::sin(0.320479840040207*x_35 + 1.98279976844788) + 0.000273437804286471*std::sin(0.264559954404831*x_36 - 7.52311992645264) + 0.00243190880828987*std::sin(0.300559937953949*x_36 + 5.09175968170166) - 0.01499061695819*std::sin(0.311679929494858*x_36 + 5.10960006713867) + 0.0323539530235656*std::sin(0.202240005135536*x_37 + 4.99927997589111) + 0.000607885013105482*std::sin(0.678639829158783*x_38 + 2.21391987800598) - 0.000170659387955216*std::sin(0.47343984246254*x_39 + 8.44896030426025) + 0.185352909460818*std::sin(0.342319846153259*x_4 + 8.3264799118042) - 0.0697810261379341*std::sin(0.398239850997925*x_4 - 4.21464014053345) - 0.00713925336764068*std::sin(0.243759974837303*x_40 + 1.85207998752594) + 0.0167229545361107*std::sin(0.337839841842651*x_41 - 4.25608015060425) - 0.0905415876340826*std::sin(0.198319986462593*x_42 - 7.60856008529663) - 0.0134780446653214*std::sin(0.370559841394424*x_43 - 7.410560131073) - 0.0126793734416035*std::sin(0.370959848165512*x_43 - 4.21415996551514) - 0.345653746233697*std::sin(0.37271985411644*x_43 - 7.42679977416992) - 0.286945913209046*std::sin(0.294719934463501*x_45 + 5.10903978347778) - 0.0326624173586818*std::sin(0.342879861593246*x_45 - 7.43375968933105) - 0.00287615630553291*std::sin(0.519439876079559*x_45 + 5.34327983856201) + 0.0102543826368878*std::sin(0.367279827594757*x_46 - 4.23912000656128) - 8.73484076467644e-5*std::sin(0.57127982378006*x_46 + 2.17831993103027) - 0.0212843932816031*std::sin(0.667999863624573*x_46 - 7.14032030105591) + 0.0453373809078842*std::sin(0.356239855289459*x_47 - 4.23776006698608) - 0.0033234129346369*std::sin(0.314479827880859*x_48 - 1.26639986038208) - 0.0127013013707168*std::sin(0.370799839496613*x_48 - 7.42199993133545) + 0.0855928100719172*std::sin(0.499119848012924*x_49 + 8.48079967498779) - 0.00901395040470698*std::sin(0.324479848146439*x_51 - 7.46815967559814) - 0.00442760356864355*std::sin(0.344719856977463*x_51 - 4.25576019287109) + 0.131155763733897*std::sin(0.392559856176376*x_51 + 2.00583982467651) - 0.00640011184779454*std::sin(0.256319969892502*x_53 + 5.06504011154175) - 0.195136995420741*std::sin(0.331999838352203*x_53 - 4.27663993835449) + 0.00578356885161543*std::sin(0.430319845676422*x_53 + 8.42768001556396) + 0.525037613603146*std::sin(0.0974400714039803*x_54 + 4.85640001296997) + 0.00793471796841905*std::sin(0.376319825649261*x_55 - 7.40751981735229) + 0.100649112016904*std::sin(0.419439852237701*x_55 + 8.40575981140137) - 0.424511053219939*std::sin(0.096000075340271*x_56 - 1.48439979553223) - 0.658058111530196*std::sin(0.198959991335869*x_56 + 1.79975986480713) - 0.142016215686377*std::sin(0.32151985168457*x_57 - 4.28575992584229) + 0.000101432026177929*std::sin(0.677679836750031*x_57 - 3.95703983306885) - 0.00881697215556406*std::sin(0.270799964666367*x_58 - 7.50408029556274) - 0.00965709384021296*std::sin(0.356159836053848*x_58 + 5.15912008285522) - 0.000213633594344034*std::sin(0.425279855728149*x_58 + 5.21239995956421) + 0.524368346666303*std::sin(0.272079944610596*x_59 - 7.50024032592773) - 0.0194623343838103*std::sin(0.396159827709198*x_59 - 4.19447994232178) + 0.0109935918069304*std::sin(0.403359860181808*x_59 - 4.1878399848938) - 0.0631952409937436*std::sin(0.133280038833618*x_63 - 7.67183971405029) + 0.00646662635123307*std::sin(0.405439853668213*x_63 + 5.19360017776489) - 0.0437544466890768*std::sin(0.202399998903275*x_64 - 4.39472007751465) + 0.0376809295041718*std::sin(0.229839980602264*x_64 - 4.35567998886108) - 0.490354264005575*std::sin(0.294319927692413*x_64 - 4.28071975708008) + 0.34091726856475*std::sin(0.199039995670319*x_66 + 4.99455976486206) + 0.0161567364808496*std::sin(0.165360018610954*x_67 - 4.45287990570068) - 0.0448978136466345*std::sin(0.220559984445572*x_67 - 7.56264019012451) + 0.000160712629189617*std::sin(0.289759933948517*x_67 - 7.48559999465942) - 0.334333247301295*std::sin(0.246639966964722*x_70 + 5.05167961120605) - 0.000393917344986831*std::sin(0.760799884796143*x_70 + 2.37687993049622) - 0.241607773464584*std::sin(0.101840071380138*x_71 - 7.71872043609619) - 0.522691829722825*std::sin(0.218639999628067*x_71 + 5.03167963027954) + 0.0580513361374033*std::sin(0.172000005841255*x_72 - 7.62408018112183) + 7.3754330681512e-5*std::sin(0.417839854955673*x_72 - 0.988559782505035) + 0.0720812376456448*std::sin(0.186880007386208*x_73 + 4.96799993515015) + 0.0261648187812081*std::sin(0.214399993419647*x_73 + 8.20792007446289) - 0.220450612828683*std::sin(0.252239972352982*x_73 + 5.07247972488403) + 0.00143903355888059*std::sin(0.510879814624786*x_73 + 2.10727977752686) + 0.103394165680393*std::sin(0.12896004319191*x_74 - 7.67944049835205) + 0.396573246529128*std::sin(0.321839839220047*x_75 + 5.12048006057739) + 0.00621437768301068*std::sin(0.450239837169647*x_75 - 7.35103988647461) + 0.00412936989855*std::sin(0.280479967594147*x_76 + 5.09592008590698) - 0.0411356245531869*std::sin(0.379359841346741*x_76 - 4.20864009857178) + 0.000124420165704101*std::sin(0.612719833850861*x_76 - 3.99183988571167) - 0.0126911498480372*std::sin(0.14144004881382*x_79 - 4.48799991607666) - 0.000423481277417614*std::sin(0.324319839477539*x_79 - 4.27648019790649) + 0.00827791810146727*std::sin(0.344319850206375*x_79 + 5.13976001739502) + 0.0139446855718362*std::sin(0.428879857063293*x_79 - 1.18207991123199) + 0.00647209227340018*std::sin(0.297279924154282*x_81 - 7.47096014022827) - 0.073156508355498*std::sin(0.23463998734951*x_82 + 5.0479998588562) - 0.331782039661376*std::sin(0.296399921178818*x_83 - 7.48288011550903) - 0.0305814352858432*std::sin(0.281279951334*x_84 - 7.50392007827759) - 0.00742843474850595*std::sin(0.285679936408997*x_84 + 5.08895969390869) + 0.116246755571475*std::sin(0.324639827013016*x_84 - 1.08567988872528) - 0.0267001208923315*std::sin(0.184720009565353*x_85 + 1.77711987495422) - 0.000985060459895238*std::sin(0.202799841761589*x_85 - 1.36799991130829) - 0.032429346150611*std::sin(0.213839992880821*x_85 + 5.00920009613037) - 0.000690700428122974*std::sin(0.271919965744019*x_86 + 5.07535982131958) + 0.012121370213985*std::sin(0.294719934463501*x_86 - 7.4986400604248) + 0.381915780811241*std::sin(0.310959845781326*x_86 - 4.30808019638062) + 0.00605136087321901*std::sin(0.434079855680466*x_86 + 5.24151992797852) + 0.010859337544279*std::sin(0.150880038738251*x_87 + 4.91951942443848) - 0.0229591889871047*std::sin(0.306479841470718*x_87 - 4.31288003921509) + 7.01910119505284e-6*std::sin(0.950239837169647*x_87 - 3.83208012580872) - 0.0840234349899533*std::sin(0.191359996795654*x_88 - 7.60824012756348) + 0.000195746737615101*std::sin(0.212960004806519*x_88 - 7.57991981506348) + 0.0680561676173268*std::sin(0.204080000519753*x_89 - 4.40327978134155) + 0.0150129864025334*std::sin(0.285919934511185*x_89 - 7.49544048309326) + 0.0687275695797755*std::sin(0.274079948663712*x_90 - 7.50888013839722) - 0.01670253302651*std::sin(0.361039847135544*x_92 + 1.97879981994629) + 0.00041949566697801*std::sin(0.362799853086472*x_92 + 1.98575985431671) - 0.0313748186589681*std::sin(0.363679856061935*x_92 + 2.00567984580994) - 0.172093800795047*std::sin(0.369039833545685*x_92 + 2.00383973121643) - 0.0119429477318422*std::sin(0.270719945430756*x_93 - 1.36999988555908) - 0.0518838481089913*std::sin(0.343679845333099*x_93 + 1.97367978096008) + 0.000313388603394469*std::sin(0.365119844675064*x_95 + 5.18239974975586) + 0.134659661069141*std::sin(0.376399844884872*x_95 + 1.9883998632431) + 0.00707857945582895*std::sin(0.381439834833145*x_95 - 7.42175960540771) + 0.00200263258275284*std::sin(0.43615984916687*x_95 + 5.22552013397217) + 0.00692011377444394*std::sin(0.403999865055084*x_96 - 7.39807987213135) + 0.00011197374812395*std::sin(0.421199858188629*x_96 + 5.20864009857178) - 1.63314338479262*std::sin(0.114480063319206*x_97 + 1.71391987800598) + 0.00254683486988503*std::sin(0.437599837779999*x_97 + 5.21184015274048) + 0.0790331851299509*std::sin(0.363839834928513*x_98 + 5.17519998550415) + 0.000299635135086248*std::sin(0.42375984787941*x_98 + 2.02567982673645) - 0.392248917416417*std::sin(0.366159856319427*x_99 - 7.4347996711731) + 0.00618377827111976*std::sin(0.376159846782684*x_99 + 1.98311984539032) - 0.0148865452758316*std::sin(0.406079858541489*x_99 + 5.20360040664673) - 0.0180722986169428*std::sin(0.441999852657318*x_99 - 4.16584014892578) + 1.21505608159509 - 4.53206951753538e-6*std::exp(-1.2125598192215*x_9));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0660355092078388*x_1 + 0.0730408920861267*x_10 - 0.000705139633528384*x_100 + 0.0424812748521751*x_101 + 0.000605837884946716*x_102 + 0.0237963080564445*x_103 + 0.00106528498698347*x_104 - 0.00380915909811781*x_105 + 0.000827321866971626*x_106 + 0.00857519773312941*x_107 + 6.1476136739916e-5*x_108 - 0.00441458887634394*x_109 + 0.0214349810093351*x_11 - 0.00259871873787609*x_110 - 3.11543317973124e-5*x_111 + 0.0141188209572898*x_113 - 0.0012986095737156*x_114 + 0.0053676157528056*x_115 + 0.0167400541762724*x_116 - 0.0189168702394362*x_117 + 0.011292360890002*x_118 - 7.59736167529468e-5*x_119 + 0.0221888767635487*x_12 - 0.00236087944720386*x_120 - 0.012884738246988*x_13 + 0.00122728916596947*x_14 - 0.00620702355737037*x_15 + 0.000623166523962339*x_16 - 0.00750184904643057*x_17 - 0.00238757394252086*x_18 + 0.0143710903643031*x_19 + 0.010569495905652*x_2 - 0.00188357794474545*x_20 - 0.00419619946996777*x_21 + 0.00381115455419853*x_22 + 0.00161550624745981*x_23 + 0.0019261030559857*x_24 - 0.0280075111598653*x_25 + 0.0119236970013522*x_26 + 0.0111438131350527*x_27 + 0.000781570515372246*x_28 + 0.0307189655362202*x_29 - 0.0221975077130671*x_3 + 0.00528075614098068*x_30 - 0.0239089641826781*x_31 - 0.0294651214861444*x_32 + 0.00803640085254505*x_33 - 0.0220487543420736*x_34 + 0.00475797581917379*x_36 - 0.00938908468266175*x_37 - 0.00530146133698449*x_38 + 0.0133805988052527*x_39 + 0.00491279438329044*x_4 - 0.000432313461508242*x_40 + 0.00733413977644476*x_41 + 0.00687712696468189*x_42 - 0.000679113759467423*x_43 + 0.0115373575104109*x_44 - 9.84273236618341e-5*x_45 - 0.00311715585465638*x_46 + 0.0347694396875149*x_47 + 0.00431681558661136*x_48 - 0.0022055429752498*x_49 + 0.000784440618397464*x_5 - 0.00191221428106482*x_50 - 0.00919497030692442*x_51 + 0.00621483744408083*x_52 + 0.00403117684765685*x_53 - 0.000853139833867902*x_54 + 0.00574161096227052*x_55 - 0.00254092240233964*x_56 + 0.00426456584814754*x_57 - 0.028941847894447*x_58 + 0.00292002138016593*x_59 + 0.00466473228783765*x_6 - 0.0104472638397898*x_60 + 0.00230024961524937*x_61 - 0.0225490261624957*x_62 + 0.00318913164013066*x_63 + 0.0124782390948546*x_64 - 0.0289303926801047*x_65 + 0.00153982923040325*x_66 + 0.00477939794705785*x_67 - 0.000808078265461699*x_68 + 0.0202564040913519*x_69 + 0.0126703983139277*x_7 - 2.35830409641729e-5*x_70 - 0.0114777601653237*x_71 + 0.00196213145095219*x_72 - 2.14026301579473e-5*x_73 + 0.00466309601781534*x_74 - 0.000503620047094801*x_75 + 0.00728827009388786*x_76 + 0.00274137308543169*x_77 - 0.00283062460603902*x_78 + 0.0110920195309367*x_79 - 0.0743473373970728*x_8 + 0.000827076884525059*x_80 - 0.0135619249747441*x_81 - 0.0169600576033914*x_82 + 0.00106165220552889*x_83 + 0.000181604318836388*x_84 + 0.00714986974319302*x_85 - 0.000387395778294076*x_86 - 0.00236605445232314*x_87 - 0.00639512166851666*x_88 - 0.0157517851592071*x_89 + 0.000669365507736233*x_9 + 0.00640333667805863*x_90 - 0.000917921090738094*x_91 + 0.00250019392711658*x_92 - 0.0313482959120618*x_93 + 0.00333540656107911*x_94 + 5.09710964903604e-5*x_95 - 0.00843828038878371*x_96 - 0.00205478366807388*x_97 + 0.000402483859026443*x_98 - 8.70537456088997e-5*x_99 - 9.60697211502732e-7*std::pow(-7.87296009063721*x_106 - 9.04559993743896, 2) + 0.000100862183864225*std::pow(-7.23343992233276*x_107 - 9.84928035736084, 2) + 0.00020416693163451*std::pow(-3.99151992797852*x_110 - 5.38871955871582, 2) + 8.82676175273216e-6*std::pow(-8.07431983947754*x_116 - 9.47160053253174, 2) - 6.36467297626347e-5*std::pow(-8.54367923736572*x_120 - 9.14231967926025, 2) - 1.54611985372211e-5*std::pow(-7.97567987442017*x_13 - 9.75928020477295, 2) + 0.000580306829843782*std::pow(-2.19231986999512*x_13 - 3.18535995483398, 2) + 2.06489763364642e-5*std::pow(-6.53927993774414*x_14 - 9.78439998626709, 2) - 0.000200803836075195*std::pow(-6.46400022506714*x_14 - 8.68704032897949, 2) - 0.000241115131400348*std::pow(-5.62559986114502*x_15 - 7.82880020141602, 2) + 0.000327813858103031*std::pow(-6.89976024627686*x_17 - 9.1307201385498, 2) + 1.62261332576489e-5*std::pow(-6.92984008789063*x_19 - 9.97432041168213, 2) + 2.89178513534823e-5*std::pow(-6.88104009628296*x_23 - 8.10231971740723, 2) - 0.000259705946744024*std::pow(-5.86168003082275*x_27 - 8.08047962188721, 2) + 2.49937517326516e-5*std::pow(-4.25631999969482*x_27 - 5.47039985656738, 2) - 3.64136549252105e-5*std::pow(-7.61320018768311*x_36 - 9.01000022888184, 2) - 1.53274697784401e-5*std::pow(-5.53175973892212*x_52 - 7.57728004455566, 2) - 9.22812314485509e-7*std::pow(-8.06855964660645*x_56 - 7.47832012176514, 2) - 9.30907305136439e-6*std::pow(-7.14911985397339*x_68 - 9.59352016448975, 2) + 0.000145185986229735*std::pow(-7.14143991470337*x_68 - 9.17271995544434, 2) - 0.000119838865970058*std::pow(-5.12191963195801*x_7 - 7.37095975875854, 2) + 7.96241767486424e-6*std::pow(-4.89592027664185*x_7 - 7.74936008453369, 2) - 3.38699467245471e-6*std::pow(-7.63944053649902*x_70 - 9.65192031860352, 2) + 2.28209248701006e-5*std::pow(-9.15408039093018*x_72 - 9.7540807723999, 2) + 0.000126665566621253*std::pow(-6.66584014892578*x_74 - 8.27351951599121, 2) - 2.50708988811306e-5*std::pow(-6.94191980361938*x_77 - 9.79944038391113, 2) - 1.67853996476024e-5*std::pow(-1.50623989105225*x_77 - 2.36735987663269, 2) - 1.97015162167454e-5*std::pow(-7.40000009536743*x_78 - 9.99612045288086, 2) - 1.19799880883077e-5*std::pow(-7.37215995788574*x_78 - 8.56719970703125, 2) + 4.06878501255552e-5*std::pow(-7.31472015380859*x_80 - 9.95207977294922, 2) - 6.77172802877877e-7*std::pow(-7.1406397819519*x_80 - 9.58688068389893, 2) + 3.90743142708135e-6*std::pow(-6.15687990188599*x_84 - 6.77792024612427, 2) + 6.67416394650487e-5*std::pow(-8.07520008087158*x_88 - 7.66735982894897, 2) - 1.28998668371344e-6*std::pow(-5.88727998733521*x_90 - 8.93711948394775, 2) + 5.12670653702039e-5*std::pow(-4.83951997756958*x_90 - 7.24056005477905, 2) - 0.0131974207295467*std::exp(0.460399866104126*x_1) + 0.000428148922217894*std::exp(1.18103992938995*x_1) - 1.31837320439672e-5*std::exp(1.18375980854034*x_1) - 0.0198909406021105*std::exp(0.595759809017181*x_100) - 7.69888827026765e-6*std::exp(1.62599992752075*x_100) + 0.00178985151951855*std::exp(1.66631984710693*x_100) + 0.0137806275338989*std::exp(0.609039843082428*x_104) + 0.00559556192712728*std::exp(0.729839861392975*x_104) - 5.61886317947647e-5*std::exp(0.828719913959503*x_104) + 0.000699735187433723*std::exp(0.893679857254028*x_104) + 0.00150591886504628*std::exp(0.863839864730835*x_106) + 0.00349572961013607*std::exp(0.912479817867279*x_106) - 0.00401704592767284*std::exp(1.19687986373901*x_106) + 0.000200694072215094*std::exp(0.576399862766266*x_110) - 0.00970710857868078*std::exp(0.783999860286713*x_110) - 0.0344574917424538*std::exp(0.562159836292267*x_112) + 0.000693453250282885*std::exp(1.24383985996246*x_26) - 9.14767640066935e-5*std::exp(0.575999855995178*x_31) - 9.38389721010024e-5*std::exp(0.60319983959198*x_31) + 0.0119872173190785*std::exp(0.629599869251251*x_31) - 0.00754786591079112*std::exp(0.646159827709198*x_31) - 0.00153071440443085*std::exp(1.33207988739014*x_50) + 0.00163244922089509*std::exp(0.898319840431213*x_6) - 0.000823864615870732*std::exp(1.28559982776642*x_60) + 0.000394554540799548*std::exp(1.3447197675705*x_60) - 0.000245997284282945*std::exp(1.45263981819153*x_60) - 0.00628050763630751*std::exp(0.721199870109558*x_70) + 0.001341988501794*std::exp(0.880959868431091*x_72) - 9.53233251643321e-5*std::exp(0.898639857769012*x_74) + 0.0253769319767465*std::exp(0.675999820232391*x_76) - 0.00317666452726892*std::exp(0.759759843349457*x_77) - 0.000551561214055533*std::exp(0.727279841899872*x_81) + 0.00014856287796946*std::exp(2.27735996246338*x_81) - 1.0462019466103e-6*std::exp(2.64103984832764*x_81) - 0.000537968935485785*std::exp(0.677599847316742*x_87) + 0.00304240567076705*std::sin(0.347919851541519*x_10 - 4.24720001220703) - 0.0616052031835198*std::sin(0.371759831905365*x_100 + 5.16815996170044) - 0.00157826947071994*std::sin(0.315839856863022*x_101 + 5.13479995727539) + 0.10917320658051*std::sin(0.362959831953049*x_102 - 7.41792011260986) + 0.0330152436965564*std::sin(0.364479839801788*x_102 - 7.41215991973877) - 0.0551368912625171*std::sin(0.372399836778641*x_102 - 7.42935991287231) + 0.0189723351724858*std::sin(0.353599846363068*x_103 - 4.24520015716553) + 0.0712701355696151*std::sin(0.331999838352203*x_105 + 5.13535976409912) - 0.0129117260239666*std::sin(0.368959844112396*x_105 - 7.41703987121582) + 0.00909885040956308*std::sin(0.512159824371338*x_107 + 5.27336025238037) - 0.424695402518859*std::sin(0.141760036349297*x_108 - 7.67880010604858) + 0.106923415981267*std::sin(0.290719926357269*x_108 - 7.48176002502441) + 0.0088810275157121*std::sin(0.500319838523865*x_108 + 5.28128004074097) + 0.0553574486809623*std::sin(0.532639861106873*x_108 + 2.15879988670349) + 0.0225553401788165*std::sin(0.234479993581772*x_110 - 7.55600023269653) - 0.0478765013038375*std::sin(0.350399851799011*x_111 + 5.14800024032593) + 0.0110964212641044*std::sin(0.36167985200882*x_111 - 7.41599988937378) + 0.0994887533603092*std::sin(0.364639848470688*x_111 - 7.42519998550415) + 0.0171310479026413*std::sin(0.411199867725372*x_111 + 8.19527912139893) + 0.0119972456409957*std::sin(0.238559976220131*x_112 - 7.55352020263672) - 0.0739341438877507*std::sin(0.42647984623909*x_112 + 5.22016000747681) - 0.0189437599729126*std::sin(0.483759850263596*x_112 - 7.34975957870483) + 0.000314034097266285*std::sin(0.561359822750092*x_112 + 2.18031978607178) + 0.0375916677708278*std::sin(0.352079838514328*x_113 + 5.14792013168335) + 0.0360560388685325*std::sin(0.23335999250412*x_114 - 7.55904006958008) - 0.179763741279937*std::sin(0.335279852151871*x_114 + 5.12943983078003) - 0.0791529222151283*std::sin(0.456959843635559*x_114 + 5.24592018127441) + 0.185832809055452*std::sin(0.163440018892288*x_115 - 7.64416027069092) - 0.000792183181044193*std::sin(0.368639826774597*x_115 - 7.41511964797974) + 0.0143239674731*std::sin(0.389999836683273*x_115 + 5.18383979797363) - 0.0253099601259241*std::sin(0.458079844713211*x_115 - 4.15824031829834) + 0.0405286436541571*std::sin(0.383359849452972*x_116 + 5.17575979232788) - 0.100950488456666*std::sin(0.291759938001633*x_117 + 5.08567953109741) + 0.00162506675447496*std::sin(0.370319843292236*x_117 + 5.17880010604858) + 0.0309745771597368*std::sin(0.399759858846664*x_117 + 5.18656015396118) + 0.0593557112008626*std::sin(0.28687995672226*x_118 + 1.89631986618042) - 0.118156801689189*std::sin(0.529999852180481*x_118 - 7.22975969314575) + 0.0368581007973005*std::sin(0.331279844045639*x_119 + 5.1526403427124) + 0.0208328834644546*std::sin(0.344959855079651*x_119 + 5.15152025222778) - 0.330712183604495*std::sin(0.345199823379517*x_119 + 5.15088033676147) + 0.0624575897063881*std::sin(0.411679863929749*x_119 + 2.01143980026245) - 0.0182270158469927*std::sin(0.413199841976166*x_120 + 5.21072006225586) - 0.00685149407161572*std::sin(0.438319861888885*x_120 - 4.1812801361084) - 2.84712201966474e-5*std::sin(0.783199846744537*x_120 - 4.01696014404297) - 0.299017726401352*std::sin(0.221440002322197*x_14 - 4.37151956558228) + 0.00988001589924179*std::sin(0.384319841861725*x_16 + 5.19271993637085) + 0.0668330732442673*std::sin(0.385279834270477*x_16 + 5.19063997268677) + 0.0178636062751325*std::sin(0.414559870958328*x_16 + 5.20528030395508) - 0.099325749715172*std::sin(0.417759865522385*x_2 - 4.17151975631714) - 0.114470417478642*std::sin(0.447039872407913*x_2 - 4.14039993286133) + 0.0130925511647508*std::sin(0.258479982614517*x_24 - 7.51384019851685) + 0.25444840081783*std::sin(0.270639955997467*x_24 - 7.49720001220703) + 0.00112141999751397*std::sin(0.297439932823181*x_28 + 5.12983989715576) - 0.113309314029781*std::sin(0.305759936571121*x_28 + 5.13399982452393) - 0.106616385186813*std::sin(0.316559851169586*x_28 - 4.28560018539429) - 0.019150396692718*std::sin(0.281359940767288*x_3 - 4.31383991241455) - 0.0248627658823927*std::sin(0.2882399559021*x_33 - 1.16303980350494) - 0.000790920056723968*std::sin(0.314479857683182*x_33 - 1.18263983726501) + 0.0305035503684447*std::sin(0.341279834508896*x_34 - 7.41287994384766) - 0.0162170837432935*std::sin(0.352959841489792*x_34 + 1.99951982498169) - 0.0380921116460305*std::sin(0.311919927597046*x_35 + 8.2792797088623) + 0.0155718434985116*std::sin(0.316639840602875*x_35 - 7.43399953842163) - 0.00168768321379014*std::sin(0.319359838962555*x_35 - 7.43088006973267) - 0.0990525947070945*std::sin(0.320079833269119*x_35 - 7.43167972564697) + 0.0664939239120801*std::sin(0.320479840040207*x_35 + 1.98279976844788) - 0.000826357596200354*std::sin(0.264559954404831*x_36 - 7.52311992645264) - 0.0374471883182835*std::sin(0.300559937953949*x_36 + 5.09175968170166) + 0.0116175503798166*std::sin(0.311679929494858*x_36 + 5.10960006713867) - 0.0983875643986635*std::sin(0.202240005135536*x_37 + 4.99927997589111) - 0.00936037752897103*std::sin(0.678639829158783*x_38 + 2.21391987800598) + 0.000515750490199038*std::sin(0.47343984246254*x_39 + 8.44896030426025) - 0.108787325755647*std::sin(0.342319846153259*x_4 + 8.3264799118042) + 0.212202360495181*std::sin(0.398239850997925*x_4 - 4.21464014053345) + 0.109932150580094*std::sin(0.243759974837303*x_40 + 1.85207998752594) - 0.0129600914601787*std::sin(0.337839841842651*x_41 - 4.25608015060425) + 0.0701686567498378*std::sin(0.198319986462593*x_42 - 7.60856008529663) + 0.0104453247893338*std::sin(0.370559841394424*x_43 - 7.410560131073) + 0.0385576584756685*std::sin(0.370959848165512*x_43 - 4.21415996551514) + 0.202871089531689*std::sin(0.37271985411644*x_43 - 7.42679977416992) + 0.168414289397074*std::sin(0.294719934463501*x_45 + 5.10903978347778) + 0.0253129861332203*std::sin(0.342879861593246*x_45 - 7.43375968933105) + 0.0442878312044304*std::sin(0.519439876079559*x_45 + 5.34327983856201) - 0.00794702494435187*std::sin(0.367279827594757*x_46 - 4.23912000656128) + 0.00026397600859641*std::sin(0.57127982378006*x_46 + 2.17831993103027) + 0.0124922356610028*std::sin(0.667999863624573*x_46 - 7.14032030105591) - 0.0351359325807144*std::sin(0.356239855289459*x_47 - 4.23776006698608) + 0.0511748095152806*std::sin(0.314479827880859*x_48 - 1.26639986038208) + 0.00984335794684678*std::sin(0.370799839496613*x_48 - 7.42199993133545) - 0.0502361303025739*std::sin(0.499119848012924*x_49 + 8.48079967498779) + 0.00698570467379185*std::sin(0.324479848146439*x_51 - 7.46815967559814) + 0.0681774349714581*std::sin(0.344719856977463*x_51 - 4.25576019287109) - 0.0769779381157556*std::sin(0.392559856176376*x_51 + 2.00583982467651) + 0.0985506499279361*std::sin(0.256319969892502*x_53 + 5.06504011154175) + 0.11452980128322*std::sin(0.331999838352203*x_53 - 4.27663993835449) - 0.00448219727688198*std::sin(0.430319845676422*x_53 + 8.42768001556396) - 1.59662629115134*std::sin(0.0974400714039803*x_54 + 4.85640001296997) - 0.00614931233349814*std::sin(0.376319825649261*x_55 - 7.40751981735229) - 0.0590729747261619*std::sin(0.419439852237701*x_55 + 8.40575981140137) + 1.29092752765635*std::sin(0.096000075340271*x_56 - 1.48439979553223) + 0.386227453097055*std::sin(0.198959991335869*x_56 + 1.79975986480713) + 0.083352154349236*std::sin(0.32151985168457*x_57 - 4.28575992584229) - 0.000306538174371495*std::sin(0.677679836750031*x_57 - 3.95703983306885) + 0.00683304886652732*std::sin(0.270799964666367*x_58 - 7.50408029556274) + 0.148702537862055*std::sin(0.356159836053848*x_58 + 5.15912008285522) + 0.000645623029158125*std::sin(0.425279855728149*x_58 + 5.21239995956421) - 0.307762259090924*std::sin(0.272079944610596*x_59 - 7.50024032592773) + 0.0591844735677506*std::sin(0.396159827709198*x_59 - 4.19447994232178) - 0.00851990328539314*std::sin(0.403359860181808*x_59 - 4.1878399848938) + 0.973097380232833*std::sin(0.133280038833618*x_63 - 7.67183971405029) - 0.00501155873920553*std::sin(0.405439853668213*x_63 + 5.19360017776489) + 0.13305618136411*std::sin(0.202399998903275*x_64 - 4.39472007751465) - 0.029202273535104*std::sin(0.229839980602264*x_64 - 4.35567998886108) + 0.287798714404972*std::sin(0.294319927692413*x_64 - 4.28071975708008) - 0.200091156156999*std::sin(0.199039995670319*x_66 + 4.99455976486206) - 0.248785789806284*std::sin(0.165360018610954*x_67 - 4.45287990570068) + 0.0347952731657531*std::sin(0.220559984445572*x_67 - 7.56264019012451) - 0.000485690346595363*std::sin(0.289759933948517*x_67 - 7.48559999465942) + 0.196226862534346*std::sin(0.246639966964722*x_70 + 5.05167961120605) + 0.00606564561519604*std::sin(0.760799884796143*x_70 + 2.37687993049622) + 0.187243159384884*std::sin(0.101840071380138*x_71 - 7.71872043609619) + 0.306778277801417*std::sin(0.218639999628067*x_71 + 5.03167963027954) - 0.0449890971180801*std::sin(0.172000005841255*x_72 - 7.62408018112183) - 0.000222893288550137*std::sin(0.417839854955673*x_72 - 0.988559782505035) - 0.0558621044166097*std::sin(0.186880007386208*x_73 + 4.96799993515015) - 0.0795665614937512*std::sin(0.214399993419647*x_73 + 8.20792007446289) + 0.129386869084434*std::sin(0.252239972352982*x_73 + 5.07247972488403) - 0.0221586272034703*std::sin(0.510879814624786*x_73 + 2.10727977752686) - 0.0801292523263903*std::sin(0.12896004319191*x_74 - 7.67944049835205) - 0.232756761583278*std::sin(0.321839839220047*x_75 + 5.12048006057739) - 0.0188977675784932*std::sin(0.450239837169647*x_75 - 7.35103988647461) - 0.0635851524118587*std::sin(0.280479967594147*x_76 + 5.09592008590698) + 0.125092408549213*std::sin(0.379359841346741*x_76 - 4.20864009857178) - 0.000376010732379839*std::sin(0.612719833850861*x_76 - 3.99183988571167) + 0.00983549063714958*std::sin(0.14144004881382*x_79 - 4.48799991607666) + 0.00127980463914217*std::sin(0.324319839477539*x_79 - 4.27648019790649) - 0.127465617531504*std::sin(0.344319850206375*x_79 + 5.13976001739502) - 0.0424054411131411*std::sin(0.428879857063293*x_79 - 1.18207991123199) - 0.0996590239523634*std::sin(0.297279924154282*x_81 - 7.47096014022827) + 0.0566954264658957*std::sin(0.23463998734951*x_82 + 5.0479998588562) + 0.194729507799524*std::sin(0.296399921178818*x_83 - 7.48288011550903) + 0.0929973821559893*std::sin(0.281279951334*x_84 - 7.50392007827759) + 0.114385043546512*std::sin(0.285679936408997*x_84 + 5.08895969390869) - 0.0682275433559587*std::sin(0.324639827013016*x_84 - 1.08567988872528) + 0.0206922770743192*std::sin(0.184720009565353*x_85 + 1.77711987495422) + 0.00297695556719083*std::sin(0.202799841761589*x_85 - 1.36799991130829) + 0.0986168330180805*std::sin(0.213839992880821*x_85 + 5.00920009613037) + 0.00208736881488518*std::sin(0.271919965744019*x_86 + 5.07535982131958) - 0.0368607845742943*std::sin(0.294719934463501*x_86 - 7.4986400604248) - 0.224154002109782*std::sin(0.310959845781326*x_86 - 4.30808019638062) - 0.0931804882768919*std::sin(0.434079855680466*x_86 + 5.24151992797852) - 0.16721501096021*std::sin(0.150880038738251*x_87 + 4.91951942443848) + 0.0698183212222797*std::sin(0.306479841470718*x_87 - 4.31288003921509) - 2.12124567272862e-5*std::sin(0.950239837169647*x_87 - 3.83208012580872) + 0.0651171657446504*std::sin(0.191359996795654*x_88 - 7.60824012756348) - 0.000591567080425388*std::sin(0.212960004806519*x_88 - 7.57991981506348) - 0.0527427228750296*std::sin(0.204080000519753*x_89 - 4.40327978134155) - 0.0456541173012043*std::sin(0.285919934511185*x_89 - 7.49544048309326) - 0.208998825369766*std::sin(0.274079948663712*x_90 - 7.50888013839722) + 0.0507919864558627*std::sin(0.361039847135544*x_92 + 1.97879981994629) - 0.00126775970822687*std::sin(0.362799853086472*x_92 + 1.98575985431671) + 0.0243151124096351*std::sin(0.363679856061935*x_92 + 2.00567984580994) + 0.101005289974019*std::sin(0.369039833545685*x_92 + 2.00383973121643) + 0.183900733146407*std::sin(0.270719945430756*x_93 - 1.36999988555908) + 0.040209367031798*std::sin(0.343679845333099*x_93 + 1.97367978096008) - 0.000947093082660674*std::sin(0.365119844675064*x_95 + 5.18239974975586) - 0.079034445466691*std::sin(0.376399844884872*x_95 + 1.9883998632431) - 0.108997877307233*std::sin(0.381439834833145*x_95 - 7.42175960540771) - 0.00608995574849675*std::sin(0.43615984916687*x_95 + 5.22552013397217) - 0.00536300611461772*std::sin(0.403999865055084*x_96 - 7.39807987213135) - 0.000338396358830877*std::sin(0.421199858188629*x_96 + 5.20864009857178) + 0.958524481347141*std::sin(0.114480063319206*x_97 + 1.71391987800598) - 0.00774486133397866*std::sin(0.437599837779999*x_97 + 5.21184015274048) - 0.0463861553684205*std::sin(0.363839834928513*x_98 + 5.17519998550415) - 0.000905528665332733*std::sin(0.42375984787941*x_98 + 2.02567982673645) + 0.230218726430619*std::sin(0.366159856319427*x_99 - 7.4347996711731) - 0.0952194871155422*std::sin(0.376159846782684*x_99 + 1.98311984539032) + 0.0115368960600989*std::sin(0.406079858541489*x_99 + 5.20360040664673) + 0.0549574094612559*std::sin(0.441999852657318*x_99 - 4.16584014892578) - 0.688098708653238 + 1.36963873086101e-5*std::exp(-1.2125598192215*x_9));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0578623114434284*x_1 + 0.0535358397101754*x_10 - 0.00259109777248656*x_100 - 0.0254769076070766*x_101 + 0.000193520619391905*x_102 + 0.0255255300880974*x_103 + 0.000945616934608846*x_104 + 0.000839298780917351*x_105 + 0.00304006716501394*x_106 + 0.00108553952300023*x_107 - 0.000306526746470804*x_108 + 0.0133228122498809*x_109 + 0.00140069022295222*x_11 + 0.000756806436780354*x_110 + 0.000155338908245053*x_111 + 0.0107231419936158*x_113 - 0.00133229693445059*x_114 - 0.00156317268686297*x_115 + 0.00614027334603971*x_116 - 0.0158489545329005*x_117 + 0.00296620613115507*x_118 + 0.000378812768593832*x_119 + 0.020749637146045*x_12 + 0.000687542186103066*x_120 - 0.0141399660757745*x_13 + 0.00110178866664798*x_14 - 0.00416147612098305*x_15 + 4.88288712667771e-5*x_16 - 0.000965617375578217*x_17 + 0.00718453386563186*x_18 + 0.019131780614031*x_19 + 0.00847609317675255*x_2 + 0.00250908442156577*x_20 + 0.0119724847208822*x_21 + 0.0120548313950906*x_22 + 0.0044278515986015*x_23 + 0.00251093688461679*x_24 - 0.00537625308103261*x_25 + 0.00859521092196671*x_26 + 0.00384954992237834*x_27 + 0.00120801073103104*x_28 + 0.0154022687133954*x_29 - 0.00651417858623469*x_3 - 0.00130106395257809*x_30 - 0.0105395124400569*x_31 - 0.0289124490226461*x_32 - 0.0109655875634759*x_33 - 0.0135286162103581*x_34 + 0.00422349189563859*x_36 - 0.00457148190954744*x_37 - 0.00969603623673717*x_38 + 0.0162038857596281*x_39 + 0.0083494128930208*x_4 - 0.00154395753936122*x_40 + 0.0126608105888205*x_41 + 0.0185448152608313*x_42 - 0.000192444397759052*x_43 + 0.00227524051715703*x_44 - 0.000194587160027023*x_45 - 0.00127928168949753*x_46 + 0.0205044476033701*x_47 + 0.00793368188629526*x_48 - 0.000924689748023923*x_49 + 0.0226103818903926*x_5 - 0.00169828986734271*x_50 + 0.00287814646605619*x_51 + 0.00796133516505944*x_52 - 0.000969618102629614*x_53 + 0.00287498570935202*x_54 - 0.00134883826845501*x_55 + 0.0054424910694087*x_56 + 0.0143844154292768*x_57 - 0.0129274159670177*x_58 + 0.00149740200157761*x_59 + 0.00480102873413853*x_6 - 0.00896395902141451*x_60 + 0.0198814602808518*x_61 - 0.0282735009337856*x_62 - 0.0030423087437286*x_63 + 0.00617319125928148*x_64 - 0.00288356514571552*x_65 - 0.0019665698409842*x_66 - 0.00490832447690786*x_67 - 0.00147167721525076*x_68 + 0.0235599827760704*x_69 + 0.0106996557119532*x_7 + 0.000117587623458161*x_70 + 0.0023822533464645*x_71 + 0.00174171677121158*x_72 + 0.000106715856528015*x_73 - 0.00227130257123131*x_74 - 0.00102752238558*x_75 + 0.0267813912417009*x_76 + 0.000380360949193881*x_77 - 0.000594835356989371*x_78 + 0.00984600518699375*x_79 - 0.0628022515809408*x_8 - 0.00255027744985887*x_80 - 0.0120384555106958*x_81 - 0.00801236542362191*x_82 - 0.000921848563073263*x_83 - 0.000905499010672553*x_84 + 0.00141915079477295*x_85 - 0.00142351995332577*x_86 - 0.00210026536153386*x_87 + 0.00258841880771896*x_88 - 0.00959576546307895*x_89 + 0.00665522155277126*x_9 + 0.00492331540784633*x_90 + 0.0129171021945505*x_91 + 0.00110213160202444*x_92 - 0.0169176313757582*x_93 + 0.0128554616686072*x_94 + 0.000187297789398834*x_95 - 0.00570738532277001*x_96 - 0.000188221492661739*x_97 - 0.00469145719976732*x_98 + 0.000434059503811781*x_99 + 4.79014144677545e-6*std::pow(-7.87296009063721*x_106 - 9.04559993743896, 2) + 4.44619111662926e-5*std::pow(-7.23343992233276*x_107 - 9.84928035736084, 2) + 0.000181231980549554*std::pow(-3.99151992797852*x_110 - 5.38871955871582, 2) + 3.24347145278613e-5*std::pow(-8.07431983947754*x_116 - 9.47160053253174, 2) - 5.64970183860803e-5*std::pow(-8.54367923736572*x_120 - 9.14231967926025, 2) - 5.68135376099995e-5*std::pow(-7.97567987442017*x_13 - 9.75928020477295, 2) + 0.000255809955021792*std::pow(-2.19231986999512*x_13 - 3.18535995483398, 2) + 7.58764846642056e-5*std::pow(-6.53927993774414*x_14 - 9.78439998626709, 2) + 5.84786777641423e-5*std::pow(-6.46400022506714*x_14 - 8.68704032897949, 2) + 7.02182505514474e-5*std::pow(-5.62559986114502*x_15 - 7.82880020141602, 2) + 0.00029098911503434*std::pow(-6.89976024627686*x_17 - 9.1307201385498, 2) + 5.96243577028661e-5*std::pow(-6.92984008789063*x_19 - 9.97432041168213, 2) + 0.000106261195179422*std::pow(-6.88104009628296*x_23 - 8.10231971740723, 2) - 0.000230532058801636*std::pow(-5.86168003082275*x_27 - 8.08047962188721, 2) + 9.18417450406279e-5*std::pow(-4.25631999969482*x_27 - 5.47039985656738, 2) + 1.06044906024039e-5*std::pow(-7.61320018768311*x_36 - 9.01000022888184, 2) - 5.63221394917843e-5*std::pow(-5.53175973892212*x_52 - 7.57728004455566, 2) + 4.60124320367016e-6*std::pow(-8.06855964660645*x_56 - 7.47832012176514, 2) - 3.42070099316492e-5*std::pow(-7.14911985397339*x_68 - 9.59352016448975, 2) + 6.4000660852503e-5*std::pow(-7.14143991470337*x_68 - 9.17271995544434, 2) + 3.48998234478895e-5*std::pow(-5.12191963195801*x_7 - 7.37095975875854, 2) + 2.9258605983772e-5*std::pow(-4.89592027664185*x_7 - 7.74936008453369, 2) - 1.2445810636551e-5*std::pow(-7.63944053649902*x_70 - 9.65192031860352, 2) - 6.64597618174273e-6*std::pow(-9.15408039093018*x_72 - 9.7540807723999, 2) + 5.58365182586517e-5*std::pow(-6.66584014892578*x_74 - 8.27351951599121, 2) - 9.21252290416299e-5*std::pow(-6.94191980361938*x_77 - 9.79944038391113, 2) + 8.36938398383616e-5*std::pow(-1.50623989105225*x_77 - 2.36735987663269, 2) - 7.2394958893999e-5*std::pow(-7.40000009536743*x_78 - 9.99612045288086, 2) - 1.06342244104974e-5*std::pow(-7.37215995788574*x_78 - 8.56719970703125, 2) + 1.7935954869519e-5*std::pow(-7.31472015380859*x_80 - 9.95207977294922, 2) + 3.37645771306082e-6*std::pow(-7.1406397819519*x_80 - 9.58688068389893, 2) + 1.4358201390827e-5*std::pow(-6.15687990188599*x_84 - 6.77792024612427, 2) + 5.9244263547185e-5*std::pow(-8.07520008087158*x_88 - 7.66735982894897, 2) + 6.43201479660649e-6*std::pow(-5.88727998733521*x_90 - 8.93711948394775, 2) + 0.000188385353150499*std::pow(-4.83951997756958*x_90 - 7.24056005477905, 2) + 0.0038433912879631*std::exp(0.460399866104126*x_1) + 0.000188735942612759*std::exp(1.18103992938995*x_1) + 6.57355309569456e-5*std::exp(1.18375980854034*x_1) + 0.00579269763283275*std::exp(0.595759809017181*x_100) + 3.83874995742065e-5*std::exp(1.62599992752075*x_100) + 0.00158878978674501*std::exp(1.66631984710693*x_100) + 0.00607475481646106*std::exp(0.609039843082428*x_104) - 0.00162955583539373*std::exp(0.729839861392975*x_104) + 0.000280162668086335*std::exp(0.828719913959503*x_104) + 0.00257123865867199*std::exp(0.893679857254028*x_104) - 0.000438558076226228*std::exp(0.863839864730835*x_106) + 0.00310303924165745*std::exp(0.912479817867279*x_106) - 0.00177078794394871*std::exp(1.19687986373901*x_106) - 0.0010006826104303*std::exp(0.576399862766266*x_110) - 0.00427907252026045*std::exp(0.783999860286713*x_110) - 0.0305867332347137*std::exp(0.562159836292267*x_112) + 0.000615554658931113*std::exp(1.24383985996246*x_26) + 0.000456113157651352*std::exp(0.575999855995178*x_31) - 0.000344819579019661*std::exp(0.60319983959198*x_31) + 0.0106406415506286*std::exp(0.629599869251251*x_31) + 0.00219811148547393*std::exp(0.646159827709198*x_31) + 0.000445779105395788*std::exp(1.33207988739014*x_50) + 0.00599857863440946*std::exp(0.898319840431213*x_6) + 0.00023992825204167*std::exp(1.28559982776642*x_60) + 0.00144982545751205*std::exp(1.3447197675705*x_60) - 0.000108440140614653*std::exp(1.45263981819153*x_60) + 0.00182902771897908*std::exp(0.721199870109558*x_70) + 0.000591573286111589*std::exp(0.880959868431091*x_72) + 0.000475292532597116*std::exp(0.898639857769012*x_74) + 0.0225262318711346*std::exp(0.675999820232391*x_76) + 0.000925117492204565*std::exp(0.759759843349457*x_77) - 0.00202676032543808*std::exp(0.727279841899872*x_81) - 4.32649138497352e-5*std::exp(2.27735996246338*x_81) + 5.21647741468533e-6*std::exp(2.64103984832764*x_81) - 0.00197681429907609*std::exp(0.677599847316742*x_87) + 0.0111795879591665*std::sin(0.347919851541519*x_10 - 4.24720001220703) - 0.0271567099420956*std::sin(0.371759831905365*x_100 + 5.16815996170044) + 0.00786942432574602*std::sin(0.315839856863022*x_101 + 5.13479995727539) + 0.0969093099119049*std::sin(0.362959831953049*x_102 - 7.41792011260986) + 0.121317424709477*std::sin(0.364479839801788*x_102 - 7.41215991973877) + 0.0160571259995744*std::sin(0.372399836778641*x_102 - 7.42935991287231) - 0.00552517868518029*std::sin(0.353599846363068*x_103 - 4.24520015716553) + 0.0632640541732728*std::sin(0.331999838352203*x_105 + 5.13535976409912) - 0.047445276011861*std::sin(0.368959844112396*x_105 - 7.41703987121582) + 0.0334345282939742*std::sin(0.512159824371338*x_107 + 5.27336025238037) + 0.123681031584043*std::sin(0.141760036349297*x_108 - 7.67880010604858) + 0.0949122479839109*std::sin(0.290719926357269*x_108 - 7.48176002502441) + 0.0326341188598459*std::sin(0.500319838523865*x_108 + 5.28128004074097) + 0.0244025845103534*std::sin(0.532639861106873*x_108 + 2.15879988670349) + 0.0828815867327865*std::sin(0.234479993581772*x_110 - 7.55600023269653) - 0.0211048449118416*std::sin(0.350399851799011*x_111 + 5.14800024032593) + 0.040774778572755*std::sin(0.36167985200882*x_111 - 7.41599988937378) + 0.0883127530474539*std::sin(0.364639848470688*x_111 - 7.42519998550415) - 0.00498895364571374*std::sin(0.411199867725372*x_111 + 8.19527912139893) + 0.0440849371929493*std::sin(0.238559976220131*x_112 - 7.55352020263672) - 0.0325915344260064*std::sin(0.42647984623909*x_112 + 5.22016000747681) + 0.00551685693236644*std::sin(0.483759850263596*x_112 - 7.34975957870483) - 0.00156580838062698*std::sin(0.561359822750092*x_112 + 2.18031978607178) + 0.138133898583543*std::sin(0.352079838514328*x_113 + 5.14792013168335) + 0.1324910947488*std::sin(0.23335999250412*x_114 - 7.55904006958008) + 0.0523513201015222*std::sin(0.335279852151871*x_114 + 5.12943983078003) - 0.0348920681790807*std::sin(0.456959843635559*x_114 + 5.24592018127441) + 0.0819185301314577*std::sin(0.163440018892288*x_115 - 7.64416027069092) + 0.00394991204671298*std::sin(0.368639826774597*x_115 - 7.41511964797974) + 0.0526346817679272*std::sin(0.389999836683273*x_115 + 5.18383979797363) - 0.0224667832568637*std::sin(0.458079844713211*x_115 - 4.15824031829834) - 0.0118028696004677*std::sin(0.383359849452972*x_116 + 5.17575979232788) + 0.0293990951566258*std::sin(0.291759938001633*x_117 + 5.08567953109741) - 0.00810276070460442*std::sin(0.370319843292236*x_117 + 5.17880010604858) + 0.113818815545384*std::sin(0.399759858846664*x_117 + 5.18656015396118) - 0.0172857430247346*std::sin(0.28687995672226*x_118 + 1.89631986618042) - 0.104883739076152*std::sin(0.529999852180481*x_118 - 7.22975969314575) + 0.0162477307214949*std::sin(0.331279844045639*x_119 + 5.1526403427124) + 0.0765522676255121*std::sin(0.344959855079651*x_119 + 5.15152025222778) - 0.293561859144772*std::sin(0.345199823379517*x_119 + 5.15088033676147) - 0.0181890811139542*std::sin(0.411679863929749*x_119 + 2.01143980026245) - 0.00803480480361722*std::sin(0.413199841976166*x_120 + 5.21072006225586) - 0.0251764192268364*std::sin(0.438319861888885*x_120 - 4.1812801361084) + 0.000141960620132229*std::sin(0.783199846744537*x_120 - 4.01696014404297) - 0.265427776875017*std::sin(0.221440002322197*x_14 - 4.37151956558228) + 0.0363049897799096*std::sin(0.384319841861725*x_16 + 5.19271993637085) + 0.059325426176041*std::sin(0.385279834270477*x_16 + 5.19063997268677) + 0.00787460716083389*std::sin(0.414559870958328*x_16 + 5.20528030395508) - 0.0881680603040772*std::sin(0.417759865522385*x_2 - 4.17151975631714) - 0.0504606715630422*std::sin(0.447039872407913*x_2 - 4.14039993286133) + 0.0481097339393651*std::sin(0.258479982614517*x_24 - 7.51384019851685) + 0.112165548673791*std::sin(0.270639955997467*x_24 - 7.49720001220703) - 0.00559152284925644*std::sin(0.297439932823181*x_28 + 5.12983989715576) - 0.100580790590955*std::sin(0.305759936571121*x_28 + 5.13399982452393) - 0.0469984692521486*std::sin(0.316559851169586*x_28 - 4.28560018539429) - 0.0703698215975238*std::sin(0.281359940767288*x_3 - 4.31383991241455) - 0.091360425981685*std::sin(0.2882399559021*x_33 - 1.16303980350494) + 0.00394361397060087*std::sin(0.314479857683182*x_33 - 1.18263983726501) + 0.0134465276754668*std::sin(0.341279834508896*x_34 - 7.41287994384766) - 0.059591104464254*std::sin(0.352959841489792*x_34 + 1.99951982498169) + 0.011093295655317*std::sin(0.311919927597046*x_35 + 8.2792797088623) + 0.0572201122784832*std::sin(0.316639840602875*x_35 - 7.43399953842163) + 0.00841497322424609*std::sin(0.319359838962555*x_35 - 7.43088006973267) - 0.0436642108858771*std::sin(0.320079833269119*x_35 - 7.43167972564697) + 0.0590243749495654*std::sin(0.320479840040207*x_35 + 1.98279976844788) + 0.0041203094211394*std::sin(0.264559954404831*x_36 - 7.52311992645264) - 0.0165074113671408*std::sin(0.300559937953949*x_36 + 5.09175968170166) + 0.0426897134689017*std::sin(0.311679929494858*x_36 + 5.10960006713867) + 0.0286527129507313*std::sin(0.202240005135536*x_37 + 4.99927997589111) - 0.00412622707769555*std::sin(0.678639829158783*x_38 + 2.21391987800598) - 0.00257158839405057*std::sin(0.47343984246254*x_39 + 8.44896030426025) - 0.0965667767426679*std::sin(0.342319846153259*x_4 + 8.3264799118042) - 0.0617981892315103*std::sin(0.398239850997925*x_4 - 4.21464014053345) + 0.0484601198006117*std::sin(0.243759974837303*x_40 + 1.85207998752594) - 0.0476229990727636*std::sin(0.337839841842651*x_41 - 4.25608015060425) + 0.257840917681959*std::sin(0.198319986462593*x_42 - 7.60856008529663) + 0.0383822671534062*std::sin(0.370559841394424*x_43 - 7.410560131073) - 0.011228873558442*std::sin(0.370959848165512*x_43 - 4.21415996551514) + 0.180081705973286*std::sin(0.37271985411644*x_43 - 7.42679977416992) + 0.149495586655123*std::sin(0.294719934463501*x_45 + 5.10903978347778) + 0.0930148000000771*std::sin(0.342879861593246*x_45 - 7.43375968933105) + 0.0195228929348771*std::sin(0.519439876079559*x_45 + 5.34327983856201) - 0.0292020440379577*std::sin(0.367279827594757*x_46 - 4.23912000656128) - 0.0013162132715615*std::sin(0.57127982378006*x_46 + 2.17831993103027) + 0.0110889290063299*std::sin(0.667999863624573*x_46 - 7.14032030105591) - 0.129110083046357*std::sin(0.356239855289459*x_47 - 4.23776006698608) + 0.0225588000125327*std::sin(0.314479827880859*x_48 - 1.26639986038208) + 0.0361702869008226*std::sin(0.370799839496613*x_48 - 7.42199993133545) - 0.0445928893430164*std::sin(0.499119848012924*x_49 + 8.48079967498779) + 0.0256695879211027*std::sin(0.324479848146439*x_51 - 7.46815967559814) + 0.0300538709465902*std::sin(0.344719856977463*x_51 - 4.25576019287109) - 0.0683306746673037*std::sin(0.392559856176376*x_51 + 2.00583982467651) + 0.0434429443682755*std::sin(0.256319969892502*x_53 + 5.06504011154175) + 0.101664175252739*std::sin(0.331999838352203*x_53 - 4.27663993835449) - 0.0164702291968201*std::sin(0.430319845676422*x_53 + 8.42768001556396) + 0.464974156943064*std::sin(0.0974400714039803*x_54 + 4.85640001296997) - 0.0225961905019054*std::sin(0.376319825649261*x_55 - 7.40751981735229) - 0.0524370529589055*std::sin(0.419439852237701*x_55 + 8.40575981140137) - 0.375947673023574*std::sin(0.096000075340271*x_56 - 1.48439979553223) + 0.34284085922736*std::sin(0.198959991335869*x_56 + 1.79975986480713) + 0.0739888477279284*std::sin(0.32151985168457*x_57 - 4.28575992584229) + 0.00152843288862987*std::sin(0.677679836750031*x_57 - 3.95703983306885) + 0.0251086406939826*std::sin(0.270799964666367*x_58 - 7.50408029556274) + 0.0655508216788676*std::sin(0.356159836053848*x_58 + 5.15912008285522) - 0.00321914708810858*std::sin(0.425279855728149*x_58 + 5.21239995956421) - 0.273189998531698*std::sin(0.272079944610596*x_59 - 7.50024032592773) - 0.0172358747026767*std::sin(0.396159827709198*x_59 - 4.19447994232178) - 0.0313071360265477*std::sin(0.403359860181808*x_59 - 4.1878399848938) + 0.428959275106578*std::sin(0.133280038833618*x_63 - 7.67183971405029) - 0.018415414576634*std::sin(0.405439853668213*x_63 + 5.19360017776489) - 0.0387490085179715*std::sin(0.202399998903275*x_64 - 4.39472007751465) - 0.107306329570121*std::sin(0.229839980602264*x_64 - 4.35567998886108) + 0.255469044833371*std::sin(0.294319927692413*x_64 - 4.28071975708008) - 0.177614054491935*std::sin(0.199039995670319*x_66 + 4.99455976486206) - 0.109669365286531*std::sin(0.165360018610954*x_67 - 4.45287990570068) + 0.127858299981964*std::sin(0.220559984445572*x_67 - 7.56264019012451) + 0.00242170522790007*std::sin(0.289759933948517*x_67 - 7.48559999465942) + 0.174183853621246*std::sin(0.246639966964722*x_70 + 5.05167961120605) + 0.00267384847498544*std::sin(0.760799884796143*x_70 + 2.37687993049622) + 0.688041502883398*std::sin(0.101840071380138*x_71 - 7.71872043609619) + 0.272316552099931*std::sin(0.218639999628067*x_71 + 5.03167963027954) - 0.165316405128923*std::sin(0.172000005841255*x_72 - 7.62408018112183) + 0.00111137033282526*std::sin(0.417839854955673*x_72 - 0.988559782505035) - 0.205270229381402*std::sin(0.186880007386208*x_73 + 4.96799993515015) + 0.023171605689104*std::sin(0.214399993419647*x_73 + 8.20792007446289) + 0.114852284616076*std::sin(0.252239972352982*x_73 + 5.07247972488403) - 0.00976793161264417*std::sin(0.510879814624786*x_73 + 2.10727977752686) - 0.294442004592791*std::sin(0.12896004319191*x_74 - 7.67944049835205) - 0.206610191720722*std::sin(0.321839839220047*x_75 + 5.12048006057739) + 0.00550346289336092*std::sin(0.450239837169647*x_75 - 7.35103988647461) - 0.0280295080843872*std::sin(0.280479967594147*x_76 + 5.09592008590698) - 0.0364297754130083*std::sin(0.379359841346741*x_76 - 4.20864009857178) + 0.00187483066676929*std::sin(0.612719833850861*x_76 - 3.99183988571167) + 0.0361413777774907*std::sin(0.14144004881382*x_79 - 4.48799991607666) - 0.0063812460079291*std::sin(0.324319839477539*x_79 - 4.27648019790649) - 0.0561891954577491*std::sin(0.344319850206375*x_79 + 5.13976001739502) + 0.0123494360206001*std::sin(0.428879857063293*x_79 - 1.18207991123199) - 0.0439315360834762*std::sin(0.297279924154282*x_81 - 7.47096014022827) + 0.20833234474551*std::sin(0.23463998734951*x_82 + 5.0479998588562) + 0.172854703195149*std::sin(0.296399921178818*x_83 - 7.48288011550903) - 0.0270829683849885*std::sin(0.281279951334*x_84 - 7.50392007827759) + 0.0504230371589388*std::sin(0.285679936408997*x_84 + 5.08895969390869) - 0.0605632494520032*std::sin(0.324639827013016*x_84 - 1.08567988872528) + 0.0760355970443191*std::sin(0.184720009565353*x_85 + 1.77711987495422) - 0.0148434262917283*std::sin(0.202799841761589*x_85 - 1.36799991130829) - 0.0287194812255729*std::sin(0.213839992880821*x_85 + 5.00920009613037) - 0.0104078493776909*std::sin(0.271919965744019*x_86 + 5.07535982131958) + 0.0107347050005879*std::sin(0.294719934463501*x_86 - 7.4986400604248) - 0.198973817283925*std::sin(0.310959845781326*x_86 - 4.30808019638062) - 0.0410756780536895*std::sin(0.434079855680466*x_86 + 5.24151992797852) - 0.0737114613043841*std::sin(0.150880038738251*x_87 + 4.91951942443848) - 0.0203326947761205*std::sin(0.306479841470718*x_87 - 4.31288003921509) + 0.000105767630987878*std::sin(0.950239837169647*x_87 - 3.83208012580872) + 0.239278768472188*std::sin(0.191359996795654*x_88 - 7.60824012756348) + 0.00294961821119592*std::sin(0.212960004806519*x_88 - 7.57991981506348) - 0.193807786796123*std::sin(0.204080000519753*x_89 - 4.40327978134155) + 0.0132955249583167*std::sin(0.285919934511185*x_89 - 7.49544048309326) + 0.0608652464054823*std::sin(0.274079948663712*x_90 - 7.50888013839722) - 0.0147917901719806*std::sin(0.361039847135544*x_92 + 1.97879981994629) + 0.00632118866404374*std::sin(0.362799853086472*x_92 + 1.98575985431671) + 0.0893480249962856*std::sin(0.363679856061935*x_92 + 2.00567984580994) + 0.089658930569339*std::sin(0.369039833545685*x_92 + 2.00383973121643) + 0.0810668354313892*std::sin(0.270719945430756*x_93 - 1.36999988555908) + 0.147752865383353*std::sin(0.343679845333099*x_93 + 1.97367978096008) + 0.00472230977136996*std::sin(0.365119844675064*x_95 + 5.18239974975586) - 0.0701561656870343*std::sin(0.376399844884872*x_95 + 1.9883998632431) - 0.0480482749081898*std::sin(0.381439834833145*x_95 - 7.42175960540771) + 0.00177353464343613*std::sin(0.43615984916687*x_95 + 5.22552013397217) - 0.0197068389531368*std::sin(0.403999865055084*x_96 - 7.39807987213135) + 0.00168728128328607*std::sin(0.421199858188629*x_96 + 5.20864009857178) + 0.850849296548928*std::sin(0.114480063319206*x_97 + 1.71391987800598) + 0.00225548106614907*std::sin(0.437599837779999*x_97 + 5.21184015274048) - 0.0411753986808566*std::sin(0.363839834928513*x_98 + 5.17519998550415) + 0.0045150650372646*std::sin(0.42375984787941*x_98 + 2.02567982673645) + 0.204357264991902*std::sin(0.366159856319427*x_99 - 7.4347996711731) - 0.0419745063534444*std::sin(0.376159846782684*x_99 + 1.98311984539032) + 0.0423933420578719*std::sin(0.406079858541489*x_99 + 5.20360040664673) - 0.016004856786866*std::sin(0.441999852657318*x_99 - 4.16584014892578) + 2.52405712132992 - 6.82916862175945e-5*std::exp(-1.2125598192215*x_9));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
