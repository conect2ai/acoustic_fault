
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (96.2064912559334*x_1 + 0.00375471370928671*x_10 - 136.46180914816*x_100 + 96.7509364191769*x_101 - 45.1938582785969*x_102 - 77.1476490590459*x_103 - 21.6718194000541*x_104 + 31.7442207225459*x_105 - 9.26626553973849*x_106 - 24.0248045990537*x_107 - 39.3369913547682*x_108 - 140.500322015204*x_109 - 37.5936665209372*x_11 - 83.4445293738309*x_110 + 32.3095216335005*x_111 - 24.2486408725667*x_112 + 289.666238754522*x_113 - 73.4957800521284*x_114 + 12.6806881289838*x_115 + 419.913660209898*x_116 - 21.6141065450094*x_117 - 30.1536847755303*x_118 - 15.1007710236562*x_119 + 642.037353328511*x_12 - 98.9965617841116*x_120 - 71.5268151050596*x_13 - 7.37349166184279*x_14 - 15.9156554615881*x_15 - 36.7985230276285*x_16 - 44.2053595704902*x_17 - 123.880880735161*x_18 + 9.39305193578001*x_19 - 86.4761203090787*x_2 + 57.1052290710282*x_20 + 248.300983750079*x_21 - 1.6935687908314*x_22 + 70.8868850367374*x_23 - 21.5291963657312*x_24 - 139.524483149221*x_25 - 35.020917024499*x_26 - 102.48846929668*x_27 + 22.7187477162911*x_28 + 15.513417374952*x_29 + 216.582249834126*x_3 + 203.701447860297*x_30 - 830.364338389692*x_31 - 3.11651739717198*x_32 + 65.8532872296897*x_33 + 33.1213488954825*x_34 - 29.2283108544051*x_35 + 12.2714164571836*x_36 + 853.967065556955*x_37 - 32.5131242159783*x_38 - 75.6094869135067*x_39 + 38.2778772500677*x_4 + 16.60132555388*x_40 - 2.37531866410635*x_41 - 59452.989570179*x_42 + 37.9226317373795*x_43 + 15.2030197545481*x_44 - 3.23226046391854*x_45 - 50.2001039125505*x_46 - 279.378677290665*x_47 + 153.396840788246*x_48 - 357.047406236878*x_49 + 36.7078465373454*x_5 - 768.358552061268*x_50 + 207.199619637006*x_51 + 348.074905188914*x_52 - 21.1697419464446*x_53 + 348.389150965901*x_54 - 90.4558355529291*x_55 - 93.8452805773576*x_56 - 1125.71804113484*x_57 + 25.3377796459991*x_58 + 51.0884284116884*x_59 - 11.1382864101583*x_6 - 150.491531937132*x_60 + 24.9244883085087*x_61 - 30.6306936065694*x_62 + 32.9693444660536*x_63 - 55.7431002722214*x_64 - 2.23736457178931*x_65 - 64.1655483220484*x_66 - 0.520499561794658*x_67 + 31.7447771204232*x_68 - 67.4770361161853*x_69 - 29.7016158289275*x_7 + 55.0074008342642*x_70 + 36.517621278731*x_72 + 13.2490876803714*x_73 + 35.8390451339755*x_74 + 69.0055352171853*x_75 - 32.6234841928588*x_76 + 82.8703915599275*x_77 - 1.0275141348863*x_78 + 35.473249043822*x_79 - 46.0535335056754*x_8 - 9.90905267669379*x_80 - 166.280562620488*x_81 + 53.5339600713076*x_82 - 24.208103368326*x_83 + 180.325719714767*x_84 + 6.55983932873409*x_85 + 43.1619498834294*x_86 + 19.319246232944*x_87 + 67.3179133036839*x_88 - 47.3564731685709*x_89 + 394.559144465846*x_9 + 10.3799872565783*x_90 + 35.2719662776835*x_91 - 37.0619668800117*x_92 - 32.678830627601*x_93 + 11.0057429422093*x_94 - 39.73458063427*x_95 - 45.6485541838867*x_96 - 111.63575069579*x_97 - 8.39582586960934*x_98 - 72.5343855094918*x_99 - 1.29406707602225*std::pow(-0.694239854812622*x_108 - 0.926799833774567, 2) + 0.176882459358478*std::pow(-3.91479992866516*x_109 - 5.28447961807251, 2) + 0.000169014950186274*std::pow(-7.3600001335144*x_14 - 9.39999961853027, 2) - 16.1316653634281*std::pow(-1.35455989837646*x_15 - 1.93879985809326, 2) + 0.0497659638474333*std::pow(-6.25352001190186*x_22 - 9.28151988983154, 2) + 0.0126999599519541*std::pow(-7.00447988510132*x_66 - 9.6115198135376, 2) - 0.00643129101226853*std::pow(-6.60400009155273*x_66 - 9.97791957855225, 2) - 1.87895491402465*std::pow(-3.48359990119934*x_78 - 4.50279951095581, 2) + 0.00261919361490347*std::pow(-5.99087953567505*x_80 - 9.3931999206543, 2) + 0.160844811543363*std::pow(-6.52103996276855*x_87 - 9.17527961730957, 2) - 1.35284338500337*std::exp(1.00759983062744*x_38) + 0.00507568915102795*std::exp(1.10831987857819*x_38) + 5.8502591681793*std::exp(2.49903988838196*x_71) - 0.125943269583139*std::exp(2.50559997558594*x_71) + 0.107024754596141*std::exp(2.54895973205566*x_71) + 0.0310361901632898*std::exp(2.56287980079651*x_71) + 1.10911821173305*std::exp(2.58863997459412*x_71) + 0.000828845915830763*std::exp(2.59767985343933*x_71) + 0.00133997623145433*std::exp(2.62127995491028*x_71) + 1.22871636459906*std::exp(2.63247990608215*x_71) - 0.0842310658382903*std::exp(2.64488005638123*x_71) - 0.000399418890869652*std::exp(2.67615985870361*x_71) + 0.00469981805366563*std::exp(1.12335991859436*x_89) + 0.159598505199609*std::exp(2.01415991783142*x_89) + 4.42618156295348*std::sin(0.40191987156868*x_103 - 4.19952011108398) - 14.2717298982947*std::sin(0.337119847536087*x_106 + 1.95119988918304) + 0.0173010429600791*std::sin(0.51911985874176*x_106 + 2.13583993911743) + 0.0334311041637603*std::sin(0.509919822216034*x_107 + 8.34679985046387) + 0.165715331936581*std::sin(0.350639849901199*x_114 - 7.44543981552124) - 2.11380559985729*std::sin(0.315279841423035*x_119 - 4.26600027084351) + 10.8807119701364*std::sin(0.341759830713272*x_119 + 5.15256023406982) - 0.175842509933134*std::sin(0.31455984711647*x_120 + 8.32087993621826) + 0.0194520598562985*std::sin(0.443679869174957*x_14 + 8.23079967498779) + 45.9846577082958*std::sin(0.332719832658768*x_16 - 4.25744009017944) - 0.047484666086842*std::sin(0.33791983127594*x_16 - 4.26087999343872) - 11.239315961622*std::sin(0.48159983754158*x_16 + 8.26519966125488) - 44.9957178731524*std::sin(0.326719850301743*x_26 + 8.32287979125977) - 0.0663281375406227*std::sin(0.33247983455658*x_26 + 5.14400005340576) + 0.0836498644095124*std::sin(0.30431991815567*x_28 + 5.12759971618652) + 39.49225645395*std::sin(0.32151985168457*x_28 - 4.2868800163269) - 145.597452702016*std::sin(0.328239858150482*x_28 - 4.28272008895874) + 6.53296167133635*std::sin(0.338879853487015*x_28 - 4.26279973983765) - 0.0494074366894513*std::sin(0.351759850978851*x_28 - 4.26024007797241) + 474.176397747297*std::sin(0.371999859809875*x_34 + 2.00143980979919) - 0.0544283635994028*std::sin(0.343839854001999*x_36 - 1.24111986160278) + 240.514634374545*std::sin(0.380959838628769*x_36 + 5.18408012390137) + 0.0205092698153143*std::sin(0.402399837970734*x_36 - 7.40079975128174) + 11.150362487436*std::sin(0.403119832277298*x_36 + 2.00967979431152) + 460.951023266565*std::sin(0.200159981846809*x_38 - 1.38711988925934) + 0.178453256366162*std::sin(0.866239905357361*x_38 - 0.756079852581024) + 11.7374204709138*std::sin(0.382639855146408*x_40 - 7.4047999382019) - 111.85016164707*std::sin(0.421359837055206*x_41 + 2.02663993835449) + 7.65551159571476*std::sin(0.261839985847473*x_53 - 7.5128002166748) - 18.9416208137141*std::sin(0.332879841327667*x_53 - 7.45375967025757) - 102.832018420207*std::sin(0.410319864749908*x_53 + 5.19792032241821) + 3.16933533116154*std::sin(0.499439835548401*x_53 - 7.30983972549438) + 0.151685879878743*std::sin(0.453039854764938*x_59 - 1.14135980606079) - 167.940827040741*std::sin(0.32847985625267*x_60 - 7.45623970031738) + 31.0876129331009*std::sin(0.210639998316765*x_66 + 1.79599988460541) + 0.534226696501204*std::sin(0.537039816379547*x_75 + 5.33615970611572) + 8.45973715768578*std::sin(0.287599951028824*x_80 - 7.48920011520386) + 19.2715368041652*std::sin(0.356879830360413*x_80 + 5.14264011383057) + 87.2001807728902*std::sin(0.480559855699539*x_80 - 7.31775999069214) - 5.76638080108633*std::sin(0.483359843492508*x_80 - 1.12239992618561) + 0.0654116767713918*std::sin(0.528159856796265*x_80 - 7.26775979995728) + 3.4920031537592*std::sin(0.367679834365845*x_83 + 5.17600011825562) + 2.58314229144549*std::sin(0.782319843769073*x_88 - 7.20016002655029) + 1.69184525034972*std::sin(0.339359849691391*x_92 + 5.18760013580322) - 17.420599361941*std::sin(0.344559848308563*x_92 + 1.98527979850769) - 12.3845283421598*std::sin(0.401919841766357*x_94 + 5.1908802986145) + 0.125148807515776*std::sin(0.427519857883453*x_94 + 1.99663984775543) + 0.0410132566650857*std::sin(0.359279841184616*x_95 - 4.23464012145996) + 1.3181989682762*std::sin(0.378079831600189*x_95 - 7.41408014297485) - 9.20253645165303*std::sin(0.395039826631546*x_96 - 4.21056032180786) + 1.54523569510355*std::sin(0.398399859666824*x_96 + 5.18368005752563) - 3.29059337044261*std::sin(0.449919849634171*x_96 - 7.36735963821411) - 10.2945779415438*std::sin(0.44735985994339*x_97 + 2.00095963478088) + 56.8210174635911*std::sin(0.477439850568771*x_98 - 1.12615978717804) + 6.16843063270533*std::sin(0.52511990070343*x_98 - 7.43271970748901) - 4.13973785945037*std::sin(0.418879866600037*x_99 + 5.21640014648438) + 193836.172018499 + 2.82409125158468e-6*std::exp(-4.01200008392334*x_74) - 0.000353847685140278*std::exp(-3.20415997505188*x_74) + 0.0656840250967075*std::exp(-2.78751993179321*x_74) - 0.00043659536908826*std::exp(-2.69967985153198*x_74) - 0.0217306246611263*std::exp(-2.53735995292664*x_74) + 7.08467325398719e-6*std::exp(-3.91295981407166*x_45) - 0.00104500351979047*std::exp(-4.45559978485107*x_111) - 1.45345243766586e-5*std::exp(-4.44000005722046*x_111) - 0.00861082811266391*std::exp(-3.17839980125427*x_111) - 0.0401497890976706*std::exp(-3.65016007423401*x_101));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-11603.0532113475*x_1 - 463.530084106047*x_10 - 75.0157398182496*x_100 + 205.929475987301*x_101 - 947.363885210573*x_102 - 594.605353228492*x_103 + 393.692246571708*x_104 + 106.565375731469*x_105 - 4.70661536001261*x_106 + 195.589766038474*x_107 + 637.304560133443*x_108 - 32.5705370990006*x_109 + 568.874242276557*x_11 - 724.647597227031*x_110 + 217.199170560849*x_111 - 16.6151637147034*x_112 - 1047.4772008746*x_113 + 487.175931399443*x_114 - 1006.49590092151*x_115 + 3402.8382761349*x_116 - 62.7805298657868*x_117 - 643.080647430044*x_118 - 464.695027926846*x_119 - 1355.59074353833*x_12 + 2983.63175455965*x_120 + 951.031172758105*x_13 + 366.936744390707*x_14 + 484.106850416154*x_15 + 90.3101939690512*x_16 - 664.869575140251*x_17 + 76.1640483135382*x_18 + 81.1096564125034*x_19 - 1187.73209789781*x_2 + 2453.28818710167*x_20 + 1056.57257534475*x_21 + 2302.48319861136*x_22 - 810.325632093464*x_23 - 376.821810769866*x_24 + 1524.71665377598*x_25 - 26.8815738938737*x_26 + 168.680863207233*x_27 + 13.6191669099036*x_28 + 1176.31877426529*x_29 - 2546.56749638126*x_3 - 5431.63713843041*x_30 + 29344.8800785228*x_31 + 877.678115939889*x_32 + 159.378829953576*x_33 - 1351.39605925018*x_34 - 1975.88652132952*x_35 - 726.619721792654*x_36 - 5068.9336580464*x_37 - 17.1958257193297*x_38 - 87.1078328881518*x_39 - 39.1323428012412*x_4 + 904.354456745834*x_40 + 4.77533698664324*x_41 - 62157.0375111078*x_42 + 780.852230183174*x_43 + 451.830034042085*x_44 - 747.93568041782*x_45 + 246.465761119735*x_46 + 2425.90130803668*x_47 + 841.588413497745*x_48 + 3873.12234834303*x_49 + 264.025292905454*x_5 + 3528.40996040451*x_50 - 1132.10878873612*x_51 + 1715.13775054732*x_52 - 12.5762742818974*x_53 + 683.92376207312*x_54 + 897.045263923003*x_55 + 67.6309280492855*x_56 + 6235.86539416886*x_57 + 349.384341512677*x_58 - 564.911486018287*x_59 - 148.253824684841*x_6 - 101.71034617233*x_60 - 522.115897465258*x_61 - 1094.77938047329*x_62 + 484.403910836811*x_63 + 750.815729654815*x_64 - 466.177765996594*x_65 + 949.184987411798*x_66 - 1085.39494027441*x_67 + 264.232913949211*x_68 - 980.32242057106*x_69 + 627.775648717095*x_7 - 562.756782417952*x_70 - 279.628033233316*x_72 + 1679.74526413235*x_73 + 522.754076706171*x_74 - 86.8328605639967*x_75 + 1755.52709062039*x_76 - 489.414813540897*x_77 - 611.637706350665*x_78 + 846.831476631197*x_79 - 3380.8099279468*x_8 - 5.88016531619174*x_80 - 663.72500852886*x_81 + 187.801954307317*x_82 - 6.3892001637235*x_83 + 2167.46130649953*x_84 + 870.11283346745*x_85 + 748.473592964078*x_86 + 7.13953611907738*x_87 + 1920.44002416056*x_88 - 382.595281457503*x_89 - 2401.11184890906*x_9 + 4993.07218913601*x_90 + 570.23770039118*x_91 + 532.025923555672*x_92 + 567.569590929552*x_93 + 299.287698877076*x_94 + 436.416398711566*x_95 + 177.233311905189*x_96 + 2322.6426889761*x_97 + 736.907852050148*x_98 + 372.632572161462*x_99 - 3.92915534002643*std::pow(-0.694239854812622*x_108 - 0.926799833774567, 2) + 0.139442074417031*std::pow(-3.91479992866516*x_109 - 5.28447961807251, 2) - 0.000248427226030749*std::pow(-7.3600001335144*x_14 - 9.39999961853027, 2) - 9.50120936430898*std::pow(-1.35455989837646*x_15 - 1.93879985809326, 2) + 0.0392320937837326*std::pow(-6.25352001190186*x_22 - 9.28151988983154, 2) + 0.0385606869906059*std::pow(-7.00447988510132*x_66 - 9.6115198135376, 2) - 0.00999350586310255*std::pow(-6.60400009155273*x_66 - 9.97791957855225, 2) - 1.10666466369419*std::pow(-3.48359990119934*x_78 - 4.50279951095581, 2) + 0.000956744735635994*std::pow(-5.99087953567505*x_80 - 9.3931999206543, 2) - 8.33926080440615*std::pow(-6.52103996276855*x_87 - 9.17527961730957, 2) - 0.61263623505233*std::exp(1.00759983062744*x_38) + 0.00135192184661607*std::exp(1.10831987857819*x_38) + 3.44567879013624*std::exp(2.49903988838196*x_71) - 0.0570335127945373*std::exp(2.50559997558594*x_71) + 0.324957565050683*std::exp(2.54895973205566*x_71) + 0.011336966990132*std::exp(2.56287980079651*x_71) + 0.874353199173512*std::exp(2.58863997459412*x_71) + 0.00717861309380771*std::exp(2.59767985343933*x_71) - 0.00196956883258231*std::exp(2.62127995491028*x_71) - 63.704797939789*std::exp(2.63247990608215*x_71) - 0.130885641577182*std::exp(2.64488005638123*x_71) - 0.00010638616913892*std::exp(2.67615985870361*x_71) - 0.00690804429214457*std::exp(1.12335991859436*x_89) + 0.072274313811443*std::exp(2.01415991783142*x_89) + 6.87779037150575*std::sin(0.40191987156868*x_103 - 4.19952011108398) + 739.941043854155*std::sin(0.337119847536087*x_106 + 1.95119988918304) + 0.149843886731672*std::sin(0.51911985874176*x_106 + 2.13583993911743) + 0.289545930681066*std::sin(0.509919822216034*x_107 + 8.34679985046387) - 0.24357727040358*std::sin(0.350639849901199*x_114 - 7.44543981552124) - 0.772135503199858*std::sin(0.315279841423035*x_119 - 4.26600027084351) + 4.92733932838544*std::sin(0.341759830713272*x_119 + 5.15256023406982) + 0.258462739022957*std::sin(0.31455984711647*x_120 + 8.32087993621826) + 0.00518110228954573*std::sin(0.443679869174957*x_14 + 8.23079967498779) + 36.2511697624389*std::sin(0.332719832658768*x_16 - 4.25744009017944) - 0.41126346793231*std::sin(0.33791983127594*x_16 - 4.26087999343872) - 5.08973343967268*std::sin(0.48159983754158*x_16 + 8.26519966125488) + 2332.87616072426*std::sin(0.326719850301743*x_26 + 8.32287979125977) - 0.574466288055177*std::sin(0.33247983455658*x_26 + 5.14400005340576) + 0.0222803398310531*std::sin(0.30431991815567*x_28 + 5.12759971618652) + 31.1330031441257*std::sin(0.32151985168457*x_28 - 4.2868800163269) + 7548.73669152809*std::sin(0.328239858150482*x_28 - 4.28272008895874) + 10.1514906791467*std::sin(0.338879853487015*x_28 - 4.26279973983765) - 0.427916534516398*std::sin(0.351759850978851*x_28 - 4.26024007797241) + 279.279859153582*std::sin(0.371999859809875*x_34 + 2.00143980979919) + 0.080001723939157*std::sin(0.343839854001999*x_36 - 1.24111986160278) + 141.658027543361*std::sin(0.380959838628769*x_36 + 5.18408012390137) + 0.00546269267018677*std::sin(0.402399837970734*x_36 - 7.40079975128174) + 5.04945078602319*std::sin(0.403119832277298*x_36 + 2.00967979431152) - 23898.7553542655*std::sin(0.200159981846809*x_38 - 1.38711988925934) + 0.0651857932968116*std::sin(0.866239905357361*x_38 - 0.756079852581024) + 35.6381436294525*std::sin(0.382639855146408*x_40 - 7.4047999382019) + 5799.05351027402*std::sin(0.421359837055206*x_41 + 2.02663993835449) + 23.2443084475938*std::sin(0.261839985847473*x_53 - 7.5128002166748) - 14.9322827637319*std::sin(0.332879841327667*x_53 - 7.45375967025757) + 5331.49321026382*std::sin(0.410319864749908*x_53 + 5.19792032241821) + 4.92479210685396*std::sin(0.499439835548401*x_53 - 7.30983972549438) - 0.222956030367601*std::sin(0.453039854764938*x_59 - 1.14135980606079) + 8707.16526670702*std::sin(0.32847985625267*x_60 - 7.45623970031738) + 14.078050981527*std::sin(0.210639998316765*x_66 + 1.79599988460541) + 0.195143488669727*std::sin(0.537039816379547*x_75 + 5.33615970611572) + 13.145483966495*std::sin(0.287599951028824*x_80 - 7.48920011520386) + 15.1923660430955*std::sin(0.356879830360413*x_80 + 5.14264011383057) - 4521.03516848878*std::sin(0.480559855699539*x_80 - 7.31775999069214) - 17.5083705760124*std::sin(0.483359843492508*x_80 - 1.12239992618561) - 0.0961455858930081*std::sin(0.528159856796265*x_80 - 7.26775979995728) + 5.42618176109491*std::sin(0.367679834365845*x_83 + 5.17600011825562) + 4.0139137827139*std::sin(0.782319843769073*x_88 - 7.20016002655029) + 0.618000909735155*std::sin(0.339359849691391*x_92 + 5.18760013580322) - 13.7332131259777*std::sin(0.344559848308563*x_92 + 1.98527979850769) - 37.6029469962879*std::sin(0.401919841766357*x_94 + 5.1908802986145) - 0.183950420113341*std::sin(0.427519857883453*x_94 + 1.99663984775543) + 0.355214757884861*std::sin(0.359279841184616*x_95 - 4.23464012145996) + 0.481514583818019*std::sin(0.378079831600189*x_95 - 7.41408014297485) - 4.16737617019763*std::sin(0.395039826631546*x_96 - 4.21056032180786) + 0.564447052785609*std::sin(0.398399859666824*x_96 + 5.18368005752563) - 5.11321351776384*std::sin(0.449919849634171*x_96 - 7.36735963821411) - 4.66190805341777*std::sin(0.44735985994339*x_97 + 2.00095963478088) + 33.4663762886233*std::sin(0.477439850568771*x_98 - 1.12615978717804) + 18.7291081035587*std::sin(0.52511990070343*x_98 - 7.43271970748901) - 6.4326889408682*std::sin(0.418879866600037*x_99 + 5.21640014648438) + 108376.398910102 + 2.44593814719032e-5*std::exp(-4.01200008392334*x_74) - 0.000129254251403412*std::exp(-3.20415997505188*x_74) + 0.199435363703451*std::exp(-2.78751993179321*x_74) - 0.000116288212307542*std::exp(-2.69967985153198*x_74) - 0.0337669566725522*std::exp(-2.53735995292664*x_74) + 6.13601722769496e-5*std::exp(-3.91295981407166*x_45) - 0.00317292761419468*std::exp(-4.45559978485107*x_111) + 2.13636223812752e-5*std::exp(-4.44000005722046*x_111) - 0.00678818995864891*std::exp(-3.17839980125427*x_111) - 0.0181818648807457*std::exp(-3.65016007423401*x_101));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1482.44784387138*x_1 - 46.6494413676522*x_10 + 298.224429708432*x_100 - 241.412877055884*x_101 + 19.3714647558451*x_102 + 104.208411894757*x_103 + 90.039035141925*x_104 - 68.2735277597724*x_105 + 21.9721012413069*x_106 + 86.17727998144*x_107 + 142.010105306912*x_108 + 313.415010099161*x_109 + 120.035603782649*x_11 + 111.252288161689*x_110 - 56.6249462994036*x_111 + 39.9105052977088*x_112 - 707.960324084233*x_113 + 219.7631073462*x_114 - 102.263302592006*x_115 - 620.965390101168*x_116 + 67.7299140743293*x_117 + 14.7171834528702*x_118 - 8.66656523076535*x_119 - 1595.13077308373*x_12 + 472.944051263189*x_120 + 188.553508797386*x_13 + 58.966281230238*x_14 + 64.2989888414558*x_15 + 85.9619251240708*x_16 + 28.0943080333196*x_17 + 264.849151159387*x_18 - 20.5502256292131*x_19 + 76.2951571074933*x_2 + 98.4912937417508*x_20 - 491.414130194447*x_21 + 214.702582584821*x_22 - 213.565480752356*x_23 + 7.09746138292887*x_24 + 422.686750934645*x_25 + 60.314569453135*x_26 + 250.950747555417*x_27 - 44.4366470366442*x_28 + 56.1031845850783*x_29 - 678.648601108507*x_3 - 859.010638318047*x_30 + 3987.88057052672*x_31 + 86.5191958895156*x_32 - 144.143811913599*x_33 - 168.680198556835*x_34 - 94.4255351466739*x_35 - 94.8252852331003*x_36 - 2340.9257305101*x_37 + 74.9765953694177*x_38 + 165.067124994841*x_39 - 78.7454259230465*x_4 + 45.5125278259948*x_40 + 24.2811740490665*x_41 + 118720.272819599*x_42 - 19.333379183234*x_43 - 28.8795029821969*x_44 - 45.2259114828249*x_45 + 113.408324200248*x_46 + 848.060568594018*x_47 - 176.456240229211*x_48 + 1127.11188533383*x_49 - 68.0138440733936*x_5 + 1964.80781998751*x_50 - 518.218592868686*x_51 - 643.883172220724*x_52 + 46.5146073109785*x_53 - 657.309256483334*x_54 + 275.776446898263*x_55 + 198.302907081718*x_56 + 3087.388828783*x_57 - 42.8680054895758*x_58 - 172.680121169849*x_59 + 14.1657216819972*x_6 + 262.054341076333*x_60 - 90.8665691825876*x_61 - 20.9741282676955*x_62 - 53.0114154090355*x_63 + 182.643104385266*x_64 - 25.6621611400604*x_65 + 224.312187212966*x_66 - 79.96415838625*x_67 - 38.307571895162*x_68 + 54.1811730969249*x_69 + 111.784853893077*x_7 - 175.421691081369*x_70 - 98.8806853749161*x_72 + 132.668053248245*x_73 - 47.6172880907692*x_74 - 168.992760069786*x_75 + 215.142849746676*x_76 - 211.699329943472*x_77 - 73.7980080588417*x_78 + 10.333965969273*x_79 - 105.104315955829*x_8 + 20.7710906609446*x_80 + 325.651143892588*x_81 - 81.3410618527915*x_82 + 45.999348364865*x_83 - 130.570385050642*x_84 + 71.6442763160057*x_85 - 36.0876789627148*x_86 - 54.199246638756*x_87 + 41.4864029823857*x_88 + 57.7331473451907*x_89 - 1038.07464077876*x_9 + 400.945535117395*x_90 - 45.0836449099351*x_91 + 130.319223735539*x_92 + 125.78749115173*x_93 - 15.342843321146*x_94 + 108.381998135189*x_95 + 115.681911630157*x_96 + 436.677051124832*x_97 + 93.5249906834002*x_98 + 176.143472178956*x_99 + 1.72175681846269*std::pow(-0.694239854812622*x_108 - 0.926799833774567, 2) + 0.00695659868182324*std::pow(-3.91479992866516*x_109 - 5.28447961807251, 2) - 0.000126588477097636*std::pow(-7.3600001335144*x_14 - 9.39999961853027, 2) + 34.3804186258764*std::pow(-1.35455989837646*x_15 - 1.93879985809326, 2) + 0.00195724233910096*std::pow(-6.25352001190186*x_22 - 9.28151988983154, 2) - 0.0168973023474899*std::pow(-7.00447988510132*x_66 - 9.6115198135376, 2) - 0.00370298276927002*std::pow(-6.60400009155273*x_66 - 9.97791957855225, 2) + 4.0045001596529*std::pow(-3.48359990119934*x_78 - 4.50279951095581, 2) + 0.00218253623446171*std::pow(-5.99087953567505*x_80 - 9.3931999206543, 2) - 1.06245364147969*std::pow(-6.52103996276855*x_87 - 9.17527961730957, 2) - 0.256299740028575*std::exp(1.00759983062744*x_38) + 0.000227250510310846*std::exp(1.10831987857819*x_38) - 12.4682947941547*std::exp(2.49903988838196*x_71) - 0.023860283910415*std::exp(2.50559997558594*x_71) - 0.142396483447071*std::exp(2.54895973205566*x_71) + 0.0258620092938492*std::exp(2.56287980079651*x_71) + 0.0436204376494522*std::exp(2.58863997459412*x_71) - 0.00677454426370913*std::exp(2.59767985343933*x_71) - 0.00100361269994096*std::exp(2.62127995491028*x_71) - 8.11623429682103*std::exp(2.63247990608215*x_71) - 0.0484982229604345*std::exp(2.64488005638123*x_71) - 1.78829207378741e-5*std::exp(2.67615985870361*x_71) - 0.00352006026327146*std::exp(1.12335991859436*x_89) + 0.030236356879926*std::exp(2.01415991783142*x_89) + 2.54848894724421*std::sin(0.40191987156868*x_103 - 4.19952011108398) + 94.271311925843*std::sin(0.337119847536087*x_106 + 1.95119988918304) - 0.141409493734322*std::sin(0.51911985874176*x_106 + 2.13583993911743) - 0.273248007399615*std::sin(0.509919822216034*x_107 + 8.34679985046387) - 0.124117135664397*std::sin(0.350639849901199*x_114 - 7.44543981552124) - 1.76140369617793*std::sin(0.315279841423035*x_119 - 4.26600027084351) + 2.06137952122582*std::sin(0.341759830713272*x_119 + 5.15256023406982) + 0.131702169050304*std::sin(0.31455984711647*x_120 + 8.32087993621826) + 0.000870914352200959*std::sin(0.443679869174957*x_14 + 8.23079967498779) + 1.80852759712768*std::sin(0.332719832658768*x_16 - 4.25744009017944) + 0.388114323915474*std::sin(0.33791983127594*x_16 - 4.26087999343872) - 2.12931799127328*std::sin(0.48159983754158*x_16 + 8.26519966125488) + 297.217322999786*std::sin(0.326719850301743*x_26 + 8.32287979125977) + 0.542130805154481*std::sin(0.33247983455658*x_26 + 5.14400005340576) + 0.00374520066317396*std::sin(0.30431991815567*x_28 + 5.12759971618652) + 1.5531883725847*std::sin(0.32151985168457*x_28 - 4.2868800163269) + 961.737853581433*std::sin(0.328239858150482*x_28 - 4.28272008895874) + 3.76152229079848*std::sin(0.338879853487015*x_28 - 4.26279973983765) + 0.403830024876948*std::sin(0.351759850978851*x_28 - 4.26024007797241) - 1010.58276934141*std::sin(0.371999859809875*x_34 + 2.00143980979919) + 0.0407656461832*std::sin(0.343839854001999*x_36 - 1.24111986160278) - 512.593934299741*std::sin(0.380959838628769*x_36 + 5.18408012390137) + 0.000918248122166637*std::sin(0.402399837970734*x_36 - 7.40079975128174) + 2.11246552145954*std::sin(0.403119832277298*x_36 + 2.00967979431152) - 3044.79260794384*std::sin(0.200159981846809*x_38 - 1.38711988925934) + 0.148702522776724*std::sin(0.866239905357361*x_38 - 0.756079852581024) - 15.6166431411566*std::sin(0.382639855146408*x_40 - 7.4047999382019) + 738.821541097604*std::sin(0.421359837055206*x_41 + 2.02663993835449) - 10.1856615727046*std::sin(0.261839985847473*x_53 - 7.5128002166748) - 0.744953766824498*std::sin(0.332879841327667*x_53 - 7.45375967025757) + 679.252575093483*std::sin(0.410319864749908*x_53 + 5.19792032241821) + 1.82482709909129*std::sin(0.499439835548401*x_53 - 7.30983972549438) - 0.113609384908865*std::sin(0.453039854764938*x_59 - 1.14135980606079) + 1109.32607356403*std::sin(0.32847985625267*x_60 - 7.45623970031738) + 5.88963009405769*std::sin(0.210639998316765*x_66 + 1.79599988460541) + 0.445163395289366*std::sin(0.537039816379547*x_75 + 5.33615970611572) + 4.87091329994317*std::sin(0.287599951028824*x_80 - 7.48920011520386) + 0.75792901124731*std::sin(0.356879830360413*x_80 + 5.14264011383057) - 575.997128604098*std::sin(0.480559855699539*x_80 - 7.31775999069214) + 7.67217221277333*std::sin(0.483359843492508*x_80 - 1.12239992618561) - 0.0489919059690719*std::sin(0.528159856796265*x_80 - 7.26775979995728) + 2.01061147504283*std::sin(0.367679834365845*x_83 + 5.17600011825562) + 1.48731123775121*std::sin(0.782319843769073*x_88 - 7.20016002655029) + 1.40979022741176*std::sin(0.339359849691391*x_92 + 5.18760013580322) - 0.685133613572412*std::sin(0.344559848308563*x_92 + 1.98527979850769) + 16.4776204507898*std::sin(0.401919841766357*x_94 + 5.1908802986145) - 0.0937337018799057*std::sin(0.427519857883453*x_94 + 1.99663984775543) - 0.335220476290817*std::sin(0.359279841184616*x_95 - 4.23464012145996) + 1.09843617368428*std::sin(0.378079831600189*x_95 - 7.41408014297485) - 1.74344475222184*std::sin(0.395039826631546*x_96 - 4.21056032180786) + 1.28762260115368*std::sin(0.398399859666824*x_96 + 5.18368005752563) - 1.89464456330442*std::sin(0.449919849634171*x_96 - 7.36735963821411) - 1.95033488677997*std::sin(0.44735985994339*x_97 + 2.00095963478088) - 121.099113026193*std::sin(0.477439850568771*x_98 - 1.12615978717804) - 8.20709969201931*std::sin(0.52511990070343*x_98 - 7.43271970748901) - 2.3835615483107*std::sin(0.418879866600037*x_99 + 5.21640014648438) - 401172.917239889 - 2.30826150231288e-5*std::exp(-4.01200008392334*x_74) - 0.000294856168671409*std::exp(-3.20415997505188*x_74) - 0.0873926245167728*std::exp(-2.78751993179321*x_74) - 1.95473988797295e-5*std::exp(-2.69967985153198*x_74) - 0.0125119713183747*std::exp(-2.53735995292664*x_74) - 5.79063389664482e-5*std::exp(-3.91295981407166*x_45) + 0.00139037764645657*std::exp(-4.45559978485107*x_111) + 1.0886038803975e-5*std::exp(-4.44000005722046*x_111) - 0.00033865469597844*std::exp(-3.17839980125427*x_111) - 0.00760648322045751*std::exp(-3.65016007423401*x_101));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1381.08323317555*x_1 - 54.3624230383089*x_10 - 8.78408166201763*x_100 + 10.2524933499081*x_101 - 102.669074675102*x_102 - 67.4927850334744*x_103 + 42.7622426294304*x_104 + 6.31748678510331*x_105 - 1.25576253983726*x_106 + 30.9200710825512*x_107 + 61.1678477791633*x_108 - 4.52797220804055*x_109 + 54.9753258758113*x_11 - 81.3586627152621*x_110 + 23.0817631740561*x_111 - 7.50691198944573*x_112 - 103.788813424163*x_113 + 58.4014263734665*x_114 - 99.7092343743176*x_115 + 345.387384030682*x_116 + 3.58760543888817*x_117 - 61.9271242973729*x_118 - 46.083905876718*x_119 - 206.325513857308*x_12 + 316.085602342708*x_120 + 85.6340394553014*x_13 + 46.0629557301416*x_14 + 44.8323863614661*x_15 + 11.0541437046327*x_16 - 71.8406642889411*x_17 + 2.32577150651564*x_18 + 10.1393737348513*x_19 - 126.508379176071*x_2 + 262.961934036314*x_20 + 79.573307702881*x_21 + 241.243439109494*x_22 - 81.7142189333401*x_23 - 43.0422828326271*x_24 + 155.188733286547*x_25 - 7.21538960962092*x_26 + 28.8954915843321*x_27 + 1.41778809153419*x_28 + 120.777730739982*x_29 - 260.841896321145*x_3 - 534.949505386125*x_30 + 2972.17271763774*x_31 + 87.5749615600234*x_32 + 4.862209943217*x_33 - 130.509228459909*x_34 - 202.278276459552*x_35 - 80.29639326366*x_36 - 522.612710431299*x_37 - 2.44306237376157*x_38 - 3.28409661945765*x_39 - 1.18596540933796*x_4 + 93.9392037700352*x_40 + 11.5962759747944*x_41 - 15202.1152176285*x_42 + 81.0720360766482*x_43 + 33.7085394293042*x_44 - 72.614527735989*x_45 + 21.7574507767103*x_46 + 255.794288586671*x_47 + 110.30602424483*x_48 + 420.908782837348*x_49 + 21.4685385466604*x_5 + 341.968043588995*x_50 - 104.860522979399*x_51 + 147.397925854267*x_52 - 1.19504182981334*x_53 + 98.8241783870708*x_54 + 95.8374700201956*x_55 - 0.1134372031002*x_56 + 689.975162573237*x_57 + 27.9971605365388*x_58 - 68.1666069105062*x_59 - 15.8304030461039*x_6 - 31.7659779276384*x_60 - 51.8454860828897*x_61 - 109.265227128397*x_62 + 37.1467700890504*x_63 + 80.4996855231095*x_64 - 46.1380965908871*x_65 + 101.617108621483*x_66 - 110.234921575531*x_67 + 29.5186116392067*x_68 - 107.08202675287*x_69 + 66.7203448733285*x_7 - 54.9733945829948*x_70 - 30.1885416791397*x_72 + 182.459977796508*x_73 + 45.2771578737544*x_74 - 12.6136251374746*x_75 + 185.649590354193*x_76 - 42.9096957380426*x_77 - 73.766514222597*x_78 + 94.7981633978395*x_79 - 312.167847198472*x_8 - 0.574517490686173*x_80 - 55.0873142444018*x_81 + 33.9713751317342*x_82 - 5.72707955307959*x_83 + 277.256879969808*x_84 + 98.6299175958215*x_85 + 80.4075592693862*x_86 - 2.62535798751354*x_87 + 212.81080769832*x_88 - 49.3747709073699*x_89 - 247.814695875379*x_9 + 529.058478262024*x_90 + 35.7887384850295*x_91 + 55.7470609720305*x_92 + 58.8798647199269*x_93 + 26.2944319259819*x_94 + 36.4531741358754*x_95 + 21.3151164651884*x_96 + 246.783620975643*x_97 + 83.7443908540408*x_98 + 35.6220141984214*x_99 + 0.375832527307049*std::pow(-0.694239854812622*x_108 - 0.926799833774567, 2) + 0.21586673683447*std::pow(-3.91479992866516*x_109 - 5.28447961807251, 2) - 0.000188984163856907*std::pow(-7.3600001335144*x_14 - 9.39999961853027, 2) - 0.97402115124728*std::pow(-1.35455989837646*x_15 - 1.93879985809326, 2) + 0.0607342088080976*std::pow(-6.25352001190186*x_22 - 9.28151988983154, 2) - 0.00368841626054875*std::pow(-7.00447988510132*x_66 - 9.6115198135376, 2) + 0.00191674161495796*std::pow(-6.60400009155273*x_66 - 9.97791957855225, 2) - 0.113450272322727*std::pow(-3.48359990119934*x_78 - 4.50279951095581, 2) + 0.0029297998871203*std::pow(-5.99087953567505*x_80 - 9.3931999206543, 2) - 0.877049296396695*std::pow(-6.52103996276855*x_87 - 9.17527961730957, 2) - 0.132808951453672*std::exp(1.00759983062744*x_38) + 0.00230778552391025*std::exp(1.10831987857819*x_38) + 0.353235455962498*std::exp(2.49903988838196*x_71) - 0.0123638802254573*std::exp(2.50559997558594*x_71) - 0.0310829204680214*std::exp(2.54895973205566*x_71) + 0.0347167257585126*std::exp(2.56287980079651*x_71) + 1.35356399949908*std::exp(2.58863997459412*x_71) - 0.00280801140503161*std::exp(2.59767985343933*x_71) - 0.00149829519465842*std::exp(2.62127995491028*x_71) - 6.69990416664565*std::exp(2.63247990608215*x_71) + 0.0251036982864761*std::exp(2.64488005638123*x_71) - 0.000181605513438227*std::exp(2.67615985870361*x_71) - 0.00525510426250878*std::exp(1.12335991859436*x_89) + 0.0156678225758414*std::exp(2.01415991783142*x_89) - 1.31915137736553*std::sin(0.40191987156868*x_103 - 4.19952011108398) + 77.8204192324138*std::sin(0.337119847536087*x_106 + 1.95119988918304) - 0.0586134588141754*std::sin(0.51911985874176*x_106 + 2.13583993911743) - 0.113259798934458*std::sin(0.509919822216034*x_107 + 8.34679985046387) - 0.185294693811341*std::sin(0.350639849901199*x_114 - 7.44543981552124) - 2.3644786596215*std::sin(0.315279841423035*x_119 - 4.26600027084351) + 1.06816203844589*std::sin(0.341759830713272*x_119 + 5.15256023406982) + 0.196618403718656*std::sin(0.31455984711647*x_120 + 8.32087993621826) + 0.00884435212852026*std::sin(0.443679869174957*x_14 + 8.23079967498779) + 56.1195159765518*std::sin(0.332719832658768*x_16 - 4.25744009017944) + 0.160871256513732*std::sin(0.33791983127594*x_16 - 4.26087999343872) - 1.10336627614572*std::sin(0.48159983754158*x_16 + 8.26519966125488) + 245.351170005713*std::sin(0.326719850301743*x_26 + 8.32287979125977) + 0.224710242436186*std::sin(0.33247983455658*x_26 + 5.14400005340576) + 0.0380334453937612*std::sin(0.30431991815567*x_28 + 5.12759971618652) + 48.1962121165838*std::sin(0.32151985168457*x_28 - 4.2868800163269) + 793.90899976297*std::sin(0.328239858150482*x_28 - 4.28272008895874) - 1.94704290017173*std::sin(0.338879853487015*x_28 - 4.26279973983765) + 0.167385328283*std::sin(0.351759850978851*x_28 - 4.26024007797241) + 28.63051212773*std::sin(0.371999859809875*x_34 + 2.00143980979919) + 0.0608591060944397*std::sin(0.343839854001999*x_36 - 1.24111986160278) + 14.5221423695296*std::sin(0.380959838628769*x_36 + 5.18408012390137) + 0.0093250383499482*std::sin(0.402399837970734*x_36 - 7.40079975128174) + 1.09463369278407*std::sin(0.403119832277298*x_36 + 2.00967979431152) - 2513.45857382715*std::sin(0.200159981846809*x_38 - 1.38711988925934) + 0.199615762417435*std::sin(0.866239905357361*x_38 - 0.756079852581024) - 3.40886842837287*std::sin(0.382639855146408*x_40 - 7.4047999382019) + 609.892881424853*std::sin(0.421359837055206*x_41 + 2.02663993835449) - 2.22337027512509*std::sin(0.261839985847473*x_53 - 7.5128002166748) - 23.1162880154537*std::sin(0.332879841327667*x_53 - 7.45375967025757) + 560.71904674513*std::sin(0.410319864749908*x_53 + 5.19792032241821) - 0.944568813540766*std::sin(0.499439835548401*x_53 - 7.30983972549438) - 0.169607653915763*std::sin(0.453039854764938*x_59 - 1.14135980606079) + 915.74221623339*std::sin(0.32847985625267*x_60 - 7.45623970031738) + 3.05187823114681*std::sin(0.210639998316765*x_66 + 1.79599988460541) + 0.597579845262248*std::sin(0.537039816379547*x_75 + 5.33615970611572) - 2.5212869750117*std::sin(0.287599951028824*x_80 - 7.48920011520386) + 23.5189163401981*std::sin(0.356879830360413*x_80 + 5.14264011383057) - 475.482276728023*std::sin(0.480559855699539*x_80 - 7.31775999069214) + 1.67471494333101*std::sin(0.483359843492508*x_80 - 1.12239992618561) - 0.0731401040410667*std::sin(0.528159856796265*x_80 - 7.26775979995728) - 1.04073470654747*std::sin(0.367679834365845*x_83 + 5.17600011825562) - 0.769863518526271*std::sin(0.782319843769073*x_88 - 7.20016002655029) + 1.89247866033848*std::sin(0.339359849691391*x_92 + 5.18760013580322) - 21.260038737598*std::sin(0.344559848308563*x_92 + 1.98527979850769) + 3.596806280434*std::sin(0.401919841766357*x_94 + 5.1908802986145) - 0.139935211175057*std::sin(0.427519857883453*x_94 + 1.99663984775543) - 0.138947047060752*std::sin(0.359279841184616*x_95 - 4.23464012145996) + 1.47452222183279*std::sin(0.378079831600189*x_95 - 7.41408014297485) - 0.90341515537306*std::sin(0.395039826631546*x_96 - 4.21056032180786) + 1.72848289615867*std::sin(0.398399859666824*x_96 + 5.18368005752563) + 0.980707798636428*std::sin(0.449919849634171*x_96 - 7.36735963821411) - 1.01062112379781*std::sin(0.44735985994339*x_97 + 2.00095963478088) + 3.43082202600113*std::sin(0.477439850568771*x_98 - 1.12615978717804) - 1.79148122779998*std::sin(0.52511990070343*x_98 - 7.43271970748901) + 1.23378149349622*std::sin(0.418879866600037*x_99 + 5.21640014648438) + 10451.9268487823 - 9.56761720343564e-6*std::exp(-4.01200008392334*x_74) - 0.000395809955431637*std::exp(-3.20415997505188*x_74) - 0.0190764401731606*std::exp(-2.78751993179321*x_74) - 0.000198508703470164*std::exp(-2.69967985153198*x_74) + 0.00647645900761694*std::exp(-2.53735995292664*x_74) - 2.40018595955541e-5*std::exp(-3.91295981407166*x_45) + 0.000303497647969573*std::exp(-4.45559978485107*x_111) + 1.62517867996493e-5*std::exp(-4.44000005722046*x_111) - 0.0105086246135699*std::exp(-3.17839980125427*x_111) - 0.00394151418431515*std::exp(-3.65016007423401*x_101));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1588.96200010937*x_1 - 59.7972891032585*x_10 + 234.856102321533*x_100 - 195.726927946571*x_101 - 24.44449188322*x_102 + 59.5245671780819*x_103 + 80.7442134871013*x_104 - 47.5077442536617*x_105 + 17.6245122111918*x_106 + 75.5006490326267*x_107 + 140.54036708251*x_108 + 252.904464324852*x_109 + 121.883838147873*x_11 + 65.1232487084945*x_110 - 35.866036090239*x_111 + 30.7315535255468*x_112 - 622.627812629777*x_113 + 200.468191628895*x_114 - 126.878486595024*x_115 - 347.046098330134*x_116 + 53.2344263575364*x_117 - 15.1521419947895*x_118 - 28.7259542250021*x_119 - 1297.00417185853*x_12 + 500.769101034506*x_120 + 199.499771667429*x_13 + 57.9320193755636*x_14 + 71.2888910001302*x_15 + 69.6140033224534*x_16 - 7.51161725627177*x_17 + 216.910771272622*x_18 - 15.0662524516068*x_19 + 15.3358731172978*x_2 + 174.183296433425*x_20 - 340.56322445632*x_21 + 267.42480235927*x_22 - 208.351580115789*x_23 - 10.2687428179106*x_24 + 408.469958365962*x_25 + 46.4815139595358*x_26 + 205.270564857156*x_27 - 35.8990560877491*x_28 + 93.6359035957424*x_29 - 670.844889752538*x_3 - 945.8054986817*x_30 + 4264.45511962523*x_31 + 106.312662938507*x_32 - 105.071214931406*x_33 - 199.790474675754*x_34 - 161.239860999181*x_35 - 103.697971347873*x_36 - 2119.17119502741*x_37 + 58.6555755674794*x_38 + 129.471616150652*x_39 - 67.5474967927988*x_4 + 73.1693586854972*x_40 + 22.2564082232608*x_41 + 98553.3850960954*x_42 + 17.3059886934535*x_43 - 2.07815080626359*x_44 - 65.9118561335919*x_45 + 103.623433507332*x_46 + 798.847940544251*x_47 - 107.277189758368*x_48 + 1059.12212613685*x_49 - 43.0283251248084*x_5 + 1765.24284692236*x_50 - 471.067373253863*x_51 - 427.448589629803*x_52 + 37.0562999841522*x_53 - 523.825280430864*x_54 + 257.081982308292*x_55 + 163.792949687222*x_56 + 2723.59816309328*x_57 - 16.8305452609382*x_58 - 162.279564479341*x_59 + 6.79331657804989*x_6 + 211.367904046632*x_60 - 99.2360292396191*x_61 - 65.5923652889611*x_62 - 14.6933897198425*x_63 + 178.390714332045*x_64 - 42.1408564598148*x_65 + 221.159845511203*x_66 - 110.915286354394*x_67 - 22.2890319777645*x_68 + 7.19756916471914*x_69 + 116.233221162723*x_7 - 161.47523117925*x_70 - 85.8348153571291*x_72 + 174.368955202229*x_73 - 15.6122013645336*x_74 - 140.713891547876*x_75 + 255.162409377025*x_76 - 195.439100860698*x_77 - 85.8042532918373*x_78 + 45.6301424930075*x_79 - 236.398002656106*x_8 + 16.6655832132723*x_80 + 240.340377276076*x_81 - 65.7747681800647*x_82 + 38.4698015971171*x_83 - 44.3609774399101*x_84 + 88.4380413996025*x_85 + 0.715117253443525*x_86 - 44.5384633660497*x_87 + 112.572690952907*x_88 + 31.3281546642194*x_89 - 914.689049159348*x_9 + 515.085793452706*x_90 - 9.41978398993575*x_91 + 129.477179942861*x_92 + 127.560122967238*x_93 + 2.17066701518649*x_94 + 106.545499541955*x_95 + 97.0940197988824*x_96 + 434.396142522493*x_97 + 104.502893201445*x_98 + 155.407350587753*x_99 - 1.01191197196641*std::pow(-0.694239854812622*x_108 - 0.926799833774567, 2) - 0.0369280809107558*std::pow(-3.91479992866516*x_109 - 5.28447961807251, 2) + 5.42890657485298e-5*std::pow(-7.3600001335144*x_14 - 9.39999961853027, 2) + 27.5834498933625*std::pow(-1.35455989837646*x_15 - 1.93879985809326, 2) - 0.0103897330816465*std::pow(-6.25352001190186*x_22 - 9.28151988983154, 2) + 0.00993089288569109*std::pow(-7.00447988510132*x_66 - 9.6115198135376, 2) + 0.00247980013929592*std::pow(-6.60400009155273*x_66 - 9.97791957855225, 2) + 3.21281514061064*std::pow(-3.48359990119934*x_78 - 4.50279951095581, 2) + 0.000294619839749151*std::pow(-5.99087953567505*x_80 - 9.3931999206543, 2) - 1.20719471456159*std::pow(-6.52103996276855*x_87 - 9.17527961730957, 2) + 0.272996428593359*std::exp(1.00759983062744*x_38) - 0.00134576454580904*std::exp(1.10831987857819*x_38) - 10.00332743044*std::exp(2.49903988838196*x_71) + 0.0254146660158167*std::exp(2.50559997558594*x_71) + 0.0836893484729542*std::exp(2.54895973205566*x_71) + 0.00349110402541571*std::exp(2.56287980079651*x_71) - 0.231552677473034*std::exp(2.58863997459412*x_71) + 0.00061099119751495*std::exp(2.59767985343933*x_71) + 0.000430411970365443*std::exp(2.62127995491028*x_71) - 9.22193191565541*std::exp(2.63247990608215*x_71) + 0.0324781149539613*std::exp(2.64488005638123*x_71) + 0.000105901635475428*std::exp(2.67615985870361*x_71) + 0.0015096222614649*std::exp(1.12335991859436*x_89) - 0.0322061093037931*std::exp(2.01415991783142*x_89) - 1.7066628823704*std::sin(0.40191987156868*x_103 - 4.19952011108398) + 107.114160137066*std::sin(0.337119847536087*x_106 + 1.95119988918304) + 0.0127536189230553*std::sin(0.51911985874176*x_106 + 2.13583993911743) + 0.0246440381464504*std::sin(0.509919822216034*x_107 + 8.34679985046387) + 0.0532291997904877*std::sin(0.350639849901199*x_114 - 7.44543981552124) - 0.23777129859633*std::sin(0.315279841423035*x_119 - 4.26600027084351) - 2.19566842794065*std::sin(0.341759830713272*x_119 + 5.15256023406982) - 0.0564821370690893*std::sin(0.31455984711647*x_120 + 8.32087993621826) - 0.00515750506357547*std::sin(0.443679869174957*x_14 + 8.23079967498779) - 9.60030274716985*std::sin(0.332719832658768*x_16 - 4.25744009017944) - 0.0350037473091936*std::sin(0.33791983127594*x_16 - 4.26087999343872) + 2.26803276075264*std::sin(0.48159983754158*x_16 + 8.26519966125488) + 337.708081927965*std::sin(0.326719850301743*x_26 + 8.32287979125977) - 0.0488943812243579*std::sin(0.33247983455658*x_26 + 5.14400005340576) - 0.0221788644722769*std::sin(0.30431991815567*x_28 + 5.12759971618652) - 8.24487202953333*std::sin(0.32151985168457*x_28 - 4.2868800163269) + 1092.75812921152*std::sin(0.328239858150482*x_28 - 4.28272008895874) - 2.51900267484247*std::sin(0.338879853487015*x_28 - 4.26279973983765) - 0.0364211348966769*std::sin(0.351759850978851*x_28 - 4.26024007797241) - 810.791732484724*std::sin(0.371999859809875*x_34 + 2.00143980979919) - 0.0174828617632716*std::sin(0.343839854001999*x_36 - 1.24111986160278) - 411.254710312243*std::sin(0.380959838628769*x_36 + 5.18408012390137) - 0.00543781294650237*std::sin(0.402399837970734*x_36 - 7.40079975128174) - 2.25008243403121*std::sin(0.403119832277298*x_36 + 2.00967979431152) - 3459.59334105804*std::sin(0.200159981846809*x_38 - 1.38711988925934) + 0.020073304048296*std::sin(0.866239905357361*x_38 - 0.756079852581024) + 9.17822307250877*std::sin(0.382639855146408*x_40 - 7.4047999382019) + 839.473295206666*std::sin(0.421359837055206*x_41 + 2.02663993835449) + 5.98632325848487*std::sin(0.261839985847473*x_53 - 7.5128002166748) + 3.95447750176347*std::sin(0.332879841327667*x_53 - 7.45375967025757) + 771.789080004653*std::sin(0.410319864749908*x_53 + 5.19792032241821) - 1.22204362711891*std::sin(0.499439835548401*x_53 - 7.30983972549438) + 0.0487228182878785*std::sin(0.453039854764938*x_59 - 1.14135980606079) + 1260.45271101597*std::sin(0.32847985625267*x_60 - 7.45623970031738) - 6.27331101168679*std::sin(0.210639998316765*x_66 + 1.79599988460541) + 0.0600924585404138*std::sin(0.537039816379547*x_75 + 5.33615970611572) - 3.26193564278415*std::sin(0.287599951028824*x_80 - 7.48920011520386) - 4.02335467835472*std::sin(0.356879830360413*x_80 + 5.14264011383057) - 654.466851170195*std::sin(0.480559855699539*x_80 - 7.31775999069214) - 4.50909375229034*std::sin(0.483359843492508*x_80 - 1.12239992618561) + 0.0210107970747553*std::sin(0.528159856796265*x_80 - 7.26775979995728) - 1.34645903763253*std::sin(0.367679834365845*x_83 + 5.17600011825562) - 0.996017222969391*std::sin(0.782319843769073*x_88 - 7.20016002655029) + 0.190307113495604*std::sin(0.339359849691391*x_92 + 5.18760013580322) + 3.63693101670334*std::sin(0.344559848308563*x_92 + 1.98527979850769) - 9.68423718429677*std::sin(0.401919841766357*x_94 + 5.1908802986145) + 0.0401988808214071*std::sin(0.427519857883453*x_94 + 1.99663984775543) + 0.030233289837318*std::sin(0.359279841184616*x_95 - 4.23464012145996) + 0.148277533429061*std::sin(0.378079831600189*x_95 - 7.41408014297485) + 1.85702174630896*std::sin(0.395039826631546*x_96 - 4.21056032180786) + 0.173815746295203*std::sin(0.398399859666824*x_96 + 5.18368005752563) + 1.26879873462785*std::sin(0.449919849634171*x_96 - 7.36735963821411) + 2.0773897725866*std::sin(0.44735985994339*x_97 + 2.00095963478088) - 97.1579593790789*std::sin(0.477439850568771*x_98 - 1.12615978717804) + 4.82348165804938*std::sin(0.52511990070343*x_98 - 7.43271970748901) + 1.59621489696709*std::sin(0.418879866600037*x_99 + 5.21640014648438) - 324490.267395633 + 2.0818041842768e-6*std::exp(-4.01200008392334*x_74) - 3.9802536054777e-5*std::exp(-3.20415997505188*x_74) + 0.0513624468111868*std::exp(-2.78751993179321*x_74) + 0.00011575857998798*std::exp(-2.69967985153198*x_74) + 0.00837897180501559*std::exp(-2.53735995292664*x_74) + 5.22253040375676e-6*std::exp(-3.91295981407166*x_45) - 0.000817153602016872*std::exp(-4.45559978485107*x_111) - 4.66861510557727e-6*std::exp(-4.44000005722046*x_111) + 0.00179769864353044*std::exp(-3.17839980125427*x_111) + 0.0081020088163519*std::exp(-3.65016007423401*x_101));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (5256.99357960097*x_1 + 217.354485568229*x_10 + 135.301155588765*x_100 - 193.199011740942*x_101 + 485.635608957642*x_102 + 329.810105940711*x_103 - 166.373968520261*x_104 - 80.2996589507587*x_105 + 9.73303796240942*x_106 - 63.6448739291175*x_107 - 278.421166944299*x_108 + 118.600505559762*x_109 - 253.736199650656*x_11 + 397.453308247076*x_110 - 129.180438867626*x_111 + 16.8353119936539*x_112 + 310.563574063513*x_113 - 170.870077179865*x_114 + 482.653173330607*x_115 - 1927.52514266727*x_116 + 62.293153805999*x_117 + 333.133620421897*x_118 + 233.875773707301*x_119 + 126.556894317349*x_12 - 1356.94096870468*x_120 - 439.295501962762*x_13 - 160.827468730594*x_14 - 228.871184913747*x_15 - 17.1771995514803*x_16 + 343.15529681243*x_17 + 41.9773484550939*x_18 - 48.4272601036956*x_19 + 622.3010372677*x_2 - 1203.70008138074*x_20 - 714.031073203142*x_21 - 1094.03736212168*x_22 + 346.049927186686*x_23 + 190.610272393184*x_24 - 642.454520523431*x_25 + 28.6730758489709*x_26 + 1.23508673045615*x_27 - 19.9690277793558*x_28 - 581.275581166315*x_29 + 1081.44317310973*x_3 + 2508.1763066712*x_30 - 13673.8012468448*x_31 - 417.198598439197*x_32 - 135.187462166913*x_33 + 640.48547671919*x_34 + 975.531823322446*x_35 + 334.335032965451*x_36 + 1810.11651133357*x_37 + 33.7180782948575*x_38 + 100.530459130173*x_39 - 2.30738699632009*x_4 - 442.417056827961*x_40 + 12.6303650581581*x_41 + 64244.7339493622*x_42 - 402.750966086325*x_43 - 251.165686326417*x_44 + 368.116207391331*x_45 - 94.3670393383893*x_46 - 953.23400400906*x_47 - 456.81336108735*x_48 - 1589.56111847926*x_49 - 160.230767403015*x_5 - 1178.08670807146*x_50 + 420.204388386991*x_51 - 1098.67439399685*x_52 + 21.5986251692107*x_53 - 533.225044075309*x_54 - 364.441630993486*x_55 + 24.0544553520576*x_56 - 2123.06566889348*x_57 - 198.152891730547*x_58 + 224.757288200349*x_59 + 79.8608011480747*x_6 + 114.466028592258*x_60 + 239.306554813201*x_61 + 551.635268300074*x_62 - 274.025737639962*x_63 - 321.99706370741*x_64 + 231.309058292878*x_65 - 407.707219075984*x_66 + 528.413314751746*x_67 - 142.579843114724*x_68 + 508.98346511082*x_69 - 283.54351881889*x_7 + 227.907062438973*x_70 + 109.048166619873*x_72 - 801.582078012203*x_73 - 286.497322025841*x_74 - 13.4268979902822*x_75 - 823.781722885563*x_76 + 186.533573588205*x_77 + 278.034778359203*x_78 - 420.993340548909*x_79 + 1714.16687117866*x_8 + 9.41627144802949*x_80 + 448.045883463564*x_81 - 110.312296063035*x_82 + 14.4961766188498*x_83 - 1098.7776223017*x_84 - 411.466739015306*x_85 - 391.261061794316*x_86 - 24.6759136398563*x_87 - 950.509112263262*x_88 + 206.034226611668*x_89 + 884.92402313496*x_9 - 2395.91357772308*x_90 - 315.470301640168*x_91 - 227.215102789402*x_92 - 246.637625742697*x_93 - 162.844243309329*x_94 - 193.021419002241*x_95 - 50.6914528260995*x_96 - 1033.5283492175*x_97 - 338.135776930271*x_98 - 136.318061916992*x_99 + 3.2202584176648*std::pow(-0.694239854812622*x_108 - 0.926799833774567, 2) + 0.095366630694512*std::pow(-3.91479992866516*x_109 - 5.28447961807251, 2) - 0.000131470141653262*std::pow(-7.3600001335144*x_14 - 9.39999961853027, 2) + 15.7705184317602*std::pow(-1.35455989837646*x_15 - 1.93879985809326, 2) + 0.0268314467845346*std::pow(-6.25352001190186*x_22 - 9.28151988983154, 2) - 0.0316035804457659*std::pow(-7.00447988510132*x_66 - 9.6115198135376, 2) + 0.000179849452710674*std::pow(-6.60400009155273*x_66 - 9.97791957855225, 2) + 1.83688989552502*std::pow(-3.48359990119934*x_78 - 4.50279951095581, 2) + 0.0023805834060239*std::pow(-5.99087953567505*x_80 - 9.3931999206543, 2) + 3.88458901784126*std::pow(-6.52103996276855*x_87 - 9.17527961730957, 2) - 0.744760809907926*std::exp(1.00759983062744*x_38) - 0.00136604301844328*std::exp(1.10831987857819*x_38) - 5.7192867545784*std::exp(2.49903988838196*x_71) - 0.0693336808214184*std::exp(2.50559997558594*x_71) - 0.266328827363511*std::exp(2.54895973205566*x_71) + 0.028208773444056*std::exp(2.56287980079651*x_71) + 0.597983922648536*std::exp(2.58863997459412*x_71) - 0.000251919150427317*std::exp(2.59767985343933*x_71) - 0.00104231527901614*std::exp(2.62127995491028*x_71) + 29.6749273424749*std::exp(2.63247990608215*x_71) + 0.00235550079499663*std::exp(2.64488005638123*x_71) + 0.000107497400071544*std::exp(2.67615985870361*x_71) - 0.0036558052679896*std::exp(1.12335991859436*x_89) + 0.0878613986734757*std::exp(2.01415991783142*x_89) - 0.123777065938502*std::sin(0.40191987156868*x_103 - 4.19952011108398) - 344.678853464703*std::sin(0.337119847536087*x_106 + 1.95119988918304) - 0.00525847321047736*std::sin(0.51911985874176*x_106 + 2.13583993911743) - 0.0101610386175822*std::sin(0.509919822216034*x_107 + 8.34679985046387) - 0.128903497233874*std::sin(0.350639849901199*x_114 - 7.44543981552124) - 1.92123656149266*std::sin(0.315279841423035*x_119 - 4.26600027084351) + 5.98999703076013*std::sin(0.341759830713272*x_119 + 5.15256023406982) + 0.136781034246353*std::sin(0.31455984711647*x_120 + 8.32087993621826) - 0.00523522023716833*std::sin(0.443679869174957*x_14 + 8.23079967498779) + 24.7927459013499*std::sin(0.332719832658768*x_16 - 4.25744009017944) + 0.0144324735278838*std::sin(0.33791983127594*x_16 - 4.26087999343872) - 6.18741396911055*std::sin(0.48159983754158*x_16 + 8.26519966125488) - 1086.69884855322*std::sin(0.326719850301743*x_26 + 8.32287979125977) + 0.0201597519388292*std::sin(0.33247983455658*x_26 + 5.14400005340576) - 0.0225130637180961*std::sin(0.30431991815567*x_28 + 5.12759971618652) + 21.2923511477414*std::sin(0.32151985168457*x_28 - 4.2868800163269) - 3516.34759222207*std::sin(0.328239858150482*x_28 - 4.28272008895874) - 0.182692647390436*std::sin(0.338879853487015*x_28 - 4.26279973983765) + 0.0150168797817174*std::sin(0.351759850978851*x_28 - 4.26024007797241) - 463.56079500215*std::sin(0.371999859809875*x_34 + 2.00143980979919) + 0.0423377024605359*std::sin(0.343839854001999*x_36 - 1.24111986160278) - 235.13012383154*std::sin(0.380959838628769*x_36 + 5.18408012390137) - 0.00551975190184874*std::sin(0.402399837970734*x_36 - 7.40079975128174) + 6.1384437318952*std::sin(0.403119832277298*x_36 + 2.00967979431152) + 11132.5026002549*std::sin(0.200159981846809*x_38 - 1.38711988925934) + 0.162196050890981*std::sin(0.866239905357361*x_38 - 0.756079852581024) - 29.2083214027165*std::sin(0.382639855146408*x_40 - 7.4047999382019) - 2701.31131622384*std::sin(0.421359837055206*x_41 + 2.02663993835449) - 19.0505779139436*std::sin(0.261839985847473*x_53 - 7.5128002166748) - 10.212423342871*std::sin(0.332879841327667*x_53 - 7.45375967025757) - 2483.51268284395*std::sin(0.410319864749908*x_53 + 5.19792032241821) - 0.0886296738366603*std::sin(0.499439835548401*x_53 - 7.30983972549438) - 0.117990533337314*std::sin(0.453039854764938*x_59 - 1.14135980606079) - 4055.96603402879*std::sin(0.32847985625267*x_60 - 7.45623970031738) + 17.1142026067583*std::sin(0.210639998316765*x_66 + 1.79599988460541) + 0.485558303711964*std::sin(0.537039816379547*x_75 + 5.33615970611572) - 0.236574444381932*std::sin(0.287599951028824*x_80 - 7.48920011520386) + 10.3902983935441*std::sin(0.356879830360413*x_80 + 5.14264011383057) + 2105.98564749364*std::sin(0.480559855699539*x_80 - 7.31775999069214) + 14.3495160785929*std::sin(0.483359843492508*x_80 - 1.12239992618561) - 0.0508811936543747*std::sin(0.528159856796265*x_80 - 7.26775979995728) - 0.0976529991986804*std::sin(0.367679834365845*x_83 + 5.17600011825562) - 0.072236931357021*std::sin(0.782319843769073*x_88 - 7.20016002655029) + 1.53771706895801*std::sin(0.339359849691391*x_92 + 5.18760013580322) - 9.39236073408682*std::sin(0.344559848308563*x_92 + 1.98527979850769) + 30.8186355882241*std::sin(0.401919841766357*x_94 + 5.1908802986145) - 0.0973483791445816*std::sin(0.427519857883453*x_94 + 1.99663984775543) - 0.0124655555127758*std::sin(0.359279841184616*x_95 - 4.23464012145996) + 1.19811020149872*std::sin(0.378079831600189*x_95 - 7.41408014297485) - 5.06613594516209*std::sin(0.395039826631546*x_96 - 4.21056032180786) + 1.40446373770459*std::sin(0.398399859666824*x_96 + 5.18368005752563) + 0.092020624729703*std::sin(0.449919849634171*x_96 - 7.36735963821411) - 5.66732135470755*std::sin(0.44735985994339*x_97 + 2.00095963478088) - 55.548939494645*std::sin(0.477439850568771*x_98 - 1.12615978717804) - 15.3500085403682*std::sin(0.52511990070343*x_98 - 7.43271970748901) + 0.115766739052473*std::sin(0.418879866600037*x_99 + 5.21640014648438) - 179173.174802484 - 8.58353350411751e-7*std::exp(-4.01200008392334*x_74) - 0.000321611935334519*std::exp(-3.20415997505188*x_74) - 0.163453300561479*std::exp(-2.78751993179321*x_74) + 0.00011750287263098*std::exp(-2.69967985153198*x_74) + 0.000607691510912684*std::exp(-2.53735995292664*x_74) - 2.15331321915328e-6*std::exp(-3.91295981407166*x_45) + 0.00260046905098508*std::exp(-4.45559978485107*x_111) + 1.13058399659682e-5*std::exp(-4.44000005722046*x_111) - 0.00464255001639302*std::exp(-3.17839980125427*x_111) - 0.0221030680842181*std::exp(-3.65016007423401*x_101));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-5406.17121277148*x_1 - 215.369221658919*x_10 + 75.2545154874676*x_100 - 23.0536427408005*x_101 - 382.680197220682*x_102 - 210.314299646448*x_103 + 191.977437981441*x_104 + 14.0908043710415*x_105 + 5.49399450010546*x_106 + 123.040840897329*x_107 + 303.108267735728*x_108 + 101.63589957424*x_109 + 271.128716161706*x_11 - 257.324881330761*x_110 + 68.866645890115*x_111 + 0.619593435926801*x_112 - 686.480919823469*x_113 + 289.787593281956*x_114 - 442.093617100472*x_115 + 1151.57977328161*x_116 + 12.6494619853647*x_117 - 248.371849331446*x_118 - 190.519097133769*x_119 - 1175.50431056145*x_12 + 1389.38589324007*x_120 + 447.931160704916*x_13 + 176.576144171933*x_14 + 212.882627862366*x_15 + 68.0162798624027*x_16 - 262.939677287316*x_17 + 121.987504980945*x_18 + 26.2587972534104*x_19 - 454.147926778765*x_2 + 1036.57576898774*x_20 + 218.319345775171*x_21 + 1013.84010733845*x_22 - 405.771572727525*x_23 - 155.39116212551*x_24 + 774.423557806469*x_25 + 4.68148870241472*x_26 + 171.580208688644*x_27 - 11.4696181814849*x_28 + 495.599808171473*x_29 - 1293.93622920147*x_3 - 2499.6097763195*x_30 + 13130.7268180579*x_31 + 383.020157116035*x_32 + 1.5308877603534*x_33 - 602.548619011809*x_34 - 835.091316941003*x_35 - 333.12646696885*x_36 - 2934.38052225779*x_37 + 18.7528315460291*x_38 + 32.155315114235*x_39 - 43.7003703658103*x_4 + 382.329920189726*x_40 + 28.0409189691305*x_41 + 11522.7016397084*x_42 + 310.237042443666*x_43 + 157.92585374746*x_44 - 313.645858409463*x_45 + 139.730238265562*x_46 + 1304.68542617021*x_47 + 302.051758164327*x_48 + 2000.16853705607*x_49 + 74.6429024507374*x_5 + 2151.52513988993*x_50 - 638.516040196351*x_51 + 433.648107836865*x_52 + 12.0547315216226*x_53 + 54.9783095617656*x_54 + 466.294278389586*x_55 + 92.9099270474499*x_56 + 3719.93516670939*x_57 + 118.303796443563*x_58 - 305.100451560315*x_59 - 54.2002125094646*x_6 + 32.9587616569186*x_60 - 245.398887336466*x_61 - 449.127622394048*x_62 + 164.596621104531*x_63 + 375.481443932799*x_64 - 198.262601750538*x_65 + 471.753279423153*x_66 - 468.08333619542*x_67 + 94.9021112272692*x_68 - 381.445848888614*x_69 + 297.459509939721*x_7 - 284.405750594776*x_70 - 147.643979100167*x_72 + 738.319540828748*x_73 + 184.101878227543*x_74 - 102.308776718932*x_75 + 801.650987860171*x_76 - 268.559754366388*x_77 - 288.225063961778*x_78 + 356.922877213671*x_79 - 1369.62500189365*x_8 + 5.38862582030923*x_80 - 128.413412907725*x_81 + 57.8854339259675*x_82 + 9.57252546562014*x_83 + 881.149183937629*x_84 + 385.739607745936*x_85 + 292.046180723738*x_86 - 21.271227533164*x_87 + 808.808421042368*x_88 - 146.195577296947*x_89 - 1336.24441927609*x_9 + 2173.45579391017*x_90 + 188.108797207305*x_91 + 266.016685148592*x_92 + 278.373302067957*x_93 + 111.353007361373*x_94 + 206.679942048312*x_95 + 115.513455344023*x_96 + 1097.65187485144*x_97 + 341.507118825321*x_98 + 209.693257747076*x_99 - 1.60759788438016*std::pow(-0.694239854812622*x_108 - 0.926799833774567, 2) + 0.273114148429835*std::pow(-3.91479992866516*x_109 - 5.28447961807251, 2) - 9.23870818218725e-6*std::pow(-7.3600001335144*x_14 - 9.39999961853027, 2) + 8.99895080254703*std::pow(-1.35455989837646*x_15 - 1.93879985809326, 2) + 0.076840795216647*std::pow(-6.25352001190186*x_22 - 9.28151988983154, 2) + 0.0157769478327438*std::pow(-7.00447988510132*x_66 - 9.6115198135376, 2) + 0.00341417754565145*std::pow(-6.60400009155273*x_66 - 9.97791957855225, 2) + 1.0481635002078*std::pow(-3.48359990119934*x_78 - 4.50279951095581, 2) - 0.00568370271160166*std::pow(-5.99087953567505*x_80 - 9.3931999206543, 2) - 3.78958008189716*std::pow(-6.52103996276855*x_87 - 9.17527961730957, 2) - 0.0416750413097477*std::exp(1.00759983062744*x_38) - 0.00252952708018915*std::exp(1.10831987857819*x_38) - 3.26353127532318*std::exp(2.49903988838196*x_71) - 0.00387974766387976*std::exp(2.50559997558594*x_71) + 0.132955062572123*std::exp(2.54895973205566*x_71) - 0.0673491555512121*std::exp(2.56287980079651*x_71) + 1.71252636922912*std::exp(2.58863997459412*x_71) + 0.00314349157237501*std::exp(2.59767985343933*x_71) - 7.32458836323637e-5*std::exp(2.62127995491028*x_71) - 28.9491405840616*std::exp(2.63247990608215*x_71) + 0.0447157208533688*std::exp(2.64488005638123*x_71) + 0.00019905492056961*std::exp(2.67615985870361*x_71) - 0.000256901815249704*std::exp(1.12335991859436*x_89) + 0.00491651463199573*std::exp(2.01415991783142*x_89) - 2.34972568903887*std::sin(0.40191987156868*x_103 - 4.19952011108398) + 336.24872843482*std::sin(0.337119847536087*x_106 + 1.95119988918304) + 0.0656161557890951*std::sin(0.51911985874176*x_106 + 2.13583993911743) + 0.126791231261166*std::sin(0.509919822216034*x_107 + 8.34679985046387) - 0.00905834419611423*std::sin(0.350639849901199*x_114 - 7.44543981552124) + 4.58700057580525*std::sin(0.315279841423035*x_119 - 4.26600027084351) + 0.335185968946266*std::sin(0.341759830713272*x_119 + 5.15256023406982) + 0.00961191677721492*std::sin(0.31455984711647*x_120 + 8.32087993621826) - 0.00969415397749528*std::sin(0.443679869174957*x_14 + 8.23079967498779) + 71.002295402202*std::sin(0.332719832658768*x_16 - 4.25744009017944) - 0.180090949125829*std::sin(0.33791983127594*x_16 - 4.26087999343872) - 0.34623295067724*std::sin(0.48159983754158*x_16 + 8.26519966125488) + 1060.12046385962*std::sin(0.326719850301743*x_26 + 8.32287979125977) - 0.251556938856715*std::sin(0.33247983455658*x_26 + 5.14400005340576) - 0.0416878557732716*std::sin(0.30431991815567*x_28 + 5.12759971618652) + 60.9777477660123*std::sin(0.32151985168457*x_28 - 4.2868800163269) + 3430.34507262161*std::sin(0.328239858150482*x_28 - 4.28272008895874) - 3.46815141817234*std::sin(0.338879853487015*x_28 - 4.26279973983765) - 0.18738327339198*std::sin(0.351759850978851*x_28 - 4.26024007797241) - 264.516401681054*std::sin(0.371999859809875*x_34 + 2.00143980979919) + 0.00297516738948046*std::sin(0.343839854001999*x_36 - 1.24111986160278) - 134.169616916053*std::sin(0.380959838628769*x_36 + 5.18408012390137) - 0.0102210265146432*std::sin(0.402399837970734*x_36 - 7.40079975128174) + 0.343492692822976*std::sin(0.403119832277298*x_36 + 2.00967979431152) - 10860.2248324943*std::sin(0.200159981846809*x_38 - 1.38711988925934) - 0.387247147874513*std::sin(0.866239905357361*x_38 - 0.756079852581024) + 14.5812011345825*std::sin(0.382639855146408*x_40 - 7.4047999382019) + 2635.24288205244*std::sin(0.421359837055206*x_41 + 2.02663993835449) + 9.51031401165737*std::sin(0.261839985847473*x_53 - 7.5128002166748) - 29.2466797283392*std::sin(0.332879841327667*x_53 - 7.45375967025757) + 2422.77114845847*std::sin(0.410319864749908*x_53 + 5.19792032241821) - 1.68250410402043*std::sin(0.499439835548401*x_53 - 7.30983972549438) - 0.00829146521070195*std::sin(0.453039854764938*x_59 - 1.14135980606079) + 3956.76557412207*std::sin(0.32847985625267*x_60 - 7.45623970031738) + 0.957670021208847*std::sin(0.210639998316765*x_66 + 1.79599988460541) - 1.15928265334665*std::sin(0.537039816379547*x_75 + 5.33615970611572) - 4.4910181471785*std::sin(0.287599951028824*x_80 - 7.48920011520386) + 29.75608425105*std::sin(0.356879830360413*x_80 + 5.14264011383057) - 2054.47763607649*std::sin(0.480559855699539*x_80 - 7.31775999069214) - 7.1634784225029*std::sin(0.483359843492508*x_80 - 1.12239992618561) - 0.00357553809726546*std::sin(0.528159856796265*x_80 - 7.26775979995728) - 1.85379867497293*std::sin(0.367679834365845*x_83 + 5.17600011825562) - 1.37131197948465*std::sin(0.782319843769073*x_88 - 7.20016002655029) - 3.67133814862231*std::sin(0.339359849691391*x_92 + 5.18760013580322) - 26.8981569858854*std::sin(0.344559848308563*x_92 + 1.98527979850769) - 15.385092419707*std::sin(0.401919841766357*x_94 + 5.1908802986145) - 0.00684089372397353*std::sin(0.427519857883453*x_94 + 1.99663984775543) + 0.155547399365692*std::sin(0.359279841184616*x_95 - 4.23464012145996) - 2.86051821743545*std::sin(0.378079831600189*x_95 - 7.41408014297485) - 0.283488902727749*std::sin(0.395039826631546*x_96 - 4.21056032180786) - 3.35319247128182*std::sin(0.398399859666824*x_96 + 5.18368005752563) + 1.74687632324568*std::sin(0.449919849634171*x_96 - 7.36735963821411) - 0.317129806551249*std::sin(0.44735985994339*x_97 + 2.00095963478088) - 31.6972568662843*std::sin(0.477439850568771*x_98 - 1.12615978717804) + 7.6629382037631*std::sin(0.52511990070343*x_98 - 7.43271970748901) + 2.19766140540936*std::sin(0.418879866600037*x_99 + 5.21640014648438) - 108785.608542486 + 1.07106844341223e-5*std::exp(-4.01200008392334*x_74) + 0.000767856578483563*std::exp(-3.20415997505188*x_74) + 0.0815981657671238*std::exp(-2.78751993179321*x_74) + 0.000217582238851303*std::exp(-2.69967985153198*x_74) + 0.0115361302465501*std::exp(-2.53735995292664*x_74) + 2.68694219776872e-5*std::exp(-3.91295981407166*x_45) - 0.00129819039423278*std::exp(-4.45559978485107*x_111) + 7.94487287277509e-7*std::exp(-4.44000005722046*x_111) - 0.013295490100009*std::exp(-3.17839980125427*x_111) - 0.00123683505257995*std::exp(-3.65016007423401*x_101));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-514.368911421157*x_1 - 11.1135819297269*x_10 + 209.963098674071*x_100 - 167.772862136001*x_101 + 51.7154910015543*x_102 + 98.9167119856755*x_103 + 41.6320191418908*x_104 - 49.3944593600468*x_105 + 15.8248458308035*x_106 + 46.3997058070768*x_107 + 77.2377842840669*x_108 + 219.396165456638*x_109 + 65.423347218321*x_11 + 109.155925285922*x_110 - 47.4123117339183*x_111 + 31.3702084826704*x_112 - 458.953748081174*x_113 + 130.1048153385*x_114 - 34.0182782386049*x_115 - 555.291365896643*x_116 + 43.8022477661872*x_117 + 31.6183201700852*x_118 + 11.3407304671046*x_119 - 1016.62162065816*x_12 + 212.385620490384*x_120 + 101.605012149346*x_13 + 21.7031847922995*x_14 + 29.5595769368808*x_15 + 55.4880463842061*x_16 + 45.1248486269526*x_17 + 185.583652087458*x_18 - 18.5493278618806*x_19 + 100.70430128458*x_2 - 27.9212393674551*x_20 - 364.21747639288*x_21 + 59.404697174143*x_22 - 120.328175464471*x_23 + 22.2910016367652*x_24 + 237.155416165669*x_25 + 46.1591692826236*x_26 + 161.153356598057*x_27 - 31.2664370746631*x_28 - 5.33462564381803*x_29 - 379.113674313703*x_3 - 400.075341055801*x_30 + 1603.32843902408*x_31 + 28.2320239835965*x_32 - 100.566981162178*x_33 - 72.7406127754643*x_34 + 8.21406895009395*x_35 - 35.1238880831527*x_36 - 1448.48631505109*x_37 + 51.6635159504759*x_38 + 115.285288030863*x_39 - 56.7913565533674*x_4 - 2.88919113147936*x_40 + 11.0129699899921*x_41 + 91002.9716777598*x_42 - 43.2262776032554*x_43 - 30.1218928704015*x_44 - 6.64824231166257*x_45 + 71.7175553584319*x_46 + 500.00832897214*x_47 - 170.020357503364*x_48 + 627.381314306479*x_49 - 54.5008473819527*x_5 + 1252.54875101084*x_50 - 326.206055712653*x_51 - 496.489303344219*x_52 + 32.9452051271091*x_53 - 504.786578491304*x_54 + 155.916055713565*x_55 + 140.021350824198*x_56 + 1904.44229378875*x_57 - 37.5640958951852*x_58 - 93.521896469277*x_59 + 15.8821524121826*x_6 + 199.953862713154*x_60 - 45.5434428699605*x_61 + 23.7223770094494*x_62 - 46.5038379714032*x_63 + 96.6457038017611*x_64 - 1.96025934162847*x_65 + 118.343842625682*x_66 - 15.8418537419884*x_67 - 36.9714872555136*x_68 + 77.7330490962828*x_69 + 53.1750422332839*x_7 - 100.829684212953*x_70 - 57.7394778512339*x_72 + 23.3665689671515*x_73 - 47.5520910730875*x_74 - 111.913596796382*x_75 + 81.7227718862121*x_76 - 133.375227652788*x_77 - 21.4668517392276*x_78 - 29.719994887643*x_79 + 30.7757376108044*x_8 + 14.6352916222615*x_80 + 244.598935456447*x_81 - 72.909358228166*x_82 + 35.48260775627*x_83 - 214.615010061713*x_84 + 10.5010659651784*x_85 - 54.9556863333266*x_86 - 36.2718666941393*x_87 - 52.4361170815277*x_88 + 59.6085832304405*x_89 - 634.139050803943*x_9 + 81.1387837742011*x_90 - 39.519589472334*x_91 + 71.1051345207515*x_92 + 66.2265232593481*x_93 - 19.7774471974744*x_94 + 64.5848701515764*x_95 + 72.0347373389788*x_96 + 210.623688666745*x_97 + 31.7441034514656*x_98 + 110.313548012653*x_99 + 0.813499745049784*std::pow(-0.694239854812622*x_108 - 0.926799833774567, 2) - 0.122286401949908*std::pow(-3.91479992866516*x_109 - 5.28447961807251, 2) - 1.5744906580322e-5*std::pow(-7.3600001335144*x_14 - 9.39999961853027, 2) + 24.3418328207546*std::pow(-1.35455989837646*x_15 - 1.93879985809326, 2) - 0.0344053371970495*std::pow(-6.25352001190186*x_22 - 9.28151988983154, 2) - 0.00798367748819811*std::pow(-7.00447988510132*x_66 - 9.6115198135376, 2) + 0.00170474086926783*std::pow(-6.60400009155273*x_66 - 9.97791957855225, 2) + 2.83524393573236*std::pow(-3.48359990119934*x_78 - 4.50279951095581, 2) + 0.00153474880659797*std::pow(-5.99087953567505*x_80 - 9.3931999206543, 2) - 0.414980129757892*std::pow(-6.52103996276855*x_87 - 9.17527961730957, 2) - 0.298865334306854*std::exp(1.00759983062744*x_38) - 0.00270448987292371*std::exp(1.10831987857819*x_38) - 8.82773274932632*std::exp(2.49903988838196*x_71) - 0.0278229378100328*std::exp(2.50559997558594*x_71) - 0.067279828218487*std::exp(2.54895973205566*x_71) + 0.018186038459861*std::exp(2.56287980079651*x_71) - 0.766780809933656*std::exp(2.58863997459412*x_71) + 0.000514511052007518*std::exp(2.59767985343933*x_71) - 0.000124828014094896*std::exp(2.62127995491028*x_71) - 3.17009216227967*std::exp(2.63247990608215*x_71) + 0.0223271097704337*std::exp(2.64488005638123*x_71) + 0.000212823187801527*std::exp(2.67615985870361*x_71) - 0.000437820418358977*std::exp(1.12335991859436*x_89) + 0.0352579323963923*std::exp(2.01415991783142*x_89) - 1.17324695629113*std::sin(0.40191987156868*x_103 - 4.19952011108398) + 36.8211089200554*std::sin(0.337119847536087*x_106 + 1.95119988918304) + 0.0107397257369549*std::sin(0.51911985874176*x_106 + 2.13583993911743) + 0.0207525575556812*std::sin(0.509919822216034*x_107 + 8.34679985046387) - 0.0154375244165851*std::sin(0.350639849901199*x_114 - 7.44543981552124) - 1.23861046518344*std::sin(0.315279841423035*x_119 - 4.26600027084351) + 2.40372807118638*std::sin(0.341759830713272*x_119 + 5.15256023406982) + 0.0163809407907123*std::sin(0.31455984711647*x_120 + 8.32087993621826) - 0.0103646809967097*std::sin(0.443679869174957*x_14 + 8.23079967498779) - 31.7911586962344*std::sin(0.332719832658768*x_16 - 4.25744009017944) - 0.029476390045403*std::sin(0.33791983127594*x_16 - 4.26087999343872) - 2.48294958565521*std::sin(0.48159983754158*x_16 + 8.26519966125488) + 116.089096455041*std::sin(0.326719850301743*x_26 + 8.32287979125977) - 0.0411735874809971*std::sin(0.33247983455658*x_26 + 5.14400005340576) - 0.0445713290226118*std::sin(0.30431991815567*x_28 + 5.12759971618652) - 27.3026843031913*std::sin(0.32151985168457*x_28 - 4.2868800163269) + 375.641895035032*std::sin(0.328239858150482*x_28 - 4.28272008895874) - 1.73169068811255*std::sin(0.338879853487015*x_28 - 4.26279973983765) - 0.0306699613794983*std::sin(0.351759850978851*x_28 - 4.26024007797241) - 715.507192932465*std::sin(0.371999859809875*x_34 + 2.00143980979919) + 0.0050703769059951*std::sin(0.343839854001999*x_36 - 1.24111986160278) - 362.92390704824*std::sin(0.380959838628769*x_36 + 5.18408012390137) - 0.0109279963500806*std::sin(0.402399837970734*x_36 - 7.40079975128174) + 2.46329830148215*std::sin(0.403119832277298*x_36 + 2.00967979431152) - 1189.2551187181*std::sin(0.200159981846809*x_38 - 1.38711988925934) + 0.104566886801755*std::sin(0.866239905357361*x_38 - 0.756079852581024) - 7.37858858907121*std::sin(0.382639855146408*x_40 - 7.4047999382019) + 288.573775854926*std::sin(0.421359837055206*x_41 + 2.02663993835449) - 4.81254553703873*std::sin(0.261839985847473*x_53 - 7.5128002166748) + 13.09515180199*std::sin(0.332879841327667*x_53 - 7.45375967025757) + 265.30693740021*std::sin(0.410319864749908*x_53 + 5.19792032241821) - 0.840095006918337*std::sin(0.499439835548401*x_53 - 7.30983972549438) - 0.0141305843395072*std::sin(0.453039854764938*x_59 - 1.14135980606079) + 433.287872504523*std::sin(0.32847985625267*x_60 - 7.45623970031738) + 6.86776454321807*std::sin(0.210639998316765*x_66 + 1.79599988460541) + 0.313036722540353*std::sin(0.537039816379547*x_75 + 5.33615970611572) - 2.24242063505748*std::sin(0.287599951028824*x_80 - 7.48920011520386) - 13.3232368227678*std::sin(0.356879830360413*x_80 + 5.14264011383057) - 224.976746124571*std::sin(0.480559855699539*x_80 - 7.31775999069214) + 3.62496612305671*std::sin(0.483359843492508*x_80 - 1.12239992618561) - 0.00609354816773731*std::sin(0.528159856796265*x_80 - 7.26775979995728) - 0.925624494439674*std::sin(0.367679834365845*x_83 + 5.17600011825562) - 0.684712949073657*std::sin(0.782319843769073*x_88 - 7.20016002655029) + 0.991357593477631*std::sin(0.339359849691391*x_92 + 5.18760013580322) + 12.0436046825042*std::sin(0.344559848308563*x_92 + 1.98527979850769) + 7.78538519029256*std::sin(0.401919841766357*x_94 + 5.1908802986145) - 0.011658473293652*std::sin(0.427519857883453*x_94 + 1.99663984775543) + 0.025459224000467*std::sin(0.359279841184616*x_95 - 4.23464012145996) + 0.77241494554237*std::sin(0.378079831600189*x_95 - 7.41408014297485) - 2.03299152258296*std::sin(0.395039826631546*x_96 - 4.21056032180786) + 0.905449916141526*std::sin(0.398399859666824*x_96 + 5.18368005752563) + 0.872236848252432*std::sin(0.449919849634171*x_96 - 7.36735963821411) - 2.27424143263988*std::sin(0.44735985994339*x_97 + 2.00095963478088) - 85.7399206246605*std::sin(0.477439850568771*x_98 - 1.12615978717804) - 3.87770992712962*std::sin(0.52511990070343*x_98 - 7.43271970748901) + 1.09731938791106*std::sin(0.418879866600037*x_99 + 5.21640014648438) - 282376.7647083 + 1.75307150951172e-6*std::exp(-4.01200008392334*x_74) - 0.000207341415845088*std::exp(-3.20415997505188*x_74) - 0.0412914744993455*std::exp(-2.78751993179321*x_74) + 0.00023263200703011*std::exp(-2.69967985153198*x_74) + 0.00576013181550532*std::exp(-2.53735995292664*x_74) + 4.39785323112186e-6*std::exp(-3.91295981407166*x_45) + 0.000656928927933764*std::exp(-4.45559978485107*x_111) + 1.35399104190303e-6*std::exp(-4.44000005722046*x_111) + 0.00595303339588217*std::exp(-3.17839980125427*x_111) - 0.00886974817191798*std::exp(-3.65016007423401*x_101));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1702.61445256792*x_1 + 58.4476501862748*x_10 - 63.1274488209839*x_100 + 32.3929723228345*x_101 + 88.1729644717194*x_102 + 34.1367238776991*x_103 - 62.7534280163504*x_104 + 14.6754870580159*x_105 - 3.06742770894551*x_106 - 51.6006839805584*x_107 - 85.10059156528*x_108 - 66.6813437927725*x_109 - 77.683518619188*x_11 + 50.6173656779533*x_110 - 8.09792381007762*x_111 - 3.41517718915685*x_112 + 259.415522836923*x_113 - 101.713251693785*x_114 + 109.410567974825*x_115 - 140.315685766164*x_116 - 17.2390164130236*x_117 + 48.8815412482452*x_118 + 38.0683624449717*x_119 + 616.650936948492*x_12 - 400.58482550503*x_120 - 120.42969734666*x_13 - 59.8173246132228*x_14 - 55.8159581168012*x_15 - 35.0428252174973*x_16 + 53.4816341782565*x_17 - 66.7739410467163*x_18 - 8.28651181724092*x_19 + 93.998132666519*x_2 - 264.579539529395*x_20 + 65.4478623585711*x_21 - 261.905346041704*x_22 + 123.578918243783*x_23 + 35.6645040647398*x_24 - 236.687864257569*x_25 - 10.5585036698771*x_26 - 91.4369262465702*x_27 + 9.89808296343257*x_28 - 122.116402071676*x_29 + 381.980494122992*x_3 + 644.469361558122*x_30 - 3696.082932916*x_31 - 94.1055195017054*x_32 + 37.5012120297529*x_33 + 149.027649028861*x_34 + 199.417518990499*x_35 + 97.0005014284665*x_36 + 1006.39727552172*x_37 - 13.9506153116898*x_38 - 38.373177088611*x_39 + 20.1522005315429*x_4 - 93.3859891803876*x_40 - 15.9978304289917*x_41 - 7956.95352439483*x_42 - 67.5249975358746*x_43 - 21.4517611668711*x_44 + 77.6359155285793*x_45 - 47.6379540762852*x_46 - 413.405594014903*x_47 - 42.4209246176218*x_48 - 659.40285877399*x_49 - 0.426318474826667*x_5 - 740.956492579386*x_50 + 214.187776555086*x_51 + 53.6437041867781*x_52 - 9.82565876599311*x_53 + 51.9104418559069*x_54 - 154.105479122143*x_55 - 46.7452903308205*x_56 - 1394.27376246619*x_57 - 12.2697687108089*x_58 + 104.791802899976*x_59 + 12.6245009513598*x_6 - 36.1241989770286*x_60 + 65.3176692573921*x_61 + 98.641180492412*x_62 - 11.6768991341948*x_63 - 117.354263927925*x_64 + 46.8871768513595*x_65 - 144.101753735174*x_66 + 117.319470884075*x_67 - 18.9084085757098*x_68 + 85.8854501131601*x_69 - 88.3460790076198*x_7 + 88.0749666252972*x_70 + 57.5712122188957*x_72 - 194.547474780018*x_73 - 26.3913210446439*x_74 + 50.0677556751696*x_75 - 212.342596612158*x_76 + 83.1038716570907*x_77 + 81.0115508295194*x_78 - 83.3900884253701*x_79 + 291.828854658823*x_8 - 4.40849491283313*x_80 - 28.93285286461*x_81 - 19.402623729822*x_82 - 3.84245697443734*x_83 - 240.389911744908*x_84 - 109.514597282352*x_85 - 66.1225833939532*x_86 + 12.8645550292796*x_87 - 198.413851189736*x_88 + 33.0119067198254*x_89 + 494.910776175014*x_9 - 582.386127854651*x_90 - 9.12941841202028*x_91 - 78.6108847661162*x_92 - 78.7036970202202*x_93 - 18.9557761950888*x_94 - 57.2080867014998*x_95 - 51.3090074235465*x_96 - 337.825962413163*x_97 - 98.0001056441562*x_98 - 77.4696452054222*x_99 - 3.25950971709057*std::pow(-0.694239854812622*x_108 - 0.926799833774567, 2) - 0.243366285856331*std::pow(-3.91479992866516*x_109 - 5.28447961807251, 2) - 0.000233894180992798*std::pow(-7.3600001335144*x_14 - 9.39999961853027, 2) - 7.28488336607619*std::pow(-1.35455989837646*x_15 - 1.93879985809326, 2) - 0.0684712199702338*std::pow(-6.25352001190186*x_22 - 9.28151988983154, 2) + 0.0319887922636121*std::pow(-7.00447988510132*x_66 - 9.6115198135376, 2) - 0.0061671522063743*std::pow(-6.60400009155273*x_66 - 9.97791957855225, 2) - 0.848515456427522*std::pow(-3.48359990119934*x_78 - 4.50279951095581, 2) - 0.00169484693670615*std::pow(-5.99087953567505*x_80 - 9.3931999206543, 2) + 1.03266418442516*std::pow(-6.52103996276855*x_87 - 9.17527961730957, 2) - 0.0124703928386968*std::exp(1.00759983062744*x_38) - 0.00178636013112234*std::exp(1.10831987857819*x_38) + 2.64191295451267*std::exp(2.49903988838196*x_71) - 0.00116093412179246*std::exp(2.50559997558594*x_71) + 0.269575073842122*std::exp(2.54895973205566*x_71) - 0.020083124640337*std::exp(2.56287980079651*x_71) - 1.52599630706203*std::exp(2.58863997459412*x_71) + 0.00110119469253263*std::exp(2.59767985343933*x_71) - 0.00185434864111376*std::exp(2.62127995491028*x_71) + 7.88866840256433*std::exp(2.63247990608215*x_71) - 0.0807716215203014*std::exp(2.64488005638123*x_71) + 0.000140573222874011*std::exp(2.67615985870361*x_71) - 0.0065039222463207*std::exp(1.12335991859436*x_89) + 0.00147116516100122*std::exp(2.01415991783142*x_89) + 4.24439437427248*std::sin(0.40191987156868*x_103 - 4.19952011108398) - 91.6280990001688*std::sin(0.337119847536087*x_106 + 1.95119988918304) + 0.0229859571230706*std::sin(0.51911985874176*x_106 + 2.13583993911743) + 0.0444161620000734*std::sin(0.509919822216034*x_107 + 8.34679985046387) - 0.229327948791149*std::sin(0.350639849901199*x_114 - 7.44543981552124) + 1.36781676823172*std::sin(0.315279841423035*x_119 - 4.26600027084351) + 0.100297458032789*std::sin(0.341759830713272*x_119 + 5.15256023406982) + 0.243342614361629*std::sin(0.31455984711647*x_120 + 8.32087993621826) - 0.00684604260851151*std::sin(0.443679869174957*x_14 + 8.23079967498779) - 63.2686553173836*std::sin(0.332719832658768*x_16 - 4.25744009017944) - 0.0630875549638244*std::sin(0.33791983127594*x_16 - 4.26087999343872) - 0.103603038484245*std::sin(0.48159983754158*x_16 + 8.26519966125488) - 288.883836875129*std::sin(0.326719850301743*x_26 + 8.32287979125977) - 0.0881227639905771*std::sin(0.33247983455658*x_26 + 5.14400005340576) - 0.0294400973559777*std::sin(0.30431991815567*x_28 + 5.12759971618652) - 54.3359913025931*std::sin(0.32151985168457*x_28 - 4.2868800163269) - 934.772301986095*std::sin(0.328239858150482*x_28 - 4.28272008895874) + 6.26464716161695*std::sin(0.338879853487015*x_28 - 4.26279973983765) - 0.0656421248086053*std::sin(0.351759850978851*x_28 - 4.26024007797241) + 214.132866924357*std::sin(0.371999859809875*x_34 + 2.00143980979919) + 0.0753216062415196*std::sin(0.343839854001999*x_36 - 1.24111986160278) + 108.61377419998*std::sin(0.380959838628769*x_36 + 5.18408012390137) - 0.00721812168286318*std::sin(0.402399837970734*x_36 - 7.40079975128174) + 0.102783073084139*std::sin(0.403119832277298*x_36 + 2.00967979431152) + 2959.4216184784*std::sin(0.200159981846809*x_38 - 1.38711988925934) - 0.115474836673567*std::sin(0.866239905357361*x_38 - 0.756079852581024) + 29.5643377282428*std::sin(0.382639855146408*x_40 - 7.4047999382019) - 718.106197189673*std::sin(0.421359837055206*x_41 + 2.02663993835449) + 19.2827828617926*std::sin(0.261839985847473*x_53 - 7.5128002166748) + 26.0611025098326*std::sin(0.332879841327667*x_53 - 7.45375967025757) - 660.20744726396*std::sin(0.410319864749908*x_53 + 5.19792032241821) + 3.03916792802981*std::sin(0.499439835548401*x_53 - 7.30983972549438) - 0.209913055639807*std::sin(0.453039854764938*x_59 - 1.14135980606079) - 1078.22239041238*std::sin(0.32847985625267*x_60 - 7.45623970031738) + 0.286562916292156*std::sin(0.210639998316765*x_66 + 1.79599988460541) - 0.345691313127717*std::sin(0.537039816379547*x_75 + 5.33615970611572) + 8.11228827584424*std::sin(0.287599951028824*x_80 - 7.48920011520386) - 26.5150221892168*std::sin(0.356879830360413*x_80 + 5.14264011383057) + 559.847114094114*std::sin(0.480559855699539*x_80 - 7.31775999069214) - 14.5244204120856*std::sin(0.483359843492508*x_80 - 1.12239992618561) - 0.0905210488714085*std::sin(0.528159856796265*x_80 - 7.26775979995728) + 3.34858349797729*std::sin(0.367679834365845*x_83 + 5.17600011825562) + 2.47705035453645*std::sin(0.782319843769073*x_88 - 7.20016002655029) - 1.09477158298652*std::sin(0.339359849691391*x_92 + 5.18760013580322) + 23.9683831821595*std::sin(0.344559848308563*x_92 + 1.98527979850769) - 31.1942798181192*std::sin(0.401919841766357*x_94 + 5.1908802986145) - 0.173189281799434*std::sin(0.427519857883453*x_94 + 1.99663984775543) + 0.0544897184150361*std::sin(0.359279841184616*x_95 - 4.23464012145996) - 0.852989817415415*std::sin(0.378079831600189*x_95 - 7.41408014297485) - 0.0848281818403199*std::sin(0.395039826631546*x_96 - 4.21056032180786) - 0.999902401041769*std::sin(0.398399859666824*x_96 + 5.18368005752563) - 3.15544579246889*std::sin(0.449919849634171*x_96 - 7.36735963821411) - 0.0948945254585503*std::sin(0.44735985994339*x_97 + 2.00095963478088) + 25.6597490487538*std::sin(0.477439850568771*x_98 - 1.12615978717804) + 15.5371077427493*std::sin(0.52511990070343*x_98 - 7.43271970748901) - 3.96971516683322*std::sin(0.418879866600037*x_99 + 5.21640014648438) + 86348.605925621 + 3.75205359413012e-6*std::exp(-4.01200008392334*x_74) + 0.000228970344845112*std::exp(-3.20415997505188*x_74) + 0.165445610994479*std::exp(-2.78751993179321*x_74) + 0.000153657274424294*std::exp(-2.69967985153198*x_74) - 0.0208381287006144*std::exp(-2.53735995292664*x_74) + 9.41261148376285e-6*std::exp(-3.91295981407166*x_45) - 0.00263216582066286*std::exp(-4.45559978485107*x_111) + 2.01138459731032e-5*std::exp(-4.44000005722046*x_111) + 0.0118473321974752*std::exp(-3.17839980125427*x_111) - 0.000370097269195376*std::exp(-3.65016007423401*x_101));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-7111.7528612354*x_1 - 281.240079708539*x_10 + 263.231019871812*x_100 - 156.458345175932*x_101 - 453.194888340914*x_102 - 189.16664952564*x_103 + 272.268235895905*x_104 - 9.04629942848167*x_105 + 21.1685696500821*x_106 + 176.93494413471*x_107 + 467.36196321029*x_108 + 307.579553873761*x_109 + 412.562212418405*x_11 - 237.196526516446*x_110 + 51.6994727737137*x_111 + 33.4801791905905*x_112 - 1265.42131444951*x_113 + 470.479337296755*x_114 - 614.496434749056*x_115 + 1102.73003439622*x_116 + 36.2363257352624*x_117 - 311.347315899896*x_118 - 247.461577067151*x_119 - 2186.5786238525*x_12 + 1967.35492041204*x_120 + 684.219241318581*x_13 + 231.169726862279*x_14 + 309.599127635812*x_15 + 125.572797783427*x_16 - 309.734303051497*x_17 + 311.63874716281*x_18 + 14.0135330756548*x_19 - 511.64402270941*x_2 + 1316.13425505868*x_20 + 66.0125778444068*x_21 + 1371.79124976077*x_22 - 629.506544773591*x_23 - 180.093145791529*x_24 + 1203.04593913761*x_25 + 47.8469505944017*x_26 + 328.038830391038*x_27 - 38.7620376397484*x_28 + 645.710128426936*x_29 - 2001.80379102811*x_3 - 3655.75802840825*x_30 + 18432.0506705647*x_31 + 531.858444148789*x_32 - 53.0957065540564*x_33 - 868.182228587359*x_34 - 1093.03431674956*x_35 - 453.118264760416*x_36 - 4980.38867941024*x_37 + 66.2986126804292*x_38 + 121.629680651126*x_39 - 106.333079035289*x_4 + 498.842515695825*x_40 + 26.8335084461186*x_41 + 105587.047717488*x_42 + 372.053372936538*x_43 + 205.839607077495*x_44 - 421.287999200165*x_45 + 242.977687530247*x_46 + 2110.18065892311*x_47 + 237.691380685041*x_48 + 3063.72503154263*x_49 + 66.9522186369371*x_5 + 3853.41136475205*x_50 - 1112.34659283811*x_51 + 256.888524076379*x_52 + 41.5643072426928*x_53 - 382.317435526476*x_54 + 724.686684249148*x_55 + 241.87440018406*x_56 + 6235.41333957301*x_57 + 141.127166854557*x_58 - 453.750310374941*x_59 - 56.5730268110982*x_6 + 231.744181588379*x_60 - 363.000073058305*x_61 - 579.22062393112*x_62 + 209.702694669174*x_63 + 559.971323395257*x_64 - 264.385403880738*x_65 + 704.373015141729*x_66 - 628.481516996232*x_67 + 90.1588021851406*x_68 - 427.092329293005*x_69 + 426.797899093476*x_7 - 457.9051722301*x_70 - 230.216635352109*x_72 + 970.459774422612*x_73 + 220.464219405097*x_74 - 216.138911198585*x_75 + 1111.57269228887*x_76 - 473.142034169007*x_77 - 378.916728103193*x_78 + 435.569882368517*x_79 - 1841.18895250215*x_8 + 18.514406456575*x_80 + 0.585273564890765*x_81 - 10.8379918784111*x_82 + 49.7522967909356*x_83 + 869.739325309994*x_84 + 494.744761871137*x_85 + 333.624182228693*x_86 - 53.1192075683662*x_87 + 997.85721123049*x_88 - 127.141618485456*x_89 - 2224.63782243248*x_9 + 2877.15618075057*x_90 + 261.591830558414*x_91 + 404.61637127529*x_92 + 418.636756367348*x_93 + 138.723959832924*x_94 + 335.992042600381*x_95 + 198.664600214252*x_96 + 1580.20859994645*x_97 + 457.929090074041*x_98 + 363.204492644039*x_99 - 4.78172000731166*std::pow(-0.694239854812622*x_108 - 0.926799833774567, 2) - 0.103831785963697*std::pow(-3.91479992866516*x_109 - 5.28447961807251, 2) - 7.33960028657017e-5*std::pow(-7.3600001335144*x_14 - 9.39999961853027, 2) + 30.7464241351308*std::pow(-1.35455989837646*x_15 - 1.93879985809326, 2) - 0.029213122235097*std::pow(-6.25352001190186*x_22 - 9.28151988983154, 2) + 0.0469277471929685*std::pow(-7.00447988510132*x_66 - 9.6115198135376, 2) + 0.000308356680524111*std::pow(-6.60400009155273*x_66 - 9.97791957855225, 2) + 3.58122632821049*std::pow(-3.48359990119934*x_78 - 4.50279951095581, 2) - 0.000468471516678874*std::pow(-5.99087953567505*x_80 - 9.3931999206543, 2) - 5.26437768225078*std::pow(-6.52103996276855*x_87 - 9.17527961730957, 2) - 0.318908092193603*std::exp(1.00759983062744*x_38) + 0.00224822056442719*std::exp(1.10831987857819*x_38) - 11.1504017491628*std::exp(2.49903988838196*x_71) - 0.0296888230172212*std::exp(2.50559997558594*x_71) + 0.395468225575341*std::exp(2.54895973205566*x_71) - 0.00555116314998584*std::exp(2.56287980079651*x_71) - 0.651063566092284*std::exp(2.58863997459412*x_71) - 0.000825059478615141*std::exp(2.59767985343933*x_71) - 0.000581894673905489*std::exp(2.62127995491028*x_71) - 40.2153289592917*std::exp(2.63247990608215*x_71) + 0.00403856889843046*std::exp(2.64488005638123*x_71) - 0.000176918195254725*std::exp(2.67615985870361*x_71) - 0.00204093104754903*std::exp(1.12335991859436*x_89) + 0.0376224294507168*std::exp(2.01415991783142*x_89) - 0.212219078804822*std::sin(0.40191987156868*x_103 - 4.19952011108398) + 467.107242333639*std::sin(0.337119847536087*x_106 + 1.95119988918304) - 0.0172220061793193*std::sin(0.51911985874176*x_106 + 2.13583993911743) - 0.0332783800270453*std::sin(0.509919822216034*x_107 + 8.34679985046387) - 0.0719631190276551*std::sin(0.350639849901199*x_114 - 7.44543981552124) + 0.37807732490442*std::sin(0.315279841423035*x_119 - 4.26600027084351) + 2.56492890054354*std::sin(0.341759830713272*x_119 + 5.15256023406982) + 0.0763609216151616*std::sin(0.31455984711647*x_120 + 8.32087993621826) + 0.00861607550977426*std::sin(0.443679869174957*x_14 + 8.23079967498779) - 26.9934574298579*std::sin(0.332719832658768*x_16 - 4.25744009017944) + 0.0472677407169891*std::sin(0.33791983127594*x_16 - 4.26087999343872) - 2.64946323470624*std::sin(0.48159983754158*x_16 + 8.26519966125488) + 1472.68942464094*std::sin(0.326719850301743*x_26 + 8.32287979125977) + 0.0660251290759251*std::sin(0.33247983455658*x_26 + 5.14400005340576) + 0.0370517854386186*std::sin(0.30431991815567*x_28 + 5.12759971618652) - 23.1823524741909*std::sin(0.32151985168457*x_28 - 4.2868800163269) + 4765.33854740114*std::sin(0.328239858150482*x_28 - 4.28272008895874) - 0.313231413587356*std::sin(0.338879853487015*x_28 - 4.26279973983765) + 0.0491817274792877*std::sin(0.351759850978851*x_28 - 4.26024007797241) - 903.764633815133*std::sin(0.371999859809875*x_34 + 2.00143980979919) + 0.0236359228950721*std::sin(0.343839854001999*x_36 - 1.24111986160278) - 458.412990387881*std::sin(0.380959838628769*x_36 + 5.18408012390137) + 0.00908435500839075*std::sin(0.402399837970734*x_36 - 7.40079975128174) + 2.62849407962067*std::sin(0.403119832277298*x_36 + 2.00967979431152) - 15086.717788475*std::sin(0.200159981846809*x_38 - 1.38711988925934) - 0.0319183229488825*std::sin(0.866239905357361*x_38 - 0.756079852581024) + 43.3710580695069*std::sin(0.382639855146408*x_40 - 7.4047999382019) + 3660.80502741137*std::sin(0.421359837055206*x_41 + 2.02663993835449) + 28.2879563522767*std::sin(0.261839985847473*x_53 - 7.5128002166748) + 11.1189222790553*std::sin(0.332879841327667*x_53 - 7.45375967025757) + 3365.64529248862*std::sin(0.410319864749908*x_53 + 5.19792032241821) - 0.151957938199415*std::sin(0.499439835548401*x_53 - 7.30983972549438) - 0.0658707248204771*std::sin(0.453039854764938*x_59 - 1.14135980606079) + 5496.62704894691*std::sin(0.32847985625267*x_60 - 7.45623970031738) + 7.32833633312527*std::sin(0.210639998316765*x_66 + 1.79599988460541) - 0.0955523063801786*std::sin(0.537039816379547*x_75 + 5.33615970611572) - 0.405613190737939*std::sin(0.287599951028824*x_80 - 7.48920011520386) - 11.3125862897818*std::sin(0.356879830360413*x_80 + 5.14264011383057) - 2854.02234081563*std::sin(0.480559855699539*x_80 - 7.31775999069214) - 21.3074105332221*std::sin(0.483359843492508*x_80 - 1.12239992618561) - 0.0284055085687522*std::sin(0.528159856796265*x_80 - 7.26775979995728) - 0.167428670047555*std::sin(0.367679834365845*x_83 + 5.17600011825562) - 0.123852144272759*std::sin(0.782319843769073*x_88 - 7.20016002655029) - 0.302605086507319*std::sin(0.339359849691391*x_92 + 5.18760013580322) + 10.2260673605999*std::sin(0.344559848308563*x_92 + 1.98527979850769) - 45.7621927426315*std::sin(0.401919841766357*x_94 + 5.1908802986145) - 0.0543468031966621*std::sin(0.427519857883453*x_94 + 1.99663984775543) - 0.0408258947943152*std::sin(0.359279841184616*x_95 - 4.23464012145996) - 0.23577434918863*std::sin(0.378079831600189*x_95 - 7.41408014297485) - 2.16932970635876*std::sin(0.395039826631546*x_96 - 4.21056032180786) - 0.276382358903305*std::sin(0.398399859666824*x_96 + 5.18368005752563) + 0.157771813890664*std::sin(0.449919849634171*x_96 - 7.36735963821411) - 2.4267585203648*std::sin(0.44735985994339*x_97 + 2.00095963478088) - 108.298992284203*std::sin(0.477439850568771*x_98 - 1.12615978717804) + 22.7930288287577*std::sin(0.52511990070343*x_98 - 7.43271970748901) + 0.198485159845043*std::sin(0.418879866600037*x_99 + 5.21640014648438) - 360684.739341737 - 2.81118988594956e-6*std::exp(-4.01200008392334*x_74) + 6.32895410204658e-5*std::exp(-3.20415997505188*x_74) + 0.242709688535718*std::exp(-2.78751993179321*x_74) - 0.000193385106516839*std::exp(-2.69967985153198*x_74) + 0.00104190329335707*std::exp(-2.53735995292664*x_74) - 7.05230816663252e-6*std::exp(-3.91295981407166*x_45) - 0.0038614028058367*std::exp(-4.45559978485107*x_111) + 6.31172562915374e-6*std::exp(-4.44000005722046*x_111) + 0.0050546428673989*std::exp(-3.17839980125427*x_111) - 0.00946457866819649*std::exp(-3.65016007423401*x_101));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (4069.23407629297*x_1 + 155.081553223105*x_10 + 56.9837302821544*x_100 - 120.321322452936*x_101 + 339.220623004644*x_102 + 220.312208646606*x_103 - 134.211828939145*x_104 - 42.0409197235453*x_105 + 4.66933304367836*x_106 - 60.3562464349523*x_107 - 212.200319849353*x_108 + 49.1386619964491*x_109 - 190.874522616356*x_11 + 274.778607363708*x_110 - 83.5864596343906*x_111 + 7.66539481282912*x_112 + 292.781393218808*x_113 - 143.787656106607*x_114 + 344.536110721253*x_115 - 1262.60845733268*x_116 + 35.2077383447724*x_117 + 231.448766063916*x_118 + 160.267607267058*x_119 + 357.969055560429*x_12 - 1018.47306279309*x_120 - 314.757643103327*x_13 - 128.157468385889*x_14 - 168.458144134644*x_15 - 27.8612366503651*x_16 + 236.47238284696*x_17 - 1.60511326390411*x_18 - 34.4816368400326*x_19 + 433.215142565308*x_2 - 872.035995665529*x_20 - 419.994315734412*x_21 - 795.811583980242*x_22 + 265.760933531412*x_23 + 132.574575403845*x_24 - 493.694175224041*x_25 + 11.6229390671448*x_26 - 36.846023902804*x_27 - 9.94126554733495*x_28 - 415.12830497932*x_29 + 815.00114135833*x_3 + 1809.38298270886*x_30 - 10210.878606328*x_31 - 302.022684917112*x_32 - 67.3539885387018*x_33 + 458.162339557532*x_34 + 691.179803637331*x_35 + 251.280853297123*x_36 + 1530.29558649724*x_37 + 14.9922939536491*x_38 + 49.2210150428248*x_39 + 5.51181144672906*x_4 - 317.966438628406*x_40 + 6.81964704189127*x_41 + 39781.4122205491*x_42 - 279.942920068199*x_43 - 166.006209643655*x_44 + 266.119660334026*x_45 - 75.7793732379143*x_46 - 756.772266054302*x_47 - 303.130085113186*x_48 - 1272.82350103901*x_49 - 101.438071312553*x_5 - 1011.45056800569*x_50 + 346.657060134006*x_51 - 657.688718384667*x_52 + 9.50883128705369*x_53 - 329.289850199265*x_54 - 293.123813759197*x_55 - 4.05498778863645*x_56 - 1923.50631577315*x_57 - 128.4207096802*x_58 + 181.447110531015*x_59 + 56.6588260137253*x_6 + 58.7309815314608*x_60 + 173.008717140625*x_61 + 385.340212087908*x_62 - 173.290338173037*x_63 - 248.100950502633*x_64 + 162.44866138651*x_65 - 312.833442461348*x_66 + 378.348158148798*x_67 - 100.608548671642*x_68 + 359.069690462792*x_69 - 213.067156779538*x_7 + 183.58482825215*x_70 + 97.1033658344636*x_72 - 584.031397721535*x_73 - 192.500545987162*x_74 + 9.87833428428843*x_75 - 593.08489564235*x_76 + 148.381533912726*x_77 + 204.339413714582*x_78 - 294.646373066914*x_79 + 1194.74063462617*x_8 + 4.41828630470141*x_80 + 280.247913920705*x_81 - 81.9768859889409*x_82 + 7.93674662056533*x_83 - 797.367501185325*x_84 - 305.955266499206*x_85 - 273.443569923784*x_86 - 11.4394321836421*x_87 - 676.494449843781*x_88 + 141.652447999127*x_89 + 780.940233570487*x_9 - 1755.38163079592*x_90 - 206.664087690641*x_91 - 172.999254138671*x_92 - 184.793282463254*x_93 - 107.840886643413*x_94 - 145.905305365714*x_95 - 55.2662379561151*x_96 - 799.13288902598*x_97 - 251.277198153424*x_98 - 119.527060774555*x_99 - 1.34757204063451*std::pow(-0.694239854812622*x_108 - 0.926799833774567, 2) - 0.0429423452871215*std::pow(-3.91479992866516*x_109 - 5.28447961807251, 2) + 0.000222146350770971*std::pow(-7.3600001335144*x_14 - 9.39999961853027, 2) + 7.29497844914206*std::pow(-1.35455989837646*x_15 - 1.93879985809326, 2) - 0.0120818492168961*std::pow(-6.25352001190186*x_22 - 9.28151988983154, 2) + 0.0132250570820775*std::pow(-7.00447988510132*x_66 - 9.6115198135376, 2) + 0.00251875825221994*std::pow(-6.60400009155273*x_66 - 9.97791957855225, 2) + 0.8496912932371*std::pow(-3.48359990119934*x_78 - 4.50279951095581, 2) - 0.00482385557367974*std::pow(-5.99087953567505*x_80 - 9.3931999206543, 2) + 2.85236113544723*std::pow(-6.52103996276855*x_87 - 9.17527961730957, 2) + 0.508981728761987*std::exp(1.00759983062744*x_38) + 0.00319591066526341*std::exp(1.10831987857819*x_38) - 2.6455740056769*std::exp(2.49903988838196*x_71) + 0.0473837724225583*std::exp(2.50559997558594*x_71) + 0.111449838746265*std::exp(2.54895973205566*x_71) - 0.0571603786955963*std::exp(2.56287980079651*x_71) - 0.269264331721834*std::exp(2.58863997459412*x_71) + 0.00522382791454457*std::exp(2.59767985343933*x_71) + 0.00176121005632549*std::exp(2.62127995491028*x_71) + 21.7895919131063*std::exp(2.63247990608215*x_71) + 0.0329883520693988*std::exp(2.64488005638123*x_71) - 0.000251494340030551*std::exp(2.67615985870361*x_71) + 0.00617724898749304*std::exp(1.12335991859436*x_89) - 0.0600459180898636*std::exp(2.01415991783142*x_89) - 1.7334748678369*std::sin(0.40191987156868*x_103 - 4.19952011108398) - 253.089467461756*std::sin(0.337119847536087*x_106 + 1.95119988918304) + 0.109040377034384*std::sin(0.51911985874176*x_106 + 2.13583993911743) + 0.210700604067833*std::sin(0.509919822216034*x_107 + 8.34679985046387) + 0.217809467244995*std::sin(0.350639849901199*x_114 - 7.44543981552124) + 3.89306573844975*std::sin(0.315279841423035*x_119 - 4.26600027084351) - 4.09366202334462*std::sin(0.341759830713272*x_119 + 5.15256023406982) - 0.231120216578488*std::sin(0.31455984711647*x_120 + 8.32087993621826) + 0.0122480009524413*std::sin(0.443679869174957*x_14 + 8.23079967498779) - 11.1638488993289*std::sin(0.332719832658768*x_16 - 4.25744009017944) - 0.299273627919911*std::sin(0.33791983127594*x_16 - 4.26087999343872) + 4.22857999060571*std::sin(0.48159983754158*x_16 + 8.26519966125488) - 797.937065494508*std::sin(0.326719850301743*x_26 + 8.32287979125977) - 0.418035209906498*std::sin(0.33247983455658*x_26 + 5.14400005340576) + 0.0526701864238586*std::sin(0.30431991815567*x_28 + 5.12759971618652) - 9.58766696801803*std::sin(0.32151985168457*x_28 - 4.2868800163269) - 2581.9702328128*std::sin(0.328239858150482*x_28 - 4.28272008895874) - 2.55857666675712*std::sin(0.338879853487015*x_28 - 4.26279973983765) - 0.311391951187642*std::sin(0.351759850978851*x_28 - 4.26024007797241) - 214.429603189044*std::sin(0.371999859809875*x_34 + 2.00143980979919) - 0.0715384191677549*std::sin(0.343839854001999*x_36 - 1.24111986160278) - 108.764286571633*std::sin(0.380959838628769*x_36 + 5.18408012390137) + 0.0129136738261942*std::sin(0.402399837970734*x_36 - 7.40079975128174) - 4.19511292888043*std::sin(0.403119832277298*x_36 + 2.00967979431152) + 8174.33134146027*std::sin(0.200159981846809*x_38 - 1.38711988925934) - 0.328663268902684*std::sin(0.866239905357361*x_38 - 0.756079852581024) + 12.2227200960815*std::sin(0.382639855146408*x_40 - 7.4047999382019) - 1983.50851988521*std::sin(0.421359837055206*x_41 + 2.02663993835449) + 7.97203914255303*std::sin(0.261839985847473*x_53 - 7.5128002166748) + 4.59852053295896*std::sin(0.332879841327667*x_53 - 7.45375967025757) - 1823.58417412996*std::sin(0.410319864749908*x_53 + 5.19792032241821) - 1.24124215560874*std::sin(0.499439835548401*x_53 - 7.30983972549438) + 0.199369728189188*std::sin(0.453039854764938*x_59 - 1.14135980606079) - 2978.19919405191*std::sin(0.32847985625267*x_60 - 7.45623970031738) - 11.6961262103032*std::sin(0.210639998316765*x_66 + 1.79599988460541) - 0.983902989401885*std::sin(0.537039816379547*x_75 + 5.33615970611572) - 3.313181247262*std::sin(0.287599951028824*x_80 - 7.48920011520386) - 4.67861533958407*std::sin(0.356879830360413*x_80 + 5.14264011383057) + 1546.37506957139*std::sin(0.480559855699539*x_80 - 7.31775999069214) - 6.0047996639256*std::sin(0.483359843492508*x_80 - 1.12239992618561) + 0.0859744376255484*std::sin(0.528159856796265*x_80 - 7.26775979995728) - 1.36761215493599*std::sin(0.367679834365845*x_83 + 5.17600011825562) - 1.01166483538453*std::sin(0.782319843769073*x_88 - 7.20016002655029) - 3.11592739622797*std::sin(0.339359849691391*x_92 + 5.18760013580322) + 4.22925707626544*std::sin(0.344559848308563*x_92 + 1.98527979850769) - 12.8965835230424*std::sin(0.401919841766357*x_94 + 5.1908802986145) + 0.16449048360709*std::sin(0.427519857883453*x_94 + 1.99663984775543) + 0.258487362899912*std::sin(0.359279841184616*x_95 - 4.23464012145996) - 2.42777067115461*std::sin(0.378079831600189*x_95 - 7.41408014297485) + 3.46228023441597*std::sin(0.395039826631546*x_96 - 4.21056032180786) - 2.84591172567778*std::sin(0.398399859666824*x_96 + 5.18368005752563) + 1.28873179439271*std::sin(0.449919849634171*x_96 - 7.36735963821411) + 3.87314018433031*std::sin(0.44735985994339*x_97 + 2.00095963478088) - 25.6953072430418*std::sin(0.477439850568771*x_98 - 1.12615978717804) + 6.42347279306274*std::sin(0.52511990070343*x_98 - 7.43271970748901) + 1.62129172441848*std::sin(0.418879866600037*x_99 + 5.21640014648438) - 86140.4531150168 + 1.77989255077194e-5*std::exp(-4.01200008392334*x_74) + 0.000651692993784469*std::exp(-3.20415997505188*x_74) + 0.0683998205168283*std::exp(-2.78751993179321*x_74) - 0.000274902531450571*std::exp(-2.69967985153198*x_74) + 0.00851060698181645*std::exp(-2.53735995292664*x_74) + 4.46513799522205e-5*std::exp(-3.91295981407166*x_45) - 0.00108821061267004*std::exp(-4.45559978485107*x_111) - 1.91035854929279e-5*std::exp(-4.44000005722046*x_111) + 0.00209047949334917*std::exp(-3.17839980125427*x_111) + 0.015105598542222*std::exp(-3.65016007423401*x_101));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-8364.4720799722*x_1 - 317.446124177953*x_10 + 377.793347259192*x_100 - 231.783337154363*x_101 - 483.656023302525*x_102 - 171.383910896683*x_103 + 323.814570524203*x_104 - 39.2171497613785*x_105 + 28.2475207091282*x_106 + 226.781719729382*x_107 + 542.155176284479*x_108 + 424.973234832366*x_109 + 479.396931537437*x_11 - 228.217440381424*x_110 + 38.5868304433183*x_111 + 46.1967813925793*x_112 - 1578.65320241256*x_113 + 575.745245332803*x_114 - 683.874263605858*x_115 + 960.595897493919*x_116 + 63.3917016084284*x_117 - 325.181701525471*x_118 - 261.085570295158*x_119 - 2956.17029501574*x_12 + 2273.84576935155*x_120 + 781.754635051091*x_13 + 276.873554943667*x_14 + 350.972197707156*x_15 + 168.770373036317*x_16 - 322.152125125877*x_17 + 418.118092929688*x_18 + 13.6280562132452*x_19 - 527.541336156859*x_2 + 1459.27141951766*x_20 - 122.836206516092*x_21 + 1538.57499929942*x_22 - 742.399978163914*x_23 - 191.434914918897*x_24 + 1419.73233987682*x_25 + 71.695266804259*x_26 + 444.433637741498*x_27 - 55.753184274478*x_28 + 711.304609104957*x_29 - 2345.25583749649*x_3 - 4133.29288053066*x_30 + 21111.3953142182*x_31 + 592.43396235874*x_32 - 118.584693557055*x_33 - 971.946854986038*x_34 - 1197.32942728487*x_35 - 522.802516450783*x_36 - 6073.95193896729*x_37 + 92.6011297690427*x_38 + 188.273387426024*x_39 - 138.25499572412*x_4 + 549.66479904998*x_40 + 40.9094995319261*x_41 + 139160.419475832*x_42 + 392.855585389166*x_43 + 201.926638087289*x_44 - 467.103084366958*x_45 + 294.698189512063*x_46 + 2522.37928686125*x_47 + 197.938644331168*x_48 + 3678.11639800329*x_49 + 44.3176951125254*x_5 + 4710.64388296596*x_50 - 1348.76223724404*x_51 + 17.7936834001104*x_52 + 59.4725523885625*x_53 - 585.500217691952*x_54 + 871.049904896378*x_55 + 318.654332659919*x_56 + 7758.84454975085*x_57 + 130.549624812691*x_58 - 549.768306003493*x_59 - 58.7315572545642*x_6 + 322.05008329734*x_60 - 413.875693597066*x_61 - 622.130509791853*x_62 + 191.647623322894*x_63 + 662.005922481958*x_64 - 289.676463607749*x_65 + 829.166307004838*x_66 - 698.284198791178*x_67 + 88.8153429713856*x_68 - 449.101465165399*x_69 + 496.70643189535*x_7 - 544.086160245486*x_70 - 288.137573988949*x_72 + 1089.44955310258*x_73 + 214.425789841125*x_74 - 285.900102063004*x_75 + 1256.42909941368*x_76 - 564.9294225348*x_77 - 432.6966779903*x_78 + 469.872901613084*x_79 - 1976.94944023384*x_8 + 26.3840619373614*x_80 + 109.969999993188*x_81 - 19.5800305899648*x_82 + 63.1514197217267*x_83 + 942.430589153755*x_84 + 563.492265548706*x_85 + 351.60652518069*x_86 - 73.8415898572398*x_87 + 1090.74700544123*x_88 - 126.069794111266*x_89 - 2754.18345329639*x_9 + 3241.886447403*x_90 + 242.695777303026*x_91 + 474.076473314836*x_92 + 485.268585198948*x_93 + 139.442368638202*x_94 + 389.894328889642*x_95 + 257.427257623409*x_96 + 1856.40266717262*x_97 + 525.806424112754*x_98 + 449.121578283351*x_99 - 1.01990273820111*std::pow(-0.694239854812622*x_108 - 0.926799833774567, 2) + 0.0549084336622652*std::pow(-3.91479992866516*x_109 - 5.28447961807251, 2) + 0.000190396969433784*std::pow(-7.3600001335144*x_14 - 9.39999961853027, 2) + 43.8714292614301*std::pow(-1.35455989837646*x_15 - 1.93879985809326, 2) + 0.0154485138575415*std::pow(-6.25352001190186*x_22 - 9.28151988983154, 2) + 0.0100093141770186*std::pow(-7.00447988510132*x_66 - 9.6115198135376, 2) + 0.00674083272175421*std::pow(-6.60400009155273*x_66 - 9.97791957855225, 2) + 5.10997691428253*std::pow(-3.48359990119934*x_78 - 4.50279951095581, 2) + 0.00515134596312459*std::pow(-5.99087953567505*x_80 - 9.3931999206543, 2) - 5.99225270809898*std::pow(-6.52103996276855*x_87 - 9.17527961730957, 2) - 0.711524265380528*std::exp(1.00759983062744*x_38) + 0.00208724279673548*std::exp(1.10831987857819*x_38) - 15.910274945306*std::exp(2.49903988838196*x_71) - 0.0662395169781915*std::exp(2.50559997558594*x_71) + 0.0843502182309054*std::exp(2.54895973205566*x_71) + 0.061040982995189*std::exp(2.56287980079651*x_71) + 0.344296116039021*std::exp(2.58863997459412*x_71) - 0.00126700736922583*std::exp(2.59767985343933*x_71) + 0.00150949613215297*std::exp(2.62127995491028*x_71) - 45.7756696818865*std::exp(2.63247990608215*x_71) + 0.0882851551434775*std::exp(2.64488005638123*x_71) - 0.000164250445218639*std::exp(2.67615985870361*x_71) + 0.00529439030879761*std::exp(1.12335991859436*x_89) + 0.083940395781807*std::exp(2.01415991783142*x_89) - 4.63921620947732*std::sin(0.40191987156868*x_103 - 4.19952011108398) + 531.691456576815*std::sin(0.337119847536087*x_106 + 1.95119988918304) - 0.0264470735839261*std::sin(0.51911985874176*x_106 + 2.13583993911743) - 0.0511041371234666*std::sin(0.509919822216034*x_107 + 8.34679985046387) + 0.186679917691689*std::sin(0.350639849901199*x_114 - 7.44543981552124) - 4.15736503086134*std::sin(0.315279841423035*x_119 - 4.26600027084351) + 5.72268059790908*std::sin(0.341759830713272*x_119 + 5.15256023406982) - 0.198088281255594*std::sin(0.31455984711647*x_120 + 8.32087993621826) + 0.00799914466954769*std::sin(0.443679869174957*x_14 + 8.23079967498779) + 14.2747083934465*std::sin(0.332719832658768*x_16 - 4.25744009017944) + 0.0725869799297423*std::sin(0.33791983127594*x_16 - 4.26087999343872) - 5.91128738302016*std::sin(0.48159983754158*x_16 + 8.26519966125488) + 1676.30966576479*std::sin(0.326719850301743*x_26 + 8.32287979125977) + 0.101391872054724*std::sin(0.33247983455658*x_26 + 5.14400005340576) + 0.0343987923100637*std::sin(0.30431991815567*x_28 + 5.12759971618652) + 12.259315884342*std::sin(0.32151985168457*x_28 - 4.2868800163269) + 5424.21432108652*std::sin(0.328239858150482*x_28 - 4.28272008895874) - 6.84739684770953*std::sin(0.338879853487015*x_28 - 4.26279973983765) + 0.0755262047920558*std::sin(0.351759850978851*x_28 - 4.26024007797241) - 1289.56284565461*std::sin(0.371999859809875*x_34 + 2.00143980979919) - 0.0613140758799453*std::sin(0.343839854001999*x_36 - 1.24111986160278) - 654.099904168807*std::sin(0.380959838628769*x_36 + 5.18408012390137) + 0.00843389427810987*std::sin(0.402399837970734*x_36 - 7.40079975128174) + 5.86450254741036*std::sin(0.403119832277298*x_36 + 2.00967979431152) - 17172.6709178021*std::sin(0.200159981846809*x_38 - 1.38711988925934) + 0.350976138822844*std::sin(0.866239905357361*x_38 - 0.756079852581024) + 9.25070075540423*std::sin(0.382639855146408*x_40 - 7.4047999382019) + 4166.96334559894*std::sin(0.421359837055206*x_41 + 2.02663993835449) + 6.03359546307289*std::sin(0.261839985847473*x_53 - 7.5128002166748) - 5.87992011009855*std::sin(0.332879841327667*x_53 - 7.45375967025757) + 3830.99358285266*std::sin(0.410319864749908*x_53 + 5.19792032241821) - 3.32187725073408*std::sin(0.499439835548401*x_53 - 7.30983972549438) + 0.170875604808805*std::sin(0.453039854764938*x_59 - 1.14135980606079) + 6256.61385020156*std::sin(0.32847985625267*x_60 - 7.45623970031738) + 16.350444700296*std::sin(0.210639998316765*x_66 + 1.79599988460541) + 1.05069992563963*std::sin(0.537039816379547*x_75 + 5.33615970611572) - 8.86690913864484*std::sin(0.287599951028824*x_80 - 7.48920011520386) + 5.98233371482511*std::sin(0.356879830360413*x_80 + 5.14264011383057) - 3248.6314875143*std::sin(0.480559855699539*x_80 - 7.31775999069214) - 4.54470071722708*std::sin(0.483359843492508*x_80 - 1.12239992618561) + 0.0736868839657634*std::sin(0.528159856796265*x_80 - 7.26775979995728) - 3.66007525991674*std::sin(0.367679834365845*x_83 + 5.17600011825562) - 2.70747040522754*std::sin(0.782319843769073*x_88 - 7.20016002655029) + 3.32746695434416*std::sin(0.339359849691391*x_92 + 5.18760013580322) - 5.40775963818703*std::sin(0.344559848308563*x_92 + 1.98527979850769) - 9.76071070931168*std::sin(0.401919841766357*x_94 + 5.1908802986145) + 0.140981337171621*std::sin(0.427519857883453*x_94 + 1.99663984775543) - 0.0626945219106612*std::sin(0.359279841184616*x_95 - 4.23464012145996) + 2.59259143546549*std::sin(0.378079831600189*x_95 - 7.41408014297485) - 4.84004878981882*std::sin(0.395039826631546*x_96 - 4.21056032180786) + 3.0391199851566*std::sin(0.398399859666824*x_96 + 5.18368005752563) + 3.44897150869914*std::sin(0.449919849634171*x_96 - 7.36735963821411) - 5.41440501425175*std::sin(0.44735985994339*x_97 + 2.00095963478088) - 154.529566046408*std::sin(0.477439850568771*x_98 - 1.12615978717804) + 4.86157125026154*std::sin(0.52511990070343*x_98 - 7.43271970748901) + 4.33898580692971*std::sin(0.418879866600037*x_99 + 5.21640014648438) - 512451.884707382 - 4.31702003808218e-6*std::exp(-4.01200008392334*x_74) - 0.000695936273682286*std::exp(-3.20415997505188*x_74) + 0.0517680406939359*std::exp(-2.78751993179321*x_74) - 0.000179538287728471*std::exp(-2.69967985153198*x_74) + 0.0227765320369494*std::exp(-2.53735995292664*x_74) - 1.08299179014012e-5*std::exp(-3.91295981407166*x_45) - 0.000823606419645728*std::exp(-4.45559978485107*x_111) - 1.63732817151816e-5*std::exp(-4.44000005722046*x_111) - 0.00267300152833787*std::exp(-3.17839980125427*x_111) - 0.0211166713823508*std::exp(-3.65016007423401*x_101));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
