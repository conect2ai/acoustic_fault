
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00714060976833851*x_1 + 167.743518635752*x_10 - 1783.81366160212*x_100 + 8502.12653711036*x_101 - 1002.86361107707*x_102 - 379.856119960985*x_103 + 2755.61802905372*x_104 - 716.482323834247*x_105 + 308.558860432342*x_106 - 4473.51123764934*x_107 + 838.043026978889*x_108 + 2790.19859097794*x_109 + 572.799199624777*x_11 + 1862.42062552563*x_110 - 894.060798105583*x_111 - 2407.22974377394*x_112 - 2381.43144511394*x_113 + 1376.9328707461*x_114 - 316.269829243578*x_115 - 1400.40902987173*x_116 + 1214.17029711606*x_117 + 339.083115499768*x_118 + 2828.54647831095*x_119 - 225.113374894557*x_12 + 1490.544393751*x_120 - 134.875150343141*x_13 + 0.25312763324948*x_14 + 323.803865588933*x_15 - 130.172335982212*x_16 - 44.5841187802765*x_17 + 2111.15851035691*x_18 - 1211.77164465673*x_19 + 2180.2518326832*x_2 - 488.880611377536*x_20 + 1146.91750469553*x_21 - 418.579420020447*x_22 - 2829.31581493065*x_23 - 1106.43362774092*x_24 + 1231.84669806528*x_25 + 1029.23663600107*x_26 - 240.70410331408*x_27 - 300.592654198557*x_28 + 374.878274184226*x_29 - 1306.10524901389*x_3 - 3667.41609983125*x_30 - 13922.4500576527*x_31 + 4089.37129975461*x_32 - 5546.79841067602*x_33 + 586.998150639933*x_34 + 1265.86180324585*x_35 + 94.7117076373053*x_36 + 677.422321436892*x_37 + 1721.72252021594*x_38 + 3288.64074289059*x_39 + 7573.29246647976*x_4 - 5996.66031711958*x_40 - 1634.85211017707*x_41 - 5069.77555230274*x_42 + 790.627229564578*x_43 - 153.173617828264*x_44 + 1104.99014756774*x_45 - 146.305157632414*x_46 - 417.980165884625*x_47 + 1722.46853664744*x_48 + 2363.07584146177*x_49 + 147.893248244641*x_5 + 514.85633733942*x_51 - 1421.75892773488*x_52 + 746.416342152202*x_53 - 1921.47157191133*x_54 + 0.676560432639957*x_55 + 3064.85647083543*x_56 - 1871.00562648075*x_57 + 1521.63457306767*x_58 - 213.986653351185*x_59 - 855.790946592405*x_6 + 119.972233034951*x_60 + 283.594312229215*x_61 - 2799.76773602946*x_62 - 403.96359715319*x_63 - 1800.39539336579*x_64 + 258.201351760037*x_65 - 1002.04367152149*x_66 - 814.120452168018*x_67 + 739.519342302206*x_68 + 1155.13035614717*x_69 + 176.650706458875*x_7 + 2160.63900175678*x_70 - 4.60646410842565*x_71 - 1212.22018052602*x_72 + 876.929211880749*x_73 + 662.392944374212*x_74 + 1017.00946317197*x_75 - 359.288921886236*x_76 + 1035.00536633337*x_77 - 566.682182062133*x_78 + 51.6165864531488*x_79 - 7509.41075593572*x_8 + 770.185118551529*x_80 + 1092.51714570599*x_81 + 1509.16365126732*x_82 - 4226.20389233002*x_83 + 971.146379671754*x_84 - 1143.59249242505*x_85 - 1142.44722783582*x_86 - 127.415088702167*x_87 + 253.073462415094*x_88 + 183.961803286593*x_89 - 15311.0402933126*x_9 - 608.041132064325*x_90 - 1984.81226858701*x_91 - 0.168771701148154*x_92 + 18057.777304706*x_93 - 181.3852021746*x_94 - 1571.2604734203*x_95 - 2225.69914696057*x_96 - 1661.25046822435*x_97 - 620.357051116185*x_98 + 992.654306608129*x_99 + 5.90135769920815*std::pow(-9.58376026153564*x_100 - 9.79407978057861, 2) - 3.36279345929282*std::pow(-6.21119976043701*x_14 - 8.61127948760986, 2) + 0.00121029486383719*std::pow(-7.13375997543335*x_15 - 9.79415988922119, 2) - 0.00220142243527384*std::pow(-6.92288017272949*x_27 - 9.48711967468262, 2) + 21.1929089029618*std::pow(-3.31655979156494*x_55 - 5.26735973358154, 2) - 69.3908123509472*std::pow(-1.93759977817535*x_67 - 2.71135997772217, 2) - 1.08634769205337e-5*std::pow(-9.79600048065186*x_76 - 9.91380023956299, 2) + 8.23311161884639*std::pow(-9.48680019378662*x_85 - 8.87896060943604, 2) + 20.7109688412892*std::pow(-5.09360027313232*x_87 - 6.66383981704712, 2) + 48.2158509301349*std::exp(0.924879848957062*x_1) + 0.0159458608798743*std::exp(0.940159797668457*x_1) + 22.2669784153421*std::exp(1.05847978591919*x_1) + 0.0428889161886572*std::exp(1.14207983016968*x_1) - 0.0533315015029735*std::exp(1.24071979522705*x_108) + 8.15418023579013*std::exp(3.36735987663269*x_17) + 0.00123850836667907*std::exp(3.41799974441528*x_17) + 3.41750900447495e-5*std::exp(3.64247989654541*x_17) + 0.00616432031130583*std::exp(0.811679840087891*x_22) + 0.0648840473319003*std::exp(1.71975982189178*x_50) + 581.843535969501*std::exp(1.89559984207153*x_50) - 0.629081300535015*std::exp(1.9236798286438*x_50) + 281.746159232619*std::exp(1.96079981327057*x_50) + 0.000900267797261462*std::exp(2.01327991485596*x_50) - 556.025287588457*std::exp(1.40999984741211*x_71) + 0.0177698696014841*std::exp(1.89591979980469*x_71) + 853.776470260498*std::exp(1.12383985519409*x_72) + 238.240510725121*std::exp(1.54359984397888*x_78) + 0.00347175399306918*std::exp(0.696879863739014*x_87) + 0.0470450014324899*std::sin(0.357039839029312*x_102 - 7.42975997924805) + 0.0353977669222585*std::sin(0.315199851989746*x_105 - 4.27816009521484) + 1.29797176775978*std::sin(0.407839864492416*x_112 - 7.37943983078003) - 5999.67248350244*std::sin(0.412239879369736*x_117 - 4.20151996612549) + 1.89229271768622*std::sin(0.336319833993912*x_118 + 1.96023988723755) - 0.0343027539307499*std::sin(0.35879984498024*x_120 + 5.16232013702393) - 16706.3170781826*std::sin(0.22639998793602*x_14 - 7.56480026245117) + 3.9022790601029*std::sin(0.398159831762314*x_21 + 1.96975982189178) - 204401.256229077*std::sin(0.0848800837993622*x_26 - 1.48327994346619) - 6.42434784657442*std::sin(0.325519859790802*x_28 - 4.27144002914429) + 6306.82862482485*std::sin(0.439279854297638*x_36 + 5.20919990539551) - 5.61456200109235*std::sin(0.469599843025208*x_41 - 1.14487981796265) - 6.62862741239418*std::sin(0.34063982963562*x_53 - 4.25999975204468) - 7987.26541896317*std::sin(0.301439940929413*x_55 + 5.11815977096558) + 4.32422383923157*std::sin(0.354079842567444*x_67 + 5.14880037307739) + 0.670146453978985*std::sin(0.584159851074219*x_69 + 8.59424018859863) + 3026.1232485226*std::sin(0.649519801139832*x_69 + 8.64799976348877) + 521.47632686979*std::sin(0.979519844055176*x_7 - 0.994799792766571) - 0.947042762275931*std::sin(0.333439826965332*x_75 + 5.14296007156372) + 4383.11857408578*std::sin(0.341919839382172*x_76 - 7.45951986312866) - 4.92806114257006*std::sin(0.165280014276505*x_85 - 7.63127994537354) - 2982.69108709534*std::sin(0.344719856977463*x_92 + 5.18096017837524) + 8124.12480979193*std::sin(0.366639852523804*x_92 + 1.98431980609894) + 3.33426918554138*std::sin(0.366079837083817*x_94 - 7.41951990127563) - 1.09581919168207*std::sin(0.369119822978973*x_95 + 5.17471981048584) + 1.557082123174*std::sin(0.371599853038788*x_97 - 7.41527986526489) - 3.29976552270446*std::sin(0.445759862661362*x_98 - 7.37967967987061) - 405795.629966478 - 0.618160344124846*std::exp(-4.21368026733398*x_111));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0100733893526773*x_1 + 1483.04044647646*x_10 - 352.71313554472*x_100 + 103478.488709059*x_101 - 3806.65643390126*x_102 - 1115.00020423365*x_103 + 7488.65818388888*x_104 - 2317.07488337617*x_105 - 812.102618575916*x_106 - 7460.19225482435*x_107 + 222.981408871882*x_108 + 5174.07184497428*x_109 + 4020.38415030921*x_11 + 4397.59470602051*x_110 - 2256.01188844757*x_111 - 3664.17528636375*x_112 - 5002.27072810305*x_113 - 27.0538523563855*x_114 - 3970.45555130566*x_115 + 4333.5748324502*x_116 + 3072.53868491731*x_117 - 2346.72195622026*x_118 + 5979.32223040184*x_119 - 2738.04907488144*x_12 + 705.808424580104*x_120 - 2828.96063110184*x_13 - 0.44478374353425*x_14 + 1754.28814991513*x_15 - 2322.63628018018*x_16 - 9.17432152512482*x_17 + 3087.57640219905*x_18 - 1989.54261828022*x_19 + 2886.52939492053*x_2 - 4497.56975066251*x_20 + 2599.71206780289*x_21 - 1636.87675368539*x_22 - 1609.55044611498*x_23 - 862.215781814867*x_24 + 1311.59460893998*x_25 + 2604.45693242506*x_26 - 2720.01537501281*x_27 - 621.70923572734*x_28 + 804.07311067271*x_29 - 3000.8541830311*x_3 - 2575.64461987086*x_30 - 15879.8385807014*x_31 - 266.466790174025*x_32 - 2838.86126946661*x_33 - 3048.80527130115*x_34 - 330.509626305581*x_35 + 234.753982624543*x_36 + 143.038238342367*x_37 + 474.149146243133*x_38 + 5191.18397149076*x_39 + 10514.7652362038*x_4 - 5276.59738247408*x_40 - 2069.6028514848*x_41 - 8105.94293178257*x_42 - 2098.11394253606*x_43 - 1495.67927082289*x_44 - 19.7782598416579*x_45 + 1121.40374960925*x_46 + 1018.53200385222*x_47 + 2418.28544939392*x_48 + 4321.75550854926*x_49 + 1364.78442228167*x_5 - 2734.40142968445*x_51 - 1913.57260835867*x_52 + 1844.20369528058*x_53 - 1414.09878307715*x_54 - 0.736706715953523*x_55 + 4338.04081239556*x_56 + 1259.22137911291*x_57 + 858.392816337169*x_58 + 236.307055065209*x_59 - 1339.05103465*x_6 - 2181.10501116463*x_60 - 398.529343674797*x_61 - 1825.93966666332*x_62 + 511.471755092943*x_63 - 4774.91946817242*x_64 + 3478.21218509207*x_65 - 5268.36031779134*x_66 - 161.080894296246*x_67 + 781.390602827398*x_68 + 2922.79897019537*x_69 + 34.9161253247998*x_7 + 3998.09784874501*x_70 - 9.20608753182906*x_71 - 3044.63439635391*x_72 - 119.625377864072*x_73 + 1771.80345413061*x_74 - 519.109666645642*x_75 - 71.2401184160804*x_76 + 1879.36899156414*x_77 - 1430.06950708989*x_78 + 1476.32801839499*x_79 - 31445.2350623217*x_8 - 329.122932877709*x_80 - 1637.18853083226*x_81 - 1142.23359269095*x_82 - 3688.79126767445*x_83 - 3933.39784149092*x_84 - 2890.8851750688*x_85 - 440.563377190531*x_86 - 22.2564783672848*x_87 - 608.84281698718*x_88 + 275.919146553976*x_89 - 10854.7833140648*x_9 + 4293.37130176947*x_90 - 8454.37296503312*x_91 - 0.233498277186405*x_92 + 22678.4792230656*x_93 - 1657.94156579022*x_94 - 2187.44044381683*x_95 - 4322.69606778415*x_96 + 212.623235605977*x_97 - 2187.46018002047*x_98 - 110.030923258212*x_99 + 14.9112449205394*std::pow(-9.58376026153564*x_100 - 9.79407978057861, 2) - 8.49693230685397*std::pow(-6.21119976043701*x_14 - 8.61127948760986, 2) + 0.00424050996134409*std::pow(-7.13375997543335*x_15 - 9.79415988922119, 2) + 0.00406423722423856*std::pow(-6.92288017272949*x_27 - 9.48711967468262, 2) + 4.17440603904314*std::pow(-3.31655979156494*x_55 - 5.26735973358154, 2) - 175.333109928076*std::pow(-1.93759977817535*x_67 - 2.71135997772217, 2) + 1.53253064226506e-5*std::pow(-9.79600048065186*x_76 - 9.91380023956299, 2) + 1.62169105804185*std::pow(-9.48680019378662*x_85 - 8.87896060943604, 2) + 52.3314031575414*std::pow(-5.09360027313232*x_87 - 6.66383981704712, 2) + 121.829314357259*std::exp(0.924879848957062*x_1) + 0.055869510747928*std::exp(0.940159797668457*x_1) + 4.38596747590685*std::exp(1.05847978591919*x_1) - 0.0791809544993149*std::exp(1.14207983016968*x_1) + 0.0984599185326091*std::exp(1.24071979522705*x_108) + 20.6035602007997*std::exp(3.36735987663269*x_17) + 0.00433936160768265*std::exp(3.41799974441528*x_17) - 4.82114272243267e-5*std::exp(3.64247989654541*x_17) - 0.00869611988400945*std::exp(0.811679840087891*x_22) + 0.22733422843002*std::exp(1.71975982189178*x_50) + 114.606785762659*std::exp(1.89559984207153*x_50) + 1.16140164547237*std::exp(1.9236798286438*x_50) + 711.901599576415*std::exp(1.96079981327057*x_50) - 0.00127002431692917*std::exp(2.01327991485596*x_50) - 109.52131814456*std::exp(1.40999984741211*x_71) + 0.0622602898751253*std::exp(1.89591979980469*x_71) + 168.169913331259*std::exp(1.12383985519409*x_72) + 46.9266692585403*std::exp(1.54359984397888*x_78) - 0.0048976671241671*std::exp(0.696879863739014*x_87) - 0.0663672476023012*std::sin(0.357039839029312*x_102 - 7.42975997924805) - 0.0499362799524894*std::sin(0.315199851989746*x_105 - 4.27816009521484) + 4.54770351852797*std::sin(0.407839864492416*x_112 - 7.37943983078003) - 1181.76646547626*std::sin(0.412239879369736*x_117 - 4.20151996612549) + 6.63002575561349*std::sin(0.336319833993912*x_118 + 1.96023988723755) + 0.0483915250131261*std::sin(0.35879984498024*x_120 + 5.16232013702393) - 3290.67383909665*std::sin(0.22639998793602*x_14 - 7.56480026245117) - 7.20433641508886*std::sin(0.398159831762314*x_21 + 1.96975982189178) - 40261.2893915386*std::sin(0.0848800837993622*x_26 - 1.48327994346619) + 11.8605467270332*std::sin(0.325519859790802*x_28 - 4.27144002914429) + 1242.26757257469*std::sin(0.439279854297638*x_36 + 5.20919990539551) + 10.365530720957*std::sin(0.469599843025208*x_41 - 1.14487981796265) + 12.2376849819419*std::sin(0.34063982963562*x_53 - 4.25999975204468) - 20181.8084884933*std::sin(0.301439940929413*x_55 + 5.11815977096558) - 7.98332533172291*std::sin(0.354079842567444*x_67 + 5.14880037307739) + 2.34799204604373*std::sin(0.584159851074219*x_69 + 8.59424018859863) + 596.061032553966*std::sin(0.649519801139832*x_69 + 8.64799976348877) + 1317.63936818507*std::sin(0.979519844055176*x_7 - 0.994799792766571) - 3.31815360640094*std::sin(0.333439826965332*x_75 + 5.14296007156372) + 11075.0369500104*std::sin(0.341919839382172*x_76 - 7.45951986312866) - 17.2664472019045*std::sin(0.165280014276505*x_85 - 7.63127994537354) - 587.506120258499*std::sin(0.344719856977463*x_92 + 5.18096017837524) + 20527.6177073782*std::sin(0.366639852523804*x_92 + 1.98431980609894) - 6.15568403518302*std::sin(0.366079837083817*x_94 - 7.41951990127563) - 3.83942156329348*std::sin(0.369119822978973*x_95 + 5.17471981048584) + 5.45554843801962*std::sin(0.371599853038788*x_97 - 7.41527986526489) + 6.09198382543344*std::sin(0.445759862661362*x_98 - 7.37967967987061) - 517953.466441969 - 0.121760173906618*std::exp(-4.21368026733398*x_111));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00510573725584143*x_1 - 2159.00114324466*x_10 - 4241.52632295788*x_100 - 159617.684274986*x_101 + 3984.97442774892*x_102 + 935.127658022531*x_103 - 5706.14761097803*x_104 + 2137.18590440023*x_105 + 2274.66407817182*x_106 + 955.559286601762*x_107 + 1892.46924428371*x_108 - 1526.45553655345*x_109 - 5538.46881984357*x_11 - 2686.37750641061*x_110 + 1541.90078587501*x_111 - 95.92260595264*x_112 + 2327.0070866331*x_113 + 3808.87076179741*x_114 + 6145.78415177501*x_115 - 11462.5999536936*x_116 - 2115.74853195211*x_117 + 5067.77351719855*x_118 - 2840.56176639748*x_119 + 4225.4115613199*x_12 + 2817.96363329503*x_120 + 4627.67110192526*x_13 + 2.30322792182888*x_14 - 2215.71168699588*x_15 + 3744.88334684898*x_16 - 104.798182144168*x_17 + 308.643906950171*x_18 + 204.494258815383*x_19 + 852.444428010287*x_2 + 6607.00526546606*x_20 - 1460.6361195761*x_21 + 1747.72801425425*x_22 - 4877.41613374405*x_23 - 1495.6519505366*x_24 + 1041.85904226793*x_25 - 1793.77574596997*x_26 + 4145.67033853544*x_27 + 277.922076975379*x_28 - 400.18282019022*x_29 + 1736.14325568907*x_3 - 5460.96748826766*x_30 - 9908.02971933991*x_31 + 11634.5452285306*x_32 - 10117.82907806*x_33 + 6991.16957070959*x_34 + 4040.02774576846*x_35 - 151.969593132051*x_36 + 1598.0705918873*x_37 + 3857.62185298839*x_38 - 189.488446645571*x_39 + 2095.45256506166*x_4 - 7044.38017834806*x_40 - 806.218389751197*x_41 + 478.62841307889*x_42 + 5859.85942562961*x_43 + 2220.72384390838*x_44 + 3049.32012375582*x_45 - 2376.98457775597*x_46 - 2941.91790391135*x_47 + 445.150715537392*x_48 - 1182.59040211565*x_49 - 2005.21415474614*x_5 + 6237.73710308204*x_51 - 499.661463105037*x_52 - 1219.70345252861*x_53 - 2746.62894772139*x_54 + 4.66848085857452*x_55 + 701.852064721895*x_56 - 7322.43122580063*x_57 + 2638.12083406514*x_58 - 1001.92293693337*x_59 + 27.6234841148399*x_6 + 4174.43822998514*x_60 + 1473.38512337113*x_61 - 4412.3136187451*x_62 - 2004.88342269534*x_63 + 3515.02599865367*x_64 - 5435.53337918482*x_65 + 6568.72867661013*x_66 - 1935.97567163708*x_67 + 641.474154025512*x_68 - 2012.73786268113*x_69 + 420.395359271869*x_7 - 1164.71919998584*x_70 + 1.83127910480646*x_71 + 2056.03887249216*x_72 + 2602.78941749492*x_73 - 1323.6183091471*x_74 + 3691.23320983337*x_75 - 853.896009118749*x_76 - 494.089214143604*x_77 + 977.919320403893*x_78 - 2467.32602250018*x_79 + 34980.078767415*x_8 + 2681.27855763354*x_80 + 5872.45944662341*x_81 + 6135.63263615335*x_82 - 5020.13210032606*x_83 + 9596.53852921556*x_84 + 1985.71576184062*x_85 - 2341.01761475199*x_86 - 313.110682397247*x_87 + 1769.28368026917*x_88 + 16.5950240186144*x_89 - 22615.2691603927*x_9 - 9245.74660135411*x_90 + 9515.53212485522*x_91 + 0.144232321130547*x_92 + 9343.19069950141*x_93 + 2433.07485205608*x_94 - 424.108950636253*x_95 + 1558.54483528266*x_96 - 4908.72317743992*x_97 + 2169.84549727311*x_98 + 2904.53732207529*x_99 - 10.2297833090443*std::pow(-9.58376026153564*x_100 - 9.79407978057861, 2) + 5.82927694863388*std::pow(-6.21119976043701*x_14 - 8.61127948760986, 2) - 0.00886233740388805*std::pow(-7.13375997543335*x_15 - 9.79415988922119, 2) - 0.0205784092365026*std::pow(-6.92288017272949*x_27 - 9.48711967468262, 2) + 50.4516856352291*std::pow(-3.31655979156494*x_55 - 5.26735973358154, 2) + 120.28638326465*std::pow(-1.93759977817535*x_67 - 2.71135997772217, 2) + 7.76769220565436e-6*std::pow(-9.79600048065186*x_76 - 9.91380023956299, 2) + 19.5996859655136*std::pow(-9.48680019378662*x_85 - 8.87896060943604, 2) - 35.9016914692675*std::pow(-5.09360027313232*x_87 - 6.66383981704712, 2) - 83.5803779768589*std::exp(0.924879848957062*x_1) - 0.116762950529975*std::exp(0.940159797668457*x_1) + 53.0086077471068*std::exp(1.05847978591919*x_1) + 0.400916087207254*std::exp(1.14207983016968*x_1) - 0.498531061344811*std::exp(1.24071979522705*x_108) - 14.1349670917622*std::exp(3.36735987663269*x_17) - 0.00906892968895945*std::exp(3.41799974441528*x_17) - 2.44361526710083e-5*std::exp(3.64247989654541*x_17) - 0.00440766277551357*std::exp(0.811679840087891*x_22) - 0.475110931035476*std::exp(1.71975982189178*x_50) + 1385.13251295677*std::exp(1.89559984207153*x_50) - 5.88051263492759*std::exp(1.9236798286438*x_50) - 488.39645112377*std::exp(1.96079981327057*x_50) - 0.000643716850778372*std::exp(2.01327991485596*x_50) - 1323.66977761746*std::exp(1.40999984741211*x_71) - 0.130119183958324*std::exp(1.89591979980469*x_71) + 2032.49408929976*std::exp(1.12383985519409*x_72) + 567.153636516617*std::exp(1.54359984397888*x_78) - 0.00248240196294245*std::exp(0.696879863739014*x_87) - 0.0336385020758342*std::sin(0.357039839029312*x_102 - 7.42975997924805) - 0.0253104011018683*std::sin(0.315199851989746*x_105 - 4.27816009521484) - 9.50434814714337*std::sin(0.407839864492416*x_112 - 7.37943983078003) - 14282.7769155227*std::sin(0.412239879369736*x_117 - 4.20151996612549) - 13.8562403527736*std::sin(0.336319833993912*x_118 + 1.96023988723755) + 0.0245274359479447*std::sin(0.35879984498024*x_120 + 5.16232013702393) - 39770.9375909757*std::sin(0.22639998793602*x_14 - 7.56480026245117) + 36.4776401689772*std::sin(0.398159831762314*x_21 + 1.96975982189178) - 486596.15203999*std::sin(0.0848800837993622*x_26 - 1.48327994346619) - 60.0533804626227*std::sin(0.325519859790802*x_28 - 4.27144002914429) + 15013.9906037372*std::sin(0.439279854297638*x_36 + 5.20919990539551) - 52.4836817736091*std::sin(0.469599843025208*x_41 - 1.14487981796265) - 61.9629405891738*std::sin(0.34063982963562*x_53 - 4.25999975204468) + 13845.6264867287*std::sin(0.301439940929413*x_55 + 5.11815977096558) + 40.4218864894411*std::sin(0.354079842567444*x_67 + 5.14880037307739) - 4.90712153098901*std::sin(0.584159851074219*x_69 + 8.59424018859863) + 7203.96711593392*std::sin(0.649519801139832*x_69 + 8.64799976348877) - 903.959749023538*std::sin(0.979519844055176*x_7 - 0.994799792766571) + 6.93468405590826*std::sin(0.333439826965332*x_75 + 5.14296007156372) - 7597.97245246824*std::sin(0.341919839382172*x_76 - 7.45951986312866) + 36.0855374152203*std::sin(0.165280014276505*x_85 - 7.63127994537354) - 7100.57282660724*std::sin(0.344719856977463*x_92 + 5.18096017837524) - 14082.8671325844*std::sin(0.366639852523804*x_92 + 1.98431980609894) + 31.1680096946936*std::sin(0.366079837083817*x_94 - 7.41951990127563) + 8.02409371510709*std::sin(0.369119822978973*x_95 + 5.17471981048584) - 11.4016737188985*std::sin(0.371599853038788*x_97 - 7.41527986526489) - 30.8454770982053*std::sin(0.445759862661362*x_98 - 7.37967967987061) + 815545.81547973 - 1.47158804375331*std::exp(-4.21368026733398*x_111));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00912101318535181*x_1 - 36.5125666252023*x_10 - 710.841048325855*x_100 - 3655.09393650083*x_101 - 146.669176508758*x_102 - 78.7404209059373*x_103 + 608.577656383727*x_104 - 132.94313429966*x_105 + 184.476610767699*x_106 - 1302.1150065898*x_107 + 328.019742869235*x_108 + 784.610326038754*x_109 - 43.8507482848823*x_11 + 460.377957412525*x_110 - 207.521923788297*x_111 - 733.420238117321*x_112 - 620.590137176705*x_113 + 563.865780588002*x_114 + 148.687862253115*x_115 - 883.713655245559*x_116 + 287.777447257705*x_117 + 303.854746201871*x_118 + 744.578115245502*x_119 + 94.3450464464252*x_12 + 563.558345082978*x_120 + 141.35757946331*x_13 - 0.641950712133869*x_14 + 11.7759431681283*x_15 + 109.881918573598*x_16 - 18.2362132374172*x_17 + 651.317090494302*x_18 - 355.36186337302*x_19 + 693.313208473593*x_2 + 111.225351008382*x_20 + 289.711902003549*x_21 - 56.3001102361044*x_22 - 1047.61910604105*x_23 - 394.018247000134*x_24 + 415.040732531856*x_25 + 243.372594483495*x_26 + 90.3811922917801*x_27 - 79.8510205640384*x_28 + 99.8488812144904*x_29 - 327.982908024704*x_3 - 1322.00485792968*x_30 - 4630.81870551814*x_31 + 1686.55321504803*x_32 - 2080.51888162772*x_33 + 448.835504116414*x_34 + 541.022900628283*x_35 + 19.812786923371*x_36 + 266.895560637522*x_37 + 674.918355250882*x_38 + 981.372868525335*x_39 + 2376.21573818956*x_4 - 2090.96237539153*x_40 - 526.469718732795*x_41 - 1514.31844756876*x_42 + 473.686657298678*x_43 + 42.9169220841493*x_44 + 454.714119097133*x_45 - 140.56915278681*x_46 - 239.417666692028*x_47 + 515.542705371628*x_48 + 668.19728288889*x_49 - 35.498264020841*x_5 + 399.468686545946*x_51 - 450.306296309761*x_52 + 177.824444818971*x_53 - 688.677510369491*x_54 - 1.62867521610282*x_55 + 954.193475166289*x_56 - 861.349484931947*x_57 + 560.904166848713*x_58 - 104.403822145223*x_59 - 255.981227568907*x_6 + 204.115576587429*x_60 + 146.78583145332*x_61 - 1022.48712041202*x_62 - 201.300129538034*x_63 - 401.991097367802*x_64 - 137.979586653879*x_65 - 44.1468752731672*x_66 - 322.216454356843*x_67 + 245.16119605933*x_68 + 272.974162868633*x_69 + 68.8495269640766*x_7 + 608.0166549778*x_70 + 0.457284778197747*x_71 - 271.341240184809*x_72 + 367.973318857681*x_73 + 150.312459341647*x_74 + 453.523164166032*x_75 - 142.2948098832*x_76 + 293.05259032614*x_77 - 131.340634860647*x_78 - 79.5004756773982*x_79 - 851.420966127219*x_8 + 340.294726884583*x_80 + 561.420934013274*x_81 + 698.821152593318*x_82 - 1470.36318787864*x_83 + 672.287859314619*x_84 - 268.515620422041*x_85 - 435.92769482667*x_86 - 45.9833676457108*x_87 + 143.662587896337*x_88 + 55.1145297296009*x_89 - 5509.24602023022*x_9 - 543.230880887665*x_90 - 223.12645584665*x_91 + 0.353572865037361*x_92 + 5737.33813930958*x_93 + 41.3243131782074*x_94 - 492.223088870422*x_95 - 609.405231557366*x_96 - 695.512248348576*x_97 - 102.138367036855*x_98 + 414.012429187901*x_99 + 1.38132601369477*std::pow(-9.58376026153564*x_100 - 9.79407978057861, 2) - 0.787126339524731*std::pow(-6.21119976043701*x_14 - 8.61127948760986, 2) - 0.00230667873971452*std::pow(-7.13375997543335*x_15 - 9.79415988922119, 2) + 0.00557867017277279*std::pow(-6.92288017272949*x_27 - 9.48711967468262, 2) + 8.40091338584422*std::pow(-3.31655979156494*x_55 - 5.26735973358154, 2) - 16.2422512068091*std::pow(-1.93759977817535*x_67 - 2.71135997772217, 2) - 1.38763942360077e-5*std::pow(-9.79600048065186*x_76 - 9.91380023956299, 2) + 3.26362265428555*std::pow(-9.48680019378662*x_85 - 8.87896060943604, 2) + 4.84779969076156*std::pow(-5.09360027313232*x_87 - 6.66383981704712, 2) + 11.2858451490174*std::exp(0.924879848957062*x_1) - 0.0303909232180295*std::exp(0.940159797668457*x_1) + 8.82667678553597*std::exp(1.05847978591919*x_1) - 0.108685690511032*std::exp(1.14207983016968*x_1) + 0.135148462165471*std::exp(1.24071979522705*x_108) + 1.90864235895479*std::exp(3.36735987663269*x_17) - 0.00236045033630869*std::exp(3.41799974441528*x_17) + 4.36533373229378e-5*std::exp(3.64247989654541*x_17) + 0.00787395595925906*std::exp(0.811679840087891*x_22) - 0.123661313452668*std::exp(1.71975982189178*x_50) + 230.64399380823*std::exp(1.89559984207153*x_50) + 1.59416794855517*std::exp(1.9236798286438*x_50) + 65.9480951406872*std::exp(1.96079981327057*x_50) + 0.00114995143490107*std::exp(2.01327991485596*x_50) - 220.409586185544*std::exp(1.40999984741211*x_71) - 0.0338672679212135*std::exp(1.89591979980469*x_71) + 338.438777346315*std::exp(1.12383985519409*x_72) + 94.4390364137938*std::exp(1.54359984397888*x_78) + 0.00443462322888566*std::exp(0.696879863739014*x_87) + 0.0600926380647851*std::sin(0.357039839029312*x_102 - 7.42975997924805) + 0.0452151159781211*std::sin(0.315199851989746*x_105 - 4.27816009521484) - 2.473780539685*std::sin(0.407839864492416*x_112 - 7.37943983078003) - 2378.28271277534*std::sin(0.412239879369736*x_117 - 4.20151996612549) - 3.60648591646885*std::sin(0.336319833993912*x_118 + 1.96023988723755) - 0.0438164079885084*std::sin(0.35879984498024*x_120 + 5.16232013702393) - 6622.4190087774*std::sin(0.22639998793602*x_14 - 7.56480026245117) - 9.88884616128844*std::sin(0.398159831762314*x_21 + 1.96975982189178) - 81025.0852018828*std::sin(0.0848800837993622*x_26 - 1.48327994346619) + 16.280072891482*std::sin(0.325519859790802*x_28 - 4.27144002914429) + 2500.04004920305*std::sin(0.439279854297638*x_36 + 5.20919990539551) + 14.2279778141633*std::sin(0.469599843025208*x_41 - 1.14487981796265) + 16.7977419687502*std::sin(0.34063982963562*x_53 - 4.25999975204468) - 1869.57274306198*std::sin(0.301439940929413*x_55 + 5.11815977096558) - 10.9581051622714*std::sin(0.354079842567444*x_67 + 5.14880037307739) - 1.2772198115321*std::sin(0.584159851074219*x_69 + 8.59424018859863) + 1199.56158081607*std::sin(0.649519801139832*x_69 + 8.64799976348877) + 122.061541181937*std::sin(0.979519844055176*x_7 - 0.994799792766571) + 1.80495139706407*std::sin(0.333439826965332*x_75 + 5.14296007156372) + 1025.95301218664*std::sin(0.341919839382172*x_76 - 7.45951986312866) + 9.39230116993106*std::sin(0.165280014276505*x_85 - 7.63127994537354) - 1182.34498124585*std::sin(0.344719856977463*x_92 + 5.18096017837524) + 1901.60730975085*std::sin(0.366639852523804*x_92 + 1.98431980609894) - 8.44944057775144*std::sin(0.366079837083817*x_94 - 7.41951990127563) + 2.08850165984363*std::sin(0.369119822978973*x_95 + 5.17471981048584) - 2.96761420446561*std::sin(0.371599853038788*x_97 - 7.41527986526489) + 8.36200413137227*std::sin(0.445759862661362*x_98 - 7.37967967987061) - 52141.1122276736 - 0.245040052469188*std::exp(-4.21368026733398*x_111));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0124956995573457*x_1 - 146.814142823822*x_10 - 1141.6849751833*x_100 - 12165.9183515584*x_101 - 15.3393471597488*x_102 - 60.1504132015099*x_103 + 550.249558195802*x_104 - 79.8541930277886*x_105 + 349.534284415382*x_106 - 1691.22568756279*x_107 + 522.82195968927*x_108 + 973.865126044851*x_109 - 311.441914846747*x_11 + 491.644029563125*x_110 - 206.879722617571*x_111 - 981.418667590476*x_112 - 722.265924735842*x_113 + 926.565636104047*x_114 + 477.296951655497*x_115 - 1696.11961605014*x_116 + 288.098581207271*x_117 + 635.68905243424*x_118 + 864.502471489436*x_119 + 318.891520147946*x_12 + 878.119788904383*x_120 + 398.903599882763*x_13 - 0.684882039429586*x_14 - 85.456465606581*x_15 + 317.095690383728*x_16 - 29.004868959948*x_17 + 883.348574953099*x_18 - 463.721891711867*x_19 + 964.002148848864*x_2 + 446.227753462814*x_20 + 320.858014857256*x_21 + 5.28121122090937*x_22 - 1617.58555495177*x_23 - 592.839134145878*x_24 + 598.477493191693*x_25 + 242.322780845084*x_26 + 308.08213326982*x_27 - 93.3787895535492*x_28 + 113.684120471823*x_29 - 358.663944030463*x_3 - 2010.70812686913*x_30 - 6610.8468211999*x_31 + 2774.63525420538*x_32 - 3233.5004251904*x_33 + 918.34752953258*x_34 + 906.569278263133*x_35 + 21.1200933351812*x_36 + 429.989329133086*x_37 + 1074.12990293888*x_38 + 1297.89226295601*x_39 + 3264.55919849128*x_4 - 3106.9771350313*x_40 - 738.729236530236*x_41 - 1998.825840665*x_42 + 899.186763048138*x_43 + 157.283262536701*x_44 + 744.480297647294*x_45 - 295.591473902414*x_46 - 453.066223142382*x_47 + 700.496431153762*x_48 + 838.310874122045*x_49 - 138.407813305344*x_5 + 818.967330747209*x_51 - 622.918915571945*x_52 + 181.956695546279*x_53 - 1043.11748212754*x_54 - 2.38423025934872*x_55 + 1302.8093136805*x_56 - 1481.52332466508*x_57 + 866.466004990453*x_58 - 185.819331504243*x_59 - 340.16411630549*x_6 + 460.558193088784*x_60 + 261.139579939083*x_61 - 1562.51811633372*x_62 - 359.049300846412*x_63 - 376.416026144001*x_64 - 431.006223612729*x_65 + 239.77839859158*x_66 - 516.157989543936*x_67 + 355.817420979437*x_68 + 271.630869652431*x_69 + 109.735487564759*x_7 + 757.783140239923*x_70 + 0.497064497262439*x_71 - 267.267798570482*x_72 + 607.721950143562*x_73 + 139.857677843406*x_74 + 772.479054355607*x_75 - 227.762993455211*x_76 + 368.161822777641*x_77 - 130.237533748902*x_78 - 217.289755846445*x_79 + 435.824951080727*x_8 + 575.801009293504*x_80 + 1015.50771649661*x_81 + 1212.12172140118*x_82 - 2185.04284035938*x_83 + 1334.16783708863*x_84 - 267.160619772216*x_85 - 687.56150214136*x_86 - 75.6677986603182*x_87 + 273.296183920686*x_88 + 75.0791444172829*x_89 - 8365.42889114088*x_9 - 1145.24577805592*x_90 + 140.146028440034*x_91 + 1.1159752553385*x_92 + 8107.40527393704*x_93 + 166.483663373386*x_94 - 675.148843016485*x_95 - 740.832324212302*x_96 - 1150.48707195695*x_97 - 37.6527299615813*x_98 + 685.227833536412*x_99 + 1.37426459551208*std::pow(-9.58376026153564*x_100 - 9.79407978057861, 2) - 0.783102504317915*std::pow(-6.21119976043701*x_14 - 8.61127948760986, 2) - 0.0112432155595414*std::pow(-7.13375997543335*x_15 - 9.79415988922119, 2) + 0.00570081040175973*std::pow(-6.92288017272949*x_27 - 9.48711967468262, 2) + 13.4927505568102*std::pow(-3.31655979156494*x_55 - 5.26735973358154, 2) - 16.1592198826593*std::pow(-1.93759977817535*x_67 - 2.71135997772217, 2) + 1.90105254524691e-5*std::pow(-9.79600048065186*x_76 - 9.91380023956299, 2) + 5.241721270455*std::pow(-9.48680019378662*x_85 - 8.87896060943604, 2) + 4.8230174593817*std::pow(-5.09360027313232*x_87 - 6.66383981704712, 2) + 11.2281512582543*std::exp(0.924879848957062*x_1) - 0.148131464911349*std::exp(0.940159797668457*x_1) + 14.176571361098*std::exp(1.05847978591919*x_1) - 0.111065271076918*std::exp(1.14207983016968*x_1) + 0.138107422563719*std::exp(1.24071979522705*x_108) + 1.89888526922785*std::exp(3.36735987663269*x_17) - 0.0115053091233654*std::exp(3.41799974441528*x_17) - 5.98046485382707e-5*std::exp(3.64247989654541*x_17) - 0.0107872432585326*std::exp(0.811679840087891*x_22) - 0.602750083740068*std::exp(1.71975982189178*x_50) + 370.438514593517*std::exp(1.89559984207153*x_50) + 1.62907089715221*std::exp(1.9236798286438*x_50) + 65.6109646779844*std::exp(1.96079981327057*x_50) - 0.00157542230715546*std::exp(2.01327991485596*x_50) - 354.000979434267*std::exp(1.40999984741211*x_71) - 0.16507586734773*std::exp(1.89591979980469*x_71) + 543.568275466366*std::exp(1.12383985519409*x_72) + 151.679026152557*std::exp(1.54359984397888*x_78) - 0.00607539079180096*std::exp(0.696879863739014*x_87) - 0.0823263310343421*std::sin(0.357039839029312*x_102 - 7.42975997924805) - 0.0619442701410097*std::sin(0.315199851989746*x_105 - 4.27816009521484) - 12.0577033012058*std::sin(0.407839864492416*x_112 - 7.37943983078003) - 3819.77219895201*std::sin(0.412239879369736*x_117 - 4.20151996612549) - 17.5787368536322*std::sin(0.336319833993912*x_118 + 1.96023988723755) + 0.0600280537677312*std::sin(0.35879984498024*x_120 + 5.16232013702393) - 10636.3015143897*std::sin(0.22639998793602*x_14 - 7.56480026245117) - 10.1053540201777*std::sin(0.398159831762314*x_21 + 1.96975982189178) - 130134.809545288*std::sin(0.0848800837993622*x_26 - 1.48327994346619) + 16.636511212678*std::sin(0.325519859790802*x_28 - 4.27144002914429) + 4015.3272884318*std::sin(0.439279854297638*x_36 + 5.20919990539551) + 14.5394872625484*std::sin(0.469599843025208*x_41 - 1.14487981796265) + 17.1655142132073*std::sin(0.34063982963562*x_53 - 4.25999975204468) - 1860.01537946292*std::sin(0.301439940929413*x_55 + 5.11815977096558) - 11.1980235357065*std::sin(0.354079842567444*x_67 + 5.14880037307739) - 6.22542593848565*std::sin(0.584159851074219*x_69 + 8.59424018859863) + 1926.62207597057*std::sin(0.649519801139832*x_69 + 8.64799976348877) + 121.437555549462*std::sin(0.979519844055176*x_7 - 0.994799792766571) + 8.7976957008752*std::sin(0.333439826965332*x_75 + 5.14296007156372) + 1020.70828126648*std::sin(0.341919839382172*x_76 - 7.45951986312866) + 45.7799626950812*std::sin(0.165280014276505*x_85 - 7.63127994537354) - 1898.97040611419*std::sin(0.344719856977463*x_92 + 5.18096017837524) + 1891.88618360084*std::sin(0.366639852523804*x_92 + 1.98431980609894) - 8.63443387812881*std::sin(0.366079837083817*x_94 - 7.41951990127563) + 10.1797766432737*std::sin(0.369119822978973*x_95 + 5.17471981048584) - 14.4647477881957*std::sin(0.371599853038788*x_97 - 7.41527986526489) + 8.54508308527427*std::sin(0.445759862661362*x_98 - 7.37967967987061) - 35433.0656972661 - 0.393560099067987*std::exp(-4.21368026733398*x_111));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00847145824578658*x_1 + 1491.99672250295*x_10 + 4717.16685954795*x_100 + 113247.946421471*x_101 - 2162.56729686908*x_102 - 381.229257484599*x_103 + 1977.34734094671*x_104 - 1007.43935477907*x_105 - 1981.08631053716*x_106 + 3045.46240877605*x_107 - 2138.99670153587*x_108 - 1211.67832747583*x_109 + 3696.04462273802*x_11 + 449.829661885465*x_110 - 411.824921817236*x_111 + 2111.70825296914*x_112 + 244.623036598427*x_113 - 4036.07880574232*x_114 - 4378.29488792838*x_115 + 9858.75877692837*x_116 + 566.525283726732*x_117 - 4116.90961574312*x_118 - 247.053244868219*x_119 - 2994.46825950555*x_12 - 3393.40516889316*x_120 - 3381.22672810458*x_13 - 0.754348447398724*x_14 + 1397.72785189221*x_15 - 2720.60254784523*x_16 + 117.82513457079*x_17 - 2018.52447778316*x_18 + 867.160330951589*x_19 - 2487.35658760213*x_2 - 4578.56859869384*x_20 + 133.986683908947*x_21 - 967.031517804653*x_22 + 6078.11593033695*x_23 + 2066.82973575307*x_24 - 1833.66788147794*x_25 + 479.824083950339*x_26 - 2928.83098035248*x_27 + 44.7082495469727*x_28 - 19.4235063000378*x_29 - 205.181221012422*x_3 + 7223.94121987208*x_30 + 19318.6132571183*x_31 - 12238.8831050439*x_32 + 12340.6315101238*x_33 - 5769.06054458264*x_34 - 4119.02355120591*x_35 + 40.6006991694373*x_36 - 1776.92079889486*x_37 - 4374.59076836273*x_38 - 2632.81079131379*x_39 - 7991.38461405193*x_4 + 10394.2504070681*x_40 + 1991.90630755696*x_41 + 3924.39401456538*x_42 - 5098.69719733063*x_43 - 1551.45720245338*x_44 - 3238.98639400356*x_45 + 1922.7759779352*x_46 + 2571.57529912142*x_47 - 1770.1264233912*x_48 - 1104.03760717348*x_49 + 1391.40863801599*x_5 - 5141.05938584388*x_51 + 1581.03157128979*x_52 + 290.21513597921*x_53 + 3698.93968169171*x_54 - 1.79664983378796*x_55 - 3123.49819695922*x_56 + 7123.00973004826*x_57 - 3276.88334977807*x_58 + 936.785079004436*x_59 + 700.371398780626*x_6 - 3261.05446939128*x_60 - 1358.84961596901*x_61 + 5705.30353414178*x_62 + 1856.87553085721*x_63 - 1138.21093064578*x_64 + 3890.18156469025*x_65 - 4114.38287583279*x_66 + 2152.3789208981*x_67 - 1105.10381314037*x_68 + 538.311062426679*x_69 - 466.819373517256*x_7 - 948.204041027146*x_70 - 0.200309513616161*x_71 - 546.374753483804*x_72 - 2709.56753097262*x_73 + 436.125629410321*x_74 - 3649.14539944175*x_75 + 949.837503113482*x_76 - 501.636844164618*x_77 - 260.956369665564*x_78 + 1818.27011343558*x_79 - 20152.5039038564*x_8 - 2678.91332673068*x_80 - 5359.44369641378*x_81 - 5910.20055070682*x_82 + 7363.27918423222*x_83 - 8069.04030955682*x_84 - 530.766554545254*x_85 + 2732.1541088104*x_86 + 337.353697851696*x_87 - 1545.30618768618*x_88 - 165.450148790514*x_89 + 30025.8170070312*x_9 + 7490.57446373744*x_90 - 5505.91156460416*x_91 + 0.257550630672643*x_92 - 22161.4443015087*x_93 - 1683.88520082027*x_94 + 1650.26022987416*x_95 + 703.029878675121*x_96 + 5112.52161569592*x_97 - 1114.42781669497*x_98 - 3031.18501546246*x_99 + 2.73354586402521*std::pow(-9.58376026153564*x_100 - 9.79407978057861, 2) - 1.55766700151973*std::pow(-6.21119976043701*x_14 - 8.61127948760986, 2) - 0.000715970153974253*std::pow(-7.13375997543335*x_15 - 9.79415988922119, 2) + 0.006637420002369*std::pow(-6.92288017272949*x_27 - 9.48711967468262, 2) - 56.041627772409*std::pow(-3.31655979156494*x_55 - 5.26735973358154, 2) - 32.1422590819622*std::pow(-1.93759977817535*x_67 - 2.71135997772217, 2) + 1.28881837997123e-5*std::pow(-9.79600048065186*x_76 - 9.91380023956299, 2) - 21.7712905229165*std::pow(-9.48680019378662*x_85 - 8.87896060943604, 2) + 9.5934505416707*std::pow(-5.09360027313232*x_87 - 6.66383981704712, 2) + 22.3338842700912*std::exp(0.924879848957062*x_1) - 0.00943304050156772*std::exp(0.940159797668457*x_1) - 58.8818515515098*std::exp(1.05847978591919*x_1) - 0.129312641512673*std::exp(1.14207983016968*x_1) + 0.160797659349818*std::exp(1.24071979522705*x_108) + 3.77706737909669*std::exp(3.36735987663269*x_17) - 0.000732660323103626*std::exp(3.41799974441528*x_17) - 4.05445554025082e-5*std::exp(3.64247989654541*x_17) - 0.00731321047152424*std::exp(0.811679840087891*x_22) - 0.0383832425855378*std::exp(1.71975982189178*x_50) - 1538.60232278109*std::exp(1.89559984207153*x_50) + 1.89671765872052*std::exp(1.9236798286438*x_50) + 130.506586370566*std::exp(1.96079981327057*x_50) - 0.00106805739312951*std::exp(2.01327991485596*x_50) + 1470.32964383309*std::exp(1.40999984741211*x_71) - 0.010512063344911*std::exp(1.89591979980469*x_71) - 2257.69021922673*std::exp(1.12383985519409*x_72) - 629.993083228885*std::exp(1.54359984397888*x_78) - 0.00411881057025915*std::exp(0.696879863739014*x_87) - 0.0558131277633228*std::sin(0.357039839029312*x_102 - 7.42975997924805) - 0.0419951116507762*std::sin(0.315199851989746*x_105 - 4.27816009521484) - 0.767836891805739*std::sin(0.407839864492416*x_112 - 7.37943983078003) + 15865.2789768665*std::sin(0.412239879369736*x_117 - 4.20151996612549) - 1.11941738243087*std::sin(0.336319833993912*x_118 + 1.96023988723755) + 0.040696012955131*std::sin(0.35879984498024*x_120 + 5.16232013702393) + 44177.4749955398*std::sin(0.22639998793602*x_14 - 7.56480026245117) - 11.7656042172255*std::sin(0.398159831762314*x_21 + 1.96975982189178) + 540509.996539541*std::sin(0.0848800837993622*x_26 - 1.48327994346619) + 19.3697921015896*std::sin(0.325519859790802*x_28 - 4.27144002914429) - 16677.5096252791*std::sin(0.439279854297638*x_36 + 5.20919990539551) + 16.9282394571198*std::sin(0.469599843025208*x_41 - 1.14487981796265) + 19.9857071820038*std::sin(0.34063982963562*x_53 - 4.25999975204468) - 3699.7513900586*std::sin(0.301439940929413*x_55 + 5.11815977096558) - 13.0377929039623*std::sin(0.354079842567444*x_67 + 5.14880037307739) - 0.396436334794837*std::sin(0.584159851074219*x_69 + 8.59424018859863) - 8002.15173215016*std::sin(0.649519801139832*x_69 + 8.64799976348877) + 241.551102163023*std::sin(0.979519844055176*x_7 - 0.994799792766571) + 0.560238973647426*std::sin(0.333439826965332*x_75 + 5.14296007156372) + 2030.28798802214*std::sin(0.341919839382172*x_76 - 7.45951986312866) + 2.91527692999864*std::sin(0.165280014276505*x_85 - 7.63127994537354) + 7887.30156999438*std::sin(0.344719856977463*x_92 + 5.18096017837524) + 3763.14551744781*std::sin(0.366639852523804*x_92 + 1.98431980609894) - 10.0530205519787*std::sin(0.366079837083817*x_94 - 7.41951990127563) + 0.648250156915559*std::sin(0.369119822978973*x_95 + 5.17471981048584) - 0.921117952979607*std::sin(0.371599853038788*x_97 - 7.41527986526489) + 9.94898994967399*std::sin(0.445759862661362*x_98 - 7.37967967987061) - 127997.766801069 + 1.6346369470907*std::exp(-4.21368026733398*x_111));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00785277675600506*x_1 - 10.8112762733146*x_10 - 710.613019689592*x_100 - 1800.51037276566*x_101 - 209.111541855682*x_102 - 101.835910601407*x_103 + 736.818216688714*x_104 - 172.274001391466*x_105 + 169.116646792156*x_106 - 1426.53004069643*x_107 + 331.097767004163*x_108 + 874.315425797063*x_109 + 27.4223949046281*x_11 + 532.966175855135*x_110 - 244.550668164142*x_111 - 793.570784821987*x_112 - 702.082612836072*x_113 + 557.475643721064*x_114 + 80.4775022223274*x_115 - 810.381036462299*x_116 + 337.337278777466*x_117 + 261.681367512246*x_118 + 841.048031078314*x_119 + 45.3290843117757*x_12 + 575.117203722025*x_120 + 92.1648319386633*x_13 - 0.709524955665784*x_14 + 42.3914241020495*x_15 + 68.7824229446051*x_16 - 18.3926084685314*x_17 + 698.765567818768*x_18 - 389.188352957943*x_19 + 737.236271465107*x_2 + 38.5612021258614*x_20 + 330.588287956679*x_21 - 85.8079979467793*x_22 - 1071.34635168363*x_23 - 407.536984999171*x_24 + 439.497085555688*x_25 + 287.621408921763*x_26 + 45.1579153637928*x_27 - 90.9209666959954*x_28 + 115.294578933953*x_29 - 376.886268351462*x_3 - 1359.42736957406*x_30 - 4902.83723150523*x_31 + 1679.25589711221*x_32 - 2118.28593182973*x_33 + 390.52938412356*x_34 + 529.440428155668*x_35 + 20.8496526618504*x_36 + 265.0552677425*x_37 + 681.356127251372*x_38 + 1069.03015160253*x_39 + 2540.84168709734*x_4 - 2172.22790697682*x_40 - 558.67110690781*x_41 - 1641.80101155785*x_42 + 432.677405893892*x_43 + 18.7454065314135*x_44 + 452.669881950162*x_45 - 120.176035806852*x_46 - 220.66054227214*x_47 + 569.459894184692*x_48 + 736.127539691657*x_49 - 12.0871740065555*x_5 + 345.377043695318*x_51 - 480.88630371026*x_52 + 207.775399174648*x_53 - 709.144679616619*x_54 - 0.730377304546089*x_55 + 1025.79954667348*x_56 - 834.194548627301*x_57 + 575.309463670826*x_58 - 97.7306834283353*x_59 - 277.374052940479*x_6 + 168.107359231227*x_60 + 141.979336410136*x_61 - 1050.7740228045*x_62 - 192.376481618882*x_63 - 481.365874131597*x_64 - 77.7557579655025*x_65 - 134.091325937964*x_66 - 326.079186332681*x_67 + 257.939000920388*x_68 + 322.822869026835*x_69 + 71.3883673700455*x_7 + 672.939771754326*x_70 + 0.561989507731016*x_71 - 324.756554772045*x_72 + 366.281249277036*x_73 + 180.425751539191*x_74 + 442.188086715851*x_75 - 144.244340830696*x_76 + 323.89039589325*x_77 - 156.034599007122*x_78 - 55.6890171595526*x_79 - 1350.80043857402*x_8 + 332.324309672218*x_80 + 530.487477287284*x_81 + 672.636116131808*x_82 - 1532.87194342078*x_83 + 598.327213338128*x_84 - 317.537957190196*x_85 - 441.346420673634*x_86 - 46.2211814278564*x_87 + 130.131632617131*x_88 + 57.9784718547285*x_89 - 5681.83969512998*x_9 - 465.96876896596*x_90 - 376.295117661457*x_91 - 0.888004351910226*x_92 + 6035.50305016683*x_93 + 11.1321236848248*x_94 - 527.751124872615*x_95 - 681.821828971797*x_96 - 688.110772576561*x_97 - 138.842923792559*x_98 + 407.57708256075*x_99 + 1.63347565897502*std::pow(-9.58376026153564*x_100 - 9.79407978057861, 2) - 0.930809746145754*std::pow(-6.21119976043701*x_14 - 8.61127948760986, 2) + 0.0129287193185105*std::pow(-7.13375997543335*x_15 - 9.79415988922119, 2) + 0.00666707538642741*std::pow(-6.92288017272949*x_27 - 9.48711967468262, 2) + 8.42998172261275*std::pow(-3.31655979156494*x_55 - 5.26735973358154, 2) - 19.2071399005325*std::pow(-1.93759977817535*x_67 - 2.71135997772217, 2) + 1.19469431629246e-5*std::pow(-9.79600048065186*x_76 - 9.91380023956299, 2) + 3.27491524570306*std::pow(-9.48680019378662*x_85 - 8.87896060943604, 2) + 5.73272545071712*std::pow(-5.09360027313232*x_87 - 6.66383981704712, 2) + 13.3459828882617*std::exp(0.924879848957062*x_1) + 0.170338291740155*std::exp(0.940159797668457*x_1) + 8.85721832329081*std::exp(1.05847978591919*x_1) - 0.129890398539695*std::exp(1.14207983016968*x_1) + 0.161516088550021*std::exp(1.24071979522705*x_108) + 2.25704924408253*std::exp(3.36735987663269*x_17) + 0.013230104105089*std::exp(3.41799974441528*x_17) - 3.75835343821391e-5*std::exp(3.64247989654541*x_17) - 0.00677911730617591*std::exp(0.811679840087891*x_22) + 0.693110134784419*std::exp(1.71975982189178*x_50) + 231.442054325906*std::exp(1.89559984207153*x_50) + 1.90519201933046*std::exp(1.9236798286438*x_50) + 77.9863747588013*std::exp(1.96079981327057*x_50) - 0.000990055788213121*std::exp(2.01327991485596*x_50) - 221.172234219631*std::exp(1.40999984741211*x_71) + 0.18982287975323*std::exp(1.89591979980469*x_71) + 339.609822910481*std::exp(1.12383985519409*x_72) + 94.7658087049113*std::exp(1.54359984397888*x_78) - 0.00381800853762171*std::exp(0.696879863739014*x_87) - 0.0517370232684263*std::sin(0.357039839029312*x_102 - 7.42975997924805) - 0.0389281546422156*std::sin(0.315199851989746*x_105 - 4.27816009521484) + 13.8653093309123*std::sin(0.407839864492416*x_112 - 7.37943983078003) - 2386.51190401331*std::sin(0.412239879369736*x_117 - 4.20151996612549) + 20.2140173823934*std::sin(0.336319833993912*x_118 + 1.96023988723755) + 0.0377239307949232*std::sin(0.35879984498024*x_120 + 5.16232013702393) - 6645.33350594313*std::sin(0.22639998793602*x_14 - 7.56480026245117) - 11.818171858209*std::sin(0.398159831762314*x_21 + 1.96975982189178) - 81305.4433433339*std::sin(0.0848800837993622*x_26 - 1.48327994346619) + 19.4563345568959*std::sin(0.325519859790802*x_28 - 4.27144002914429) + 2508.69053787581*std::sin(0.439279854297638*x_36 + 5.20919990539551) + 17.0038732790498*std::sin(0.469599843025208*x_41 - 1.14487981796265) + 20.0750014894229*std::sin(0.34063982963562*x_53 - 4.25999975204468) - 2210.84779277147*std::sin(0.301439940929413*x_55 + 5.11815977096558) - 13.0960445673651*std::sin(0.354079842567444*x_67 + 5.14880037307739) + 7.15869798729881*std::sin(0.584159851074219*x_69 + 8.59424018859863) + 1203.71223187081*std::sin(0.649519801139832*x_69 + 8.64799976348877) + 144.342866521682*std::sin(0.979519844055176*x_7 - 0.994799792766571) - 10.1165843315843*std::sin(0.333439826965332*x_75 + 5.14296007156372) + 1213.23225367802*std::sin(0.341919839382172*x_76 - 7.45951986312866) - 52.6429725519491*std::sin(0.165280014276505*x_85 - 7.63127994537354) - 1186.43606045509*std::sin(0.344719856977463*x_92 + 5.18096017837524) + 2248.73000480056*std::sin(0.366639852523804*x_92 + 1.98431980609894) - 10.0979365261539*std::sin(0.366079837083817*x_94 - 7.41951990127563) - 11.7058571232608*std::sin(0.369119822978973*x_95 + 5.17471981048584) + 16.6332009891889*std::sin(0.371599853038788*x_97 - 7.41527986526489) + 9.99344112465546*std::sin(0.445759862661362*x_98 - 7.37967967987061) - 44532.5661011455 - 0.245887925365837*std::exp(-4.21368026733398*x_111));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00177883279914245*x_1 - 309.377970848014*x_10 - 557.406828774938*x_100 - 22962.0667778422*x_101 + 591.002706998284*x_102 + 142.956518669333*x_103 - 877.814773005064*x_104 + 321.533349957009*x_105 + 314.97607117644*x_106 + 232.64188937904*x_107 + 249.074984041845*x_108 - 284.953449188457*x_109 - 802.568252127971*x_11 - 429.034978476194*x_110 + 238.979427507828*x_111 + 45.3313226667718*x_112 + 381.540116383252*x_113 + 511.136561204811*x_114 + 879.964364537476*x_115 - 1589.7508890788*x_116 - 333.053375636529*x_117 + 711.447981877319*x_118 - 472.444464568224*x_119 + 609.778907021302*x_12 + 363.616319954179*x_120 + 661.620419596027*x_13 + 0.97377166878519*x_14 - 323.86850566424*x_15 + 534.480079948497*x_16 - 13.3338571063677*x_17 - 7.01985293828085*x_18 + 55.7319908112405*x_19 + 68.9309694233026*x_2 + 952.157970339755*x_20 - 235.377249682933*x_21 + 257.583034920634*x_22 - 626.14905773214*x_23 - 185.845995542235*x_24 + 117.294896747278*x_25 - 282.064339235866*x_26 + 595.45456598279*x_27 + 46.6915694268718*x_28 - 67.829621442348*x_29 + 279.26242879108*x_3 - 690.86048514138*x_30 - 1050.60878405165*x_31 + 1563.57983191177*x_32 - 1302.98276549297*x_33 + 983.961907380211*x_34 + 545.378067273125*x_35 - 21.4204915238939*x_36 + 212.052739231158*x_37 + 505.619384143628*x_38 - 101.280969418319*x_39 + 114.446682649021*x_4 - 858.530729467207*x_40 - 75.3812168545903*x_41 + 189.098605800708*x_42 + 811.800410956922*x_43 + 318.034680462619*x_44 + 406.952564424114*x_45 - 332.503102016596*x_46 - 410.802600278146*x_47 + 39.5055484858118*x_48 - 224.673604768012*x_49 - 287.771214635794*x_5 + 876.890523908025*x_51 - 36.5388214161752*x_52 - 191.418948819991*x_53 - 345.24193011104*x_54 + 2.21406927737336*x_55 + 26.6476720153159*x_56 - 991.264319655013*x_57 + 341.264613003302*x_58 - 137.359719700351*x_59 + 22.9886420684263*x_6 + 588.061502874987*x_60 + 200.230856238836*x_61 - 558.935891028666*x_62 - 275.349540035493*x_63 + 539.833825882637*x_64 - 777.80644393138*x_65 + 958.253976535103*x_66 - 255.939389193833*x_67 + 76.5211894680576*x_68 - 316.357700795459*x_69 + 56.339067665665*x_7 - 217.714980556566*x_70 - 1.07391596407685*x_71 + 310.172492854145*x_72 + 348.92712602395*x_73 - 205.876243903564*x_74 + 500.308735834641*x_75 - 112.775482663692*x_76 - 94.6625165148223*x_77 + 151.508934510227*x_78 - 353.753499013431*x_79 + 5119.88626130162*x_8 + 361.618056658012*x_80 + 809.455424354908*x_81 + 836.305467167993*x_82 - 616.964894884553*x_83 + 1341.6214321603*x_84 + 310.590359155629*x_85 - 307.113169396657*x_86 - 45.4022306190684*x_87 + 247.835157596474*x_88 - 0.994717522074414*x_89 - 2859.38215922352*x_9 - 1304.61394869974*x_90 + 1399.81870977253*x_91 - 0.218034426477667*x_92 + 974.789502621429*x_93 + 350.285411917964*x_94 - 22.4365882922614*x_95 + 273.196470498907*x_96 - 658.735909858526*x_97 + 323.49298587736*x_98 + 390.071667185877*x_99 - 1.59626237241874*std::pow(-9.58376026153564*x_100 - 9.79407978057861, 2) + 0.909604355283404*std::pow(-6.21119976043701*x_14 - 8.61127948760986, 2) - 0.000408169816935235*std::pow(-7.13375997543335*x_15 - 9.79415988922119, 2) - 0.0086002028043361*std::pow(-6.92288017272949*x_27 - 9.48711967468262, 2) + 6.6662262887121*std::pow(-3.31655979156494*x_55 - 5.26735973358154, 2) + 18.7695693759165*std::pow(-1.93759977817535*x_67 - 2.71135997772217, 2) - 2.70625474376942e-6*std::pow(-9.79600048065186*x_76 - 9.91380023956299, 2) + 2.58972401394999*std::pow(-9.48680019378662*x_85 - 8.87896060943604, 2) - 5.60212445046721*std::pow(-5.09360027313232*x_87 - 6.66383981704712, 2) - 13.041939248023*std::exp(0.924879848957062*x_1) - 0.00537771357268898*std::exp(0.940159797668457*x_1) + 7.00407469131307*std::exp(1.05847978591919*x_1) + 0.167552293176636*std::exp(1.14207983016968*x_1) - 0.208347894268768*std::exp(1.24071979522705*x_108) - 2.20562991632567*std::exp(3.36735987663269*x_17) - 0.000417684771211387*std::exp(3.41799974441528*x_17) + 8.51352658351362e-6*std::exp(3.64247989654541*x_17) + 0.00153562447884926*std::exp(0.811679840087891*x_22) - 0.0218820309932683*std::exp(1.71975982189178*x_50) + 183.018796200035*std::exp(1.89559984207153*x_50) - 2.45760499135808*std::exp(1.9236798286438*x_50) - 76.2097157094673*std::exp(1.96079981327057*x_50) + 0.000224270186683656*std::exp(2.01327991485596*x_50) - 174.897670078356*std::exp(1.40999984741211*x_71) - 0.00599285731016409*std::exp(1.89591979980469*x_71) + 268.555259534897*std::exp(1.12383985519409*x_72) + 74.9385166002407*std::exp(1.54359984397888*x_78) + 0.000864865897140628*std::exp(0.696879863739014*x_87) + 0.0117196141924569*std::sin(0.357039839029312*x_102 - 7.42975997924805) + 0.00881811369904398*std::sin(0.315199851989746*x_105 - 4.27816009521484) - 0.437738698777853*std::sin(0.407839864492416*x_112 - 7.37943983078003) - 1887.19607187086*std::sin(0.412239879369736*x_117 - 4.20151996612549) - 0.638172395210431*std::sin(0.336319833993912*x_118 + 1.96023988723755) - 0.00854532956883995*std::sin(0.35879984498024*x_120 + 5.16232013702393) - 5254.96950909728*std::sin(0.22639998793602*x_14 - 7.56480026245117) + 15.244866581831*std::sin(0.398159831762314*x_21 + 1.96975982189178) - 64294.3842187524*std::sin(0.0848800837993622*x_26 - 1.48327994346619) - 25.0977247623386*std::sin(0.325519859790802*x_28 - 4.27144002914429) + 1983.8119896478*std::sin(0.439279854297638*x_36 + 5.20919990539551) - 21.9341690596094*std::sin(0.469599843025208*x_41 - 1.14487981796265) - 25.8957749987137*std::sin(0.34063982963562*x_53 - 4.25999975204468) + 2160.48101075505*std::sin(0.301439940929413*x_55 + 5.11815977096558) + 16.893260190705*std::sin(0.354079842567444*x_67 + 5.14880037307739) - 0.226005714486115*std::sin(0.584159851074219*x_69 + 8.59424018859863) + 951.866609937861*std::sin(0.649519801139832*x_69 + 8.64799976348877) - 141.054496459531*std::sin(0.979519844055176*x_7 - 0.994799792766571) + 0.319388508088394*std::sin(0.333439826965332*x_75 + 5.14296007156372) - 1185.59280936345*std::sin(0.341919839382172*x_76 - 7.45951986312866) + 1.66197996414785*std::sin(0.165280014276505*x_85 - 7.63127994537354) - 938.205030132667*std::sin(0.344719856977463*x_92 + 5.18096017837524) - 2197.50020312182*std::sin(0.366639852523804*x_92 + 1.98431980609894) + 13.0258467163925*std::sin(0.366079837083817*x_94 - 7.41951990127563) + 0.369563097578473*std::sin(0.369119822978973*x_95 + 5.17471981048584) - 0.525123211011622*std::sin(0.371599853038788*x_97 - 7.41527986526489) - 12.8910527335861*std::sin(0.445759862661362*x_98 - 7.37967967987061) + 77458.3660439154 - 0.194442242710176*std::exp(-4.21368026733398*x_111));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0119223416699369*x_1 + 438.588482576277*x_10 - 1216.41303688531*x_100 + 28473.9211768642*x_101 - 1487.67207588731*x_102 - 493.317328651538*x_103 + 3431.81250748609*x_104 - 974.13605004308*x_105 + 15.6528597277469*x_106 - 4531.71548482783*x_107 + 586.445527357069*x_108 + 2939.46801174169*x_109 + 1261.95991077834*x_11 + 2168.83790526881*x_110 - 1075.02508133179*x_111 - 2355.7940804885*x_112 - 2640.79560014283*x_113 + 874.809085497718*x_114 - 1086.86626921408*x_115 + 69.6687992711641*x_116 + 1457.92073706877*x_117 - 306.356292777757*x_118 + 3139.14136818479*x_119 - 752.261407786777*x_12 + 1111.36400255027*x_120 - 715.832663845114*x_13 + 0.442978974011618*x_14 + 597.406021139907*x_15 - 601.513721964478*x_16 - 30.3049646917708*x_17 + 2036.68211626541*x_18 - 1220.6946614296*x_19 + 2036.39438670157*x_2 - 1310.45168583532*x_20 + 1311.14509640343*x_21 - 633.876195240104*x_22 - 2169.79027972958*x_23 - 900.136148452614*x_24 + 1081.76356918228*x_25 + 1237.36740074791*x_26 - 758.300389513366*x_27 - 331.244277268486*x_28 + 418.915843726892*x_29 - 1502.54148352689*x_3 - 2921.40242655708*x_30 - 12441.6736736115*x_31 + 2565.35939781773*x_32 - 4179.1237655273*x_33 - 302.86081130786*x_34 + 735.287903310668*x_35 + 112.718059481096*x_36 + 464.211058077433*x_37 + 1207.17818086147*x_38 + 3264.92781701531*x_39 + 7183.14695507266*x_4 - 5012.86178300538*x_40 - 1506.37723519341*x_41 - 5046.47291965094*x_42 + 35.6478541334304*x_43 - 430.867964070396*x_44 + 702.879807946947*x_45 + 157.576412220348*x_46 - 42.2440375359088*x_47 + 1660.6357444294*x_48 + 2472.53679688022*x_49 + 398.929957904678*x_5 - 280.937635537198*x_51 - 1335.46508742643*x_52 + 887.633255340664*x_53 - 1544.56814431566*x_54 + 1.80202435121912*x_55 + 2928.21142532221*x_56 - 912.856480298924*x_57 + 1167.88862659715*x_58 - 83.0813341370998*x_59 - 846.444355917794*x_6 - 409.040141762983*x_60 + 92.8047111898321*x_61 - 2198.3514597423*x_62 - 145.093959892318*x_63 - 2216.71511763691*x_64 + 940.282752368829*x_65 - 1813.78009337683*x_66 - 558.511501702376*x_67 + 649.44959611329*x_68 + 1388.86709598545*x_69 + 122.671856576145*x_7 + 2272.01871834589*x_70 - 5.76149532449812*x_71 - 1462.14296162234*x_72 + 535.69773637852*x_73 + 817.427598006906*x_74 + 534.97066174643*x_75 - 246.593363323245*x_76 + 1080.95494632204*x_77 - 682.178046041787*x_78 + 359.478579406236*x_79 - 11805.9360579663*x_8 + 418.41771833719*x_80 + 334.96444971785*x_81 + 709.548630759501*x_82 - 3532.16796800718*x_83 - 255.914441063974*x_84 - 1375.25635220523*x_85 - 830.146819530477*x_86 - 89.0489173801372*x_87 + 26.4650489091492*x_88 + 178.860426051785*x_89 - 12228.642179742*x_9 + 564.396595307563*x_90 - 3158.165433623*x_91 - 1.04872285844065*x_92 + 16616.694632357*x_93 - 486.106146642326*x_94 - 1492.51596118771*x_95 - 2388.39185007615*x_96 - 1015.83834580537*x_97 - 883.692323296554*x_98 + 609.735866436543*x_99 + 7.09747444829854*std::pow(-9.58376026153564*x_100 - 9.79407978057861, 2) - 4.04438128796002*std::pow(-6.21119976043701*x_14 - 8.61127948760986, 2) + 0.0113044015526524*std::pow(-7.13375997543335*x_15 - 9.79415988922119, 2) - 0.00354088241139693*std::pow(-6.92288017272949*x_27 - 9.48711967468262, 2) + 14.4898069213404*std::pow(-3.31655979156494*x_55 - 5.26735973358154, 2) - 83.4552899027982*std::pow(-1.93759977817535*x_67 - 2.71135997772217, 2) + 1.81382385779378e-5*std::pow(-9.79600048065186*x_76 - 9.91380023956299, 2) + 5.62906197847415*std::pow(-9.48680019378662*x_85 - 8.87896060943604, 2) + 24.9087717848862*std::pow(-5.09360027313232*x_87 - 6.66383981704712, 2) + 57.9884811973899*std::exp(0.924879848957062*x_1) + 0.148937601798398*std::exp(0.940159797668457*x_1) + 15.2241591485759*std::exp(1.05847978591919*x_1) + 0.0689847648242955*std::exp(1.14207983016968*x_1) - 0.0857811624972279*std::exp(1.24071979522705*x_108) + 9.80691034507313*std::exp(3.36735987663269*x_17) + 0.0115679214393025*std::exp(3.41799974441528*x_17) - 5.70605471147555e-5*std::exp(3.64247989654541*x_17) - 0.0102922768921204*std::exp(0.811679840087891*x_22) + 0.606030271892299*std::exp(1.71975982189178*x_50) + 397.812331154305*std::exp(1.89559984207153*x_50) - 1.01184710245131*std::exp(1.9236798286438*x_50) + 338.85188256392*std::exp(1.96079981327057*x_50) - 0.00150313497328815*std::exp(2.01327991485596*x_50) - 380.160132685398*std::exp(1.40999984741211*x_71) + 0.165974216296823*std::exp(1.89591979980469*x_71) + 583.735638401637*std::exp(1.12383985519409*x_72) + 162.88745528303*std::exp(1.54359984397888*x_78) - 0.00579662502814091*std::exp(0.696879863739014*x_87) - 0.0785488353428566*std::sin(0.357039839029312*x_102 - 7.42975997924805) - 0.0591019934279583*std::sin(0.315199851989746*x_105 - 4.27816009521484) + 12.1233217666008*std::sin(0.407839864492416*x_112 - 7.37943983078003) - 4102.03697261586*std::sin(0.412239879369736*x_117 - 4.20151996612549) + 17.6744009869338*std::sin(0.336319833993912*x_118 + 1.96023988723755) + 0.0572737015255395*std::sin(0.35879984498024*x_120 + 5.16232013702393) - 11422.2785526024*std::sin(0.22639998793602*x_14 - 7.56480026245117) + 6.27662872281129*std::sin(0.398159831762314*x_21 + 1.96975982189178) - 139751.213521464*std::sin(0.0848800837993622*x_26 - 1.48327994346619) - 10.3332554125631*std::sin(0.325519859790802*x_28 - 4.27144002914429) + 4312.04274402007*std::sin(0.439279854297638*x_36 + 5.20919990539551) - 9.03075371578673*std::sin(0.469599843025208*x_41 - 1.14487981796265) - 10.6618292973518*std::sin(0.34063982963562*x_53 - 4.25999975204468) - 9606.16439679234*std::sin(0.301439940929413*x_55 + 5.11815977096558) + 6.95530666442662*std::sin(0.354079842567444*x_67 + 5.14880037307739) + 6.25930493569674*std::sin(0.584159851074219*x_69 + 8.59424018859863) + 2068.99117964613*std::sin(0.649519801139832*x_69 + 8.64799976348877) + 627.171761821443*std::sin(0.979519844055176*x_7 - 0.994799792766571) - 8.8455730848581*std::sin(0.333439826965332*x_75 + 5.14296007156372) + 5271.51100968016*std::sin(0.341919839382172*x_76 - 7.45951986312866) - 46.0290989379336*std::sin(0.165280014276505*x_85 - 7.63127994537354) - 2039.29617004933*std::sin(0.344719856977463*x_92 + 5.18096017837524) + 9770.76313473142*std::sin(0.366639852523804*x_92 + 1.98431980609894) + 5.363012080177*std::sin(0.366079837083817*x_94 - 7.41951990127563) - 10.2351753626408*std::sin(0.369119822978973*x_95 + 5.17471981048584) + 14.5434654783293*std::sin(0.371599853038788*x_97 - 7.41527986526489) - 5.30751459322929*std::sin(0.445759862661362*x_98 - 7.37967967987061) - 174924.591303077 - 0.422642501499479*std::exp(-4.21368026733398*x_111));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00745776663863379*x_1 + 292.165847957077*x_10 - 1932.21847477169*x_100 + 17673.8423910481*x_101 - 1375.3204294681*x_102 - 495.7079850809*x_103 + 3532.13417228267*x_104 - 950.143321396934*x_105 + 265.296051113404*x_106 - 5307.67650333243*x_107 + 905.993086165543*x_108 + 3382.01268093219*x_109 + 939.440229053198*x_11 + 2342.42939887214*x_110 - 1125.07571998078*x_111 - 2855.16987562862*x_112 - 2906.98817079086*x_113 + 1448.22481285578*x_114 - 653.117746709269*x_115 - 1155.7368598603*x_116 + 1550.37796491722*x_117 + 172.348443102899*x_118 + 3489.39945055908*x_119 - 475.466838050952*x_12 + 1642.22631019836*x_120 - 375.034478677282*x_13 - 2.3412912186961*x_14 + 490.231969338524*x_15 - 322.576875658955*x_16 - 49.9636699339737*x_17 + 2491.47578806768*x_18 - 1436.73421864419*x_19 + 2547.16644066796*x_2 - 890.2515951595*x_20 + 1429.1569398417*x_21 - 572.772942413709*x_22 - 3128.22740902468*x_23 - 1244.1345435146*x_24 + 1416.72369573395*x_25 + 1312.33903530497*x_26 - 478.249233782755*x_27 - 368.940633321393*x_28 + 469.975840656119*x_29 - 1633.73101780485*x_3 - 4088.61134038573*x_30 - 16143.0211255217*x_31 + 4282.57855552395*x_32 - 6122.27445057832*x_33 + 359.239784530448*x_34 + 1310.9165794062*x_35 + 110.650019840859*x_36 + 726.469924798196*x_37 + 1869.72553329107*x_38 + 3890.28675450451*x_39 + 8894.09454717552*x_4 - 6783.97261800771*x_40 - 1902.18813307358*x_41 - 6034.18709377001*x_42 + 677.732778707593*x_43 - 279.217026875235*x_44 + 1170.1497133853*x_45 - 71.6952878107176*x_46 - 350.142134103132*x_47 + 1948.84893944742*x_48 + 2857.61309869243*x_49 + 264.497309924268*x_5 + 315.455546345258*x_51 - 1664.80300371681*x_52 + 942.172501469323*x_53 - 2149.22310714502*x_54 - 5.83964416884061*x_55 + 3600.60587160422*x_56 - 1901.29146531908*x_57 + 1671.79623408164*x_58 - 208.127100019245*x_59 - 1010.63840309103*x_6 - 40.8752212733734*x_60 + 277.121588649023*x_61 - 3121.41536462583*x_62 - 386.452359781801*x_63 - 2285.39877024609*x_64 + 552.184635199038*x_65 - 1492.52209447303*x_66 - 874.608056462561*x_67 + 835.361873488188*x_68 + 1472.21735013266*x_69 + 186.237613399952*x_7 + 2617.66785980732*x_70 + 0.0244732034026516*x_71 - 1487.74802098558*x_72 + 919.747812439663*x_73 + 853.544225218835*x_74 + 1036.52014377395*x_75 - 386.343055071109*x_76 + 1248.70890076912*x_77 - 712.534686137063*x_78 + 182.320429179689*x_79 - 10399.1496845063*x_8 + 794.475734189606*x_80 + 1022.19608490035*x_81 + 1507.473287056*x_82 - 4760.93435194196*x_83 + 708.449881313208*x_84 - 1450.9256019519*x_85 - 1240.49513168841*x_86 - 121.219238739444*x_87 + 210.141817373462*x_88 + 213.79680198439*x_89 - 17068.3859139565*x_9 - 276.947780127464*x_90 - 2787.08683526018*x_91 + 1.14454883161562*x_92 + 20695.4341048136*x_93 - 326.817867376398*x_94 - 1844.56652027023*x_95 - 2704.24102362933*x_96 - 1741.47361325991*x_97 - 836.335292115208*x_98 + 1040.6303789671*x_99 + 7.47089702273675*std::pow(-9.58376026153564*x_100 - 9.79407978057861, 2) - 4.25717011637515*std::pow(-6.21119976043701*x_14 - 8.61127948760986, 2) - 0.00654162176958471*std::pow(-7.13375997543335*x_15 - 9.79415988922119, 2) + 0.0204312244587704*std::pow(-6.92288017272949*x_27 - 9.48711967468262, 2) + 22.8042876843206*std::pow(-3.31655979156494*x_55 - 5.26735973358154, 2) - 87.8461601247347*std::pow(-1.93759977817535*x_67 - 2.71135997772217, 2) - 1.1345988421991e-5*std::pow(-9.79600048065186*x_76 - 9.91380023956299, 2) + 8.859106918874*std::pow(-9.48680019378662*x_85 - 8.87896060943604, 2) + 26.2193080543385*std::pow(-5.09360027313232*x_87 - 6.66383981704712, 2) + 61.0394549056055*std::exp(0.924879848957062*x_1) - 0.0861870886040436*std::exp(0.940159797668457*x_1) + 23.9600228533542*std::exp(1.05847978591919*x_1) - 0.398048579592516*std::exp(1.14207983016968*x_1) + 0.494965373510862*std::exp(1.24071979522705*x_108) + 10.3228856733422*std::exp(3.36735987663269*x_17) - 0.00669411524030931*std::exp(3.41799974441528*x_17) + 3.5693008675272e-5*std::exp(3.64247989654541*x_17) + 0.00643811437103727*std::exp(0.811679840087891*x_22) - 0.350697098043886*std::exp(1.71975982189178*x_50) + 626.083349023243*std::exp(1.89559984207153*x_50) + 5.83845292393749*std::exp(1.9236798286438*x_50) + 356.680047112027*std::exp(1.96079981327057*x_50) + 0.00094025403460958*std::exp(2.01327991485596*x_50) - 598.302039421883*std::exp(1.40999984741211*x_71) - 0.0960458226346625*std::exp(1.89591979980469*x_71) + 918.692395417373*std::exp(1.12383985519409*x_72) + 256.354857632396*std::exp(1.54359984397888*x_78) + 0.0036259551980922*std::exp(0.696879863739014*x_87) + 0.0491345492304278*std::sin(0.357039839029312*x_102 - 7.42975997924805) + 0.0369699918913759*std::sin(0.315199851989746*x_105 - 4.27816009521484) - 7.01551384376186*std::sin(0.407839864492416*x_112 - 7.37943983078003) - 6455.85077310319*std::sin(0.412239879369736*x_117 - 4.20151996612549) - 10.2278077899106*std::sin(0.336319833993912*x_118 + 1.96023988723755) - 0.0358263428723309*std::sin(0.35879984498024*x_120 + 5.16232013702393) - 17976.5629409708*std::sin(0.22639998793602*x_14 - 7.56480026245117) - 36.2167379146405*std::sin(0.398159831762314*x_21 + 1.96975982189178) - 219942.673817324*std::sin(0.0848800837993622*x_26 - 1.48327994346619) + 59.6238553543466*std::sin(0.325519859790802*x_28 - 4.27144002914429) + 6786.36118310846*std::sin(0.439279854297638*x_36 + 5.20919990539551) + 52.1082980912439*std::sin(0.469599843025208*x_41 - 1.14487981796265) + 61.5197575649936*std::sin(0.34063982963562*x_53 - 4.25999975204468) - 10111.5777893529*std::sin(0.301439940929413*x_55 + 5.11815977096558) - 40.1327734530499*std::sin(0.354079842567444*x_67 + 5.14880037307739) - 3.62212941915669*std::sin(0.584159851074219*x_69 + 8.59424018859863) + 3256.21109605561*std::sin(0.649519801139832*x_69 + 8.64799976348877) + 660.169428191408*std::sin(0.979519844055176*x_7 - 0.994799792766571) + 5.11874893923803*std::sin(0.333439826965332*x_75 + 5.14296007156372) + 5548.86335899169*std::sin(0.341919839382172*x_76 - 7.45951986312866) + 26.6360810206804*std::sin(0.165280014276505*x_85 - 7.63127994537354) - 3209.47661951564*std::sin(0.344719856977463*x_92 + 5.18096017837524) + 10284.8366337733*std::sin(0.366639852523804*x_92 + 1.98431980609894) - 30.9450839803419*std::sin(0.366079837083817*x_94 - 7.41951990127563) + 5.922882839566*std::sin(0.369119822978973*x_95 + 5.17471981048584) - 8.41600061136542*std::sin(0.371599853038788*x_97 - 7.41527986526489) + 30.6248582622902*std::sin(0.445759862661362*x_98 - 7.37967967987061) - 436221.768496248 - 0.66516146447888*std::exp(-4.21368026733398*x_111));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00518584655930188*x_1 - 739.569540945323*x_10 + 1369.48581646606*x_100 - 49703.7969851601*x_101 + 2296.95808899688*x_102 + 729.77599137886*x_103 - 5046.39621480186*x_104 + 1469.81117350943*x_105 + 132.079758906205*x_106 + 6183.38034419334*x_107 - 663.788310414551*x_108 - 4089.01081440332*x_109 - 2094.25479726758*x_11 - 3134.69276937265*x_110 + 1561.39919361911*x_111 + 3191.5147442705*x_112 + 3728.65228014641*x_113 - 922.333994288111*x_114 + 1895.28457011555*x_115 - 875.50483437126*x_116 - 2134.25601283657*x_117 + 761.750561304839*x_118 - 4460.13966385431*x_119 + 1318.70209790505*x_12 - 1313.83907866927*x_120 + 1291.16387096981*x_13 + 1.13380158137863*x_14 - 965.102171730465*x_15 + 1070.30568446032*x_16 + 35.0391519648357*x_17 - 2746.03595188854*x_18 + 1662.07223203309*x_19 - 2707.25349842443*x_2 + 2243.04937682347*x_20 - 1883.33740559711*x_21 + 975.567049061035*x_22 + 2604.68406616988*x_23 + 1117.9681379025*x_24 - 1393.49755580405*x_25 - 1807.27285012402*x_26 + 1317.78235930739*x_27 + 467.342972120363*x_28 - 597.82956879541*x_29 + 2162.36988887232*x_3 + 3581.72479525409*x_30 + 16227.533605786*x_31 - 2652.0173508806*x_32 + 4980.51420179436*x_33 + 897.429607711797*x_34 - 720.549462921631*x_35 - 161.262776129492*x_36 - 521.224202925041*x_37 - 1373.76059158313*x_38 - 4426.3004412679*x_39 - 9612.01400020722*x_4 + 6312.47500111466*x_40 + 1989.37398421283*x_41 + 6884.35961857341*x_42 + 345.389980964585*x_43 + 736.484350334627*x_44 - 743.053673439753*x_45 - 371.911564774493*x_46 - 151.70954486146*x_47 - 2156.2403842303*x_48 - 3439.94767667636*x_49 - 677.415507085386*x_5 + 809.459615777768*x_51 + 1778.56696331486*x_52 - 1289.75556242624*x_53 + 1904.89603160517*x_54 + 3.1661776396846*x_55 - 3920.91388746142*x_56 + 748.631518235911*x_57 - 1392.48813338851*x_58 + 46.6110595676813*x_59 + 1147.04770115951*x_6 + 839.42076018441*x_60 - 26.7317779782118*x_61 + 2679.01714053026*x_62 + 57.5737539571421*x_63 + 3242.57188856094*x_64 - 1647.30141948624*x_65 + 2914.43573785837*x_66 + 620.017785798233*x_67 - 828.327860541855*x_68 - 2027.866882664*x_69 - 132.161088579343*x_7 - 3164.55220989674*x_70 + 4.63342906194832*x_71 + 2093.16055291537*x_72 - 544.662612789395*x_73 - 1204.17820553867*x_74 - 472.114957483774*x_75 + 273.73448692014*x_76 - 1499.53368758743*x_77 + 988.902276181567*x_78 - 664.810397585004*x_79 + 18393.0772469184*x_8 - 386.799395851587*x_80 - 48.1940637608916*x_81 - 544.149983274435*x_82 + 4425.56231795044*x_83 + 1005.02365760535*x_84 + 2003.75746173104*x_85 + 960.769657533639*x_86 + 89.0673169356041*x_87 + 88.5765466020455*x_88 - 241.115524325432*x_89 + 14985.5307480286*x_9 - 1413.22340718448*x_90 + 4925.44066706897*x_91 - 0.954376087546366*x_92 - 21788.0835042759*x_93 + 824.935467621822*x_94 + 1995.62217960247*x_95 + 3341.51435706163*x_96 + 1038.87372492816*x_97 + 1349.17266491826*x_98 - 628.434032611381*x_99 - 10.3305191309866*std::pow(-9.58376026153564*x_100 - 9.79407978057861, 2) + 5.88667963127241*std::pow(-6.21119976043701*x_14 - 8.61127948760986, 2) + 0.00799097908925168*std::pow(-7.13375997543335*x_15 - 9.79415988922119, 2) - 0.00974206536556345*std::pow(-6.92288017272949*x_27 - 9.48711967468262, 2) - 16.1819030940526*std::pow(-3.31655979156494*x_55 - 5.26735973358154, 2) + 121.470880269188*std::pow(-1.93759977817535*x_67 - 2.71135997772217, 2) + 7.88956773134427e-6*std::pow(-9.79600048065186*x_76 - 9.91380023956299, 2) - 6.28641471488002*std::pow(-9.48680019378662*x_85 - 8.87896060943604, 2) - 36.2552264650751*std::pow(-5.09360027313232*x_87 - 6.66383981704712, 2) - 84.4034196600883*std::exp(0.924879848957062*x_1) + 0.105282641989575*std::exp(0.940159797668457*x_1) - 17.0020117844262*std::exp(1.05847978591919*x_1) + 0.189798476781717*std::exp(1.14207983016968*x_1) - 0.236010574508834*std::exp(1.24071979522705*x_108) - 14.2741584592722*std::exp(3.36735987663269*x_17) + 0.00817725891078974*std::exp(3.41799974441528*x_17) - 2.48195572748171e-5*std::exp(3.64247989654541*x_17) - 0.00447681925128619*std::exp(0.811679840087891*x_22) + 0.428397311223307*std::exp(1.71975982189178*x_50) - 444.268210563749*std::exp(1.89559984207153*x_50) - 2.78390510238597*std::exp(1.9236798286438*x_50) - 493.205841161793*std::exp(1.96079981327057*x_50) - 0.0006538168042146*std::exp(2.01327991485596*x_50) + 424.554616961605*std::exp(1.40999984741211*x_71) + 0.117325670501474*std::exp(1.89591979980469*x_71) - 651.90334035772*std::exp(1.12383985519409*x_72) - 181.909188365016*std::exp(1.54359984397888*x_78) - 0.0025213509887531*std::exp(0.696879863739014*x_87) - 0.0341662920571273*std::sin(0.357039839029312*x_102 - 7.42975997924805) - 0.0257075227125144*std::sin(0.315199851989746*x_105 - 4.27816009521484) + 8.5698663726649*std::sin(0.407839864492416*x_112 - 7.37943983078003) + 4581.06620325831*std::sin(0.412239879369736*x_117 - 4.20151996612549) + 12.4938740050771*std::sin(0.336319833993912*x_118 + 1.96023988723755) + 0.0249122727914804*std::sin(0.35879984498024*x_120 + 5.16232013702393) + 12756.1537330954*std::sin(0.22639998793602*x_14 - 7.56480026245117) + 17.2689516873499*std::sin(0.398159831762314*x_21 + 1.96975982189178) + 156071.133780945*std::sin(0.0848800837993622*x_26 - 1.48327994346619) - 28.4299894693586*std::sin(0.325519859790802*x_28 - 4.27144002914429) - 4815.59610834971*std::sin(0.439279854297638*x_36 + 5.20919990539551) - 24.8464034604274*std::sin(0.469599843025208*x_41 - 1.14487981796265) - 29.3339981008584*std::sin(0.34063982963562*x_53 - 4.25999975204468) + 13981.9686283275*std::sin(0.301439940929413*x_55 + 5.11815977096558) + 19.1362051290631*std::sin(0.354079842567444*x_67 + 5.14880037307739) + 4.4246459771828*std::sin(0.584159851074219*x_69 + 8.59424018859863) - 2310.60461697209*std::sin(0.649519801139832*x_69 + 8.64799976348877) - 912.861318643311*std::sin(0.979519844055176*x_7 - 0.994799792766571) - 6.25285551157402*std::sin(0.333439826965332*x_75 + 5.14296007156372) - 7672.79202361378*std::sin(0.341919839382172*x_76 - 7.45951986312866) - 32.5375532173856*std::sin(0.165280014276505*x_85 - 7.63127994537354) + 2277.44187227294*std::sin(0.344719856977463*x_92 + 5.18096017837524) - 14221.5454557754*std::sin(0.366639852523804*x_92 + 1.98431980609894) + 14.7553090363084*std::sin(0.366079837083817*x_94 - 7.41951990127563) - 7.23515277803415*std::sin(0.369119822978973*x_95 + 5.17471981048584) + 10.2806440465939*std::sin(0.371599853038788*x_97 - 7.41527986526489) - 14.6026182427004*std::sin(0.445759862661362*x_98 - 7.37967967987061) + 394867.423759922 + 0.471998007966547*std::exp(-4.21368026733398*x_111));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0129401209513455*x_1 + 343.716589543885*x_10 - 3768.42182729584*x_100 + 17491.8681572869*x_101 - 2095.90929953727*x_102 - 799.908165619891*x_103 + 5780.51281069537*x_104 - 1501.07692092984*x_105 + 657.566665426954*x_106 - 9394.85122284039*x_107 + 1769.45558467363*x_108 + 5868.85641271025*x_109 + 1190.11813436482*x_11 + 3912.04107339863*x_110 - 1873.06450214779*x_111 - 5066.42900857878*x_112 - 4992.55513196536*x_113 + 2903.39662655747*x_114 - 643.044344461051*x_115 - 2995.11994469053*x_116 + 2550.47021316738*x_117 + 730.770007997816*x_118 + 5940.46296354848*x_119 - 465.726033700902*x_12 + 3147.79186018005*x_120 - 269.280565314167*x_13 - 0.387955494940677*x_14 + 675.79952063709*x_15 - 260.640941945794*x_16 - 94.8585488715553*x_17 + 4441.02229593524*x_18 - 2546.0487963396*x_19 + 4587.8164272054*x_2 - 1005.35061691289*x_20 + 2406.81614726315*x_21 - 874.614569514355*x_22 - 5967.65133883509*x_23 - 2333.14069274042*x_24 + 2598.91246272097*x_25 + 2162.95052110892*x_26 - 492.103221428428*x_27 - 631.875001880538*x_28 + 791.257871831574*x_29 - 2742.80828513703*x_3 - 7729.14831764184*x_30 - 29366.0858790442*x_31 + 8633.44370619937*x_32 - 11704.1812340386*x_33 + 1249.67832478304*x_34 + 2672.20789175588*x_35 + 193.622402277877*x_36 + 1426.92556219893*x_37 + 3637.476677004*x_38 + 6913.34764061688*x_39 + 15938.1285860414*x_4 - 12637.0614993065*x_40 - 3441.34241078156*x_41 - 10660.0411207602*x_42 + 1683.78364631963*x_43 - 312.104664384075*x_44 + 2334.82691663484*x_45 - 317.856109540033*x_46 - 885.288738147677*x_47 + 3610.15249165278*x_48 + 4965.2084630566*x_49 + 303.315022294809*x_5 + 1096.88078982752*x_51 - 2992.99132775614*x_52 + 1565.85969543789*x_53 - 4049.58935198839*x_54 - 0.13058269772281*x_55 + 6450.21084412951*x_56 - 3965.59420093501*x_57 + 3207.34890926487*x_58 - 452.053323179064*x_59 - 1797.98085358368*x_6 + 270.903933892272*x_60 + 606.370617767902*x_61 - 5906.85533374927*x_62 - 856.826488372424*x_63 - 3771.34846107702*x_64 + 523.80724391525*x_65 - 2086.85105773581*x_66 - 1720.23272151993*x_67 + 1553.93390053614*x_68 + 2427.45246640926*x_69 + 373.273008678315*x_7 + 4541.36872024527*x_70 - 7.55813091707184*x_71 - 2529.67240989003*x_72 + 1854.63398885211*x_73 + 1391.84633484245*x_74 + 2151.40730072995*x_75 - 759.467580247864*x_76 + 2175.10776019363*x_77 - 1187.87036734786*x_78 + 101.748585169401*x_79 - 15615.6226275273*x_8 + 1630.01742482851*x_80 + 2316.24769464956*x_81 + 3192.49119145808*x_82 - 8904.32881950339*x_83 + 2071.46130741816*x_84 - 2400.83612229974*x_85 - 2408.60610502704*x_86 - 263.735357602754*x_87 + 533.453409249382*x_88 + 384.625046956098*x_89 - 32274.9237863743*x_9 - 1302.19107339715*x_90 - 4149.13198553114*x_91 - 0.7843286353663*x_92 + 37870.7094959082*x_93 - 374.602589828635*x_94 - 3307.20500530312*x_95 - 4675.30867930013*x_96 - 3509.45886713289*x_97 - 1297.89181748435*x_98 + 2094.82146728782*x_99 + 12.3832909698457*std::pow(-9.58376026153564*x_100 - 9.79407978057861, 2) - 7.05641853967006*std::pow(-6.21119976043701*x_14 - 8.61127948760986, 2) + 0.0105807679409082*std::pow(-7.13375997543335*x_15 - 9.79415988922119, 2) + 0.0037371659390029*std::pow(-6.92288017272949*x_27 - 9.48711967468262, 2) + 44.7428742322805*std::pow(-3.31655979156494*x_55 - 5.26735973358154, 2) - 145.608292832519*std::pow(-1.93759977817535*x_67 - 2.71135997772217, 2) - 1.9686652802001e-5*std::pow(-9.79600048065186*x_76 - 9.91380023956299, 2) + 17.3819025688771*std::pow(-9.48680019378662*x_85 - 8.87896060943604, 2) + 43.4594828006284*std::pow(-5.09360027313232*x_87 - 6.66383981704712, 2) + 101.175177282794*std::exp(0.924879848957062*x_1) + 0.139403593809394*std::exp(0.940159797668457*x_1) + 47.0104703102517*std::exp(1.05847978591919*x_1) - 0.0728088322226361*std::exp(1.14207983016968*x_1) + 0.0905363131124819*std::exp(1.24071979522705*x_108) + 17.1105687245332*std::exp(3.36735987663269*x_17) + 0.0108274190135432*std::exp(3.41799974441528*x_17) + 6.19316575263686e-5*std::exp(3.64247989654541*x_17) + 0.0111709017855619*std::exp(0.811679840087891*x_22) + 0.567236190451264*std::exp(1.71975982189178*x_50) + 1228.39919106671*std::exp(1.89559984207153*x_50) + 1.06793733522147*std::exp(1.9236798286438*x_50) + 591.210505657395*std::exp(1.96079981327057*x_50) + 0.00163145369416755*std::exp(2.01327991485596*x_50) - 1173.89121174682*std::exp(1.40999984741211*x_71) + 0.155349636036127*std::exp(1.89591979980469*x_71) + 1802.50919806516*std::exp(1.12383985519409*x_72) + 502.977918567781*std::exp(1.54359984397888*x_78) + 0.00629146782153384*std::exp(0.696879863739014*x_87) + 0.0852543449989274*std::sin(0.357039839029312*x_102 - 7.42975997924805) + 0.0641473767986265*std::sin(0.315199851989746*x_105 - 4.27816009521484) + 11.3472662562369*std::sin(0.407839864492416*x_112 - 7.37943983078003) - 12666.6231895475*std::sin(0.412239879369736*x_117 - 4.20151996612549) + 16.543001809187*std::sin(0.336319833993912*x_118 + 1.96023988723755) - 0.0621630083744837*std::sin(0.35879984498024*x_120 + 5.16232013702393) - 35270.6958415349*std::sin(0.22639998793602*x_14 - 7.56480026245117) - 6.62456426091923*std::sin(0.398159831762314*x_21 + 1.96975982189178) - 431535.837871674*std::sin(0.0848800837993622*x_26 - 1.48327994346619) + 10.9060639920017*std::sin(0.325519859790802*x_28 - 4.27144002914429) + 13315.0971042794*std::sin(0.439279854297638*x_36 + 5.20919990539551) + 9.53136005915751*std::sin(0.469599843025208*x_41 - 1.14487981796265) + 11.2528518793164*std::sin(0.34063982963562*x_53 - 4.25999975204468) - 16760.3180111721*std::sin(0.301439940929413*x_55 + 5.11815977096558) - 7.3408637005148*std::sin(0.354079842567444*x_67 + 5.14880037307739) + 5.85862530515372*std::sin(0.584159851074219*x_69 + 8.59424018859863) + 6388.80922576438*std::sin(0.649519801139832*x_69 + 8.64799976348877) + 1094.25549486375*std::sin(0.979519844055176*x_7 - 0.994799792766571) - 8.27933753762194*std::sin(0.333439826965332*x_75 + 5.14296007156372) + 9197.44835421898*std::sin(0.341919839382172*x_76 - 7.45951986312866) - 43.082618051294*std::sin(0.165280014276505*x_85 - 7.63127994537354) - 6297.1144166528*std::sin(0.344719856977463*x_92 + 5.18096017837524) + 17047.5010197221*std::sin(0.366639852523804*x_92 + 1.98431980609894) - 5.66030264433196*std::sin(0.366079837083817*x_94 - 7.41951990127563) - 9.57998659568079*std::sin(0.369119822978973*x_95 + 5.17471981048584) + 13.6124882477044*std::sin(0.371599853038788*x_97 - 7.41527986526489) + 5.6017287370896*std::sin(0.445759862661362*x_98 - 7.37967967987061) - 780417.026151819 - 1.30507193038969*std::exp(-4.21368026733398*x_111));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
