
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-72111.2094777965*x_1 - 4086.60394620291*x_10 - 2860.07487672538*x_100 + 6472.51769284235*x_101 - 3077.65893610722*x_102 - 811.775182789128*x_103 - 2127.26044414819*x_104 - 1312.92418582307*x_105 + 2038.69673094639*x_106 + 22.0812837745092*x_107 + 1794.33862123037*x_108 - 1725.07373382953*x_109 - 2958.57170722254*x_11 + 180.196564393164*x_110 + 564.844636062362*x_111 + 64.7964130638606*x_112 + 2059.59866116068*x_113 - 3183.34996893596*x_114 - 192.053248791611*x_115 + 7457.01526677513*x_116 + 1727.6617001063*x_117 + 1393.47821809445*x_118 + 707.601730452574*x_119 - 33081.5298676182*x_12 - 5892.3474234569*x_120 + 972.155950587759*x_13 + 613.648317118466*x_14 + 743.858344702215*x_15 - 120.720485975155*x_16 + 3080.60802983057*x_17 - 2640.08480213041*x_18 + 238.638369830137*x_19 + 1644.26582489461*x_2 + 12886.5486030589*x_20 - 6024.74205528893*x_21 + 5759.30603542157*x_22 - 3579.79732618953*x_23 - 3548.24136357625*x_24 + 6009.29182385946*x_25 - 261.78049242775*x_26 + 1804.18298165854*x_27 - 3697.13396263453*x_28 + 1277.36917469868*x_29 + 12063.7994969325*x_3 + 10512.0261192265*x_30 - 171864.00048889*x_31 - 2073.5133183601*x_32 - 524.451792351279*x_33 - 570.913559622247*x_34 - 83.2761183145636*x_35 + 1457.52791628965*x_36 + 31858.5628600825*x_37 - 422.313412503484*x_38 - 2410.13088215147*x_39 + 650.031571923715*x_4 - 113.560262947326*x_40 - 5509.04666594776*x_41 + 2888515.3911523*x_42 - 8134.83025441035*x_43 - 315.46818375364*x_44 - 410.135649400366*x_45 + 632.182740308888*x_46 - 3126.01611937506*x_47 + 3414.30861455896*x_48 + 11452.1472706736*x_49 - 1722.33881219428*x_5 - 15871.5444989128*x_50 + 2191.54878889456*x_51 + 9712.89770366207*x_52 - 2034.16544533078*x_53 - 1825.42358963151*x_54 - 2322.49244387207*x_55 - 2630.88692847679*x_56 + 33705.1139215314*x_57 + 1287.56930144957*x_58 + 1240.57964289829*x_59 + 3271.51079632228*x_6 - 334.386416960023*x_60 + 226.005584659474*x_61 + 204.735924918383*x_62 + 3304.42147079014*x_63 - 1249.03433760392*x_64 - 167.172995402149*x_65 - 3212.44056934025*x_66 - 1611.85934165595*x_67 - 3353.69944942828*x_68 + 3875.19347534147*x_69 - 1365.48025654756*x_7 + 6562.2367310541*x_70 + 3130.37772554281*x_72 + 1144.69360976512*x_73 + 2073.13608643595*x_74 - 1935.41316668827*x_75 + 6680.10161425784*x_76 - 1420.22572748075*x_77 + 4138.45929820849*x_78 + 576.027855791313*x_79 - 10530.787445101*x_8 - 9.03028653693264*x_80 + 989.834729863171*x_81 - 945.283628758277*x_82 + 4044.54724701086*x_83 + 16117.3843464509*x_84 + 351.623468708121*x_85 - 1177.28653579689*x_86 - 949.347467408962*x_87 + 484.73526094288*x_88 - 4359.4180968068*x_89 + 183.272677231645*x_9 - 10909.4361031859*x_90 - 8406.20464239023*x_91 + 3402.79255643998*x_92 + 1882.70838705167*x_93 - 1123.33322530671*x_94 + 497.198712218932*x_95 + 1451.35638371652*x_96 - 1840.80117186815*x_97 - 945.13787631501*x_98 + 2718.80774411747*x_99 + 0.0127015404731812*std::pow(-6.50528001785278*x_106 - 8.69128036499023, 2) - 0.00206544944142687*std::pow(-5.92063999176025*x_115 - 8.77575969696045, 2) - 0.000170659348101842*std::pow(-6.68079996109009*x_15 - 9.93472003936768, 2) + 0.00230798058017141*std::pow(-3.65079998970032*x_67 - 5.68135976791382, 2) + 0.00447388508130718*std::pow(-5.68767976760864*x_77 - 8.32991981506348, 2) + 0.0037518776064154*std::pow(-7.47968006134033*x_78 - 8.28623962402344, 2) + 0.0252438983980346*std::pow(-4.50551986694336*x_80 - 5.93232011795044, 2) + 11.3110691370821*std::pow(-7.65576028823853*x_85 - 9.42391967773438, 2) - 2026.58425378996*std::exp(0.648559808731079*x_108) - 0.176707578659103*std::exp(0.721039831638336*x_23) - 0.0010658375959788*std::exp(2.53535985946655*x_71) + 0.0501073952568116*std::exp(2.54663991928101*x_71) + 46.0623627371853*std::exp(2.55391979217529*x_71) - 0.0462573517600503*std::exp(2.56647992134094*x_71) + 0.0418292189348014*std::exp(2.58127999305725*x_71) + 0.017670407648691*std::exp(2.58591985702515*x_71) + 0.00714872205450354*std::exp(2.59999990463257*x_71) - 0.106889114984516*std::exp(2.60031986236572*x_71) + 0.0350058497046701*std::exp(2.60800004005432*x_71) - 0.783370697334076*std::exp(2.61455988883972*x_71) + 24.193229691137*std::exp(2.62783980369568*x_71) - 19.1019722543837*std::exp(2.63567996025085*x_71) - 6.58252083826796*std::exp(2.66703987121582*x_71) + 112.92073575812*std::exp(2.67703986167908*x_71) - 0.00837797535588279*std::exp(2.79999995231628*x_71) - 264.206152482821*std::exp(1.35551989078522*x_76) - 0.0418258717953501*std::exp(1.45679986476898*x_76) - 3.81984946254688*std::sin(0.305279940366745*x_103 - 7.50447988510132) + 2.09194165448534*std::sin(0.380319833755493*x_105 - 7.4015998840332) - 22.5777037770268*std::sin(0.399839848279953*x_105 - 7.38983964920044) + 19.1025323999325*std::sin(0.579119861125946*x_106 + 2.17703986167908) + 3.23710483236034*std::sin(0.344239860773087*x_112 + 1.96727979183197) - 1.15756892167931*std::sin(0.531359851360321*x_114 + 8.36511993408203) - 328.548028820791*std::sin(0.321839839220047*x_115 + 5.11583995819092) + 292.059690922301*std::sin(0.48583984375*x_115 - 4.12815999984741) + 0.212034169350355*std::sin(0.317279845476151*x_119 - 4.27472019195557) - 5109.20965408737*std::sin(0.329919844865799*x_16 - 4.26799964904785) + 3.54932749121152*std::sin(0.414799869060516*x_16 + 2.01095986366272) - 0.115325841103189*std::sin(0.459519863128662*x_21 + 8.22743988037109) - 0.546560566987972*std::sin(0.329759836196899*x_26 + 5.13416004180908) - 489.316385602187*std::sin(0.266959935426712*x_28 - 4.29216003417969) - 2.24645267798599*std::sin(0.300159931182861*x_28 + 5.13399982452393) - 3203.79054178294*std::sin(0.316399842500687*x_28 - 4.29728031158447) + 1.91827549040063*std::sin(0.340879827737808*x_28 - 4.26624011993408) + 0.524172636787857*std::sin(0.343679845333099*x_28 + 5.15528011322021) - 53.0046997745845*std::sin(0.344479858875275*x_28 + 5.146399974823) - 1.66071201585338*std::sin(0.358399868011475*x_28 + 8.34047985076904) + 119.433881727277*std::sin(0.359679847955704*x_28 + 8.3645601272583) + 0.290753905818411*std::sin(0.350399851799011*x_34 + 1.9722398519516) + 0.737128977770396*std::sin(0.384399831295013*x_34 + 8.20399951934814) + 6774.35816429884*std::sin(0.394879847764969*x_36 - 7.38895988464355) + 1.15332758576142*std::sin(0.417199850082397*x_36 + 5.21704006195068) - 22.0132283574369*std::sin(0.417439848184586*x_36 - 7.37928009033203) + 173.327763868335*std::sin(0.419759839773178*x_36 + 2.00951981544495) - 3.18536513888604*std::sin(0.364479839801788*x_43 - 4.23239994049072) - 1.53894620982499*std::sin(0.343439847230911*x_45 + 5.14336013793945) + 1.86602790283853*std::sin(0.544799864292145*x_47 + 8.36528015136719) + 12591.2537716015*std::sin(0.325999855995178*x_48 - 7.45655965805054) + 4.79568355042006*std::sin(0.313919931650162*x_53 + 5.14799976348877) - 37.2542084462052*std::sin(0.314319938421249*x_53 + 5.13976001739502) + 1.95438748458974*std::sin(0.472319841384888*x_53 - 7.33735990524292) - 2.29642066462199*std::sin(0.402399837970734*x_55 - 4.19655990600586) + 17.4611915339472*std::sin(0.264399945735931*x_56 + 5.08799982070923) - 2.89964240859139*std::sin(0.443999856710434*x_59 + 2.02063989639282) - 2.02074920780725*std::sin(0.387199819087982*x_6 - 4.21600008010864) + 0.352896723570254*std::sin(0.181680008769035*x_64 - 4.41991996765137) + 3.67098583297411*std::sin(0.238159984350204*x_64 - 4.3471999168396) + 5.94484429977908*std::sin(0.254799991846085*x_64 - 4.33599996566772) - 2.2560311584695*std::sin(0.478079855442047*x_69 + 2.04487991333008) + 0.0990251045181945*std::sin(0.520319879055023*x_75 - 7.24647998809814) + 17.4082128082954*std::sin(0.130560040473938*x_80 + 4.91039943695068) - 6.09087678992002*std::sin(0.209040001034737*x_80 + 4.99616003036499) - 16036.2160458686*std::sin(0.282239943742752*x_80 + 5.11295986175537) - 14124.2557530005*std::sin(0.302879929542542*x_80 - 7.47616052627563) + 0.394958316913141*std::sin(0.318959832191467*x_80 - 4.28208017349243) - 505.531282757136*std::sin(0.370159834623337*x_80 + 5.1572003364563) - 1.93649634626954*std::sin(0.457199841737747*x_80 - 7.35167980194092) - 1.07246718446866*std::sin(0.469279855489731*x_80 - 7.3284797668457) - 0.0601393118384593*std::sin(0.517839848995209*x_80 + 2.12727999687195) - 0.182044537055203*std::sin(0.538959860801697*x_80 + 2.1541600227356) + 1.50094945385877*std::sin(0.296639859676361*x_81 + 1.88175988197327) + 541.613210546148*std::sin(0.386079847812653*x_81 - 7.3983998298645) - 14027.9042838854*std::sin(0.252799987792969*x_85 - 4.32671976089478) - 268.124312612961*std::sin(0.435199856758118*x_85 - 4.16016006469727) + 42.0592518150722*std::sin(0.363439828157425*x_95 + 5.16104030609131) + 2.69919005817489*std::sin(0.367999851703644*x_95 + 5.18576002120972) - 1.62527729807588*std::sin(0.37951985001564*x_95 + 1.98959982395172) + 4.02728265470788*std::sin(0.358319848775864*x_96 + 5.16488027572632) - 9.58361893797445*std::sin(0.378959834575653*x_96 + 5.17615985870361) + 0.162806843013948*std::sin(0.440159857273102*x_96 - 7.3854398727417) + 0.46489339742331*std::sin(0.448879837989807*x_96 - 7.35279989242554) - 8471.95046076758*std::sin(0.453759849071503*x_96 - 7.3551197052002) - 4348.92606745*std::sin(0.425039857625961*x_97 - 1.15743982791901) - 7322666.99479083 + 0.00140273853577309*std::exp(-3.18055987358093*x_74) - 19.7815985988195*std::exp(-3.1210401058197*x_74) - 0.00212248814801278*std::exp(-2.85591983795166*x_74) - 1.66340427369674*std::exp(-3.94351983070374*x_45) - 6.54838685541104e-5*std::exp(-3.93023991584778*x_45) - 2.47481204766843*std::exp(-3.84215998649597*x_45) + 0.287364926621001*std::exp(-4.81960010528564*x_111) + 0.470978363078224*std::exp(-4.61560010910034*x_111) - 3.11372611425007e-5*std::exp(-4.57008028030396*x_111));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-17799.4807522528*x_1 - 914.727626343777*x_10 + 212.912629096114*x_100 + 2087.48863215671*x_101 - 2074.05109301668*x_102 - 227.141424010356*x_103 + 5836.57421230481*x_104 + 2296.527030977*x_105 - 956.781148529837*x_106 - 783.553435661737*x_107 + 755.167995468981*x_108 - 4676.65316093571*x_109 + 159.663648663799*x_11 + 2890.50272192777*x_110 + 700.855838036259*x_111 - 2294.33388460964*x_112 - 367.995758692189*x_113 + 597.822401761858*x_114 + 3175.57239529418*x_115 - 8418.61923396665*x_116 + 1866.54845799117*x_117 + 2079.9984021536*x_118 + 1550.03387482863*x_119 + 342.113674838156*x_12 - 603.136535434096*x_120 - 2934.74460727617*x_13 + 1119.76808500112*x_14 + 1167.90025402389*x_15 + 1542.46371606041*x_16 + 1496.07776968716*x_17 - 6.99429186054353*x_18 - 952.867630240263*x_19 - 87.1113121205575*x_2 - 5407.00260093794*x_20 - 6352.95292865654*x_21 + 1205.17958269122*x_22 - 1557.88842107789*x_23 + 480.436346332039*x_24 - 2900.21380596116*x_25 + 668.219125433196*x_26 - 133.725752850017*x_27 - 186.449613624513*x_28 + 816.723606813958*x_29 + 888.575750162252*x_3 - 8147.16498457507*x_30 - 108480.269031455*x_31 + 125.537125817454*x_32 + 3331.18888066205*x_33 - 1827.45012724617*x_34 - 640.218672607807*x_35 + 767.514817243447*x_36 - 30988.4368785321*x_37 + 4026.93918330087*x_38 - 2897.21411768666*x_39 - 389.460195195294*x_4 - 756.231019445831*x_40 - 1748.03752673777*x_41 - 1932942.63114951*x_42 + 739.744145133746*x_43 + 3305.5270493387*x_44 - 378.31270285838*x_45 + 277.177055946495*x_46 - 2049.04158706129*x_47 + 3513.85024284103*x_48 - 3141.85602935848*x_49 + 46.0413244730635*x_5 + 13150.5438737497*x_50 + 2187.8407676013*x_51 - 6181.18792398167*x_52 + 1603.98817902462*x_53 + 1262.41422257588*x_54 + 132.241364173649*x_55 + 1501.47137408054*x_56 - 9520.37251739648*x_57 - 2272.06500204906*x_58 + 291.685408145887*x_59 + 723.859435224465*x_6 + 1935.17523582885*x_60 - 884.667735310188*x_61 - 346.194620164881*x_62 + 2398.02195012705*x_63 - 224.124426864894*x_64 - 682.829692564618*x_65 + 1402.02499207138*x_66 + 1078.58931681164*x_67 - 4769.18636621456*x_68 + 298.5056837007*x_69 + 143.356922188364*x_7 - 1479.04944503164*x_70 - 1429.21334613935*x_72 - 1770.36155108732*x_73 - 1299.92819136207*x_74 + 953.906810307042*x_75 - 649.572907084701*x_76 + 101.206741269427*x_77 - 1274.22606532291*x_78 - 556.680590151672*x_79 + 1195.26004246761*x_8 + 84.0730213652821*x_80 - 1724.07955894786*x_81 - 402.316080208095*x_82 - 569.237677302752*x_83 + 5473.78131183632*x_84 + 141.307699583774*x_85 - 1985.68884106614*x_86 + 810.219989650036*x_87 - 2927.89517689595*x_88 - 4838.70559190802*x_89 - 6607.40084257937*x_9 + 4617.23005455313*x_90 - 30.1754295299443*x_91 + 1852.67644535353*x_92 - 372.26344217951*x_93 - 709.434935756415*x_94 + 1209.17773024233*x_95 + 530.667315318772*x_96 - 1059.11014534326*x_97 + 678.071991793906*x_98 + 1313.45184376153*x_99 - 0.0128081095018301*std::pow(-6.50528001785278*x_106 - 8.69128036499023, 2) - 0.0012464632978133*std::pow(-5.92063999176025*x_115 - 8.77575969696045, 2) + 0.000515557663342608*std::pow(-6.68079996109009*x_15 - 9.93472003936768, 2) - 0.00148700649363374*std::pow(-3.65079998970032*x_67 - 5.68135976791382, 2) - 0.00232248408357698*std::pow(-5.68767976760864*x_77 - 8.32991981506348, 2) + 0.0683483628373142*std::pow(-7.47968006134033*x_78 - 8.28623962402344, 2) - 0.02545570087485*std::pow(-4.50551986694336*x_80 - 5.93232011795044, 2) + 5.29512037756834*std::pow(-7.65576028823853*x_85 - 9.42391967773438, 2) + 1530.37219544208*std::exp(0.648559808731079*x_108) - 3.21910119926189*std::exp(0.721039831638336*x_23) + 0.00321986897639863*std::exp(2.53535985946655*x_71) - 0.0260117606595839*std::exp(2.54663991928101*x_71) - 34.7839272201618*std::exp(2.55391979217529*x_71) + 0.0665271020246444*std::exp(2.56647992134094*x_71) + 0.0252432158990095*std::exp(2.58127999305725*x_71) - 0.0113848492246877*std::exp(2.58591985702515*x_71) - 9.44688328134319e-5*std::exp(2.59999990463257*x_71) + 0.107785940781442*std::exp(2.60031986236572*x_71) + 0.637705375290533*std::exp(2.60800004005432*x_71) + 0.0164350364518439*std::exp(2.61455988883972*x_71) + 32.7988402652644*std::exp(2.62783980369568*x_71) + 30.6674165988779*std::exp(2.63567996025085*x_71) - 2.31076753033876*std::exp(2.66703987121582*x_71) + 52.8622786861574*std::exp(2.67703986167908*x_71) + 0.028716642589709*std::exp(2.79999995231628*x_71) - 358.185141174382*std::exp(1.35551989078522*x_76) - 0.0252411959577826*std::exp(1.45679986476898*x_76) - 69.5866135408169*std::sin(0.305279940366745*x_103 - 7.50447988510132) + 1.2624508938265*std::sin(0.380319833755493*x_105 - 7.4015998840332) + 0.473677897114556*std::sin(0.399839848279953*x_105 - 7.38983964920044) - 0.400769159969653*std::sin(0.579119861125946*x_106 + 2.17703986167908) + 58.9706911670751*std::sin(0.344239860773087*x_112 + 1.96727979183197) - 0.698572982045884*std::sin(0.531359851360321*x_114 + 8.36511993408203) - 115.335467339843*std::sin(0.321839839220047*x_115 + 5.11583995819092) - 468.889604380942*std::sin(0.48583984375*x_115 - 4.12815999984741) - 0.00280198619310912*std::sin(0.317279845476151*x_119 - 4.27472019195557) - 2391.80574574809*std::sin(0.329919844865799*x_16 - 4.26799964904785) - 1.84252756964702*std::sin(0.414799869060516*x_16 + 2.01095986366272) + 0.348396509323943*std::sin(0.459519863128662*x_21 + 8.22743988037109) + 0.352142959632222*std::sin(0.329759836196899*x_26 + 5.13416004180908) + 785.576967973853*std::sin(0.266959935426712*x_28 - 4.29216003417969) - 1.35569564532625*std::sin(0.300159931182861*x_28 + 5.13399982452393) - 4343.38926901517*std::sin(0.316399842500687*x_28 - 4.29728031158447) - 6.57514844654604*std::sin(0.340879827737808*x_28 - 4.26624011993408) - 0.337718662533449*std::sin(0.343679845333099*x_28 + 5.15528011322021) + 1.11203313562651*std::sin(0.344479858875275*x_28 + 5.146399974823) + 0.862109140965591*std::sin(0.358399868011475*x_28 + 8.34047985076904) + 41.9267849959942*std::sin(0.359679847955704*x_28 + 8.3645601272583) - 0.00384225067210552*std::sin(0.350399851799011*x_34 + 1.9722398519516) - 1.06013536969933*std::sin(0.384399831295013*x_34 + 8.20399951934814) - 5115.64686107715*std::sin(0.394879847764969*x_36 - 7.38895988464355) - 0.598715638064296*std::sin(0.417199850082397*x_36 + 5.21704006195068) + 0.461835261018133*std::sin(0.417439848184586*x_36 - 7.37928009033203) - 278.270467149397*std::sin(0.419759839773178*x_36 + 2.00951981544495) - 58.0281435379558*std::sin(0.364479839801788*x_43 - 4.23239994049072) - 0.928727631566019*std::sin(0.343439847230911*x_45 + 5.14336013793945) - 2.68371240353162*std::sin(0.544799864292145*x_47 + 8.36528015136719) - 9508.26724414652*std::sin(0.325999855995178*x_48 - 7.45655965805054) - 2.48953616673324*std::sin(0.313919931650162*x_53 + 5.14799976348877) + 0.781589451688237*std::sin(0.314319938421249*x_53 + 5.13976001739502) + 35.6032895884012*std::sin(0.472319841384888*x_53 - 7.33735990524292) + 1.19211833693849*std::sin(0.402399837970734*x_55 - 4.19655990600586) - 17.6076951981881*std::sin(0.264399945735931*x_56 + 5.08799982070923) + 4.1702518413072*std::sin(0.443999856710434*x_59 + 2.02063989639282) + 2.90623184421282*std::sin(0.387199819087982*x_6 - 4.21600008010864) - 1.06609226056911*std::sin(0.181680008769035*x_64 - 4.41991996765137) + 2.21537696145869*std::sin(0.238159984350204*x_64 - 4.3471999168396) + 108.29787584698*std::sin(0.254799991846085*x_64 - 4.33599996566772) - 41.0983652365677*std::sin(0.478079855442047*x_69 + 2.04487991333008) - 0.00130859557438922*std::sin(0.520319879055023*x_75 - 7.24647998809814) + 317.127308027333*std::sin(0.130560040473938*x_80 + 4.91039943695068) - 3.67573963219036*std::sin(0.209040001034737*x_80 + 4.99616003036499) - 7507.13246771576*std::sin(0.282239943742752*x_80 + 5.11295986175537) + 10665.9114938258*std::sin(0.302879929542542*x_80 - 7.47616052627563) - 0.00521928967503174*std::sin(0.318959832191467*x_80 - 4.28208017349243) - 177.464728554216*std::sin(0.370159834623337*x_80 + 5.1572003364563) + 2.78505978178127*std::sin(0.457199841737747*x_80 - 7.35167980194092) + 3.67602618978258*std::sin(0.469279855489731*x_80 - 7.3284797668457) + 0.181679371398782*std::sin(0.517839848995209*x_80 + 2.12727999687195) + 0.117289292231189*std::sin(0.538959860801697*x_80 + 2.1541600227356) + 0.905797241309093*std::sin(0.296639859676361*x_81 + 1.88175988197327) - 869.537330600125*std::sin(0.386079847812653*x_81 - 7.3983998298645) + 10593.1518199815*std::sin(0.252799987792969*x_85 - 4.32671976089478) - 94.1239641929424*std::sin(0.435199856758118*x_85 - 4.16016006469727) - 0.882398766089158*std::sin(0.363439828157425*x_95 + 5.16104030609131) - 1.40120406195788*std::sin(0.367999851703644*x_95 + 5.18576002120972) + 2.33746603541652*std::sin(0.37951985001564*x_95 + 1.98959982395172) + 73.3654465864577*std::sin(0.358319848775864*x_96 + 5.16488027572632) + 9.66402784296655*std::sin(0.378959834575653*x_96 + 5.17615985870361) - 0.00215145760547204*std::sin(0.440159857273102*x_96 - 7.3854398727417) - 0.299525700846482*std::sin(0.448879837989807*x_96 - 7.35279989242554) + 6397.58125134686*std::sin(0.453759849071503*x_96 - 7.3551197052002) + 3284.08528844147*std::sin(0.425039857625961*x_97 - 1.15743982791901) + 5191739.78735509 + 0.000846528637399922*std::exp(-3.18055987358093*x_74) - 9.26048144273895*std::exp(-3.1210401058197*x_74) + 0.00727511492434489*std::exp(-2.85591983795166*x_74) + 1.25611735386001*std::exp(-3.94351983070374*x_45) + 4.21905360057183e-5*std::exp(-3.93023991584778*x_45) - 1.158548988203*std::exp(-3.84215998649597*x_45) + 0.13452591088501*std::exp(-4.81960010528564*x_111) - 0.355658636033418*std::exp(-4.61560010910034*x_111) + 2.0061394758109e-5*std::exp(-4.57008028030396*x_111));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-4529.88007144039*x_1 - 300.772617529968*x_10 + 332.20185582644*x_100 + 2212.11774492902*x_101 - 778.037250414317*x_102 - 331.72377684455*x_103 + 2168.9436306043*x_104 + 776.86771069469*x_105 - 775.04597701564*x_106 - 100.057250219713*x_107 + 641.617423427255*x_108 - 2369.54946896267*x_109 - 435.348705269333*x_11 + 1033.52126431265*x_110 - 82.3860859678984*x_111 - 790.596378675247*x_112 + 1097.43303574431*x_113 + 292.719693862796*x_114 + 967.360789617167*x_115 - 5076.86297739451*x_116 + 568.855526462924*x_117 + 992.053366145578*x_118 + 265.113019481268*x_119 - 2104.82664546081*x_12 + 106.934314251847*x_120 - 530.395318329142*x_13 + 623.072933973484*x_14 + 950.825719823559*x_15 + 49.4271404003842*x_16 + 898.993466983202*x_17 - 157.137886590476*x_18 - 319.68493205026*x_19 + 183.753694126212*x_2 - 870.77868445764*x_20 - 2480.56223788503*x_21 + 1682.30082276372*x_22 - 973.696449648677*x_23 - 284.552122451514*x_24 - 429.284381236026*x_25 + 319.10913054935*x_26 - 83.1589137513025*x_27 - 451.572615946625*x_28 + 476.367240299666*x_29 + 801.294300756464*x_3 - 4611.36096415942*x_30 - 43098.4895402326*x_31 - 612.874347754136*x_32 + 1401.93740317938*x_33 - 567.78375173889*x_34 - 346.114567595498*x_35 + 479.425238209331*x_36 - 9062.94334208609*x_37 + 1585.90861073661*x_38 - 1276.73992603993*x_39 - 533.322868854238*x_4 - 45.1802962638029*x_40 - 734.48336961414*x_41 - 657205.373020642*x_42 + 624.16150150453*x_43 + 2335.62904062921*x_44 + 135.216037207327*x_45 + 489.361548751227*x_46 - 665.20527067426*x_47 + 1154.87386486157*x_48 - 1915.30295127617*x_49 + 149.584244409813*x_5 + 5189.22985812605*x_50 + 1886.38220701538*x_51 - 2038.19532401174*x_52 + 423.132517626317*x_53 - 204.078333037057*x_54 + 57.1045909278422*x_55 + 664.900672539497*x_56 - 1620.24709904175*x_57 - 1467.53382018796*x_58 + 31.4577283364217*x_59 + 289.385534160078*x_6 + 723.562584377381*x_60 - 156.889259776279*x_61 - 931.573208300603*x_62 + 769.97122381349*x_63 - 486.629437489882*x_64 - 397.317808313744*x_65 - 164.70009782772*x_66 + 203.781832153902*x_67 - 2108.24439453124*x_68 + 211.096876883114*x_69 + 125.82653161161*x_7 - 209.723066957952*x_70 + 280.24022613643*x_72 - 833.118610649649*x_73 - 548.569038885635*x_74 - 119.30444336213*x_75 + 397.337159167824*x_76 - 165.205407953036*x_77 - 641.95474292825*x_78 - 114.83090812576*x_79 + 2057.52577542824*x_8 + 46.6846182106761*x_80 - 1380.6448928902*x_81 - 436.099526138144*x_82 + 154.059927639024*x_83 + 1830.84935827705*x_84 - 180.17407984236*x_85 - 971.148894634734*x_86 + 686.836764703903*x_87 - 562.451868453616*x_88 - 1767.38140090877*x_89 - 3666.26586808984*x_9 + 997.073096650666*x_90 + 287.280106790483*x_91 + 990.271400553443*x_92 + 17.2594460383194*x_93 - 220.902177670572*x_94 + 778.628874679702*x_95 + 632.02482783396*x_96 + 171.93087000545*x_97 + 649.061138026275*x_98 + 402.067615839309*x_99 + 0.0330768743036836*std::pow(-6.50528001785278*x_106 - 8.69128036499023, 2) - 0.00078276337851119*std::pow(-5.92063999176025*x_115 - 8.77575969696045, 2) - 0.00389627833265732*std::pow(-6.68079996109009*x_15 - 9.93472003936768, 2) - 0.000810336184110341*std::pow(-3.65079998970032*x_67 - 5.68135976791382, 2) + 0.00244206686826738*std::pow(-5.68767976760864*x_77 - 8.32991981506348, 2) - 0.000733323423808606*std::pow(-7.47968006134033*x_78 - 8.28623962402344, 2) + 0.0657392113980032*std::pow(-4.50551986694336*x_80 - 5.93232011795044, 2) + 3.79529819798846*std::pow(-7.65576028823853*x_85 - 9.42391967773438, 2) + 589.877429673114*std::exp(0.648559808731079*x_108) + 0.0345383885587431*std::exp(0.721039831638336*x_23) - 0.0243338555873633*std::exp(2.53535985946655*x_71) + 0.0273510847033391*std::exp(2.54663991928101*x_71) - 13.4073617148007*std::exp(2.55391979217529*x_71) - 0.0442752212772939*std::exp(2.56647992134094*x_71) + 0.0158524242119769*std::exp(2.58127999305725*x_71) - 0.00620411230004848*std::exp(2.58591985702515*x_71) + 0.0116877336907926*std::exp(2.59999990463257*x_71) - 0.27835661573807*std::exp(2.60031986236572*x_71) - 0.00684207009174913*std::exp(2.60800004005432*x_71) + 0.153018540840341*std::exp(2.61455988883972*x_71) - 1.75497647833241*std::exp(2.62783980369568*x_71) + 28.3616510852509*std::exp(2.63567996025085*x_71) - 6.37191500033486*std::exp(2.66703987121582*x_71) + 37.8892445748837*std::exp(2.67703986167908*x_71) + 0.0513053433733693*std::exp(2.79999995231628*x_71) + 19.1655098950233*std::exp(1.35551989078522*x_76) - 0.0158511557141222*std::exp(1.45679986476898*x_76) + 0.746608866322969*std::sin(0.305279940366745*x_103 - 7.50447988510132) + 0.792803389068679*std::sin(0.380319833755493*x_105 - 7.4015998840332) + 4.41018192184531*std::sin(0.399839848279953*x_105 - 7.38983964920044) - 3.73136453040757*std::sin(0.579119861125946*x_106 + 2.17703986167908) - 0.632708485701875*std::sin(0.344239860773087*x_112 + 1.96727979183197) - 0.438695105200585*std::sin(0.531359851360321*x_114 + 8.36511993408203) - 318.036230284764*std::sin(0.321839839220047*x_115 + 5.11583995819092) - 433.635592162666*std::sin(0.48583984375*x_115 - 4.12815999984741) + 0.346663205789928*std::sin(0.317279845476151*x_119 - 4.27472019195557) - 1714.33610371382*std::sin(0.329919844865799*x_16 - 4.26799964904785) + 1.93739779037546*std::sin(0.414799869060516*x_16 + 2.01095986366272) - 2.63297370395257*std::sin(0.459519863128662*x_21 + 8.22743988037109) + 0.191898410256695*std::sin(0.329759836196899*x_26 + 5.13416004180908) + 726.512446669503*std::sin(0.266959935426712*x_28 - 4.29216003417969) - 0.851359928070205*std::sin(0.300159931182861*x_28 + 5.13399982452393) + 232.402912472355*std::sin(0.316399842500687*x_28 - 4.29728031158447) - 11.7472036547131*std::sin(0.340879827737808*x_28 - 4.26624011993408) - 0.184037967199092*std::sin(0.343679845333099*x_28 + 5.15528011322021) + 10.3535935729906*std::sin(0.344479858875275*x_28 + 5.146399974823) - 0.90649842764046*std::sin(0.358399868011475*x_28 + 8.34047985076904) + 115.612629450711*std::sin(0.359679847955704*x_28 + 8.3645601272583) + 0.475365274360127*std::sin(0.350399851799011*x_34 + 1.9722398519516) + 0.705542953906755*std::sin(0.384399831295013*x_34 + 8.20399951934814) - 1971.81092972996*std::sin(0.394879847764969*x_36 - 7.38895988464355) + 0.629543011110122*std::sin(0.417199850082397*x_36 + 5.21704006195068) + 4.29992096194495*std::sin(0.417439848184586*x_36 - 7.37928009033203) - 257.348377264674*std::sin(0.419759839773178*x_36 + 2.00951981544495) + 0.62259570134545*std::sin(0.364479839801788*x_43 - 4.23239994049072) - 0.583229349694179*std::sin(0.343439847230911*x_45 + 5.14336013793945) + 1.78606848780162*std::sin(0.544799864292145*x_47 + 8.36528015136719) - 3664.93344516235*std::sin(0.325999855995178*x_48 - 7.45655965805054) + 2.61772032502763*std::sin(0.313919931650162*x_53 + 5.14799976348877) + 7.27699496036826*std::sin(0.314319938421249*x_53 + 5.13976001739502) - 0.381994902818094*std::sin(0.472319841384888*x_53 - 7.33735990524292) - 1.25349952418522*std::sin(0.402399837970734*x_55 - 4.19655990600586) + 45.4717787012066*std::sin(0.264399945735931*x_56 + 5.08799982070923) - 2.77539254584576*std::sin(0.443999856710434*x_59 + 2.02063989639282) - 1.93415997495238*std::sin(0.387199819087982*x_6 - 4.21600008010864) + 8.05689153864582*std::sin(0.181680008769035*x_64 - 4.41991996765137) + 1.39122905429262*std::sin(0.238159984350204*x_64 - 4.3471999168396) - 1.1619498377209*std::sin(0.254799991846085*x_64 - 4.33599996566772) + 0.440952682070135*std::sin(0.478079855442047*x_69 + 2.04487991333008) + 0.161900132847161*std::sin(0.520319879055023*x_75 - 7.24647998809814) - 3.40252309860519*std::sin(0.130560040473938*x_80 + 4.91039943695068) - 2.30831856667453*std::sin(0.209040001034737*x_80 + 4.99616003036499) - 5380.7664972985*std::sin(0.282239943742752*x_80 + 5.11295986175537) + 4111.14399218516*std::sin(0.302879929542542*x_80 - 7.47616052627563) + 0.645733264190396*std::sin(0.318959832191467*x_80 - 4.28208017349243) - 489.356956534346*std::sin(0.370159834623337*x_80 + 5.1572003364563) - 1.8535173539226*std::sin(0.457199841737747*x_80 - 7.35167980194092) + 6.56761267711292*std::sin(0.469279855489731*x_80 - 7.3284797668457) - 1.37302468492543*std::sin(0.517839848995209*x_80 + 2.12727999687195) + 0.0639161684300181*std::sin(0.538959860801697*x_80 + 2.1541600227356) + 0.568829351090467*std::sin(0.296639859676361*x_81 + 1.88175988197327) - 804.160151428717*std::sin(0.386079847812653*x_81 - 7.3983998298645) + 4083.09899142066*std::sin(0.252799987792969*x_85 - 4.32671976089478) - 259.5457532866*std::sin(0.435199856758118*x_85 - 4.16016006469727) - 8.21558090375467*std::sin(0.363439828157425*x_95 + 5.16104030609131) + 1.47335090026489*std::sin(0.367999851703644*x_95 + 5.18576002120972) - 1.55563406185779*std::sin(0.37951985001564*x_95 + 1.98959982395172) - 0.787152731193973*std::sin(0.358319848775864*x_96 + 5.16488027572632) - 24.9573002310316*std::sin(0.378959834575653*x_96 + 5.17615985870361) + 0.266179466718384*std::sin(0.440159857273102*x_96 - 7.3854398727417) - 0.163224918321505*std::sin(0.448879837989807*x_96 - 7.35279989242554) + 2465.92874328801*std::sin(0.453759849071503*x_96 - 7.3551197052002) + 1265.84094675971*std::sin(0.425039857625961*x_97 - 1.15743982791901) + 2051603.98861248 + 0.000531609408299553*std::exp(-3.18055987358093*x_74) - 6.6374862186368*std::exp(-3.1210401058197*x_74) + 0.0129977683884257*std::exp(-2.85591983795166*x_74) + 0.484166713345637*std::exp(-3.94351983070374*x_45) + 2.29915054835427e-5*std::exp(-3.93023991584778*x_45) - 0.830394509223122*std::exp(-3.84215998649597*x_45) + 0.0964219716944565*std::exp(-4.81960010528564*x_111) - 0.13708756777552*std::exp(-4.61560010910034*x_111) + 1.09323490824118e-5*std::exp(-4.57008028030396*x_111));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (11671.6095891861*x_1 + 131.635915695846*x_10 + 212.255960688924*x_100 - 523.77077867157*x_101 + 1710.33699776609*x_102 - 358.396240902513*x_103 - 6406.0688291347*x_104 - 2503.39927408709*x_105 + 1009.71400614182*x_106 + 1290.97772531017*x_107 - 175.071664495622*x_108 + 3104.83413440137*x_109 - 916.996822014055*x_11 - 2789.96844736248*x_110 - 815.901724155421*x_111 + 2286.30739513028*x_112 + 1159.86415241308*x_113 - 1581.09576719608*x_114 - 3224.49116322123*x_115 + 7481.57462873795*x_116 - 1823.40016695042*x_117 - 1634.15325816489*x_118 - 1444.45956984847*x_119 - 8747.36994343142*x_12 - 240.199421699549*x_120 + 3331.32644762412*x_13 - 904.186762770363*x_14 - 419.902098027677*x_15 - 2085.43564237856*x_16 - 614.340746563459*x_17 - 584.732925037514*x_18 + 911.504815761956*x_19 + 536.285304550625*x_2 + 7950.54534501253*x_20 + 4331.75274608201*x_21 + 650.667030573522*x_22 + 318.952461208227*x_23 - 1114.43112785065*x_24 + 3995.56929872446*x_25 - 795.554881481593*x_26 + 605.421119867249*x_27 - 710.986505167705*x_28 - 804.827935253983*x_29 + 1671.52353267488*x_3 + 6809.81164259561*x_30 + 65593.0910977226*x_31 - 1306.09732006069*x_32 - 3394.29951634799*x_33 + 1458.08394524589*x_34 - 113.76001593148*x_35 - 397.645700511841*x_36 + 33596.3794831693*x_37 - 4504.50023064858*x_38 + 2145.84412344815*x_39 + 476.166903103873*x_4 + 1006.7962810403*x_40 + 916.620287429159*x_41 + 2365769.72648524*x_42 - 2114.13392162402*x_43 - 3859.79944924756*x_44 + 651.40415928376*x_45 - 97.0891798867123*x_46 + 1709.15896052772*x_47 - 2350.69084374815*x_48 + 4267.66503334195*x_49 - 37.9447900927421*x_5 - 15055.9957710243*x_50 - 1274.31330989396*x_51 + 7674.85723419826*x_52 - 1985.87544084186*x_53 - 1119.96047455458*x_54 - 247.818954614271*x_55 - 2150.06721610287*x_56 + 22190.6177936963*x_57 + 2109.60968464114*x_58 - 285.740511176219*x_59 - 197.820050447653*x_6 - 2027.47121127059*x_60 + 854.324976232235*x_61 - 989.211179041228*x_62 - 1770.36968777624*x_63 - 405.085403446656*x_64 + 391.543843542126*x_65 - 2746.19646536084*x_66 - 1675.04378333705*x_67 + 3368.22778123599*x_68 + 295.561567790614*x_69 - 536.354350197742*x_7 + 2734.42607249591*x_70 + 2299.30805249508*x_72 + 1751.75187528711*x_73 + 1894.90427684216*x_74 - 1478.26582803501*x_75 + 2694.26141481108*x_76 - 633.444652658183*x_77 + 1964.42316452142*x_78 + 532.813345902024*x_79 - 2270.69208305*x_8 + 23.5645551482729*x_80 + 1560.14918410121*x_81 + 91.2326803569602*x_82 + 1470.25441663697*x_83 - 1814.76233945344*x_84 - 546.621302629398*x_85 + 1294.70765111749*x_86 - 614.459055671833*x_87 + 3930.17747251116*x_88 + 4044.23235530105*x_89 + 5665.1566246227*x_9 - 8109.61995604351*x_90 - 2365.82968857963*x_91 - 1213.02211109049*x_92 + 1138.34094892537*x_93 + 432.905241430579*x_94 - 795.138148632641*x_95 + 79.1534625434887*x_96 + 2010.45470558142*x_97 - 585.408532721319*x_98 - 1035.17340657778*x_99 + 0.0114893037480412*std::pow(-6.50528001785278*x_106 - 8.69128036499023, 2) + 0.00261749014577518*std::pow(-5.92063999176025*x_115 - 8.77575969696045, 2) - 0.00123506967712476*std::pow(-6.68079996109009*x_15 - 9.93472003936768, 2) - 0.00272383757886425*std::pow(-3.65079998970032*x_67 - 5.68135976791382, 2) + 0.000886840564778785*std::pow(-5.68767976760864*x_77 - 8.32991981506348, 2) + 0.067403711725157*std::pow(-7.47968006134033*x_78 - 8.28623962402344, 2) + 0.0228346173515023*std::pow(-4.50551986694336*x_80 - 5.93232011795044, 2) - 2.06737964360647*std::pow(-7.65576028823853*x_85 - 9.42391967773438, 2) - 1851.18867386964*std::exp(0.648559808731079*x_108) - 3.17460960646006*std::exp(0.721039831638336*x_23) - 0.00771351648869194*std::exp(2.53535985946655*x_71) + 0.0099325910034687*std::exp(2.54663991928101*x_71) + 42.0757854164153*std::exp(2.55391979217529*x_71) + 0.00987811316844847*std::exp(2.56647992134094*x_71) - 0.0530090769453443*std::exp(2.58127999305725*x_71) - 0.020854300422138*std::exp(2.58591985702515*x_71) - 0.00157777450486498*std::exp(2.59999990463257*x_71) - 0.0966876035241131*std::exp(2.60031986236572*x_71) + 0.628891571023843*std::exp(2.60800004005432*x_71) - 0.032459766680278*std::exp(2.61455988883972*x_71) - 34.7358731040367*std::exp(2.62783980369568*x_71) + 33.3356358684171*std::exp(2.63567996025085*x_71) + 1.45088963502751*std::exp(2.66703987121582*x_71) - 20.6390773160479*std::exp(2.67703986167908*x_71) + 0.0287435279207636*std::exp(2.79999995231628*x_71) + 379.338827560966*std::exp(1.35551989078522*x_76) + 0.0530048352029154*std::exp(1.45679986476898*x_76) - 68.6248484136982*std::sin(0.305279940366745*x_103 - 7.50447988510132) - 2.65106303564094*std::sin(0.380319833755493*x_105 - 7.4015998840332) - 0.935530265904473*std::sin(0.399839848279953*x_105 - 7.38983964920044) + 0.791532982806769*std::sin(0.579119861125946*x_106 + 2.17703986167908) + 58.1556500061294*std::sin(0.344239860773087*x_112 + 1.96727979183197) + 1.46695686894085*std::sin(0.531359851360321*x_114 + 8.36511993408203) + 72.4170787054027*std::sin(0.321839839220047*x_115 + 5.11583995819092) - 509.685354934695*std::sin(0.48583984375*x_115 - 4.12815999984741) - 0.0467974700947366*std::sin(0.317279845476151*x_119 - 4.27472019195557) + 933.835334729699*std::sin(0.329919844865799*x_16 - 4.26799964904785) + 0.70356916632539*std::sin(0.414799869060516*x_16 + 2.01095986366272) - 0.834618501240605*std::sin(0.459519863128662*x_21 + 8.22743988037109) + 0.645041047692274*std::sin(0.329759836196899*x_26 + 5.13416004180908) + 853.9261097053*std::sin(0.266959935426712*x_28 - 4.29216003417969) + 2.84687082125646*std::sin(0.300159931182861*x_28 + 5.13399982452393) + 4599.90101082098*std::sin(0.316399842500687*x_28 - 4.29728031158447) - 6.58130428604456*std::sin(0.340879827737808*x_28 - 4.26624011993408) - 0.618619211167318*std::sin(0.343679845333099*x_28 + 5.15528011322021) - 2.19630398928167*std::sin(0.344479858875275*x_28 + 5.146399974823) - 0.329196381960711*std::sin(0.358399868011475*x_28 + 8.34047985076904) - 26.3250789973654*std::sin(0.359679847955704*x_28 + 8.3645601272583) - 0.0641714835592472*std::sin(0.350399851799011*x_34 + 1.9722398519516) - 0.157411593727405*std::sin(0.384399831295013*x_34 + 8.20399951934814) + 6188.0551391011*std::sin(0.394879847764969*x_36 - 7.38895988464355) + 0.228619570897151*std::sin(0.417199850082397*x_36 + 5.21704006195068) - 0.912140649112586*std::sin(0.417439848184586*x_36 - 7.37928009033203) - 302.481395389726*std::sin(0.419759839773178*x_36 + 2.00951981544495) - 57.2261294434847*std::sin(0.364479839801788*x_43 - 4.23239994049072) + 1.95026634799262*std::sin(0.343439847230911*x_45 + 5.14336013793945) - 0.398484437573032*std::sin(0.544799864292145*x_47 + 8.36528015136719) + 11501.5136075477*std::sin(0.325999855995178*x_48 - 7.45655965805054) + 0.950629403988223*std::sin(0.313919931650162*x_53 + 5.14799976348877) - 1.54366625932979*std::sin(0.314319938421249*x_53 + 5.13976001739502) + 35.1112121528935*std::sin(0.472319841384888*x_53 - 7.33735990524292) - 0.455210395924607*std::sin(0.402399837970734*x_55 - 4.19655990600586) + 15.7946930736347*std::sin(0.264399945735931*x_56 + 5.08799982070923) + 0.619209590913837*std::sin(0.443999856710434*x_59 + 2.02063989639282) + 0.431524689595652*std::sin(0.387199819087982*x_6 - 4.21600008010864) + 2.55393007934264*std::sin(0.181680008769035*x_64 - 4.41991996765137) - 4.65214449231544*std::sin(0.238159984350204*x_64 - 4.3471999168396) + 106.801077611935*std::sin(0.254799991846085*x_64 - 4.33599996566772) - 40.5303396860366*std::sin(0.478079855442047*x_69 + 2.04487991333008) - 0.0218555546095081*std::sin(0.520319879055023*x_75 - 7.24647998809814) + 312.744252577468*std::sin(0.130560040473938*x_80 + 4.91039943695068) + 7.71880911581776*std::sin(0.209040001034737*x_80 + 4.99616003036499) + 2931.01794462697*std::sin(0.282239943742752*x_80 + 5.11295986175537) - 12901.8382669732*std::sin(0.302879929542542*x_80 - 7.47616052627563) - 0.0871701484767284*std::sin(0.318959832191467*x_80 - 4.28208017349243) + 111.426931468322*std::sin(0.370159834623337*x_80 + 5.1572003364563) + 0.413532753841261*std::sin(0.457199841737747*x_80 - 7.35167980194092) + 3.67946778922335*std::sin(0.469279855489731*x_80 - 7.3284797668457) - 0.435231010085113*std::sin(0.517839848995209*x_80 + 2.12727999687195) + 0.214845720678066*std::sin(0.538959860801697*x_80 + 2.1541600227356) - 1.90211405129718*std::sin(0.296639859676361*x_81 + 1.88175988197327) - 945.191445566426*std::sin(0.386079847812653*x_81 - 7.3983998298645) - 12813.8257661344*std::sin(0.252799987792969*x_85 - 4.32671976089478) + 59.0987549644251*std::sin(0.435199856758118*x_85 - 4.16016006469727) + 1.74276814962621*std::sin(0.363439828157425*x_95 + 5.16104030609131) + 0.535049781595572*std::sin(0.367999851703644*x_95 + 5.18576002120972) + 0.347072896948007*std::sin(0.37951985001564*x_95 + 1.98959982395172) + 72.3514537439844*std::sin(0.358319848775864*x_96 + 5.16488027572632) - 8.66895706204772*std::sin(0.378959834575653*x_96 + 5.17615985870361) - 0.0359326442078048*std::sin(0.440159857273102*x_96 - 7.3854398727417) - 0.548658908548285*std::sin(0.448879837989807*x_96 - 7.35279989242554) - 7738.72525123402*std::sin(0.453759849071503*x_96 - 7.3551197052002) - 3972.53786241757*std::sin(0.425039857625961*x_97 - 1.15743982791901) - 6257835.65362432 - 0.00177765391921125*std::exp(-3.18055987358093*x_74) + 3.61557990368215*std::exp(-3.1210401058197*x_74) + 0.00728192609221001*std::exp(-2.85591983795166*x_74) - 1.51944097353719*std::exp(-3.94351983070374*x_45) + 7.72828954929274e-5*std::exp(-3.93023991584778*x_45) + 0.452333549295375*std::exp(-3.84215998649597*x_45) - 0.0525230986021521*std::exp(-4.81960010528564*x_111) + 0.430216414510065*std::exp(-4.61560010910034*x_111) + 3.67476410900104e-5*std::exp(-4.57008028030396*x_111));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-24497.352380775*x_1 - 1373.24669362055*x_10 + 935.024809405952*x_100 + 8943.81352233393*x_101 - 3735.57657962957*x_102 - 477.232985102305*x_103 + 8582.23509337019*x_104 + 3054.61748911553*x_105 - 2463.23313697849*x_106 - 1430.63139203522*x_107 + 2531.21640729677*x_108 - 8400.20779729538*x_109 - 1323.31681705079*x_11 + 4835.93260488164*x_110 + 10.3270133743194*x_111 - 2765.96502011965*x_112 + 4608.23725608471*x_113 + 2424.60465620282*x_114 + 4057.56726824124*x_115 - 16542.2860023512*x_116 + 2777.39283993549*x_117 + 4256.72606288094*x_118 + 1299.95600202651*x_119 - 3340.60835525186*x_12 - 234.51954267712*x_120 - 2933.09684673955*x_13 + 2399.63989266015*x_14 + 3010.47542198503*x_15 + 1227.53070196579*x_16 + 3602.6784118917*x_17 - 537.909232580192*x_18 - 1009.43845863433*x_19 + 345.556998753665*x_2 - 4385.26284517506*x_20 - 10734.1782919655*x_21 + 6302.91390979108*x_22 - 3072.39146050133*x_23 - 1212.11546120204*x_24 - 1080.33944026464*x_25 + 1416.15711033006*x_26 - 1066.96528768799*x_27 - 1661.87736773748*x_28 + 2201.16546056097*x_29 + 2179.46650929903*x_3 - 9645.31955504444*x_30 - 129082.846284684*x_31 - 452.816537962242*x_32 + 5892.14141472082*x_33 - 1885.86861525597*x_34 + 197.035116976623*x_35 + 1622.15588116133*x_36 - 35256.4209423067*x_37 + 6796.52688170035*x_38 - 4505.26642510778*x_39 - 2744.90763669399*x_4 - 483.248927278832*x_40 - 4032.81914079998*x_41 - 3233557.83534855*x_42 + 2297.7889136911*x_43 + 11737.0171324918*x_44 - 74.4080618269307*x_45 + 2096.50539652148*x_46 - 3282.58700683006*x_47 + 1287.78127431699*x_48 - 5332.80372060942*x_49 + 111.718825951889*x_5 + 16203.6534252466*x_50 + 7625.67203562723*x_51 - 8719.68242448084*x_52 + 1840.6810171958*x_53 - 2867.37386706725*x_54 + 171.234041318506*x_55 + 3517.19078387013*x_56 - 24551.5279468945*x_57 - 5522.78874390018*x_58 + 6.38632422311645*x_59 + 1381.84147692068*x_6 + 3977.51880495772*x_60 - 762.337991110603*x_61 - 828.630077115845*x_62 + 2726.85742670784*x_63 - 1703.14424097998*x_64 - 1602.60173175256*x_65 + 610.556063319249*x_66 + 1313.45494580073*x_67 - 6627.59564182372*x_68 + 1375.80476674196*x_69 + 838.306244106961*x_7 - 976.11718190672*x_70 + 668.481153160308*x_72 - 3401.69995885427*x_73 - 2552.9656788832*x_74 - 502.438843927301*x_75 + 539.490845398701*x_76 - 358.660323671771*x_77 - 2450.61155595683*x_78 - 372.344864079095*x_79 + 9236.65709409982*x_8 - 42.5541443635448*x_80 - 4805.14678010538*x_81 - 1783.74471015526*x_82 + 180.825594927011*x_83 + 2108.36332252847*x_84 + 115.808973036662*x_85 - 3551.36804511692*x_86 + 2500.57512830426*x_87 - 4637.01017304382*x_88 - 7778.90481095446*x_89 - 13257.1265842065*x_9 + 7062.17392453675*x_90 + 4263.49553723682*x_91 + 4123.35581667008*x_92 - 914.640602209241*x_93 - 533.659628390138*x_94 + 2537.26995294365*x_95 + 2242.09418916828*x_96 - 558.52677440831*x_97 + 2658.42073002513*x_98 + 2687.63152941994*x_99 - 0.01620879645155*std::pow(-6.50528001785278*x_106 - 8.69128036499023, 2) + 0.00328029178771176*std::pow(-5.92063999176025*x_115 - 8.77575969696045, 2) + 0.000597820841833653*std::pow(-6.68079996109009*x_15 - 9.93472003936768, 2) + 9.89280216042373e-5*std::pow(-3.65079998970032*x_67 - 5.68135976791382, 2) - 0.00067260790907991*std::pow(-5.68767976760864*x_77 - 8.32991981506348, 2) + 0.0322773156550967*std::pow(-7.47968006134033*x_78 - 8.28623962402344, 2) - 0.0322144555332723*std::pow(-4.50551986694336*x_80 - 5.93232011795044, 2) + 14.7665194761834*std::pow(-7.65576028823853*x_85 - 9.42391967773438, 2) + 2431.47460439229*std::exp(0.648559808731079*x_108) - 1.52021118313533*std::exp(0.721039831638336*x_23) + 0.00373363625241182*std::exp(2.53535985946655*x_71) - 0.00753319089351248*std::exp(2.54663991928101*x_71) - 55.265141335387*std::exp(2.55391979217529*x_71) - 0.065299750692385*std::exp(2.56647992134094*x_71) - 0.0664320513521922*std::exp(2.58127999305725*x_71) + 0.000757414722049159*std::exp(2.58591985702515*x_71) + 0.0108714284645294*std::exp(2.59999990463257*x_71) + 0.136404234693308*std::exp(2.60031986236572*x_71) + 0.301154509614195*std::exp(2.60800004005432*x_71) - 0.0808300915283975*std::exp(2.61455988883972*x_71) - 1.59934948914326*std::exp(2.62783980369568*x_71) - 24.0141729723182*std::exp(2.63567996025085*x_71) + 8.73115528826474*std::exp(2.66703987121582*x_71) + 147.417209074489*std::exp(2.67703986167908*x_71) + 0.0257468442131816*std::exp(2.79999995231628*x_71) + 17.4659597084182*std::exp(1.35551989078522*x_76) + 0.0664267355144697*std::exp(1.45679986476898*x_76) - 32.8620759501199*std::sin(0.305279940366745*x_103 - 7.50447988510132) - 3.32236601484655*std::sin(0.380319833755493*x_105 - 7.4015998840332) - 2.32962232185696*std::sin(0.399839848279953*x_105 - 7.38983964920044) + 1.97104569722276*std::sin(0.579119861125946*x_106 + 2.17703986167908) + 27.8487374705594*std::sin(0.344239860773087*x_112 + 1.96727979183197) + 1.83842012848875*std::sin(0.531359851360321*x_114 + 8.36511993408203) + 435.791079097049*std::sin(0.321839839220047*x_115 + 5.11583995819092) + 367.164805950358*std::sin(0.48583984375*x_115 - 4.12815999984741) + 0.322451241851838*std::sin(0.317279845476151*x_119 - 4.27472019195557) - 6670.03648820838*std::sin(0.329919844865799*x_16 - 4.26799964904785) - 0.533609088994771*std::sin(0.414799869060516*x_16 + 2.01095986366272) + 0.403987195429459*std::sin(0.459519863128662*x_21 + 8.22743988037109) - 0.0234274742359377*std::sin(0.329759836196899*x_26 + 5.13416004180908) - 615.147387168036*std::sin(0.266959935426712*x_28 - 4.29216003417969) + 3.5677563068258*std::sin(0.300159931182861*x_28 + 5.13399982452393) + 211.793994920806*std::sin(0.316399842500687*x_28 - 4.29728031158447) - 5.89516417885254*std::sin(0.340879827737808*x_28 - 4.26624011993408) + 0.0224678501985697*std::sin(0.343679845333099*x_28 + 5.15528011322021) - 5.46915368266293*std::sin(0.344479858875275*x_28 + 5.146399974823) + 0.24967293890362*std::sin(0.358399868011475*x_28 + 8.34047985076904) - 158.418908752819*std::sin(0.359679847955704*x_28 + 8.3645601272583) + 0.442164384597392*std::sin(0.350399851799011*x_34 + 1.9722398519516) + 1.0405770465682*std::sin(0.384399831295013*x_34 + 8.20399951934814) - 8127.80411509966*std::sin(0.394879847764969*x_36 - 7.38895988464355) - 0.173392307098893*std::sin(0.417199850082397*x_36 + 5.21704006195068) - 2.27137837683036*std::sin(0.417439848184586*x_36 - 7.37928009033203) + 217.900164810685*std::sin(0.419759839773178*x_36 + 2.00951981544495) - 27.4036220927784*std::sin(0.364479839801788*x_43 - 4.23239994049072) + 2.44411337918377*std::sin(0.343439847230911*x_45 + 5.14336013793945) + 2.63420088275839*std::sin(0.544799864292145*x_47 + 8.36528015136719) - 15106.8546623973*std::sin(0.325999855995178*x_48 - 7.45655965805054) - 0.720987380506093*std::sin(0.313919931650162*x_53 + 5.14799976348877) - 3.84397972603842*std::sin(0.314319938421249*x_53 + 5.13976001739502) + 16.8135500061643*std::sin(0.472319841384888*x_53 - 7.33735990524292) + 0.345245949220491*std::sin(0.402399837970734*x_55 - 4.19655990600586) - 22.2827223180428*std::sin(0.264399945735931*x_56 + 5.08799982070923) - 4.09331531472605*std::sin(0.443999856710434*x_59 + 2.02063989639282) - 2.85261508627065*std::sin(0.387199819087982*x_6 - 4.21600008010864) - 1.23619959124191*std::sin(0.181680008769035*x_64 - 4.41991996765137) - 5.83016191981553*std::sin(0.238159984350204*x_64 - 4.3471999168396) + 51.1433570370916*std::sin(0.254799991846085*x_64 - 4.33599996566772) - 19.4085835063328*std::sin(0.478079855442047*x_69 + 2.04487991333008) + 0.15059255790815*std::sin(0.520319879055023*x_75 - 7.24647998809814) + 149.762449298362*std::sin(0.130560040473938*x_80 + 4.91039943695068) + 9.67336828159598*std::sin(0.209040001034737*x_80 + 4.99616003036499) - 20935.1648103081*std::sin(0.282239943742752*x_80 + 5.11295986175537) + 16946.134415649*std::sin(0.302879929542542*x_80 - 7.47616052627563) + 0.600633379792289*std::sin(0.318959832191467*x_80 - 4.28208017349243) + 670.544346349481*std::sin(0.370159834623337*x_80 + 5.1572003364563) - 2.73367851415405*std::sin(0.457199841737747*x_80 - 7.35167980194092) + 3.29586139243956*std::sin(0.469279855489731*x_80 - 7.3284797668457) + 0.210668413013681*std::sin(0.517839848995209*x_80 + 2.12727999687195) - 0.00780305781142793*std::sin(0.538959860801697*x_80 + 2.1541600227356) - 2.38376794343707*std::sin(0.296639859676361*x_81 + 1.88175988197327) + 680.89269259424*std::sin(0.386079847812653*x_81 - 7.3983998298645) + 16830.532930139*std::sin(0.252799987792969*x_85 - 4.32671976089478) + 355.644147204704*std::sin(0.435199856758118*x_85 - 4.16016006469727) + 4.33977577333147*std::sin(0.363439828157425*x_95 + 5.16104030609131) - 0.405798662291039*std::sin(0.367999851703644*x_95 + 5.18576002120972) - 2.29434237655615*std::sin(0.37951985001564*x_95 + 1.98959982395172) + 34.646618870517*std::sin(0.358319848775864*x_96 + 5.16488027572632) + 12.2299282486908*std::sin(0.378959834575653*x_96 + 5.17615985870361) + 0.24758872059475*std::sin(0.440159857273102*x_96 - 7.3854398727417) + 0.0199269371930958*std::sin(0.448879837989807*x_96 - 7.35279989242554) + 10164.5576079567*std::sin(0.453759849071503*x_96 - 7.3551197052002) + 5217.79603764762*std::sin(0.425039857625961*x_97 - 1.15743982791901) + 8269430.42617831 - 0.00222779197927232*std::exp(-3.18055987358093*x_74) - 25.824734818557*std::exp(-3.1210401058197*x_74) + 0.00652274199551537*std::exp(-2.85591983795166*x_74) + 1.99573506049278*std::exp(-3.94351983070374*x_45) - 2.80686484916998e-6*std::exp(-3.93023991584778*x_45) - 3.2308493440273*std::exp(-3.84215998649597*x_45) + 0.375152846675614*std::exp(-4.81960010528564*x_111) - 0.565074917019286*std::exp(-4.61560010910034*x_111) - 1.33465058998604e-6*std::exp(-4.57008028030396*x_111));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (9715.18260672835*x_1 + 592.949535610814*x_10 - 184.955783841301*x_100 - 3774.77193830437*x_101 + 1174.48165390597*x_102 + 192.74752506317*x_103 - 1635.74783709369*x_104 - 468.429332483337*x_105 + 617.099215345252*x_106 + 368.154423263774*x_107 - 1014.1606143728*x_108 + 2296.98928398457*x_109 + 858.181960153778*x_11 - 1195.08272050349*x_110 + 202.250917656395*x_111 + 416.928664790347*x_112 - 2374.56822213394*x_113 - 661.623924167162*x_114 - 698.121873229612*x_115 + 3932.64649129924*x_116 - 713.953972575771*x_117 - 1297.58848213178*x_118 - 95.9944168934853*x_119 + 3988.04129094196*x_12 + 331.638092711856*x_120 + 233.139767462857*x_13 - 731.919628751817*x_14 - 1001.91492100687*x_15 - 2.4256058022402*x_16 - 1333.71873922813*x_17 + 427.192462806143*x_18 + 101.249090621543*x_19 - 300.021258054952*x_2 - 836.483339015655*x_20 + 3092.42407453237*x_21 - 2858.36447672413*x_22 + 1096.02916397994*x_23 + 959.909492880476*x_24 - 980.330465690553*x_25 - 380.739217831195*x_26 + 314.993154602854*x_27 + 955.470687521385*x_28 - 793.320539348831*x_29 - 1516.09098407715*x_3 + 589.337893424354*x_30 + 31299.4306252973*x_31 + 377.18952216052*x_32 - 1442.68789634698*x_33 + 251.079391080223*x_34 - 313.075484677771*x_35 - 557.796257874284*x_36 + 2797.56930112013*x_37 - 1591.30889491008*x_38 + 1175.51646079921*x_39 + 1067.55424355302*x_4 - 46.4142023921037*x_40 + 1615.17962217135*x_41 + 594245.377435102*x_42 - 186.558606413681*x_43 - 4116.4267223318*x_44 - 76.7280596561156*x_45 - 893.55496977732*x_46 + 995.691112462133*x_47 + 491.734701253705*x_48 + 431.016584848308*x_49 + 84.2785134612803*x_5 - 1406.45196189223*x_50 - 2834.47618866321*x_51 + 1091.6669287744*x_52 - 120.898179884927*x_53 + 1895.04172453881*x_54 + 115.838266051866*x_55 - 879.934818025937*x_56 + 5446.01858867685*x_57 + 1597.92443651694*x_58 + 31.0703946648063*x_59 - 602.54716589219*x_6 - 1118.38266953494*x_60 + 27.0588414608691*x_61 + 223.167231255527*x_62 - 606.613448125793*x_63 + 790.878815885274*x_64 + 508.170800995554*x_65 + 460.415876362403*x_66 - 94.5564052541221*x_67 + 1519.94321525584*x_68 - 799.502621041155*x_69 - 229.494517274754*x_7 - 552.965498971312*x_70 - 1027.89134665491*x_72 + 838.252485912211*x_73 + 538.603362773657*x_74 + 710.75470734602*x_75 - 955.601602739945*x_76 + 311.134445578561*x_77 + 356.257996709441*x_78 - 67.0027139146295*x_79 - 3036.92821312703*x_8 + 50.0290404543588*x_80 + 1469.41052495009*x_81 + 733.000793800194*x_82 - 567.46360389709*x_83 - 56.1020223022718*x_84 - 24.8452335544882*x_85 + 995.232489162721*x_86 - 785.507772429203*x_87 + 1033.03880009104*x_88 + 2131.31335572781*x_89 + 3590.86188950789*x_9 - 772.299350196516*x_90 - 1371.82653550707*x_91 - 1444.52738812174*x_92 + 147.652093151162*x_93 + 67.593770859898*x_94 - 751.387413153981*x_95 - 933.630507735921*x_96 - 39.8149829060932*x_97 - 900.940506389208*x_98 - 961.182275595556*x_99 - 0.00701899891230318*std::pow(-6.50528001785278*x_106 - 8.69128036499023, 2) + 0.00015652317435904*std::pow(-5.92063999176025*x_115 - 8.77575969696045, 2) + 0.0037129385256705*std::pow(-6.68079996109009*x_15 - 9.93472003936768, 2) - 0.00208005670635723*std::pow(-3.65079998970032*x_67 - 5.68135976791382, 2) - 0.000876713080409292*std::pow(-5.68767976760864*x_77 - 8.32991981506348, 2) - 0.026437270665275*std::pow(-7.47968006134033*x_78 - 8.28623962402344, 2) - 0.0139500319486617*std::pow(-4.50551986694336*x_80 - 5.93232011795044, 2) - 5.62893429890941*std::pow(-7.65576028823853*x_85 - 9.42391967773438, 2) - 412.456408862662*std::exp(0.648559808731079*x_108) + 1.24515418030373*std::exp(0.721039831638336*x_23) + 0.0231888233269012*std::exp(2.53535985946655*x_71) - 0.00981916344486206*std::exp(2.54663991928101*x_71) + 9.37474801887898*std::exp(2.55391979217529*x_71) - 0.0490612801409115*std::exp(2.56647992134094*x_71) - 0.0031698873849516*std::exp(2.58127999305725*x_71) - 0.0159253722711116*std::exp(2.58591985702515*x_71) - 0.00572827139421601*std::exp(2.59999990463257*x_71) + 0.0590679991452615*std::exp(2.60031986236572*x_71) - 0.246665595361597*std::exp(2.60800004005432*x_71) - 0.0435203296989972*std::exp(2.61455988883972*x_71) + 10.7014934535612*std::exp(2.62783980369568*x_71) + 23.2016808517907*std::exp(2.63567996025085*x_71) - 5.46484840009576*std::exp(2.66703987121582*x_71) - 56.1948119018337*std::exp(2.67703986167908*x_71) - 0.0103374458607846*std::exp(2.79999995231628*x_71) - 116.867423129592*std::exp(1.35551989078522*x_76) + 0.00316963373318872*std::exp(1.45679986476898*x_76) + 26.9162282824148*std::sin(0.305279940366745*x_103 - 7.50447988510132) - 0.158530798075475*std::sin(0.380319833755493*x_105 - 7.4015998840332) - 1.25430925048178*std::sin(0.399839848279953*x_105 - 7.38983964920044) + 1.06124534777729*std::sin(0.579119861125946*x_106 + 2.17703986167908) - 22.8099702609287*std::sin(0.344239860773087*x_112 + 1.96727979183197) + 0.087722487186831*std::sin(0.531359851360321*x_114 + 8.36511993408203) - 272.762550058003*std::sin(0.321839839220047*x_115 + 5.11583995819092) - 354.742204009681*std::sin(0.48583984375*x_115 - 4.12815999984741) - 0.169902992118826*std::sin(0.317279845476151*x_119 - 4.27472019195557) + 2542.5894858981*std::sin(0.329919844865799*x_16 - 4.26799964904785) - 0.69553459278669*std::sin(0.414799869060516*x_16 + 2.01095986366272) + 2.50907883570408*std::sin(0.459519863128662*x_21 + 8.22743988037109) + 0.492585155421588*std::sin(0.329759836196899*x_26 + 5.13416004180908) + 594.334577765303*std::sin(0.266959935426712*x_28 - 4.29216003417969) + 0.170239898955272*std::sin(0.300159931182861*x_28 + 5.13399982452393) - 1417.14619946058*std::sin(0.316399842500687*x_28 - 4.29728031158447) + 2.36692854606721*std::sin(0.340879827737808*x_28 - 4.26624011993408) - 0.472408138008925*std::sin(0.343679845333099*x_28 + 5.15528011322021) - 2.94468763975547*std::sin(0.344479858875275*x_28 + 5.146399974823) + 0.325437046466588*std::sin(0.358399868011475*x_28 + 8.34047985076904) + 99.1547271191439*std::sin(0.359679847955704*x_28 + 8.3645601272583) - 0.232981121486873*std::sin(0.350399851799011*x_34 + 1.9722398519516) + 0.781810672300748*std::sin(0.384399831295013*x_34 + 8.20399951934814) + 1378.73736834321*std::sin(0.394879847764969*x_36 - 7.38895988464355) - 0.226008795947542*std::sin(0.417199850082397*x_36 + 5.21704006195068) - 1.2229496956106*std::sin(0.417439848184586*x_36 - 7.37928009033203) - 210.527761556389*std::sin(0.419759839773178*x_36 + 2.00951981544495) + 22.4453911290883*std::sin(0.364479839801788*x_43 - 4.23239994049072) + 0.116623888776098*std::sin(0.343439847230911*x_45 + 5.14336013793945) + 1.97913875759279*std::sin(0.544799864292145*x_47 + 8.36528015136719) + 2562.60913110374*std::sin(0.325999855995178*x_48 - 7.45655965805054) - 0.939773467969473*std::sin(0.313919931650162*x_53 + 5.14799976348877) - 2.06966566374206*std::sin(0.314319938421249*x_53 + 5.13976001739502) - 13.7714169637559*std::sin(0.472319841384888*x_53 - 7.33735990524292) + 0.450012013765908*std::sin(0.402399837970734*x_55 - 4.19655990600586) - 9.64922992160467*std::sin(0.264399945735931*x_56 + 5.08799982070923) - 3.0754066781495*std::sin(0.443999856710434*x_59 + 2.02063989639282) - 2.14323862492228*std::sin(0.387199819087982*x_6 - 4.21600008010864) - 7.67777361803218*std::sin(0.181680008769035*x_64 - 4.41991996765137) - 0.278193377227973*std::sin(0.238159984350204*x_64 - 4.3471999168396) - 41.8898147283474*std::sin(0.254799991846085*x_64 - 4.33599996566772) + 15.8969221873781*std::sin(0.478079855442047*x_69 + 2.04487991333008) - 0.0793488219567124*std::sin(0.520319879055023*x_75 - 7.24647998809814) - 122.665417716362*std::sin(0.130560040473938*x_80 + 4.91039943695068) + 0.461576715782241*std::sin(0.209040001034737*x_80 + 4.99616003036499) + 7980.39561347751*std::sin(0.282239943742752*x_80 + 5.11295986175537) - 2874.61021906478*std::sin(0.302879929542542*x_80 - 7.47616052627563) - 0.316480122101819*std::sin(0.318959832191467*x_80 - 4.28208017349243) - 419.695112199694*std::sin(0.370159834623337*x_80 + 5.1572003364563) - 2.05387870514095*std::sin(0.457199841737747*x_80 - 7.35167980194092) - 1.32329960234703*std::sin(0.469279855489731*x_80 - 7.3284797668457) + 1.30841685683152*std::sin(0.517839848995209*x_80 + 2.12727999687195) + 0.164066787827673*std::sin(0.538959860801697*x_80 + 2.1541600227356) - 0.113744431772749*std::sin(0.296639859676361*x_81 + 1.88175988197327) - 657.855465857541*std::sin(0.386079847812653*x_81 - 7.3983998298645) - 2855.00048368588*std::sin(0.252799987792969*x_85 - 4.32671976089478) - 222.598417355754*std::sin(0.435199856758118*x_85 - 4.16016006469727) + 2.33661089457943*std::sin(0.363439828157425*x_95 + 5.16104030609131) - 0.528939654798021*std::sin(0.367999851703644*x_95 + 5.18576002120972) - 1.72379485192296*std::sin(0.37951985001564*x_95 + 1.98959982395172) - 28.3778877557263*std::sin(0.358319848775864*x_96 + 5.16488027572632) + 5.29600413773458*std::sin(0.378959834575653*x_96 + 5.17615985870361) - 0.130457132688758*std::sin(0.440159857273102*x_96 - 7.3854398727417) - 0.41898300070607*std::sin(0.448879837989807*x_96 - 7.35279989242554) - 1724.23636302107*std::sin(0.453759849071503*x_96 - 7.3551197052002) - 885.106269248431*std::sin(0.425039857625961*x_97 - 1.15743982791901) - 1303376.36356905 - 0.000106301845986255*std::exp(-3.18055987358093*x_74) + 9.84427886441845*std::exp(-3.1210401058197*x_74) - 0.00261890318223874*std::exp(-2.85591983795166*x_74) - 0.338540947376209*std::exp(-3.94351983070374*x_45) + 5.90170303487028e-5*std::exp(-3.93023991584778*x_45) + 1.23158600214061*std::exp(-3.84215998649597*x_45) - 0.14300666649252*std::exp(-4.81960010528564*x_111) + 0.0958549065620998*std::exp(-4.61560010910034*x_111) + 2.80623110148721e-5*std::exp(-4.57008028030396*x_111));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-14000.6530662913*x_1 - 870.873639118259*x_10 + 239.437129825452*x_100 + 2524.15406182899*x_101 - 1549.8164368279*x_102 - 230.207644740324*x_103 + 3170.80786358692*x_104 + 1218.54892879538*x_105 - 561.850046341844*x_106 - 480.829269638096*x_107 + 812.645876427374*x_108 - 3276.40517553354*x_109 - 312.283060646104*x_11 + 1885.83985377639*x_110 + 300.444970535966*x_111 - 1214.58691739758*x_112 + 690.234885722754*x_113 + 358.349837029498*x_114 + 1784.46013570752*x_115 - 5098.53936624081*x_116 + 1198.25241228468*x_117 + 1567.93671377999*x_118 + 865.584072213521*x_119 - 2662.83141529626*x_12 - 705.555125286004*x_120 - 1513.7812464385*x_13 + 806.95089481875*x_14 + 980.188831638656*x_15 + 747.459483594199*x_16 + 1361.21010440124*x_17 - 283.03508112084*x_18 - 480.671380198889*x_19 + 116.749104168224*x_2 - 1846.49350879885*x_20 - 4692.55559747602*x_21 + 1850.19132644261*x_22 - 1333.44235227828*x_23 - 222.080453208921*x_24 - 781.021978252041*x_25 + 419.107372753241*x_26 - 120.161360705776*x_27 - 590.039182901349*x_28 + 651.268190355249*x_29 + 1456.86788708036*x_3 - 3545.03227099235*x_30 - 69881.5513055941*x_31 - 131.376033968057*x_32 + 2082.12265581398*x_33 - 1035.52768725653*x_34 - 264.743256201435*x_35 + 605.939916582039*x_36 - 15448.0199847794*x_37 + 2363.37766686995*x_38 - 1910.19990301508*x_39 - 542.11570354955*x_4 - 329.207618901892*x_40 - 1688.88783552952*x_41 - 1075460.19251842*x_42 + 4.75397644138157*x_43 + 2927.20287983529*x_44 - 178.932603857435*x_45 + 448.380482618329*x_46 - 1441.27027706107*x_47 + 1560.34680579407*x_48 - 1094.11015246738*x_49 - 59.3349084995699*x_5 + 5868.30126884718*x_50 + 2161.55634580841*x_51 - 3015.40606049861*x_52 + 747.494582169336*x_53 - 102.420799711321*x_54 - 16.4543596572836*x_55 + 913.24426231683*x_56 - 4861.65107828008*x_57 - 1586.29672925573*x_58 + 132.02262746503*x_59 + 705.412734543065*x_6 + 1378.78089081761*x_60 - 472.22549219588*x_61 - 278.511238139383*x_62 + 1504.39217751342*x_63 - 480.115325790342*x_64 - 563.337770939362*x_65 + 359.311437073255*x_66 + 446.823510003466*x_67 - 2994.44924903634*x_68 + 606.132308698339*x_69 + 64.6052432969629*x_7 - 257.132665369224*x_70 - 243.670323242501*x_72 - 1131.47253080043*x_73 - 665.607842374345*x_74 + 132.929502003425*x_75 + 426.042238296323*x_76 - 140.786354386052*x_77 - 522.833087018799*x_78 - 262.889603989376*x_79 + 1299.55000077061*x_8 + 30.9671213336972*x_80 - 1241.86846464614*x_81 - 495.744200576067*x_82 + 73.2400406059406*x_83 + 3135.47186414664*x_84 + 69.1567195659395*x_85 - 1433.32183115928*x_86 + 642.886327067577*x_87 - 1767.97096088575*x_88 - 3305.21827983872*x_89 - 4463.66016483808*x_9 + 1912.77901778427*x_90 + 64.1615271163616*x_91 + 1536.6616943202*x_92 - 133.959222836604*x_93 - 394.878202906633*x_94 + 852.495875272551*x_95 + 659.790194707636*x_96 - 418.685248913401*x_97 + 620.381878141961*x_98 + 1134.80454279176*x_99 - 0.0404327112868086*std::pow(-6.50528001785278*x_106 - 8.69128036499023, 2) - 0.0013287731926446*std::pow(-5.92063999176025*x_115 - 8.77575969696045, 2) - 0.00182548318923413*std::pow(-6.68079996109009*x_15 - 9.93472003936768, 2) + 0.000377372603593173*std::pow(-3.65079998970032*x_67 - 5.68135976791382, 2) + 0.00236645373778171*std::pow(-5.68767976760864*x_77 - 8.32991981506348, 2) + 0.0214417997681909*std::pow(-7.47968006134033*x_78 - 8.28623962402344, 2) - 0.0803586980521293*std::pow(-4.50551986694336*x_80 - 5.93232011795044, 2) + 5.05979350519094*std::pow(-7.65576028823853*x_85 - 9.42391967773438, 2) + 797.186017094597*std::exp(0.648559808731079*x_108) - 1.00987529887744*std::exp(0.721039831638336*x_23) - 0.0114008909301115*std::exp(2.53535985946655*x_71) + 0.0265042196303668*std::exp(2.54663991928101*x_71) - 18.1192918181181*std::exp(2.55391979217529*x_71) + 0.0250405117328551*std::exp(2.56647992134094*x_71) + 0.026910145402266*std::exp(2.58127999305725*x_71) + 0.00288924776847299*std::exp(2.58591985702515*x_71) - 0.00439905580405248*std::exp(2.59999990463257*x_71) + 0.340259257134738*std::exp(2.60031986236572*x_71) + 0.20005674460155*std::exp(2.60800004005432*x_71) + 0.0480690320522436*std::exp(2.61455988883972*x_71) + 13.6292899579953*std::exp(2.62783980369568*x_71) + 10.4751255130773*std::exp(2.63567996025085*x_71) + 4.46414089974823*std::exp(2.66703987121582*x_71) + 50.512961990232*std::exp(2.67703986167908*x_71) - 0.0315327961000543*std::exp(2.79999995231628*x_71) - 148.840907429315*std::exp(1.35551989078522*x_76) - 0.026907992074721*std::exp(1.45679986476898*x_76) - 21.8302556513336*std::sin(0.305279940366745*x_103 - 7.50447988510132) + 1.34581652559668*std::sin(0.380319833755493*x_105 - 7.4015998840332) + 1.38540842824138*std::sin(0.399839848279953*x_105 - 7.38983964920044) - 1.17216567499433*std::sin(0.579119861125946*x_106 + 2.17703986167908) + 18.4998981644362*std::sin(0.344239860773087*x_112 + 1.96727979183197) - 0.744703075715757*std::sin(0.531359851360321*x_114 + 8.36511993408203) + 222.815047460826*std::sin(0.321839839220047*x_115 + 5.11583995819092) - 160.159478768983*std::sin(0.48583984375*x_115 - 4.12815999984741) - 0.130477886288852*std::sin(0.317279845476151*x_119 - 4.27472019195557) - 2285.50860321935*std::sin(0.329919844865799*x_16 - 4.26799964904785) + 1.87741060745681*std::sin(0.414799869060516*x_16 + 2.01095986366272) - 1.23360007265776*std::sin(0.459519863128662*x_21 + 8.22743988037109) - 0.0893668629440085*std::sin(0.329759836196899*x_26 + 5.13416004180908) + 268.330960098215*std::sin(0.266959935426712*x_28 - 4.29216003417969) - 1.44521867114323*std::sin(0.300159931182861*x_28 + 5.13399982452393) - 1804.85990568837*std::sin(0.316399842500687*x_28 - 4.29728031158447) + 7.21995319072661*std::sin(0.340879827737808*x_28 - 4.26624011993408) + 0.0857062638985642*std::sin(0.343679845333099*x_28 + 5.15528011322021) + 3.25246351574659*std::sin(0.344479858875275*x_28 + 5.146399974823) - 0.878430734333247*std::sin(0.358399868011475*x_28 + 8.34047985076904) - 80.9977954243323*std::sin(0.359679847955704*x_28 + 8.3645601272583) - 0.178919063741699*std::sin(0.350399851799011*x_34 + 1.9722398519516) - 0.399030340349666*std::sin(0.384399831295013*x_34 + 8.20399951934814) - 2664.79106075665*std::sin(0.394879847764969*x_36 - 7.38895988464355) + 0.610050621911465*std::sin(0.417199850082397*x_36 + 5.21704006195068) + 1.35077120332436*std::sin(0.417439848184586*x_36 - 7.37928009033203) - 95.049351828326*std::sin(0.419759839773178*x_36 + 2.00951981544495) - 18.2042083088699*std::sin(0.364479839801788*x_43 - 4.23239994049072) - 0.990055930453946*std::sin(0.343439847230911*x_45 + 5.14336013793945) - 1.01013767146129*std::sin(0.544799864292145*x_47 + 8.36528015136719) - 4952.95047597398*std::sin(0.325999855995178*x_48 - 7.45655965805054) + 2.53666847870708*std::sin(0.313919931650162*x_53 + 5.14799976348877) + 2.28598509744603*std::sin(0.314319938421249*x_53 + 5.13976001739502) + 11.1692303188079*std::sin(0.472319841384888*x_53 - 7.33735990524292) - 1.21468771918613*std::sin(0.402399837970734*x_55 - 4.19655990600586) - 55.5840700981469*std::sin(0.264399945735931*x_56 + 5.08799982070923) + 1.56966464768795*std::sin(0.443999856710434*x_59 + 2.02063989639282) + 1.09389302071883*std::sin(0.387199819087982*x_6 - 4.21600008010864) + 3.7748124763073*std::sin(0.181680008769035*x_64 - 4.41991996765137) + 2.36166882984282*std::sin(0.238159984350204*x_64 - 4.3471999168396) + 33.9744987712216*std::sin(0.254799991846085*x_64 - 4.33599996566772) - 12.8931093828829*std::sin(0.478079855442047*x_69 + 2.04487991333008) - 0.0609363404334958*std::sin(0.520319879055023*x_75 - 7.24647998809814) + 99.4870975319865*std::sin(0.130560040473938*x_80 + 4.91039943695068) - 3.91846618746368*std::sin(0.209040001034737*x_80 + 4.99616003036499) - 7173.49888090736*std::sin(0.282239943742752*x_80 + 5.11295986175537) + 5555.97881859735*std::sin(0.302879929542542*x_80 - 7.47616052627563) - 0.243042555456608*std::sin(0.318959832191467*x_80 - 4.28208017349243) + 342.841736609244*std::sin(0.370159834623337*x_80 + 5.1572003364563) + 1.04828438365709*std::sin(0.457199841737747*x_80 - 7.35167980194092) - 4.03652286087279*std::sin(0.469279855489731*x_80 - 7.3284797668457) - 0.643289125349892*std::sin(0.517839848995209*x_80 + 2.12727999687195) - 0.0297656841260482*std::sin(0.538959860801697*x_80 + 2.1541600227356) + 0.965611337561613*std::sin(0.296639859676361*x_81 + 1.88175988197327) - 297.00945454518*std::sin(0.386079847812653*x_81 - 7.3983998298645) + 5518.07758465583*std::sin(0.252799987792969*x_85 - 4.32671976089478) + 181.836828102978*std::sin(0.435199856758118*x_85 - 4.16016006469727) - 2.5808311830815*std::sin(0.363439828157425*x_95 + 5.16104030609131) + 1.42773188986*std::sin(0.367999851703644*x_95 + 5.18576002120972) + 0.879812045071725*std::sin(0.37951985001564*x_95 + 1.98959982395172) + 23.0157263511207*std::sin(0.358319848775864*x_96 + 5.16488027572632) + 30.507456825421*std::sin(0.378959834575653*x_96 + 5.17615985870361) - 0.100185233422075*std::sin(0.440159857273102*x_96 - 7.3854398727417) + 0.0760136516252145*std::sin(0.448879837989807*x_96 - 7.35279989242554) + 3332.56336725787*std::sin(0.453759849071503*x_96 - 7.3551197052002) + 1710.7125173137*std::sin(0.425039857625961*x_97 - 1.15743982791901) + 2673239.0624295 + 0.000902428946087961*std::exp(-3.18055987358093*x_74) - 8.84892514576399*std::exp(-3.1210401058197*x_74) - 0.00798856324506542*std::exp(-2.85591983795166*x_74) + 0.654323956818757*std::exp(-3.94351983070374*x_45) - 1.07071169410717e-5*std::exp(-3.93023991584778*x_45) - 1.1070605062707*std::exp(-3.84215998649597*x_45) + 0.128547281580112*std::exp(-4.81960010528564*x_111) - 0.185266102160772*std::exp(-4.61560010910034*x_111) - 5.09118205198821e-6*std::exp(-4.57008028030396*x_111));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-4542.0073528741*x_1 - 567.4573939935*x_10 + 640.770292744281*x_100 + 73.7516463175571*x_101 - 779.84632739832*x_102 - 242.015553446008*x_103 + 2056.90044611893*x_104 + 996.145228159581*x_105 - 226.646106354089*x_106 - 95.3717259415013*x_107 + 252.539954227849*x_108 - 2411.19431372217*x_109 + 272.52129586976*x_11 + 1282.79247665191*x_110 + 417.752073882739*x_111 - 963.06392696702*x_112 - 866.860228328596*x_113 - 191.018041676186*x_114 + 1442.43830390645*x_115 - 3326.31483480676*x_116 + 668.949174005607*x_117 + 882.789074863725*x_118 + 910.003028667314*x_119 - 577.942675199247*x_12 - 515.299314377308*x_120 - 1464.14035270043*x_13 + 360.220281580207*x_14 + 555.427060662142*x_15 + 669.897140918091*x_16 + 658.381235016695*x_17 - 38.6309953654891*x_18 - 460.017360415976*x_19 - 75.5053216425007*x_2 - 2672.56235162894*x_20 - 3408.77616522644*x_21 + 210.559201297792*x_22 - 851.696905523951*x_23 + 490.547452385293*x_24 - 1528.4449229872*x_25 + 125.669115354633*x_26 + 89.8017305091892*x_27 - 23.1736954985971*x_28 - 5.63203497371508*x_29 + 514.235716689851*x_3 - 4007.04382541296*x_30 - 53568.4194653416*x_31 - 41.3601119920069*x_32 + 1223.40547156657*x_33 - 1065.59062228154*x_34 - 768.222675704659*x_35 + 245.266769121187*x_36 - 16669.9011432974*x_37 + 1151.12949540748*x_38 - 1262.49117002036*x_39 + 133.640657533222*x_4 - 277.258569266376*x_40 - 672.206311416069*x_41 - 853477.767638697*x_42 - 141.316908266234*x_43 + 47.2211362263827*x_44 - 157.521225088418*x_45 - 166.429667927646*x_46 - 760.431908367448*x_47 + 1947.29303975037*x_48 - 1038.54129008689*x_49 + 112.1777385233*x_5 + 5156.40550230352*x_50 + 483.229370663563*x_51 - 2667.08240259542*x_52 + 742.411193042282*x_53 + 1337.90097917527*x_54 + 239.668296693727*x_55 + 327.345655673603*x_56 + 401.515037255968*x_57 - 678.46598835224*x_58 + 26.4172526188358*x_59 + 306.581187972614*x_6 + 783.35114761735*x_60 - 568.173061493254*x_61 - 551.41124287546*x_62 + 1155.93232750464*x_63 - 114.905999944413*x_64 - 380.912723614696*x_65 + 484.074175885611*x_66 + 291.856542817808*x_67 - 2348.97376803515*x_68 + 60.2115240404065*x_69 - 158.364280267019*x_7 - 702.731278650551*x_70 - 979.77875233353*x_72 - 724.9731525972*x_73 - 209.806649918631*x_74 + 596.832647152905*x_75 + 129.353392677034*x_76 - 31.704767016318*x_77 - 301.059470866091*x_78 - 413.109317061816*x_79 - 254.181945464725*x_8 + 106.287746690194*x_80 - 308.771459414229*x_81 - 56.5251335097937*x_82 - 327.659793049566*x_83 + 3053.50334630083*x_84 - 91.1864720965696*x_85 - 1053.48718046963*x_86 + 267.572651166825*x_87 - 956.866621862196*x_88 - 2080.99275221343*x_89 - 2485.8715027785*x_9 + 990.783234424707*x_90 - 1082.86896834939*x_91 + 610.923774159508*x_92 + 89.1622465881878*x_93 - 359.967015746414*x_94 + 443.583232384752*x_95 + 161.074456226648*x_96 + 103.249837455051*x_97 + 144.129006703162*x_98 + 534.755107150973*x_99 - 0.0363211328581081*std::pow(-6.50528001785278*x_106 - 8.69128036499023, 2) - 0.00152965882754581*std::pow(-5.92063999176025*x_115 - 8.77575969696045, 2) - 0.00259575670810957*std::pow(-6.68079996109009*x_15 - 9.93472003936768, 2) + 0.0010745604481723*std::pow(-3.65079998970032*x_67 - 5.68135976791382, 2) + 0.00288248216172359*std::pow(-5.68767976760864*x_77 - 8.32991981506348, 2) + 0.0219023729008958*std::pow(-7.47968006134033*x_78 - 8.28623962402344, 2) - 0.0721870697107624*std::pow(-4.50551986694336*x_80 - 5.93232011795044, 2) + 1.81716875537472*std::pow(-7.65576028823853*x_85 - 9.42391967773438, 2) + 587.823549641281*std::exp(0.648559808731079*x_108) - 1.03156757448274*std::exp(0.721039831638336*x_23) - 0.0162115648529628*std::exp(2.53535985946655*x_71) + 0.0322837244080467*std::exp(2.54663991928101*x_71) - 13.3606789445838*std::exp(2.55391979217529*x_71) + 0.0318789171573149*std::exp(2.56647992134094*x_71) + 0.0309784556860241*std::exp(2.58127999305725*x_71) + 0.00822707146043423*std::exp(2.58591985702515*x_71) - 0.00223079845260813*std::exp(2.59999990463257*x_71) + 0.305658495096372*std::exp(2.60031986236572*x_71) + 0.20435399401979*std::exp(2.60800004005432*x_71) + 0.0114682122720321*std::exp(2.61455988883972*x_71) + 20.7039782894715*std::exp(2.62783980369568*x_71) + 50.5249330397933*std::exp(2.63567996025085*x_71) + 6.51549983395011*std::exp(2.66703987121582*x_71) + 18.1411704204749*std::exp(2.67703986167908*x_71) - 0.0278765134796784*std::exp(2.79999995231628*x_71) - 226.101207436272*std::exp(1.35551989078522*x_76) - 0.0309759768156601*std::exp(1.45679986476898*x_76) - 22.2991728757169*std::sin(0.305279940366745*x_103 - 7.50447988510132) + 1.54927879342506*std::sin(0.380319833755493*x_105 - 7.4015998840332) + 0.330527935766766*std::sin(0.399839848279953*x_105 - 7.38983964920044) - 0.279652911758546*std::sin(0.579119861125946*x_106 + 2.17703986167908) + 18.8972788015297*std::sin(0.344239860773087*x_112 + 1.96727979183197) - 0.857288241495858*std::sin(0.531359851360321*x_114 + 8.36511993408203) + 325.202863739018*std::sin(0.321839839220047*x_115 + 5.11583995819092) - 772.501191550289*std::sin(0.48583984375*x_115 - 4.12815999984741) - 0.0661664411177992*std::sin(0.317279845476151*x_119 - 4.27472019195557) - 820.8150826016*std::sin(0.329919844865799*x_16 - 4.26799964904785) + 2.28679838520642*std::sin(0.414799869060516*x_16 + 2.01095986366272) - 1.75412498050408*std::sin(0.459519863128662*x_21 + 8.22743988037109) - 0.25447023812145*std::sin(0.329759836196899*x_26 + 5.13416004180908) + 1294.24738391349*std::sin(0.266959935426712*x_28 - 4.29216003417969) - 1.66370868278011*std::sin(0.300159931182861*x_28 + 5.13399982452393) - 2741.72612205588*std::sin(0.316399842500687*x_28 - 4.29728031158447) + 6.38278704512319*std::sin(0.340879827737808*x_28 - 4.26624011993408) + 0.244046760334779*std::sin(0.343679845333099*x_28 + 5.15528011322021) + 0.775966155613088*std::sin(0.344479858875275*x_28 + 5.146399974823) - 1.06998116278363*std::sin(0.358399868011475*x_28 + 8.34047985076904) - 118.217846275265*std::sin(0.359679847955704*x_28 + 8.3645601272583) - 0.0907313724389197*std::sin(0.350399851799011*x_34 + 1.9722398519516) - 0.508003003252192*std::sin(0.384399831295013*x_34 + 8.20399951934814) - 1964.94532868914*std::sin(0.394879847764969*x_36 - 7.38895988464355) + 0.743078137270727*std::sin(0.417199850082397*x_36 + 5.21704006195068) + 0.32226425682622*std::sin(0.417439848184586*x_36 - 7.37928009033203) - 458.453899249855*std::sin(0.419759839773178*x_36 + 2.00951981544495) - 18.5952374827206*std::sin(0.364479839801788*x_43 - 4.23239994049072) - 1.13973385538342*std::sin(0.343439847230911*x_45 + 5.14336013793945) - 1.28599988249225*std::sin(0.544799864292145*x_47 + 8.36528015136719) - 3652.1726015661*std::sin(0.325999855995178*x_48 - 7.45655965805054) + 3.08981389466493*std::sin(0.313919931650162*x_53 + 5.14799976348877) + 0.545385692803636*std::sin(0.314319938421249*x_53 + 5.13976001739502) + 11.4091470913481*std::sin(0.472319841384888*x_53 - 7.33735990524292) - 1.4795622778161*std::sin(0.402399837970734*x_55 - 4.19655990600586) - 49.9317589787222*std::sin(0.264399945735931*x_56 + 5.08799982070923) + 1.99833013806801*std::sin(0.443999856710434*x_59 + 2.02063989639282) + 1.39262828805154*std::sin(0.387199819087982*x_6 - 4.21600008010864) + 5.36761711365925*std::sin(0.181680008769035*x_64 - 4.41991996765137) + 2.71870895146444*std::sin(0.238159984350204*x_64 - 4.3471999168396) + 34.704276191975*std::sin(0.254799991846085*x_64 - 4.33599996566772) - 13.1700553409172*std::sin(0.478079855442047*x_69 + 2.04487991333008) - 0.0309013342866479*std::sin(0.520319879055023*x_75 - 7.24647998809814) + 101.624095576432*std::sin(0.130560040473938*x_80 + 4.91039943695068) - 4.51086492960034*std::sin(0.209040001034737*x_80 + 4.99616003036499) - 2576.28261306061*std::sin(0.282239943742752*x_80 + 5.11295986175537) + 4096.82949881962*std::sin(0.302879929542542*x_80 - 7.47616052627563) - 0.123248938131465*std::sin(0.318959832191467*x_80 - 4.28208017349243) + 500.384133949417*std::sin(0.370159834623337*x_80 + 5.1572003364563) + 1.33456422058915*std::sin(0.457199841737747*x_80 - 7.35167980194092) - 3.56848100577914*std::sin(0.469279855489731*x_80 - 7.3284797668457) - 0.914728808366341*std::sin(0.517839848995209*x_80 + 2.12727999687195) - 0.0847571513408615*std::sin(0.538959860801697*x_80 + 2.1541600227356) + 1.11159369759689*std::sin(0.296639859676361*x_81 + 1.88175988197327) - 1432.57307841768*std::sin(0.386079847812653*x_81 - 7.3983998298645) + 4068.88214726861*std::sin(0.252799987792969*x_85 - 4.32671976089478) + 265.394361405077*std::sin(0.435199856758118*x_85 - 4.16016006469727) - 0.615729474512625*std::sin(0.363439828157425*x_95 + 5.16104030609131) + 1.73906281730364*std::sin(0.367999851703644*x_95 + 5.18576002120972) + 1.12008315157748*std::sin(0.37951985001564*x_95 + 1.98959982395172) + 23.5101076671304*std::sin(0.358319848775864*x_96 + 5.16488027572632) + 27.4051716358835*std::sin(0.378959834575653*x_96 + 5.17615985870361) - 0.0508047803090525*std::sin(0.440159857273102*x_96 - 7.3854398727417) + 0.216447253403854*std::sin(0.448879837989807*x_96 - 7.35279989242554) + 2457.34268531903*std::sin(0.453759849071503*x_96 - 7.3551197052002) + 1261.43344561924*std::sin(0.425039857625961*x_97 - 1.15743982791901) + 2025524.00530318 + 0.0010388593111733*std::exp(-3.18055987358093*x_74) - 3.17799338590306*std::exp(-3.1210401058197*x_74) - 0.00706227542517062*std::exp(-2.85591983795166*x_74) + 0.482480904913926*std::exp(-3.94351983070374*x_45) - 3.04882873565318e-5*std::exp(-3.93023991584778*x_45) - 0.397588510329636*std::exp(-3.84215998649597*x_45) + 0.0461663313801424*std::exp(-4.81960010528564*x_111) - 0.136610245871167*std::exp(-4.61560010910034*x_111) - 1.44970324168233e-5*std::exp(-4.57008028030396*x_111));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (19699.1411176339*x_1 + 1031.87706322538*x_10 + 289.653954600518*x_100 - 3788.83699678431*x_101 + 1638.22616750789*x_102 + 307.693284649886*x_103 - 2563.84364132805*x_104 - 805.025004714753*x_105 + 514.630531947336*x_106 + 424.647587489192*x_107 - 1042.49044700397*x_108 + 2898.01971323764*x_109 + 890.730401410465*x_11 - 1499.14094366607*x_110 - 92.4897387791711*x_111 + 957.858777198011*x_112 - 1684.00415951088*x_113 - 210.296349312558*x_114 - 1285.62146030533*x_115 + 4324.12496153229*x_116 - 1164.19247418448*x_117 - 1513.7076626018*x_118 - 510.158690462783*x_119 + 6302.46657615936*x_12 + 923.625315415831*x_120 + 763.133528587173*x_13 - 870.613587563128*x_14 - 1070.52729945738*x_15 - 354.908784183925*x_16 - 1569.61054785199*x_17 + 560.220228235202*x_18 + 321.431764937102*x_19 - 384.913322079123*x_2 - 570.50188603446*x_20 + 4123.84530131885*x_21 - 2808.1615407001*x_22 + 1537.99310528896*x_23 + 908.752786373666*x_24 - 443.038291993921*x_25 - 423.989081927106*x_26 - 7.89864165387045*x_27 + 1069.54323640249*x_28 - 922.843027311082*x_29 - 2607.54930924465*x_3 + 2172.73066003046*x_30 + 72376.9714829604*x_31 + 571.35231472442*x_32 - 1804.25378013048*x_33 + 704.532123759529*x_34 + 15.2452864616983*x_35 - 773.003009592696*x_36 + 6228.45256260951*x_37 - 2199.30001523953*x_38 + 1874.95436915836*x_39 + 693.122113826687*x_4 + 197.868729278368*x_40 + 2028.16421982923*x_41 + 518677.057380262*x_42 + 473.270006308652*x_43 - 3525.14121941165*x_44 + 69.4892088611717*x_45 - 744.886205369532*x_46 + 1524.36785738447*x_47 - 1334.06727356827*x_48 + 146.715401900504*x_49 + 221.216308288021*x_5 - 3417.16306333152*x_50 - 2684.1008065779*x_51 + 1267.22963519317*x_52 - 280.611480150257*x_53 + 989.377791876022*x_54 + 353.129989117594*x_55 - 665.688421931369*x_56 + 1748.13237315328*x_57 + 1570.3643570589*x_58 - 256.255346778186*x_59 - 930.000301683961*x_6 - 1101.56212649964*x_60 + 183.697335418611*x_61 + 349.588899605349*x_62 - 1450.20234764708*x_63 + 687.444273317201*x_64 + 489.330433077981*x_65 + 297.255241875108*x_66 - 190.043748396942*x_67 + 2768.2776498847*x_68 - 981.157667820444*x_69 - 50.8201505207291*x_7 - 676.610273551077*x_70 - 681.644397222253*x_72 + 883.813353480953*x_73 + 524.008377990476*x_74 + 406.039805330244*x_75 - 1128.37387999247*x_76 + 316.926243804506*x_77 + 180.736001439092*x_78 + 19.4455765442301*x_79 - 1035.58449703894*x_8 + 5.29334542470245*x_80 + 1445.23822603334*x_81 + 686.475604768436*x_82 - 694.937024755851*x_83 - 3798.29695005276*x_84 - 69.4495407757832*x_85 + 1279.81260683364*x_86 - 628.564960834876*x_87 + 1296.13630614044*x_88 + 3117.16731311662*x_89 + 4287.19445459113*x_9 - 564.397394812123*x_90 + 161.106838143961*x_91 - 1831.44844794071*x_92 - 35.4409287744127*x_93 + 391.890025675165*x_94 - 923.906148247821*x_95 - 913.482647079237*x_96 + 569.899773097582*x_97 - 650.452176952927*x_98 - 1182.03778540186*x_99 - 0.0123355666522162*std::pow(-6.50528001785278*x_106 - 8.69128036499023, 2) + 0.000644505869825245*std::pow(-5.92063999176025*x_115 - 8.77575969696045, 2) - 0.00118389154458495*std::pow(-6.68079996109009*x_15 - 9.93472003936768, 2) + 0.0017857972400881*std::pow(-3.65079998970032*x_67 - 5.68135976791382, 2) - 0.00160332814983072*std::pow(-5.68767976760864*x_77 - 8.32991981506348, 2) - 0.0109294921693753*std::pow(-7.47968006134033*x_78 - 8.28623962402344, 2) - 0.0245165373372022*std::pow(-4.50551986694336*x_80 - 5.93232011795044, 2) - 6.33103398709543*std::pow(-7.65576028823853*x_85 - 9.42391967773438, 2) - 471.170741806314*std::exp(0.648559808731079*x_108) + 0.514762020467175*std::exp(0.721039831638336*x_23) - 0.00739388806892105*std::exp(2.53535985946655*x_71) - 0.0179572331139241*std::exp(2.54663991928101*x_71) + 10.7092698364963*std::exp(2.55391979217529*x_71) + 0.0470774635226355*std::exp(2.56647992134094*x_71) - 0.0130524507610608*std::exp(2.58127999305725*x_71) + 0.0136724569874502*std::exp(2.58591985702515*x_71) + 0.0133033237820245*std::exp(2.59999990463257*x_71) + 0.103809282430895*std::exp(2.60031986236572*x_71) - 0.101974584558759*std::exp(2.60800004005432*x_71) - 0.0405981376496963*std::exp(2.61455988883972*x_71) - 4.02281751224776*std::exp(2.62783980369568*x_71) + 5.32827545970219*std::exp(2.63567996025085*x_71) + 3.44691746789964*std::exp(2.66703987121582*x_71) - 63.204017875617*std::exp(2.67703986167908*x_71) - 0.0107902506895762*std::exp(2.79999995231628*x_71) + 43.931841702014*std::exp(1.35551989078522*x_76) + 0.0130514063147625*std::exp(1.45679986476898*x_76) + 11.1274991267602*std::sin(0.305279940366745*x_103 - 7.50447988510132) - 0.652772538802167*std::sin(0.380319833755493*x_105 - 7.4015998840332) - 1.17008809350818*std::sin(0.399839848279953*x_105 - 7.38983964920044) + 0.989987553107966*std::sin(0.579119861125946*x_106 + 2.17703986167908) - 9.42992166275161*std::sin(0.344239860773087*x_112 + 1.96727979183197) + 0.361209502293212*std::sin(0.531359851360321*x_114 + 8.36511993408203) + 172.043198557403*std::sin(0.321839839220047*x_115 + 5.11583995819092) - 81.4666916685723*std::sin(0.48583984375*x_115 - 4.12815999984741) + 0.394582302433113*std::sin(0.317279845476151*x_119 - 4.27472019195557) + 2859.72789797372*std::sin(0.329919844865799*x_16 - 4.26799964904785) - 1.27198990948707*std::sin(0.414799869060516*x_16 + 2.01095986366272) - 0.800034042511027*std::sin(0.459519863128662*x_21 + 8.22743988037109) - 0.422900591302036*std::sin(0.329759836196899*x_26 + 5.13416004180908) + 136.489177908631*std::sin(0.266959935426712*x_28 - 4.29216003417969) + 0.700986384951837*std::sin(0.300159931182861*x_28 + 5.13399982452393) + 532.721958233616*std::sin(0.316399842500687*x_28 - 4.29728031158447) + 2.47060567187734*std::sin(0.340879827737808*x_28 - 4.26624011993408) + 0.405577956828361*std::sin(0.343679845333099*x_28 + 5.15528011322021) - 2.74696526797927*std::sin(0.344479858875275*x_28 + 5.146399974823) + 0.595157514193874*std::sin(0.358399868011475*x_28 + 8.34047985076904) - 62.5411971036215*std::sin(0.359679847955704*x_28 + 8.3645601272583) + 0.541074799173904*std::sin(0.350399851799011*x_34 + 1.9722398519516) - 0.750197779208657*std::sin(0.384399831295013*x_34 + 8.20399951934814) + 1575.00452081631*std::sin(0.394879847764969*x_36 - 7.38895988464355) - 0.413323666259058*std::sin(0.417199850082397*x_36 + 5.21704006195068) - 1.14083419000838*std::sin(0.417439848184586*x_36 - 7.37928009033203) - 48.3477862079275*std::sin(0.419759839773178*x_36 + 2.00951981544495) + 9.27920017500738*std::sin(0.364479839801788*x_43 - 4.23239994049072) + 0.480215030048044*std::sin(0.343439847230911*x_45 + 5.14336013793945) - 1.89911132361818*std::sin(0.544799864292145*x_47 + 8.36528015136719) + 2927.40376756717*std::sin(0.325999855995178*x_48 - 7.45655965805054) - 1.71865264626377*std::sin(0.313919931650162*x_53 + 5.14799976348877) - 1.93069703484775*std::sin(0.314319938421249*x_53 + 5.13976001739502) - 5.69327279552617*std::sin(0.472319841384888*x_53 - 7.33735990524292) + 0.822979542059586*std::sin(0.402399837970734*x_55 - 4.19655990600586) - 16.9580762623963*std::sin(0.264399945735931*x_56 + 5.08799982070923) + 2.9510511199874*std::sin(0.443999856710434*x_59 + 2.02063989639282) + 2.05657573335402*std::sin(0.387199819087982*x_6 - 4.21600008010864) + 2.44810174065142*std::sin(0.181680008769035*x_64 - 4.41991996765137) - 1.14549979774022*std::sin(0.238159984350204*x_64 - 4.3471999168396) - 17.3177635409776*std::sin(0.254799991846085*x_64 - 4.33599996566772) + 6.5719827422401*std::sin(0.478079855442047*x_69 + 2.04487991333008) + 0.184279514283878*std::sin(0.520319879055023*x_75 - 7.24647998809814) - 50.711389211031*std::sin(0.130560040473938*x_80 + 4.91039943695068) + 1.90060611736586*std::sin(0.209040001034737*x_80 + 4.99616003036499) + 8975.79420480753*std::sin(0.282239943742752*x_80 + 5.11295986175537) - 3283.81909025386*std::sin(0.302879929542542*x_80 - 7.47616052627563) + 0.734992678445076*std::sin(0.318959832191467*x_80 - 4.28208017349243) + 264.719953330796*std::sin(0.370159834623337*x_80 + 5.1572003364563) + 1.97082912519768*std::sin(0.457199841737747*x_80 - 7.35167980194092) - 1.3812632867958*std::sin(0.469279855489731*x_80 - 7.3284797668457) - 0.417196148787709*std::sin(0.517839848995209*x_80 + 2.12727999687195) - 0.140856744913405*std::sin(0.538959860801697*x_80 + 2.1541600227356) - 0.468358466646699*std::sin(0.296639859676361*x_81 + 1.88175988197327) - 151.076775736666*std::sin(0.386079847812653*x_81 - 7.3983998298645) - 3261.41785374361*std::sin(0.252799987792969*x_85 - 4.32671976089478) + 140.402499197767*std::sin(0.435199856758118*x_85 - 4.16016006469727) + 2.17971810847981*std::sin(0.363439828157425*x_95 + 5.16104030609131) - 0.96732198600652*std::sin(0.367999851703644*x_95 + 5.18576002120972) + 1.65409237241322*std::sin(0.37951985001564*x_95 + 1.98959982395172) - 11.7317670926223*std::sin(0.358319848775864*x_96 + 5.16488027572632) + 9.30748285441766*std::sin(0.378959834575653*x_96 + 5.17615985870361) + 0.302973332860148*std::sin(0.440159857273102*x_96 - 7.3854398727417) + 0.359710715586727*std::sin(0.448879837989807*x_96 - 7.35279989242554) - 1969.68627170628*std::sin(0.453759849071503*x_96 - 7.3551197052002) - 1011.10364270777*std::sin(0.425039857625961*x_97 - 1.15743982791901) - 1453251.98816212 - 0.000437712587876886*std::exp(-3.18055987358093*x_74) + 11.0721605120091*std::exp(-3.1210401058197*x_74) - 0.0027336173991764*std::exp(-2.85591983795166*x_74) - 0.386733205932979*std::exp(-3.94351983070374*x_45) - 5.06680657276315e-5*std::exp(-3.93023991584778*x_45) + 1.38520231779822*std::exp(-3.84215998649597*x_45) - 0.160843956931738*std::exp(-4.81960010528564*x_111) + 0.109500122825532*std::exp(-4.61560010910034*x_111) - 2.4092418926701e-5*std::exp(-4.57008028030396*x_111));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (12412.1094365891*x_1 + 535.557104773199*x_10 + 775.458801881465*x_100 - 708.219211409619*x_101 + 440.494952582086*x_102 - 23.1269802243196*x_103 + 352.918014821933*x_104 + 249.848077186847*x_105 - 410.107915020072*x_106 + 132.081339353537*x_107 - 138.457502899278*x_108 - 312.677759755016*x_109 + 357.501901745818*x_11 + 100.099976370669*x_110 - 135.753283673258*x_111 - 48.3179362152596*x_112 - 120.069514440974*x_113 + 369.507555219011*x_114 + 101.355901870773*x_115 - 1998.16146739055*x_116 - 290.503068178986*x_117 - 58.198710722506*x_118 - 64.8673094690205*x_119 + 4008.96406791527*x_12 + 885.781629013486*x_120 - 150.781039039182*x_13 - 25.3636851359752*x_14 + 130.933523296227*x_15 - 108.669781870698*x_16 - 275.024854760532*x_17 + 333.467072399074*x_18 - 73.6675824908071*x_19 - 194.54899358496*x_2 - 1919.86493262299*x_20 + 302.73789065336*x_21 - 487.494609416682*x_22 + 279.035208082581*x_23 + 511.927583369122*x_24 - 886.00387618624*x_25 + 26.2032701880131*x_26 - 240.210913503733*x_27 + 437.611930846794*x_28 - 239.078824995192*x_29 - 1600.42731153746*x_3 - 2548.20143117819*x_30 + 19617.989009969*x_31 + 71.7414340995493*x_32 + 180.059392772183*x_33 - 48.3418616084996*x_34 - 221.165196090218*x_35 - 163.745160082004*x_36 - 6484.05202376518*x_37 + 9.23519178628966*x_38 + 187.83448626916*x_39 - 147.600565577375*x_4 + 95.102914697757*x_40 + 759.04123597889*x_41 - 522021.047148524*x_42 + 1210.28809833777*x_43 + 50.6417647214405*x_44 + 157.005143778062*x_45 - 50.8157665274372*x_46 + 459.812056972918*x_47 - 364.760400338837*x_48 - 1974.83586892932*x_49 + 352.082611688403*x_5 + 2705.58139438176*x_50 - 45.6044591777717*x_51 - 1653.10880860447*x_52 + 327.774447942946*x_53 + 366.486150226355*x_54 + 455.243981913078*x_55 + 383.611416379408*x_56 - 3254.43378836569*x_57 - 380.656973912773*x_58 - 265.182566687261*x_59 - 466.291200523087*x_6 + 131.95995994497*x_60 - 87.0235518172165*x_61 - 447.650713029693*x_62 - 426.721710110354*x_63 + 22.1492055306862*x_64 - 98.524746701999*x_65 + 244.471647832466*x_66 + 155.225495084279*x_67 + 140.168774132922*x_68 - 563.192454482764*x_69 + 155.085884699165*x_7 - 952.567889695118*x_70 - 378.763457749458*x_72 - 295.929439570068*x_73 - 252.95376857407*x_74 + 224.318346521817*x_75 - 675.874371308464*x_76 + 109.549681865665*x_77 - 637.524360358786*x_78 - 142.902176441898*x_79 + 1942.64487903475*x_8 + 35.7122901719597*x_80 - 284.40117300324*x_81 + 65.9583294673468*x_82 - 545.288061358002*x_83 - 2164.05948011908*x_84 - 194.504818606804*x_85 - 54.0913138880788*x_86 + 290.792537810178*x_87 + 113.546622896717*x_88 + 478.958033820611*x_89 - 504.199178153261*x_9 + 1196.3041575133*x_90 + 1011.79409577223*x_91 - 425.107488828781*x_92 - 153.955079904577*x_93 + 136.597764752388*x_94 + 56.0972567041842*x_95 - 67.5891777122247*x_96 + 698.740505237867*x_97 + 264.222153663366*x_98 - 391.567031692623*x_99 - 0.00534140621510915*std::pow(-6.50528001785278*x_106 - 8.69128036499023, 2) + 0.000286151649217262*std::pow(-5.92063999176025*x_115 - 8.77575969696045, 2) + 0.00283449088373668*std::pow(-6.68079996109009*x_15 - 9.93472003936768, 2) + 0.00270111279980408*std::pow(-3.65079998970032*x_67 - 5.68135976791382, 2) + 0.000223636479864975*std::pow(-5.68767976760864*x_77 - 8.32991981506348, 2) + 0.0466771360489805*std::pow(-7.47968006134033*x_78 - 8.28623962402344, 2) - 0.0106158710497795*std::pow(-4.50551986694336*x_80 - 5.93232011795044, 2) - 1.03473345206023*std::pow(-7.65576028823853*x_85 - 9.42391967773438, 2) + 345.919746493911*std::exp(0.648559808731079*x_108) - 2.19842024586654*std::exp(0.721039831638336*x_23) + 0.0177025576562198*std::exp(2.53535985946655*x_71) + 0.00250472269331561*std::exp(2.54663991928101*x_71) - 7.86243197693826*std::exp(2.55391979217529*x_71) - 0.0336234557009024*std::exp(2.56647992134094*x_71) - 0.00579510674218899*std::exp(2.58127999305725*x_71) + 0.0206803145085781*std::exp(2.58591985702515*x_71) - 0.0036887752360706*std::exp(2.59999990463257*x_71) + 0.0449503101069769*std::exp(2.60031986236572*x_71) + 0.435508025736525*std::exp(2.60800004005432*x_71) + 0.0681005219103746*std::exp(2.61455988883972*x_71) - 5.06346754910322*std::exp(2.62783980369568*x_71) + 23.7559883530236*std::exp(2.63567996025085*x_71) + 2.80595511170326*std::exp(2.66703987121582*x_71) - 10.3299574340964*std::exp(2.67703986167908*x_71) + 0.0210915373380278*std::exp(2.79999995231628*x_71) + 55.2964319542783*std::exp(1.35551989078522*x_76) + 0.00579464302254767*std::exp(1.45679986476898*x_76) - 47.5227743956914*std::sin(0.305279940366745*x_103 - 7.50447988510132) - 0.289821935357434*std::sin(0.380319833755493*x_105 - 7.4015998840332) + 1.96274052116817*std::sin(0.399839848279953*x_105 - 7.38983964920044) - 1.66063452548374*std::sin(0.579119861125946*x_106 + 2.17703986167908) + 40.2728442970872*std::sin(0.344239860773087*x_112 + 1.96727979183197) + 0.160371999128844*std::sin(0.531359851360321*x_114 + 8.36511993408203) + 140.051363840772*std::sin(0.321839839220047*x_115 + 5.11583995819092) - 363.21729104939*std::sin(0.48583984375*x_115 - 4.12815999984741) - 0.109410659295063*std::sin(0.317279845476151*x_119 - 4.27472019195557) + 467.389075126549*std::sin(0.329919844865799*x_16 - 4.26799964904785) + 0.177420539776271*std::sin(0.414799869060516*x_16 + 2.01095986366272) + 1.91545349787216*std::sin(0.459519863128662*x_21 + 8.22743988037109) - 0.639659517087332*std::sin(0.329759836196899*x_26 + 5.13416004180908) + 608.533726387416*std::sin(0.266959935426712*x_28 - 4.29216003417969) + 0.311228212998593*std::sin(0.300159931182861*x_28 + 5.13399982452393) + 670.530129690979*std::sin(0.316399842500687*x_28 - 4.29728031158447) - 4.82925497053402*std::sin(0.340879827737808*x_28 - 4.26624011993408) + 0.613458116025214*std::sin(0.343679845333099*x_28 + 5.15528011322021) + 4.60784112890113*std::sin(0.344479858875275*x_28 + 5.146399974823) - 0.0830141549336357*std::sin(0.358399868011475*x_28 + 8.34047985076904) - 50.9115153870744*std::sin(0.359679847955704*x_28 + 8.3645601272583) - 0.150030424934214*std::sin(0.350399851799011*x_34 + 1.9722398519516) + 0.535802906713729*std::sin(0.384399831295013*x_34 + 8.20399951934814) - 1156.32214869468*std::sin(0.394879847764969*x_36 - 7.38895988464355) + 0.0576514856156057*std::sin(0.417199850082397*x_36 + 5.21704006195068) + 1.91366915455915*std::sin(0.417439848184586*x_36 - 7.37928009033203) - 215.557445319127*std::sin(0.419759839773178*x_36 + 2.00951981544495) - 39.6291504017153*std::sin(0.364479839801788*x_43 - 4.23239994049072) + 0.213208799579163*std::sin(0.343439847230911*x_45 + 5.14336013793945) + 1.35637480617569*std::sin(0.544799864292145*x_47 + 8.36528015136719) - 2149.21403073544*std::sin(0.325999855995178*x_48 - 7.45655965805054) + 0.239722247726789*std::sin(0.313919931650162*x_53 + 5.14799976348877) + 3.23860855043256*std::sin(0.314319938421249*x_53 + 5.13976001739502) + 24.3145486288339*std::sin(0.472319841384888*x_53 - 7.33735990524292) - 0.114791378051041*std::sin(0.402399837970734*x_55 - 4.19655990600586) - 7.34299254327198*std::sin(0.264399945735931*x_56 + 5.08799982070923) - 2.10768654849653*std::sin(0.443999856710434*x_59 + 2.02063989639282) - 1.46883833349968*std::sin(0.387199819087982*x_6 - 4.21600008010864) - 5.86128188690552*std::sin(0.181680008769035*x_64 - 4.41991996765137) - 0.508585990675743*std::sin(0.238159984350204*x_64 - 4.3471999168396) + 73.9598503150296*std::sin(0.254799991846085*x_64 - 4.33599996566772) - 28.0672997260244*std::sin(0.478079855442047*x_69 + 2.04487991333008) - 0.051097433990443*std::sin(0.520319879055023*x_75 - 7.24647998809814) + 216.575699653152*std::sin(0.130560040473938*x_80 + 4.91039943695068) + 0.843842702540665*std::sin(0.209040001034737*x_80 + 4.99616003036499) + 1466.9885742919*std::sin(0.282239943742752*x_80 + 5.11295986175537) + 2410.88371251082*std::sin(0.302879929542542*x_80 - 7.47616052627563) - 0.203800406226662*std::sin(0.318959832191467*x_80 - 4.28208017349243) + 215.494659543157*std::sin(0.370159834623337*x_80 + 5.1572003364563) - 1.40759677405455*std::sin(0.457199841737747*x_80 - 7.35167980194092) + 2.69993413732677*std::sin(0.469279855489731*x_80 - 7.3284797668457) + 0.998857273605575*std::sin(0.517839848995209*x_80 + 2.12727999687195) - 0.213053278436899*std::sin(0.538959860801697*x_80 + 2.1541600227356) - 0.207944650204909*std::sin(0.296639859676361*x_81 + 1.88175988197327) - 673.572181460229*std::sin(0.386079847812653*x_81 - 7.3983998298645) + 2394.4373813463*std::sin(0.252799987792969*x_85 - 4.32671976089478) + 114.294326449291*std::sin(0.435199856758118*x_85 - 4.16016006469727) - 3.65632389558834*std::sin(0.363439828157425*x_95 + 5.16104030609131) + 0.134924646504419*std::sin(0.367999851703644*x_95 + 5.18576002120972) - 1.18137846535202*std::sin(0.37951985001564*x_95 + 1.98959982395172) + 50.1034522181815*std::sin(0.358319848775864*x_96 + 5.16488027572632) + 4.03021994588926*std::sin(0.378959834575653*x_96 + 5.17615985870361) - 0.0840091202586829*std::sin(0.440159857273102*x_96 - 7.3854398727417) + 0.544081487128997*std::sin(0.448879837989807*x_96 - 7.35279989242554) + 1446.08592029524*std::sin(0.453759849071503*x_96 - 7.3551197052002) + 742.322654466348*std::sin(0.425039857625961*x_97 - 1.15743982791901) + 1241854.65291362 - 0.000194338305930539*std::exp(-3.18055987358093*x_74) + 1.80961512632983*std::exp(-3.1210401058197*x_74) + 0.00534335995532611*std::exp(-2.85591983795166*x_74) + 0.283928182900853*std::exp(-3.94351983070374*x_45) - 7.66381299096801e-5*std::exp(-3.93023991584778*x_45) + 0.22639511634572*std::exp(-3.84215998649597*x_45) - 0.0262880633934741*std::exp(-4.81960010528564*x_111) - 0.0803917802358599*std::exp(-4.61560010910034*x_111) - 3.6441058189755e-5*std::exp(-4.57008028030396*x_111));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (46007.8799494443*x_1 + 2830.11617945023*x_10 + 450.434857315831*x_100 - 10132.0952501457*x_101 + 3539.96602099382*x_102 + 1007.12464378409*x_103 - 2901.90119841734*x_104 - 663.398866127209*x_105 + 730.539564878444*x_106 + 454.31012963741*x_107 - 2814.59463075785*x_108 + 6107.62375196955*x_109 + 2955.05025612051*x_11 - 2531.11317996368*x_110 + 231.440389744224*x_111 + 1121.79039220418*x_112 - 5383.35386777204*x_113 + 266.380829099148*x_114 - 1553.73993782976*x_115 + 6948.61105438905*x_116 - 2079.33812105545*x_117 - 3268.85549152507*x_118 - 564.510248575627*x_119 + 22339.3591475187*x_12 + 2798.23429047938*x_120 + 119.106754182101*x_13 - 1818.5277676092*x_14 - 2683.14355426706*x_15 + 226.863063304376*x_16 - 4010.68891967972*x_17 + 1924.11529618041*x_18 + 276.303270550327*x_19 - 1337.62203631951*x_2 - 6409.61600322952*x_20 + 8998.32356761079*x_21 - 8180.47311088747*x_22 + 4013.28852543733*x_23 + 3213.27421641138*x_24 - 3845.06716877832*x_25 - 659.88540065417*x_26 - 268.806579712361*x_27 + 3400.85708921881*x_28 - 1991.61861809096*x_29 - 8086.16251747263*x_3 + 673.711972768833*x_30 + 152674.665961069*x_31 + 2175.71468643482*x_32 - 2888.38164488076*x_33 + 1035.06866707773*x_34 + 26.1383442692414*x_35 - 1831.7906097224*x_36 - 2995.16768280342*x_37 - 3151.7203806106*x_38 + 3732.5709915322*x_39 + 1730.24719258671*x_4 - 99.7269219909096*x_40 + 5190.84023133188*x_41 + 78240.6239648193*x_42 + 2685.88017793824*x_43 - 7579.10533138296*x_44 - 140.453997378046*x_45 - 1994.83909556477*x_46 + 3136.28337742948*x_47 - 1695.44980997746*x_48 - 2543.09428002808*x_49 + 665.396832527965*x_5 + 823.443903647655*x_50 - 6715.52546561265*x_51 - 1188.62133704294*x_52 + 435.563949416196*x_53 + 3701.74709490756*x_54 + 1073.85188856717*x_55 - 593.233159112112*x_56 - 7265.39902910626*x_57 + 3008.71976844463*x_58 - 458.422616577635*x_59 - 2466.86600545879*x_6 - 1969.27032624837*x_60 + 27.4219603337144*x_61 + 1385.66783142424*x_62 - 2827.95834909413*x_63 + 2192.01409783518*x_64 + 1163.68556721423*x_65 + 2439.38872429599*x_66 + 533.093483680945*x_67 + 5387.5745038475*x_68 - 2963.19323341263*x_69 + 178.886551097824*x_7 - 3531.15632724312*x_70 - 3244.80583391343*x_72 + 1394.8747823677*x_73 + 231.668956149414*x_74 + 2068.96390622775*x_75 - 4886.72751679336*x_76 + 1257.02058702197*x_77 - 762.54836237044*x_78 - 245.60194512031*x_79 - 1903.31546972532*x_8 + 16.0275233875043*x_80 + 2924.71919488657*x_81 + 1860.72246473602*x_82 - 2768.5390611363*x_83 - 8369.8688762206*x_84 + 74.0722846746139*x_85 + 2793.8975860954*x_86 - 1360.66612719741*x_87 + 1400.15808519549*x_88 + 6158.87114230415*x_89 + 8279.40130623381*x_9 + 3330.47573870261*x_90 + 1547.04222927429*x_91 - 4325.78841177548*x_92 - 721.390063146785*x_93 + 723.239912543349*x_94 - 1970.89172965941*x_95 - 2577.01890885427*x_96 + 251.725951275168*x_97 - 1494.10490763111*x_98 - 2775.66069432134*x_99 - 0.0178714350516473*std::pow(-6.50528001785278*x_106 - 8.69128036499023, 2) + 6.25326700863419e-5*std::pow(-5.92063999176025*x_115 - 8.77575969696045, 2) - 0.000441560305176842*std::pow(-6.68079996109009*x_15 - 9.93472003936768, 2) - 0.00428217469564764*std::pow(-3.65079998970032*x_67 - 5.68135976791382, 2) - 0.00407979457762877*std::pow(-5.68767976760864*x_77 - 8.32991981506348, 2) + 0.0513501100464428*std::pow(-7.47968006134033*x_78 - 8.28623962402344, 2) - 0.0355188956507627*std::pow(-4.50551986694336*x_80 - 5.93232011795044, 2) - 16.2681837048625*std::pow(-7.65576028823853*x_85 - 9.42391967773438, 2) - 158.886136343814*std::exp(0.648559808731079*x_108) - 2.4185100267316*std::exp(0.721039831638336*x_23) - 0.00275772513714573*std::exp(2.53535985946655*x_71) - 0.0456935919793701*std::exp(2.54663991928101*x_71) + 3.61133312493267*std::exp(2.55391979217529*x_71) - 0.0682591434256719*std::exp(2.56647992134094*x_71) - 0.00126640366748087*std::exp(2.58127999305725*x_71) - 0.0327852726080492*std::exp(2.58591985702515*x_71) - 0.00415707669951765*std::exp(2.59999990463257*x_71) + 0.150396078350283*std::exp(2.60031986236572*x_71) + 0.479107908938815*std::exp(2.60800004005432*x_71) + 0.137584812118561*std::exp(2.61455988883972*x_71) + 10.416463559311*std::exp(2.62783980369568*x_71) + 3.50300307184315*std::exp(2.63567996025085*x_71) + 0.30852386976027*std::exp(2.66703987121582*x_71) - 162.408632741786*std::exp(2.67703986167908*x_71) + 0.0096208057304648*std::exp(2.79999995231628*x_71) - 113.754707189479*std::exp(1.35551989078522*x_76) + 0.00126630233090838*std::exp(1.45679986476898*x_76) - 52.2804075290803*std::sin(0.305279940366745*x_103 - 7.50447988510132) - 0.0633347370775813*std::sin(0.380319833755493*x_105 - 7.4015998840332) + 3.96536294094496*std::sin(0.399839848279953*x_105 - 7.38983964920044) - 3.35501230793754*std::sin(0.579119861125946*x_106 + 2.17703986167908) + 44.3046673722359*std::sin(0.344239860773087*x_112 + 1.96727979183197) + 0.0350460650499237*std::sin(0.531359851360321*x_114 + 8.36511993408203) + 15.3991019161849*std::sin(0.321839839220047*x_115 + 5.11583995819092) - 53.5591812634736*std::sin(0.48583984375*x_115 - 4.12815999984741) - 0.123300682022272*std::sin(0.317279845476151*x_119 - 4.27472019195557) + 7348.33818377595*std::sin(0.329919844865799*x_16 - 4.26799964904785) - 3.2366783656058*std::sin(0.414799869060516*x_16 + 2.01095986366272) - 0.298391586272272*std::sin(0.459519863128662*x_21 + 8.22743988037109) + 1.01407604973041*std::sin(0.329759836196899*x_26 + 5.13416004180908) + 89.7329751630376*std::sin(0.266959935426712*x_28 - 4.29216003417969) + 0.0680126472038125*std::sin(0.300159931182861*x_28 + 5.13399982452393) - 1379.40109097435*std::sin(0.316399842500687*x_28 - 4.29728031158447) - 2.20284198111155*std::sin(0.340879827737808*x_28 - 4.26624011993408) - 0.972537993035089*std::sin(0.343679845333099*x_28 + 5.15528011322021) + 9.30931126822187*std::sin(0.344479858875275*x_28 + 5.146399974823) + 1.5144251034946*std::sin(0.358399868011475*x_28 + 8.34047985076904) - 5.59788632293731*std::sin(0.359679847955704*x_28 + 8.3645601272583) - 0.169077252962999*std::sin(0.350399851799011*x_34 + 1.9722398519516) + 1.08773612631026*std::sin(0.384399831295013*x_34 + 8.20399951934814) + 531.116134412721*std::sin(0.394879847764969*x_36 - 7.38895988464355) - 1.0517345763482*std::sin(0.417199850082397*x_36 + 5.21704006195068) + 3.86622310227839*std::sin(0.417439848184586*x_36 - 7.37928009033203) - 31.785602092849*std::sin(0.419759839773178*x_36 + 2.00951981544495) - 43.5965315446889*std::sin(0.364479839801788*x_43 - 4.23239994049072) + 0.046592481853795*std::sin(0.343439847230911*x_45 + 5.14336013793945) + 2.75358319077327*std::sin(0.544799864292145*x_47 + 8.36528015136719) + 987.166292125736*std::sin(0.325999855995178*x_48 - 7.45655965805054) - 4.37324682897546*std::sin(0.313919931650162*x_53 + 5.14799976348877) + 6.54302399507673*std::sin(0.314319938421249*x_53 + 5.13976001739502) + 26.7487436784904*std::sin(0.472319841384888*x_53 - 7.33735990524292) + 2.09413617140609*std::sin(0.402399837970734*x_55 - 4.19655990600586) - 24.5684018471781*std::sin(0.264399945735931*x_56 + 5.08799982070923) - 4.27882486826965*std::sin(0.443999856710434*x_59 + 2.02063989639282) - 2.98189595285378*std::sin(0.387199819087982*x_6 - 4.21600008010864) + 0.913077347879004*std::sin(0.181680008769035*x_64 - 4.41991996765137) - 0.111141208000919*std::sin(0.238159984350204*x_64 - 4.3471999168396) + 81.364170430464*std::sin(0.254799991846085*x_64 - 4.33599996566772) - 30.8771928107471*std::sin(0.478079855442047*x_69 + 2.04487991333008) - 0.0575844118041424*std::sin(0.520319879055023*x_75 - 7.24647998809814) + 238.257677139932*std::sin(0.130560040473938*x_80 + 4.91039943695068) + 0.184404798878787*std::sin(0.209040001034737*x_80 + 4.99616003036499) + 23064.1423373309*std::sin(0.282239943742752*x_80 + 5.11295986175537) - 1107.35510804907*std::sin(0.302879929542542*x_80 - 7.47616052627563) - 0.229673500242744*std::sin(0.318959832191467*x_80 - 4.28208017349243) + 23.6943370895799*std::sin(0.370159834623337*x_80 + 5.1572003364563) - 2.85756916065959*std::sin(0.457199841737747*x_80 - 7.35167980194092) + 1.2315622803577*std::sin(0.469279855489731*x_80 - 7.3284797668457) - 0.155603154376686*std::sin(0.517839848995209*x_80 + 2.12727999687195) + 0.337761295201532*std::sin(0.538959860801697*x_80 + 2.1541600227356) - 0.0454421082074928*std::sin(0.296639859676361*x_81 + 1.88175988197327) - 99.3233952509056*std::sin(0.386079847812653*x_81 - 7.3983998298645) - 1099.8010610707*std::sin(0.252799987792969*x_85 - 4.32671976089478) + 12.5670320742851*std::sin(0.435199856758118*x_85 - 4.16016006469727) - 7.38694245076689*std::sin(0.363439828157425*x_95 + 5.16104030609131) - 2.46142687243854*std::sin(0.367999851703644*x_95 + 5.18576002120972) - 2.39832225526715*std::sin(0.37951985001564*x_95 + 1.98959982395172) + 55.1194439695385*std::sin(0.358319848775864*x_96 + 5.16488027572632) + 13.4844292132426*std::sin(0.378959834575653*x_96 + 5.17615985870361) - 0.0946743387776483*std::sin(0.440159857273102*x_96 - 7.3854398727417) - 0.862552640053805*std::sin(0.448879837989807*x_96 - 7.35279989242554) - 664.208987852455*std::sin(0.453759849071503*x_96 - 7.3551197052002) - 340.959947167161*std::sin(0.425039857625961*x_97 - 1.15743982791901) - 347382.364265856 - 4.24687161619891e-5*std::exp(-3.18055987358093*x_74) + 28.450951548552*std::exp(-3.1210401058197*x_74) + 0.00243734855616478*std::exp(-2.85591983795166*x_74) - 0.130412479881458*std::exp(-3.94351983070374*x_45) + 0.000121497280915034*std::exp(-3.93023991584778*x_45) + 3.55940685522701*std::exp(-3.84215998649597*x_45) - 0.413303584298553*std::exp(-4.81960010528564*x_111) + 0.0369251523942753*std::exp(-4.61560010910034*x_111) + 5.77713664065087e-5*std::exp(-4.57008028030396*x_111));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-9555.34681560857*x_1 - 538.113890326215*x_10 - 235.549334442313*x_100 - 2527.64248176752*x_101 - 529.362944561249*x_102 - 15.9955132402816*x_103 + 2023.96974492928*x_104 + 1031.9297224382*x_105 + 381.536018032181*x_106 - 148.68783153212*x_107 - 475.846107486954*x_108 - 1023.80531662909*x_109 + 939.419765307755*x_11 + 837.080136119496*x_110 + 921.415913893686*x_111 - 1190.6612875765*x_112 - 3195.01765240515*x_113 - 782.564051001087*x_114 + 1592.41422128784*x_115 - 328.3351206573*x_116 + 745.905105198626*x_117 + 192.128654308092*x_118 + 1256.99616962766*x_119 + 1371.54746009404*x_12 - 914.255794552852*x_120 - 1971.93501175*x_13 - 18.3253019526123*x_14 - 285.28911536667*x_15 + 1250.73452755382*x_16 - 113.296705749399*x_17 + 200.915751759341*x_18 - 572.530044032074*x_19 - 287.335450948128*x_2 - 3811.9206043983*x_20 - 2058.88070148966*x_21 - 2043.43087654256*x_22 - 270.709641059651*x_23 + 1211.29300289392*x_24 - 2751.08088931553*x_25 - 37.5727971014674*x_26 + 484.450352556438*x_27 + 616.576750217288*x_28 - 300.170302989986*x_29 + 217.538689751269*x_3 - 3645.84080955746*x_30 - 63638.8669706677*x_31 + 440.921631715454*x_32 + 668.163940985966*x_33 - 1233.72942253345*x_34 - 932.210083135815*x_35 + 17.0918360712782*x_36 - 17596.8433099667*x_37 + 896.808477923101*x_38 - 1000.39546911002*x_39 + 1138.17862010407*x_4 - 652.635942930401*x_40 - 76.7863383851271*x_41 - 464516.294102894*x_42 - 804.415344909638*x_43 - 2820.73015524135*x_44 - 487.048575268862*x_45 - 907.407827642244*x_46 - 725.008266282166*x_47 + 3560.44448085644*x_48 - 187.573612188151*x_49 - 75.6929223034478*x_5 + 5827.39944063845*x_50 - 1686.39661947305*x_51 - 2269.20503368899*x_52 + 866.929465699786*x_53 + 3154.74889485279*x_54 + 25.4905347110066*x_55 - 282.513145341328*x_56 + 3542.04995114014*x_57 + 499.145605371074*x_58 + 362.828316383665*x_59 + 219.906787940454*x_6 + 143.930406442179*x_60 - 695.486914900977*x_61 + 116.303128834119*x_62 + 1494.83473131212*x_63 + 661.801238092108*x_64 + 48.689334006166*x_65 + 1309.64728743813*x_66 + 488.185642170089*x_67 - 2145.12144989169*x_68 - 273.426890560132*x_69 - 386.066614121284*x_7 - 1073.80610929648*x_70 - 2155.81515331446*x_72 - 180.334017461708*x_73 + 12.2293404851062*x_74 + 1428.24225576083*x_75 - 788.519294522347*x_76 + 285.250318754229*x_77 + 48.7944725167452*x_78 - 495.559587357903*x_79 - 4168.89192430672*x_8 + 130.46618885583*x_80 + 806.607548297295*x_81 + 519.077806715457*x_82 - 716.319199964692*x_83 + 5773.86032809063*x_84 + 139.349931386931*x_85 - 487.945654903354*x_86 - 503.850018627667*x_87 - 1012.30908665421*x_88 - 1661.6118832565*x_89 - 379.886584325573*x_9 + 1171.00894156078*x_90 - 2800.13020318706*x_91 + 2.92951397835466*x_92 + 131.139569798272*x_93 - 573.200802369046*x_94 - 18.7567318695454*x_95 - 610.261135949477*x_96 - 962.856905941747*x_97 - 740.70967504454*x_98 + 229.271792286506*x_99 + 0.00021570755075859*std::pow(-6.50528001785278*x_106 - 8.69128036499023, 2) + 0.00144648338371808*std::pow(-5.92063999176025*x_115 - 8.77575969696045, 2) - 0.00256090442420666*std::pow(-6.68079996109009*x_15 - 9.93472003936768, 2) - 0.00185147929988802*std::pow(-3.65079998970032*x_67 - 5.68135976791382, 2) - 0.00516882522354229*std::pow(-5.68767976760864*x_77 - 8.32991981506348, 2) - 0.00758999109764204*std::pow(-7.47968006134033*x_78 - 8.28623962402344, 2) + 0.000428711738275864*std::pow(-4.50551986694336*x_80 - 5.93232011795044, 2) - 1.69491466928716*std::pow(-7.65576028823853*x_85 - 9.42391967773438, 2) + 404.54305099216*std::exp(0.648559808731079*x_108) + 0.35747673288039*std::exp(0.721039831638336*x_23) - 0.0159938980512164*std::exp(2.53535985946655*x_71) - 0.0578907065743712*std::exp(2.54663991928101*x_71) - 9.1948848032152*std::exp(2.55391979217529*x_71) - 0.0198466040533617*std::exp(2.56647992134094*x_71) - 0.0292939971947689*std::exp(2.58127999305725*x_71) - 0.0141753333035864*std::exp(2.58591985702515*x_71) - 0.00477612272479514*std::exp(2.59999990463257*x_71) - 0.00181527502469066*std::exp(2.60031986236572*x_71) - 0.0708162993295747*std::exp(2.60800004005432*x_71) - 0.027099535824967*std::exp(2.61455988883972*x_71) + 43.7664393702593*std::exp(2.62783980369568*x_71) + 51.5705237545415*std::exp(2.63567996025085*x_71) - 3.4026088940173*std::exp(2.66703987121582*x_71) - 16.9206826678905*std::exp(2.67703986167908*x_71) - 0.0215285989852841*std::exp(2.79999995231628*x_71) - 477.958614931228*std::exp(1.35551989078522*x_76) + 0.0292916531133781*std::exp(1.45679986476898*x_76) + 7.72749712450335*std::sin(0.305279940366745*x_103 - 7.50447988510132) - 1.46503651080916*std::sin(0.380319833755493*x_105 - 7.4015998840332) - 0.78104184191881*std::sin(0.399839848279953*x_105 - 7.38983964920044) + 0.660823493757512*std::sin(0.579119861125946*x_106 + 2.17703986167908) - 6.54861363753897*std::sin(0.344239860773087*x_112 + 1.96727979183197) + 0.81067305601092*std::sin(0.531359851360321*x_114 + 8.36511993408203) - 169.831660612203*std::sin(0.321839839220047*x_115 + 5.11583995819092) - 788.487755498442*std::sin(0.48583984375*x_115 - 4.12815999984741) - 0.141661853257997*std::sin(0.317279845476151*x_119 - 4.27472019195557) + 765.59291488958*std::sin(0.329919844865799*x_16 - 4.26799964904785) - 4.10065371143282*std::sin(0.414799869060516*x_16 + 2.01095986366272) - 1.73057298056868*std::sin(0.459519863128662*x_21 + 8.22743988037109) + 0.438454978610841*std::sin(0.329759836196899*x_26 + 5.13416004180908) + 1321.0312501314*std::sin(0.266959935426712*x_28 - 4.29216003417969) + 1.57324425659671*std::sin(0.300159931182861*x_28 + 5.13399982452393) - 5795.7745324644*std::sin(0.316399842500687*x_28 - 4.29728031158447) + 4.92932743555235*std::sin(0.340879827737808*x_28 - 4.26624011993408) - 0.420495213399224*std::sin(0.343679845333099*x_28 + 5.15528011322021) - 1.83361819036793*std::sin(0.344479858875275*x_28 + 5.146399974823) + 1.91867470902374*std::sin(0.358399868011475*x_28 + 8.34047985076904) + 61.7372581412405*std::sin(0.359679847955704*x_28 + 8.3645601272583) - 0.19425518663541*std::sin(0.350399851799011*x_34 + 1.9722398519516) + 0.316263391686485*std::sin(0.384399831295013*x_34 + 8.20399951934814) - 1352.28501611714*std::sin(0.394879847764969*x_36 - 7.38895988464355) - 1.33247694295916*std::sin(0.417199850082397*x_36 + 5.21704006195068) - 0.761514660333456*std::sin(0.417439848184586*x_36 - 7.37928009033203) - 467.941396043134*std::sin(0.419759839773178*x_36 + 2.00951981544495) + 6.44394502782922*std::sin(0.364479839801788*x_43 - 4.23239994049072) + 1.07776064439028*std::sin(0.343439847230911*x_45 + 5.14336013793945) + 0.800614724601367*std::sin(0.544799864292145*x_47 + 8.36528015136719) - 2513.44310361357*std::sin(0.325999855995178*x_48 - 7.45655965805054) - 5.54060948125549*std::sin(0.313919931650162*x_53 + 5.14799976348877) - 1.28875353629443*std::sin(0.314319938421249*x_53 + 5.13976001739502) - 3.95369603315806*std::sin(0.472319841384888*x_53 - 7.33735990524292) + 2.65312962658705*std::sin(0.402399837970734*x_55 - 4.19655990600586) + 0.296539688793435*std::sin(0.264399945735931*x_56 + 5.08799982070923) - 1.24408450959681*std::sin(0.443999856710434*x_59 + 2.02063989639282) - 0.866997523475417*std::sin(0.387199819087982*x_6 - 4.21600008010864) + 5.29554806537637*std::sin(0.181680008769035*x_64 - 4.41991996765137) - 2.57087871664058*std::sin(0.238159984350204*x_64 - 4.3471999168396) - 12.0263292264752*std::sin(0.254799991846085*x_64 - 4.33599996566772) + 4.56391657859713*std::sin(0.478079855442047*x_69 + 2.04487991333008) - 0.0661595245148202*std::sin(0.520319879055023*x_75 - 7.24647998809814) - 35.2165486461743*std::sin(0.130560040473938*x_80 + 4.91039943695068) + 4.26558592632844*std::sin(0.209040001034737*x_80 + 4.99616003036499) + 2402.95744695734*std::sin(0.282239943742752*x_80 + 5.11295986175537) + 2819.45816199191*std::sin(0.302879929542542*x_80 - 7.47616052627563) - 0.26387505044588*std::sin(0.318959832191467*x_80 - 4.28208017349243) - 261.317097382105*std::sin(0.370159834623337*x_80 + 5.1572003364563) - 0.830849038538895*std::sin(0.457199841737747*x_80 - 7.35167980194092) - 2.75588253229825*std::sin(0.469279855489731*x_80 - 7.3284797668457) - 0.902447076405964*std::sin(0.517839848995209*x_80 + 2.12727999687195) + 0.146037490484592*std::sin(0.538959860801697*x_80 + 2.1541600227356) - 1.05115061219197*std::sin(0.296639859676361*x_81 + 1.88175988197327) - 1462.21953253197*std::sin(0.386079847812653*x_81 - 7.3983998298645) + 2800.22465753212*std::sin(0.252799987792969*x_85 - 4.32671976089478) - 138.597688213197*std::sin(0.435199856758118*x_85 - 4.16016006469727) + 1.45497681393076*std::sin(0.363439828157425*x_95 + 5.16104030609131) - 3.11846223188024*std::sin(0.367999851703644*x_95 + 5.18576002120972) - 0.697321264285761*std::sin(0.37951985001564*x_95 + 1.98959982395172) - 8.14713130424453*std::sin(0.358319848775864*x_96 + 5.16488027572632) - 0.162756554835144*std::sin(0.378959834575653*x_96 + 5.17615985870361) - 0.108772652894123*std::sin(0.440159857273102*x_96 - 7.3854398727417) - 0.372940963792663*std::sin(0.448879837989807*x_96 - 7.35279989242554) + 1691.15529287467*std::sin(0.453759849071503*x_96 - 7.3551197052002) + 868.124686439955*std::sin(0.425039857625961*x_97 - 1.15743982791901) + 1405548.89726098 - 0.000982371169683571*std::exp(-3.18055987358093*x_74) + 2.96418678382675*std::exp(-3.1210401058197*x_74) - 0.00545408577234599*std::exp(-2.85591983795166*x_74) + 0.332045726031985*std::exp(-3.94351983070374*x_45) + 5.25316495927879e-5*std::exp(-3.93023991584778*x_45) + 0.370839855409449*std::exp(-3.84215998649597*x_45) - 0.0430603883386933*std::exp(-4.81960010528564*x_111) - 0.0940158414803834*std::exp(-4.61560010910034*x_111) + 2.49785439946233e-5*std::exp(-4.57008028030396*x_111));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
