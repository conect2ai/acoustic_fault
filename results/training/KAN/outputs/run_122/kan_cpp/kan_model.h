
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000161985708441148*x_1 + 0.000293684120370318*x_10 + 0.000182403609717911*x_100 + 1.4884599705121e-5*x_101 + 0.00017657935888732*x_102 + 0.000117939688045047*x_103 - 0.000506724375158455*x_104 + 0.000691999766474297*x_105 + 0.000774504074963262*x_106 - 9.98669404367174e-5*x_107 + 8.34604916657318e-5*x_108 + 0.00018691727128595*x_109 + 5.97936656949872e-5*x_11 + 0.000310785197209791*x_110 - 0.00023733542865722*x_111 + 0.000678509887101068*x_112 + 3.56257855830013e-5*x_113 + 0.000516042948046002*x_114 + 0.000370180864987079*x_115 - 0.000848321863933748*x_116 + 0.000707516023386334*x_117 + 0.000198708492160782*x_118 + 0.000357941630451263*x_119 + 0.000264587316174977*x_12 + 0.000369634244704952*x_120 - 0.000226608767185418*x_13 + 0.00012942395354189*x_14 - 2.07844077398604e-5*x_15 - 1.60466464095579e-6*x_16 + 7.28724288361594e-5*x_17 - 0.000417728596997653*x_18 - 0.000242022511373299*x_19 - 4.56590807221768e-5*x_2 - 0.000224211682493789*x_20 + 2.3061824592204e-5*x_21 + 0.000316288756791174*x_22 + 0.000214199426546789*x_23 + 0.000230688958984084*x_24 + 0.000125925102302219*x_25 - 0.000105174027794837*x_26 - 0.000274109192829053*x_27 - 0.000318754723447907*x_28 - 0.000154877191335149*x_29 + 4.52573452511076e-5*x_3 + 0.000130446138761677*x_30 - 3.2036079822953e-5*x_31 + 0.000224629181151027*x_32 + 0.000210986810755778*x_33 - 0.000288428265043067*x_34 + 0.000330917424765124*x_35 + 9.61335894386392e-5*x_36 + 0.00105296644319836*x_37 + 0.00131790189667236*x_38 - 0.000835372710033279*x_39 + 9.06051276230367e-6*x_4 + 0.000714895767662835*x_40 + 0.00019497297742849*x_41 + 0.00128581614513499*x_42 + 0.00201650939075727*x_43 + 0.00064136474477922*x_44 + 0.000689643625792887*x_45 + 0.000779186342418852*x_46 + 0.00131635862113057*x_47 + 0.000283728800256542*x_48 + 0.000393075168996949*x_49 + 0.00134728873110976*x_50 - 0.00029599631145861*x_51 - 0.000715519220215436*x_52 + 0.000194908934554983*x_53 + 0.000306343869849868*x_54 + 9.55966838311976e-6*x_55 + 7.03548320990801e-5*x_56 + 0.000271490217049206*x_57 - 0.000119926278425265*x_58 + 0.000732854228077745*x_59 - 3.75697594710599e-5*x_6 + 0.000905094197921074*x_60 - 0.000261843488233671*x_61 + 2.21226207265496e-5*x_62 + 5.88804668816285e-5*x_63 + 3.93125338458427e-5*x_64 - 0.000137066839941338*x_65 + 1.34034114411923e-5*x_66 - 0.000186534029257714*x_67 - 0.00032529265342465*x_68 + 1.89125908461955e-5*x_69 - 0.000285813382665493*x_7 - 1.06465133654849e-5*x_70 + 1.40495755373274e-5*x_71 + 1.95411233422394e-6*x_72 - 5.93055133161784e-6*x_73 + 0.000136859866638428*x_74 + 1.67483795577781e-5*x_75 + 0.000357207143072913*x_76 + 4.00436231537811e-5*x_77 + 1.41014745714795e-5*x_78 + 0.000149626048751876*x_79 - 4.16131618397811e-5*x_8 - 0.000139732006168437*x_80 + 6.97866245955867e-6*x_81 - 0.000126461820129794*x_82 + 2.45798645549865e-5*x_83 + 1.90028549914038e-5*x_84 + 0.000158926160791693*x_85 + 9.63598182225402e-6*x_86 + 7.93975080624936e-6*x_87 + 2.04635741908047e-5*x_88 + 0.000343389082554132*x_89 + 4.39406352293532e-5*x_9 - 7.60205157595583e-5*x_90 - 0.000199262941980033*x_91 + 2.12354663837142e-6*x_92 + 0.00052043568117529*x_93 - 6.09627520812408e-6*x_94 - 0.000109705798671674*x_95 + 5.83208962806573e-5*x_96 - 0.000263679803204341*x_97 - 0.00026167519654046*x_98 + 0.0005932046640271*x_99 - 8.36393409856293e-8*std::pow(-9.30727958679199*x_49 - 3.04655981063843, 2) + 9.59755161701718e-8*std::pow(-8.91152000427246*x_5 - 1.61951982975006, 2) + 0.000406299751091639*std::exp(0.411199867725372*x_6) - 0.000965292175786302*std::sin(0.336239844560623*x_1 - 7.45831966400146) - 0.000349362941503828*std::sin(0.292959928512573*x_10 - 1.3983998298645) - 0.000751417000841425*std::sin(0.306079924106598*x_10 + 1.79959988594055) - 6.97401074037525e-5*std::sin(0.27007994055748*x_100 + 1.78159987926483) - 0.000933353791976269*std::sin(0.264799952507019*x_107 - 1.23319983482361) + 0.000119935537183318*std::sin(0.275119960308075*x_107 + 4.97192001342773) + 0.00448629362680064*std::sin(0.267439961433411*x_108 + 8.1782398223877) - 0.00613902653316684*std::sin(0.245279967784882*x_109 - 1.21599984169006) + 0.000260779892934575*std::sin(0.356959849596024*x_11 - 1.3368798494339) + 0.000102682776942623*std::sin(0.248719975352287*x_110 - 4.4334397315979) - 0.000175925992752772*std::sin(0.222079992294312*x_111 - 1.22215986251831) - 0.00122143684442383*std::sin(0.227119997143745*x_111 - 1.20175993442535) - 8.42784938983872e-5*std::sin(0.287679940462112*x_113 + 1.95039987564087) + 0.000492317739450408*std::sin(0.303199917078018*x_116 + 1.75935995578766) - 0.00235530359999283*std::sin(0.329039841890335*x_12 + 1.85455989837646) + 9.40012255328292e-5*std::sin(0.329919844865799*x_12 + 1.85023999214172) + 0.000275181224607886*std::sin(0.374719828367233*x_12 - 4.57239961624146) - 0.00053907198725664*std::sin(0.309839934110641*x_120 - 7.65032005310059) - 0.00141714061513794*std::sin(0.397519826889038*x_13 - 7.78760004043579) + 9.55116033438542e-5*std::sin(0.288319945335388*x_14 + 8.1715202331543) + 0.000181751870242759*std::sin(0.334799855947495*x_14 - 7.75631999969482) + 0.000316570660712289*std::sin(0.359839856624603*x_15 - 1.37655985355377) + 0.00310302127062*std::sin(0.36575984954834*x_15 - 7.55879974365234) + 0.00452169729755288*std::sin(0.33519983291626*x_16 - 4.35847997665405) + 4.78650636452717e-5*std::sin(0.341119825839996*x_16 - 7.55671977996826) + 0.00107361877440282*std::sin(0.356159836053848*x_16 - 7.57928037643433) - 0.000430871871054093*std::sin(0.32847985625267*x_17 - 7.58584022521973) + 0.00337057995676188*std::sin(0.378079831600189*x_17 - 1.20383989810944) - 0.000373650639412639*std::sin(0.39591982960701*x_17 + 1.81023991107941) + 0.00238494445923862*std::sin(0.353919863700867*x_18 - 7.57656002044678) + 3.85971796924818e-5*std::sin(0.372879832983017*x_2 - 1.20743989944458) + 5.52059258741833e-5*std::sin(0.335679858922958*x_20 + 5.03431987762451) + 0.0013196769783893*std::sin(0.357039839029312*x_20 + 5.03447961807251) - 0.00376584860197108*std::sin(0.282239943742752*x_21 - 1.39167988300323) - 5.92280169082543e-5*std::sin(0.363999843597412*x_21 + 5.02055978775024) + 0.000552928039786762*std::sin(0.384639829397202*x_21 + 8.19575977325439) + 8.87078557667577e-5*std::sin(0.353439837694168*x_22 + 8.20743942260742) - 0.000749737848901256*std::sin(0.307599931955338*x_24 - 7.55647993087769) + 0.00411202242699282*std::sin(0.30991992354393*x_24 + 1.82943987846375) - 0.000161408453219819*std::sin(0.347839832305908*x_24 - 1.18343985080719) - 7.45644809385183e-5*std::sin(0.341839849948883*x_25 - 7.59144020080566) - 0.000775783163428915*std::sin(0.365119844675064*x_25 + 5.02320003509521) + 0.0033271288799344*std::sin(0.364959836006165*x_26 + 5.00607967376709) - 0.00332087826518567*std::sin(0.362719833850861*x_27 - 4.3744797706604) + 0.000122024783976042*std::sin(0.221599996089935*x_28 - 7.58168029785156) + 0.00287099472480576*std::sin(0.274799942970276*x_28 - 7.58152008056641) + 0.000833884120179394*std::sin(0.328959852457047*x_28 + 5.03695964813232) - 0.00235623387556098*std::sin(0.149280041456223*x_29 - 1.22135996818542) + 8.12203936225078e-5*std::sin(0.291919946670532*x_3 - 4.32119989395142) - 0.00390097284200323*std::sin(0.301119923591614*x_3 + 5.06943941116333) - 0.000337891695746101*std::sin(0.345439851284027*x_3 - 4.41095972061157) - 0.000617550683431979*std::sin(0.435919851064682*x_31 + 1.99383985996246) + 0.000982908881301838*std::sin(0.255519956350327*x_34 + 8.17208003997803) + 3.81117562433027e-5*std::sin(0.263919949531555*x_35 - 1.41455984115601) - 0.00435228841424132*std::sin(0.217360004782677*x_36 + 8.19919967651367) - 0.0010541186628325*std::sin(0.247679978609085*x_37 + 8.16775989532471) + 0.000203031298242164*std::sin(0.263599961996078*x_37 + 1.95351982116699) + 0.00463615256490192*std::sin(0.269439965486526*x_37 + 1.93767988681793) + 0.000192178837134697*std::sin(0.256319969892502*x_38 + 1.94175982475281) + 0.000357837794312081*std::sin(0.321599900722504*x_4 - 7.55352020263672) + 0.00010339566785956*std::sin(0.335679858922958*x_4 - 4.3918399810791) + 0.00143722483059892*std::sin(0.352239847183228*x_4 + 1.98887979984283) + 0.000176853030715229*std::sin(0.303679943084717*x_44 - 1.44399976730347) + 0.000107789329473847*std::sin(0.217840000987053*x_47 - 7.60080003738403) + 0.00564341612346219*std::sin(0.243039980530739*x_47 + 8.16695976257324) - 6.78742573504353e-5*std::sin(0.222399994730949*x_48 - 4.41351985931396) + 0.00139281299218332*std::sin(0.236959978938103*x_48 - 7.59352016448975) - 0.00377636607534288*std::sin(0.242639973759651*x_48 + 8.17303943634033) - 0.00371540831318133*std::sin(0.230879992246628*x_49 - 7.61863994598389) - 0.000535811765598031*std::sin(0.263919949531555*x_49 + 8.14167976379395) + 0.000259242025534338*std::sin(0.19336000084877*x_5 + 1.7973598241806) + 6.78459803866353e-5*std::sin(0.358879864215851*x_5 - 1.15943992137909) - 0.00207037520235228*std::sin(0.401039868593216*x_5 + 5.00216007232666) - 0.000861448139807034*std::sin(0.478239864110947*x_5 + 8.16103935241699) - 0.00734917245446611*std::sin(0.215920001268387*x_51 + 8.19279956817627) + 0.0041556184995464*std::sin(0.22511999309063*x_53 + 8.1846399307251) - 0.000197339513908998*std::sin(0.245599970221519*x_53 - 1.20199990272522) + 0.00105753226454461*std::sin(0.197839990258217*x_57 + 8.19095993041992) + 0.000176227058854888*std::sin(0.255759954452515*x_57 + 8.15783977508545) - 0.000702813902226836*std::sin(0.403199851512909*x_6 - 1.17351984977722) + 9.34635135276368e-5*std::sin(0.421999871730804*x_6 + 1.96639978885651) + 6.49933159778319e-5*std::sin(0.419279843568802*x_7 - 4.40727996826172) - 0.000331290122522934*std::sin(0.309999912977219*x_8 + 8.19192028045654) - 6.60470406234017e-5*std::sin(0.319999933242798*x_8 + 8.18048000335693) - 0.00414157058439021*std::sin(0.354479849338531*x_8 + 8.23911952972412) + 4.31415845594084e-5*std::sin(0.468639850616455*x_8 - 8.01272010803223) + 0.00261880968863027*std::sin(0.300959944725037*x_9 - 7.42592000961304) - 0.0011080717515245*std::sin(0.306479930877686*x_9 + 1.95599985122681) - 0.000501471645520488*std::sin(0.356319844722748*x_9 - 7.57816028594971) + 6.15315323438341e-5*std::sin(0.388399839401245*x_9 - 7.60120010375977) + 0.00162351420416292*std::sin(0.315759837627411*x_92 - 7.59328031539917) - 0.00315602686185754*std::sin(0.320479840040207*x_92 - 4.37967967987061) - 0.000179064547985832*std::sin(0.332799851894379*x_92 + 5.01823997497559) + 0.00504284480419152*std::sin(0.251279979944229*x_93 - 1.22199988365173) + 0.00335550026509154*std::sin(0.287999957799911*x_94 - 1.19415986537933) - 0.000149001879979911*std::sin(0.29215994477272*x_94 - 1.19487988948822) - 0.000146483679767662*std::sin(0.277599930763245*x_96 - 1.20943987369537) + 0.00369065045760231*std::sin(0.287279933691025*x_96 + 8.1637601852417) - 0.00358219440724383*std::sin(0.276479959487915*x_97 + 8.18136024475098) - 0.0043580608564069*std::sin(0.276639938354492*x_99 + 4.97024011611938) + 0.0550484000233609);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-3.51659389747418e-5*x_1 + 1.77807077569247e-5*x_10 - 6.03616008943298e-5*x_100 - 4.49456680462555e-5*x_101 + 1.25590103487311e-5*x_102 - 8.75679880784852e-5*x_103 - 0.000266653683302043*x_104 - 0.000180590969841884*x_105 + 3.65724111871041e-5*x_106 - 5.28769041080396e-5*x_107 - 0.000194490409386318*x_108 - 6.30702335319572e-5*x_109 - 7.75017535475557e-6*x_11 + 0.000239917597750284*x_110 - 1.07462553738285e-5*x_111 - 0.000178055748604686*x_112 - 6.73926903150762e-5*x_113 - 0.00014826682628322*x_114 + 0.000155474624282745*x_115 - 0.000213161702898021*x_116 + 0.000190213004229391*x_117 + 5.67143726258575e-5*x_118 - 8.47789621938475e-5*x_119 + 3.06364182075127e-6*x_12 - 2.70865291967271e-5*x_120 - 2.47413302154446e-5*x_13 - 0.000341782111136949*x_14 - 1.1094745847444e-5*x_15 - 9.24772061078687e-6*x_16 + 1.56216671702758e-5*x_17 - 0.00013649218396329*x_18 - 8.11997011220473e-5*x_19 - 1.99732946493115e-5*x_2 - 5.02150148393515e-5*x_20 - 6.42320077011232e-6*x_21 + 8.01169171629952e-5*x_22 + 8.26124735730757e-5*x_23 + 1.44802984384828e-5*x_24 + 4.76039790034164e-5*x_25 + 3.97613525176736e-5*x_26 - 0.000299458699168336*x_27 - 6.30236335618589e-5*x_28 + 4.15654040045515e-5*x_29 - 6.10641601947331e-6*x_3 + 4.68214799815928e-5*x_30 + 6.92176579086937e-6*x_31 + 7.40239064751048e-5*x_32 + 2.00853406061194e-6*x_33 - 0.000103449889129485*x_34 - 0.000204115835484011*x_35 - 0.000337404577640509*x_36 + 4.09348198920427e-5*x_37 + 0.000369898652948178*x_38 - 0.000210956390479565*x_39 - 6.1008942695148e-5*x_4 - 0.000235314067948998*x_40 - 0.000208271779543678*x_41 - 8.23389209910733e-5*x_42 - 9.96228334347709e-5*x_43 + 6.98444856434542e-5*x_44 + 0.000157081243485165*x_45 + 4.82150603398831e-5*x_46 - 8.59505691376306e-5*x_47 - 0.000225353853588878*x_48 + 3.40191535844816e-6*x_49 + 0.000336119769109465*x_50 - 0.000263020087003639*x_51 - 0.000363088119427617*x_52 + 0.000195068920389809*x_53 + 3.81605999792182e-5*x_54 - 0.000417659499228106*x_55 + 0.000130432919993152*x_56 - 7.28434855212068e-5*x_57 - 0.000531469921624999*x_58 - 0.000112755444005927*x_59 - 1.26457891553962e-5*x_6 + 5.18620775475275e-5*x_60 - 7.48625483466508e-6*x_61 + 8.63409071699882e-7*x_62 + 1.35307770940286e-6*x_63 + 4.46067718445239e-6*x_64 - 5.56085029530499e-5*x_65 + 2.75114533555323e-6*x_66 - 2.62483983646806e-5*x_67 - 1.21838175137613e-5*x_68 + 2.13211688882118e-6*x_69 + 8.29337853491866e-6*x_7 - 3.60475740766392e-6*x_70 - 1.60546596857133e-6*x_71 + 2.16613973537096e-6*x_72 - 1.67944666729611e-6*x_73 + 1.65176600684456e-5*x_74 + 2.45280891310468e-5*x_75 + 2.26475431014113e-5*x_76 + 4.06381980401995e-6*x_77 - 1.67304839275759e-6*x_78 + 4.89536719765241e-6*x_79 - 8.97286299855636e-6*x_8 - 1.10773345506906e-5*x_80 + 2.69011795321799e-6*x_81 - 2.14380413818453e-5*x_82 + 1.68008810353679e-5*x_83 - 2.59699531265867e-5*x_84 - 1.44432271049048e-5*x_85 + 1.96710473623904e-5*x_86 - 1.60619506256231e-5*x_87 + 1.0925210094265e-6*x_88 + 1.6033797499456e-5*x_89 - 9.22289294299157e-5*x_9 + 6.75088610215099e-6*x_90 - 1.0313631227152e-5*x_91 - 3.56214639521022e-6*x_92 - 0.000370162253123106*x_93 - 1.15867542198901e-6*x_94 - 1.123931201678e-5*x_95 - 3.84081655755391e-5*x_96 - 1.30920677486974e-5*x_97 + 1.42883399147733e-5*x_98 + 3.96999096576352e-5*x_99 + 1.75554286756764e-7*std::pow(-9.30727958679199*x_49 - 3.04655981063843, 2) + 1.71743295288861e-7*std::pow(-8.91152000427246*x_5 - 1.61951982975006, 2) + 1.70940455112783e-5*std::exp(0.411199867725372*x_6) - 4.06122532446499e-5*std::sin(0.336239844560623*x_1 - 7.45831966400146) - 0.000625167180338904*std::sin(0.292959928512573*x_10 - 1.3983998298645) + 0.00157718214999193*std::sin(0.306079924106598*x_10 + 1.79959988594055) - 0.000101110212598602*std::sin(0.27007994055748*x_100 + 1.78159987926483) - 0.0016701890471747*std::sin(0.264799952507019*x_107 - 1.23319983482361) + 0.000173884269958556*std::sin(0.275119960308075*x_107 + 4.97192001342773) + 0.000967359756020656*std::sin(0.267439961433411*x_108 + 8.1782398223877) - 0.00132373128095133*std::sin(0.245279967784882*x_109 - 1.21599984169006) + 0.000466652329102866*std::sin(0.356959849596024*x_11 - 1.3368798494339) + 0.000148870969566713*std::sin(0.248719975352287*x_110 - 4.4334397315979) - 0.00025506003920917*std::sin(0.222079992294312*x_111 - 1.22215986251831) - 0.0021856989888612*std::sin(0.227119997143745*x_111 - 1.20175993442535) - 0.000122188174822016*std::sin(0.287679940462112*x_113 + 1.95039987564087) + 0.000880977506309614*std::sin(0.303199917078018*x_116 + 1.75935995578766) - 0.00050786375243755*std::sin(0.329039841890335*x_12 + 1.85455989837646) + 0.000136284331240391*std::sin(0.329919844865799*x_12 + 1.85023999214172) + 0.000492422778242589*std::sin(0.374719828367233*x_12 - 4.57239961624146) - 0.000964641850169532*std::sin(0.309839934110641*x_120 - 7.65032005310059) - 0.000305571795728501*std::sin(0.397519826889038*x_13 - 7.78760004043579) + 0.000138474098753837*std::sin(0.288319945335388*x_14 + 8.1715202331543) + 0.000325235709751839*std::sin(0.334799855947495*x_14 - 7.75631999969482) + 0.000566487064952071*std::sin(0.359839856624603*x_15 - 1.37655985355377) + 0.000130551856554003*std::sin(0.36575984954834*x_15 - 7.55879974365234) + 0.000974993693776431*std::sin(0.33519983291626*x_16 - 4.35847997665405) + 6.93954589602281e-5*std::sin(0.341119825839996*x_16 - 7.55671977996826) + 4.51698238605746e-5*std::sin(0.356159836053848*x_16 - 7.57928037643433) - 0.000771023256086488*std::sin(0.32847985625267*x_17 - 7.58584022521973) + 0.000141808718871931*std::sin(0.378079831600189*x_17 - 1.20383989810944) + 0.000784271740132018*std::sin(0.39591982960701*x_17 + 1.81023991107941) + 0.000100340571261883*std::sin(0.353919863700867*x_18 - 7.57656002044678) + 5.59587472646088e-5*std::sin(0.372879832983017*x_2 - 1.20743989944458) + 8.00383467941284e-5*std::sin(0.335679858922958*x_20 + 5.03431987762451) + 5.55221071835828e-5*std::sin(0.357039839029312*x_20 + 5.03447961807251) - 0.000812013365119704*std::sin(0.282239943742752*x_21 - 1.39167988300323) - 8.58696323296016e-5*std::sin(0.363999843597412*x_21 + 5.02055978775024) + 0.000989436550069862*std::sin(0.384639829397202*x_21 + 8.19575977325439) + 0.000128609927481419*std::sin(0.353439837694168*x_22 + 8.20743942260742) - 0.0013416176740824*std::sin(0.307599931955338*x_24 - 7.55647993087769) + 0.000886657303918819*std::sin(0.30991992354393*x_24 + 1.82943987846375) - 0.000234012301211184*std::sin(0.347839832305908*x_24 - 1.18343985080719) - 0.000108104658863664*std::sin(0.341839849948883*x_25 - 7.59144020080566) - 0.0013882244371644*std::sin(0.365119844675064*x_25 + 5.02320003509521) + 0.000139980623524082*std::sin(0.364959836006165*x_26 + 5.00607967376709) - 0.000139717644546859*std::sin(0.362719833850861*x_27 - 4.3744797706604) + 0.000176913290062587*std::sin(0.221599996089935*x_28 - 7.58168029785156) + 0.000120789920142975*std::sin(0.274799942970276*x_28 - 7.58152008056641) - 0.00175027600924113*std::sin(0.328959852457047*x_28 + 5.03695964813232) - 9.9132645284271e-5*std::sin(0.149280041456223*x_29 - 1.22135996818542) + 0.000117754496977904*std::sin(0.291919946670532*x_3 - 4.32119989395142) - 0.000841149610480265*std::sin(0.301119923591614*x_3 + 5.06943941116333) - 0.000604639970628384*std::sin(0.345439851284027*x_3 - 4.41095972061157) - 2.59818999636214e-5*std::sin(0.435919851064682*x_31 + 1.99383985996246) + 0.00175886535420301*std::sin(0.255519956350327*x_34 + 8.17208003997803) + 5.52549733535265e-5*std::sin(0.263919949531555*x_35 - 1.41455984115601) - 0.000938464801630583*std::sin(0.217360004782677*x_36 + 8.19919967651367) + 0.0022125359648918*std::sin(0.247679978609085*x_37 + 8.16775989532471) + 0.000294357701667817*std::sin(0.263599961996078*x_37 + 1.95351982116699) + 0.000999673179496362*std::sin(0.269439965486526*x_37 + 1.93767988681793) + 0.000278623647181186*std::sin(0.256319969892502*x_38 + 1.94175982475281) + 0.000640332497562066*std::sin(0.321599900722504*x_4 - 7.55352020263672) + 0.000149904529090128*std::sin(0.335679858922958*x_4 - 4.3918399810791) + 6.04676389739062e-5*std::sin(0.352239847183228*x_4 + 1.98887979984283) + 0.00031646948606144*std::sin(0.303679943084717*x_44 - 1.44399976730347) + 0.000156274523006757*std::sin(0.217840000987053*x_47 - 7.60080003738403) + 0.00121686498888585*std::sin(0.243039980530739*x_47 + 8.16695976257324) - 9.84050763062839e-5*std::sin(0.222399994730949*x_48 - 4.41351985931396) - 0.00292343637033568*std::sin(0.236959978938103*x_48 - 7.59352016448975) - 0.000158881154580375*std::sin(0.242639973759651*x_48 + 8.17303943634033) - 0.000801137147574385*std::sin(0.230879992246628*x_49 - 7.61863994598389) - 0.00095880784965185*std::sin(0.263919949531555*x_49 + 8.14167976379395) - 0.000544134474922264*std::sin(0.19336000084877*x_5 + 1.7973598241806) + 9.83640799567241e-5*std::sin(0.358879864215851*x_5 - 1.15943992137909) - 0.000446425895677941*std::sin(0.401039868593216*x_5 + 5.00216007232666) - 3.62432752368242e-5*std::sin(0.478239864110947*x_5 + 8.16103935241699) - 0.000309198044225584*std::sin(0.215920001268387*x_51 + 8.19279956817627) + 0.000896057733230213*std::sin(0.22511999309063*x_53 + 8.1846399307251) - 0.000286105670728718*std::sin(0.245599970221519*x_53 - 1.20199990272522) + 0.00189240009571972*std::sin(0.197839990258217*x_57 + 8.19095993041992) + 0.000255496529182076*std::sin(0.255759954452515*x_57 + 8.15783977508545) - 0.00125764966274569*std::sin(0.403199851512909*x_6 - 1.17351984977722) + 0.000135504748627375*std::sin(0.421999871730804*x_6 + 1.96639978885651) + 9.42282459928227e-5*std::sin(0.419279843568802*x_7 - 4.40727996826172) - 0.00059282679176069*std::sin(0.309999912977219*x_8 + 8.19192028045654) - 9.57559511670797e-5*std::sin(0.319999933242798*x_8 + 8.18048000335693) - 0.000174246220598274*std::sin(0.354479849338531*x_8 + 8.23911952972412) - 9.05517668794744e-5*std::sin(0.468639850616455*x_8 - 8.01272010803223) + 0.000564682410960365*std::sin(0.300959944725037*x_9 - 7.42592000961304) - 4.66193466755277e-5*std::sin(0.306479930877686*x_9 + 1.95599985122681) - 0.000897357954740367*std::sin(0.356319844722748*x_9 - 7.57816028594971) + 8.92093021994404e-5*std::sin(0.388399839401245*x_9 - 7.60120010375977) + 0.000350071224730584*std::sin(0.315759837627411*x_92 - 7.59328031539917) - 0.000132781934191344*std::sin(0.320479840040207*x_92 - 4.37967967987061) - 0.000320426883518601*std::sin(0.332799851894379*x_92 + 5.01823997497559) + 0.000212165078510522*std::sin(0.251279979944229*x_93 - 1.22199988365173) + 0.00014117427857258*std::sin(0.287999957799911*x_94 - 1.19415986537933) - 0.000216025072561753*std::sin(0.29215994477272*x_94 - 1.19487988948822) - 0.000212374149609308*std::sin(0.277599930763245*x_96 - 1.20943987369537) + 0.000795798720105117*std::sin(0.287279933691025*x_96 + 8.1637601852417) - 0.000150711867440602*std::sin(0.276479959487915*x_97 + 8.18136024475098) - 0.000939709487937243*std::sin(0.276639938354492*x_99 + 4.97024011611938) + 0.0186704679069452);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000204698088193969*x_1 + 4.87490311831533e-6*x_10 - 6.02102594132289e-5*x_100 - 0.000198512091486707*x_101 + 0.00013814536045201*x_102 - 0.000151752203725525*x_103 - 0.000902509924546431*x_104 - 3.8068102424586e-5*x_105 - 0.000235860378991477*x_106 - 1.78516167571472e-5*x_107 - 0.000119979577795085*x_108 - 0.000318425023126107*x_109 - 0.000156880711264024*x_11 + 0.000395047444938957*x_110 + 2.27160668415424e-5*x_111 - 0.000270771449509989*x_112 - 7.02362094488316e-5*x_113 + 5.29823800447394e-5*x_114 + 0.000665451346005549*x_115 - 0.000861238074154929*x_116 + 0.000281709173730781*x_117 - 6.32987129806801e-6*x_118 + 0.000204785049023849*x_119 - 5.02624530079054e-5*x_12 - 0.000308385563774428*x_120 + 2.88754185430442e-5*x_13 - 0.000155969079246918*x_14 - 2.96918661711856e-5*x_15 - 4.19073611797692e-6*x_16 + 5.81001640630621e-5*x_17 - 0.000344088178928074*x_18 - 0.000264425876744961*x_19 - 8.18768702547735e-6*x_2 - 0.000190718590956865*x_20 - 6.42582819082977e-6*x_21 - 4.13947518081346e-5*x_22 - 1.40679466058183e-5*x_23 - 4.0213450018085e-5*x_24 - 6.80090413177759e-5*x_25 + 3.9193492957237e-5*x_26 - 0.000503527189192794*x_27 - 0.000257451047925494*x_28 - 9.03014146608671e-5*x_29 - 1.06239375618034e-5*x_3 - 0.000135671518294311*x_30 - 1.41721451791325e-5*x_31 + 2.45793091891991e-5*x_32 - 8.64142866390588e-5*x_33 - 0.000346522615293081*x_34 - 0.000836140710202896*x_35 - 0.000186413585999715*x_36 - 0.000192236373823393*x_37 + 0.000485063065164445*x_38 - 0.000809613987579433*x_39 - 3.73813335833806e-5*x_4 + 0.000314639328402859*x_40 + 0.000165376967846082*x_41 - 0.000177691151033649*x_42 + 0.000406477855165875*x_43 + 0.000149977243923432*x_44 + 0.000224309496991262*x_45 + 0.000339964809297316*x_46 - 0.000251027895366144*x_47 + 0.000218211871138348*x_48 - 0.000181942137936659*x_49 + 0.000667046711216905*x_50 - 0.000188135244438352*x_51 - 0.000879882852180945*x_52 + 1.98889302523591e-5*x_53 - 0.00029137902482345*x_54 - 0.000319139417954077*x_55 + 5.00970716896208e-5*x_56 - 0.000102973392637634*x_57 - 0.000955534983997667*x_58 + 0.000305148525195712*x_59 - 3.35973809681669e-5*x_6 + 0.000197656758376139*x_60 + 4.6928987672695e-5*x_61 - 1.57918375800416e-6*x_62 - 8.67476228666793e-6*x_63 + 1.57070398977778e-5*x_64 - 0.000117543970897861*x_65 + 6.32473291905474e-6*x_66 + 2.41746546774995e-5*x_67 + 6.47702374661734e-5*x_68 + 2.98902983002635e-5*x_69 + 0.000170031550394871*x_7 - 8.89249795192666e-6*x_70 + 1.51613555642923e-5*x_71 + 3.00864878472345e-6*x_72 + 3.46504495175945e-6*x_73 - 1.97291731834422e-5*x_74 + 6.85386058850348e-6*x_75 - 5.03578887635794e-5*x_76 + 2.13327667622266e-6*x_77 - 2.52858090719916e-6*x_78 - 2.97846794638031e-5*x_79 - 3.36390086626719e-5*x_8 + 2.2040848648541e-5*x_80 - 1.52994673851154e-6*x_81 - 8.07879113493175e-5*x_82 + 9.05980035897667e-5*x_83 + 1.57523856564183e-5*x_84 + 4.24389226296118e-5*x_85 - 7.0867470048837e-5*x_86 - 0.000128319951975454*x_87 - 7.00557348189794e-7*x_88 - 2.95634160252249e-5*x_89 - 3.66926024822181e-5*x_9 - 6.97374243863979e-5*x_90 + 2.13936311444459e-5*x_91 + 1.3903441088804e-6*x_92 - 2.8517054075839e-5*x_93 - 4.70398473556451e-6*x_94 - 9.12326806005857e-5*x_95 - 3.97828917775732e-5*x_96 - 5.82639398123585e-6*x_97 - 2.49810260211932e-5*x_98 + 6.00492405247098e-5*x_99 + 6.98429841681093e-8*std::pow(-9.30727958679199*x_49 - 3.04655981063843, 2) + 8.34604774545176e-8*std::pow(-8.91152000427246*x_5 - 1.61951982975006, 2) - 7.33960485009681e-5*std::exp(0.411199867725372*x_6) + 0.000174375276286194*std::sin(0.336239844560623*x_1 - 7.45831966400146) - 0.000303806627631206*std::sin(0.292959928512573*x_10 - 1.3983998298645) + 0.00062747033961486*std::sin(0.306079924106598*x_10 + 1.79959988594055) - 0.000816526596850518*std::sin(0.27007994055748*x_100 + 1.78159987926483) - 0.000811646097054634*std::sin(0.264799952507019*x_107 - 1.23319983482361) + 0.00140422146829765*std::sin(0.275119960308075*x_107 + 4.97192001342773) + 0.00362660426420581*std::sin(0.267439961433411*x_108 + 8.1782398223877) - 0.00496263099460405*std::sin(0.245279967784882*x_109 - 1.21599984169006) + 0.000226774652988237*std::sin(0.356959849596024*x_11 - 1.3368798494339) + 0.00120222382117538*std::sin(0.248719975352287*x_110 - 4.4334397315979) - 0.0020597652843913*std::sin(0.222079992294312*x_111 - 1.22215986251831) - 0.00106216362551676*std::sin(0.227119997143745*x_111 - 1.20175993442535) - 0.000986743989540149*std::sin(0.287679940462112*x_113 + 1.95039987564087) + 0.000428120371043442*std::sin(0.303199917078018*x_116 + 1.75935995578766) - 0.00190396679080606*std::sin(0.329039841890335*x_12 + 1.85455989837646) + 0.00110057904470576*std::sin(0.329919844865799*x_12 + 1.85023999214172) + 0.000239298076309079*std::sin(0.374719828367233*x_12 - 4.57239961624146) - 0.000468777947065395*std::sin(0.309839934110641*x_120 - 7.65032005310059) - 0.00114557998770661*std::sin(0.397519826889038*x_13 - 7.78760004043579) + 0.00111826275211468*std::sin(0.288319945335388*x_14 + 8.1715202331543) + 0.000158051745632878*std::sin(0.334799855947495*x_14 - 7.75631999969482) + 0.000275290402651162*std::sin(0.359839856624603*x_15 - 1.37655985355377) - 0.000560545506282116*std::sin(0.36575984954834*x_15 - 7.55879974365234) + 0.0036552236801423*std::sin(0.33519983291626*x_16 - 4.35847997665405) + 0.000560410629998602*std::sin(0.341119825839996*x_16 - 7.55671977996826) - 0.000193943942682472*std::sin(0.356159836053848*x_16 - 7.57928037643433) - 0.000374686935948693*std::sin(0.32847985625267*x_17 - 7.58584022521973) - 0.000608878664872942*std::sin(0.378079831600189*x_17 - 1.20383989810944) + 0.000312016754141867*std::sin(0.39591982960701*x_17 + 1.81023991107941) - 0.000430828467731235*std::sin(0.353919863700867*x_18 - 7.57656002044678) + 0.000451900992923253*std::sin(0.372879832983017*x_2 - 1.20743989944458) + 0.000646358436459812*std::sin(0.335679858922958*x_20 + 5.03431987762451) - 0.000238393145088652*std::sin(0.357039839029312*x_20 + 5.03447961807251) - 0.00304421505464441*std::sin(0.282239943742752*x_21 - 1.39167988300323) - 0.000693449621525814*std::sin(0.363999843597412*x_21 + 5.02055978775024) + 0.00048082719468547*std::sin(0.384639829397202*x_21 + 8.19575977325439) + 0.0010386035565417*std::sin(0.353439837694168*x_22 + 8.20743942260742) - 0.000651973350412352*std::sin(0.307599931955338*x_24 - 7.55647993087769) + 0.00332405306223278*std::sin(0.30991992354393*x_24 + 1.82943987846375) - 0.0018897919707447*std::sin(0.347839832305908*x_24 - 1.18343985080719) - 0.000873011013794017*std::sin(0.341839849948883*x_25 - 7.59144020080566) - 0.00067462240167744*std::sin(0.365119844675064*x_25 + 5.02320003509521) - 0.000601029441894881*std::sin(0.364959836006165*x_26 + 5.00607967376709) + 0.000599900299132607*std::sin(0.362719833850861*x_27 - 4.3744797706604) + 0.00142868265192858*std::sin(0.221599996089935*x_28 - 7.58168029785156) - 0.00051863105380131*std::sin(0.274799942970276*x_28 - 7.58152008056641) - 0.000696334460762119*std::sin(0.328959852457047*x_28 + 5.03695964813232) + 0.000425642042225353*std::sin(0.149280041456223*x_29 - 1.22135996818542) + 0.000950939338471357*std::sin(0.291919946670532*x_3 - 4.32119989395142) - 0.00315344601139025*std::sin(0.301119923591614*x_3 + 5.06943941116333) - 0.000293831212169616*std::sin(0.345439851284027*x_3 - 4.41095972061157) + 0.000111557488753559*std::sin(0.435919851064682*x_31 + 1.99383985996246) + 0.00085473928978183*std::sin(0.255519956350327*x_34 + 8.17208003997803) + 0.000446217589617105*std::sin(0.263919949531555*x_35 - 1.41455984115601) - 0.00351827790045864*std::sin(0.217360004782677*x_36 + 8.19919967651367) + 0.000880241190472417*std::sin(0.247679978609085*x_37 + 8.16775989532471) + 0.00237711786200801*std::sin(0.263599961996078*x_37 + 1.95351982116699) + 0.00374774637151256*std::sin(0.269439965486526*x_37 + 1.93767988681793) + 0.0022500557815866*std::sin(0.256319969892502*x_38 + 1.94175982475281) + 0.000311176374520397*std::sin(0.321599900722504*x_4 - 7.55352020263672) + 0.00121057044431667*std::sin(0.335679858922958*x_4 - 4.3918399810791) - 0.000259627585520332*std::sin(0.352239847183228*x_4 + 1.98887979984283) + 0.000153791706174317*std::sin(0.303679943084717*x_44 - 1.44399976730347) + 0.0012620120279216*std::sin(0.217840000987053*x_47 - 7.60080003738403) + 0.00456199229933848*std::sin(0.243039980530739*x_47 + 8.16695976257324) - 0.000794680972417389*std::sin(0.222399994730949*x_48 - 4.41351985931396) - 0.00116306769775853*std::sin(0.236959978938103*x_48 - 7.59352016448975) + 0.000682181928191144*std::sin(0.242639973759651*x_48 + 8.17303943634033) - 0.00300344042381778*std::sin(0.230879992246628*x_49 - 7.61863994598389) - 0.000465942852584084*std::sin(0.263919949531555*x_49 + 8.14167976379395) - 0.000216479906127122*std::sin(0.19336000084877*x_5 + 1.7973598241806) + 0.000794349901906022*std::sin(0.358879864215851*x_5 - 1.15943992137909) - 0.00167363800989355*std::sin(0.401039868593216*x_5 + 5.00216007232666) + 0.000155616362748116*std::sin(0.478239864110947*x_5 + 8.16103935241699) + 0.00132759180004595*std::sin(0.215920001268387*x_51 + 8.19279956817627) + 0.00335929500486466*std::sin(0.22511999309063*x_53 + 8.1846399307251) - 0.00231047768228099*std::sin(0.245599970221519*x_53 - 1.20199990272522) + 0.000919631914934998*std::sin(0.197839990258217*x_57 + 8.19095993041992) + 0.00206329020697802*std::sin(0.255759954452515*x_57 + 8.15783977508545) - 0.000611168203956526*std::sin(0.403199851512909*x_6 - 1.17351984977722) + 0.00109428343992351*std::sin(0.421999871730804*x_6 + 1.96639978885651) + 0.000760950521715916*std::sin(0.419279843568802*x_7 - 4.40727996826172) - 0.000288090472498265*std::sin(0.309999912977219*x_8 + 8.19192028045654) - 0.000773287672186354*std::sin(0.319999933242798*x_8 + 8.18048000335693) + 0.000748154323662201*std::sin(0.354479849338531*x_8 + 8.23911952972412) - 3.60253556742827e-5*std::sin(0.468639850616455*x_8 - 8.01272010803223) + 0.00211697832865723*std::sin(0.300959944725037*x_9 - 7.42592000961304) + 0.00020016770327556*std::sin(0.306479930877686*x_9 + 1.95599985122681) - 0.000436080623841959*std::sin(0.356319844722748*x_9 - 7.57816028594971) + 0.000720419491367245*std::sin(0.388399839401245*x_9 - 7.60120010375977) + 0.00131240708379911*std::sin(0.315759837627411*x_92 - 7.59328031539917) + 0.000570120705220439*std::sin(0.320479840040207*x_92 - 4.37967967987061) - 0.000155714845477639*std::sin(0.332799851894379*x_92 + 5.01823997497559) - 0.000910965071568098*std::sin(0.251279979944229*x_93 - 1.22199988365173) - 0.000606154592859009*std::sin(0.287999957799911*x_94 - 1.19415986537933) - 0.00174453413557232*std::sin(0.29215994477272*x_94 - 1.19487988948822) - 0.00171505070736949*std::sin(0.277599930763245*x_96 - 1.20943987369537) + 0.00298342681078116*std::sin(0.287279933691025*x_96 + 8.1637601852417) + 0.000647105772887033*std::sin(0.276479959487915*x_97 + 8.18136024475098) - 0.00352294419408853*std::sin(0.276639938354492*x_99 + 4.97024011611938) - 0.0240361467100379);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000109321826953269*x_1 - 0.000582786904387791*x_10 - 0.000249486645968082*x_100 - 0.000301538505269283*x_101 - 0.000273772263686581*x_102 - 0.000419789166710322*x_103 - 0.000780586724734712*x_104 - 0.000599754380545807*x_105 - 0.000391553560118007*x_106 + 0.000131182098526002*x_107 - 0.000498893271385185*x_108 - 0.000242778099669983*x_109 - 0.000513931642389077*x_11 + 0.000729812208098225*x_110 + 0.00031967303547347*x_111 - 0.000586660234456587*x_112 - 0.000134474211903245*x_113 + 0.00013505504912949*x_114 + 0.00084391865769897*x_115 - 0.00136645895787679*x_116 + 0.000400078871373087*x_117 - 0.000244124566004063*x_118 + 0.000551367450455188*x_119 - 0.000416242851504988*x_12 - 0.00110651551487607*x_120 + 0.000356964865891462*x_13 - 3.89130243716762e-5*x_14 - 1.73984862083677e-5*x_15 - 5.761801383785e-6*x_16 + 7.87445186570749e-5*x_17 - 0.000465879308989724*x_18 + 0.000101770269178228*x_19 + 4.04252392789424e-5*x_2 - 0.000241948320143391*x_20 - 3.15340533969097e-5*x_21 - 0.000422342316494969*x_22 - 0.000234446479414006*x_23 - 0.000371292562940398*x_24 - 0.000404241055068948*x_25 - 0.000171294864155059*x_26 - 0.000115470746847148*x_27 - 0.000338992672450694*x_28 - 0.000162506590586466*x_29 - 6.64939633374591e-5*x_3 - 0.000290393520711088*x_30 - 2.90208413114212e-5*x_31 - 0.000307242132404598*x_32 - 0.000419320283652614*x_33 - 0.00135436920965503*x_34 - 0.00228050655257243*x_35 + 9.4822448676294e-5*x_36 - 0.00168570166698851*x_37 - 0.000269595458082462*x_38 - 0.00148476359294658*x_39 - 2.14962384579336e-5*x_4 + 9.35139685619916e-6*x_40 + 0.000109065003317744*x_41 - 0.00247392587498825*x_42 - 0.00177803960184229*x_43 + 0.000136678613508787*x_44 + 0.000848989388694485*x_45 + 6.69422791820565e-5*x_46 - 0.0017336603172424*x_47 + 0.000182560441334458*x_48 - 0.000564555967191847*x_49 - 0.000392295866462944*x_50 - 0.000601714670441438*x_51 - 0.00154753565910731*x_52 - 0.000461292267782889*x_53 - 0.000565146692155534*x_54 - 0.000870332788812433*x_55 - 0.000697723897046202*x_56 - 0.000457147459721116*x_57 - 0.00254762984332446*x_58 - 0.000582363270780863*x_59 - 4.24921178165361e-5*x_6 + 0.000174092890710744*x_60 + 0.00041204266657773*x_61 - 3.2714309160892e-5*x_62 - 0.000104223170755462*x_63 - 6.70899450997361e-5*x_64 + 0.000216858376627478*x_65 + 3.36909612169977e-6*x_66 + 0.000305823397962691*x_67 + 0.000518390679570341*x_68 - 5.72993979185819e-5*x_69 + 0.000788173665589577*x_7 + 1.77869056558484e-5*x_70 + 4.20445719853297e-5*x_71 + 7.51015627644592e-6*x_72 + 1.28630027569585e-5*x_73 - 0.000212952711823337*x_74 + 6.16933210177939e-6*x_75 - 0.00053715895619596*x_76 - 5.95863999669865e-5*x_77 - 2.5372965699712e-5*x_78 - 0.000241999538535512*x_79 - 4.45707598799992e-5*x_8 + 0.000224945768549651*x_80 - 1.23119184228422e-5*x_81 - 9.98484628840981e-5*x_82 - 3.31427698756925e-5*x_83 + 8.11884632345232e-5*x_84 - 0.000212701665851315*x_85 + 3.23485867388815e-5*x_86 - 0.000139717854107497*x_87 - 1.97838135284432e-5*x_88 - 0.000428378150979271*x_89 - 3.33492519352916e-6*x_9 - 9.85568729645507e-5*x_90 + 0.000201185741318367*x_91 - 2.22889055500031e-6*x_92 + 0.000547838257857218*x_93 - 6.44015066797716e-6*x_94 + 0.000233947868024283*x_95 - 0.000212459462679121*x_96 - 0.000451727297170124*x_97 - 0.000227768561525087*x_98 - 0.00105326845826899*x_99 + 6.34790425689657e-9*std::pow(-9.30727958679199*x_49 - 3.04655981063843, 2) + 1.66759167395708e-7*std::pow(-8.91152000427246*x_5 - 1.61951982975006, 2) - 0.000647971263736279*std::exp(0.411199867725372*x_6) + 0.00153945846468884*std::sin(0.336239844560623*x_1 - 7.45831966400146) - 0.000607024328379701*std::sin(0.292959928512573*x_10 - 1.3983998298645) + 5.7029659991765e-5*std::sin(0.306079924106598*x_10 + 1.79959988594055) + 0.000577034169652506*std::sin(0.27007994055748*x_100 + 1.78159987926483) - 0.00162171882420115*std::sin(0.264799952507019*x_107 - 1.23319983482361) - 0.000992354409633148*std::sin(0.275119960308075*x_107 + 4.97192001342773) + 0.00480515075401332*std::sin(0.267439961433411*x_108 + 8.1782398223877) - 0.00657534937047607*std::sin(0.245279967784882*x_109 - 1.21599984169006) + 0.000453109705002316*std::sin(0.356959849596024*x_11 - 1.3368798494339) - 0.000849603952968844*std::sin(0.248719975352287*x_110 - 4.4334397315979) + 0.00145562306866947*std::sin(0.222079992294312*x_111 - 1.22215986251831) - 0.00212226825476414*std::sin(0.227119997143745*x_111 - 1.20175993442535) + 0.000697325721979071*std::sin(0.287679940462112*x_113 + 1.95039987564087) + 0.000855410833939356*std::sin(0.303199917078018*x_116 + 1.75935995578766) - 0.00252270355239919*std::sin(0.329039841890335*x_12 + 1.85455989837646) - 0.000777772233811264*std::sin(0.329919844865799*x_12 + 1.85023999214172) + 0.000478132275081257*std::sin(0.374719828367233*x_12 - 4.57239961624146) - 0.000936647171575257*std::sin(0.309839934110641*x_120 - 7.65032005310059) - 0.00151786192831724*std::sin(0.397519826889038*x_13 - 7.78760004043579) - 0.000790269197731905*std::sin(0.288319945335388*x_14 + 8.1715202331543) + 0.000315797109135161*std::sin(0.334799855947495*x_14 - 7.75631999969482) + 0.000550047156909142*std::sin(0.359839856624603*x_15 - 1.37655985355377) - 0.00494873208443265*std::sin(0.36575984954834*x_15 - 7.55879974365234) + 0.00484307069179752*std::sin(0.33519983291626*x_16 - 4.35847997665405) - 0.000396038639516456*std::sin(0.341119825839996*x_16 - 7.55671977996826) - 0.00171221890279693*std::sin(0.356159836053848*x_16 - 7.57928037643433) - 0.000748647544065431*std::sin(0.32847985625267*x_17 - 7.58584022521973) - 0.00537543758823167*std::sin(0.378079831600189*x_17 - 1.20383989810944) + 2.83586462610597e-5*std::sin(0.39591982960701*x_17 + 1.81023991107941) - 0.00380353537269368*std::sin(0.353919863700867*x_18 - 7.57656002044678) - 0.00031935556688835*std::sin(0.372879832983017*x_2 - 1.20743989944458) - 0.000456777409479485*std::sin(0.335679858922958*x_20 + 5.03431987762451) - 0.00210463520372112*std::sin(0.357039839029312*x_20 + 5.03447961807251) - 0.00403350109345516*std::sin(0.282239943742752*x_21 - 1.39167988300323) + 0.000490056451432711*std::sin(0.363999843597412*x_21 + 5.02055978775024) + 0.000960722309438724*std::sin(0.384639829397202*x_21 + 8.19575977325439) - 0.000733974549217156*std::sin(0.353439837694168*x_22 + 8.20743942260742) - 0.00130268285534555*std::sin(0.307599931955338*x_24 - 7.55647993087769) + 0.00440427874527577*std::sin(0.30991992354393*x_24 + 1.82943987846375) + 0.00133550400545529*std::sin(0.347839832305908*x_24 - 1.18343985080719) + 0.000616951349025495*std::sin(0.341839849948883*x_25 - 7.59144020080566) - 0.0013479370528587*std::sin(0.365119844675064*x_25 + 5.02320003509521) - 0.00530614133814302*std::sin(0.364959836006165*x_26 + 5.00607967376709) + 0.00529617278973268*std::sin(0.362719833850861*x_27 - 4.3744797706604) - 0.00100964097303431*std::sin(0.221599996089935*x_28 - 7.58168029785156) - 0.00457869362463131*std::sin(0.274799942970276*x_28 - 7.58152008056641) - 6.32885971346274e-5*std::sin(0.328959852457047*x_28 + 5.03695964813232) + 0.00375774742146254*std::sin(0.149280041456223*x_29 - 1.22135996818542) - 0.000672022802051087*std::sin(0.291919946670532*x_3 - 4.32119989395142) - 0.0041782291023392*std::sin(0.301119923591614*x_3 + 5.06943941116333) - 0.000587092834725024*std::sin(0.345439851284027*x_3 - 4.41095972061157) + 0.000984876549122888*std::sin(0.435919851064682*x_31 + 1.99383985996246) + 0.0017078216738227*std::sin(0.255519956350327*x_34 + 8.17208003997803) - 0.000315339141801631*std::sin(0.263919949531555*x_35 - 1.41455984115601) - 0.00466162130593519*std::sin(0.217360004782677*x_36 + 8.19919967651367) + 8.000355177617e-5*std::sin(0.247679978609085*x_37 + 8.16775989532471) - 0.00167989412342565*std::sin(0.263599961996078*x_37 + 1.95351982116699) + 0.00496566070929382*std::sin(0.269439965486526*x_37 + 1.93767988681793) - 0.00159010015669745*std::sin(0.256319969892502*x_38 + 1.94175982475281) + 0.000621749535958681*std::sin(0.321599900722504*x_4 - 7.55352020263672) - 0.00085550245862967*std::sin(0.335679858922958*x_4 - 4.3918399810791) - 0.00229210179739021*std::sin(0.352239847183228*x_4 + 1.98887979984283) + 0.00030728528827277*std::sin(0.303679943084717*x_44 - 1.44399976730347) - 0.000891855899651156*std::sin(0.217840000987053*x_47 - 7.60080003738403) + 0.00604451413497957*std::sin(0.243039980530739*x_47 + 8.16695976257324) + 0.000561596005355185*std::sin(0.222399994730949*x_48 - 4.41351985931396) - 0.000105709148565152*std::sin(0.236959978938103*x_48 - 7.59352016448975) + 0.00602258970525146*std::sin(0.242639973759651*x_48 + 8.17303943634033) - 0.00397947583076108*std::sin(0.230879992246628*x_49 - 7.61863994598389) - 0.00093098247842215*std::sin(0.263919949531555*x_49 + 8.14167976379395) - 1.9675472547526e-5*std::sin(0.19336000084877*x_5 + 1.7973598241806) - 0.000561362039923612*std::sin(0.358879864215851*x_5 - 1.15943992137909) - 0.00221752426217545*std::sin(0.401039868593216*x_5 + 5.00216007232666) + 0.00137384686624662*std::sin(0.478239864110947*x_5 + 8.16103935241699) + 0.0117205401921651*std::sin(0.215920001268387*x_51 + 8.19279956817627) + 0.0044509733485116*std::sin(0.22511999309063*x_53 + 8.1846399307251) + 0.00163279993087566*std::sin(0.245599970221519*x_53 - 1.20199990272522) + 0.00183748113025897*std::sin(0.197839990258217*x_57 + 8.19095993041992) - 0.00145811410911538*std::sin(0.255759954452515*x_57 + 8.15783977508545) - 0.00122115166290609*std::sin(0.403199851512909*x_6 - 1.17351984977722) - 0.000773323169822416*std::sin(0.421999871730804*x_6 + 1.96639978885651) - 0.000537758909677464*std::sin(0.419279843568802*x_7 - 4.40727996826172) - 0.000575622483763376*std::sin(0.309999912977219*x_8 + 8.19192028045654) + 0.00054647749570399*std::sin(0.319999933242798*x_8 + 8.18048000335693) + 0.00660502182984366*std::sin(0.354479849338531*x_8 + 8.23911952972412) - 3.2742803212783e-6*std::sin(0.468639850616455*x_8 - 8.01272010803223) + 0.00280493797257607*std::sin(0.300959944725037*x_9 - 7.42592000961304) + 0.00176716488557204*std::sin(0.306479930877686*x_9 + 1.95599985122681) - 0.000871315908645687*std::sin(0.356319844722748*x_9 - 7.57816028594971) - 0.000509115887475105*std::sin(0.388399839401245*x_9 - 7.60120010375977) + 0.00173890323533018*std::sin(0.315759837627411*x_92 - 7.59328031539917) + 0.00503326597805921*std::sin(0.320479840040207*x_92 - 4.37967967987061) - 0.000311127838888211*std::sin(0.332799851894379*x_92 + 5.01823997497559) - 0.00804238376178801*std::sin(0.251279979944229*x_93 - 1.22199988365173) - 0.00535138833188304*std::sin(0.287999957799911*x_94 - 1.19415986537933) + 0.00123285121419592*std::sin(0.29215994477272*x_94 - 1.19487988948822) + 0.00121201546239414*std::sin(0.277599930763245*x_96 - 1.20943987369537) + 0.00395295834476939*std::sin(0.287279933691025*x_96 + 8.1637601852417) + 0.00571292261630573*std::sin(0.276479959487915*x_97 + 8.18136024475098) - 0.00466780401646013*std::sin(0.276639938354492*x_99 + 4.97024011611938) - 0.0962500799952999);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000152196001889014*x_1 + 0.000463645648767097*x_10 + 0.000116465565437788*x_100 + 0.000127800053097809*x_101 + 0.000224612806218908*x_102 + 0.000274393635430041*x_103 - 0.00025532517821571*x_104 + 0.00114722364024969*x_105 + 0.00124231532997552*x_106 - 0.000259017485349402*x_107 + 0.000271330247561141*x_108 + 0.000453761506015819*x_109 + 0.000232952712322775*x_11 + 0.000211340976771587*x_110 - 0.000366773048716083*x_111 + 0.000624240832043742*x_112 - 6.46258278567227e-5*x_113 + 0.000747107529755438*x_114 + 0.000244517698983785*x_115 - 0.000743553725705225*x_116 + 0.000656257559684532*x_117 + 0.000283684848865366*x_118 - 0.000126415995680759*x_119 + 0.000411927673459009*x_12 + 0.000738721909591197*x_120 - 0.000380878215478606*x_13 - 0.000612709276021799*x_14 - 2.89817393228284e-5*x_15 - 6.49739932198009e-6*x_16 + 7.36504357438396e-5*x_17 - 0.000406394363191342*x_18 - 0.00029498012617128*x_19 - 8.499250754973e-5*x_2 - 0.000260260325370349*x_20 + 1.94566388140665e-5*x_21 + 0.000440742619508136*x_22 + 0.00027354695312317*x_23 + 0.000388184606426644*x_24 + 0.000374888336046379*x_25 - 7.2462996340186e-5*x_26 + 6.16809396190258e-5*x_27 - 0.000323944622094081*x_28 - 0.000202535569360669*x_29 + 5.41591230642779e-5*x_3 + 0.000209796384337927*x_30 - 4.41376194887573e-6*x_31 + 0.000311254531227106*x_32 + 0.000385740443102574*x_33 - 0.000183111898264113*x_34 + 0.000447389844850058*x_35 - 0.000608309547508727*x_36 + 0.00172108962540726*x_37 + 0.00189993379361039*x_38 - 0.000745618576607161*x_39 - 0.000117057619577466*x_4 + 0.000816892891658483*x_40 + 0.000238439979092775*x_41 + 0.00173160548681896*x_42 + 0.00275279008906448*x_43 + 0.000814119384819112*x_44 + 0.000775917715588304*x_45 + 0.00082131589180711*x_46 + 0.00146620108457794*x_47 + 0.000438510157417176*x_48 + 0.000683484119779461*x_49 + 0.00190150705596543*x_50 - 0.00079791909977845*x_51 - 0.000532287571076156*x_52 + 0.000799992109457226*x_53 + 0.000765610779987852*x_54 + 0.000282080443266729*x_55 + 0.00024233844119394*x_56 + 0.000267524350958308*x_57 + 0.000407369671473254*x_58 + 0.00109382990928941*x_59 - 4.69304186578719e-5*x_6 + 0.00150742075096482*x_60 - 0.000419158639963004*x_61 + 3.71014737493575e-5*x_62 + 9.30504387018117e-5*x_63 + 4.98135678080971e-5*x_64 - 0.000147671373207069*x_65 + 1.19352015611998e-5*x_66 - 0.000346846265952783*x_67 - 0.000536763313180533*x_68 + 1.45294908522339e-5*x_69 - 0.000563805133078495*x_7 - 2.31809343585587e-5*x_70 - 6.95097730053336e-6*x_71 - 1.31559440291368e-6*x_72 - 1.50978223092509e-5*x_73 + 0.000226263347834262*x_74 + 1.40353980462532e-5*x_75 + 0.000574290995568034*x_76 + 6.31983642326871e-5*x_77 + 2.60893180784476e-5*x_78 + 0.00024030091366163*x_79 - 4.18931264771786e-5*x_8 - 0.00023296917737341*x_80 + 1.00189949652301e-5*x_81 - 0.000132239073032087*x_82 + 8.77823894832636e-6*x_83 - 0.000131490861481444*x_84 + 0.000148593459308888*x_85 + 0.000113732616385972*x_86 + 8.39501705657684e-5*x_87 + 2.39373368134728e-5*x_88 + 0.000536148673975993*x_89 - 0.000159581091811272*x_9 - 7.45820040352701e-5*x_90 - 0.000314148825598296*x_91 - 7.52121849126057e-6*x_92 + 0.00012002119229807*x_93 - 5.39607831392816e-6*x_94 - 0.000133797387407561*x_95 + 0.000181742038591029*x_96 - 0.000353324259508933*x_97 - 0.000380629911687295*x_98 + 0.00090913946893273*x_99 + 3.03756586203055e-7*std::pow(-9.30727958679199*x_49 - 3.04655981063843, 2) + 1.60330879751741e-8*std::pow(-8.91152000427246*x_5 - 1.61951982975006, 2) + 0.000663014310950012*std::exp(0.411199867725372*x_6) - 0.0015751979297916*std::sin(0.336239844560623*x_1 - 7.45831966400146) - 5.83624553418899e-5*std::sin(0.292959928512573*x_10 - 1.3983998298645) + 0.00272895338845085*std::sin(0.306079924106598*x_10 + 1.79959988594055) + 0.000200477033733759*std::sin(0.27007994055748*x_100 + 1.78159987926483) - 0.000155920426957482*std::sin(0.264799952507019*x_107 - 1.23319983482361) - 0.00034477034276094*std::sin(0.275119960308075*x_107 + 4.97192001342773) + 0.00451647647071243*std::sin(0.267439961433411*x_108 + 8.1782398223877) - 0.00618032861792428*std::sin(0.245279967784882*x_109 - 1.21599984169006) + 4.35643081946349e-5*std::sin(0.356959849596024*x_11 - 1.3368798494339) - 0.00029517503346854*std::sin(0.248719975352287*x_110 - 4.4334397315979) + 0.000505722209166612*std::sin(0.222079992294312*x_111 - 1.22215986251831) - 0.000204045835482077*std::sin(0.227119997143745*x_111 - 1.20175993442535) + 0.000242269521704067*std::sin(0.287679940462112*x_113 + 1.95039987564087) + 8.22436173654089e-5*std::sin(0.303199917078018*x_116 + 1.75935995578766) - 0.0023711495893188*std::sin(0.329039841890335*x_12 + 1.85455989837646) - 0.000270218781755786*std::sin(0.329919844865799*x_12 + 1.85023999214172) + 4.59701073702126e-5*std::sin(0.374719828367233*x_12 - 4.57239961624146) - 9.00540986027413e-5*std::sin(0.309839934110641*x_120 - 7.65032005310059) - 0.00142667484039066*std::sin(0.397519826889038*x_13 - 7.78760004043579) - 0.000274560559746155*std::sin(0.288319945335388*x_14 + 8.1715202331543) + 3.0362365752613e-5*std::sin(0.334799855947495*x_14 - 7.75631999969482) + 5.28843756834785e-5*std::sin(0.359839856624603*x_15 - 1.37655985355377) + 0.00506361991134796*std::sin(0.36575984954834*x_15 - 7.55879974365234) + 0.00455211832994654*std::sin(0.33519983291626*x_16 - 4.35847997665405) - 0.000137594367664615*std::sin(0.341119825839996*x_16 - 7.55671977996826) + 0.00175196910660458*std::sin(0.356159836053848*x_16 - 7.57928037643433) - 7.19788430456511e-5*std::sin(0.32847985625267*x_17 - 7.58584022521973) + 0.00550023164309141*std::sin(0.378079831600189*x_17 - 1.20383989810944) + 0.00135700307203607*std::sin(0.39591982960701*x_17 + 1.81023991107941) + 0.00389183676103089*std::sin(0.353919863700867*x_18 - 7.57656002044678) - 0.000110952626591758*std::sin(0.372879832983017*x_2 - 1.20743989944458) - 0.000158696633483913*std::sin(0.335679858922958*x_20 + 5.03431987762451) + 0.00215349559076159*std::sin(0.357039839029312*x_20 + 5.03447961807251) - 0.00379118444264581*std::sin(0.282239943742752*x_21 - 1.39167988300323) + 0.000170258658693446*std::sin(0.363999843597412*x_21 + 5.02055978775024) + 9.2368806749871e-5*std::sin(0.384639829397202*x_21 + 8.19575977325439) - 0.000255002300040118*std::sin(0.353439837694168*x_22 + 8.20743942260742) - 0.000125246660496602*std::sin(0.307599931955338*x_24 - 7.55647993087769) + 0.00413968725265966*std::sin(0.30991992354393*x_24 + 1.82943987846375) + 0.000463989648506368*std::sin(0.347839832305908*x_24 - 1.18343985080719) + 0.000214345324619435*std::sin(0.341839849948883*x_25 - 7.59144020080566) - 0.000129597632867749*std::sin(0.365119844675064*x_25 + 5.02320003509521) + 0.00542932663838638*std::sin(0.364959836006165*x_26 + 5.00607967376709) - 0.00541912666405829*std::sin(0.362719833850861*x_27 - 4.3744797706604) - 0.000350776155131119*std::sin(0.221599996089935*x_28 - 7.58168029785156) + 0.00468499078351362*std::sin(0.274799942970276*x_28 - 7.58152008056641) - 0.00302845276695989*std::sin(0.328959852457047*x_28 + 5.03695964813232) - 0.00384498581464744*std::sin(0.149280041456223*x_29 - 1.22135996818542) - 0.000233478613645676*std::sin(0.291919946670532*x_3 - 4.32119989395142) - 0.00392721777026449*std::sin(0.301119923591614*x_3 + 5.06943941116333) - 5.64461385586347e-5*std::sin(0.345439851284027*x_3 - 4.41095972061157) - 0.00100774105756224*std::sin(0.435919851064682*x_31 + 1.99383985996246) + 0.000164198799801715*std::sin(0.255519956350327*x_34 + 8.17208003997803) - 0.000109557213581668*std::sin(0.263919949531555*x_35 - 1.41455984115601) - 0.00438156969914906*std::sin(0.217360004782677*x_36 + 8.19919967651367) + 0.00382828801257465*std::sin(0.247679978609085*x_37 + 8.16775989532471) - 0.000583639944674263*std::sin(0.263599961996078*x_37 + 1.95351982116699) + 0.0046673436283628*std::sin(0.269439965486526*x_37 + 1.93767988681793) - 0.000552443129921164*std::sin(0.256319969892502*x_38 + 1.94175982475281) + 5.97782128816613e-5*std::sin(0.321599900722504*x_4 - 7.55352020263672) - 0.000297224331379367*std::sin(0.335679858922958*x_4 - 4.3918399810791) + 0.00234531433548643*std::sin(0.352239847183228*x_4 + 1.98887979984283) + 2.95439953154916e-5*std::sin(0.303679943084717*x_44 - 1.44399976730347) - 0.000309854484679286*std::sin(0.217840000987053*x_47 - 7.60080003738403) + 0.00568138384518378*std::sin(0.243039980530739*x_47 + 8.16695976257324) + 0.000195113404424796*std::sin(0.222399994730949*x_48 - 4.41351985931396) - 0.00505833875230506*std::sin(0.236959978938103*x_48 - 7.59352016448975) - 0.00616240779033542*std::sin(0.242639973759651*x_48 + 8.17303943634033) - 0.0037404048021573*std::sin(0.230879992246628*x_49 - 7.61863994598389) - 8.95094657343089e-5*std::sin(0.263919949531555*x_49 + 8.14167976379395) - 0.00094150039620955*std::sin(0.19336000084877*x_5 + 1.7973598241806) - 0.000195032118604675*std::sin(0.358879864215851*x_5 - 1.15943992137909) - 0.00208430425309432*std::sin(0.401039868593216*x_5 + 5.00216007232666) - 0.00140574155730779*std::sin(0.478239864110947*x_5 + 8.16103935241699) - 0.0119926396653186*std::sin(0.215920001268387*x_51 + 8.19279956817627) + 0.00418357663045862*std::sin(0.22511999309063*x_53 + 8.1846399307251) + 0.000567278168327127*std::sin(0.245599970221519*x_53 - 1.20199990272522) + 0.00017666492987613*std::sin(0.197839990258217*x_57 + 8.19095993041992) - 0.000506587662940014*std::sin(0.255759954452515*x_57 + 8.15783977508545) - 0.000117407830394981*std::sin(0.403199851512909*x_6 - 1.17351984977722) - 0.00026867305847234*std::sin(0.421999871730804*x_6 + 1.96639978885651) - 0.000186831762737658*std::sin(0.419279843568802*x_7 - 4.40727996826172) - 5.53433197514513e-5*std::sin(0.309999912977219*x_8 + 8.19192028045654) + 0.000189860831650515*std::sin(0.319999933242798*x_8 + 8.18048000335693) - 0.00675836143114195*std::sin(0.354479849338531*x_8 + 8.23911952972412) - 0.000156679145181308*std::sin(0.468639850616455*x_8 - 8.01272010803223) + 0.00263642849173188*std::sin(0.300959944725037*x_9 - 7.42592000961304) - 0.00180819069380747*std::sin(0.306479930877686*x_9 + 1.95599985122681) - 8.37728134270155e-5*std::sin(0.356319844722748*x_9 - 7.57816028594971) - 0.000176880414220884*std::sin(0.388399839401245*x_9 - 7.60120010375977) + 0.00163443686769972*std::sin(0.315759837627411*x_92 - 7.59328031539917) - 0.00515011631075859*std::sin(0.320479840040207*x_92 - 4.37967967987061) - 2.99134379855922e-5*std::sin(0.332799851894379*x_92 + 5.01823997497559) + 0.00822909259505005*std::sin(0.251279979944229*x_93 - 1.22199988365173) + 0.00547562406862136*std::sin(0.287999957799911*x_94 - 1.19415986537933) + 0.000428325335752478*std::sin(0.29215994477272*x_94 - 1.19487988948822) + 0.000421086440836863*std::sin(0.277599930763245*x_96 - 1.20943987369537) + 0.00371548038091124*std::sin(0.287279933691025*x_96 + 8.1637601852417) - 0.00584555159147038*std::sin(0.276479959487915*x_97 + 8.18136024475098) - 0.00438738097709654*std::sin(0.276639938354492*x_99 + 4.97024011611938) + 0.0685787714938078);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00023847673048436*x_1 - 0.00037361906885952*x_10 - 0.000242214922849324*x_100 - 0.000421524940658434*x_101 + 3.04040798905428e-5*x_102 - 0.000443094591846777*x_103 - 0.00129302911622298*x_104 - 0.000767236112252822*x_105 - 0.00117358654974259*x_106 + 0.000130921681708126*x_107 - 0.000362938614609168*x_108 - 0.000773594373866205*x_109 - 0.000455201908441932*x_11 + 0.000543283826445147*x_110 + 0.000312696016219483*x_111 - 0.000982527143330609*x_112 - 0.000119065028839506*x_113 - 0.000285272572606751*x_114 + 0.00100130976270464*x_115 - 0.0010661380895822*x_116 + 6.54916893905687e-6*x_117 - 0.000241610648074952*x_118 + 0.000365569252809413*x_119 - 0.00040024188915355*x_12 - 0.00109904033551939*x_120 + 0.000334039508608025*x_13 - 3.66635238105889e-5*x_14 - 3.22494587492556e-5*x_15 - 2.94889997529547e-6*x_16 + 5.53673161275299e-5*x_17 - 0.000330911934314356*x_18 - 0.000206848097656494*x_19 + 4.44650311660252e-5*x_2 - 0.000179051900715823*x_20 - 3.04485393776019e-5*x_21 - 0.00043698894159415*x_22 - 0.000262463463100569*x_23 - 0.000356795911400506*x_24 - 0.000371871995671581*x_25 + 8.51109955991369e-5*x_26 - 0.000684835674746111*x_27 - 0.00024744380394014*x_28 - 6.7467987060401e-5*x_29 - 6.40634088775882e-5*x_3 - 0.000411673352791404*x_30 - 1.67735168891247e-5*x_31 - 0.000226538762155315*x_32 - 0.000430697652316521*x_33 - 0.000640506488536003*x_34 - 0.00205078580994406*x_35 - 4.9734800525894e-5*x_36 - 0.00161871419277946*x_37 - 0.0004682385455374*x_38 - 0.00100929630503978*x_39 - 1.7171394904915e-5*x_4 + 4.42095017598977e-5*x_40 + 0.000198163654620867*x_41 - 0.00181444494642681*x_42 - 0.00131655111998569*x_43 - 0.000253707713104252*x_44 - 2.07735458871707e-5*x_45 - 5.15697585664043e-6*x_46 - 0.00171842712415337*x_47 + 0.000206898724047237*x_48 - 0.000783236911327884*x_49 - 0.00019485101343836*x_50 + 6.32039046928565e-6*x_51 - 0.00121174410574502*x_52 - 0.000436574180664614*x_53 - 0.000964200682554022*x_54 - 0.000679965203465361*x_55 - 0.000193162056954445*x_56 - 0.000433288131451847*x_57 - 0.00202039177540569*x_58 - 0.000214127561532779*x_59 - 3.09444032485577e-5*x_6 - 0.000483651595635022*x_60 + 0.000396216125965568*x_61 - 2.97003496178555e-5*x_62 - 8.78152109873923e-5*x_63 - 1.97132088607494e-5*x_64 - 3.58669506903133e-5*x_65 + 1.30672915822925e-6*x_66 + 0.000289905783948075*x_67 + 0.000509950017587198*x_68 + 2.54341311967059e-5*x_69 + 0.000724412299279266*x_7 + 1.23506400142907e-6*x_70 + 3.03194628579825e-5*x_71 + 5.50621344887582e-6*x_72 + 1.57838111649978e-5*x_73 - 0.000204259139059888*x_74 - 5.05340288877703e-6*x_75 - 0.000517069409801207*x_76 - 4.5016275368253e-5*x_77 - 2.25070492127207e-5*x_78 - 0.000233018476050404*x_79 - 3.23389403125325e-5*x_8 + 0.000212238290173349*x_80 - 1.15896982436965e-5*x_81 - 5.58092300499984e-5*x_82 + 0.000126203901508942*x_83 + 8.21481958740666e-5*x_84 - 7.79436280324953e-5*x_85 - 0.000155176268722981*x_86 - 0.000264764572464566*x_87 - 2.10038291830979e-5*x_88 - 0.000442044401784982*x_89 - 4.96299079810051e-6*x_9 - 8.29251859696202e-5*x_90 + 0.000255362283025634*x_91 + 4.28580246082473e-6*x_92 - 8.67254527597992e-5*x_93 - 4.62070658908793e-6*x_94 - 1.60777564707411e-5*x_95 - 0.000177351742487153*x_96 + 0.00012008720701223*x_97 + 0.000133049596968601*x_98 - 0.000639681001294718*x_99 + 9.44686569741652e-9*std::pow(-9.30727958679199*x_49 - 3.04655981063843, 2) + 8.17530254701076e-8*std::pow(-8.91152000427246*x_5 - 1.61951982975006, 2) - 0.000622827701828088*std::exp(0.411199867725372*x_6) + 0.00147972206682946*std::sin(0.336239844560623*x_1 - 7.45831966400146) - 0.000297591287807534*std::sin(0.292959928512573*x_10 - 1.3983998298645) + 8.48707726059691e-5*std::sin(0.306079924106598*x_10 + 1.79959988594055) - 0.0012435011751991*std::sin(0.27007994055748*x_100 + 1.78159987926483) - 0.000795041270658694*std::sin(0.264799952507019*x_107 - 1.23319983482361) + 0.00213851092273435*std::sin(0.275119960308075*x_107 + 4.97192001342773) + 0.00348644456242463*std::sin(0.267439961433411*x_108 + 8.1782398223877) - 0.00477083701059569*std::sin(0.245279967784882*x_109 - 1.21599984169006) + 0.000222135249487704*std::sin(0.356959849596024*x_11 - 1.3368798494339) + 0.00183088553422544*std::sin(0.248719975352287*x_110 - 4.4334397315979) - 0.00313684889341553*std::sin(0.222079992294312*x_111 - 1.22215986251831) - 0.00104043365888501*std::sin(0.227119997143745*x_111 - 1.20175993442535) - 0.00150272791522853*std::sin(0.287679940462112*x_113 + 1.95039987564087) + 0.000419361794536342*std::sin(0.303199917078018*x_116 + 1.75935995578766) - 0.0018303829646813*std::sin(0.329039841890335*x_12 + 1.85455989837646) + 0.0016760891081441*std::sin(0.329919844865799*x_12 + 1.85023999214172) + 0.000234402465982837*std::sin(0.374719828367233*x_12 - 4.57239961624146) - 0.000459187589325103*std::sin(0.309839934110641*x_120 - 7.65032005310059) - 0.0011013060229324*std::sin(0.397519826889038*x_13 - 7.78760004043579) + 0.00170301990382141*std::sin(0.288319945335388*x_14 + 8.1715202331543) + 0.000154818289811021*std::sin(0.334799855947495*x_14 - 7.75631999969482) + 0.000269658453749937*std::sin(0.359839856624603*x_15 - 1.37655985355377) - 0.00475670389044375*std::sin(0.36575984954834*x_15 - 7.55879974365234) + 0.00351395790543158*std::sin(0.33519983291626*x_16 - 4.35847997665405) + 0.000853458147824312*std::sin(0.341119825839996*x_16 - 7.55671977996826) - 0.00164577879288432*std::sin(0.356159836053848*x_16 - 7.57928037643433) - 0.00036702151188415*std::sin(0.32847985625267*x_17 - 7.58584022521973) - 0.00516685172131531*std::sin(0.378079831600189*x_17 - 1.20383989810944) + 4.22029557704369e-5*std::sin(0.39591982960701*x_17 + 1.81023991107941) - 0.00365594483517219*std::sin(0.353919863700867*x_18 - 7.57656002044678) + 0.000688207117736524*std::sin(0.372879832983017*x_2 - 1.20743989944458) + 0.000984349411810739*std::sin(0.335679858922958*x_20 + 5.03431987762451) - 0.00202296796243979*std::sin(0.357039839029312*x_20 + 5.03447961807251) - 0.00292656332229854*std::sin(0.282239943742752*x_21 - 1.39167988300323) - 0.0010560653169594*std::sin(0.363999843597412*x_21 + 5.02055978775024) + 0.000470990330905588*std::sin(0.384639829397202*x_21 + 8.19575977325439) + 0.00158170566409854*std::sin(0.353439837694168*x_22 + 8.20743942260742) - 0.000638635142617523*std::sin(0.307599931955338*x_24 - 7.55647993087769) + 0.0031955862508672*std::sin(0.30991992354393*x_24 + 1.82943987846375) - 0.00287799386519319*std::sin(0.347839832305908*x_24 - 1.18343985080719) - 0.00132952218066371*std::sin(0.341839849948883*x_25 - 7.59144020080566) - 0.000660820834832831*std::sin(0.365119844675064*x_25 + 5.02320003509521) - 0.00510024440922688*std::sin(0.364959836006165*x_26 + 5.00607967376709) + 0.00509066267552287*std::sin(0.362719833850861*x_27 - 4.3744797706604) + 0.00217576324336805*std::sin(0.221599996089935*x_28 - 7.58168029785156) - 0.00440102422314315*std::sin(0.274799942970276*x_28 - 7.58152008056641) - 9.41852386414256e-5*std::sin(0.328959852457047*x_28 + 5.03695964813232) + 0.00361193361734091*std::sin(0.149280041456223*x_29 - 1.22135996818542) + 0.00144820044992199*std::sin(0.291919946670532*x_3 - 4.32119989395142) - 0.00303157276017785*std::sin(0.301119923591614*x_3 + 5.06943941116333) - 0.000287819951491483*std::sin(0.345439851284027*x_3 - 4.41095972061157) + 0.000946659878306333*std::sin(0.435919851064682*x_31 + 1.99383985996246) + 0.000837252853794371*std::sin(0.255519956350327*x_34 + 8.17208003997803) + 0.000679551773602498*std::sin(0.263919949531555*x_35 - 1.41455984115601) - 0.00338230475715799*std::sin(0.217360004782677*x_36 + 8.19919967651367) + 0.000119060209221757*std::sin(0.247679978609085*x_37 + 8.16775989532471) + 0.0036201501168429*std::sin(0.263599961996078*x_37 + 1.95351982116699) + 0.00360290481298708*std::sin(0.269439965486526*x_37 + 1.93767988681793) + 0.0034266452794785*std::sin(0.256319969892502*x_38 + 1.94175982475281) + 0.00030481026286634*std::sin(0.321599900722504*x_4 - 7.55352020263672) + 0.00184359673766348*std::sin(0.335679858922958*x_4 - 4.3918399810791) - 0.00220316019354463*std::sin(0.352239847183228*x_4 + 1.98887979984283) + 0.000150645403134819*std::sin(0.303679943084717*x_44 - 1.44399976730347) + 0.00192193793305573*std::sin(0.217840000987053*x_47 - 7.60080003738403) + 0.00438568205603065*std::sin(0.243039980530739*x_47 + 8.16695976257324) - 0.00121023213073646*std::sin(0.222399994730949*x_48 - 4.41351985931396) - 0.000157314932467406*std::sin(0.236959978938103*x_48 - 7.59352016448975) + 0.00578889206219788*std::sin(0.242639973759651*x_48 + 8.17303943634033) - 0.00288736453478994*std::sin(0.230879992246628*x_49 - 7.61863994598389) - 0.000456410495802398*std::sin(0.263919949531555*x_49 + 8.14167976379395) - 2.92807734911481e-5*std::sin(0.19336000084877*x_5 + 1.7973598241806) + 0.00120972793825633*std::sin(0.358879864215851*x_5 - 1.15943992137909) - 0.00160895584794068*std::sin(0.401039868593216*x_5 + 5.00216007232666) + 0.00132053678034148*std::sin(0.478239864110947*x_5 + 8.16103935241699) + 0.0112657420484637*std::sin(0.215920001268387*x_51 + 8.19279956817627) + 0.0032294661755314*std::sin(0.22511999309063*x_53 + 8.1846399307251) - 0.00351866274077254*std::sin(0.245599970221519*x_53 - 1.20199990272522) + 0.000900817891986972*std::sin(0.197839990258217*x_57 + 8.19095993041992) + 0.00314221705337012*std::sin(0.255759954452515*x_57 + 8.15783977508545) - 0.000598664796421833*std::sin(0.403199851512909*x_6 - 1.17351984977722) + 0.00166650143276952*std::sin(0.421999871730804*x_6 + 1.96639978885651) + 0.00115886349773777*std::sin(0.419279843568802*x_7 - 4.40727996826172) - 0.000282196657078567*std::sin(0.309999912977219*x_8 + 8.19192028045654) - 0.00117765193790344*std::sin(0.319999933242798*x_8 + 8.18048000335693) + 0.00634872377377552*std::sin(0.354479849338531*x_8 + 8.23911952972412) - 4.87273991525703e-6*std::sin(0.468639850616455*x_8 - 8.01272010803223) + 0.00203516210896369*std::sin(0.300959944725037*x_9 - 7.42592000961304) + 0.0016985926784557*std::sin(0.306479930877686*x_9 + 1.95599985122681) - 0.000427159194810506*std::sin(0.356319844722748*x_9 - 7.57816028594971) + 0.00109713815521372*std::sin(0.388399839401245*x_9 - 7.60120010375977) + 0.0012616856452081*std::sin(0.315759837627411*x_92 - 7.59328031539917) + 0.004837957571958*std::sin(0.320479840040207*x_92 - 4.37967967987061) - 0.000152529198450185*std::sin(0.332799851894379*x_92 + 5.01823997497559) - 0.0077303110120831*std::sin(0.251279979944229*x_93 - 1.22199988365173) - 0.00514373566061854*std::sin(0.287999957799911*x_94 - 1.19415986537933) - 0.00265677842721426*std::sin(0.29215994477272*x_94 - 1.19487988948822) - 0.00261187765146424*std::sin(0.277599930763245*x_96 - 1.20943987369537) + 0.00286812440069682*std::sin(0.287279933691025*x_96 + 8.1637601852417) + 0.0054912411444276*std::sin(0.276479959487915*x_97 + 8.18136024475098) - 0.00338679070954413*std::sin(0.276639938354492*x_99 + 4.97024011611938) - 0.108182842317679);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000115366731313906*x_1 - 9.01847086752433e-6*x_10 - 1.07107390018506e-5*x_100 - 6.26414911272172e-5*x_101 + 3.18074478919514e-6*x_102 - 3.91439558700998e-5*x_103 - 0.000445493566213475*x_104 + 0.000281529465499044*x_105 + 0.00040347997670786*x_106 - 4.87334903220211e-5*x_107 - 7.49636907042e-5*x_108 + 9.65703738467099e-5*x_109 - 0.000100762307029284*x_11 + 0.000382131728171564*x_110 - 4.60262631080355e-5*x_111 + 0.00013877506062119*x_112 - 5.53379397826914e-5*x_113 + 0.000387910484592839*x_114 + 0.00044207466733918*x_115 - 0.000881156987630405*x_116 + 0.00048851721303539*x_117 + 3.8797857815411e-5*x_118 + 0.000244686801038447*x_119 + 3.13788393868763e-5*x_12 - 9.23786118031777e-5*x_120 - 3.38492452091562e-5*x_13 - 0.000146980082025482*x_14 - 1.84861703972865e-5*x_15 - 3.99154624594168e-6*x_16 + 6.4992400998184e-5*x_17 - 0.000371796713411271*x_18 - 9.61359218138214e-5*x_19 - 1.98576252844844e-5*x_2 - 0.000209154420798664*x_20 - 5.21353101322865e-8*x_21 + 4.7494901416657e-5*x_22 + 4.25993196127845e-5*x_23 + 3.22783669251371e-5*x_24 - 8.32813429088926e-6*x_25 - 0.000109741809272172*x_26 - 6.8129964249129e-5*x_27 - 0.000282873613782347*x_28 - 0.000152345476132479*x_29 + 2.6050575399616e-6*x_3 - 1.16907791134881e-5*x_30 - 1.91502940162273e-5*x_31 + 2.87395366831663e-5*x_32 + 1.10488286948197e-5*x_33 - 0.000599657605387*x_34 - 0.000592237205483766*x_35 - 0.000104451497606035*x_36 + 0.000136877092815029*x_37 + 0.000737793969894103*x_38 - 0.000922949482144698*x_39 - 3.67833307532537e-5*x_4 + 0.00040474910131383*x_40 + 0.00015500679903613*x_41 - 8.78850078049966e-5*x_42 + 0.000615454577910902*x_43 + 0.000429339779563712*x_44 + 0.000683628042879103*x_45 + 0.000434273926556493*x_46 + 0.000113176333188801*x_47 + 0.000259150335907506*x_48 + 8.95061863586435e-5*x_49 + 0.000696830803990856*x_50 - 0.000505693047732118*x_51 - 0.000850388887092924*x_52 + 0.000103493719853047*x_53 + 9.44049984575107e-5*x_54 - 0.000213043796317258*x_55 - 0.000171032030850879*x_56 - 2.00290431450579e-5*x_57 - 0.000795627473242951*x_58 + 0.000271441959312119*x_59 - 3.65582581926517e-5*x_6 + 0.000703684573130582*x_60 - 3.41322890014569e-5*x_61 + 4.0606844336588e-6*x_62 + 3.09808693726194e-6*x_63 - 1.21890766064605e-6*x_64 + 8.1981222101885e-6*x_65 + 7.58234526866849e-6*x_66 - 3.29639159731151e-5*x_67 - 4.47540265791938e-5*x_68 - 1.29464773121609e-5*x_69 + 5.12454943350527e-5*x_7 - 2.41233703536705e-6*x_70 + 1.6192806828798e-5*x_71 + 2.67041274741851e-6*x_72 - 1.13016266414738e-6*x_73 + 2.03351506133208e-5*x_74 + 9.42901190200398e-6*x_75 + 5.56415066008327e-5*x_76 + 5.88443816804595e-6*x_77 + 1.74828576571958e-6*x_78 + 1.74200729510404e-5*x_79 - 3.69094267955728e-5*x_8 - 1.87944941476422e-5*x_80 + 4.13100146962622e-8*x_81 - 0.000101395935860884*x_82 - 6.4689778632109e-6*x_83 - 3.66221511813104e-6*x_84 + 2.46246052142642e-6*x_85 + 4.80466392442231e-5*x_86 - 2.08372790177362e-5*x_87 + 4.53943506481219e-6*x_88 + 8.04367819057e-5*x_89 - 3.34235259626133e-5*x_9 - 7.34379316423e-5*x_90 - 6.47997371659622e-5*x_91 - 2.4146316461726e-6*x_92 + 0.000365910937795066*x_93 - 5.17151268007499e-6*x_94 + 2.30346892796357e-5*x_95 - 8.92900265401671e-6*x_96 - 0.000326984733589701*x_97 - 0.000253427884856764*x_98 + 1.73812280566522e-5*x_99 + 6.36204203771179e-8*std::pow(-9.30727958679199*x_49 - 3.04655981063843, 2) + 8.11770661344252e-8*std::pow(-8.91152000427246*x_5 - 1.61951982975006, 2) + 5.3346778286646e-5*std::exp(0.411199867725372*x_6) - 0.000126741962172385*std::sin(0.336239844560623*x_1 - 7.45831966400146) - 0.000295494723436431*std::sin(0.292959928512573*x_10 - 1.3983998298645) + 0.00057156674010928*std::sin(0.306079924106598*x_10 + 1.79959988594055) + 0.000274075002044597*std::sin(0.27007994055748*x_100 + 1.78159987926483) - 0.000789440114744824*std::sin(0.264799952507019*x_107 - 1.23319983482361) - 0.000471340435546404*std::sin(0.275119960308075*x_107 + 4.97192001342773) + 0.00397918636510688*std::sin(0.267439961433411*x_108 + 8.1782398223877) - 0.00544510295310913*std::sin(0.245279967784882*x_109 - 1.21599984169006) + 0.000220570281463697*std::sin(0.356959849596024*x_11 - 1.3368798494339) - 0.00040353798335246*std::sin(0.248719975352287*x_110 - 4.4334397315979) + 0.000691380019595716*std::sin(0.222079992294312*x_111 - 1.22215986251831) - 0.00103310368576723*std::sin(0.227119997143745*x_111 - 1.20175993442535) + 0.000331210106313561*std::sin(0.287679940462112*x_113 + 1.95039987564087) + 0.000416407343135886*std::sin(0.303199917078018*x_116 + 1.75935995578766) - 0.00208907235023364*std::sin(0.329039841890335*x_12 + 1.85455989837646) - 0.000369419936951782*std::sin(0.329919844865799*x_12 + 1.85023999214172) + 0.000232751074027451*std::sin(0.374719828367233*x_12 - 4.57239961624146) - 0.000455952560683894*std::sin(0.309839934110641*x_120 - 7.65032005310059) - 0.00125695442213343*std::sin(0.397519826889038*x_13 - 7.78760004043579) - 0.000375355643348794*std::sin(0.288319945335388*x_14 + 8.1715202331543) + 0.000153727577402051*std::sin(0.334799855947495*x_14 - 7.75631999969482) + 0.000267758679362508*std::sin(0.359839856624603*x_15 - 1.37655985355377) + 0.000407423798064734*std::sin(0.36575984954834*x_15 - 7.55879974365234) + 0.00401058818934114*std::sin(0.33519983291626*x_16 - 4.35847997665405) - 0.000188107215558098*std::sin(0.341119825839996*x_16 - 7.55671977996826) + 0.000140965143514277*std::sin(0.356159836053848*x_16 - 7.57928037643433) - 0.000364435803710656*std::sin(0.32847985625267*x_17 - 7.58584022521973) + 0.000442554003953189*std::sin(0.378079831600189*x_17 - 1.20383989810944) + 0.000284218054249081*std::sin(0.39591982960701*x_17 + 1.81023991107941) + 0.000313140982614759*std::sin(0.353919863700867*x_18 - 7.57656002044678) - 0.000151684912698649*std::sin(0.372879832983017*x_2 - 1.20743989944458) - 0.00021695642307007*std::sin(0.335679858922958*x_20 + 5.03431987762451) + 0.000173272356153245*std::sin(0.357039839029312*x_20 + 5.03447961807251) - 0.00334017669296125*std::sin(0.282239943742752*x_21 - 1.39167988300323) + 0.000232763032056268*std::sin(0.363999843597412*x_21 + 5.02055978775024) + 0.000467672150611448*std::sin(0.384639829397202*x_21 + 8.19575977325439) - 0.000348617268538043*std::sin(0.353439837694168*x_22 + 8.20743942260742) - 0.000634135885613024*std::sin(0.307599931955338*x_24 - 7.55647993087769) + 0.00364722083208189*std::sin(0.30991992354393*x_24 + 1.82943987846375) + 0.00063432684280404*std::sin(0.347839832305908*x_24 - 1.18343985080719) + 0.000293034539613845*std::sin(0.341839849948883*x_25 - 7.59144020080566) - 0.000656165277110694*std::sin(0.365119844675064*x_25 + 5.02320003509521) + 0.000436848918100678*std::sin(0.364959836006165*x_26 + 5.00607967376709) - 0.000436028218215286*std::sin(0.362719833850861*x_27 - 4.3744797706604) - 0.000479551066993706*std::sin(0.221599996089935*x_28 - 7.58168029785156) + 0.000376958929053833*std::sin(0.274799942970276*x_28 - 7.58152008056641) - 0.00063429550790855*std::sin(0.328959852457047*x_28 + 5.03695964813232) - 0.00030937130976161*std::sin(0.149280041456223*x_29 - 1.22135996818542) - 0.000319191930968463*std::sin(0.291919946670532*x_3 - 4.32119989395142) - 0.00346002719278572*std::sin(0.301119923591614*x_3 + 5.06943941116333) - 0.00028579222729285*std::sin(0.345439851284027*x_3 - 4.41095972061157) - 8.10838286297203e-5*std::sin(0.435919851064682*x_31 + 1.99383985996246) + 0.000831354312490283*std::sin(0.255519956350327*x_34 + 8.17208003997803) - 0.000149777223740615*std::sin(0.263919949531555*x_35 - 1.41455984115601) - 0.00386032840371893*std::sin(0.217360004782677*x_36 + 8.19919967651367) + 0.000801817322643558*std::sin(0.247679978609085*x_37 + 8.16775989532471) - 0.000797902463193571*std::sin(0.263599961996078*x_37 + 1.95351982116699) + 0.00411210602948633*std::sin(0.269439965486526*x_37 + 1.93767988681793) - 0.000755252854368075*std::sin(0.256319969892502*x_38 + 1.94175982475281) + 0.000302662839997276*std::sin(0.321599900722504*x_4 - 7.55352020263672) - 0.000406339607651458*std::sin(0.335679858922958*x_4 - 4.3918399810791) + 0.000188706279489524*std::sin(0.352239847183228*x_4 + 1.98887979984283) + 0.000149584089185712*std::sin(0.303679943084717*x_44 - 1.44399976730347) - 0.000423606469730513*std::sin(0.217840000987053*x_47 - 7.60080003738403) + 0.00500551376239712*std::sin(0.243039980530739*x_47 + 8.16695976257324) + 0.000266742308187141*std::sin(0.222399994730949*x_48 - 4.41351985931396) - 0.00105944579458892*std::sin(0.236959978938103*x_48 - 7.59352016448975) - 0.000495833342770349*std::sin(0.242639973759651*x_48 + 8.17303943634033) - 0.00329543791166411*std::sin(0.230879992246628*x_49 - 7.61863994598389) - 0.000453195032099994*std::sin(0.263919949531555*x_49 + 8.14167976379395) - 0.000197192929183217*std::sin(0.19336000084877*x_5 + 1.7973598241806) - 0.0002666311811872*std::sin(0.358879864215851*x_5 - 1.15943992137909) - 0.00183635077442105*std::sin(0.401039868593216*x_5 + 5.00216007232666) - 0.00011310733712304*std::sin(0.478239864110947*x_5 + 8.16103935241699) - 0.000964939487325217*std::sin(0.215920001268387*x_51 + 8.19279956817627) + 0.00368588903169351*std::sin(0.22511999309063*x_53 + 8.1846399307251) + 0.000775534046211953*std::sin(0.245599970221519*x_53 - 1.20199990272522) + 0.00089447152778019*std::sin(0.197839990258217*x_57 + 8.19095993041992) - 0.000692563193749367*std::sin(0.255759954452515*x_57 + 8.15783977508545) - 0.000594447135039141*std::sin(0.403199851512909*x_6 - 1.17351984977722) - 0.000367306756682797*std::sin(0.421999871730804*x_6 + 1.96639978885651) - 0.000255420358135998*std::sin(0.419279843568802*x_7 - 4.40727996826172) - 0.000280208549626786*std::sin(0.309999912977219*x_8 + 8.19192028045654) + 0.00025956144129661*std::sin(0.319999933242798*x_8 + 8.18048000335693) - 0.000543784354113787*std::sin(0.354479849338531*x_8 + 8.23911952972412) - 3.28157265834522e-5*std::sin(0.468639850616455*x_8 - 8.01272010803223) + 0.00232279308326032*std::sin(0.300959944725037*x_9 - 7.42592000961304) - 0.000145488787269626*std::sin(0.306479930877686*x_9 + 1.95599985122681) - 0.000424149809840849*std::sin(0.356319844722748*x_9 - 7.57816028594971) - 0.00024181572814779*std::sin(0.388399839401245*x_9 - 7.60120010375977) + 0.00144000061569076*std::sin(0.315759837627411*x_92 - 7.59328031539917) - 0.000414383382746006*std::sin(0.320479840040207*x_92 - 4.37967967987061) - 0.000151454612949448*std::sin(0.332799851894379*x_92 + 5.01823997497559) + 0.000662120818386851*std::sin(0.251279979944229*x_93 - 1.22199988365173) + 0.000440574054504519*std::sin(0.287999957799911*x_94 - 1.19415986537933) + 0.000585569653968522*std::sin(0.29215994477272*x_94 - 1.19487988948822) + 0.000575673257848493*std::sin(0.277599930763245*x_96 - 1.20943987369537) + 0.00327347855511179*std::sin(0.287279933691025*x_96 + 8.1637601852417) - 0.000470338783889135*std::sin(0.276479959487915*x_97 + 8.18136024475098) - 0.00386544835909176*std::sin(0.276639938354492*x_99 + 4.97024011611938) - 0.0116732156355099);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-7.21032458434883e-5*x_1 + 0.000102550402610153*x_10 + 3.7589157067798e-6*x_100 - 7.11866391334127e-5*x_101 + 0.000143076506820395*x_102 - 4.16991407903674e-5*x_103 - 0.000338186585430389*x_104 - 0.000140388950436121*x_105 - 0.000335234656039334*x_106 - 7.08302346239538e-6*x_107 - 1.18054777568773e-5*x_108 - 0.000265241771271819*x_109 + 1.80753090760119e-5*x_11 + 5.62007713803467e-6*x_110 - 9.34567441281373e-6*x_111 - 0.000181651677875377*x_112 + 8.28962724899375e-8*x_113 - 0.000237933141421703*x_114 + 0.000127818352602012*x_115 + 4.51927053631438e-5*x_116 - 8.12592501190994e-5*x_117 + 2.42790093905899e-5*x_118 - 5.27511967326254e-5*x_119 + 1.20872740130799e-5*x_12 - 5.51317905268889e-6*x_120 - 1.85335632896114e-5*x_13 - 2.36040256904221e-5*x_14 - 9.56282696818484e-6*x_15 - 1.24271084870197e-6*x_16 - 3.89823466002252e-6*x_17 + 5.76322637380158e-6*x_18 - 0.000165721676059866*x_19 - 3.31600723047644e-6*x_2 + 1.11476450972334e-5*x_20 + 4.1995713789803e-7*x_21 + 2.92829368223906e-5*x_22 + 2.30156449893445e-5*x_23 + 1.16570463157863e-5*x_24 + 1.67061412619145e-5*x_25 + 0.000119517762642664*x_26 - 0.00038953613448798*x_27 + 1.42851634349526e-5*x_28 + 5.7587927468586e-5*x_29 + 1.43958790396575e-6*x_3 - 3.31600528158554e-5*x_30 + 3.88465534924718e-6*x_31 + 6.59672222638743e-5*x_32 - 5.15485434744099e-6*x_33 + 0.000281315694917444*x_34 + 8.59284916422241e-5*x_35 - 9.39304758502691e-5*x_36 + 5.06498347181401e-5*x_37 + 3.20618120612897e-5*x_38 + 0.00012615497899334*x_39 - 3.4527585287819e-6*x_4 - 4.59993703824357e-5*x_40 - 3.0506086733869e-5*x_41 + 0.00031717690920009*x_42 + 0.000206720423391258*x_43 - 0.000141178120691251*x_44 - 0.000323547001575386*x_45 + 1.00719536224802e-5*x_46 + 5.58376243041738e-5*x_47 - 7.45867174603614e-5*x_48 - 9.5782808911798e-5*x_49 + 0.00019813036537982*x_50 + 0.000232246758180597*x_51 + 1.1592220300394e-5*x_52 + 2.68080869261012e-5*x_53 - 0.000183984502334971*x_54 - 6.60164290785626e-5*x_55 + 0.000260321006135354*x_56 + 8.39372014896272e-6*x_57 + 4.74824658728945e-5*x_58 + 0.000123862438126845*x_59 + 1.31332102363627e-6*x_6 - 0.000300122746082669*x_60 - 1.21571667511607e-5*x_61 + 1.58516548159839e-6*x_62 + 8.55267137153435e-6*x_63 + 2.38410705025962e-5*x_64 - 0.000136495200750783*x_65 + 6.49465553834619e-7*x_66 - 1.25127602163383e-5*x_67 - 9.61093864355656e-6*x_68 + 3.88523024005856e-5*x_69 - 2.40362752507113e-5*x_7 - 7.76024441836682e-6*x_70 - 3.66977715695162e-6*x_71 + 1.215214477436e-7*x_72 + 1.17144996974302e-6*x_73 + 9.86095247751661e-6*x_74 + 4.15128611340679e-6*x_75 + 1.91932224241805e-5*x_76 + 8.06286372466618e-6*x_77 + 5.14448673897898e-7*x_78 + 7.19518069648705e-6*x_79 + 1.70110409283846e-6*x_8 - 9.75429637873789e-6*x_80 + 1.44013101454114e-6*x_81 + 9.74788822105177e-6*x_82 + 7.75350774975365e-5*x_83 + 7.38605868528559e-6*x_84 + 6.57085463496621e-5*x_85 - 8.59761711694539e-5*x_86 - 6.38201605576999e-5*x_87 + 7.49121703203222e-7*x_88 + 2.05087252482569e-6*x_89 - 6.77521394827717e-6*x_9 + 8.10100380343803e-6*x_90 + 1.98053480065407e-5*x_91 + 2.82876460998669e-6*x_92 - 0.000342892274857952*x_93 + 2.27957068566136e-7*x_94 - 0.000118414723314983*x_95 - 3.9927667285512e-6*x_96 + 0.000251389386116513*x_97 + 0.000167863356835283*x_98 + 0.000204649559978923*x_99 + 1.28963640765028e-8*std::pow(-9.30727958679199*x_49 - 3.04655981063843, 2) + 2.9281407911404e-8*std::pow(-8.91152000427246*x_5 - 1.61951982975006, 2) + 1.97345235172652e-5*std::exp(0.411199867725372*x_6) - 4.68855348616502e-5*std::sin(0.336239844560623*x_1 - 7.45831966400146) - 0.000106588005019564*std::sin(0.292959928512573*x_10 - 1.3983998298645) + 0.000115861113943854*std::sin(0.306079924106598*x_10 + 1.79959988594055) - 0.000861959241025872*std::sin(0.27007994055748*x_100 + 1.78159987926483) - 0.000284759219841598*std::sin(0.264799952507019*x_107 - 1.23319983482361) + 0.00148235424995919*std::sin(0.275119960308075*x_107 + 4.97192001342773) - 0.00018339515943559*std::sin(0.267439961433411*x_108 + 8.1782398223877) + 0.000250957214013732*std::sin(0.245279967784882*x_109 - 1.21599984169006) + 7.95619833559462e-5*std::sin(0.356959849596024*x_11 - 1.3368798494339) + 0.00126911718055556*std::sin(0.248719975352287*x_110 - 4.4334397315979) - 0.00217437341058272*std::sin(0.222079992294312*x_111 - 1.22215986251831) - 0.000372651191749543*std::sin(0.227119997143745*x_111 - 1.20175993442535) - 0.00104164775965843*std::sin(0.287679940462112*x_113 + 1.95039987564087) + 0.000150202438352167*std::sin(0.303199917078018*x_116 + 1.75935995578766) + 9.62824360535551e-5*std::sin(0.329039841890335*x_12 + 1.85455989837646) + 0.0011618167512518*std::sin(0.329919844865799*x_12 + 1.85023999214172) + 8.39557213010064e-5*std::sin(0.374719828367233*x_12 - 4.57239961624146) - 0.00016446680760211*std::sin(0.309839934110641*x_120 - 7.65032005310059) + 5.79312792865981e-5*std::sin(0.397519826889038*x_13 - 7.78760004043579) + 0.00118048440405761*std::sin(0.288319945335388*x_14 + 8.1715202331543) + 5.54511282002648e-5*std::sin(0.334799855947495*x_14 - 7.75631999969482) + 9.65833268628996e-5*std::sin(0.359839856624603*x_15 - 1.37655985355377) + 0.00015071790242326*std::sin(0.36575984954834*x_15 - 7.55879974365234) - 0.000184842425794489*std::sin(0.33519983291626*x_16 - 4.35847997665405) + 0.00059159263538951*std::sin(0.341119825839996*x_16 - 7.55671977996826) + 5.21471029581094e-5*std::sin(0.356159836053848*x_16 - 7.57928037643433) - 0.000131455766192647*std::sin(0.32847985625267*x_17 - 7.58584022521973) + 0.000163713586446518*std::sin(0.378079831600189*x_17 - 1.20383989810944) + 5.76132550364237e-5*std::sin(0.39591982960701*x_17 + 1.81023991107941) + 0.000115839949179788*std::sin(0.353919863700867*x_18 - 7.57656002044678) + 0.000477045375351411*std::sin(0.372879832983017*x_2 - 1.20743989944458) + 0.000682322694043932*std::sin(0.335679858922958*x_20 + 5.03431987762451) + 6.40984797436986e-5*std::sin(0.357039839029312*x_20 + 5.03447961807251) + 0.000153944093325274*std::sin(0.282239943742752*x_21 - 1.39167988300323) - 0.000732034096336356*std::sin(0.363999843597412*x_21 + 5.02055978775024) + 0.000168694184982993*std::sin(0.384639829397202*x_21 + 8.19575977325439) + 0.00109639286310638*std::sin(0.353439837694168*x_22 + 8.20743942260742) - 0.000228739377044571*std::sin(0.307599931955338*x_24 - 7.55647993087769) - 0.000168095330206656*std::sin(0.30991992354393*x_24 + 1.82943987846375) - 0.00199494255188125*std::sin(0.347839832305908*x_24 - 1.18343985080719) - 0.000921586527321509*std::sin(0.341839849948883*x_25 - 7.59144020080566) - 0.000236685606554949*std::sin(0.365119844675064*x_25 + 5.02320003509521) + 0.000161603109402911*std::sin(0.364959836006165*x_26 + 5.00607967376709) - 0.000161299508666202*std::sin(0.362719833850861*x_27 - 4.3744797706604) + 0.00150817648693032*std::sin(0.221599996089935*x_28 - 7.58168029785156) + 0.00013944806208322*std::sin(0.274799942970276*x_28 - 7.58152008056641) - 0.000128576732967031*std::sin(0.328959852457047*x_28 + 5.03695964813232) - 0.000114445437646718*std::sin(0.149280041456223*x_29 - 1.22135996818542) + 0.00100385088937951*std::sin(0.291919946670532*x_3 - 4.32119989395142) + 0.000159467835997013*std::sin(0.301119923591614*x_3 + 5.06943941116333) - 0.000103088214242837*std::sin(0.345439851284027*x_3 - 4.41095972061157) - 2.99952644631151e-5*std::sin(0.435919851064682*x_31 + 1.99383985996246) + 0.00029987810476695*std::sin(0.255519956350327*x_34 + 8.17208003997803) + 0.000471045739798684*std::sin(0.263919949531555*x_35 - 1.41455984115601) + 0.000177917161478501*std::sin(0.217360004782677*x_36 + 8.19919967651367) + 0.000162534734199543*std::sin(0.247679978609085*x_37 + 8.16775989532471) + 0.00250938391482742*std::sin(0.263599961996078*x_37 + 1.95351982116699) - 0.000189521241705763*std::sin(0.269439965486526*x_37 + 1.93767988681793) + 0.00237525192840389*std::sin(0.256319969892502*x_38 + 1.94175982475281) + 0.000109173618850779*std::sin(0.321599900722504*x_4 - 7.55352020263672) + 0.00127792822109698*std::sin(0.335679858922958*x_4 - 4.3918399810791) + 6.98079364874008e-5*std::sin(0.352239847183228*x_4 + 1.98887979984283) + 5.3956529116851e-5*std::sin(0.303679943084717*x_44 - 1.44399976730347) + 0.00133223208398681*std::sin(0.217840000987053*x_47 - 7.60080003738403) - 0.000230697160244014*std::sin(0.243039980530739*x_47 + 8.16695976257324) - 0.000838898096503762*std::sin(0.222399994730949*x_48 - 4.41351985931396) - 0.000214758069898776*std::sin(0.236959978938103*x_48 - 7.59352016448975) - 0.000183423162144266*std::sin(0.242639973759651*x_48 + 8.17303943634033) + 0.000151882145184093*std::sin(0.230879992246628*x_49 - 7.61863994598389) - 0.000163472138502357*std::sin(0.263919949531555*x_49 + 8.14167976379395) - 3.99725715891915e-5*std::sin(0.19336000084877*x_5 + 1.7973598241806) + 0.000838548604781381*std::sin(0.358879864215851*x_5 - 1.15943992137909) + 8.46348504829508e-5*std::sin(0.401039868593216*x_5 + 5.00216007232666) - 4.18416908409376e-5*std::sin(0.478239864110947*x_5 + 8.16103935241699) - 0.000356959156990444*std::sin(0.215920001268387*x_51 + 8.19279956817627) - 0.000169877493689886*std::sin(0.22511999309063*x_53 + 8.1846399307251) - 0.00243903578537165*std::sin(0.245599970221519*x_53 - 1.20199990272522) + 0.000322645137565046*std::sin(0.197839990258217*x_57 + 8.19095993041992) + 0.00217809446462951*std::sin(0.255759954452515*x_57 + 8.15783977508545) - 0.000214423233946674*std::sin(0.403199851512909*x_6 - 1.17351984977722) + 0.00115517085050486*std::sin(0.421999871730804*x_6 + 1.96639978885651) + 0.000803290837905883*std::sin(0.419279843568802*x_7 - 4.40727996826172) - 0.000101074123919407*std::sin(0.309999912977219*x_8 + 8.19192028045654) - 0.000816314444114106*std::sin(0.319999933242798*x_8 + 8.18048000335693) - 0.000201161634671117*std::sin(0.354479849338531*x_8 + 8.23911952972412) - 6.65200819086986e-6*std::sin(0.468639850616455*x_8 - 8.01272010803223) - 0.000107054299234605*std::sin(0.300959944725037*x_9 - 7.42592000961304) - 5.38205302378969e-5*std::sin(0.306479930877686*x_9 + 1.95599985122681) - 0.000152995226224706*std::sin(0.356319844722748*x_9 - 7.57816028594971) + 0.000760504606211666*std::sin(0.388399839401245*x_9 - 7.60120010375977) - 6.63676234965338e-5*std::sin(0.315759837627411*x_92 - 7.59328031539917) - 0.000153292455038696*std::sin(0.320479840040207*x_92 - 4.37967967987061) - 5.46312463977545e-5*std::sin(0.332799851894379*x_92 + 5.01823997497559) + 0.000244937731600506*std::sin(0.251279979944229*x_93 - 1.22199988365173) + 0.000162981145609176*std::sin(0.287999957799911*x_94 - 1.19415986537933) - 0.00184160237430322*std::sin(0.29215994477272*x_94 - 1.19487988948822) - 0.00181047844827978*std::sin(0.277599930763245*x_96 - 1.20943987369537) - 0.000150870069014118*std::sin(0.287279933691025*x_96 + 8.1637601852417) - 0.000173991983955768*std::sin(0.276479959487915*x_97 + 8.18136024475098) + 0.000178153133093235*std::sin(0.276639938354492*x_99 + 4.97024011611938) + 0.0412532445527596);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-5.70393729946056e-5*x_1 + 9.43003007346907e-5*x_10 - 7.6711624173063e-5*x_100 - 3.55082694086026e-5*x_101 + 0.000107017911063258*x_102 - 7.45402806266904e-6*x_103 - 0.0002052084161817*x_104 + 2.98294915549008e-6*x_105 - 0.000144296750513849*x_106 - 7.14607654516159e-5*x_107 + 2.99024769371362e-5*x_108 - 0.000128731903876762*x_109 + 4.88353107461353e-5*x_11 + 7.1211692905639e-6*x_110 - 2.41734447993502e-5*x_111 - 0.000313044138360349*x_112 - 7.38060612864759e-5*x_113 - 0.000109409725772321*x_114 + 0.000107881708774272*x_115 + 1.3362331904543e-5*x_116 - 0.000112966230491414*x_117 + 2.45477888230829e-5*x_118 - 0.000282503195680163*x_119 + 2.33174919221452e-5*x_12 + 4.39388888497385e-5*x_120 - 4.27383148302228e-5*x_13 - 0.000448076010440495*x_14 - 1.32297476540158e-5*x_15 - 4.34791700568411e-6*x_16 - 1.14768810800753e-7*x_17 - 6.95344275008998e-6*x_18 - 0.000143860029377779*x_19 - 1.64128188835969e-5*x_2 - 1.90087069553477e-5*x_20 - 7.12140982759172e-6*x_21 + 2.10039017183607e-5*x_22 + 9.11294471582087e-6*x_23 + 3.64877935274209e-5*x_24 + 9.66827410943856e-5*x_25 + 0.000112829174963487*x_26 - 0.000147939849223961*x_27 - 2.29329855803968e-6*x_28 + 1.89058142483432e-5*x_29 - 5.08356942292652e-6*x_3 - 2.87161289170417e-5*x_30 + 1.81265428801038e-5*x_31 + 5.29259158872957e-5*x_32 + 2.74292197136312e-5*x_33 + 0.000176700253886538*x_34 - 0.000145394257765439*x_35 - 0.000471218998055947*x_36 + 0.000137122091376206*x_37 + 0.000211887143788156*x_38 + 6.1881964740124e-5*x_39 - 7.62694520269514e-5*x_4 - 4.29189378372474e-5*x_40 - 7.21247538496736e-6*x_41 + 0.000139855276367693*x_42 + 0.000221461198308088*x_43 - 6.61697347211302e-5*x_44 - 0.000197948151148748*x_45 - 2.478678798708e-5*x_46 - 0.000173124226773285*x_47 + 1.65485518092737e-5*x_48 - 1.97770327042528e-5*x_49 + 0.000326270005086518*x_50 - 0.000117780118346819*x_51 - 4.62558021602611e-6*x_52 + 0.000291138117861768*x_53 + 3.37654448274785e-6*x_54 - 7.33796955874333e-6*x_55 + 0.000240171916924498*x_56 - 6.91743742750877e-5*x_57 + 5.47628858574731e-5*x_58 + 0.00018212916352276*x_59 - 5.7450266777302e-6*x_6 + 1.42242680972969e-5*x_60 - 2.96203708767926e-5*x_61 + 4.16648823327181e-6*x_62 + 9.80775908856667e-6*x_63 + 1.59770953303111e-5*x_64 - 9.03114842366438e-5*x_65 - 9.66562015848628e-7*x_66 - 4.9893338962176e-5*x_67 - 4.01221744255971e-5*x_68 + 2.37364361090605e-5*x_69 - 6.24345324065779e-5*x_7 - 1.08937639498687e-5*x_70 - 1.12895869496269e-5*x_71 - 1.01292832256747e-6*x_72 - 2.10807266673719e-6*x_73 + 2.28534330873916e-5*x_74 + 1.5247555071697e-6*x_75 + 4.69271176823934e-5*x_76 + 9.88517118214614e-6*x_77 + 3.05464621870951e-6*x_78 + 1.68392060245177e-5*x_79 - 2.60978419645089e-7*x_8 - 2.32759950296073e-5*x_80 + 9.9000259290654e-7*x_81 + 4.54370686466333e-6*x_82 + 5.37582530762187e-5*x_83 - 6.93677985847142e-5*x_84 + 1.48609836468762e-5*x_85 - 1.50940696426661e-5*x_86 - 3.05425558983494e-5*x_87 - 1.34583848249195e-6*x_88 + 3.17727580430341e-5*x_89 - 0.000123014418864888*x_9 + 3.12809657643361e-6*x_90 - 6.99011003032332e-6*x_91 - 3.2919498606545e-6*x_92 - 0.000506065534221485*x_93 + 3.64291801408566e-7*x_94 - 8.20885386297742e-5*x_95 + 3.59325676212286e-5*x_96 + 0.000142458069507321*x_97 + 7.78929839587959e-5*x_98 + 0.000187120857264939*x_99 + 2.34153304154242e-7*std::pow(-9.30727958679199*x_49 - 3.04655981063843, 2) - 7.18377162366337e-9*std::pow(-8.91152000427246*x_5 - 1.61951982975006, 2) + 5.2758049231746e-5*std::exp(0.411199867725372*x_6) - 0.000125343252109614*std::sin(0.336239844560623*x_1 - 7.45831966400146) + 2.61498315996009e-5*std::sin(0.292959928512573*x_10 - 1.3983998298645) + 0.00210363653600429*std::sin(0.306079924106598*x_10 + 1.79959988594055) - 0.000538346134423981*std::sin(0.27007994055748*x_100 + 1.78159987926483) + 6.98615725467864e-5*std::sin(0.264799952507019*x_107 - 1.23319983482361) + 0.000925820667996687*std::sin(0.275119960308075*x_107 + 4.97192001342773) + 2.8135949517467e-5*std::sin(0.267439961433411*x_108 + 8.1782398223877) - 3.85011225283423e-5*std::sin(0.245279967784882*x_109 - 1.21599984169006) - 1.95193865023213e-5*std::sin(0.356959849596024*x_11 - 1.3368798494339) + 0.000792641108493711*std::sin(0.248719975352287*x_110 - 4.4334397315979) - 0.00135802885411186*std::sin(0.222079992294312*x_111 - 1.22215986251831) + 9.14246017443754e-5*std::sin(0.227119997143745*x_111 - 1.20175993442535) - 0.000650572577162829*std::sin(0.287679940462112*x_113 + 1.95039987564087) - 3.68500045388566e-5*std::sin(0.303199917078018*x_116 + 1.75935995578766) - 1.47713700217535e-5*std::sin(0.329039841890335*x_12 + 1.85455989837646) + 0.000725625443960708*std::sin(0.329919844865799*x_12 + 1.85023999214172) - 2.05973268140385e-5*std::sin(0.374719828367233*x_12 - 4.57239961624146) + 4.03495620518437e-5*std::sin(0.309839934110641*x_120 - 7.65032005310059) - 8.88764760480202e-6*std::sin(0.397519826889038*x_13 - 7.78760004043579) + 0.000737284532057284*std::sin(0.288319945335388*x_14 + 8.1715202331543) - 1.36041355139225e-5*std::sin(0.334799855947495*x_14 - 7.75631999969482) - 2.3695327934231e-5*std::sin(0.359839856624603*x_15 - 1.37655985355377) + 0.000402927514778617*std::sin(0.36575984954834*x_15 - 7.55879974365234) + 2.8357984893633e-5*std::sin(0.33519983291626*x_16 - 4.35847997665405) + 0.000369485694052764*std::sin(0.341119825839996*x_16 - 7.55671977996826) + 0.000139409468019328*std::sin(0.356159836053848*x_16 - 7.57928037643433) + 3.22507785759127e-5*std::sin(0.32847985625267*x_17 - 7.58584022521973) + 0.000437670027659633*std::sin(0.378079831600189*x_17 - 1.20383989810944) + 0.00104605716385125*std::sin(0.39591982960701*x_17 + 1.81023991107941) + 0.000309685193892998*std::sin(0.353919863700867*x_18 - 7.57656002044678) + 0.000297943941594752*std::sin(0.372879832983017*x_2 - 1.20743989944458) + 0.000426152151151752*std::sin(0.335679858922958*x_20 + 5.03431987762451) + 0.000171360141887366*std::sin(0.357039839029312*x_20 + 5.03447961807251) - 2.3617653004813e-5*std::sin(0.282239943742752*x_21 - 1.39167988300323) - 0.000457199954791598*std::sin(0.363999843597412*x_21 + 5.02055978775024) - 4.13866881956134e-5*std::sin(0.384639829397202*x_21 + 8.19575977325439) + 0.000684764234281986*std::sin(0.353439837694168*x_22 + 8.20743942260742) + 5.61179110990513e-5*std::sin(0.307599931955338*x_24 - 7.55647993087769) + 2.57886944201352e-5*std::sin(0.30991992354393*x_24 + 1.82943987846375) - 0.0012459633357199*std::sin(0.347839832305908*x_24 - 1.18343985080719) - 0.000575587012595022*std::sin(0.341839849948883*x_25 - 7.59144020080566) + 5.80674040416205e-5*std::sin(0.365119844675064*x_25 + 5.02320003509521) + 0.00043202790249397*std::sin(0.364959836006165*x_26 + 5.00607967376709) - 0.000431216259760358*std::sin(0.362719833850861*x_27 - 4.3744797706604) + 0.000941948230407927*std::sin(0.221599996089935*x_28 - 7.58168029785156) + 0.000372798852641242*std::sin(0.274799942970276*x_28 - 7.58152008056641) - 0.00233450813601349*std::sin(0.328959852457047*x_28 + 5.03695964813232) - 0.000305957122726163*std::sin(0.149280041456223*x_29 - 1.22135996818542) + 0.000626966125674743*std::sin(0.291919946670532*x_3 - 4.32119989395142) - 2.44650894662651e-5*std::sin(0.301119923591614*x_3 + 5.06943941116333) + 2.52912083480592e-5*std::sin(0.345439851284027*x_3 - 4.41095972061157) - 8.01889966018076e-5*std::sin(0.435919851064682*x_31 + 1.99383985996246) - 7.35707731711824e-5*std::sin(0.255519956350327*x_34 + 8.17208003997803) + 0.000294196803152429*std::sin(0.263919949531555*x_35 - 1.41455984115601) - 2.72955310764798e-5*std::sin(0.217360004782677*x_36 + 8.19919967651367) + 0.00295106782244123*std::sin(0.247679978609085*x_37 + 8.16775989532471) + 0.00156726335310849*std::sin(0.263599961996078*x_37 + 1.95351982116699) + 2.90757951601976e-5*std::sin(0.269439965486526*x_37 + 1.93767988681793) + 0.00148348974415249*std::sin(0.256319969892502*x_38 + 1.94175982475281) - 2.67841747065523e-5*std::sin(0.321599900722504*x_4 - 7.55352020263672) + 0.000798144140876171*std::sin(0.335679858922958*x_4 - 4.3918399810791) + 0.000186623738178771*std::sin(0.352239847183228*x_4 + 1.98887979984283) - 1.32374571589518e-5*std::sin(0.303679943084717*x_44 - 1.44399976730347) + 0.000832060216346559*std::sin(0.217840000987053*x_47 - 7.60080003738403) + 3.5392884274725e-5*std::sin(0.243039980530739*x_47 + 8.16695976257324) - 0.000523943042702271*std::sin(0.222399994730949*x_48 - 4.41351985931396) - 0.00389926271949842*std::sin(0.236959978938103*x_48 - 7.59352016448975) - 0.000490361381676305*std::sin(0.242639973759651*x_48 + 8.17303943634033) - 2.33013149455838e-5*std::sin(0.230879992246628*x_49 - 7.61863994598389) + 4.01055343167238e-5*std::sin(0.263919949531555*x_49 + 8.14167976379395) - 0.000725763452212439*std::sin(0.19336000084877*x_5 + 1.7973598241806) + 0.000523724763799045*std::sin(0.358879864215851*x_5 - 1.15943992137909) - 1.29844314753738e-5*std::sin(0.401039868593216*x_5 + 5.00216007232666) - 0.000111859097251292*std::sin(0.478239864110947*x_5 + 8.16103935241699) - 0.000954290523495458*std::sin(0.215920001268387*x_51 + 8.19279956817627) + 2.60621087346152e-5*std::sin(0.22511999309063*x_53 + 8.1846399307251) - 0.00152332665430194*std::sin(0.245599970221519*x_53 - 1.20199990272522) - 7.91563367023088e-5*std::sin(0.197839990258217*x_57 + 8.19095993041992) + 0.00136035287938675*std::sin(0.255759954452515*x_57 + 8.15783977508545) + 5.26056516182864e-5*std::sin(0.403199851512909*x_6 - 1.17351984977722) + 0.000721474673475759*std::sin(0.421999871730804*x_6 + 1.96639978885651) + 0.000501704137297894*std::sin(0.419279843568802*x_7 - 4.40727996826172) + 2.47970803007764e-5*std::sin(0.309999912977219*x_8 + 8.19192028045654) - 0.000509838173949224*std::sin(0.319999933242798*x_8 + 8.18048000335693) - 0.000537783211042942*std::sin(0.354479849338531*x_8 + 8.23911952972412) - 0.000120777429042282*std::sin(0.468639850616455*x_8 - 8.01272010803223) + 1.64239577978093e-5*std::sin(0.300959944725037*x_9 - 7.42592000961304) - 0.000143883189350149*std::sin(0.306479930877686*x_9 + 1.95599985122681) + 3.75351748124432e-5*std::sin(0.356319844722748*x_9 - 7.57816028594971) + 0.000474981525203456*std::sin(0.388399839401245*x_9 - 7.60120010375977) + 1.01819268842183e-5*std::sin(0.315759837627411*x_92 - 7.59328031539917) - 0.000409810294264833*std::sin(0.320479840040207*x_92 - 4.37967967987061) + 1.34029893243181e-5*std::sin(0.332799851894379*x_92 + 5.01823997497559) + 0.000654813727384205*std::sin(0.251279979944229*x_93 - 1.22199988365173) + 0.000435711928710751*std::sin(0.287999957799911*x_94 - 1.19415986537933) - 0.00115019303949014*std::sin(0.29215994477272*x_94 - 1.19487988948822) - 0.00113075424880802*std::sin(0.277599930763245*x_96 - 1.20943987369537) + 2.31460451766657e-5*std::sin(0.287279933691025*x_96 + 8.1637601852417) - 0.000465148177884139*std::sin(0.276479959487915*x_97 + 8.18136024475098) - 2.73317331521516e-5*std::sin(0.276639938354492*x_99 + 4.97024011611938) + 0.00490190575947215);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (4.45786547312674e-6*x_1 - 0.000312109982282259*x_10 - 0.000134218088490789*x_100 - 0.000117040539100265*x_101 - 0.000150493429092175*x_102 - 0.000175884748324151*x_103 - 0.000119412397846624*x_104 - 0.000377628248821753*x_105 - 0.000404535279101417*x_106 + 9.38995618123013e-5*x_107 - 0.00015988954614831*x_108 - 0.000148089784560873*x_109 - 0.000219085086089204*x_11 + 0.000133773881971256*x_110 + 0.000195863756559543*x_111 - 0.000387280949297755*x_112 - 4.55707737774754e-5*x_113 - 5.27740063294448e-5*x_114 + 0.000203339350272772*x_115 - 0.000252681267920573*x_116 - 0.000101208209272477*x_117 - 0.000169201601908064*x_118 + 0.000138876692813469*x_119 - 0.000239819793871564*x_12 - 0.000538570379031549*x_120 + 0.000211376473481067*x_13 + 3.91804413117522e-5*x_14 + 1.07600700120161e-6*x_15 + 8.79682826643851e-7*x_16 + 6.94636962425348e-6*x_17 - 3.13604381989322e-5*x_18 + 0.000118041890904773*x_19 + 3.43941728342937e-5*x_2 - 2.15281375246657e-5*x_20 - 1.72416038281568e-5*x_21 - 0.000281047790669202*x_22 - 0.000178868777941963*x_23 - 0.000215557546183972*x_24 - 0.000208412814373628*x_25 - 4.27296241972207e-5*x_26 + 9.92040214111107e-5*x_27 - 3.02104934437216e-5*x_28 - 3.41522691098151e-5*x_29 - 3.73921621976766e-5*x_3 - 0.000171865152757814*x_30 - 4.3455209046477e-6*x_31 - 0.000204059149867151*x_32 - 0.000226926755664495*x_33 - 0.000415156059738297*x_34 - 0.000951243388536098*x_35 + 9.63346116393969e-5*x_36 - 0.000973470752556174*x_37 - 0.000575826164750196*x_38 - 0.000298457021109939*x_39 + 5.09381162664438e-6*x_4 - 0.0001155928153263*x_40 + 5.88587960073753e-5*x_41 - 0.00130205888519864*x_42 - 0.00121232924658466*x_43 - 0.000151206637776188*x_44 + 8.04858778367034e-5*x_45 - 0.000199820022688471*x_46 - 0.00103709622738353*x_47 + 6.93689308923783e-5*x_48 - 0.000342517085792376*x_49 - 0.000608290706327188*x_50 - 7.14211627897324e-5*x_51 - 0.000314995421524015*x_52 - 0.000288966812492828*x_53 - 0.000334217551850892*x_54 - 0.000221485766539412*x_55 - 0.000320631442421068*x_56 - 0.000237906826513436*x_57 - 0.000821572224664363*x_58 - 0.000381744904499512*x_59 - 3.15173052722516e-6*x_6 - 0.000205330324847501*x_60 + 0.000238522872943466*x_61 - 1.92652053957189e-5*x_62 - 5.77754204705197e-5*x_63 - 3.73491120080473e-5*x_64 + 0.000132139924743638*x_65 - 3.17595615360309e-6*x_66 + 0.000180227519901588*x_67 + 0.000300034960248285*x_68 - 2.59424529424521e-5*x_69 + 0.000390384261495863*x_7 + 1.03622682240621e-5*x_70 + 1.30800501444038e-5*x_71 + 1.76217094517708e-6*x_72 + 7.34030637478561e-6*x_73 - 0.000127326308913421*x_74 - 9.86132133462361e-6*x_75 - 0.000318921492367006*x_76 - 3.54710249048681e-5*x_77 - 1.33851097322162e-5*x_78 - 0.000139156054481025*x_79 - 3.83148848625525e-6*x_8 + 0.000131155633820872*x_80 - 7.65690975238432e-6*x_81 + 1.38851204247087e-6*x_82 - 1.90612662157929e-5*x_83 + 3.34140183488914e-5*x_84 - 0.000120464688237215*x_85 - 1.10530593107661e-6*x_86 - 5.83611161691199e-5*x_87 - 1.39544702015297e-5*x_88 - 0.000270414976229372*x_89 + 1.09262876528043e-5*x_9 - 2.1204686557285e-5*x_90 + 0.000139627950373693*x_91 - 3.1681761643266e-7*x_92 + 0.00016236790061924*x_93 - 5.57775973449365e-7*x_94 + 0.000118313072717882*x_95 - 8.77671757209165e-5*x_96 - 8.81980631520229e-5*x_97 - 1.42599951505527e-5*x_98 - 0.000581624099951101*x_99 - 2.07977762253534e-8*std::pow(-9.30727958679199*x_49 - 3.04655981063843, 2) - 1.39600977756133e-8*std::pow(-8.91152000427246*x_5 - 1.61951982975006, 2) - 0.000375047362031966*std::exp(0.411199867725372*x_6) + 0.000891042347788923*std::sin(0.336239844560623*x_1 - 7.45831966400146) + 5.08165104725437e-5*std::sin(0.292959928512573*x_10 - 1.3983998298645) - 0.000186847510409142*std::sin(0.306079924106598*x_10 + 1.79959988594055) + 0.000216268574201556*std::sin(0.27007994055748*x_100 + 1.78159987926483) + 0.000135760772279938*std::sin(0.264799952507019*x_107 - 1.23319983482361) - 0.000371927841644508*std::sin(0.275119960308075*x_107 + 4.97192001342773) + 0.000413070807818659*std::sin(0.267439961433411*x_108 + 8.1782398223877) - 0.000565244466863803*std::sin(0.245279967784882*x_109 - 1.21599984169006) - 3.79316824597822e-5*std::sin(0.356959849596024*x_11 - 1.3368798494339) - 0.000318425918616272*std::sin(0.248719975352287*x_110 - 4.4334397315979) + 0.000545557858082507*std::sin(0.222079992294312*x_111 - 1.22215986251831) + 0.000177663829852812*std::sin(0.227119997143745*x_111 - 1.20175993442535) + 0.000261353049053061*std::sin(0.287679940462112*x_113 + 1.95039987564087) - 7.16099694343984e-5*std::sin(0.303199917078018*x_116 + 1.75935995578766) - 0.000216862123088687*std::sin(0.329039841890335*x_12 + 1.85455989837646) - 0.000291503867372736*std::sin(0.329919844865799*x_12 + 1.85023999214172) - 4.00264250178944e-5*std::sin(0.374719828367233*x_12 - 4.57239961624146) + 7.84105983535801e-5*std::sin(0.309839934110641*x_120 - 7.65032005310059) - 0.000130481744482944*std::sin(0.397519826889038*x_13 - 7.78760004043579) - 0.00029618764644702*std::sin(0.288319945335388*x_14 + 8.1715202331543) - 2.64366786524046e-5*std::sin(0.334799855947495*x_14 - 7.75631999969482) - 4.60467164208652e-5*std::sin(0.359839856624603*x_15 - 1.37655985355377) - 0.00286433830871982*std::sin(0.36575984954834*x_15 - 7.55879974365234) + 0.00041633056388768*std::sin(0.33519983291626*x_16 - 4.35847997665405) - 0.000148432651654801*std::sin(0.341119825839996*x_16 - 7.55671977996826) - 0.000991036514509094*std::sin(0.356159836053848*x_16 - 7.57928037643433) + 6.26723740460173e-5*std::sin(0.32847985625267*x_17 - 7.58584022521973) - 0.00311131650439097*std::sin(0.378079831600189*x_17 - 1.20383989810944) - 9.29120470509146e-5*std::sin(0.39591982960701*x_17 + 1.81023991107941) - 0.00220149563377029*std::sin(0.353919863700867*x_18 - 7.57656002044678) - 0.000119692345352556*std::sin(0.372879832983017*x_2 - 1.20743989944458) - 0.000171197139218113*std::sin(0.335679858922958*x_20 + 5.03431987762451) - 0.00121816803517458*std::sin(0.357039839029312*x_20 + 5.03447961807251) - 0.000346736583367213*std::sin(0.282239943742752*x_21 - 1.39167988300323) + 0.000183669903107212*std::sin(0.363999843597412*x_21 + 5.02055978775024) - 8.04260274528262e-5*std::sin(0.384639829397202*x_21 + 8.19575977325439) - 0.00027508878608526*std::sin(0.353439837694168*x_22 + 8.20743942260742) + 0.000109052955320207*std::sin(0.307599931955338*x_24 - 7.55647993087769) + 0.000378610177349822*std::sin(0.30991992354393*x_24 + 1.82943987846375) + 0.000500538031004672*std::sin(0.347839832305908*x_24 - 1.18343985080719) + 0.000231229267905956*std::sin(0.341839849948883*x_25 - 7.59144020080566) + 0.000112841370865251*std::sin(0.365119844675064*x_25 + 5.02320003509521) - 0.0030712076643097*std::sin(0.364959836006165*x_26 + 5.00607967376709) + 0.00306543784395837*std::sin(0.362719833850861*x_27 - 4.3744797706604) - 0.000378406730792207*std::sin(0.221599996089935*x_28 - 7.58168029785156) - 0.00265015913756548*std::sin(0.274799942970276*x_28 - 7.58152008056641) + 0.000207353801751577*std::sin(0.328959852457047*x_28 + 5.03695964813232) + 0.00217499345491892*std::sin(0.149280041456223*x_29 - 1.22135996818542) - 0.000251869682722681*std::sin(0.291919946670532*x_3 - 4.32119989395142) - 0.000359178006873809*std::sin(0.301119923591614*x_3 + 5.06943941116333) + 4.91479629223328e-5*std::sin(0.345439851284027*x_3 - 4.41095972061157) + 0.000570048970298194*std::sin(0.435919851064682*x_31 + 1.99383985996246) - 0.000142968796991548*std::sin(0.255519956350327*x_34 + 8.17208003997803) - 0.000118187015906615*std::sin(0.263919949531555*x_35 - 1.41455984115601) - 0.000400732417599813*std::sin(0.217360004782677*x_36 + 8.19919967651367) - 0.000262117369723488*std::sin(0.247679978609085*x_37 + 8.16775989532471) - 0.000629613159826608*std::sin(0.263599961996078*x_37 + 1.95351982116699) + 0.000426868913286064*std::sin(0.269439965486526*x_37 + 1.93767988681793) - 0.000595958977496462*std::sin(0.256319969892502*x_38 + 1.94175982475281) - 5.20492183396978e-5*std::sin(0.321599900722504*x_4 - 7.55352020263672) - 0.00032063663936086*std::sin(0.335679858922958*x_4 - 4.3918399810791) - 0.00132667416092359*std::sin(0.352239847183228*x_4 + 1.98887979984283) - 2.57241190171942e-5*std::sin(0.303679943084717*x_44 - 1.44399976730347) - 0.000334261667600993*std::sin(0.217840000987053*x_47 - 7.60080003738403) + 0.000519611655164398*std::sin(0.243039980530739*x_47 + 8.16695976257324) + 0.000210482452761153*std::sin(0.222399994730949*x_48 - 4.41351985931396) + 0.000346337173318602*std::sin(0.236959978938103*x_48 - 7.59352016448975) + 0.00348588974228761*std::sin(0.242639973759651*x_48 + 8.17303943634033) - 0.000342092346371106*std::sin(0.230879992246628*x_49 - 7.61863994598389) + 7.7936383523168e-5*std::sin(0.263919949531555*x_49 + 8.14167976379395) + 6.44631769181072e-5*std::sin(0.19336000084877*x_5 + 1.7973598241806) - 0.000210394764071367*std::sin(0.358879864215851*x_5 - 1.15943992137909) - 0.000190627637971449*std::sin(0.401039868593216*x_5 + 5.00216007232666) + 0.000795185947059815*std::sin(0.478239864110947*x_5 + 8.16103935241699) + 0.00678387750610222*std::sin(0.215920001268387*x_51 + 8.19279956817627) + 0.000382624240272465*std::sin(0.22511999309063*x_53 + 8.1846399307251) + 0.000611962569252233*std::sin(0.245599970221519*x_53 - 1.20199990272522) - 0.000153823124928363*std::sin(0.197839990258217*x_57 + 8.19095993041992) - 0.000546491483496475*std::sin(0.255759954452515*x_57 + 8.15783977508545) + 0.000102227642889158*std::sin(0.403199851512909*x_6 - 1.17351984977722) - 0.000289836387739807*std::sin(0.421999871730804*x_6 + 1.96639978885651) - 0.000201548467623962*std::sin(0.419279843568802*x_7 - 4.40727996826172) + 4.81877325287303e-5*std::sin(0.309999912977219*x_8 + 8.19192028045654) + 0.000204816135759016*std::sin(0.319999933242798*x_8 + 8.18048000335693) + 0.00382300288929884*std::sin(0.354479849338531*x_8 + 8.23911952972412) + 1.07275955441579e-5*std::sin(0.468639850616455*x_8 - 8.01272010803223) + 0.000241124171441556*std::sin(0.300959944725037*x_9 - 7.42592000961304) + 0.00102283938455496*std::sin(0.306479930877686*x_9 + 1.95599985122681) + 7.29414488456738e-5*std::sin(0.356319844722748*x_9 - 7.57816028594971) - 0.000190813253145662*std::sin(0.388399839401245*x_9 - 7.60120010375977) + 0.000149483377506188*std::sin(0.315759837627411*x_92 - 7.59328031539917) + 0.00291326673437889*std::sin(0.320479840040207*x_92 - 4.37967967987061) + 2.60457947795348e-5*std::sin(0.332799851894379*x_92 + 5.01823997497559) - 0.00465495151268764*std::sin(0.251279979944229*x_93 - 1.22199988365173) - 0.00309739673563398*std::sin(0.287999957799911*x_94 - 1.19415986537933) + 0.000462064446646848*std::sin(0.29215994477272*x_94 - 1.19487988948822) + 0.000454255345259834*std::sin(0.277599930763245*x_96 - 1.20943987369537) + 0.000339812792633743*std::sin(0.287279933691025*x_96 + 8.1637601852417) + 0.00330665366915137*std::sin(0.276479959487915*x_97 + 8.18136024475098) - 0.000401263909193269*std::sin(0.276639938354492*x_99 + 4.97024011611938) - 0.00975638816020643);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (4.44496766050338e-5*x_1 + 0.000557551118393897*x_10 + 0.000268784439964369*x_100 + 0.000272342035030808*x_101 + 0.00021311494376887*x_102 + 0.000359272856938202*x_103 + 0.000444696999882256*x_104 + 0.000745398410864021*x_105 + 0.000940437118470321*x_106 - 0.000172963983424731*x_107 + 0.000292240742829495*x_108 + 0.00041850134574135*x_109 + 0.00042880257940935*x_11 - 0.000276388515127064*x_110 - 0.000375406792833264*x_111 + 0.00086032838639454*x_112 + 9.88470243447931e-5*x_113 + 0.000159666339825315*x_114 - 0.000513327180962497*x_115 + 0.00055460594705791*x_116 + 0.000229467100352428*x_117 + 0.000324575191972365*x_118 - 0.000246581906871255*x_119 + 0.000461956666671291*x_12 + 0.00106970137178972*x_120 - 0.000402557552243184*x_13 - 2.74035210802888e-5*x_14 + 5.22527968694035e-6*x_15 - 1.50018662269232e-6*x_16 - 1.76364090368777e-5*x_17 + 8.50622022560335e-5*x_18 - 0.000131481051530883*x_19 - 6.46208595329583e-5*x_2 + 5.92901810159068e-5*x_20 + 3.41284543544016e-5*x_21 + 0.000547632098872143*x_22 + 0.000351258661760965*x_23 + 0.000413603307279812*x_24 + 0.000397423841665411*x_25 + 2.92457998670113e-5*x_26 - 3.01136513237056e-5*x_27 + 7.93778109787205e-5*x_28 + 6.44390152116117e-5*x_29 + 7.29355955135773e-5*x_3 + 0.000371527237778406*x_30 + 7.25130268720146e-6*x_31 + 0.000373231457843822*x_32 + 0.000446294880542503*x_33 + 0.000718110136494127*x_34 + 0.00191266084719361*x_35 - 0.000108030694804053*x_36 + 0.00187059043438328*x_37 + 0.00105753053846807*x_38 + 0.000604135553611372*x_39 - 7.72196040805222e-7*x_4 + 0.000163545445107813*x_40 - 0.000158511366425488*x_41 + 0.00240278124733771*x_42 + 0.00216711021853221*x_43 + 0.000334753845486994*x_44 - 3.21934101190175e-5*x_45 + 0.00034752606812995*x_46 + 0.00203073221848823*x_47 - 0.000179480655994124*x_48 + 0.000716858819570684*x_49 + 0.00102193296074714*x_50 + 7.21988968355749e-5*x_51 + 0.000666466304081909*x_52 + 0.000528922533697993*x_53 + 0.000743559188841227*x_54 + 0.000424965162955593*x_55 + 0.000514783922658984*x_56 + 0.000469789162857422*x_57 + 0.00160578196257347*x_58 + 0.000609529507680646*x_59 + 9.19826453328098e-6*x_6 + 0.000463602218428891*x_60 - 0.000458643551231744*x_61 + 3.63132753006874e-5*x_62 + 0.000108558180695385*x_63 + 6.08299411391232e-5*x_64 - 0.000192050768390934*x_65 + 5.66097864086702e-6*x_66 - 0.000342746812534362*x_67 - 0.000579351210296468*x_68 + 3.0827887071143e-5*x_69 - 0.000756544641414509*x_7 - 1.52299175292317e-5*x_70 - 2.45662822918917e-5*x_71 - 3.33118800364131e-6*x_72 - 1.48786600925343e-5*x_73 + 0.000243922451745711*x_74 + 2.04583537396169e-5*x_75 + 0.00061147151870066*x_76 + 6.46753158502635e-5*x_77 + 2.52131841549914e-5*x_78 + 0.000268028639737557*x_79 + 1.00745782142124e-5*x_8 - 0.000250717934771263*x_80 + 1.47951780461833e-5*x_81 + 1.27687598816286e-6*x_82 - 4.78050170233925e-6*x_83 - 6.13773078271859e-5*x_84 + 0.000202126494261549*x_85 + 4.28434761944264e-5*x_86 + 0.000151302151216506*x_87 + 2.71540029032476e-5*x_88 + 0.00052172353375458*x_89 - 8.34213385197558e-6*x_9 + 4.8477900478729e-5*x_90 - 0.000278282592410087*x_91 - 4.36956885460712e-7*x_92 - 0.000182315175008924*x_93 + 1.4032251088435e-6*x_94 - 0.000168697739988621*x_95 + 0.000163709490878958*x_96 + 7.06397510586718e-5*x_97 - 2.94882161781447e-5*x_98 + 0.00102722841921326*x_99 + 1.58789369828465e-8*std::pow(-9.30727958679199*x_49 - 3.04655981063843, 2) + 3.51680568165236e-8*std::pow(-8.91152000427246*x_5 - 1.61951982975006, 2) + 0.000720743577133078*std::exp(0.411199867725372*x_6) - 0.00171235186309005*std::sin(0.336239844560623*x_1 - 7.45831966400146) - 0.000128016146895316*std::sin(0.292959928512573*x_10 - 1.3983998298645) + 0.000142656590350833*std::sin(0.306079924106598*x_10 + 1.79959988594055) + 2.25865037472444e-5*std::sin(0.27007994055748*x_100 + 1.78159987926483) - 0.00034200638346075*std::sin(0.264799952507019*x_107 - 1.23319983482361) - 3.88431357631236e-5*std::sin(0.275119960308075*x_107 + 4.97192001342773) - 0.00108613510814547*std::sin(0.267439961433411*x_108 + 8.1782398223877) + 0.0014862630050954*std::sin(0.245279967784882*x_109 - 1.21599984169006) + 9.55568926044535e-5*std::sin(0.356959849596024*x_11 - 1.3368798494339) - 3.32555399257561e-5*std::sin(0.248719975352287*x_110 - 4.4334397315979) + 5.69765840987846e-5*std::sin(0.222079992294312*x_111 - 1.22215986251831) - 0.000447567901237739*std::sin(0.227119997143745*x_111 - 1.20175993442535) + 2.72950041104412e-5*std::sin(0.287679940462112*x_113 + 1.95039987564087) + 0.000180398698789758*std::sin(0.303199917078018*x_116 + 1.75935995578766) + 0.000570220797633786*std::sin(0.329039841890335*x_12 + 1.85455989837646) - 3.04438738594281e-5*std::sin(0.329919844865799*x_12 + 1.85023999214172) + 0.00010083393482033*std::sin(0.374719828367233*x_12 - 4.57239961624146) - 0.000197530735259852*std::sin(0.309839934110641*x_120 - 7.65032005310059) + 0.000343090823588794*std::sin(0.397519826889038*x_13 - 7.78760004043579) - 3.09330350517241e-5*std::sin(0.288319945335388*x_14 + 8.1715202331543) + 6.65988613999587e-5*std::sin(0.334799855947495*x_14 - 7.75631999969482) + 0.000116000157400917*std::sin(0.359839856624603*x_15 - 1.37655985355377) + 0.00550451395674681*std::sin(0.36575984954834*x_15 - 7.55879974365234) - 0.00109470636383224*std::sin(0.33519983291626*x_16 - 4.35847997665405) - 1.55019038489156e-5*std::sin(0.341119825839996*x_16 - 7.55671977996826) + 0.00190451466893907*std::sin(0.356159836053848*x_16 - 7.57928037643433) - 0.000157883250296929*std::sin(0.32847985625267*x_17 - 7.58584022521973) + 0.00597914187375834*std::sin(0.378079831600189*x_17 - 1.20383989810944) + 7.09376100638218e-5*std::sin(0.39591982960701*x_17 + 1.81023991107941) + 0.00423070256921634*std::sin(0.353919863700867*x_18 - 7.57656002044678) - 1.25003441521858e-5*std::sin(0.372879832983017*x_2 - 1.20743989944458) - 1.78793652325268e-5*std::sin(0.335679858922958*x_20 + 5.03431987762451) + 0.00234100243357016*std::sin(0.357039839029312*x_20 + 5.03447961807251) + 0.000911714818247022*std::sin(0.282239943742752*x_21 - 1.39167988300323) + 1.91819868887692e-5*std::sin(0.363999843597412*x_21 + 5.02055978775024) + 0.000202607972268591*std::sin(0.384639829397202*x_21 + 8.19575977325439) - 2.87295272587733e-5*std::sin(0.353439837694168*x_22 + 8.20743942260742) - 0.000274724474739028*std::sin(0.307599931955338*x_24 - 7.55647993087769) - 0.000995523765265334*std::sin(0.30991992354393*x_24 + 1.82943987846375) + 5.22748353738582e-5*std::sin(0.347839832305908*x_24 - 1.18343985080719) + 2.41489580504798e-5*std::sin(0.341839849948883*x_25 - 7.59144020080566) - 0.00028426819107069*std::sin(0.365119844675064*x_25 + 5.02320003509521) + 0.00590206310504441*std::sin(0.364959836006165*x_26 + 5.00607967376709) - 0.0058909750095652*std::sin(0.362719833850861*x_27 - 4.3744797706604) - 3.95197733862861e-5*std::sin(0.221599996089935*x_28 - 7.58168029785156) + 0.00509291724232434*std::sin(0.274799942970276*x_28 - 7.58152008056641) - 0.000158312980940394*std::sin(0.328959852457047*x_28 + 5.03695964813232) - 0.00417977226781743*std::sin(0.149280041456223*x_29 - 1.22135996818542) - 2.63045870332102e-5*std::sin(0.291919946670532*x_3 - 4.32119989395142) + 0.000944428499800021*std::sin(0.301119923591614*x_3 + 5.06943941116333) - 0.000123812768381062*std::sin(0.345439851284027*x_3 - 4.41095972061157) - 0.00109548599880228*std::sin(0.435919851064682*x_31 + 1.99383985996246) + 0.00036016472494713*std::sin(0.255519956350327*x_34 + 8.17208003997803) - 1.2343131624674e-5*std::sin(0.263919949531555*x_35 - 1.41455984115601) + 0.00105369234399698*std::sin(0.217360004782677*x_36 + 8.19919967651367) + 0.000200124530182939*std::sin(0.247679978609085*x_37 + 8.16775989532471) - 6.5755092001877e-5*std::sin(0.263599961996078*x_37 + 1.95351982116699) - 0.00112241607133719*std::sin(0.269439965486526*x_37 + 1.93767988681793) - 6.22403404106363e-5*std::sin(0.256319969892502*x_38 + 1.94175982475281) + 0.000131121564995322*std::sin(0.321599900722504*x_4 - 7.55352020263672) - 3.34864216087102e-5*std::sin(0.335679858922958*x_4 - 4.3918399810791) + 0.00254952301291642*std::sin(0.352239847183228*x_4 + 1.98887979984283) + 6.48037924728616e-5*std::sin(0.303679943084717*x_44 - 1.44399976730347) - 3.49093826308477e-5*std::sin(0.217840000987053*x_47 - 7.60080003738403) - 0.00136627534697003*std::sin(0.243039980530739*x_47 + 8.16695976257324) + 2.19822169058568e-5*std::sin(0.222399994730949*x_48 - 4.41351985931396) - 0.000264425681397571*std::sin(0.236959978938103*x_48 - 7.59352016448975) - 0.00669897430750023*std::sin(0.242639973759651*x_48 + 8.17303943634033) + 0.000899503185866953*std::sin(0.230879992246628*x_49 - 7.61863994598389) - 0.000196336100783272*std::sin(0.263919949531555*x_49 + 8.14167976379395) - 4.92171236436754e-5*std::sin(0.19336000084877*x_5 + 1.7973598241806) - 2.1973058936754e-5*std::sin(0.358879864215851*x_5 - 1.15943992137909) + 0.000501239415288168*std::sin(0.401039868593216*x_5 + 5.00216007232666) - 0.00152814076831447*std::sin(0.478239864110947*x_5 + 8.16103935241699) - 0.0130368498370187*std::sin(0.215920001268387*x_51 + 8.19279956817627) - 0.00100607840767546*std::sin(0.22511999309063*x_53 + 8.1846399307251) + 6.39117121598402e-5*std::sin(0.245599970221519*x_53 - 1.20199990272522) + 0.000387508775663874*std::sin(0.197839990258217*x_57 + 8.19095993041992) - 5.70740894066591e-5*std::sin(0.255759954452515*x_57 + 8.15783977508545) - 0.000257530255957485*std::sin(0.403199851512909*x_6 - 1.17351984977722) - 3.02697268058553e-5*std::sin(0.421999871730804*x_6 + 1.96639978885651) - 2.10491757114809e-5*std::sin(0.419279843568802*x_7 - 4.40727996826172) - 0.000121393771209126*std::sin(0.309999912977219*x_8 + 8.19192028045654) + 2.13904421153013e-5*std::sin(0.319999933242798*x_8 + 8.18048000335693) - 0.00734681818022889*std::sin(0.354479849338531*x_8 + 8.23911952972412) - 8.19043400493427e-6*std::sin(0.468639850616455*x_8 - 8.01272010803223) - 0.000634015822633814*std::sin(0.300959944725037*x_9 - 7.42592000961304) - 0.00196563152147676*std::sin(0.306479930877686*x_9 + 1.95599985122681) - 0.000183752940596543*std::sin(0.356319844722748*x_9 - 7.57816028594971) - 1.99280190065052e-5*std::sin(0.388399839401245*x_9 - 7.60120010375977) - 0.000393054026865317*std::sin(0.315759837627411*x_92 - 7.59328031539917) - 0.00559854167725109*std::sin(0.320479840040207*x_92 - 4.37967967987061) - 6.56141529494376e-5*std::sin(0.332799851894379*x_92 + 5.01823997497559) + 0.00894560725999604*std::sin(0.251279979944229*x_93 - 1.22199988365173) + 0.00595239169513444*std::sin(0.287999957799911*x_94 - 1.19415986537933) + 4.82567584966414e-5*std::sin(0.29215994477272*x_94 - 1.19487988948822) + 4.74411971124154e-5*std::sin(0.277599930763245*x_96 - 1.20943987369537) - 0.000893509290151762*std::sin(0.287279933691025*x_96 + 8.1637601852417) - 0.006354529147818*std::sin(0.276479959487915*x_97 + 8.18136024475098) + 0.00105508985664714*std::sin(0.276639938354492*x_99 + 4.97024011611938) + 0.157991274131684);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000159207370178614*x_1 - 1.2961198640788e-5*x_10 - 6.11494781747071e-5*x_100 - 0.000177077957194261*x_101 + 0.000126912333459048*x_102 - 0.000135462245141369*x_103 - 0.000713379709252497*x_104 - 0.000131288290633479*x_105 - 0.000409270259901818*x_106 + 9.45827335743059e-6*x_107 - 7.2579429813969e-5*x_108 - 0.00035215249919952*x_109 - 0.000132048646728399*x_11 + 0.000232395013968561*x_110 + 5.25287552591127e-5*x_111 - 0.000332392364833562*x_112 - 4.80604953034907e-5*x_113 - 6.49617228308056e-5*x_114 + 0.000500855978051269*x_115 - 0.000533523410038912*x_116 + 6.85733444273204e-5*x_117 - 3.91661857445136e-5*x_118 + 0.000124041703798903*x_119 - 7.67836855089163e-5*x_12 - 0.000304377507912822*x_120 + 5.66488222371797e-5*x_13 - 7.68113452121499e-5*x_14 - 2.18807415421577e-5*x_15 - 1.55484095347935e-6*x_16 + 3.32395604122274e-5*x_17 - 0.00019416725740917*x_18 - 0.000213532326236565*x_19 + 3.2474272982202e-6*x_2 - 0.000111817692151418*x_20 - 7.04544183264655e-6*x_21 - 8.86494325310966e-5*x_22 - 5.36879918433944e-5*x_23 - 6.63234769764276e-5*x_24 - 8.06188231290807e-5*x_25 + 7.23515823906064e-5*x_26 - 0.000423848668582732*x_27 - 0.000150072045521884*x_28 - 4.54083186104889e-5*x_29 - 1.34834661945189e-5*x_3 - 0.000150603990128362*x_30 - 7.70006596939615e-6*x_31 - 9.2443138767074e-6*x_32 - 0.000103856146693169*x_33 - 0.000144002467935361*x_34 - 0.00067011529118914*x_35 - 0.000118288367300654*x_36 - 0.000304967321421534*x_37 + 0.000141091783737254*x_38 - 0.000470149320828405*x_39 - 1.94241366644049e-5*x_4 + 0.000197196429315954*x_40 + 0.00014595425332545*x_41 - 0.000222719394487895*x_42 + 0.000128710706378171*x_43 - 2.24995718926839e-5*x_44 - 3.82265191497112e-5*x_45 + 0.000163191104424679*x_46 - 0.000359903717669732*x_47 + 0.000167975926089271*x_48 - 0.000235025644561144*x_49 + 0.000341999881415468*x_50 + 1.11806911789033e-5*x_51 - 0.000544771966342051*x_52 - 4.82419717397548e-5*x_53 - 0.000346448754194623*x_54 - 0.000193787829572754*x_55 + 7.61105344618693e-5*x_56 - 0.000105312301715893*x_57 - 0.000645886262213662*x_58 + 0.000207227037171821*x_59 - 1.93144611900077e-5*x_6 - 6.29283734832836e-5*x_60 + 7.4618228937283e-5*x_61 - 4.22868473270025e-6*x_62 - 1.35015127447702e-5*x_63 + 1.31721662601986e-5*x_64 - 0.000104319038881445*x_65 + 2.92416264456606e-6*x_66 + 4.91433517741802e-5*x_67 + 0.000100292671805313*x_68 + 3.26043389666695e-5*x_69 + 0.000173468938438135*x_7 - 7.21732446495663e-6*x_70 + 9.9402944063486e-6*x_71 + 1.78522696862148e-6*x_72 + 4.43640152559752e-6*x_73 - 3.68159555543717e-5*x_74 - 8.73316785950544e-7*x_75 - 9.24766774169547e-5*x_76 - 2.58640400291384e-6*x_77 - 3.617810493955e-6*x_78 - 4.51622483779713e-5*x_79 - 1.95007163107296e-5*x_8 + 3.79898908347856e-5*x_80 - 2.44386627400014e-6*x_81 - 4.14833332976409e-5*x_82 + 8.98181783133088e-5*x_83 + 1.86287738928207e-5*x_84 + 3.44194294560785e-5*x_85 - 8.8998373796924e-5*x_86 - 0.000122116609695908*x_87 - 3.51400632404344e-6*x_88 - 7.66410363206159e-5*x_89 - 1.76428910947007e-5*x_9 - 4.61280851346947e-5*x_90 + 5.41559943013658e-5*x_91 + 2.46231464078229e-6*x_92 - 0.000112074018091497*x_93 - 2.71404692092562e-6*x_94 - 9.0949095408874e-5*x_95 - 3.43340471510781e-5*x_96 + 0.000106840595535221*x_97 + 6.11784578470608e-5*x_98 + 1.39195007341974e-5*x_99 + 3.3582577414726e-8*std::pow(-9.30727958679199*x_49 - 3.04655981063843, 2) + 2.65173454502769e-8*std::pow(-8.91152000427246*x_5 - 1.61951982975006, 2) - 0.000117255415328623*std::exp(0.411199867725372*x_6) + 0.000278576924256507*std::sin(0.336239844560623*x_1 - 7.45831966400146) - 9.65264702609758e-5*std::sin(0.292959928512573*x_10 - 1.3983998298645) + 0.000301706341825841*std::sin(0.306079924106598*x_10 + 1.79959988594055) - 0.000888608800959022*std::sin(0.27007994055748*x_100 + 1.78159987926483) - 0.000257878945764427*std::sin(0.264799952507019*x_107 - 1.23319983482361) + 0.00152818482586836*std::sin(0.275119960308075*x_107 + 4.97192001342773) + 0.00210236221990801*std::sin(0.267439961433411*x_108 + 8.1782398223877) - 0.00287686418321819*std::sin(0.245279967784882*x_109 - 1.21599984169006) + 7.20516104875247e-5*std::sin(0.356959849596024*x_11 - 1.3368798494339) + 0.00130835501542714*std::sin(0.248719975352287*x_110 - 4.4334397315979) - 0.00224159943678485*std::sin(0.222079992294312*x_111 - 1.22215986251831) - 0.000337474223028445*std::sin(0.227119997143745*x_111 - 1.20175993442535) - 0.00107385282583675*std::sin(0.287679940462112*x_113 + 1.95039987564087) + 0.000136023853679082*std::sin(0.303199917078018*x_116 + 1.75935995578766) - 0.00110373990580049*std::sin(0.329039841890335*x_12 + 1.85455989837646) + 0.00119773713317957*std::sin(0.329919844865799*x_12 + 1.85023999214172) + 7.60305949427693e-5*std::sin(0.374719828367233*x_12 - 4.57239961624146) - 0.000148941716378018*std::sin(0.309839934110641*x_120 - 7.65032005310059) - 0.000664098950582488*std::sin(0.397519826889038*x_13 - 7.78760004043579) + 0.00121698194173543*std::sin(0.288319945335388*x_14 + 8.1715202331543) + 5.02167357028397e-5*std::sin(0.334799855947495*x_14 - 7.75631999969482) + 8.74661987193263e-5*std::sin(0.359839856624603*x_15 - 1.37655985355377) - 0.000895511372779639*std::sin(0.36575984954834*x_15 - 7.55879974365234) + 0.00211895305100986*std::sin(0.33519983291626*x_16 - 4.35847997665405) + 0.000609883156150165*std::sin(0.341119825839996*x_16 - 7.55671977996826) - 0.000309839262660087*std::sin(0.356159836053848*x_16 - 7.57928037643433) - 0.000119046801783177*std::sin(0.32847985625267*x_17 - 7.58584022521973) - 0.000972727036299136*std::sin(0.378079831600189*x_17 - 1.20383989810944) + 0.000150026905715252*std::sin(0.39591982960701*x_17 + 1.81023991107941) - 0.000688279164218956*std::sin(0.353919863700867*x_18 - 7.57656002044678) + 0.000491794389824681*std::sin(0.372879832983017*x_2 - 1.20743989944458) + 0.000703418354561511*std::sin(0.335679858922958*x_20 + 5.03431987762451) - 0.000380850029528469*std::sin(0.357039839029312*x_20 + 5.03447961807251) - 0.00176474802705311*std::sin(0.282239943742752*x_21 - 1.39167988300323) - 0.000754666705391288*std::sin(0.363999843597412*x_21 + 5.02055978775024) + 0.000152770044124304*std::sin(0.384639829397202*x_21 + 8.19575977325439) + 0.00113029050689852*std::sin(0.353439837694168*x_22 + 8.20743942260742) - 0.000207147180133019*std::sin(0.307599931955338*x_24 - 7.55647993087769) + 0.00192697164231072*std::sin(0.30991992354393*x_24 + 1.82943987846375) - 0.00205662103801974*std::sin(0.347839832305908*x_24 - 1.18343985080719) - 0.000950079609389064*std::sin(0.341839849948883*x_25 - 7.59144020080566) - 0.000214343313378778*std::sin(0.365119844675064*x_25 + 5.02320003509521) - 0.000960187343507809*std::sin(0.364959836006165*x_26 + 5.00607967376709) + 0.000958383457518579*std::sin(0.362719833850861*x_27 - 4.3744797706604) + 0.00155480541990676*std::sin(0.221599996089935*x_28 - 7.58168029785156) - 0.000828550049462023*std::sin(0.274799942970276*x_28 - 7.58152008056641) - 0.000334818252879906*std::sin(0.328959852457047*x_28 + 5.03695964813232) + 0.000679993480054976*std::sin(0.149280041456223*x_29 - 1.22135996818542) + 0.00103488737366689*std::sin(0.291919946670532*x_3 - 4.32119989395142) - 0.00182806980687161*std::sin(0.301119923591614*x_3 + 5.06943941116333) - 9.33570474889916e-5*std::sin(0.345439851284027*x_3 - 4.41095972061157) + 0.000178221034292388*std::sin(0.435919851064682*x_31 + 1.99383985996246) + 0.000271570660848673*std::sin(0.255519956350327*x_34 + 8.17208003997803) + 0.000485609260991495*std::sin(0.263919949531555*x_35 - 1.41455984115601) - 0.00203956483757163*std::sin(0.217360004782677*x_36 + 8.19919967651367) + 0.000423246060785703*std::sin(0.247679978609085*x_37 + 8.16775989532471) + 0.0025869676030699*std::sin(0.263599961996078*x_37 + 1.95351982116699) + 0.00217258895850076*std::sin(0.269439965486526*x_37 + 1.93767988681793) + 0.0024486886010556*std::sin(0.256319969892502*x_38 + 1.94175982475281) + 9.88680111927091e-5*std::sin(0.321599900722504*x_4 - 7.55352020263672) + 0.00131743847065107*std::sin(0.335679858922958*x_4 - 4.3918399810791) - 0.000414773560603233*std::sin(0.352239847183228*x_4 + 1.98887979984283) + 4.88632215438052e-5*std::sin(0.303679943084717*x_44 - 1.44399976730347) + 0.00137342126913298*std::sin(0.217840000987053*x_47 - 7.60080003738403) + 0.00264461175218433*std::sin(0.243039980530739*x_47 + 8.16695976257324) - 0.00086483466523754*std::sin(0.222399994730949*x_48 - 4.41351985931396) - 0.000559237430412908*std::sin(0.236959978938103*x_48 - 7.59352016448975) + 0.0010898342206894*std::sin(0.242639973759651*x_48 + 8.17303943634033) - 0.00174111075175769*std::sin(0.230879992246628*x_49 - 7.61863994598389) - 0.000148040940561272*std::sin(0.263919949531555*x_49 + 8.14167976379395) - 0.000104089956820118*std::sin(0.19336000084877*x_5 + 1.7973598241806) + 0.000864474368131147*std::sin(0.358879864215851*x_5 - 1.15943992137909) - 0.000970217058566427*std::sin(0.401039868593216*x_5 + 5.00216007232666) + 0.000248608223720918*std::sin(0.478239864110947*x_5 + 8.16103935241699) + 0.00212092246218418*std::sin(0.215920001268387*x_51 + 8.19279956817627) + 0.00194740158816301*std::sin(0.22511999309063*x_53 + 8.1846399307251) - 0.00251444449061854*std::sin(0.245599970221519*x_53 - 1.20199990272522) + 0.00029218856540475*std::sin(0.197839990258217*x_57 + 8.19095993041992) + 0.00224543553623995*std::sin(0.255759954452515*x_57 + 8.15783977508545) - 0.000194182430856238*std::sin(0.403199851512909*x_6 - 1.17351984977722) + 0.00119088575829669*std::sin(0.421999871730804*x_6 + 1.96639978885651) + 0.000828126521903011*std::sin(0.419279843568802*x_7 - 4.40727996826172) - 9.15330802454746e-5*std::sin(0.309999912977219*x_8 + 8.19192028045654) - 0.000841552784475563*std::sin(0.319999933242798*x_8 + 8.18048000335693) + 0.00119522982153133*std::sin(0.354479849338531*x_8 + 8.23911952972412) - 1.73220590476581e-5*std::sin(0.468639850616455*x_8 - 8.01272010803223) + 0.0012272238530298*std::sin(0.300959944725037*x_9 - 7.42592000961304) + 0.000319782163513106*std::sin(0.306479930877686*x_9 + 1.95599985122681) - 0.000138553012147471*std::sin(0.356319844722748*x_9 - 7.57816028594971) + 0.00078401745011198*std::sin(0.388399839401245*x_9 - 7.60120010375977) + 0.000760809525690865*std::sin(0.315759837627411*x_92 - 7.59328031539917) + 0.000910808435105173*std::sin(0.320479840040207*x_92 - 4.37967967987061) - 4.94742478739981e-5*std::sin(0.332799851894379*x_92 + 5.01823997497559) - 0.00145533158798293*std::sin(0.251279979944229*x_93 - 1.22199988365173) - 0.00096837513722688*std::sin(0.287999957799911*x_94 - 1.19415986537933) - 0.00189853997704719*std::sin(0.29215994477272*x_94 - 1.19487988948822) - 0.00186645377938439*std::sin(0.277599930763245*x_96 - 1.20943987369537) + 0.0017295087514106*std::sin(0.287279933691025*x_96 + 8.1637601852417) + 0.00103379756418928*std::sin(0.276479959487915*x_97 + 8.18136024475098) - 0.00204226991337251*std::sin(0.276639938354492*x_99 + 4.97024011611938) - 0.00462004053541116);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
